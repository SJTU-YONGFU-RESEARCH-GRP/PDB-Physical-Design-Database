* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT dma_controller channel_busy[0] channel_busy[1] channel_busy[2]
+ channel_busy[3] channel_done[0] channel_done[1] channel_done[2]
+ channel_done[3] channel_dst_addr[0] channel_dst_addr[100]
+ channel_dst_addr[101] channel_dst_addr[102] channel_dst_addr[103]
+ channel_dst_addr[104] channel_dst_addr[105] channel_dst_addr[106]
+ channel_dst_addr[107] channel_dst_addr[108] channel_dst_addr[109]
+ channel_dst_addr[10] channel_dst_addr[110] channel_dst_addr[111]
+ channel_dst_addr[112] channel_dst_addr[113] channel_dst_addr[114]
+ channel_dst_addr[115] channel_dst_addr[116] channel_dst_addr[117]
+ channel_dst_addr[118] channel_dst_addr[119] channel_dst_addr[11]
+ channel_dst_addr[120] channel_dst_addr[121] channel_dst_addr[122]
+ channel_dst_addr[123] channel_dst_addr[124] channel_dst_addr[125]
+ channel_dst_addr[126] channel_dst_addr[127] channel_dst_addr[12]
+ channel_dst_addr[13] channel_dst_addr[14] channel_dst_addr[15]
+ channel_dst_addr[16] channel_dst_addr[17] channel_dst_addr[18]
+ channel_dst_addr[19] channel_dst_addr[1] channel_dst_addr[20]
+ channel_dst_addr[21] channel_dst_addr[22] channel_dst_addr[23]
+ channel_dst_addr[24] channel_dst_addr[25] channel_dst_addr[26]
+ channel_dst_addr[27] channel_dst_addr[28] channel_dst_addr[29]
+ channel_dst_addr[2] channel_dst_addr[30] channel_dst_addr[31]
+ channel_dst_addr[32] channel_dst_addr[33] channel_dst_addr[34]
+ channel_dst_addr[35] channel_dst_addr[36] channel_dst_addr[37]
+ channel_dst_addr[38] channel_dst_addr[39] channel_dst_addr[3]
+ channel_dst_addr[40] channel_dst_addr[41] channel_dst_addr[42]
+ channel_dst_addr[43] channel_dst_addr[44] channel_dst_addr[45]
+ channel_dst_addr[46] channel_dst_addr[47] channel_dst_addr[48]
+ channel_dst_addr[49] channel_dst_addr[4] channel_dst_addr[50]
+ channel_dst_addr[51] channel_dst_addr[52] channel_dst_addr[53]
+ channel_dst_addr[54] channel_dst_addr[55] channel_dst_addr[56]
+ channel_dst_addr[57] channel_dst_addr[58] channel_dst_addr[59]
+ channel_dst_addr[5] channel_dst_addr[60] channel_dst_addr[61]
+ channel_dst_addr[62] channel_dst_addr[63] channel_dst_addr[64]
+ channel_dst_addr[65] channel_dst_addr[66] channel_dst_addr[67]
+ channel_dst_addr[68] channel_dst_addr[69] channel_dst_addr[6]
+ channel_dst_addr[70] channel_dst_addr[71] channel_dst_addr[72]
+ channel_dst_addr[73] channel_dst_addr[74] channel_dst_addr[75]
+ channel_dst_addr[76] channel_dst_addr[77] channel_dst_addr[78]
+ channel_dst_addr[79] channel_dst_addr[7] channel_dst_addr[80]
+ channel_dst_addr[81] channel_dst_addr[82] channel_dst_addr[83]
+ channel_dst_addr[84] channel_dst_addr[85] channel_dst_addr[86]
+ channel_dst_addr[87] channel_dst_addr[88] channel_dst_addr[89]
+ channel_dst_addr[8] channel_dst_addr[90] channel_dst_addr[91]
+ channel_dst_addr[92] channel_dst_addr[93] channel_dst_addr[94]
+ channel_dst_addr[95] channel_dst_addr[96] channel_dst_addr[97]
+ channel_dst_addr[98] channel_dst_addr[99] channel_dst_addr[9]
+ channel_enable[0] channel_enable[1] channel_enable[2] channel_enable[3]
+ channel_error[0] channel_error[1] channel_error[2] channel_error[3]
+ channel_length[0] channel_length[100] channel_length[101]
+ channel_length[102] channel_length[103] channel_length[104]
+ channel_length[105] channel_length[106] channel_length[107]
+ channel_length[108] channel_length[109] channel_length[10]
+ channel_length[110] channel_length[111] channel_length[112]
+ channel_length[113] channel_length[114] channel_length[115]
+ channel_length[116] channel_length[117] channel_length[118]
+ channel_length[119] channel_length[11] channel_length[120]
+ channel_length[121] channel_length[122] channel_length[123]
+ channel_length[124] channel_length[125] channel_length[126]
+ channel_length[127] channel_length[12] channel_length[13]
+ channel_length[14] channel_length[15] channel_length[16] channel_length[17]
+ channel_length[18] channel_length[19] channel_length[1] channel_length[20]
+ channel_length[21] channel_length[22] channel_length[23] channel_length[24]
+ channel_length[25] channel_length[26] channel_length[27] channel_length[28]
+ channel_length[29] channel_length[2] channel_length[30] channel_length[31]
+ channel_length[32] channel_length[33] channel_length[34] channel_length[35]
+ channel_length[36] channel_length[37] channel_length[38] channel_length[39]
+ channel_length[3] channel_length[40] channel_length[41] channel_length[42]
+ channel_length[43] channel_length[44] channel_length[45] channel_length[46]
+ channel_length[47] channel_length[48] channel_length[49] channel_length[4]
+ channel_length[50] channel_length[51] channel_length[52] channel_length[53]
+ channel_length[54] channel_length[55] channel_length[56] channel_length[57]
+ channel_length[58] channel_length[59] channel_length[5] channel_length[60]
+ channel_length[61] channel_length[62] channel_length[63] channel_length[64]
+ channel_length[65] channel_length[66] channel_length[67] channel_length[68]
+ channel_length[69] channel_length[6] channel_length[70] channel_length[71]
+ channel_length[72] channel_length[73] channel_length[74] channel_length[75]
+ channel_length[76] channel_length[77] channel_length[78] channel_length[79]
+ channel_length[7] channel_length[80] channel_length[81] channel_length[82]
+ channel_length[83] channel_length[84] channel_length[85] channel_length[86]
+ channel_length[87] channel_length[88] channel_length[89] channel_length[8]
+ channel_length[90] channel_length[91] channel_length[92] channel_length[93]
+ channel_length[94] channel_length[95] channel_length[96] channel_length[97]
+ channel_length[98] channel_length[99] channel_length[9] channel_mode[0]
+ channel_mode[1] channel_mode[2] channel_mode[3] channel_mode[4]
+ channel_mode[5] channel_mode[6] channel_mode[7] channel_src_addr[0]
+ channel_src_addr[100] channel_src_addr[101] channel_src_addr[102]
+ channel_src_addr[103] channel_src_addr[104] channel_src_addr[105]
+ channel_src_addr[106] channel_src_addr[107] channel_src_addr[108]
+ channel_src_addr[109] channel_src_addr[10] channel_src_addr[110]
+ channel_src_addr[111] channel_src_addr[112] channel_src_addr[113]
+ channel_src_addr[114] channel_src_addr[115] channel_src_addr[116]
+ channel_src_addr[117] channel_src_addr[118] channel_src_addr[119]
+ channel_src_addr[11] channel_src_addr[120] channel_src_addr[121]
+ channel_src_addr[122] channel_src_addr[123] channel_src_addr[124]
+ channel_src_addr[125] channel_src_addr[126] channel_src_addr[127]
+ channel_src_addr[12] channel_src_addr[13] channel_src_addr[14]
+ channel_src_addr[15] channel_src_addr[16] channel_src_addr[17]
+ channel_src_addr[18] channel_src_addr[19] channel_src_addr[1]
+ channel_src_addr[20] channel_src_addr[21] channel_src_addr[22]
+ channel_src_addr[23] channel_src_addr[24] channel_src_addr[25]
+ channel_src_addr[26] channel_src_addr[27] channel_src_addr[28]
+ channel_src_addr[29] channel_src_addr[2] channel_src_addr[30]
+ channel_src_addr[31] channel_src_addr[32] channel_src_addr[33]
+ channel_src_addr[34] channel_src_addr[35] channel_src_addr[36]
+ channel_src_addr[37] channel_src_addr[38] channel_src_addr[39]
+ channel_src_addr[3] channel_src_addr[40] channel_src_addr[41]
+ channel_src_addr[42] channel_src_addr[43] channel_src_addr[44]
+ channel_src_addr[45] channel_src_addr[46] channel_src_addr[47]
+ channel_src_addr[48] channel_src_addr[49] channel_src_addr[4]
+ channel_src_addr[50] channel_src_addr[51] channel_src_addr[52]
+ channel_src_addr[53] channel_src_addr[54] channel_src_addr[55]
+ channel_src_addr[56] channel_src_addr[57] channel_src_addr[58]
+ channel_src_addr[59] channel_src_addr[5] channel_src_addr[60]
+ channel_src_addr[61] channel_src_addr[62] channel_src_addr[63]
+ channel_src_addr[64] channel_src_addr[65] channel_src_addr[66]
+ channel_src_addr[67] channel_src_addr[68] channel_src_addr[69]
+ channel_src_addr[6] channel_src_addr[70] channel_src_addr[71]
+ channel_src_addr[72] channel_src_addr[73] channel_src_addr[74]
+ channel_src_addr[75] channel_src_addr[76] channel_src_addr[77]
+ channel_src_addr[78] channel_src_addr[79] channel_src_addr[7]
+ channel_src_addr[80] channel_src_addr[81] channel_src_addr[82]
+ channel_src_addr[83] channel_src_addr[84] channel_src_addr[85]
+ channel_src_addr[86] channel_src_addr[87] channel_src_addr[88]
+ channel_src_addr[89] channel_src_addr[8] channel_src_addr[90]
+ channel_src_addr[91] channel_src_addr[92] channel_src_addr[93]
+ channel_src_addr[94] channel_src_addr[95] channel_src_addr[96]
+ channel_src_addr[97] channel_src_addr[98] channel_src_addr[99]
+ channel_src_addr[9] channel_start[0] channel_start[1] channel_start[2]
+ channel_start[3] clk debug_active_channels[0] debug_active_channels[1]
+ debug_active_channels[2] debug_active_channels[3] debug_channel_state[0]
+ debug_channel_state[10] debug_channel_state[11] debug_channel_state[1]
+ debug_channel_state[2] debug_channel_state[3] debug_channel_state[4]
+ debug_channel_state[5] debug_channel_state[6] debug_channel_state[7]
+ debug_channel_state[8] debug_channel_state[9] debug_has_active_channels
+ debug_transfer_count[0] debug_transfer_count[100] debug_transfer_count[101]
+ debug_transfer_count[102] debug_transfer_count[103] debug_transfer_count[104]
+ debug_transfer_count[105] debug_transfer_count[106] debug_transfer_count[107]
+ debug_transfer_count[108] debug_transfer_count[109] debug_transfer_count[10]
+ debug_transfer_count[110] debug_transfer_count[111] debug_transfer_count[112]
+ debug_transfer_count[113] debug_transfer_count[114] debug_transfer_count[115]
+ debug_transfer_count[116] debug_transfer_count[117] debug_transfer_count[118]
+ debug_transfer_count[119] debug_transfer_count[11] debug_transfer_count[120]
+ debug_transfer_count[121] debug_transfer_count[122] debug_transfer_count[123]
+ debug_transfer_count[124] debug_transfer_count[125] debug_transfer_count[126]
+ debug_transfer_count[127] debug_transfer_count[12] debug_transfer_count[13]
+ debug_transfer_count[14] debug_transfer_count[15] debug_transfer_count[16]
+ debug_transfer_count[17] debug_transfer_count[18] debug_transfer_count[19]
+ debug_transfer_count[1] debug_transfer_count[20] debug_transfer_count[21]
+ debug_transfer_count[22] debug_transfer_count[23] debug_transfer_count[24]
+ debug_transfer_count[25] debug_transfer_count[26] debug_transfer_count[27]
+ debug_transfer_count[28] debug_transfer_count[29] debug_transfer_count[2]
+ debug_transfer_count[30] debug_transfer_count[31] debug_transfer_count[32]
+ debug_transfer_count[33] debug_transfer_count[34] debug_transfer_count[35]
+ debug_transfer_count[36] debug_transfer_count[37] debug_transfer_count[38]
+ debug_transfer_count[39] debug_transfer_count[3] debug_transfer_count[40]
+ debug_transfer_count[41] debug_transfer_count[42] debug_transfer_count[43]
+ debug_transfer_count[44] debug_transfer_count[45] debug_transfer_count[46]
+ debug_transfer_count[47] debug_transfer_count[48] debug_transfer_count[49]
+ debug_transfer_count[4] debug_transfer_count[50] debug_transfer_count[51]
+ debug_transfer_count[52] debug_transfer_count[53] debug_transfer_count[54]
+ debug_transfer_count[55] debug_transfer_count[56] debug_transfer_count[57]
+ debug_transfer_count[58] debug_transfer_count[59] debug_transfer_count[5]
+ debug_transfer_count[60] debug_transfer_count[61] debug_transfer_count[62]
+ debug_transfer_count[63] debug_transfer_count[64] debug_transfer_count[65]
+ debug_transfer_count[66] debug_transfer_count[67] debug_transfer_count[68]
+ debug_transfer_count[69] debug_transfer_count[6] debug_transfer_count[70]
+ debug_transfer_count[71] debug_transfer_count[72] debug_transfer_count[73]
+ debug_transfer_count[74] debug_transfer_count[75] debug_transfer_count[76]
+ debug_transfer_count[77] debug_transfer_count[78] debug_transfer_count[79]
+ debug_transfer_count[7] debug_transfer_count[80] debug_transfer_count[81]
+ debug_transfer_count[82] debug_transfer_count[83] debug_transfer_count[84]
+ debug_transfer_count[85] debug_transfer_count[86] debug_transfer_count[87]
+ debug_transfer_count[88] debug_transfer_count[89] debug_transfer_count[8]
+ debug_transfer_count[90] debug_transfer_count[91] debug_transfer_count[92]
+ debug_transfer_count[93] debug_transfer_count[94] debug_transfer_count[95]
+ debug_transfer_count[96] debug_transfer_count[97] debug_transfer_count[98]
+ debug_transfer_count[99] debug_transfer_count[9] dst_addr[0]
+ dst_addr[100] dst_addr[101] dst_addr[102] dst_addr[103] dst_addr[104]
+ dst_addr[105] dst_addr[106] dst_addr[107] dst_addr[108] dst_addr[109]
+ dst_addr[10] dst_addr[110] dst_addr[111] dst_addr[112] dst_addr[113]
+ dst_addr[114] dst_addr[115] dst_addr[116] dst_addr[117] dst_addr[118]
+ dst_addr[119] dst_addr[11] dst_addr[120] dst_addr[121] dst_addr[122]
+ dst_addr[123] dst_addr[124] dst_addr[125] dst_addr[126] dst_addr[127]
+ dst_addr[12] dst_addr[13] dst_addr[14] dst_addr[15] dst_addr[16]
+ dst_addr[17] dst_addr[18] dst_addr[19] dst_addr[1] dst_addr[20]
+ dst_addr[21] dst_addr[22] dst_addr[23] dst_addr[24] dst_addr[25]
+ dst_addr[26] dst_addr[27] dst_addr[28] dst_addr[29] dst_addr[2]
+ dst_addr[30] dst_addr[31] dst_addr[32] dst_addr[33] dst_addr[34]
+ dst_addr[35] dst_addr[36] dst_addr[37] dst_addr[38] dst_addr[39]
+ dst_addr[3] dst_addr[40] dst_addr[41] dst_addr[42] dst_addr[43]
+ dst_addr[44] dst_addr[45] dst_addr[46] dst_addr[47] dst_addr[48]
+ dst_addr[49] dst_addr[4] dst_addr[50] dst_addr[51] dst_addr[52]
+ dst_addr[53] dst_addr[54] dst_addr[55] dst_addr[56] dst_addr[57]
+ dst_addr[58] dst_addr[59] dst_addr[5] dst_addr[60] dst_addr[61]
+ dst_addr[62] dst_addr[63] dst_addr[64] dst_addr[65] dst_addr[66]
+ dst_addr[67] dst_addr[68] dst_addr[69] dst_addr[6] dst_addr[70]
+ dst_addr[71] dst_addr[72] dst_addr[73] dst_addr[74] dst_addr[75]
+ dst_addr[76] dst_addr[77] dst_addr[78] dst_addr[79] dst_addr[7]
+ dst_addr[80] dst_addr[81] dst_addr[82] dst_addr[83] dst_addr[84]
+ dst_addr[85] dst_addr[86] dst_addr[87] dst_addr[88] dst_addr[89]
+ dst_addr[8] dst_addr[90] dst_addr[91] dst_addr[92] dst_addr[93]
+ dst_addr[94] dst_addr[95] dst_addr[96] dst_addr[97] dst_addr[98]
+ dst_addr[99] dst_addr[9] dst_wdata[0] dst_wdata[100] dst_wdata[101]
+ dst_wdata[102] dst_wdata[103] dst_wdata[104] dst_wdata[105]
+ dst_wdata[106] dst_wdata[107] dst_wdata[108] dst_wdata[109]
+ dst_wdata[10] dst_wdata[110] dst_wdata[111] dst_wdata[112]
+ dst_wdata[113] dst_wdata[114] dst_wdata[115] dst_wdata[116]
+ dst_wdata[117] dst_wdata[118] dst_wdata[119] dst_wdata[11]
+ dst_wdata[120] dst_wdata[121] dst_wdata[122] dst_wdata[123]
+ dst_wdata[124] dst_wdata[125] dst_wdata[126] dst_wdata[127]
+ dst_wdata[12] dst_wdata[13] dst_wdata[14] dst_wdata[15] dst_wdata[16]
+ dst_wdata[17] dst_wdata[18] dst_wdata[19] dst_wdata[1] dst_wdata[20]
+ dst_wdata[21] dst_wdata[22] dst_wdata[23] dst_wdata[24] dst_wdata[25]
+ dst_wdata[26] dst_wdata[27] dst_wdata[28] dst_wdata[29] dst_wdata[2]
+ dst_wdata[30] dst_wdata[31] dst_wdata[32] dst_wdata[33] dst_wdata[34]
+ dst_wdata[35] dst_wdata[36] dst_wdata[37] dst_wdata[38] dst_wdata[39]
+ dst_wdata[3] dst_wdata[40] dst_wdata[41] dst_wdata[42] dst_wdata[43]
+ dst_wdata[44] dst_wdata[45] dst_wdata[46] dst_wdata[47] dst_wdata[48]
+ dst_wdata[49] dst_wdata[4] dst_wdata[50] dst_wdata[51] dst_wdata[52]
+ dst_wdata[53] dst_wdata[54] dst_wdata[55] dst_wdata[56] dst_wdata[57]
+ dst_wdata[58] dst_wdata[59] dst_wdata[5] dst_wdata[60] dst_wdata[61]
+ dst_wdata[62] dst_wdata[63] dst_wdata[64] dst_wdata[65] dst_wdata[66]
+ dst_wdata[67] dst_wdata[68] dst_wdata[69] dst_wdata[6] dst_wdata[70]
+ dst_wdata[71] dst_wdata[72] dst_wdata[73] dst_wdata[74] dst_wdata[75]
+ dst_wdata[76] dst_wdata[77] dst_wdata[78] dst_wdata[79] dst_wdata[7]
+ dst_wdata[80] dst_wdata[81] dst_wdata[82] dst_wdata[83] dst_wdata[84]
+ dst_wdata[85] dst_wdata[86] dst_wdata[87] dst_wdata[88] dst_wdata[89]
+ dst_wdata[8] dst_wdata[90] dst_wdata[91] dst_wdata[92] dst_wdata[93]
+ dst_wdata[94] dst_wdata[95] dst_wdata[96] dst_wdata[97] dst_wdata[98]
+ dst_wdata[99] dst_wdata[9] dst_wready[0] dst_wready[1] dst_wready[2]
+ dst_wready[3] dst_write[0] dst_write[1] dst_write[2] dst_write[3]
+ dst_wstrb[0] dst_wstrb[10] dst_wstrb[11] dst_wstrb[12] dst_wstrb[13]
+ dst_wstrb[14] dst_wstrb[15] dst_wstrb[1] dst_wstrb[2] dst_wstrb[3]
+ dst_wstrb[4] dst_wstrb[5] dst_wstrb[6] dst_wstrb[7] dst_wstrb[8]
+ dst_wstrb[9] rst_n src_addr[0] src_addr[100] src_addr[101]
+ src_addr[102] src_addr[103] src_addr[104] src_addr[105] src_addr[106]
+ src_addr[107] src_addr[108] src_addr[109] src_addr[10] src_addr[110]
+ src_addr[111] src_addr[112] src_addr[113] src_addr[114] src_addr[115]
+ src_addr[116] src_addr[117] src_addr[118] src_addr[119] src_addr[11]
+ src_addr[120] src_addr[121] src_addr[122] src_addr[123] src_addr[124]
+ src_addr[125] src_addr[126] src_addr[127] src_addr[12] src_addr[13]
+ src_addr[14] src_addr[15] src_addr[16] src_addr[17] src_addr[18]
+ src_addr[19] src_addr[1] src_addr[20] src_addr[21] src_addr[22]
+ src_addr[23] src_addr[24] src_addr[25] src_addr[26] src_addr[27]
+ src_addr[28] src_addr[29] src_addr[2] src_addr[30] src_addr[31]
+ src_addr[32] src_addr[33] src_addr[34] src_addr[35] src_addr[36]
+ src_addr[37] src_addr[38] src_addr[39] src_addr[3] src_addr[40]
+ src_addr[41] src_addr[42] src_addr[43] src_addr[44] src_addr[45]
+ src_addr[46] src_addr[47] src_addr[48] src_addr[49] src_addr[4]
+ src_addr[50] src_addr[51] src_addr[52] src_addr[53] src_addr[54]
+ src_addr[55] src_addr[56] src_addr[57] src_addr[58] src_addr[59]
+ src_addr[5] src_addr[60] src_addr[61] src_addr[62] src_addr[63]
+ src_addr[64] src_addr[65] src_addr[66] src_addr[67] src_addr[68]
+ src_addr[69] src_addr[6] src_addr[70] src_addr[71] src_addr[72]
+ src_addr[73] src_addr[74] src_addr[75] src_addr[76] src_addr[77]
+ src_addr[78] src_addr[79] src_addr[7] src_addr[80] src_addr[81]
+ src_addr[82] src_addr[83] src_addr[84] src_addr[85] src_addr[86]
+ src_addr[87] src_addr[88] src_addr[89] src_addr[8] src_addr[90]
+ src_addr[91] src_addr[92] src_addr[93] src_addr[94] src_addr[95]
+ src_addr[96] src_addr[97] src_addr[98] src_addr[99] src_addr[9]
+ src_rdata[0] src_rdata[100] src_rdata[101] src_rdata[102]
+ src_rdata[103] src_rdata[104] src_rdata[105] src_rdata[106]
+ src_rdata[107] src_rdata[108] src_rdata[109] src_rdata[10]
+ src_rdata[110] src_rdata[111] src_rdata[112] src_rdata[113]
+ src_rdata[114] src_rdata[115] src_rdata[116] src_rdata[117]
+ src_rdata[118] src_rdata[119] src_rdata[11] src_rdata[120]
+ src_rdata[121] src_rdata[122] src_rdata[123] src_rdata[124]
+ src_rdata[125] src_rdata[126] src_rdata[127] src_rdata[12]
+ src_rdata[13] src_rdata[14] src_rdata[15] src_rdata[16] src_rdata[17]
+ src_rdata[18] src_rdata[19] src_rdata[1] src_rdata[20] src_rdata[21]
+ src_rdata[22] src_rdata[23] src_rdata[24] src_rdata[25] src_rdata[26]
+ src_rdata[27] src_rdata[28] src_rdata[29] src_rdata[2] src_rdata[30]
+ src_rdata[31] src_rdata[32] src_rdata[33] src_rdata[34] src_rdata[35]
+ src_rdata[36] src_rdata[37] src_rdata[38] src_rdata[39] src_rdata[3]
+ src_rdata[40] src_rdata[41] src_rdata[42] src_rdata[43] src_rdata[44]
+ src_rdata[45] src_rdata[46] src_rdata[47] src_rdata[48] src_rdata[49]
+ src_rdata[4] src_rdata[50] src_rdata[51] src_rdata[52] src_rdata[53]
+ src_rdata[54] src_rdata[55] src_rdata[56] src_rdata[57] src_rdata[58]
+ src_rdata[59] src_rdata[5] src_rdata[60] src_rdata[61] src_rdata[62]
+ src_rdata[63] src_rdata[64] src_rdata[65] src_rdata[66] src_rdata[67]
+ src_rdata[68] src_rdata[69] src_rdata[6] src_rdata[70] src_rdata[71]
+ src_rdata[72] src_rdata[73] src_rdata[74] src_rdata[75] src_rdata[76]
+ src_rdata[77] src_rdata[78] src_rdata[79] src_rdata[7] src_rdata[80]
+ src_rdata[81] src_rdata[82] src_rdata[83] src_rdata[84] src_rdata[85]
+ src_rdata[86] src_rdata[87] src_rdata[88] src_rdata[89] src_rdata[8]
+ src_rdata[90] src_rdata[91] src_rdata[92] src_rdata[93] src_rdata[94]
+ src_rdata[95] src_rdata[96] src_rdata[97] src_rdata[98] src_rdata[99]
+ src_rdata[9] src_read[0] src_read[1] src_read[2] src_read[3]
+ src_rready[0] src_rready[1] src_rready[2] src_rready[3] src_rvalid[0]
+ src_rvalid[1] src_rvalid[2] src_rvalid[3]
X_1868_ rst_n _1087_ VDD VSS BUF_X8
X_1869_ _1087_ _1088_ VDD VSS BUF_X4
X_1870_ _1088_ _1089_ VDD VSS BUF_X4
X_1871_ _1089_ _1090_ VDD VSS BUF_X4
X_1872_ channel_state\[2\]\[0\] _1091_ VDD VSS CLKBUF_X3
X_1873_ channel_state\[2\]\[4\] _1091_ _1092_ VDD VSS NOR2_X1
X_1874_ net129 _1093_ VDD VSS INV_X1
X_1875_ channel_enable[2] _1094_ VDD VSS BUF_X2
X_1876_ _1094_ _1095_ VDD VSS INV_X1
X_1877_ _1093_ _1091_ _1095_ _1096_ VDD VSS AOI21_X1
X_1878_ _1090_ _1092_ _1096_ _0014_ VDD VSS OAI21_X1
X_1879_ transfer_count\[2\]\[5\] _1097_ VDD VSS BUF_X2
X_1880_ transfer_count\[2\]\[3\] _1098_ VDD VSS CLKBUF_X3
X_1881_ transfer_count\[2\]\[4\] _1099_ VDD VSS BUF_X2
X_1882_ transfer_count\[2\]\[2\] _1100_ VDD VSS CLKBUF_X3
X_1883_ _1100_ transfer_count\[2\]\[1\] transfer_count\[2\]\[0\]
+ _1101_ VDD VSS NAND3_X2
X_1884_ _1101_ _1102_ VDD VSS INV_X1
X_1885_ _1098_ _1099_ _1102_ _1103_ VDD VSS NAND3_X1
X_1886_ _1097_ _1103_ _1486_ VDD VSS XOR2_X2
X_1887_ transfer_count\[2\]\[13\] _1104_ VDD VSS INV_X1
X_1888_ transfer_count\[2\]\[12\] _1105_ VDD VSS BUF_X1
X_1889_ _1105_ _1106_ VDD VSS INV_X1
X_1890_ transfer_count\[2\]\[11\] _1107_ VDD VSS INV_X1
X_1891_ transfer_count\[2\]\[7\] _1108_ VDD VSS BUF_X2
X_1892_ _1100_ transfer_count\[2\]\[1\] transfer_count\[2\]\[0\]
+ _1108_ _1109_ VDD VSS NAND4_X4
X_1893_ transfer_count\[2\]\[10\] _1110_ VDD VSS INV_X1
X_1894_ transfer_count\[2\]\[9\] _1111_ VDD VSS INV_X1
X_1895_ transfer_count\[2\]\[8\] _1112_ VDD VSS CLKBUF_X2
X_1896_ _1112_ _1113_ VDD VSS INV_X1
X_1897_ _1098_ transfer_count\[2\]\[6\] _1097_ _1099_ _1114_
+ VDD VSS NAND4_X4
X_1898_ _1110_ _1111_ _1113_ _1114_ _1115_ VDD VSS OR4_X1
X_1899_ _1106_ _1107_ _1109_ _1115_ _1116_ VDD VSS OR4_X1
X_1900_ _1104_ _1116_ _1498_ VDD VSS XNOR2_X1
X_1901_ _1113_ _1109_ _1114_ _1117_ VDD VSS NOR3_X2
X_1902_ transfer_count\[2\]\[9\] _1117_ _1510_ VDD VSS XNOR2_X2
X_1903_ transfer_count\[2\]\[29\] _1118_ VDD VSS BUF_X1
X_1904_ transfer_count\[2\]\[11\] transfer_count\[2\]\[10\]
+ transfer_count\[2\]\[9\] _1112_ _1119_ VDD VSS NAND4_X1
X_1905_ _1109_ _1114_ _1119_ _1120_ VDD VSS OR3_X4
X_1906_ transfer_count\[2\]\[28\] _1121_ VDD VSS CLKBUF_X2
X_1907_ transfer_count\[2\]\[27\] _1122_ VDD VSS CLKBUF_X2
X_1908_ transfer_count\[2\]\[26\] _1123_ VDD VSS BUF_X2
X_1909_ _1121_ _1122_ _1123_ _1124_ VDD VSS NAND3_X1
X_1910_ transfer_count\[2\]\[24\] _1125_ VDD VSS BUF_X2
X_1911_ transfer_count\[2\]\[21\] _1126_ VDD VSS BUF_X2
X_1912_ transfer_count\[2\]\[20\] _1127_ VDD VSS CLKBUF_X3
X_1913_ transfer_count\[2\]\[23\] transfer_count\[2\]\[22\]
+ _1126_ _1127_ _1128_ VDD VSS AND4_X2
X_1914_ transfer_count\[2\]\[25\] _1125_ _1128_ _1129_ VDD
+ VSS NAND3_X4
X_1915_ transfer_count\[2\]\[16\] _1130_ VDD VSS BUF_X2
X_1916_ transfer_count\[2\]\[14\] _1131_ VDD VSS BUF_X1
X_1917_ _1131_ transfer_count\[2\]\[13\] _1105_ transfer_count\[2\]\[15\]
+ _1132_ VDD VSS AND4_X1
X_1918_ transfer_count\[2\]\[18\] _1133_ VDD VSS BUF_X1
X_1919_ transfer_count\[2\]\[17\] _1134_ VDD VSS BUF_X1
X_1920_ transfer_count\[2\]\[19\] _1133_ _1134_ _1135_ VDD
+ VSS AND3_X1
X_1921_ _1130_ _1132_ _1135_ _1136_ VDD VSS NAND3_X4
X_1922_ _1120_ _1124_ _1129_ _1136_ _1137_ VDD VSS NOR4_X2
X_1923_ _1118_ _1137_ _1522_ VDD VSS XNOR2_X1
X_1924_ transfer_count\[2\]\[25\] _1138_ VDD VSS INV_X1
X_1925_ _1125_ _1128_ _1139_ VDD VSS AND2_X1
X_1926_ _1120_ _1136_ _1140_ VDD VSS NOR2_X4
X_1927_ _1139_ _1140_ _1141_ VDD VSS NAND2_X1
X_1928_ _1138_ _1141_ _1534_ VDD VSS XNOR2_X1
X_1929_ _1127_ _1140_ _1142_ VDD VSS NAND2_X1
X_1930_ _1126_ _1142_ _1546_ VDD VSS XOR2_X2
X_1931_ _1130_ _1132_ _1143_ VDD VSS NAND2_X1
X_1932_ _1120_ _1143_ _1144_ VDD VSS NOR2_X2
X_1933_ _1134_ _1144_ _1558_ VDD VSS XNOR2_X1
X_1934_ _1518_ _1524_ _1521_ _1527_ _1145_ VDD VSS NAND4_X2
X_1935_ _1530_ _1536_ _1533_ _1539_ _1146_ VDD VSS NAND4_X1
X_1936_ _1542_ _1548_ _1545_ _1551_ _1147_ VDD VSS NAND4_X2
X_1937_ _1145_ _1146_ _1147_ _1148_ VDD VSS NOR3_X1
X_1938_ _1553_ _1556_ _1554_ _1149_ VDD VSS AOI21_X1
X_1939_ _1559_ _1562_ _1560_ _1150_ VDD VSS AOI21_X1
X_1940_ _1554_ _1557_ _1151_ VDD VSS NAND2_X1
X_1941_ _1149_ _1150_ _1151_ _1152_ VDD VSS OAI21_X1
X_1942_ _1524_ _1521_ _1526_ _1153_ VDD VSS NAND3_X1
X_1943_ _1520_ _1523_ _1521_ _1154_ VDD VSS AOI21_X1
X_1944_ _1153_ _1154_ _1155_ VDD VSS NAND2_X1
X_1945_ _1517_ _1148_ _1152_ _1155_ _1518_ _1156_ VDD VSS
+ AOI221_X2
X_1946_ _1542_ _1545_ _1157_ VDD VSS AND2_X1
X_1947_ _1547_ _1550_ _1548_ _1158_ VDD VSS AOI21_X1
X_1948_ _1158_ _1159_ VDD VSS INV_X1
X_1949_ _1541_ _1157_ _1159_ _1544_ _1542_ _1160_ VDD VSS
+ AOI221_X2
X_1950_ _1145_ _1146_ _1161_ VDD VSS OR2_X2
X_1951_ _1532_ _1162_ VDD VSS INV_X1
X_1952_ _1535_ _1538_ _1536_ _1163_ VDD VSS AOI21_X1
X_1953_ _1533_ _1164_ VDD VSS INV_X1
X_1954_ _1162_ _1163_ _1164_ _1165_ VDD VSS OAI21_X1
X_1955_ _1529_ _1165_ _1530_ _1166_ VDD VSS AOI21_X1
X_1956_ _1156_ _1160_ _1161_ _1145_ _1166_ _1167_ VDD VSS
+ OAI221_X2
X_1957_ _1476_ _1479_ _1168_ VDD VSS AND2_X1
X_1958_ _1506_ _1512_ _1509_ _1515_ _1169_ VDD VSS NAND4_X4
X_1959_ _1494_ _1500_ _1497_ _1503_ _1170_ VDD VSS NAND4_X4
X_1960_ _1482_ _1485_ _1171_ VDD VSS NAND2_X2
X_1961_ _1488_ _1491_ _1172_ VDD VSS NAND2_X2
X_1962_ _1169_ _1170_ _1171_ _1172_ _1173_ VDD VSS NOR4_X4
X_1963_ _1560_ _1563_ _1174_ VDD VSS NAND2_X1
X_1964_ _1161_ _1147_ _1151_ _1174_ _1175_ VDD VSS NOR4_X4
X_1965_ _1473_ _1468_ _1176_ VDD VSS AND2_X1
X_1966_ _1168_ _1173_ _1175_ _1176_ _1177_ VDD VSS NAND4_X4
X_1967_ _1087_ _1178_ VDD VSS INV_X8
X_1968_ channel_state\[2\]\[1\] _1179_ VDD VSS CLKBUF_X3
X_1969_ net132 _1179_ _1180_ VDD VSS NAND2_X4
X_1970_ _1178_ _1180_ _1181_ VDD VSS NOR2_X4
X_1971_ _1167_ _1177_ _1181_ _1182_ VDD VSS NAND3_X1
X_1972_ _1177_ _1181_ _1183_ VDD VSS NAND2_X1
X_1973_ _1169_ _1170_ _1184_ VDD VSS NOR2_X1
X_1974_ _1481_ _1484_ _1482_ _1185_ VDD VSS AOI21_X1
X_1975_ _1487_ _1490_ _1488_ _1186_ VDD VSS AOI21_X1
X_1976_ _1185_ _1171_ _1186_ _1187_ VDD VSS OAI21_X1
X_1977_ _1500_ _1497_ _1502_ _1188_ VDD VSS NAND3_X1
X_1978_ _1496_ _1499_ _1497_ _1189_ VDD VSS AOI21_X1
X_1979_ _1188_ _1189_ _1190_ VDD VSS NAND2_X1
X_1980_ _1493_ _1184_ _1187_ _1190_ _1494_ _1191_ VDD VSS
+ AOI221_X2
X_1981_ _1170_ _1192_ VDD VSS INV_X1
X_1982_ _1505_ _1508_ _1506_ _1193_ VDD VSS AOI21_X1
X_1983_ _1506_ _1509_ _1194_ VDD VSS NAND2_X1
X_1984_ _1511_ _1514_ _1512_ _1195_ VDD VSS AOI21_X1
X_1985_ _1193_ _1194_ _1195_ _1196_ VDD VSS OAI21_X1
X_1986_ _1192_ _1196_ _1197_ VDD VSS NAND2_X1
X_1987_ _1472_ _1198_ VDD VSS INV_X1
X_1988_ _1473_ _1199_ VDD VSS INV_X1
X_1989_ _1198_ _1467_ _1199_ _1200_ VDD VSS OAI21_X1
X_1990_ _1475_ _1200_ _1168_ _1478_ _1476_ _1201_ VDD VSS
+ AOI221_X2
X_1991_ _1169_ _1170_ _1171_ _1172_ _1202_ VDD VSS OR4_X2
X_1992_ _1191_ _1197_ _1201_ _1202_ _1203_ VDD VSS OAI211_X4
X_1993_ _1203_ _1175_ _1204_ VDD VSS NAND2_X1
X_1994_ _1178_ _1205_ VDD VSS BUF_X8
X_1995_ _1205_ _1206_ VDD VSS BUF_X4
X_1996_ net129 _1091_ _1094_ _1207_ VDD VSS NAND3_X4
X_1997_ _1182_ _1183_ _1204_ _1206_ _1207_ _0017_ VDD VSS
+ OAI221_X1
X_1998_ transfer_count\[1\]\[28\] _1208_ VDD VSS CLKBUF_X2
X_1999_ transfer_count\[1\]\[27\] _1209_ VDD VSS BUF_X2
X_2000_ transfer_count\[1\]\[26\] _1210_ VDD VSS BUF_X1
X_2001_ transfer_count\[1\]\[25\] _1211_ VDD VSS CLKBUF_X2
X_2002_ transfer_count\[1\]\[24\] _1212_ VDD VSS BUF_X2
X_2003_ transfer_count\[1\]\[23\] _1213_ VDD VSS BUF_X2
X_2004_ _1210_ _1211_ _1212_ _1213_ _1214_ VDD VSS AND4_X2
X_2005_ _1208_ _1209_ _1214_ _1215_ VDD VSS NAND3_X1
X_2006_ transfer_count\[1\]\[22\] _1216_ VDD VSS BUF_X2
X_2007_ transfer_count\[1\]\[21\] _1217_ VDD VSS CLKBUF_X3
X_2008_ _1216_ _1217_ _1218_ VDD VSS NAND2_X4
X_2009_ transfer_count\[1\]\[20\] _1219_ VDD VSS BUF_X2
X_2010_ transfer_count\[1\]\[16\] _1220_ VDD VSS BUF_X2
X_2011_ transfer_count\[1\]\[15\] _1221_ VDD VSS BUF_X2
X_2012_ transfer_count\[1\]\[14\] _1222_ VDD VSS BUF_X4
X_2013_ transfer_count\[1\]\[17\] _1220_ _1221_ _1222_ _1223_
+ VDD VSS AND4_X2
X_2014_ transfer_count\[1\]\[18\] _1224_ VDD VSS BUF_X2
X_2015_ transfer_count\[1\]\[19\] _1224_ _1225_ VDD VSS AND2_X2
X_2016_ _1219_ _1223_ _1225_ _1226_ VDD VSS NAND3_X4
X_2017_ transfer_count\[1\]\[6\] _1227_ VDD VSS BUF_X2
X_2018_ transfer_count\[1\]\[5\] _1228_ VDD VSS BUF_X2
X_2019_ transfer_count\[1\]\[4\] _1229_ VDD VSS BUF_X2
X_2020_ _1227_ _1228_ _1229_ _1230_ VDD VSS NAND3_X4
X_2021_ transfer_count\[1\]\[3\] _1231_ VDD VSS CLKBUF_X3
X_2022_ transfer_count\[1\]\[2\] _1232_ VDD VSS CLKBUF_X3
X_2023_ _1231_ _1232_ transfer_count\[1\]\[1\] transfer_count\[1\]\[0\]
+ _1233_ VDD VSS NAND4_X4
X_2024_ _1230_ _1233_ _1234_ VDD VSS OR2_X2
X_2025_ transfer_count\[1\]\[8\] _1235_ VDD VSS BUF_X4
X_2026_ transfer_count\[1\]\[7\] _1236_ VDD VSS BUF_X4
X_2027_ transfer_count\[1\]\[10\] transfer_count\[1\]\[9\]
+ _1235_ _1236_ _1237_ VDD VSS NAND4_X4
X_2028_ transfer_count\[1\]\[12\] _1238_ VDD VSS BUF_X2
X_2029_ transfer_count\[1\]\[11\] _1239_ VDD VSS CLKBUF_X3
X_2030_ transfer_count\[1\]\[13\] _1238_ _1239_ _1240_ VDD
+ VSS NAND3_X4
X_2031_ _1237_ _1240_ _1241_ VDD VSS OR2_X2
X_2032_ _1226_ _1234_ _1241_ _1242_ VDD VSS OR3_X4
X_2033_ _1215_ _1218_ _1242_ _1243_ VDD VSS NOR3_X2
X_2034_ transfer_count\[1\]\[29\] _1243_ _1570_ VDD VSS XNOR2_X2
X_2035_ _1218_ _1226_ _1234_ _1241_ _1244_ VDD VSS NOR4_X4
X_2036_ _1214_ _1244_ _1245_ VDD VSS NAND2_X1
X_2037_ _1209_ _1245_ _1576_ VDD VSS XOR2_X2
X_2038_ _1212_ _1213_ _1246_ VDD VSS NAND2_X1
X_2039_ _1246_ _1218_ _1242_ _1247_ VDD VSS NOR3_X2
X_2040_ _1211_ _1247_ _1582_ VDD VSS XNOR2_X2
X_2041_ _1213_ _1244_ _1588_ VDD VSS XNOR2_X1
X_2042_ _1217_ _1242_ _1594_ VDD VSS XOR2_X2
X_2043_ _1224_ transfer_count\[1\]\[17\] _1220_ _1248_ VDD
+ VSS NAND3_X1
X_2044_ _1230_ _1233_ _1237_ _1240_ _1249_ VDD VSS NOR4_X4
X_2045_ _1221_ _1222_ _1249_ _1250_ VDD VSS NAND3_X1
X_2046_ _1248_ _1250_ _1251_ VDD VSS NOR2_X2
X_2047_ transfer_count\[1\]\[19\] _1251_ _1600_ VDD VSS XNOR2_X2
X_2048_ _1222_ _1249_ _1252_ VDD VSS NAND2_X1
X_2049_ _1221_ _1252_ _1612_ VDD VSS XOR2_X2
X_2050_ _1234_ _1237_ _1253_ VDD VSS NOR2_X2
X_2051_ _1238_ _1239_ _1253_ _1254_ VDD VSS NAND3_X2
X_2052_ transfer_count\[1\]\[13\] _1254_ _1618_ VDD VSS XOR2_X2
X_2053_ _1239_ _1253_ _1624_ VDD VSS XNOR2_X1
X_2054_ _1230_ _1233_ _1255_ VDD VSS NOR2_X2
X_2055_ _1235_ _1236_ _1255_ _1256_ VDD VSS NAND3_X1
X_2056_ transfer_count\[1\]\[9\] _1256_ _1630_ VDD VSS XOR2_X2
X_2057_ _1236_ _1255_ _1636_ VDD VSS XNOR2_X1
X_2058_ _1229_ _1257_ VDD VSS INV_X1
X_2059_ _1257_ _1233_ _1258_ VDD VSS NOR2_X1
X_2060_ _1228_ _1258_ _1642_ VDD VSS XNOR2_X2
X_2061_ _1232_ transfer_count\[1\]\[1\] transfer_count\[1\]\[0\]
+ _1259_ VDD VSS NAND3_X2
X_2062_ _1231_ _1259_ _1648_ VDD VSS XOR2_X2
X_2063_ channel_start[1] _1260_ VDD VSS BUF_X2
X_2064_ channel_state\[1\]\[0\] _1261_ VDD VSS BUF_X2
X_2065_ channel_enable[1] _1262_ VDD VSS BUF_X2
X_2066_ _1261_ _1262_ _1263_ VDD VSS NAND2_X1
X_2067_ _1088_ _1260_ channel_state\[1\]\[4\] _1263_ _1264_
+ VDD VSS NAND4_X1
X_2068_ net131 channel_state\[1\]\[1\] _1265_ VDD VSS AND2_X1
X_2069_ _1265_ _1266_ VDD VSS CLKBUF_X3
X_2070_ _1087_ _1266_ _1267_ VDD VSS NAND2_X2
X_2071_ _1267_ _1268_ VDD VSS CLKBUF_X3
X_2072_ _1566_ _1569_ _1575_ _1572_ _1269_ VDD VSS NAND4_X4
X_2073_ _1269_ _1270_ VDD VSS INV_X1
X_2074_ _1577_ _1580_ _1578_ _1271_ VDD VSS AOI21_X1
X_2075_ _1578_ _1581_ _1272_ VDD VSS NAND2_X1
X_2076_ _1583_ _1584_ _1586_ _1273_ VDD VSS AOI21_X1
X_2077_ _1271_ _1272_ _1273_ _1274_ VDD VSS OAI21_X1
X_2078_ _1589_ _1592_ _1590_ _1275_ VDD VSS AOI21_X1
X_2079_ _1590_ _1593_ _1276_ VDD VSS NAND2_X1
X_2080_ _1595_ _1596_ _1598_ _1277_ VDD VSS AOI21_X1
X_2081_ _1275_ _1276_ _1277_ _1278_ VDD VSS OAI21_X1
X_2082_ _1578_ _1581_ _1587_ _1584_ _1279_ VDD VSS NAND4_X2
X_2083_ _1269_ _1279_ _1280_ VDD VSS NOR2_X2
X_2084_ _1270_ _1274_ _1278_ _1280_ _1281_ VDD VSS AOI22_X2
X_2085_ _1565_ _1568_ _1566_ _1282_ VDD VSS AOI21_X1
X_2086_ _1571_ _1572_ _1574_ _1283_ VDD VSS AOI21_X1
X_2087_ _1566_ _1569_ _1284_ VDD VSS NAND2_X1
X_2088_ _1282_ _1283_ _1284_ _1285_ VDD VSS OAI21_X2
X_2089_ _1601_ _1604_ _1602_ _1286_ VDD VSS AOI21_X1
X_2090_ _1602_ _1605_ _1287_ VDD VSS NAND2_X1
X_2091_ _1607_ _1608_ _1610_ _1288_ VDD VSS AOI21_X1
X_2092_ _1286_ _1287_ _1288_ _1289_ VDD VSS OAI21_X1
X_2093_ _1590_ _1593_ _1599_ _1596_ _0181_ VDD VSS NAND4_X2
X_2094_ _1269_ _1279_ _0181_ _0182_ VDD VSS NOR3_X2
X_2095_ _1285_ _1289_ _0182_ _0183_ VDD VSS AOI21_X1
X_2096_ _1281_ _0183_ _0184_ VDD VSS NAND2_X1
X_2097_ _1622_ _1617_ _1620_ _0185_ VDD VSS NAND3_X1
X_2098_ _1616_ _1619_ _1617_ _0186_ VDD VSS AOI21_X1
X_2099_ _0185_ _0186_ _0187_ VDD VSS NAND2_X1
X_2100_ _1613_ _0187_ _1614_ _0188_ VDD VSS AOI21_X1
X_2101_ _1614_ _1617_ _1623_ _1620_ _0189_ VDD VSS NAND4_X2
X_2102_ _0189_ _0190_ VDD VSS INV_X1
X_2103_ _1625_ _1628_ _1626_ _0191_ VDD VSS AOI21_X1
X_2104_ _1626_ _1629_ _0192_ VDD VSS NAND2_X1
X_2105_ _1631_ _1632_ _1634_ _0193_ VDD VSS AOI21_X1
X_2106_ _0191_ _0192_ _0193_ _0194_ VDD VSS OAI21_X1
X_2107_ _1626_ _1629_ _1635_ _1632_ _0195_ VDD VSS NAND4_X1
X_2108_ _0189_ _0195_ _0196_ VDD VSS NOR2_X1
X_2109_ _1637_ _1640_ _1638_ _0197_ VDD VSS AOI21_X1
X_2110_ _1638_ _1641_ _0198_ VDD VSS NAND2_X1
X_2111_ _1643_ _1644_ _1646_ _0199_ VDD VSS AOI21_X1
X_2112_ _0197_ _0198_ _0199_ _0200_ VDD VSS OAI21_X1
X_2113_ _0190_ _0194_ _0196_ _0200_ _0201_ VDD VSS AOI22_X2
X_2114_ _1647_ _1644_ _0202_ VDD VSS NAND2_X1
X_2115_ _0189_ _0195_ _0198_ _0202_ _0203_ VDD VSS OR4_X1
X_2116_ _1657_ _0204_ VDD VSS INV_X1
X_2117_ _1658_ _0205_ VDD VSS INV_X1
X_2118_ _0204_ _1661_ _0205_ _0206_ VDD VSS OAI21_X1
X_2119_ _1650_ _1653_ _0207_ VDD VSS AND2_X1
X_2120_ _1649_ _0206_ _0207_ _1652_ _1650_ _0208_ VDD VSS
+ AOI221_X2
X_2121_ _0188_ _0201_ _0203_ _0208_ _0209_ VDD VSS OAI211_X2
X_2122_ _0184_ _0209_ _0210_ VDD VSS OR2_X1
X_2123_ _1608_ _1611_ _0211_ VDD VSS NAND2_X1
X_2124_ _0181_ _1287_ _0211_ _0212_ VDD VSS NOR3_X2
X_2125_ _1285_ _0212_ _1280_ _0182_ _1289_ _0213_ VDD VSS
+ AOI221_X2
X_2126_ _1281_ _0213_ _0214_ VDD VSS NAND2_X2
X_2127_ _1280_ _0212_ _0215_ VDD VSS NAND2_X1
X_2128_ _1658_ _1662_ _0207_ _0216_ VDD VSS NAND3_X1
X_2129_ _0203_ _0215_ _0216_ _0217_ VDD VSS OR3_X2
X_2130_ _1264_ _0214_ _0217_ _0218_ VDD VSS AND3_X1
X_2131_ _1264_ _1268_ _0210_ _0218_ _0013_ VDD VSS AOI22_X1
X_2132_ _1205_ _0219_ VDD VSS BUF_X8
X_2133_ _1261_ _1260_ _1262_ _0220_ VDD VSS NAND3_X4
X_2134_ net131 channel_state\[1\]\[1\] _0221_ VDD VSS NAND2_X2
X_2135_ _1178_ _0221_ _0222_ VDD VSS NOR2_X2
X_2136_ _0222_ _0223_ VDD VSS CLKBUF_X3
X_2137_ _0223_ _0214_ _0217_ _0224_ VDD VSS NAND3_X1
X_2138_ _0184_ _0209_ _0225_ VDD VSS NOR2_X1
X_2139_ _0219_ _0220_ _0224_ _0225_ _0012_ VDD VSS OAI22_X1
X_2140_ transfer_count\[0\]\[29\] _0226_ VDD VSS CLKBUF_X2
X_2141_ transfer_count\[0\]\[20\] _0227_ VDD VSS BUF_X2
X_2142_ transfer_count\[0\]\[19\] _0228_ VDD VSS BUF_X2
X_2143_ transfer_count\[0\]\[18\] _0229_ VDD VSS BUF_X2
X_2144_ transfer_count\[0\]\[16\] _0230_ VDD VSS CLKBUF_X2
X_2145_ transfer_count\[0\]\[14\] _0231_ VDD VSS CLKBUF_X2
X_2146_ transfer_count\[0\]\[17\] _0230_ transfer_count\[0\]\[15\]
+ _0231_ _0232_ VDD VSS AND4_X2
X_2147_ _0227_ _0228_ _0229_ _0232_ _0233_ VDD VSS NAND4_X4
X_2148_ transfer_count\[0\]\[13\] _0234_ VDD VSS BUF_X2
X_2149_ transfer_count\[0\]\[12\] _0235_ VDD VSS BUF_X2
X_2150_ transfer_count\[0\]\[11\] _0236_ VDD VSS CLKBUF_X3
X_2151_ _0234_ _0235_ _0236_ _0237_ VDD VSS NAND3_X4
X_2152_ transfer_count\[0\]\[3\] _0238_ VDD VSS BUF_X2
X_2153_ transfer_count\[0\]\[2\] _0239_ VDD VSS CLKBUF_X3
X_2154_ _0238_ _0239_ transfer_count\[0\]\[1\] transfer_count\[0\]\[0\]
+ _0240_ VDD VSS NAND4_X4
X_2155_ transfer_count\[0\]\[6\] _0241_ VDD VSS BUF_X2
X_2156_ transfer_count\[0\]\[5\] _0242_ VDD VSS BUF_X2
X_2157_ transfer_count\[0\]\[4\] _0243_ VDD VSS BUF_X2
X_2158_ _0241_ _0242_ _0243_ _0244_ VDD VSS NAND3_X4
X_2159_ transfer_count\[0\]\[10\] _0245_ VDD VSS BUF_X2
X_2160_ transfer_count\[0\]\[9\] _0246_ VDD VSS BUF_X2
X_2161_ transfer_count\[0\]\[8\] _0247_ VDD VSS BUF_X2
X_2162_ transfer_count\[0\]\[7\] _0248_ VDD VSS CLKBUF_X3
X_2163_ _0245_ _0246_ _0247_ _0248_ _0249_ VDD VSS NAND4_X4
X_2164_ _0240_ _0244_ _0249_ _0250_ VDD VSS OR3_X4
X_2165_ transfer_count\[0\]\[28\] _0251_ VDD VSS CLKBUF_X2
X_2166_ transfer_count\[0\]\[27\] _0252_ VDD VSS BUF_X2
X_2167_ transfer_count\[0\]\[25\] _0253_ VDD VSS CLKBUF_X2
X_2168_ transfer_count\[0\]\[24\] _0254_ VDD VSS CLKBUF_X2
X_2169_ transfer_count\[0\]\[23\] _0255_ VDD VSS BUF_X2
X_2170_ transfer_count\[0\]\[26\] _0253_ _0254_ _0255_ _0256_
+ VDD VSS AND4_X2
X_2171_ transfer_count\[0\]\[22\] _0257_ VDD VSS BUF_X2
X_2172_ transfer_count\[0\]\[21\] _0258_ VDD VSS BUF_X2
X_2173_ _0257_ _0258_ _0259_ VDD VSS AND2_X1
X_2174_ _0251_ _0252_ _0256_ _0259_ _0260_ VDD VSS NAND4_X2
X_2175_ _0233_ _0237_ _0250_ _0260_ _0261_ VDD VSS NOR4_X4
X_2176_ _0226_ _0261_ _1669_ VDD VSS XNOR2_X2
X_2177_ _0256_ _0259_ _0262_ VDD VSS NAND2_X1
X_2178_ _0233_ _0237_ _0250_ _0262_ _0263_ VDD VSS NOR4_X4
X_2179_ _0252_ _0263_ _1675_ VDD VSS XNOR2_X2
X_2180_ _0254_ _0255_ _0264_ VDD VSS NAND2_X1
X_2181_ _0257_ _0258_ _0265_ VDD VSS NAND2_X1
X_2182_ _0233_ _0237_ _0250_ _0266_ VDD VSS OR3_X4
X_2183_ _0264_ _0265_ _0266_ _0267_ VDD VSS NOR3_X2
X_2184_ _0253_ _0267_ _1681_ VDD VSS XNOR2_X2
X_2185_ _0265_ _0266_ _0268_ VDD VSS NOR2_X1
X_2186_ _0255_ _0268_ _1687_ VDD VSS XNOR2_X2
X_2187_ _0258_ _0269_ VDD VSS INV_X1
X_2188_ _0269_ _0266_ _1693_ VDD VSS XNOR2_X2
X_2189_ _0237_ _0240_ _0244_ _0249_ _0270_ VDD VSS NOR4_X4
X_2190_ _0229_ _0232_ _0270_ _0271_ VDD VSS AND3_X1
X_2191_ _0228_ _0271_ _1699_ VDD VSS XNOR2_X1
X_2192_ transfer_count\[0\]\[15\] _0272_ VDD VSS INV_X1
X_2193_ _0231_ _0270_ _0273_ VDD VSS NAND2_X1
X_2194_ _0272_ _0273_ _1711_ VDD VSS XNOR2_X2
X_2195_ _0235_ _0236_ _0274_ VDD VSS NAND2_X1
X_2196_ _0274_ _0250_ _0275_ VDD VSS NOR2_X2
X_2197_ _0234_ _0275_ _1717_ VDD VSS XNOR2_X2
X_2198_ _0236_ _0250_ _1723_ VDD VSS XOR2_X2
X_2199_ _0240_ _0244_ _0276_ VDD VSS NOR2_X1
X_2200_ _0247_ _0248_ _0276_ _0277_ VDD VSS AND3_X1
X_2201_ _0246_ _0277_ _1729_ VDD VSS XNOR2_X1
X_2202_ _0248_ _0276_ _1735_ VDD VSS XNOR2_X2
X_2203_ _0243_ _0278_ VDD VSS INV_X1
X_2204_ _0278_ _0240_ _0279_ VDD VSS NOR2_X1
X_2205_ _0242_ _0279_ _1741_ VDD VSS XNOR2_X2
X_2206_ _0239_ transfer_count\[0\]\[1\] transfer_count\[0\]\[0\]
+ _0280_ VDD VSS NAND3_X1
X_2207_ _0238_ _0280_ _1747_ VDD VSS XOR2_X2
X_2208_ channel_state\[0\]\[0\] _0281_ VDD VSS CLKBUF_X2
X_2209_ channel_start[0] _0282_ VDD VSS CLKBUF_X2
X_2210_ channel_enable[0] _0283_ VDD VSS CLKBUF_X2
X_2211_ _0281_ _0282_ _0283_ _0284_ VDD VSS NAND3_X2
X_2212_ _0284_ _0285_ VDD VSS CLKBUF_X3
X_2213_ _1665_ _1668_ _1674_ _1671_ _0286_ VDD VSS NAND4_X2
X_2214_ _0286_ _0287_ VDD VSS INV_X1
X_2215_ _1676_ _1679_ _1677_ _0288_ VDD VSS AOI21_X1
X_2216_ _1677_ _1680_ _0289_ VDD VSS NAND2_X1
X_2217_ _1682_ _1683_ _1685_ _0290_ VDD VSS AOI21_X1
X_2218_ _0288_ _0289_ _0290_ _0291_ VDD VSS OAI21_X1
X_2219_ _1688_ _1691_ _1689_ _0292_ VDD VSS AOI21_X1
X_2220_ _1689_ _1692_ _0293_ VDD VSS NAND2_X1
X_2221_ _1694_ _1695_ _1697_ _0294_ VDD VSS AOI21_X1
X_2222_ _0292_ _0293_ _0294_ _0295_ VDD VSS OAI21_X1
X_2223_ _1677_ _1680_ _1686_ _1683_ _0296_ VDD VSS NAND4_X2
X_2224_ _0286_ _0296_ _0297_ VDD VSS NOR2_X2
X_2225_ _0287_ _0291_ _0295_ _0297_ _0298_ VDD VSS AOI22_X2
X_2226_ _1664_ _1667_ _1665_ _0299_ VDD VSS AOI21_X1
X_2227_ _1670_ _1671_ _1673_ _0300_ VDD VSS AOI21_X1
X_2228_ _1665_ _1668_ _0301_ VDD VSS NAND2_X1
X_2229_ _0299_ _0300_ _0301_ _0302_ VDD VSS OAI21_X1
X_2230_ _1700_ _1703_ _1701_ _0303_ VDD VSS AOI21_X1
X_2231_ _1701_ _1704_ _0304_ VDD VSS NAND2_X1
X_2232_ _1706_ _1707_ _1709_ _0305_ VDD VSS AOI21_X1
X_2233_ _0303_ _0304_ _0305_ _0306_ VDD VSS OAI21_X1
X_2234_ _1689_ _1692_ _1698_ _1695_ _0307_ VDD VSS NAND4_X2
X_2235_ _0286_ _0296_ _0307_ _0308_ VDD VSS NOR3_X2
X_2236_ _0302_ _0306_ _0308_ _0309_ VDD VSS AOI21_X1
X_2237_ _0298_ _0309_ _0310_ VDD VSS NAND2_X1
X_2238_ _1721_ _1716_ _1719_ _0311_ VDD VSS NAND3_X1
X_2239_ _1715_ _1718_ _1716_ _0312_ VDD VSS AOI21_X1
X_2240_ _0311_ _0312_ _0313_ VDD VSS NAND2_X1
X_2241_ _1712_ _0313_ _1713_ _0314_ VDD VSS AOI21_X2
X_2242_ _1713_ _1716_ _1722_ _1719_ _0315_ VDD VSS NAND4_X2
X_2243_ _0315_ _0316_ VDD VSS INV_X1
X_2244_ _1724_ _1727_ _1725_ _0317_ VDD VSS AOI21_X1
X_2245_ _1725_ _1728_ _0318_ VDD VSS NAND2_X1
X_2246_ _1730_ _1731_ _1733_ _0319_ VDD VSS AOI21_X1
X_2247_ _0317_ _0318_ _0319_ _0320_ VDD VSS OAI21_X2
X_2248_ _1725_ _1728_ _1734_ _1731_ _0321_ VDD VSS NAND4_X2
X_2249_ _0315_ _0321_ _0322_ VDD VSS NOR2_X1
X_2250_ _1736_ _1739_ _1737_ _0323_ VDD VSS AOI21_X1
X_2251_ _1737_ _1740_ _0324_ VDD VSS NAND2_X1
X_2252_ _1742_ _1743_ _1745_ _0325_ VDD VSS AOI21_X1
X_2253_ _0323_ _0324_ _0325_ _0326_ VDD VSS OAI21_X2
X_2254_ _0316_ _0320_ _0322_ _0326_ _0327_ VDD VSS AOI22_X4
X_2255_ _1737_ _1740_ _1746_ _1743_ _0328_ VDD VSS NAND4_X2
X_2256_ _0315_ _0321_ _0328_ _0329_ VDD VSS OR3_X1
X_2257_ _1756_ _0330_ VDD VSS INV_X1
X_2258_ _1757_ _0331_ VDD VSS INV_X1
X_2259_ _0330_ _1760_ _0331_ _0332_ VDD VSS OAI21_X1
X_2260_ _1749_ _1752_ _0333_ VDD VSS AND2_X1
X_2261_ _1748_ _0332_ _0333_ _1751_ _1749_ _0334_ VDD VSS
+ AOI221_X2
X_2262_ _0314_ _0327_ _0329_ _0334_ _0335_ VDD VSS OAI211_X4
X_2263_ _0310_ _0335_ _0336_ VDD VSS NOR2_X1
X_2264_ channel_state\[0\]\[1\] _0337_ VDD VSS CLKBUF_X2
X_2265_ _0337_ net130 _0338_ VDD VSS NAND2_X4
X_2266_ _1178_ _0338_ _0339_ VDD VSS NOR2_X1
X_2267_ _0339_ _0340_ VDD VSS CLKBUF_X3
X_2268_ _1707_ _1710_ _0341_ VDD VSS NAND2_X1
X_2269_ _0307_ _0304_ _0341_ _0342_ VDD VSS NOR3_X2
X_2270_ _0302_ _0342_ _0297_ _0308_ _0306_ _0343_ VDD VSS
+ AOI221_X2
X_2271_ _0298_ _0343_ _0344_ VDD VSS NAND2_X2
X_2272_ _0315_ _0321_ _0328_ _0345_ VDD VSS NOR3_X2
X_2273_ _1757_ _1761_ _0333_ _0346_ VDD VSS AND3_X1
X_2274_ _0297_ _0345_ _0342_ _0346_ _0347_ VDD VSS NAND4_X2
X_2275_ _0340_ _0344_ _0347_ _0348_ VDD VSS NAND3_X1
X_2276_ _0219_ _0285_ _0336_ _0348_ _0007_ VDD VSS OAI22_X1
X_2277_ _1206_ _0349_ VDD VSS BUF_X4
X_2278_ channel_state\[0\]\[2\] _0350_ VDD VSS INV_X1
X_2279_ _0350_ net134 _0351_ VDD VSS NOR2_X1
X_2280_ channel_state\[0\]\[3\] _0285_ _0351_ _0352_ VDD VSS
+ AOI21_X1
X_2281_ _0349_ _0352_ _0006_ VDD VSS NOR2_X1
X_2282_ _1089_ channel_state\[2\]\[3\] _0047_ VDD VSS AND2_X1
X_2283_ net129 _1091_ _1094_ _0353_ VDD VSS AND3_X4
X_2284_ _1178_ _0353_ _0354_ VDD VSS NOR2_X4
X_2285_ channel_state\[2\]\[2\] _0355_ VDD VSS INV_X1
X_2286_ net136 _0355_ _0356_ VDD VSS NOR2_X1
X_2287_ _0047_ _0354_ _0356_ _0357_ VDD VSS AOI21_X1
X_2288_ _0357_ _0016_ VDD VSS INV_X1
X_2289_ _1088_ channel_state\[1\]\[3\] _0046_ VDD VSS AND2_X1
X_2290_ _1261_ _1260_ _1262_ _0358_ VDD VSS AND3_X2
X_2291_ _1178_ _0358_ _0359_ VDD VSS NOR2_X4
X_2292_ channel_state\[1\]\[2\] _0360_ VDD VSS INV_X1
X_2293_ _0360_ net135 _0361_ VDD VSS NOR2_X1
X_2294_ _0046_ _0359_ _0361_ _0362_ VDD VSS AOI21_X1
X_2295_ _0362_ _0011_ VDD VSS INV_X1
X_2296_ _0281_ _0283_ _0363_ VDD VSS NAND2_X1
X_2297_ _1087_ channel_state\[0\]\[4\] _0282_ _0363_ _0364_
+ VDD VSS NAND4_X1
X_2298_ _0347_ _0364_ _0365_ VDD VSS AND2_X1
X_2299_ _0344_ _0365_ _0310_ _0335_ _0366_ VDD VSS OAI211_X2
X_2300_ _0337_ net130 _0367_ VDD VSS AND2_X1
X_2301_ _0367_ _0368_ VDD VSS BUF_X4
X_2302_ _1087_ _0368_ _0369_ VDD VSS NAND2_X1
X_2303_ _0369_ _0370_ VDD VSS CLKBUF_X3
X_2304_ _0370_ _0364_ _0371_ VDD VSS NAND2_X1
X_2305_ _0366_ _0371_ _0008_ VDD VSS AND2_X1
X_2306_ _1089_ _0372_ VDD VSS BUF_X4
X_2307_ _0337_ _0373_ VDD VSS INV_X1
X_2308_ _0281_ _0282_ _0283_ _0374_ VDD VSS AND3_X2
X_2309_ _0373_ net130 _0374_ _0375_ VDD VSS NOR3_X1
X_2310_ _0372_ channel_state\[0\]\[5\] _0375_ _0376_ VDD VSS
+ OAI21_X1
X_2311_ _0376_ _0005_ VDD VSS INV_X1
X_2312_ _1179_ _0377_ VDD VSS INV_X1
X_2313_ net132 _0377_ _0353_ _0378_ VDD VSS NOR3_X1
X_2314_ _0372_ channel_state\[2\]\[5\] _0378_ _0379_ VDD VSS
+ OAI21_X1
X_2315_ _0379_ _0015_ VDD VSS INV_X1
X_2316_ _1089_ _0380_ VDD VSS BUF_X4
X_2317_ channel_state\[1\]\[1\] _0381_ VDD VSS INV_X1
X_2318_ net131 _0381_ _0358_ _0382_ VDD VSS NOR3_X1
X_2319_ _0380_ channel_state\[1\]\[5\] _0382_ _0383_ VDD VSS
+ OAI21_X1
X_2320_ _0383_ _0010_ VDD VSS INV_X1
X_2321_ _0282_ _0283_ _0384_ VDD VSS AND2_X1
X_2322_ _0282_ _0385_ VDD VSS INV_X1
X_2323_ _0281_ channel_state\[0\]\[4\] _0385_ _0386_ VDD VSS
+ AOI21_X1
X_2324_ _1090_ _0384_ _0386_ _0004_ VDD VSS OAI21_X1
X_2325_ _1260_ _1262_ _0387_ VDD VSS AND2_X1
X_2326_ _1260_ _0388_ VDD VSS INV_X1
X_2327_ _1261_ _0388_ channel_state\[1\]\[4\] _0389_ VDD VSS
+ AOI21_X1
X_2328_ _1090_ _0387_ _0389_ _0009_ VDD VSS OAI21_X1
X_2329_ transfer_count\[3\]\[5\] _0390_ VDD VSS BUF_X2
X_2330_ transfer_count\[3\]\[3\] _0391_ VDD VSS BUF_X2
X_2331_ transfer_count\[3\]\[4\] _0392_ VDD VSS BUF_X2
X_2332_ transfer_count\[3\]\[2\] _0393_ VDD VSS BUF_X2
X_2333_ _0393_ transfer_count\[3\]\[1\] transfer_count\[3\]\[0\]
+ _0394_ VDD VSS AND3_X1
X_2334_ _0394_ _0395_ VDD VSS BUF_X2
X_2335_ _0391_ _0392_ _0395_ _0396_ VDD VSS NAND3_X1
X_2336_ _0390_ _0396_ _1783_ VDD VSS XOR2_X2
X_2337_ transfer_count\[3\]\[13\] _0397_ VDD VSS BUF_X2
X_2338_ transfer_count\[3\]\[11\] _0398_ VDD VSS CLKBUF_X2
X_2339_ transfer_count\[3\]\[10\] _0399_ VDD VSS BUF_X2
X_2340_ transfer_count\[3\]\[9\] _0400_ VDD VSS BUF_X4
X_2341_ transfer_count\[3\]\[12\] _0398_ _0399_ _0400_ _0401_
+ VDD VSS AND4_X2
X_2342_ transfer_count\[3\]\[7\] _0402_ VDD VSS BUF_X4
X_2343_ transfer_count\[3\]\[8\] _0403_ VDD VSS CLKBUF_X3
X_2344_ _0391_ transfer_count\[3\]\[6\] _0390_ _0392_ _0404_
+ VDD VSS AND4_X4
X_2345_ _0402_ _0403_ _0395_ _0404_ _0405_ VDD VSS AND4_X1
X_2346_ _0405_ _0406_ VDD VSS CLKBUF_X3
X_2347_ _0401_ _0406_ _0407_ VDD VSS NAND2_X1
X_2348_ _0397_ _0407_ _1795_ VDD VSS XOR2_X2
X_2349_ _0400_ _0406_ _1807_ VDD VSS XNOR2_X1
X_2350_ transfer_count\[3\]\[23\] _0408_ VDD VSS BUF_X2
X_2351_ transfer_count\[3\]\[24\] _0408_ _0409_ VDD VSS AND2_X1
X_2352_ transfer_count\[3\]\[26\] transfer_count\[3\]\[25\]
+ _0410_ VDD VSS AND2_X1
X_2353_ transfer_count\[3\]\[27\] _0409_ _0410_ _0411_ VDD
+ VSS AND3_X1
X_2354_ _0395_ _0412_ VDD VSS INV_X1
X_2355_ _0402_ _0403_ _0404_ _0413_ VDD VSS NAND3_X2
X_2356_ transfer_count\[3\]\[22\] _0414_ VDD VSS BUF_X2
X_2357_ transfer_count\[3\]\[21\] _0415_ VDD VSS BUF_X2
X_2358_ transfer_count\[3\]\[20\] _0416_ VDD VSS CLKBUF_X2
X_2359_ transfer_count\[3\]\[19\] _0417_ VDD VSS BUF_X2
X_2360_ transfer_count\[3\]\[17\] _0418_ VDD VSS BUF_X4
X_2361_ _0416_ _0417_ transfer_count\[3\]\[18\] _0418_ _0419_
+ VDD VSS AND4_X1
X_2362_ _0414_ _0415_ _0419_ _0420_ VDD VSS NAND3_X4
X_2363_ transfer_count\[3\]\[16\] _0421_ VDD VSS BUF_X2
X_2364_ transfer_count\[3\]\[14\] _0397_ transfer_count\[3\]\[15\]
+ _0422_ VDD VSS AND3_X1
X_2365_ _0421_ _0401_ _0422_ _0423_ VDD VSS NAND3_X4
X_2366_ _0412_ _0413_ _0420_ _0423_ _0424_ VDD VSS NOR4_X4
X_2367_ transfer_count\[3\]\[28\] _0411_ _0424_ _0425_ VDD
+ VSS AND3_X1
X_2368_ transfer_count\[3\]\[29\] _0425_ _1819_ VDD VSS XNOR2_X1
X_2369_ transfer_count\[3\]\[25\] _0426_ VDD VSS INV_X1
X_2370_ _0409_ _0424_ _0427_ VDD VSS NAND2_X1
X_2371_ _0426_ _0427_ _1831_ VDD VSS XNOR2_X1
X_2372_ _0421_ _0401_ _0422_ _0428_ VDD VSS AND3_X1
X_2373_ _0406_ _0419_ _0428_ _0429_ VDD VSS AND3_X1
X_2374_ _0415_ _0429_ _1843_ VDD VSS XNOR2_X1
X_2375_ _0402_ _0403_ _0395_ _0404_ _0430_ VDD VSS NAND4_X4
X_2376_ _0430_ _0423_ _0431_ VDD VSS NOR2_X2
X_2377_ _0418_ _0431_ _1855_ VDD VSS XNOR2_X2
X_2378_ channel_start[3] _0432_ VDD VSS BUF_X2
X_2379_ _1088_ channel_state\[3\]\[4\] _0432_ _0433_ VDD VSS
+ NAND3_X1
X_2380_ channel_enable[3] _0434_ VDD VSS BUF_X2
X_2381_ channel_state\[3\]\[0\] _0435_ VDD VSS BUF_X2
X_2382_ _0433_ _0434_ _0435_ _0436_ VDD VSS AOI21_X1
X_2383_ channel_state\[3\]\[1\] _0437_ VDD VSS BUF_X2
X_2384_ _0437_ net133 _0438_ VDD VSS NAND2_X4
X_2385_ _1178_ _0438_ _0439_ VDD VSS NOR2_X4
X_2386_ _1850_ _1853_ _1851_ _0440_ VDD VSS AOI21_X1
X_2387_ _1851_ _1854_ _0441_ VDD VSS NAND2_X1
X_2388_ _1856_ _1859_ _1857_ _0442_ VDD VSS AOI21_X1
X_2389_ _0440_ _0441_ _0442_ _0443_ VDD VSS OAI21_X1
X_2390_ _1815_ _1821_ _1818_ _1824_ _0444_ VDD VSS NAND4_X4
X_2391_ _1827_ _1833_ _1830_ _1836_ _0445_ VDD VSS NAND4_X4
X_2392_ _1839_ _1845_ _1842_ _1848_ _0446_ VDD VSS NAND4_X2
X_2393_ _0444_ _0445_ _0446_ _0447_ VDD VSS NOR3_X1
X_2394_ _1821_ _1818_ _1823_ _0448_ VDD VSS NAND3_X1
X_2395_ _1817_ _1820_ _1818_ _0449_ VDD VSS AOI21_X1
X_2396_ _0448_ _0449_ _0450_ VDD VSS NAND2_X1
X_2397_ _1814_ _0443_ _0447_ _0450_ _1815_ _0451_ VDD VSS
+ AOI221_X2
X_2398_ _0444_ _0452_ VDD VSS INV_X1
X_2399_ _1826_ _1829_ _1827_ _0453_ VDD VSS AOI21_X1
X_2400_ _1827_ _1830_ _0454_ VDD VSS NAND2_X1
X_2401_ _1832_ _1835_ _1833_ _0455_ VDD VSS AOI21_X1
X_2402_ _0453_ _0454_ _0455_ _0456_ VDD VSS OAI21_X1
X_2403_ _0444_ _0445_ _0457_ VDD VSS NOR2_X1
X_2404_ _1838_ _1841_ _1839_ _0458_ VDD VSS AOI21_X1
X_2405_ _1839_ _1842_ _0459_ VDD VSS NAND2_X1
X_2406_ _1844_ _1847_ _1845_ _0460_ VDD VSS AOI21_X1
X_2407_ _0458_ _0459_ _0460_ _0461_ VDD VSS OAI21_X1
X_2408_ _0452_ _0456_ _0457_ _0461_ _0462_ VDD VSS AOI22_X2
X_2409_ _0439_ _0451_ _0462_ _0463_ VDD VSS NAND3_X1
X_2410_ _1851_ _1857_ _1854_ _1860_ _0464_ VDD VSS NAND4_X2
X_2411_ _0444_ _0445_ _0446_ _0464_ _0465_ VDD VSS NOR4_X4
X_2412_ _1803_ _1809_ _1806_ _1812_ _0466_ VDD VSS NAND4_X2
X_2413_ _1791_ _1797_ _1794_ _1800_ _0467_ VDD VSS NAND4_X2
X_2414_ _0466_ _0467_ _0468_ VDD VSS NOR2_X1
X_2415_ _1778_ _1781_ _1779_ _0469_ VDD VSS AOI21_X1
X_2416_ _1779_ _1782_ _0470_ VDD VSS NAND2_X1
X_2417_ _1784_ _1787_ _1785_ _0471_ VDD VSS AOI21_X1
X_2418_ _0469_ _0470_ _0471_ _0472_ VDD VSS OAI21_X1
X_2419_ _1797_ _1794_ _1799_ _0473_ VDD VSS NAND3_X1
X_2420_ _1793_ _1796_ _1794_ _0474_ VDD VSS AOI21_X1
X_2421_ _0473_ _0474_ _0475_ VDD VSS NAND2_X1
X_2422_ _1790_ _0468_ _0472_ _0475_ _1791_ _0476_ VDD VSS
+ AOI221_X2
X_2423_ _0467_ _0477_ VDD VSS INV_X1
X_2424_ _1802_ _1805_ _1803_ _0478_ VDD VSS AOI21_X1
X_2425_ _1803_ _1806_ _0479_ VDD VSS NAND2_X1
X_2426_ _1808_ _1811_ _1809_ _0480_ VDD VSS AOI21_X1
X_2427_ _0478_ _0479_ _0480_ _0481_ VDD VSS OAI21_X1
X_2428_ _0477_ _0481_ _0482_ VDD VSS NAND2_X1
X_2429_ _1769_ _0483_ VDD VSS INV_X1
X_2430_ _1770_ _0484_ VDD VSS INV_X1
X_2431_ _0483_ _1764_ _0484_ _0485_ VDD VSS OAI21_X1
X_2432_ _1773_ _1776_ _0486_ VDD VSS AND2_X1
X_2433_ _1772_ _0485_ _0486_ _1775_ _1773_ _0487_ VDD VSS
+ AOI221_X2
X_2434_ _1785_ _1788_ _0488_ VDD VSS NAND2_X1
X_2435_ _0466_ _0467_ _0470_ _0488_ _0489_ VDD VSS OR4_X1
X_2436_ _0476_ _0482_ _0487_ _0489_ _0490_ VDD VSS OAI211_X2
X_2437_ _0463_ _0465_ _0490_ _0491_ VDD VSS AOI21_X1
X_2438_ _0437_ net133 _0492_ VDD VSS AND2_X1
X_2439_ _1087_ _0492_ _0493_ VDD VSS NAND2_X1
X_2440_ _0466_ _0467_ _0470_ _0488_ _0494_ VDD VSS NOR4_X2
X_2441_ _1770_ _1765_ _0495_ VDD VSS AND2_X1
X_2442_ _0486_ _0494_ _0495_ _0465_ _0496_ VDD VSS NAND4_X2
X_2443_ _0493_ _0496_ _0497_ VDD VSS NOR2_X1
X_2444_ _0436_ _0491_ _0497_ _0023_ VDD VSS OR3_X1
X_2445_ _0439_ _0498_ VDD VSS CLKBUF_X3
X_2446_ _0451_ _0462_ _0499_ VDD VSS NAND2_X1
X_2447_ _0498_ _0499_ _0496_ _0500_ VDD VSS NAND3_X1
X_2448_ _0439_ _0496_ _0501_ VDD VSS NAND2_X1
X_2449_ _0490_ _0465_ _0502_ VDD VSS NAND2_X1
X_2450_ _0435_ _0432_ _0434_ _0503_ VDD VSS NAND3_X4
X_2451_ _0500_ _0501_ _0502_ _1206_ _0503_ _0022_ VDD VSS
+ OAI221_X1
X_2452_ channel_state\[3\]\[2\] _0504_ VDD VSS INV_X1
X_2453_ _0504_ net137 _0505_ VDD VSS NOR2_X1
X_2454_ channel_state\[3\]\[3\] _0503_ _0505_ _0506_ VDD VSS
+ AOI21_X1
X_2455_ _0349_ _0506_ _0021_ VDD VSS NOR2_X1
X_2456_ _0437_ _0507_ VDD VSS INV_X1
X_2457_ _0435_ _0432_ _0434_ _0508_ VDD VSS AND3_X2
X_2458_ _0507_ net133 _0508_ _0509_ VDD VSS NOR3_X1
X_2459_ _0380_ channel_state\[3\]\[5\] _0509_ _0510_ VDD VSS
+ OAI21_X1
X_2460_ _0510_ _0020_ VDD VSS INV_X1
X_2461_ _0432_ _0434_ _0511_ VDD VSS AND2_X1
X_2462_ _0432_ _0512_ VDD VSS INV_X1
X_2463_ _0435_ channel_state\[3\]\[4\] _0512_ _0513_ VDD VSS
+ AOI21_X1
X_2464_ _1090_ _0511_ _0513_ _0019_ VDD VSS OAI21_X1
X_2465_ net129 channel_state\[2\]\[4\] _0354_ _0514_ VDD VSS
+ AND3_X1
X_2466_ net132 _1179_ _0515_ VDD VSS AND2_X2
X_2467_ _1087_ _0515_ _0516_ VDD VSS NAND2_X2
X_2468_ _1167_ _0516_ _1175_ _1203_ _0517_ VDD VSS AOI211_X2
X_2469_ _0516_ _0518_ VDD VSS CLKBUF_X3
X_2470_ _1177_ _0518_ _0519_ VDD VSS NOR2_X2
X_2471_ _0514_ _0517_ _0519_ _0018_ VDD VSS OR3_X1
X_2472_ _0380_ channel_state\[1\]\[2\] net135 _0001_ VDD VSS
+ AND3_X1
X_2473_ _0380_ channel_state\[0\]\[2\] net134 _0000_ VDD VSS
+ AND3_X1
X_2474_ _0380_ channel_state\[3\]\[2\] net137 _0003_ VDD VSS
+ AND3_X1
X_2475_ _0380_ net136 channel_state\[2\]\[2\] _0002_ VDD VSS
+ AND3_X1
X_2476_ net89 _1465_ VDD VSS INV_X1
X_2477_ _1100_ _1469_ _1108_ _0520_ VDD VSS NAND3_X2
X_2478_ _1114_ _1119_ _0520_ _0521_ VDD VSS OR3_X1
X_2479_ _0521_ _0522_ VDD VSS BUF_X4
X_2480_ _1104_ _1106_ _0522_ _0523_ VDD VSS NOR3_X2
X_2481_ _1131_ _0523_ _1495_ VDD VSS XNOR2_X1
X_2482_ _1106_ _0522_ _1501_ VDD VSS XNOR2_X1
X_2483_ transfer_count\[2\]\[30\] _0524_ VDD VSS INV_X1
X_2484_ _1118_ _1121_ _1122_ _1123_ _0525_ VDD VSS NAND4_X2
X_2485_ _0524_ _0525_ _0526_ VDD VSS OR2_X1
X_2486_ _1120_ _1129_ _1136_ _0526_ _0527_ VDD VSS NOR4_X4
X_2487_ transfer_count\[2\]\[31\] _0527_ _1516_ VDD VSS XNOR2_X2
X_2488_ net54 _1659_ VDD VSS INV_X1
X_2489_ net1 _1758_ VDD VSS INV_X1
X_2490_ net124 _1762_ VDD VSS INV_X2
X_2491_ _1098_ _1101_ _1474_ VDD VSS XOR2_X2
X_2492_ _1100_ _1469_ _1477_ VDD VSS XNOR2_X2
X_2493_ _1101_ _1114_ _0528_ VDD VSS NOR2_X1
X_2494_ _1108_ _0528_ _1480_ VDD VSS XNOR2_X2
X_2495_ _1100_ _1469_ _0529_ VDD VSS AND2_X1
X_2496_ _1098_ _1097_ _1099_ _0529_ _0530_ VDD VSS NAND4_X2
X_2497_ transfer_count\[2\]\[6\] _0530_ _1483_ VDD VSS XOR2_X2
X_2498_ _1098_ _0529_ _0531_ VDD VSS NAND2_X1
X_2499_ _1099_ _0531_ _1489_ VDD VSS XOR2_X2
X_2500_ _1131_ transfer_count\[2\]\[13\] _1105_ _0532_ VDD
+ VSS NAND3_X1
X_2501_ _1120_ _0532_ _0533_ VDD VSS NOR2_X1
X_2502_ transfer_count\[2\]\[15\] _0533_ _1492_ VDD VSS XNOR2_X1
X_2503_ _1109_ _1115_ _0534_ VDD VSS NOR2_X1
X_2504_ transfer_count\[2\]\[11\] _0534_ _1504_ VDD VSS XNOR2_X2
X_2505_ _1111_ _1113_ _1114_ _0520_ _0535_ VDD VSS NOR4_X2
X_2506_ transfer_count\[2\]\[10\] _0535_ _1507_ VDD VSS XNOR2_X2
X_2507_ _1114_ _0520_ _0536_ VDD VSS NOR2_X2
X_2508_ _1112_ _0536_ _1513_ VDD VSS XNOR2_X2
X_2509_ _1129_ _1136_ _0522_ _0525_ _0537_ VDD VSS NOR4_X2
X_2510_ transfer_count\[2\]\[30\] _0537_ _1519_ VDD VSS XNOR2_X1
X_2511_ _1122_ _1123_ _0538_ VDD VSS NAND2_X1
X_2512_ _0538_ _1129_ _1136_ _0522_ _0539_ VDD VSS NOR4_X2
X_2513_ _1121_ _0539_ _1525_ VDD VSS XNOR2_X1
X_2514_ _1122_ _0540_ VDD VSS INV_X1
X_2515_ _1123_ transfer_count\[2\]\[25\] _1139_ _1140_ _0541_
+ VDD VSS NAND4_X2
X_2516_ _0540_ _0541_ _1528_ VDD VSS XNOR2_X2
X_2517_ _1136_ _0521_ _0542_ VDD VSS OR2_X2
X_2518_ _1129_ _0542_ _0543_ VDD VSS NOR2_X1
X_2519_ _1123_ _0543_ _1531_ VDD VSS XNOR2_X1
X_2520_ _1128_ _0544_ VDD VSS INV_X1
X_2521_ _0544_ _1136_ _0522_ _0545_ VDD VSS NOR3_X2
X_2522_ _1125_ _0545_ _1537_ VDD VSS XNOR2_X1
X_2523_ transfer_count\[2\]\[22\] _1126_ _1127_ _0546_ VDD
+ VSS AND3_X1
X_2524_ _0546_ _1140_ _0547_ VDD VSS NAND2_X1
X_2525_ transfer_count\[2\]\[23\] _0547_ _1540_ VDD VSS XOR2_X2
X_2526_ _1126_ _1127_ _0548_ VDD VSS NAND2_X1
X_2527_ _0548_ _0542_ _0549_ VDD VSS NOR2_X1
X_2528_ transfer_count\[2\]\[22\] _0549_ _1543_ VDD VSS XNOR2_X2
X_2529_ _1127_ _0542_ _1549_ VDD VSS XOR2_X2
X_2530_ _1133_ _1134_ _1144_ _0550_ VDD VSS AND3_X1
X_2531_ transfer_count\[2\]\[19\] _0550_ _1552_ VDD VSS XNOR2_X1
X_2532_ _1134_ _0551_ VDD VSS INV_X1
X_2533_ _0551_ _1143_ _0522_ _0552_ VDD VSS NOR3_X2
X_2534_ _1133_ _0552_ _1555_ VDD VSS XNOR2_X1
X_2535_ transfer_count\[2\]\[15\] _0553_ VDD VSS INV_X1
X_2536_ _0553_ _0532_ _0522_ _0554_ VDD VSS NOR3_X2
X_2537_ _1130_ _0554_ _1561_ VDD VSS XNOR2_X1
X_2538_ transfer_count\[1\]\[31\] _0555_ VDD VSS INV_X1
X_2539_ transfer_count\[1\]\[30\] _0556_ VDD VSS INV_X1
X_2540_ _1219_ _1223_ _1225_ _0557_ VDD VSS AND3_X1
X_2541_ _1216_ _1217_ _0557_ _1249_ _0558_ VDD VSS NAND4_X2
X_2542_ transfer_count\[1\]\[29\] _1208_ _1209_ _1214_ _0559_
+ VDD VSS NAND4_X2
X_2543_ _0556_ _0558_ _0559_ _0560_ VDD VSS OR3_X2
X_2544_ _0555_ _0560_ _1564_ VDD VSS XNOR2_X2
X_2545_ _1654_ _0561_ VDD VSS BUF_X2
X_2546_ _1231_ _1232_ _0561_ _0562_ VDD VSS NAND3_X4
X_2547_ _1230_ _1237_ _1240_ _0562_ _0563_ VDD VSS OR4_X4
X_2548_ _1218_ _1226_ _0559_ _0563_ _0564_ VDD VSS NOR4_X4
X_2549_ transfer_count\[1\]\[30\] _0564_ _1567_ VDD VSS XNOR2_X1
X_2550_ _1209_ _1214_ _0565_ VDD VSS NAND2_X1
X_2551_ _0565_ _1218_ _1226_ _0563_ _0566_ VDD VSS NOR4_X2
X_2552_ _1208_ _0566_ _1573_ VDD VSS XNOR2_X1
X_2553_ _1211_ _1212_ _1213_ _0567_ VDD VSS NAND3_X2
X_2554_ _0567_ _1218_ _1226_ _0563_ _0568_ VDD VSS NOR4_X4
X_2555_ _1210_ _0568_ _1579_ VDD VSS XNOR2_X1
X_2556_ _1213_ _0569_ VDD VSS INV_X1
X_2557_ _0569_ _1218_ _1226_ _0563_ _0570_ VDD VSS NOR4_X4
X_2558_ _1212_ _0570_ _1585_ VDD VSS XNOR2_X1
X_2559_ _1230_ _1237_ _1240_ _0562_ _0571_ VDD VSS NOR4_X4
X_2560_ _1217_ _0557_ _0571_ _0572_ VDD VSS AND3_X1
X_2561_ _1216_ _0572_ _1591_ VDD VSS XNOR2_X1
X_2562_ _1223_ _1225_ _0571_ _0573_ VDD VSS NAND3_X2
X_2563_ _1219_ _0573_ _1597_ VDD VSS XOR2_X2
X_2564_ _1223_ _0571_ _0574_ VDD VSS AND2_X1
X_2565_ _1224_ _0574_ _1603_ VDD VSS XNOR2_X2
X_2566_ transfer_count\[1\]\[17\] _0575_ VDD VSS INV_X1
X_2567_ _1220_ _1221_ _1222_ _0576_ VDD VSS AND3_X1
X_2568_ _0576_ _1249_ _0577_ VDD VSS NAND2_X1
X_2569_ _0575_ _0577_ _1606_ VDD VSS XNOR2_X2
X_2570_ _1221_ _1222_ _0571_ _0578_ VDD VSS AND3_X1
X_2571_ _1220_ _0578_ _1609_ VDD VSS XNOR2_X2
X_2572_ _1222_ _0571_ _1615_ VDD VSS XNOR2_X2
X_2573_ _1239_ _0579_ VDD VSS INV_X1
X_2574_ _0579_ _1230_ _1237_ _0562_ _0580_ VDD VSS NOR4_X2
X_2575_ _1238_ _0580_ _1621_ VDD VSS XNOR2_X2
X_2576_ _1230_ _0562_ _0581_ VDD VSS NOR2_X1
X_2577_ transfer_count\[1\]\[9\] _1235_ _1236_ _0581_ _0582_
+ VDD VSS AND4_X1
X_2578_ transfer_count\[1\]\[10\] _0582_ _1627_ VDD VSS XNOR2_X2
X_2579_ _1236_ _0581_ _0583_ VDD VSS NAND2_X1
X_2580_ _1235_ _0583_ _1633_ VDD VSS XOR2_X2
X_2581_ _1231_ _1232_ _0561_ _0584_ VDD VSS AND3_X1
X_2582_ _1228_ _1229_ _0584_ _0585_ VDD VSS AND3_X1
X_2583_ _1227_ _0585_ _1639_ VDD VSS XNOR2_X2
X_2584_ _1229_ _0584_ _1645_ VDD VSS XNOR2_X2
X_2585_ _1232_ _0561_ _1651_ VDD VSS XNOR2_X1
X_2586_ transfer_count\[0\]\[31\] _0586_ VDD VSS INV_X1
X_2587_ transfer_count\[0\]\[30\] _0226_ _0261_ _0587_ VDD
+ VSS NAND3_X1
X_2588_ _0586_ _0587_ _1663_ VDD VSS XNOR2_X2
X_2589_ _0226_ _0251_ _0252_ _0256_ _0588_ VDD VSS NAND4_X1
X_2590_ _0227_ _0228_ _0229_ _0232_ _0589_ VDD VSS AND4_X2
X_2591_ _0238_ _0239_ _1753_ _0590_ VDD VSS NAND3_X4
X_2592_ _0237_ _0244_ _0249_ _0590_ _0591_ VDD VSS NOR4_X4
X_2593_ _0257_ _0258_ _0589_ _0591_ _0592_ VDD VSS NAND4_X4
X_2594_ _0588_ _0592_ _0593_ VDD VSS NOR2_X1
X_2595_ transfer_count\[0\]\[30\] _0593_ _1666_ VDD VSS XNOR2_X2
X_2596_ _0252_ _0256_ _0594_ VDD VSS NAND2_X1
X_2597_ _0594_ _0592_ _0595_ VDD VSS NOR2_X1
X_2598_ _0251_ _0595_ _1672_ VDD VSS XNOR2_X2
X_2599_ _0253_ _0254_ _0255_ _0596_ VDD VSS NAND3_X1
X_2600_ _0596_ _0592_ _0597_ VDD VSS NOR2_X1
X_2601_ transfer_count\[0\]\[26\] _0597_ _1678_ VDD VSS XNOR2_X2
X_2602_ _0255_ _0598_ VDD VSS INV_X1
X_2603_ _0598_ _0592_ _0599_ VDD VSS NOR2_X1
X_2604_ _0254_ _0599_ _1684_ VDD VSS XNOR2_X2
X_2605_ _0246_ _0247_ _0248_ _0600_ VDD VSS NAND3_X2
X_2606_ _0244_ _0600_ _0590_ _0601_ VDD VSS NOR3_X4
X_2607_ _0245_ _0602_ VDD VSS INV_X1
X_2608_ _0602_ _0237_ _0603_ VDD VSS NOR2_X1
X_2609_ _0258_ _0589_ _0601_ _0603_ _0604_ VDD VSS NAND4_X2
X_2610_ _0257_ _0604_ _1690_ VDD VSS XOR2_X2
X_2611_ _0228_ _0229_ _0232_ _0605_ VDD VSS NAND3_X1
X_2612_ _0237_ _0244_ _0249_ _0590_ _0606_ VDD VSS OR4_X4
X_2613_ _0605_ _0606_ _0607_ VDD VSS NOR2_X2
X_2614_ _0227_ _0607_ _1696_ VDD VSS XNOR2_X2
X_2615_ _0232_ _0608_ VDD VSS INV_X1
X_2616_ _0608_ _0606_ _0609_ VDD VSS NOR2_X1
X_2617_ _0229_ _0609_ _1702_ VDD VSS XNOR2_X1
X_2618_ transfer_count\[0\]\[17\] _0610_ VDD VSS INV_X1
X_2619_ _0230_ transfer_count\[0\]\[15\] _0231_ _0270_ _0611_
+ VDD VSS NAND4_X2
X_2620_ _0610_ _0611_ _1705_ VDD VSS XNOR2_X2
X_2621_ _0231_ _0612_ VDD VSS INV_X1
X_2622_ _0272_ _0612_ _0606_ _0613_ VDD VSS NOR3_X2
X_2623_ _0230_ _0613_ _1708_ VDD VSS XNOR2_X1
X_2624_ _0612_ _0606_ _1714_ VDD VSS XNOR2_X1
X_2625_ _0236_ _0245_ _0601_ _0614_ VDD VSS NAND3_X2
X_2626_ _0235_ _0614_ _1720_ VDD VSS XOR2_X2
X_2627_ _0245_ _0601_ _1726_ VDD VSS XNOR2_X1
X_2628_ _0248_ _0615_ VDD VSS INV_X1
X_2629_ _0615_ _0244_ _0590_ _0616_ VDD VSS NOR3_X2
X_2630_ _0247_ _0616_ _1732_ VDD VSS XNOR2_X2
X_2631_ _0242_ _0617_ VDD VSS INV_X1
X_2632_ _0617_ _0278_ _0590_ _0618_ VDD VSS NOR3_X2
X_2633_ _0241_ _0618_ _1738_ VDD VSS XNOR2_X1
X_2634_ _0278_ _0590_ _1744_ VDD VSS XNOR2_X1
X_2635_ _0239_ _1753_ _1750_ VDD VSS XNOR2_X2
X_2636_ _0391_ _0395_ _1771_ VDD VSS XNOR2_X1
X_2637_ _1766_ _0619_ VDD VSS BUF_X1
X_2638_ _0393_ _0619_ _1774_ VDD VSS XNOR2_X1
X_2639_ _0395_ _0404_ _0620_ VDD VSS NAND2_X1
X_2640_ _0402_ _0620_ _1777_ VDD VSS XOR2_X2
X_2641_ _0393_ _0619_ _0621_ VDD VSS AND2_X2
X_2642_ _0391_ _0390_ _0392_ _0621_ _0622_ VDD VSS NAND4_X2
X_2643_ transfer_count\[3\]\[6\] _0622_ _1780_ VDD VSS XOR2_X2
X_2644_ _0391_ _0621_ _0623_ VDD VSS NAND2_X1
X_2645_ _0392_ _0623_ _1786_ VDD VSS XOR2_X2
X_2646_ transfer_count\[3\]\[14\] _0397_ _0401_ _0406_ _0624_
+ VDD VSS AND4_X1
X_2647_ transfer_count\[3\]\[15\] _0624_ _1789_ VDD VSS XNOR2_X1
X_2648_ transfer_count\[3\]\[14\] _0625_ VDD VSS INV_X1
X_2649_ _0402_ _0403_ _0404_ _0621_ _0626_ VDD VSS AND4_X2
X_2650_ _0397_ _0401_ _0626_ _0627_ VDD VSS NAND3_X1
X_2651_ _0625_ _0627_ _1792_ VDD VSS XNOR2_X1
X_2652_ _0398_ _0399_ _0400_ _0626_ _0628_ VDD VSS NAND4_X2
X_2653_ transfer_count\[3\]\[12\] _0628_ _1798_ VDD VSS XOR2_X2
X_2654_ _0399_ _0400_ _0406_ _0629_ VDD VSS NAND3_X2
X_2655_ _0398_ _0629_ _1801_ VDD VSS XOR2_X2
X_2656_ _0400_ _0626_ _0630_ VDD VSS NAND2_X1
X_2657_ _0399_ _0630_ _1804_ VDD VSS XOR2_X2
X_2658_ _0403_ _0631_ VDD VSS INV_X1
X_2659_ _0402_ _0404_ _0621_ _0632_ VDD VSS NAND3_X2
X_2660_ _0631_ _0632_ _1810_ VDD VSS XNOR2_X1
X_2661_ transfer_count\[3\]\[31\] _0633_ VDD VSS INV_X1
X_2662_ _0430_ _0420_ _0423_ _0634_ VDD VSS NOR3_X4
X_2663_ transfer_count\[3\]\[29\] transfer_count\[3\]\[28\]
+ _0411_ _0635_ VDD VSS AND3_X1
X_2664_ transfer_count\[3\]\[30\] _0634_ _0635_ _0636_ VDD
+ VSS NAND3_X1
X_2665_ _0633_ _0636_ _1813_ VDD VSS XNOR2_X1
X_2666_ transfer_count\[3\]\[30\] _0637_ VDD VSS INV_X1
X_2667_ _0402_ _0403_ _0404_ _0621_ _0638_ VDD VSS NAND4_X4
X_2668_ _0420_ _0423_ _0638_ _0639_ VDD VSS NOR3_X4
X_2669_ _0635_ _0639_ _0640_ VDD VSS NAND2_X1
X_2670_ _0637_ _0640_ _1816_ VDD VSS XNOR2_X1
X_2671_ transfer_count\[3\]\[28\] _0641_ VDD VSS INV_X1
X_2672_ _0411_ _0639_ _0642_ VDD VSS NAND2_X1
X_2673_ _0641_ _0642_ _1822_ VDD VSS XNOR2_X1
X_2674_ _0409_ _0410_ _0424_ _0643_ VDD VSS NAND3_X1
X_2675_ transfer_count\[3\]\[27\] _0643_ _1825_ VDD VSS XOR2_X2
X_2676_ transfer_count\[3\]\[26\] _0644_ VDD VSS INV_X1
X_2677_ transfer_count\[3\]\[25\] _0409_ _0639_ _0645_ VDD
+ VSS NAND3_X1
X_2678_ _0644_ _0645_ _1828_ VDD VSS XNOR2_X1
X_2679_ transfer_count\[3\]\[24\] _0646_ VDD VSS INV_X1
X_2680_ _0408_ _0639_ _0647_ VDD VSS NAND2_X1
X_2681_ _0646_ _0647_ _1834_ VDD VSS XNOR2_X1
X_2682_ _0408_ _0634_ _1837_ VDD VSS XNOR2_X2
X_2683_ _0417_ transfer_count\[3\]\[18\] _0418_ _0648_ VDD
+ VSS NAND3_X2
X_2684_ _0415_ _0416_ _0649_ VDD VSS NAND2_X1
X_2685_ _0648_ _0649_ _0423_ _0638_ _0650_ VDD VSS NOR4_X4
X_2686_ _0414_ _0650_ _1840_ VDD VSS XNOR2_X1
X_2687_ _0648_ _0423_ _0638_ _0651_ VDD VSS OR3_X2
X_2688_ _0416_ _0651_ _1846_ VDD VSS XOR2_X2
X_2689_ transfer_count\[3\]\[18\] _0418_ _0406_ _0428_ _0652_
+ VDD VSS AND4_X1
X_2690_ _0417_ _0652_ _1849_ VDD VSS XNOR2_X1
X_2691_ transfer_count\[3\]\[18\] _0653_ VDD VSS INV_X1
X_2692_ _0423_ _0638_ _0654_ VDD VSS NOR2_X1
X_2693_ _0418_ _0654_ _0655_ VDD VSS NAND2_X1
X_2694_ _0653_ _0655_ _1852_ VDD VSS XNOR2_X1
X_2695_ _0401_ _0422_ _0626_ _0656_ VDD VSS AND3_X1
X_2696_ _0421_ _0656_ _1858_ VDD VSS XNOR2_X2
X_2697_ _1470_ _1471_ VDD VSS INV_X1
X_2698_ _1655_ _1656_ VDD VSS INV_X1
X_2699_ _1754_ _1755_ VDD VSS INV_X1
X_2700_ _1767_ _1768_ VDD VSS INV_X1
X_2701_ _0281_ channel_state\[0\]\[2\] channel_state\[0\]\[3\]
+ _0657_ VDD VSS NOR3_X1
X_2702_ _0337_ channel_state\[0\]\[5\] _0658_ VDD VSS NOR2_X1
X_2703_ _0657_ _0658_ _0659_ VDD VSS NAND2_X1
X_2704_ _0283_ net138 _0659_ _0660_ VDD VSS NAND3_X1
X_2705_ active_channel_count\[0\] _0660_ _0661_ VDD VSS NOR2_X1
X_2706_ _1094_ net140 _0662_ VDD VSS NAND2_X1
X_2707_ _1179_ channel_state\[2\]\[5\] _0663_ VDD VSS NOR2_X2
X_2708_ _1091_ channel_state\[2\]\[2\] channel_state\[2\]\[3\]
+ _0664_ VDD VSS NOR3_X2
X_2709_ _0662_ _0663_ _0664_ _0665_ VDD VSS AOI21_X4
X_2710_ _0434_ net141 _0666_ VDD VSS NAND2_X1
X_2711_ channel_state\[3\]\[5\] _0437_ _0667_ VDD VSS NOR2_X2
X_2712_ _0435_ channel_state\[3\]\[2\] channel_state\[3\]\[3\]
+ _0668_ VDD VSS NOR3_X1
X_2713_ _0666_ _0667_ _0668_ _0669_ VDD VSS AOI21_X2
X_2714_ _1262_ net139 _0670_ VDD VSS NAND2_X1
X_2715_ channel_state\[1\]\[1\] channel_state\[1\]\[5\] _0671_
+ VDD VSS NOR2_X2
X_2716_ _1261_ channel_state\[1\]\[3\] channel_state\[1\]\[2\]
+ _0672_ VDD VSS NOR3_X2
X_2717_ _0670_ _0671_ _0672_ _0673_ VDD VSS AOI21_X4
X_2718_ _0665_ _0669_ _0673_ _0674_ VDD VSS NOR3_X4
X_2719_ _1861_ _0661_ _0674_ _0675_ VDD VSS MUX2_X1
X_2720_ _1090_ _0675_ _0024_ VDD VSS AND2_X1
X_2721_ _0674_ _0660_ _0676_ VDD VSS NAND2_X1
X_2722_ _0380_ _1864_ _0676_ _0025_ VDD VSS AND3_X1
X_2723_ _1088_ _0677_ VDD VSS BUF_X8
X_2724_ _0677_ _0676_ _0678_ VDD VSS NAND2_X1
X_2725_ _1865_ active_channel_count\[2\] _0679_ VDD VSS XNOR2_X1
X_2726_ _0678_ _0679_ _0026_ VDD VSS NOR2_X1
X_2727_ active_channel_count\[0\] active_channel_count\[2\]
+ active_channel_count\[1\] _0680_ VDD VSS NAND3_X1
X_2728_ active_channel_count\[3\] _0680_ _0681_ VDD VSS XOR2_X1
X_2729_ _0678_ _0681_ _0027_ VDD VSS NOR2_X1
X_2730_ _0677_ net138 _0374_ _0682_ VDD VSS OAI21_X1
X_2731_ net138 _0683_ VDD VSS INV_X1
X_2732_ _1205_ _0683_ _0284_ _0684_ VDD VSS AOI21_X1
X_2733_ _0344_ _0347_ _0684_ _0685_ VDD VSS NAND3_X1
X_2734_ _0368_ _0682_ _0685_ _0336_ _0028_ VDD VSS OAI22_X1
X_2735_ _1266_ _0686_ VDD VSS CLKBUF_X3
X_2736_ _0677_ net139 _0358_ _0687_ VDD VSS OAI21_X1
X_2737_ net139 _0688_ VDD VSS INV_X1
X_2738_ _1205_ _0688_ _0220_ _0689_ VDD VSS AOI21_X1
X_2739_ _0214_ _0217_ _0689_ _0690_ VDD VSS NAND3_X1
X_2740_ _0686_ _0687_ _0690_ _0225_ _0029_ VDD VSS OAI22_X1
X_2741_ _1180_ _0691_ VDD VSS CLKBUF_X3
X_2742_ _0677_ net140 _0353_ _0691_ _1177_ _0692_ VDD VSS
+ OAI221_X1
X_2743_ _1180_ _0693_ VDD VSS CLKBUF_X3
X_2744_ _0693_ _1167_ _0694_ VDD VSS NOR2_X1
X_2745_ _0692_ _0694_ _1204_ _0030_ VDD VSS AOI21_X1
X_2746_ _0438_ _0695_ VDD VSS CLKBUF_X3
X_2747_ _0677_ _0695_ _0496_ _0508_ net141 _0696_ VDD VSS
+ OAI221_X1
X_2748_ _0438_ _0697_ VDD VSS CLKBUF_X3
X_2749_ _0697_ _0499_ _0698_ VDD VSS NOR2_X1
X_2750_ _0696_ _0698_ _0502_ _0031_ VDD VSS AOI21_X1
X_2751_ _0373_ channel_state\[0\]\[4\] _0385_ _0699_ VDD VSS
+ NAND3_X1
X_2752_ _1087_ net142 _0284_ _0699_ _0700_ VDD VSS NAND4_X1
X_2753_ _0347_ _0700_ _0701_ VDD VSS AND2_X1
X_2754_ _0344_ _0701_ _0310_ _0335_ _0702_ VDD VSS OAI211_X2
X_2755_ _0370_ _0700_ _0703_ VDD VSS NAND2_X1
X_2756_ _0702_ _0703_ _0032_ VDD VSS AND2_X1
X_2757_ _0388_ channel_state\[1\]\[4\] _0381_ _0704_ VDD VSS
+ NAND3_X1
X_2758_ net143 _0359_ _0704_ _0705_ VDD VSS NAND3_X1
X_2759_ _0214_ _0217_ _0705_ _0706_ VDD VSS AND3_X1
X_2760_ _1268_ _0705_ _0706_ _0210_ _0033_ VDD VSS AOI22_X1
X_2761_ _1093_ channel_state\[2\]\[4\] _0377_ _0707_ VDD VSS
+ NAND3_X1
X_2762_ net144 _0354_ _0707_ _0708_ VDD VSS AND3_X1
X_2763_ _0517_ _0519_ _0708_ _0034_ VDD VSS OR3_X1
X_2764_ _0507_ channel_state\[3\]\[4\] _0512_ _0709_ VDD VSS
+ NAND3_X1
X_2765_ _1088_ net145 _0503_ _0709_ _0710_ VDD VSS AND4_X1
X_2766_ _0491_ _0497_ _0710_ _0035_ VDD VSS OR3_X1
X_2767_ _1090_ active_channel_count\[0\] _0036_ VDD VSS AND2_X1
X_2768_ _1090_ active_channel_count\[1\] _0037_ VDD VSS AND2_X1
X_2769_ _1090_ active_channel_count\[2\] _0038_ VDD VSS AND2_X1
X_2770_ _1090_ active_channel_count\[3\] _0039_ VDD VSS AND2_X1
X_2771_ active_channel_count\[2\] active_channel_count\[3\]
+ _0711_ VDD VSS NOR2_X1
X_2772_ _0219_ _1863_ _0711_ _0040_ VDD VSS AOI21_X1
X_2773_ _1205_ _0712_ VDD VSS BUF_X4
X_2774_ channel_state\[0\]\[4\] _0713_ VDD VSS INV_X1
X_2775_ _0713_ _0657_ _0714_ VDD VSS AND2_X1
X_2776_ net151 _0714_ _0715_ VDD VSS NAND2_X1
X_2777_ _0712_ _0658_ _0715_ _0041_ VDD VSS AOI21_X1
X_2778_ channel_state\[1\]\[4\] _0716_ VDD VSS INV_X1
X_2779_ _0716_ _0672_ _0717_ VDD VSS AND2_X1
X_2780_ net152 _0717_ _0718_ VDD VSS NAND2_X1
X_2781_ _0712_ _0671_ _0718_ _0042_ VDD VSS AOI21_X1
X_2782_ channel_state\[2\]\[4\] _1091_ channel_state\[2\]\[2\]
+ channel_state\[2\]\[3\] _0719_ VDD VSS NOR4_X2
X_2783_ net153 _0719_ _0720_ VDD VSS NAND2_X1
X_2784_ _0712_ _0663_ _0720_ _0043_ VDD VSS AOI21_X1
X_2785_ channel_state\[3\]\[4\] _0721_ VDD VSS INV_X1
X_2786_ _0721_ _0668_ _0722_ VDD VSS AND2_X1
X_2787_ net154 _0722_ _0723_ VDD VSS NAND2_X1
X_2788_ _0712_ _0667_ _0723_ _0044_ VDD VSS AOI21_X1
X_2789_ _1090_ channel_state\[0\]\[3\] _0045_ VDD VSS AND2_X1
X_2790_ _1089_ _0724_ VDD VSS BUF_X4
X_2791_ _0724_ channel_state\[3\]\[3\] _0048_ VDD VSS AND2_X1
X_2792_ net159 _0658_ _0714_ _0725_ VDD VSS NAND3_X1
X_2793_ channel_state\[0\]\[3\] _0351_ _0726_ VDD VSS NOR2_X1
X_2794_ _0712_ _0725_ _0726_ _0049_ VDD VSS AOI21_X1
X_2795_ net160 _0671_ _0717_ _0727_ VDD VSS NAND3_X1
X_2796_ channel_state\[1\]\[3\] _0361_ _0728_ VDD VSS NOR2_X1
X_2797_ _0712_ _0727_ _0728_ _0050_ VDD VSS AOI21_X1
X_2798_ net161 _0663_ _0719_ _0729_ VDD VSS NAND3_X1
X_2799_ channel_state\[2\]\[3\] _0356_ _0730_ VDD VSS NOR2_X1
X_2800_ _0712_ _0729_ _0730_ _0051_ VDD VSS AOI21_X1
X_2801_ net162 _0667_ _0722_ _0731_ VDD VSS NAND3_X1
X_2802_ channel_state\[3\]\[3\] _0505_ _0732_ VDD VSS NOR2_X1
X_2803_ _0712_ _0731_ _0732_ _0052_ VDD VSS AOI21_X1
X_2804_ _1759_ _0368_ _0733_ VDD VSS NAND2_X1
X_2805_ _0338_ _0734_ VDD VSS CLKBUF_X3
X_2806_ transfer_count\[0\]\[0\] _0285_ _0734_ _0735_ VDD
+ VSS NAND3_X1
X_2807_ _0712_ _0733_ _0735_ _0053_ VDD VSS AOI21_X1
X_2808_ _0284_ _0338_ _0736_ VDD VSS NAND2_X2
X_2809_ _0338_ _0737_ VDD VSS CLKBUF_X3
X_2810_ _0736_ _0601_ _0737_ _0738_ VDD VSS OAI21_X1
X_2811_ _0245_ _0738_ _0739_ VDD VSS NAND2_X1
X_2812_ _0602_ _0368_ _0601_ _0740_ VDD VSS NAND3_X1
X_2813_ _0712_ _0739_ _0740_ _0054_ VDD VSS AOI21_X1
X_2814_ _0236_ _0285_ _0737_ _0741_ VDD VSS NAND3_X1
X_2815_ _0741_ _0734_ _1723_ _0742_ VDD VSS OAI21_X1
X_2816_ _0724_ _0742_ _0055_ VDD VSS AND2_X1
X_2817_ _1205_ _0743_ VDD VSS BUF_X4
X_2818_ _0374_ _0368_ _0744_ VDD VSS NOR2_X4
X_2819_ _0368_ _0614_ _0745_ VDD VSS AND2_X1
X_2820_ _0235_ _0744_ _0745_ _0746_ VDD VSS OAI21_X1
X_2821_ _0235_ _0338_ _0614_ _0747_ VDD VSS OR3_X1
X_2822_ _0743_ _0746_ _0747_ _0056_ VDD VSS AOI21_X1
X_2823_ _0736_ _0737_ _0275_ _0748_ VDD VSS OAI21_X1
X_2824_ _0234_ _0737_ _0749_ VDD VSS NOR2_X1
X_2825_ _0234_ _0748_ _0749_ _0275_ _0750_ VDD VSS AOI22_X1
X_2826_ _0349_ _0750_ _0057_ VDD VSS NOR2_X1
X_2827_ _0744_ _0606_ _0368_ _0751_ VDD VSS AOI21_X1
X_2828_ _0612_ _0751_ _0752_ VDD VSS NOR2_X1
X_2829_ _0231_ _0734_ _0606_ _0753_ VDD VSS NOR3_X1
X_2830_ _0380_ _0752_ _0753_ _0754_ VDD VSS OAI21_X1
X_2831_ _0754_ _0058_ VDD VSS INV_X1
X_2832_ _1087_ _0744_ _0755_ VDD VSS NAND2_X2
X_2833_ _0755_ _0756_ VDD VSS CLKBUF_X3
X_2834_ _1711_ _0370_ _0756_ _0272_ _0059_ VDD VSS OAI22_X1
X_2835_ _0756_ _0613_ _0370_ _0757_ VDD VSS OAI21_X1
X_2836_ _0230_ _0757_ _0758_ VDD VSS NAND2_X1
X_2837_ _0340_ _0613_ _0759_ VDD VSS NAND2_X1
X_2838_ _0758_ _0759_ _0230_ _0060_ VDD VSS OAI21_X1
X_2839_ _0370_ _1705_ _0756_ _0610_ _0061_ VDD VSS OAI22_X1
X_2840_ _0756_ _0609_ _0370_ _0760_ VDD VSS OAI21_X1
X_2841_ _0229_ _0760_ _0761_ VDD VSS NAND2_X1
X_2842_ _0340_ _0609_ _0762_ VDD VSS NAND2_X1
X_2843_ _0761_ _0762_ _0229_ _0062_ VDD VSS OAI21_X1
X_2844_ _0756_ _0370_ _0271_ _0763_ VDD VSS OAI21_X1
X_2845_ _0369_ _0764_ VDD VSS CLKBUF_X3
X_2846_ _0228_ _0764_ _0765_ VDD VSS NOR2_X1
X_2847_ _0228_ _0763_ _0765_ _0271_ _0766_ VDD VSS AOI22_X1
X_2848_ _0766_ _0063_ VDD VSS INV_X1
X_2849_ _1754_ _0368_ _0767_ VDD VSS NAND2_X1
X_2850_ transfer_count\[0\]\[1\] _0285_ _0734_ _0768_ VDD
+ VSS NAND3_X1
X_2851_ _0743_ _0767_ _0768_ _0064_ VDD VSS AOI21_X1
X_2852_ _0756_ _0607_ _0370_ _0769_ VDD VSS OAI21_X1
X_2853_ _0227_ _0769_ _0770_ VDD VSS NAND2_X1
X_2854_ _0340_ _0607_ _0771_ VDD VSS NAND2_X1
X_2855_ _0770_ _0771_ _0227_ _0065_ VDD VSS OAI21_X1
X_2856_ _0269_ _0589_ _0270_ _0340_ _0772_ VDD VSS NAND4_X1
X_2857_ _0266_ _0340_ _0744_ _0677_ _0773_ VDD VSS AOI22_X1
X_2858_ _0772_ _0773_ _0269_ _0066_ VDD VSS OAI21_X1
X_2859_ _1205_ _0257_ _0338_ _0604_ _0774_ VDD VSS OR4_X1
X_2860_ _0677_ _0257_ _0775_ VDD VSS NAND2_X1
X_2861_ _0744_ _0604_ _0368_ _0776_ VDD VSS AOI21_X1
X_2862_ _0774_ _0775_ _0776_ _0067_ VDD VSS OAI21_X1
X_2863_ _0255_ _0268_ _0340_ _0777_ VDD VSS AOI21_X1
X_2864_ _0598_ _0744_ _0677_ _0778_ VDD VSS AOI21_X1
X_2865_ _0340_ _0266_ _0265_ _0779_ VDD VSS OAI21_X1
X_2866_ _0777_ _0778_ _0779_ _0068_ VDD VSS AOI21_X1
X_2867_ _0598_ _0764_ _0592_ _0780_ VDD VSS NOR3_X1
X_2868_ _0756_ _0599_ _0764_ _0781_ VDD VSS OAI21_X1
X_2869_ _0780_ _0781_ _0254_ _0069_ VDD VSS MUX2_X1
X_2870_ _0253_ _0267_ _0340_ _0782_ VDD VSS AOI21_X1
X_2871_ _0253_ _0756_ _0783_ VDD VSS AND2_X1
X_2872_ _0267_ _0764_ _0784_ VDD VSS OR2_X1
X_2873_ _0782_ _0783_ _0784_ _0070_ VDD VSS AOI21_X1
X_2874_ _0596_ _0764_ _0592_ _0785_ VDD VSS NOR3_X1
X_2875_ _0755_ _0597_ _0764_ _0786_ VDD VSS OAI21_X1
X_2876_ _0785_ _0786_ transfer_count\[0\]\[26\] _0071_ VDD
+ VSS MUX2_X1
X_2877_ _0756_ _0370_ _0263_ _0787_ VDD VSS OAI21_X1
X_2878_ _0252_ _0787_ _0788_ VDD VSS NAND2_X1
X_2879_ _0263_ _0340_ _0789_ VDD VSS NAND2_X1
X_2880_ _0788_ _0789_ _0252_ _0072_ VDD VSS OAI21_X1
X_2881_ _0594_ _0369_ _0592_ _0790_ VDD VSS NOR3_X1
X_2882_ _0755_ _0595_ _0764_ _0791_ VDD VSS OAI21_X1
X_2883_ _0790_ _0791_ _0251_ _0073_ VDD VSS MUX2_X1
X_2884_ _0261_ _0339_ _0792_ VDD VSS AND2_X1
X_2885_ _0755_ _0764_ _0261_ _0793_ VDD VSS OAI21_X1
X_2886_ _0792_ _0793_ _0226_ _0074_ VDD VSS MUX2_X1
X_2887_ _0734_ _1750_ _0794_ VDD VSS OR2_X1
X_2888_ _0239_ _0285_ _0734_ _0795_ VDD VSS NAND3_X1
X_2889_ _0743_ _0794_ _0795_ _0075_ VDD VSS AOI21_X1
X_2890_ _0764_ _0588_ _0592_ _0796_ VDD VSS NOR3_X1
X_2891_ _0755_ _0593_ _0764_ _0797_ VDD VSS OAI21_X1
X_2892_ _0796_ _0797_ transfer_count\[0\]\[30\] _0076_ VDD
+ VSS MUX2_X1
X_2893_ _0370_ _1663_ _0756_ _0586_ _0077_ VDD VSS OAI22_X1
X_2894_ _0238_ _0285_ _0737_ _0798_ VDD VSS NAND3_X1
X_2895_ _0798_ _0734_ _1747_ _0799_ VDD VSS OAI21_X1
X_2896_ _0724_ _0799_ _0078_ VDD VSS AND2_X1
X_2897_ _0368_ _0590_ _0800_ VDD VSS AND2_X1
X_2898_ _0243_ _0744_ _0800_ _0801_ VDD VSS OAI21_X1
X_2899_ _0243_ _0338_ _0590_ _0802_ VDD VSS OR3_X1
X_2900_ _0743_ _0801_ _0802_ _0079_ VDD VSS AOI21_X1
X_2901_ _0242_ _0285_ _0737_ _0803_ VDD VSS NAND3_X1
X_2902_ _0803_ _0734_ _1741_ _0804_ VDD VSS OAI21_X1
X_2903_ _0724_ _0804_ _0080_ VDD VSS AND2_X1
X_2904_ _0736_ _0618_ _0737_ _0805_ VDD VSS OAI21_X1
X_2905_ _0241_ _0338_ _0806_ VDD VSS NOR2_X1
X_2906_ _0241_ _0805_ _0806_ _0618_ _0807_ VDD VSS AOI22_X1
X_2907_ _0349_ _0807_ _0081_ VDD VSS NOR2_X1
X_2908_ _0248_ _0285_ _0737_ _0808_ VDD VSS NAND3_X1
X_2909_ _0808_ _0734_ _1735_ _0809_ VDD VSS OAI21_X1
X_2910_ _0724_ _0809_ _0082_ VDD VSS AND2_X1
X_2911_ _0247_ _0285_ _0737_ _0810_ VDD VSS NAND3_X1
X_2912_ _0810_ _1732_ _0734_ _0811_ VDD VSS OAI21_X1
X_2913_ _0724_ _0811_ _0083_ VDD VSS AND2_X1
X_2914_ _0736_ _0737_ _0277_ _0812_ VDD VSS OAI21_X1
X_2915_ _0246_ _0338_ _0813_ VDD VSS NOR2_X1
X_2916_ _0246_ _0812_ _0813_ _0277_ _0814_ VDD VSS AOI22_X1
X_2917_ _0349_ _0814_ _0084_ VDD VSS NOR2_X1
X_2918_ _1660_ _0686_ _0815_ VDD VSS NAND2_X1
X_2919_ _0221_ _0816_ VDD VSS BUF_X4
X_2920_ _0816_ _0817_ VDD VSS CLKBUF_X3
X_2921_ transfer_count\[1\]\[0\] _0817_ _0220_ _0818_ VDD
+ VSS NAND3_X1
X_2922_ _0743_ _0815_ _0818_ _0085_ VDD VSS AOI21_X1
X_2923_ _0221_ _0819_ VDD VSS CLKBUF_X3
X_2924_ transfer_count\[1\]\[10\] _0819_ _0220_ _0820_ VDD
+ VSS NAND3_X1
X_2925_ _0820_ _1627_ _0817_ _0821_ VDD VSS OAI21_X1
X_2926_ _0724_ _0821_ _0086_ VDD VSS AND2_X1
X_2927_ _0221_ _0220_ _0822_ VDD VSS NAND2_X4
X_2928_ _0822_ _0819_ _1253_ _0823_ VDD VSS OAI21_X1
X_2929_ _1239_ _0819_ _0824_ VDD VSS NOR2_X1
X_2930_ _1239_ _0823_ _0824_ _1253_ _0825_ VDD VSS AOI22_X1
X_2931_ _0349_ _0825_ _0087_ VDD VSS NOR2_X1
X_2932_ _1238_ _0826_ VDD VSS INV_X1
X_2933_ _0817_ _1621_ _0822_ _0826_ _0827_ VDD VSS OAI22_X1
X_2934_ _0724_ _0827_ _0088_ VDD VSS AND2_X1
X_2935_ _1254_ _0817_ _0828_ VDD VSS NOR2_X1
X_2936_ transfer_count\[1\]\[13\] _0359_ _0829_ VDD VSS NAND2_X1
X_2937_ _1618_ _1268_ _0828_ _0829_ _0089_ VDD VSS OAI22_X1
X_2938_ _1222_ _0816_ _0563_ _0830_ VDD VSS NOR3_X1
X_2939_ _0822_ _0571_ _0817_ _0831_ VDD VSS OAI21_X1
X_2940_ _0830_ _0831_ _1222_ _0832_ VDD VSS AOI21_X1
X_2941_ _0349_ _0832_ _0090_ VDD VSS NOR2_X1
X_2942_ _1252_ _0819_ _0833_ VDD VSS NOR2_X1
X_2943_ _1221_ _0822_ _0834_ VDD VSS NAND2_X1
X_2944_ _0819_ _1249_ _1222_ _0835_ VDD VSS AOI21_X1
X_2945_ _0380_ _1221_ _0833_ _0834_ _0835_ _0836_ VDD VSS
+ OAI221_X1
X_2946_ _0836_ _0091_ VDD VSS INV_X1
X_2947_ _0822_ _0578_ _0819_ _0837_ VDD VSS OAI21_X1
X_2948_ _1220_ _0816_ _0838_ VDD VSS NOR2_X1
X_2949_ _1220_ _0837_ _0838_ _0578_ _0839_ VDD VSS AOI22_X1
X_2950_ _0349_ _0839_ _0092_ VDD VSS NOR2_X1
X_2951_ _1266_ _0358_ _0840_ VDD VSS NOR2_X2
X_2952_ _0816_ _1249_ _0576_ _0841_ VDD VSS AOI21_X1
X_2953_ transfer_count\[1\]\[17\] _0840_ _0841_ _0842_ VDD
+ VSS OAI21_X1
X_2954_ _0575_ _0576_ _1249_ _1266_ _0843_ VDD VSS NAND4_X1
X_2955_ _0743_ _0842_ _0843_ _0093_ VDD VSS AOI21_X1
X_2956_ _0822_ _0574_ _0817_ _0844_ VDD VSS OAI21_X1
X_2957_ _1224_ _0844_ _0845_ VDD VSS NAND2_X1
X_2958_ _1224_ _0846_ VDD VSS INV_X1
X_2959_ _0846_ _0686_ _0574_ _0847_ VDD VSS NAND3_X1
X_2960_ _0743_ _0845_ _0847_ _0094_ VDD VSS AOI21_X1
X_2961_ transfer_count\[1\]\[19\] _0848_ VDD VSS INV_X1
X_2962_ _0848_ _1251_ _0223_ _0849_ VDD VSS NAND3_X1
X_2963_ transfer_count\[1\]\[19\] _0222_ _0850_ VDD VSS NAND2_X1
X_2964_ _0816_ _0359_ _0851_ VDD VSS NAND2_X4
X_2965_ _0849_ _0850_ _1251_ _0848_ _0851_ _0095_ VDD VSS
+ OAI221_X1
X_2966_ _1655_ _0686_ _0852_ VDD VSS NAND2_X1
X_2967_ transfer_count\[1\]\[1\] _0817_ _0220_ _0853_ VDD
+ VSS NAND3_X1
X_2968_ _0743_ _0852_ _0853_ _0096_ VDD VSS AOI21_X1
X_2969_ _1205_ _1219_ _0816_ _0573_ _0854_ VDD VSS OR4_X1
X_2970_ _0677_ _1219_ _0855_ VDD VSS NAND2_X1
X_2971_ _0840_ _0573_ _0686_ _0856_ VDD VSS AOI21_X1
X_2972_ _0854_ _0855_ _0856_ _0097_ VDD VSS OAI21_X1
X_2973_ _1242_ _0816_ _0857_ VDD VSS NOR2_X1
X_2974_ _1217_ _0857_ _0858_ VDD VSS NOR2_X1
X_2975_ _1217_ _0822_ _0859_ VDD VSS NAND2_X1
X_2976_ _0859_ _1266_ _1242_ _0860_ VDD VSS AOI21_X1
X_2977_ _0219_ _0858_ _0860_ _0098_ VDD VSS NOR3_X1
X_2978_ _0851_ _0572_ _1268_ _0861_ VDD VSS OAI21_X1
X_2979_ _1216_ _0861_ _0862_ VDD VSS NAND2_X1
X_2980_ _0223_ _0572_ _0863_ VDD VSS NAND2_X1
X_2981_ _0862_ _0863_ _1216_ _0099_ VDD VSS OAI21_X1
X_2982_ _0822_ _0817_ _1244_ _0864_ VDD VSS OAI21_X1
X_2983_ _1213_ _0864_ _0865_ VDD VSS NAND2_X1
X_2984_ _0569_ _1244_ _0686_ _0866_ VDD VSS NAND3_X1
X_2985_ _0743_ _0865_ _0866_ _0100_ VDD VSS AOI21_X1
X_2986_ _0851_ _0570_ _1268_ _0867_ VDD VSS OAI21_X1
X_2987_ _1212_ _0867_ _0868_ VDD VSS NAND2_X1
X_2988_ _0223_ _0570_ _0869_ VDD VSS NAND2_X1
X_2989_ _0868_ _0869_ _1212_ _0101_ VDD VSS OAI21_X1
X_2990_ _1246_ _0558_ _1267_ _0870_ VDD VSS NOR3_X1
X_2991_ _0851_ _1268_ _1247_ _0871_ VDD VSS OAI21_X1
X_2992_ _0870_ _0871_ _1211_ _0102_ VDD VSS MUX2_X1
X_2993_ _0851_ _0568_ _1268_ _0872_ VDD VSS OAI21_X1
X_2994_ _1210_ _0872_ _0873_ VDD VSS NAND2_X1
X_2995_ _0223_ _0568_ _0874_ VDD VSS NAND2_X1
X_2996_ _0873_ _0874_ _1210_ _0103_ VDD VSS OAI21_X1
X_2997_ _1205_ _1266_ _0358_ _0875_ VDD VSS NOR3_X2
X_2998_ _1267_ _1244_ _1214_ _0876_ VDD VSS AOI21_X1
X_2999_ _1209_ _0875_ _0876_ _0877_ VDD VSS OAI21_X1
X_3000_ _1214_ _1244_ _0223_ _0878_ VDD VSS NAND3_X1
X_3001_ _0877_ _0878_ _1209_ _0104_ VDD VSS OAI21_X1
X_3002_ _0851_ _0566_ _1268_ _0879_ VDD VSS OAI21_X1
X_3003_ _1208_ _0879_ _0880_ VDD VSS NAND2_X1
X_3004_ _0223_ _0566_ _0881_ VDD VSS NAND2_X1
X_3005_ _0880_ _0881_ _1208_ _0105_ VDD VSS OAI21_X1
X_3006_ _1215_ _0558_ _1267_ _0882_ VDD VSS NOR3_X1
X_3007_ _0851_ _1268_ _1243_ _0883_ VDD VSS OAI21_X1
X_3008_ _0882_ _0883_ transfer_count\[1\]\[29\] _0106_ VDD
+ VSS MUX2_X1
X_3009_ _0561_ _0819_ _0884_ VDD VSS NOR2_X1
X_3010_ _1232_ _0840_ _0884_ _0885_ VDD VSS OAI21_X1
X_3011_ _1232_ _0886_ VDD VSS INV_X1
X_3012_ _0886_ _0561_ _0686_ _0887_ VDD VSS NAND3_X1
X_3013_ _0743_ _0885_ _0887_ _0107_ VDD VSS AOI21_X1
X_3014_ _0851_ _0564_ _1268_ _0888_ VDD VSS OAI21_X1
X_3015_ transfer_count\[1\]\[30\] _0888_ _0889_ VDD VSS NAND2_X1
X_3016_ _0556_ _0223_ _0564_ _0890_ VDD VSS NAND3_X1
X_3017_ _0889_ _0890_ _0108_ VDD VSS NAND2_X1
X_3018_ transfer_count\[1\]\[31\] _1267_ _0560_ _0891_ VDD
+ VSS OR3_X1
X_3019_ _0875_ _0560_ _0223_ _0892_ VDD VSS AOI21_X1
X_3020_ _0891_ _0892_ _0555_ _0109_ VDD VSS OAI21_X1
X_3021_ _1205_ _0893_ VDD VSS BUF_X4
X_3022_ _1259_ _1266_ _0894_ VDD VSS AND2_X1
X_3023_ _1231_ _0840_ _0894_ _0895_ VDD VSS OAI21_X1
X_3024_ _1231_ _1259_ _0816_ _0896_ VDD VSS OR3_X1
X_3025_ _0893_ _0895_ _0896_ _0110_ VDD VSS AOI21_X1
X_3026_ _0817_ _0584_ _0897_ VDD VSS NOR2_X1
X_3027_ _1229_ _0840_ _0897_ _0898_ VDD VSS OAI21_X1
X_3028_ _1257_ _0686_ _0584_ _0899_ VDD VSS NAND3_X1
X_3029_ _0893_ _0898_ _0899_ _0111_ VDD VSS AOI21_X1
X_3030_ _0223_ _0359_ _1228_ _0900_ VDD VSS AOI21_X1
X_3031_ _0900_ _0686_ _1642_ _0112_ VDD VSS AOI21_X1
X_3032_ _0822_ _0585_ _0819_ _0901_ VDD VSS OAI21_X1
X_3033_ _1227_ _0816_ _0902_ VDD VSS NOR2_X1
X_3034_ _1227_ _0901_ _0902_ _0585_ _0903_ VDD VSS AOI22_X1
X_3035_ _0349_ _0903_ _0113_ VDD VSS NOR2_X1
X_3036_ _0822_ _0819_ _1255_ _0904_ VDD VSS OAI21_X1
X_3037_ _1236_ _0816_ _0905_ VDD VSS NOR2_X1
X_3038_ _1236_ _0904_ _0905_ _1255_ _0906_ VDD VSS AOI22_X1
X_3039_ _0349_ _0906_ _0114_ VDD VSS NOR2_X1
X_3040_ _0222_ _0359_ _1235_ _0907_ VDD VSS AOI21_X1
X_3041_ _0907_ _1633_ _0686_ _0115_ VDD VSS AOI21_X1
X_3042_ transfer_count\[1\]\[9\] _0819_ _0220_ _0908_ VDD
+ VSS NAND3_X1
X_3043_ _0908_ _0817_ _1630_ _0909_ VDD VSS OAI21_X1
X_3044_ _0724_ _0909_ _0116_ VDD VSS AND2_X1
X_3045_ _1466_ _0515_ _0910_ VDD VSS NAND2_X1
X_3046_ transfer_count\[2\]\[0\] _1207_ _0693_ _0911_ VDD
+ VSS NAND3_X1
X_3047_ _0893_ _0910_ _0911_ _0117_ VDD VSS AOI21_X1
X_3048_ _0516_ _0912_ VDD VSS CLKBUF_X3
X_3049_ _1180_ _0354_ _0913_ VDD VSS NAND2_X1
X_3050_ _0913_ _0914_ VDD VSS CLKBUF_X3
X_3051_ _0912_ _1507_ _0914_ _1110_ _0118_ VDD VSS OAI22_X1
X_3052_ _1207_ _1180_ _0915_ VDD VSS NAND2_X2
X_3053_ _0693_ _1504_ _0915_ _1107_ _0916_ VDD VSS OAI22_X1
X_3054_ _0724_ _0916_ _0119_ VDD VSS AND2_X1
X_3055_ _1105_ _1180_ _0522_ _0917_ VDD VSS NOR3_X1
X_3056_ _0522_ _0918_ VDD VSS INV_X1
X_3057_ _0915_ _0918_ _0691_ _0919_ VDD VSS OAI21_X1
X_3058_ _0917_ _0919_ _1105_ _0920_ VDD VSS AOI21_X1
X_3059_ _0219_ _0920_ _0120_ VDD VSS NOR2_X1
X_3060_ transfer_count\[2\]\[13\] _1106_ _1120_ _0516_ _0921_
+ VDD VSS OR4_X1
X_3061_ _1178_ _0353_ _0515_ _0922_ VDD VSS NOR3_X4
X_3062_ _1181_ _0923_ VDD VSS CLKBUF_X3
X_3063_ _0922_ _0923_ _1116_ _0924_ VDD VSS AOI21_X1
X_3064_ _0921_ _0924_ _1104_ _0121_ VDD VSS OAI21_X1
X_3065_ _0914_ _0523_ _0912_ _0925_ VDD VSS OAI21_X1
X_3066_ _1131_ _0925_ _0926_ VDD VSS NAND2_X1
X_3067_ _0923_ _0523_ _0927_ VDD VSS NAND2_X1
X_3068_ _0926_ _0927_ _1131_ _0122_ VDD VSS OAI21_X1
X_3069_ _0914_ _0533_ _0912_ _0928_ VDD VSS OAI21_X1
X_3070_ transfer_count\[2\]\[15\] _0928_ _0929_ VDD VSS NAND2_X1
X_3071_ _0553_ _0923_ _0533_ _0930_ VDD VSS NAND3_X1
X_3072_ _0929_ _0930_ _0123_ VDD VSS NAND2_X1
X_3073_ _0914_ _0554_ _0912_ _0931_ VDD VSS OAI21_X1
X_3074_ _1130_ _0931_ _0932_ VDD VSS NAND2_X1
X_3075_ _0923_ _0554_ _0933_ VDD VSS NAND2_X1
X_3076_ _0932_ _0933_ _1130_ _0124_ VDD VSS OAI21_X1
X_3077_ _0914_ _0912_ _1144_ _0934_ VDD VSS OAI21_X1
X_3078_ _1134_ _0934_ _0935_ VDD VSS NAND2_X1
X_3079_ _0551_ _1144_ _0923_ _0936_ VDD VSS NAND3_X1
X_3080_ _0935_ _0936_ _0125_ VDD VSS NAND2_X1
X_3081_ _0914_ _0552_ _0912_ _0937_ VDD VSS OAI21_X1
X_3082_ _1133_ _0937_ _0938_ VDD VSS NAND2_X1
X_3083_ _0923_ _0552_ _0939_ VDD VSS NAND2_X1
X_3084_ _0938_ _0939_ _1133_ _0126_ VDD VSS OAI21_X1
X_3085_ _1181_ _0550_ _0940_ VDD VSS AND2_X1
X_3086_ _0913_ _0550_ _0518_ _0941_ VDD VSS OAI21_X1
X_3087_ _0940_ _0941_ transfer_count\[2\]\[19\] _0127_ VDD
+ VSS MUX2_X1
X_3088_ _1470_ _0515_ _0942_ VDD VSS NAND2_X1
X_3089_ transfer_count\[2\]\[1\] _1207_ _0693_ _0943_ VDD
+ VSS NAND3_X1
X_3090_ _0893_ _0942_ _0943_ _0128_ VDD VSS AOI21_X1
X_3091_ _1127_ _0691_ _0542_ _0944_ VDD VSS OR3_X1
X_3092_ _0515_ _0522_ _1136_ _0945_ VDD VSS OAI21_X1
X_3093_ _0915_ _0945_ _0946_ VDD VSS NAND2_X1
X_3094_ _1127_ _0946_ _0947_ VDD VSS NAND2_X1
X_3095_ _0893_ _0944_ _0947_ _0129_ VDD VSS AOI21_X1
X_3096_ _0518_ _1140_ _1127_ _0948_ VDD VSS AOI21_X1
X_3097_ _1126_ _0922_ _0948_ _0949_ VDD VSS OAI21_X1
X_3098_ _1127_ _1140_ _1181_ _0950_ VDD VSS NAND3_X1
X_3099_ _0949_ _0950_ _1126_ _0130_ VDD VSS OAI21_X1
X_3100_ _0548_ _0691_ _0542_ _0951_ VDD VSS NOR3_X1
X_3101_ transfer_count\[2\]\[22\] _0354_ _0952_ VDD VSS NAND2_X1
X_3102_ _0912_ _1543_ _0951_ _0952_ _0131_ VDD VSS OAI22_X1
X_3103_ _0518_ _1140_ _0546_ _0953_ VDD VSS AOI21_X1
X_3104_ transfer_count\[2\]\[23\] _0922_ _0953_ _0954_ VDD
+ VSS OAI21_X1
X_3105_ _0546_ _1140_ _1181_ _0955_ VDD VSS NAND3_X1
X_3106_ _0954_ _0955_ transfer_count\[2\]\[23\] _0132_ VDD
+ VSS OAI21_X1
X_3107_ _0914_ _0545_ _0518_ _0956_ VDD VSS OAI21_X1
X_3108_ _1125_ _0956_ _0957_ VDD VSS NAND2_X1
X_3109_ _0923_ _0545_ _0958_ VDD VSS NAND2_X1
X_3110_ _0957_ _0958_ _1125_ _0133_ VDD VSS OAI21_X1
X_3111_ _1138_ _1139_ _1140_ _1181_ _0959_ VDD VSS NAND4_X1
X_3112_ _0922_ _1181_ _1141_ _0960_ VDD VSS AOI21_X1
X_3113_ _0959_ _0960_ _1138_ _0134_ VDD VSS OAI21_X1
X_3114_ _1129_ _0518_ _0542_ _0961_ VDD VSS NOR3_X1
X_3115_ _0913_ _0543_ _0518_ _0962_ VDD VSS OAI21_X1
X_3116_ _0961_ _0962_ _1123_ _0135_ VDD VSS MUX2_X1
X_3117_ _1122_ _0518_ _0541_ _0963_ VDD VSS OR3_X1
X_3118_ _0922_ _0541_ _1181_ _0964_ VDD VSS AOI21_X1
X_3119_ _0963_ _0964_ _0540_ _0136_ VDD VSS OAI21_X1
X_3120_ _0914_ _0539_ _0518_ _0965_ VDD VSS OAI21_X1
X_3121_ _1121_ _0965_ _0966_ VDD VSS NAND2_X1
X_3122_ _0923_ _0539_ _0967_ VDD VSS NAND2_X1
X_3123_ _0966_ _0967_ _1121_ _0137_ VDD VSS OAI21_X1
X_3124_ _0914_ _0912_ _1137_ _0968_ VDD VSS OAI21_X1
X_3125_ _1118_ _0968_ _0969_ VDD VSS NAND2_X1
X_3126_ _1137_ _0923_ _0970_ VDD VSS NAND2_X1
X_3127_ _0969_ _0970_ _1118_ _0138_ VDD VSS OAI21_X1
X_3128_ _0691_ _1477_ _0971_ VDD VSS OR2_X1
X_3129_ _1100_ _1207_ _0693_ _0972_ VDD VSS NAND3_X1
X_3130_ _0893_ _0971_ _0972_ _0139_ VDD VSS AOI21_X1
X_3131_ _0914_ _0537_ _0912_ _0973_ VDD VSS OAI21_X1
X_3132_ transfer_count\[2\]\[30\] _0973_ _0974_ VDD VSS NAND2_X1
X_3133_ _0524_ _0923_ _0537_ _0975_ VDD VSS NAND3_X1
X_3134_ _0974_ _0975_ _0140_ VDD VSS NAND2_X1
X_3135_ transfer_count\[2\]\[31\] _0912_ _0976_ VDD VSS NOR2_X1
X_3136_ _0913_ _0527_ _0518_ _0977_ VDD VSS OAI21_X1
X_3137_ _0527_ _0976_ _0977_ transfer_count\[2\]\[31\] _0978_
+ VDD VSS AOI22_X1
X_3138_ _0978_ _0141_ VDD VSS INV_X1
X_3139_ _1098_ _1207_ _0691_ _0979_ VDD VSS NAND3_X1
X_3140_ _0979_ _1474_ _0693_ _0980_ VDD VSS OAI21_X1
X_3141_ _0372_ _0980_ _0142_ VDD VSS AND2_X1
X_3142_ _1181_ _0354_ _1099_ _0981_ VDD VSS AOI21_X1
X_3143_ _0981_ _1489_ _0515_ _0143_ VDD VSS AOI21_X1
X_3144_ _1097_ _1207_ _0691_ _0982_ VDD VSS NAND3_X1
X_3145_ _0982_ _0693_ _1486_ _0983_ VDD VSS OAI21_X1
X_3146_ _0372_ _0983_ _0144_ VDD VSS AND2_X1
X_3147_ transfer_count\[2\]\[6\] _1207_ _0691_ _0984_ VDD
+ VSS NAND3_X1
X_3148_ _0984_ _1483_ _0693_ _0985_ VDD VSS OAI21_X1
X_3149_ _0372_ _0985_ _0145_ VDD VSS AND2_X1
X_3150_ _1108_ _0986_ VDD VSS INV_X1
X_3151_ _0693_ _1480_ _0915_ _0986_ _0987_ VDD VSS OAI22_X1
X_3152_ _0372_ _0987_ _0146_ VDD VSS AND2_X1
X_3153_ _0915_ _0536_ _0691_ _0988_ VDD VSS OAI21_X1
X_3154_ _1112_ _0691_ _0989_ VDD VSS NOR2_X1
X_3155_ _1112_ _0988_ _0989_ _0536_ _0990_ VDD VSS AOI22_X1
X_3156_ _0219_ _0990_ _0147_ VDD VSS NOR2_X1
X_3157_ _1510_ _0693_ _0915_ _1111_ _0991_ VDD VSS OAI22_X1
X_3158_ _0372_ _0991_ _0148_ VDD VSS AND2_X1
X_3159_ _0492_ _0992_ VDD VSS CLKBUF_X3
X_3160_ _1763_ _0992_ _0993_ VDD VSS NAND2_X1
X_3161_ transfer_count\[3\]\[0\] _0697_ _0503_ _0994_ VDD
+ VSS NAND3_X1
X_3162_ _0893_ _0993_ _0994_ _0149_ VDD VSS AOI21_X1
X_3163_ _0492_ _0508_ _0995_ VDD VSS NOR2_X4
X_3164_ _0995_ _0996_ VDD VSS CLKBUF_X3
X_3165_ _0695_ _0626_ _0400_ _0997_ VDD VSS AOI21_X1
X_3166_ _0399_ _0996_ _0997_ _0998_ VDD VSS OAI21_X1
X_3167_ _0438_ _0999_ VDD VSS CLKBUF_X3
X_3168_ _0399_ _0999_ _0630_ _1000_ VDD VSS OR3_X1
X_3169_ _0893_ _0998_ _1000_ _0150_ VDD VSS AOI21_X1
X_3170_ _0992_ _0629_ _1001_ VDD VSS AND2_X1
X_3171_ _0398_ _0996_ _1001_ _1002_ VDD VSS OAI21_X1
X_3172_ _0398_ _0999_ _0629_ _1003_ VDD VSS OR3_X1
X_3173_ _0893_ _1002_ _1003_ _0151_ VDD VSS AOI21_X1
X_3174_ _0992_ _0628_ _1004_ VDD VSS AND2_X1
X_3175_ transfer_count\[3\]\[12\] _0996_ _1004_ _1005_ VDD
+ VSS OAI21_X1
X_3176_ transfer_count\[3\]\[12\] _0999_ _0628_ _1006_ VDD
+ VSS OR3_X1
X_3177_ _0893_ _1005_ _1006_ _0152_ VDD VSS AOI21_X1
X_3178_ _0999_ _0406_ _0401_ _1007_ VDD VSS AOI21_X1
X_3179_ _0397_ _0996_ _1007_ _1008_ VDD VSS OAI21_X1
X_3180_ _0397_ _0407_ _0999_ _1009_ VDD VSS OR3_X1
X_3181_ _1206_ _1008_ _1009_ _0153_ VDD VSS AOI21_X1
X_3182_ _0493_ _1010_ VDD VSS BUF_X2
X_3183_ transfer_count\[3\]\[14\] _1010_ _0627_ _1011_ VDD
+ VSS OR3_X1
X_3184_ _0498_ _0627_ _0996_ _1089_ _1012_ VDD VSS AOI22_X1
X_3185_ _1011_ _1012_ _0625_ _0154_ VDD VSS OAI21_X1
X_3186_ transfer_count\[3\]\[15\] _0992_ _0624_ _1013_ VDD
+ VSS AOI21_X1
X_3187_ transfer_count\[3\]\[15\] _1014_ VDD VSS INV_X1
X_3188_ _0438_ _0624_ _1015_ VDD VSS NOR2_X1
X_3189_ _1014_ _0995_ _1015_ _1016_ VDD VSS NOR3_X1
X_3190_ _0219_ _1013_ _1016_ _0155_ VDD VSS NOR3_X1
X_3191_ _0992_ _0656_ _1017_ VDD VSS AND2_X1
X_3192_ _0438_ _0503_ _1018_ VDD VSS NAND2_X2
X_3193_ _0421_ _1018_ _1019_ VDD VSS NAND2_X1
X_3194_ _0697_ _0656_ _1020_ VDD VSS NOR2_X1
X_3195_ _0677_ _0421_ _1017_ _1019_ _1020_ _1021_ VDD VSS
+ OAI221_X1
X_3196_ _1021_ _0156_ VDD VSS INV_X1
X_3197_ _1018_ _0695_ _0431_ _1022_ VDD VSS OAI21_X1
X_3198_ _0418_ _0695_ _1023_ VDD VSS NOR2_X1
X_3199_ _0418_ _1022_ _1023_ _0431_ _1024_ VDD VSS AOI22_X1
X_3200_ _0219_ _1024_ _0157_ VDD VSS NOR2_X1
X_3201_ _0653_ _0418_ _0498_ _0654_ _1025_ VDD VSS NAND4_X1
X_3202_ _0498_ _0655_ _0996_ _1089_ _1026_ VDD VSS AOI22_X1
X_3203_ _1025_ _1026_ _0653_ _0158_ VDD VSS OAI21_X1
X_3204_ _1088_ _0995_ _1027_ VDD VSS NAND2_X2
X_3205_ _1027_ _0652_ _1010_ _1028_ VDD VSS OAI21_X1
X_3206_ _0417_ _1010_ _1029_ VDD VSS NOR2_X1
X_3207_ _0417_ _1028_ _1029_ _0652_ _1030_ VDD VSS AOI22_X1
X_3208_ _1030_ _0159_ VDD VSS INV_X1
X_3209_ _1767_ _0992_ _1031_ VDD VSS NAND2_X1
X_3210_ transfer_count\[3\]\[1\] _0697_ _0503_ _1032_ VDD
+ VSS NAND3_X1
X_3211_ _1206_ _1031_ _1032_ _0160_ VDD VSS AOI21_X1
X_3212_ _0992_ _0651_ _1033_ VDD VSS AND2_X1
X_3213_ _0416_ _0996_ _1033_ _1034_ VDD VSS OAI21_X1
X_3214_ _0416_ _0999_ _0651_ _1035_ VDD VSS OR3_X1
X_3215_ _1206_ _1034_ _1035_ _0161_ VDD VSS AOI21_X1
X_3216_ _1027_ _1010_ _0429_ _1036_ VDD VSS OAI21_X1
X_3217_ _0415_ _1010_ _1037_ VDD VSS NOR2_X1
X_3218_ _0415_ _1036_ _1037_ _0429_ _1038_ VDD VSS AOI22_X1
X_3219_ _1038_ _0162_ VDD VSS INV_X1
X_3220_ _1027_ _0650_ _1010_ _1039_ VDD VSS OAI21_X1
X_3221_ _0414_ _1039_ _1040_ VDD VSS NAND2_X1
X_3222_ _0498_ _0650_ _1041_ VDD VSS NAND2_X1
X_3223_ _1040_ _1041_ _0414_ _0163_ VDD VSS OAI21_X1
X_3224_ _1018_ _0697_ _0634_ _1042_ VDD VSS OAI21_X1
X_3225_ _0408_ _1042_ _1043_ VDD VSS NAND2_X1
X_3226_ _0408_ _1044_ VDD VSS INV_X1
X_3227_ _1044_ _0424_ _0992_ _1045_ VDD VSS NAND3_X1
X_3228_ _1206_ _1043_ _1045_ _0164_ VDD VSS AOI21_X1
X_3229_ _0646_ _0439_ _0647_ _0995_ _1088_ _1046_ VDD VSS
+ AOI221_X1
X_3230_ _0408_ _0498_ _0639_ _1047_ VDD VSS NAND3_X1
X_3231_ _1046_ _1047_ _0646_ _0165_ VDD VSS AOI21_X1
X_3232_ _0426_ _0409_ _0424_ _0498_ _1048_ VDD VSS NAND4_X1
X_3233_ _0427_ _0498_ _0996_ _1089_ _1049_ VDD VSS AOI22_X1
X_3234_ _1048_ _1049_ _0426_ _0166_ VDD VSS OAI21_X1
X_3235_ _0644_ _0439_ _0645_ _0995_ _1088_ _1050_ VDD VSS
+ AOI221_X1
X_3236_ _1010_ _0645_ _1051_ VDD VSS OR2_X1
X_3237_ _1050_ _1051_ _0644_ _0167_ VDD VSS AOI21_X1
X_3238_ _0409_ _0410_ _0634_ _1018_ _1052_ VDD VSS NAND4_X1
X_3239_ _0697_ _0508_ _1053_ VDD VSS NAND2_X1
X_3240_ transfer_count\[3\]\[27\] _1052_ _1053_ _1054_ VDD
+ VSS NAND3_X1
X_3241_ transfer_count\[3\]\[27\] _0999_ _0643_ _1055_ VDD
+ VSS OR3_X1
X_3242_ _1206_ _1054_ _1055_ _0168_ VDD VSS AOI21_X1
X_3243_ transfer_count\[3\]\[28\] _1010_ _0642_ _1056_ VDD
+ VSS OR3_X1
X_3244_ _0498_ _0642_ _0995_ _1089_ _1057_ VDD VSS AOI22_X1
X_3245_ _1056_ _1057_ _0641_ _0169_ VDD VSS OAI21_X1
X_3246_ _0425_ _0439_ _1058_ VDD VSS AND2_X1
X_3247_ _1027_ _1010_ _0425_ _1059_ VDD VSS OAI21_X1
X_3248_ _1058_ _1059_ transfer_count\[3\]\[29\] _0170_ VDD
+ VSS MUX2_X1
X_3249_ _0619_ _0695_ _1060_ VDD VSS NOR2_X1
X_3250_ _0393_ _0996_ _1060_ _1061_ VDD VSS OAI21_X1
X_3251_ _0393_ _1062_ VDD VSS INV_X1
X_3252_ _1062_ _0619_ _0992_ _1063_ VDD VSS NAND3_X1
X_3253_ _1206_ _1061_ _1063_ _0171_ VDD VSS AOI21_X1
X_3254_ transfer_count\[3\]\[30\] _0493_ _0640_ _1064_ VDD
+ VSS OR3_X1
X_3255_ _0498_ _0640_ _0995_ _1089_ _1065_ VDD VSS AOI22_X1
X_3256_ _1064_ _1065_ _0637_ _0172_ VDD VSS OAI21_X1
X_3257_ _0633_ _0439_ _0636_ _0995_ _1088_ _1066_ VDD VSS
+ AOI221_X1
X_3258_ _1010_ _0636_ _1067_ VDD VSS OR2_X1
X_3259_ _1066_ _1067_ _0633_ _0173_ VDD VSS AOI21_X1
X_3260_ _0391_ _0412_ _0999_ _1068_ VDD VSS NOR3_X1
X_3261_ _1018_ _0695_ _0395_ _1069_ VDD VSS OAI21_X1
X_3262_ _1068_ _1069_ _0391_ _1070_ VDD VSS AOI21_X1
X_3263_ _0219_ _1070_ _0174_ VDD VSS NOR2_X1
X_3264_ _0999_ _0621_ _0391_ _1071_ VDD VSS AOI21_X1
X_3265_ _0392_ _0996_ _1071_ _1072_ VDD VSS OAI21_X1
X_3266_ _0392_ _0999_ _0623_ _1073_ VDD VSS OR3_X1
X_3267_ _1206_ _1072_ _1073_ _0175_ VDD VSS AOI21_X1
X_3268_ _0390_ _0695_ _0503_ _1074_ VDD VSS NAND3_X1
X_3269_ _1074_ _0697_ _1783_ _1075_ VDD VSS OAI21_X1
X_3270_ _0372_ _1075_ _0176_ VDD VSS AND2_X1
X_3271_ transfer_count\[3\]\[6\] _0695_ _0503_ _1076_ VDD
+ VSS NAND3_X1
X_3272_ _1076_ _1780_ _0697_ _1077_ VDD VSS OAI21_X1
X_3273_ _0372_ _1077_ _0177_ VDD VSS AND2_X1
X_3274_ _0402_ _0695_ _0503_ _1078_ VDD VSS NAND3_X1
X_3275_ _1078_ _1777_ _0697_ _1079_ VDD VSS OAI21_X1
X_3276_ _0372_ _1079_ _0178_ VDD VSS AND2_X1
X_3277_ _0995_ _0632_ _0992_ _1080_ VDD VSS AOI21_X1
X_3278_ _0631_ _1080_ _1081_ VDD VSS NOR2_X1
X_3279_ _0403_ _0697_ _0632_ _1082_ VDD VSS NOR3_X1
X_3280_ _0380_ _1081_ _1082_ _1083_ VDD VSS OAI21_X1
X_3281_ _1083_ _0179_ VDD VSS INV_X1
X_3282_ _0400_ _0430_ _0438_ _1084_ VDD VSS NOR3_X1
X_3283_ _1018_ _0695_ _0406_ _1085_ VDD VSS OAI21_X1
X_3284_ _1084_ _1085_ _0400_ _1086_ VDD VSS AOI21_X1
X_3285_ _0219_ _1086_ _0180_ VDD VSS NOR2_X1
X_3286_ _1465_ _1466_ _1467_ _1468_ VDD VSS HA_X1
X_3287_ transfer_count\[2\]\[0\] transfer_count\[2\]\[1\]
+ _1469_ _1470_ VDD VSS HA_X1
X_3288_ net90 _1471_ _1472_ _1473_ VDD VSS HA_X1
X_3289_ net92 _1474_ _1475_ _1476_ VDD VSS HA_X1
X_3290_ net91 _1477_ _1478_ _1479_ VDD VSS HA_X1
X_3291_ net97 _1480_ _1481_ _1482_ VDD VSS HA_X1
X_3292_ net96 _1483_ _1484_ _1485_ VDD VSS HA_X1
X_3293_ net94 _1486_ _1487_ _1488_ VDD VSS HA_X1
X_3294_ net93 _1489_ _1490_ _1491_ VDD VSS HA_X1
X_3295_ net105 _1492_ _1493_ _1494_ VDD VSS HA_X1
X_3296_ _1495_ net104 _1496_ _1497_ VDD VSS HA_X1
X_3297_ _1498_ net103 _1499_ _1500_ VDD VSS HA_X1
X_3298_ _1501_ net102 _1502_ _1503_ VDD VSS HA_X1
X_3299_ net101 _1504_ _1505_ _1506_ VDD VSS HA_X1
X_3300_ net100 _1507_ _1508_ _1509_ VDD VSS HA_X1
X_3301_ net99 _1510_ _1511_ _1512_ VDD VSS HA_X1
X_3302_ net98 _1513_ _1514_ _1515_ VDD VSS HA_X1
X_3303_ net123 _1516_ _1517_ _1518_ VDD VSS HA_X1
X_3304_ net122 _1519_ _1520_ _1521_ VDD VSS HA_X1
X_3305_ net121 _1522_ _1523_ _1524_ VDD VSS HA_X1
X_3306_ net120 _1525_ _1526_ _1527_ VDD VSS HA_X1
X_3307_ net119 _1528_ _1529_ _1530_ VDD VSS HA_X1
X_3308_ net118 _1531_ _1532_ _1533_ VDD VSS HA_X1
X_3309_ net116 _1534_ _1535_ _1536_ VDD VSS HA_X1
X_3310_ net115 _1537_ _1538_ _1539_ VDD VSS HA_X1
X_3311_ net114 _1540_ _1541_ _1542_ VDD VSS HA_X1
X_3312_ net113 _1543_ _1544_ _1545_ VDD VSS HA_X1
X_3313_ net112 _1546_ _1547_ _1548_ VDD VSS HA_X1
X_3314_ net111 _1549_ _1550_ _1551_ VDD VSS HA_X1
X_3315_ net110 _1552_ _1553_ _1554_ VDD VSS HA_X1
X_3316_ net109 _1555_ _1556_ _1557_ VDD VSS HA_X1
X_3317_ net108 _1558_ _1559_ _1560_ VDD VSS HA_X1
X_3318_ net107 _1561_ _1562_ _1563_ VDD VSS HA_X1
X_3319_ net88 _1564_ _1565_ _1566_ VDD VSS HA_X1
X_3320_ net87 _1567_ _1568_ _1569_ VDD VSS HA_X1
X_3321_ net86 _1570_ _1571_ _1572_ VDD VSS HA_X1
X_3322_ net85 _1573_ _1574_ _1575_ VDD VSS HA_X1
X_3323_ net83 _1576_ _1577_ _1578_ VDD VSS HA_X1
X_3324_ net82 _1579_ _1580_ _1581_ VDD VSS HA_X1
X_3325_ net81 _1582_ _1583_ _1584_ VDD VSS HA_X1
X_3326_ net80 _1585_ _1586_ _1587_ VDD VSS HA_X1
X_3327_ net79 _1588_ _1589_ _1590_ VDD VSS HA_X1
X_3328_ net78 _1591_ _1592_ _1593_ VDD VSS HA_X1
X_3329_ net77 _1594_ _1595_ _1596_ VDD VSS HA_X1
X_3330_ net76 _1597_ _1598_ _1599_ VDD VSS HA_X1
X_3331_ net75 _1600_ _1601_ _1602_ VDD VSS HA_X1
X_3332_ net74 _1603_ _1604_ _1605_ VDD VSS HA_X1
X_3333_ net72 _1606_ _1607_ _1608_ VDD VSS HA_X1
X_3334_ net71 _1609_ _1610_ _1611_ VDD VSS HA_X1
X_3335_ net70 _1612_ _1613_ _1614_ VDD VSS HA_X1
X_3336_ net69 _1615_ _1616_ _1617_ VDD VSS HA_X1
X_3337_ net68 _1618_ _1619_ _1620_ VDD VSS HA_X1
X_3338_ net67 _1621_ _1622_ _1623_ VDD VSS HA_X1
X_3339_ net66 _1624_ _1625_ _1626_ VDD VSS HA_X1
X_3340_ net65 _1627_ _1628_ _1629_ VDD VSS HA_X1
X_3341_ net64 _1630_ _1631_ _1632_ VDD VSS HA_X1
X_3342_ net63 _1633_ _1634_ _1635_ VDD VSS HA_X1
X_3343_ net61 _1636_ _1637_ _1638_ VDD VSS HA_X1
X_3344_ net60 _1639_ _1640_ _1641_ VDD VSS HA_X1
X_3345_ net59 _1642_ _1643_ _1644_ VDD VSS HA_X1
X_3346_ net58 _1645_ _1646_ _1647_ VDD VSS HA_X1
X_3347_ net57 _1648_ _1649_ _1650_ VDD VSS HA_X1
X_3348_ net56 _1651_ _1652_ _1653_ VDD VSS HA_X1
X_3349_ transfer_count\[1\]\[0\] transfer_count\[1\]\[1\]
+ _1654_ _1655_ VDD VSS HA_X1
X_3350_ net55 _1656_ _1657_ _1658_ VDD VSS HA_X1
X_3351_ _1659_ _1660_ _1661_ _1662_ VDD VSS HA_X1
X_3352_ net53 _1663_ _1664_ _1665_ VDD VSS HA_X1
X_3353_ net52 _1666_ _1667_ _1668_ VDD VSS HA_X1
X_3354_ net50 _1669_ _1670_ _1671_ VDD VSS HA_X1
X_3355_ net49 _1672_ _1673_ _1674_ VDD VSS HA_X1
X_3356_ net48 _1675_ _1676_ _1677_ VDD VSS HA_X1
X_3357_ net47 _1678_ _1679_ _1680_ VDD VSS HA_X1
X_3358_ net46 _1681_ _1682_ _1683_ VDD VSS HA_X1
X_3359_ net45 _1684_ _1685_ _1686_ VDD VSS HA_X1
X_3360_ net44 _1687_ _1688_ _1689_ VDD VSS HA_X1
X_3361_ net43 _1690_ _1691_ _1692_ VDD VSS HA_X1
X_3362_ net42 _1693_ _1694_ _1695_ VDD VSS HA_X1
X_3363_ net41 _1696_ _1697_ _1698_ VDD VSS HA_X1
X_3364_ net39 _1699_ _1700_ _1701_ VDD VSS HA_X1
X_3365_ net38 _1702_ _1703_ _1704_ VDD VSS HA_X1
X_3366_ net37 _1705_ _1706_ _1707_ VDD VSS HA_X1
X_3367_ net36 _1708_ _1709_ _1710_ VDD VSS HA_X1
X_3368_ net35 _1711_ _1712_ _1713_ VDD VSS HA_X1
X_3369_ net34 _1714_ _1715_ _1716_ VDD VSS HA_X1
X_3370_ net33 _1717_ _1718_ _1719_ VDD VSS HA_X1
X_3371_ net32 _1720_ _1721_ _1722_ VDD VSS HA_X1
X_3372_ net23 _1723_ _1724_ _1725_ VDD VSS HA_X1
X_3373_ net12 _1726_ _1727_ _1728_ VDD VSS HA_X1
X_3374_ net128 _1729_ _1730_ _1731_ VDD VSS HA_X1
X_3375_ net117 _1732_ _1733_ _1734_ VDD VSS HA_X1
X_3376_ net106 _1735_ _1736_ _1737_ VDD VSS HA_X1
X_3377_ net95 _1738_ _1739_ _1740_ VDD VSS HA_X1
X_3378_ net84 _1741_ _1742_ _1743_ VDD VSS HA_X1
X_3379_ net73 _1744_ _1745_ _1746_ VDD VSS HA_X1
X_3380_ net62 _1747_ _1748_ _1749_ VDD VSS HA_X1
X_3381_ net51 _1750_ _1751_ _1752_ VDD VSS HA_X1
X_3382_ transfer_count\[0\]\[0\] transfer_count\[0\]\[1\]
+ _1753_ _1754_ VDD VSS HA_X1
X_3383_ net40 _1755_ _1756_ _1757_ VDD VSS HA_X1
X_3384_ _1758_ _1759_ _1760_ _1761_ VDD VSS HA_X1
X_3385_ _1762_ _1763_ _1764_ _1765_ VDD VSS HA_X1
X_3386_ transfer_count\[3\]\[0\] transfer_count\[3\]\[1\]
+ _1766_ _1767_ VDD VSS HA_X1
X_3387_ net125 _1768_ _1769_ _1770_ VDD VSS HA_X1
X_3388_ net127 _1771_ _1772_ _1773_ VDD VSS HA_X1
X_3389_ net126 _1774_ _1775_ _1776_ VDD VSS HA_X1
X_3390_ net5 _1777_ _1778_ _1779_ VDD VSS HA_X1
X_3391_ net4 _1780_ _1781_ _1782_ VDD VSS HA_X1
X_3392_ net3 _1783_ _1784_ _1785_ VDD VSS HA_X1
X_3393_ net2 _1786_ _1787_ _1788_ VDD VSS HA_X1
X_3394_ net14 _1789_ _1790_ _1791_ VDD VSS HA_X1
X_3395_ net13 _1792_ _1793_ _1794_ VDD VSS HA_X1
X_3396_ net11 _1795_ _1796_ _1797_ VDD VSS HA_X1
X_3397_ net10 _1798_ _1799_ _1800_ VDD VSS HA_X1
X_3398_ net9 _1801_ _1802_ _1803_ VDD VSS HA_X1
X_3399_ net8 _1804_ _1805_ _1806_ VDD VSS HA_X1
X_3400_ net7 _1807_ _1808_ _1809_ VDD VSS HA_X1
X_3401_ net6 _1810_ _1811_ _1812_ VDD VSS HA_X1
X_3402_ net31 _1813_ _1814_ _1815_ VDD VSS HA_X1
X_3403_ net30 _1816_ _1817_ _1818_ VDD VSS HA_X1
X_3404_ net29 _1819_ _1820_ _1821_ VDD VSS HA_X1
X_3405_ net28 _1822_ _1823_ _1824_ VDD VSS HA_X1
X_3406_ net27 _1825_ _1826_ _1827_ VDD VSS HA_X1
X_3407_ net26 _1828_ _1829_ _1830_ VDD VSS HA_X1
X_3408_ net25 _1831_ _1832_ _1833_ VDD VSS HA_X1
X_3409_ net24 _1834_ _1835_ _1836_ VDD VSS HA_X1
X_3410_ net22 _1837_ _1838_ _1839_ VDD VSS HA_X1
X_3411_ net21 _1840_ _1841_ _1842_ VDD VSS HA_X1
X_3412_ net20 _1843_ _1844_ _1845_ VDD VSS HA_X1
X_3413_ net19 _1846_ _1847_ _1848_ VDD VSS HA_X1
X_3414_ net18 _1849_ _1850_ _1851_ VDD VSS HA_X1
X_3415_ net17 _1852_ _1853_ _1854_ VDD VSS HA_X1
X_3416_ net16 _1855_ _1856_ _1857_ VDD VSS HA_X1
X_3417_ net15 _1858_ _1859_ _1860_ VDD VSS HA_X1
X_3418_ _1861_ _1862_ _1863_ _1864_ VDD VSS HA_X1
X_3419_ active_channel_count\[0\] active_channel_count\[1\]
+ _1865_ _1866_ VDD VSS HA_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
X_3421_ net163 channel_error[0] VDD VSS BUF_X1
X_3422_ net164 channel_error[1] VDD VSS BUF_X1
X_3423_ net165 channel_error[2] VDD VSS BUF_X1
X_3424_ net166 channel_error[3] VDD VSS BUF_X1
X_3425_ net167 debug_channel_state[0] VDD VSS BUF_X1
X_3426_ net168 debug_channel_state[1] VDD VSS BUF_X1
X_3427_ net169 debug_channel_state[2] VDD VSS BUF_X1
X_3428_ net170 debug_channel_state[3] VDD VSS BUF_X1
X_3429_ net171 debug_channel_state[4] VDD VSS BUF_X1
X_3430_ net172 debug_channel_state[5] VDD VSS BUF_X1
X_3431_ net173 debug_channel_state[6] VDD VSS BUF_X1
X_3432_ net174 debug_channel_state[7] VDD VSS BUF_X1
X_3433_ net175 debug_channel_state[8] VDD VSS BUF_X1
X_3434_ net176 debug_channel_state[9] VDD VSS BUF_X1
X_3435_ net177 debug_channel_state[10] VDD VSS BUF_X1
X_3436_ net178 debug_channel_state[11] VDD VSS BUF_X1
X_3437_ net179 debug_transfer_count[0] VDD VSS BUF_X1
X_3438_ net180 debug_transfer_count[1] VDD VSS BUF_X1
X_3439_ net181 debug_transfer_count[2] VDD VSS BUF_X1
X_3440_ net182 debug_transfer_count[3] VDD VSS BUF_X1
X_3441_ net183 debug_transfer_count[4] VDD VSS BUF_X1
X_3442_ net184 debug_transfer_count[5] VDD VSS BUF_X1
X_3443_ net185 debug_transfer_count[6] VDD VSS BUF_X1
X_3444_ net186 debug_transfer_count[7] VDD VSS BUF_X1
X_3445_ net187 debug_transfer_count[8] VDD VSS BUF_X1
X_3446_ net188 debug_transfer_count[9] VDD VSS BUF_X1
X_3447_ net189 debug_transfer_count[10] VDD VSS BUF_X1
X_3448_ net190 debug_transfer_count[11] VDD VSS BUF_X1
X_3449_ net191 debug_transfer_count[12] VDD VSS BUF_X1
X_3450_ net192 debug_transfer_count[13] VDD VSS BUF_X1
X_3451_ net193 debug_transfer_count[14] VDD VSS BUF_X1
X_3452_ net194 debug_transfer_count[15] VDD VSS BUF_X1
X_3453_ net195 debug_transfer_count[16] VDD VSS BUF_X1
X_3454_ net196 debug_transfer_count[17] VDD VSS BUF_X1
X_3455_ net197 debug_transfer_count[18] VDD VSS BUF_X1
X_3456_ net198 debug_transfer_count[19] VDD VSS BUF_X1
X_3457_ net199 debug_transfer_count[20] VDD VSS BUF_X1
X_3458_ net200 debug_transfer_count[21] VDD VSS BUF_X1
X_3459_ net201 debug_transfer_count[22] VDD VSS BUF_X1
X_3460_ net202 debug_transfer_count[23] VDD VSS BUF_X1
X_3461_ net203 debug_transfer_count[24] VDD VSS BUF_X1
X_3462_ net204 debug_transfer_count[25] VDD VSS BUF_X1
X_3463_ net205 debug_transfer_count[26] VDD VSS BUF_X1
X_3464_ net206 debug_transfer_count[27] VDD VSS BUF_X1
X_3465_ net207 debug_transfer_count[28] VDD VSS BUF_X1
X_3466_ net208 debug_transfer_count[29] VDD VSS BUF_X1
X_3467_ net209 debug_transfer_count[30] VDD VSS BUF_X1
X_3468_ net210 debug_transfer_count[31] VDD VSS BUF_X1
X_3469_ net211 debug_transfer_count[32] VDD VSS BUF_X1
X_3470_ net212 debug_transfer_count[33] VDD VSS BUF_X1
X_3471_ net213 debug_transfer_count[34] VDD VSS BUF_X1
X_3472_ net214 debug_transfer_count[35] VDD VSS BUF_X1
X_3473_ net215 debug_transfer_count[36] VDD VSS BUF_X1
X_3474_ net216 debug_transfer_count[37] VDD VSS BUF_X1
X_3475_ net217 debug_transfer_count[38] VDD VSS BUF_X1
X_3476_ net218 debug_transfer_count[39] VDD VSS BUF_X1
X_3477_ net219 debug_transfer_count[40] VDD VSS BUF_X1
X_3478_ net220 debug_transfer_count[41] VDD VSS BUF_X1
X_3479_ net221 debug_transfer_count[42] VDD VSS BUF_X1
X_3480_ net222 debug_transfer_count[43] VDD VSS BUF_X1
X_3481_ net223 debug_transfer_count[44] VDD VSS BUF_X1
X_3482_ net224 debug_transfer_count[45] VDD VSS BUF_X1
X_3483_ net225 debug_transfer_count[46] VDD VSS BUF_X1
X_3484_ net226 debug_transfer_count[47] VDD VSS BUF_X1
X_3485_ net227 debug_transfer_count[48] VDD VSS BUF_X1
X_3486_ net228 debug_transfer_count[49] VDD VSS BUF_X1
X_3487_ net229 debug_transfer_count[50] VDD VSS BUF_X1
X_3488_ net230 debug_transfer_count[51] VDD VSS BUF_X1
X_3489_ net231 debug_transfer_count[52] VDD VSS BUF_X1
X_3490_ net232 debug_transfer_count[53] VDD VSS BUF_X1
X_3491_ net233 debug_transfer_count[54] VDD VSS BUF_X1
X_3492_ net234 debug_transfer_count[55] VDD VSS BUF_X1
X_3493_ net235 debug_transfer_count[56] VDD VSS BUF_X1
X_3494_ net236 debug_transfer_count[57] VDD VSS BUF_X1
X_3495_ net237 debug_transfer_count[58] VDD VSS BUF_X1
X_3496_ net238 debug_transfer_count[59] VDD VSS BUF_X1
X_3497_ net239 debug_transfer_count[60] VDD VSS BUF_X1
X_3498_ net240 debug_transfer_count[61] VDD VSS BUF_X1
X_3499_ net241 debug_transfer_count[62] VDD VSS BUF_X1
X_3500_ net242 debug_transfer_count[63] VDD VSS BUF_X1
X_3501_ net243 debug_transfer_count[64] VDD VSS BUF_X1
X_3502_ net244 debug_transfer_count[65] VDD VSS BUF_X1
X_3503_ net245 debug_transfer_count[66] VDD VSS BUF_X1
X_3504_ net246 debug_transfer_count[67] VDD VSS BUF_X1
X_3505_ net247 debug_transfer_count[68] VDD VSS BUF_X1
X_3506_ net248 debug_transfer_count[69] VDD VSS BUF_X1
X_3507_ net249 debug_transfer_count[70] VDD VSS BUF_X1
X_3508_ net250 debug_transfer_count[71] VDD VSS BUF_X1
X_3509_ net251 debug_transfer_count[72] VDD VSS BUF_X1
X_3510_ net252 debug_transfer_count[73] VDD VSS BUF_X1
X_3511_ net253 debug_transfer_count[74] VDD VSS BUF_X1
X_3512_ net254 debug_transfer_count[75] VDD VSS BUF_X1
X_3513_ net255 debug_transfer_count[76] VDD VSS BUF_X1
X_3514_ net256 debug_transfer_count[77] VDD VSS BUF_X1
X_3515_ net257 debug_transfer_count[78] VDD VSS BUF_X1
X_3516_ net258 debug_transfer_count[79] VDD VSS BUF_X1
X_3517_ net259 debug_transfer_count[80] VDD VSS BUF_X1
X_3518_ net260 debug_transfer_count[81] VDD VSS BUF_X1
X_3519_ net261 debug_transfer_count[82] VDD VSS BUF_X1
X_3520_ net262 debug_transfer_count[83] VDD VSS BUF_X1
X_3521_ net263 debug_transfer_count[84] VDD VSS BUF_X1
X_3522_ net264 debug_transfer_count[85] VDD VSS BUF_X1
X_3523_ net265 debug_transfer_count[86] VDD VSS BUF_X1
X_3524_ net266 debug_transfer_count[87] VDD VSS BUF_X1
X_3525_ net267 debug_transfer_count[88] VDD VSS BUF_X1
X_3526_ net268 debug_transfer_count[89] VDD VSS BUF_X1
X_3527_ net269 debug_transfer_count[90] VDD VSS BUF_X1
X_3528_ net270 debug_transfer_count[91] VDD VSS BUF_X1
X_3529_ net271 debug_transfer_count[92] VDD VSS BUF_X1
X_3530_ net272 debug_transfer_count[93] VDD VSS BUF_X1
X_3531_ net273 debug_transfer_count[94] VDD VSS BUF_X1
X_3532_ net274 debug_transfer_count[95] VDD VSS BUF_X1
X_3533_ net275 debug_transfer_count[96] VDD VSS BUF_X1
X_3534_ net276 debug_transfer_count[97] VDD VSS BUF_X1
X_3535_ net277 debug_transfer_count[98] VDD VSS BUF_X1
X_3536_ net278 debug_transfer_count[99] VDD VSS BUF_X1
X_3537_ net279 debug_transfer_count[100] VDD VSS BUF_X1
X_3538_ net280 debug_transfer_count[101] VDD VSS BUF_X1
X_3539_ net281 debug_transfer_count[102] VDD VSS BUF_X1
X_3540_ net282 debug_transfer_count[103] VDD VSS BUF_X1
X_3541_ net283 debug_transfer_count[104] VDD VSS BUF_X1
X_3542_ net284 debug_transfer_count[105] VDD VSS BUF_X1
X_3543_ net285 debug_transfer_count[106] VDD VSS BUF_X1
X_3544_ net286 debug_transfer_count[107] VDD VSS BUF_X1
X_3545_ net287 debug_transfer_count[108] VDD VSS BUF_X1
X_3546_ net288 debug_transfer_count[109] VDD VSS BUF_X1
X_3547_ net289 debug_transfer_count[110] VDD VSS BUF_X1
X_3548_ net290 debug_transfer_count[111] VDD VSS BUF_X1
X_3549_ net291 debug_transfer_count[112] VDD VSS BUF_X1
X_3550_ net292 debug_transfer_count[113] VDD VSS BUF_X1
X_3551_ net293 debug_transfer_count[114] VDD VSS BUF_X1
X_3552_ net294 debug_transfer_count[115] VDD VSS BUF_X1
X_3553_ net295 debug_transfer_count[116] VDD VSS BUF_X1
X_3554_ net296 debug_transfer_count[117] VDD VSS BUF_X1
X_3555_ net297 debug_transfer_count[118] VDD VSS BUF_X1
X_3556_ net298 debug_transfer_count[119] VDD VSS BUF_X1
X_3557_ net299 debug_transfer_count[120] VDD VSS BUF_X1
X_3558_ net300 debug_transfer_count[121] VDD VSS BUF_X1
X_3559_ net301 debug_transfer_count[122] VDD VSS BUF_X1
X_3560_ net302 debug_transfer_count[123] VDD VSS BUF_X1
X_3561_ net303 debug_transfer_count[124] VDD VSS BUF_X1
X_3562_ net304 debug_transfer_count[125] VDD VSS BUF_X1
X_3563_ net305 debug_transfer_count[126] VDD VSS BUF_X1
X_3564_ net306 debug_transfer_count[127] VDD VSS BUF_X1
X_3565_ net307 dst_addr[0] VDD VSS BUF_X1
X_3566_ net308 dst_addr[1] VDD VSS BUF_X1
X_3567_ net309 dst_addr[2] VDD VSS BUF_X1
X_3568_ net310 dst_addr[3] VDD VSS BUF_X1
X_3569_ net311 dst_addr[4] VDD VSS BUF_X1
X_3570_ net312 dst_addr[5] VDD VSS BUF_X1
X_3571_ net313 dst_addr[6] VDD VSS BUF_X1
X_3572_ net314 dst_addr[7] VDD VSS BUF_X1
X_3573_ net315 dst_addr[8] VDD VSS BUF_X1
X_3574_ net316 dst_addr[9] VDD VSS BUF_X1
X_3575_ net317 dst_addr[10] VDD VSS BUF_X1
X_3576_ net318 dst_addr[11] VDD VSS BUF_X1
X_3577_ net319 dst_addr[12] VDD VSS BUF_X1
X_3578_ net320 dst_addr[13] VDD VSS BUF_X1
X_3579_ net321 dst_addr[14] VDD VSS BUF_X1
X_3580_ net322 dst_addr[15] VDD VSS BUF_X1
X_3581_ net323 dst_addr[16] VDD VSS BUF_X1
X_3582_ net324 dst_addr[17] VDD VSS BUF_X1
X_3583_ net325 dst_addr[18] VDD VSS BUF_X1
X_3584_ net326 dst_addr[19] VDD VSS BUF_X1
X_3585_ net327 dst_addr[20] VDD VSS BUF_X1
X_3586_ net328 dst_addr[21] VDD VSS BUF_X1
X_3587_ net329 dst_addr[22] VDD VSS BUF_X1
X_3588_ net330 dst_addr[23] VDD VSS BUF_X1
X_3589_ net331 dst_addr[24] VDD VSS BUF_X1
X_3590_ net332 dst_addr[25] VDD VSS BUF_X1
X_3591_ net333 dst_addr[26] VDD VSS BUF_X1
X_3592_ net334 dst_addr[27] VDD VSS BUF_X1
X_3593_ net335 dst_addr[28] VDD VSS BUF_X1
X_3594_ net336 dst_addr[29] VDD VSS BUF_X1
X_3595_ net337 dst_addr[30] VDD VSS BUF_X1
X_3596_ net338 dst_addr[31] VDD VSS BUF_X1
X_3597_ net339 dst_addr[32] VDD VSS BUF_X1
X_3598_ net340 dst_addr[33] VDD VSS BUF_X1
X_3599_ net341 dst_addr[34] VDD VSS BUF_X1
X_3600_ net342 dst_addr[35] VDD VSS BUF_X1
X_3601_ net343 dst_addr[36] VDD VSS BUF_X1
X_3602_ net344 dst_addr[37] VDD VSS BUF_X1
X_3603_ net345 dst_addr[38] VDD VSS BUF_X1
X_3604_ net346 dst_addr[39] VDD VSS BUF_X1
X_3605_ net347 dst_addr[40] VDD VSS BUF_X1
X_3606_ net348 dst_addr[41] VDD VSS BUF_X1
X_3607_ net349 dst_addr[42] VDD VSS BUF_X1
X_3608_ net350 dst_addr[43] VDD VSS BUF_X1
X_3609_ net351 dst_addr[44] VDD VSS BUF_X1
X_3610_ net352 dst_addr[45] VDD VSS BUF_X1
X_3611_ net353 dst_addr[46] VDD VSS BUF_X1
X_3612_ net354 dst_addr[47] VDD VSS BUF_X1
X_3613_ net355 dst_addr[48] VDD VSS BUF_X1
X_3614_ net356 dst_addr[49] VDD VSS BUF_X1
X_3615_ net357 dst_addr[50] VDD VSS BUF_X1
X_3616_ net358 dst_addr[51] VDD VSS BUF_X1
X_3617_ net359 dst_addr[52] VDD VSS BUF_X1
X_3618_ net360 dst_addr[53] VDD VSS BUF_X1
X_3619_ net361 dst_addr[54] VDD VSS BUF_X1
X_3620_ net362 dst_addr[55] VDD VSS BUF_X1
X_3621_ net363 dst_addr[56] VDD VSS BUF_X1
X_3622_ net364 dst_addr[57] VDD VSS BUF_X1
X_3623_ net365 dst_addr[58] VDD VSS BUF_X1
X_3624_ net366 dst_addr[59] VDD VSS BUF_X1
X_3625_ net367 dst_addr[60] VDD VSS BUF_X1
X_3626_ net368 dst_addr[61] VDD VSS BUF_X1
X_3627_ net369 dst_addr[62] VDD VSS BUF_X1
X_3628_ net370 dst_addr[63] VDD VSS BUF_X1
X_3629_ net371 dst_addr[64] VDD VSS BUF_X1
X_3630_ net372 dst_addr[65] VDD VSS BUF_X1
X_3631_ net373 dst_addr[66] VDD VSS BUF_X1
X_3632_ net374 dst_addr[67] VDD VSS BUF_X1
X_3633_ net375 dst_addr[68] VDD VSS BUF_X1
X_3634_ net376 dst_addr[69] VDD VSS BUF_X1
X_3635_ net377 dst_addr[70] VDD VSS BUF_X1
X_3636_ net378 dst_addr[71] VDD VSS BUF_X1
X_3637_ net379 dst_addr[72] VDD VSS BUF_X1
X_3638_ net380 dst_addr[73] VDD VSS BUF_X1
X_3639_ net381 dst_addr[74] VDD VSS BUF_X1
X_3640_ net382 dst_addr[75] VDD VSS BUF_X1
X_3641_ net383 dst_addr[76] VDD VSS BUF_X1
X_3642_ net384 dst_addr[77] VDD VSS BUF_X1
X_3643_ net385 dst_addr[78] VDD VSS BUF_X1
X_3644_ net386 dst_addr[79] VDD VSS BUF_X1
X_3645_ net387 dst_addr[80] VDD VSS BUF_X1
X_3646_ net388 dst_addr[81] VDD VSS BUF_X1
X_3647_ net389 dst_addr[82] VDD VSS BUF_X1
X_3648_ net390 dst_addr[83] VDD VSS BUF_X1
X_3649_ net391 dst_addr[84] VDD VSS BUF_X1
X_3650_ net392 dst_addr[85] VDD VSS BUF_X1
X_3651_ net393 dst_addr[86] VDD VSS BUF_X1
X_3652_ net394 dst_addr[87] VDD VSS BUF_X1
X_3653_ net395 dst_addr[88] VDD VSS BUF_X1
X_3654_ net396 dst_addr[89] VDD VSS BUF_X1
X_3655_ net397 dst_addr[90] VDD VSS BUF_X1
X_3656_ net398 dst_addr[91] VDD VSS BUF_X1
X_3657_ net399 dst_addr[92] VDD VSS BUF_X1
X_3658_ net400 dst_addr[93] VDD VSS BUF_X1
X_3659_ net401 dst_addr[94] VDD VSS BUF_X1
X_3660_ net402 dst_addr[95] VDD VSS BUF_X1
X_3661_ net403 dst_addr[96] VDD VSS BUF_X1
X_3662_ net404 dst_addr[97] VDD VSS BUF_X1
X_3663_ net405 dst_addr[98] VDD VSS BUF_X1
X_3664_ net406 dst_addr[99] VDD VSS BUF_X1
X_3665_ net407 dst_addr[100] VDD VSS BUF_X1
X_3666_ net408 dst_addr[101] VDD VSS BUF_X1
X_3667_ net409 dst_addr[102] VDD VSS BUF_X1
X_3668_ net410 dst_addr[103] VDD VSS BUF_X1
X_3669_ net411 dst_addr[104] VDD VSS BUF_X1
X_3670_ net412 dst_addr[105] VDD VSS BUF_X1
X_3671_ net413 dst_addr[106] VDD VSS BUF_X1
X_3672_ net414 dst_addr[107] VDD VSS BUF_X1
X_3673_ net415 dst_addr[108] VDD VSS BUF_X1
X_3674_ net416 dst_addr[109] VDD VSS BUF_X1
X_3675_ net417 dst_addr[110] VDD VSS BUF_X1
X_3676_ net418 dst_addr[111] VDD VSS BUF_X1
X_3677_ net419 dst_addr[112] VDD VSS BUF_X1
X_3678_ net420 dst_addr[113] VDD VSS BUF_X1
X_3679_ net421 dst_addr[114] VDD VSS BUF_X1
X_3680_ net422 dst_addr[115] VDD VSS BUF_X1
X_3681_ net423 dst_addr[116] VDD VSS BUF_X1
X_3682_ net424 dst_addr[117] VDD VSS BUF_X1
X_3683_ net425 dst_addr[118] VDD VSS BUF_X1
X_3684_ net426 dst_addr[119] VDD VSS BUF_X1
X_3685_ net427 dst_addr[120] VDD VSS BUF_X1
X_3686_ net428 dst_addr[121] VDD VSS BUF_X1
X_3687_ net429 dst_addr[122] VDD VSS BUF_X1
X_3688_ net430 dst_addr[123] VDD VSS BUF_X1
X_3689_ net431 dst_addr[124] VDD VSS BUF_X1
X_3690_ net432 dst_addr[125] VDD VSS BUF_X1
X_3691_ net433 dst_addr[126] VDD VSS BUF_X1
X_3692_ net434 dst_addr[127] VDD VSS BUF_X1
X_3693_ net435 dst_wdata[0] VDD VSS BUF_X1
X_3694_ net436 dst_wdata[1] VDD VSS BUF_X1
X_3695_ net437 dst_wdata[2] VDD VSS BUF_X1
X_3696_ net438 dst_wdata[3] VDD VSS BUF_X1
X_3697_ net439 dst_wdata[4] VDD VSS BUF_X1
X_3698_ net440 dst_wdata[5] VDD VSS BUF_X1
X_3699_ net441 dst_wdata[6] VDD VSS BUF_X1
X_3700_ net442 dst_wdata[7] VDD VSS BUF_X1
X_3701_ net443 dst_wdata[8] VDD VSS BUF_X1
X_3702_ net444 dst_wdata[9] VDD VSS BUF_X1
X_3703_ net445 dst_wdata[10] VDD VSS BUF_X1
X_3704_ net446 dst_wdata[11] VDD VSS BUF_X1
X_3705_ net447 dst_wdata[12] VDD VSS BUF_X1
X_3706_ net448 dst_wdata[13] VDD VSS BUF_X1
X_3707_ net449 dst_wdata[14] VDD VSS BUF_X1
X_3708_ net450 dst_wdata[15] VDD VSS BUF_X1
X_3709_ net451 dst_wdata[16] VDD VSS BUF_X1
X_3710_ net452 dst_wdata[17] VDD VSS BUF_X1
X_3711_ net453 dst_wdata[18] VDD VSS BUF_X1
X_3712_ net454 dst_wdata[19] VDD VSS BUF_X1
X_3713_ net455 dst_wdata[20] VDD VSS BUF_X1
X_3714_ net456 dst_wdata[21] VDD VSS BUF_X1
X_3715_ net457 dst_wdata[22] VDD VSS BUF_X1
X_3716_ net458 dst_wdata[23] VDD VSS BUF_X1
X_3717_ net459 dst_wdata[24] VDD VSS BUF_X1
X_3718_ net460 dst_wdata[25] VDD VSS BUF_X1
X_3719_ net461 dst_wdata[26] VDD VSS BUF_X1
X_3720_ net462 dst_wdata[27] VDD VSS BUF_X1
X_3721_ net463 dst_wdata[28] VDD VSS BUF_X1
X_3722_ net464 dst_wdata[29] VDD VSS BUF_X1
X_3723_ net465 dst_wdata[30] VDD VSS BUF_X1
X_3724_ net466 dst_wdata[31] VDD VSS BUF_X1
X_3725_ net467 dst_wdata[32] VDD VSS BUF_X1
X_3726_ net468 dst_wdata[33] VDD VSS BUF_X1
X_3727_ net469 dst_wdata[34] VDD VSS BUF_X1
X_3728_ net470 dst_wdata[35] VDD VSS BUF_X1
X_3729_ net471 dst_wdata[36] VDD VSS BUF_X1
X_3730_ net472 dst_wdata[37] VDD VSS BUF_X1
X_3731_ net473 dst_wdata[38] VDD VSS BUF_X1
X_3732_ net474 dst_wdata[39] VDD VSS BUF_X1
X_3733_ net475 dst_wdata[40] VDD VSS BUF_X1
X_3734_ net476 dst_wdata[41] VDD VSS BUF_X1
X_3735_ net477 dst_wdata[42] VDD VSS BUF_X1
X_3736_ net478 dst_wdata[43] VDD VSS BUF_X1
X_3737_ net479 dst_wdata[44] VDD VSS BUF_X1
X_3738_ net480 dst_wdata[45] VDD VSS BUF_X1
X_3739_ net481 dst_wdata[46] VDD VSS BUF_X1
X_3740_ net482 dst_wdata[47] VDD VSS BUF_X1
X_3741_ net483 dst_wdata[48] VDD VSS BUF_X1
X_3742_ net484 dst_wdata[49] VDD VSS BUF_X1
X_3743_ net485 dst_wdata[50] VDD VSS BUF_X1
X_3744_ net486 dst_wdata[51] VDD VSS BUF_X1
X_3745_ net487 dst_wdata[52] VDD VSS BUF_X1
X_3746_ net488 dst_wdata[53] VDD VSS BUF_X1
X_3747_ net489 dst_wdata[54] VDD VSS BUF_X1
X_3748_ net490 dst_wdata[55] VDD VSS BUF_X1
X_3749_ net491 dst_wdata[56] VDD VSS BUF_X1
X_3750_ net492 dst_wdata[57] VDD VSS BUF_X1
X_3751_ net493 dst_wdata[58] VDD VSS BUF_X1
X_3752_ net494 dst_wdata[59] VDD VSS BUF_X1
X_3753_ net495 dst_wdata[60] VDD VSS BUF_X1
X_3754_ net496 dst_wdata[61] VDD VSS BUF_X1
X_3755_ net497 dst_wdata[62] VDD VSS BUF_X1
X_3756_ net498 dst_wdata[63] VDD VSS BUF_X1
X_3757_ net499 dst_wdata[64] VDD VSS BUF_X1
X_3758_ net500 dst_wdata[65] VDD VSS BUF_X1
X_3759_ net501 dst_wdata[66] VDD VSS BUF_X1
X_3760_ net502 dst_wdata[67] VDD VSS BUF_X1
X_3761_ net503 dst_wdata[68] VDD VSS BUF_X1
X_3762_ net504 dst_wdata[69] VDD VSS BUF_X1
X_3763_ net505 dst_wdata[70] VDD VSS BUF_X1
X_3764_ net506 dst_wdata[71] VDD VSS BUF_X1
X_3765_ net507 dst_wdata[72] VDD VSS BUF_X1
X_3766_ net508 dst_wdata[73] VDD VSS BUF_X1
X_3767_ net509 dst_wdata[74] VDD VSS BUF_X1
X_3768_ net510 dst_wdata[75] VDD VSS BUF_X1
X_3769_ net511 dst_wdata[76] VDD VSS BUF_X1
X_3770_ net512 dst_wdata[77] VDD VSS BUF_X1
X_3771_ net513 dst_wdata[78] VDD VSS BUF_X1
X_3772_ net514 dst_wdata[79] VDD VSS BUF_X1
X_3773_ net515 dst_wdata[80] VDD VSS BUF_X1
X_3774_ net516 dst_wdata[81] VDD VSS BUF_X1
X_3775_ net517 dst_wdata[82] VDD VSS BUF_X1
X_3776_ net518 dst_wdata[83] VDD VSS BUF_X1
X_3777_ net519 dst_wdata[84] VDD VSS BUF_X1
X_3778_ net520 dst_wdata[85] VDD VSS BUF_X1
X_3779_ net521 dst_wdata[86] VDD VSS BUF_X1
X_3780_ net522 dst_wdata[87] VDD VSS BUF_X1
X_3781_ net523 dst_wdata[88] VDD VSS BUF_X1
X_3782_ net524 dst_wdata[89] VDD VSS BUF_X1
X_3783_ net525 dst_wdata[90] VDD VSS BUF_X1
X_3784_ net526 dst_wdata[91] VDD VSS BUF_X1
X_3785_ net527 dst_wdata[92] VDD VSS BUF_X1
X_3786_ net528 dst_wdata[93] VDD VSS BUF_X1
X_3787_ net529 dst_wdata[94] VDD VSS BUF_X1
X_3788_ net530 dst_wdata[95] VDD VSS BUF_X1
X_3789_ net531 dst_wdata[96] VDD VSS BUF_X1
X_3790_ net532 dst_wdata[97] VDD VSS BUF_X1
X_3791_ net533 dst_wdata[98] VDD VSS BUF_X1
X_3792_ net534 dst_wdata[99] VDD VSS BUF_X1
X_3793_ net535 dst_wdata[100] VDD VSS BUF_X1
X_3794_ net536 dst_wdata[101] VDD VSS BUF_X1
X_3795_ net537 dst_wdata[102] VDD VSS BUF_X1
X_3796_ net538 dst_wdata[103] VDD VSS BUF_X1
X_3797_ net539 dst_wdata[104] VDD VSS BUF_X1
X_3798_ net540 dst_wdata[105] VDD VSS BUF_X1
X_3799_ net541 dst_wdata[106] VDD VSS BUF_X1
X_3800_ net542 dst_wdata[107] VDD VSS BUF_X1
X_3801_ net543 dst_wdata[108] VDD VSS BUF_X1
X_3802_ net544 dst_wdata[109] VDD VSS BUF_X1
X_3803_ net545 dst_wdata[110] VDD VSS BUF_X1
X_3804_ net546 dst_wdata[111] VDD VSS BUF_X1
X_3805_ net547 dst_wdata[112] VDD VSS BUF_X1
X_3806_ net548 dst_wdata[113] VDD VSS BUF_X1
X_3807_ net549 dst_wdata[114] VDD VSS BUF_X1
X_3808_ net550 dst_wdata[115] VDD VSS BUF_X1
X_3809_ net551 dst_wdata[116] VDD VSS BUF_X1
X_3810_ net552 dst_wdata[117] VDD VSS BUF_X1
X_3811_ net553 dst_wdata[118] VDD VSS BUF_X1
X_3812_ net554 dst_wdata[119] VDD VSS BUF_X1
X_3813_ net555 dst_wdata[120] VDD VSS BUF_X1
X_3814_ net556 dst_wdata[121] VDD VSS BUF_X1
X_3815_ net557 dst_wdata[122] VDD VSS BUF_X1
X_3816_ net558 dst_wdata[123] VDD VSS BUF_X1
X_3817_ net559 dst_wdata[124] VDD VSS BUF_X1
X_3818_ net560 dst_wdata[125] VDD VSS BUF_X1
X_3819_ net561 dst_wdata[126] VDD VSS BUF_X1
X_3820_ net562 dst_wdata[127] VDD VSS BUF_X1
X_3821_ net563 dst_wstrb[0] VDD VSS BUF_X1
X_3822_ net564 dst_wstrb[1] VDD VSS BUF_X1
X_3823_ net565 dst_wstrb[2] VDD VSS BUF_X1
X_3824_ net566 dst_wstrb[3] VDD VSS BUF_X1
X_3825_ net567 dst_wstrb[4] VDD VSS BUF_X1
X_3826_ net568 dst_wstrb[5] VDD VSS BUF_X1
X_3827_ net569 dst_wstrb[6] VDD VSS BUF_X1
X_3828_ net570 dst_wstrb[7] VDD VSS BUF_X1
X_3829_ net571 dst_wstrb[8] VDD VSS BUF_X1
X_3830_ net572 dst_wstrb[9] VDD VSS BUF_X1
X_3831_ net573 dst_wstrb[10] VDD VSS BUF_X1
X_3832_ net574 dst_wstrb[11] VDD VSS BUF_X1
X_3833_ net575 dst_wstrb[12] VDD VSS BUF_X1
X_3834_ net576 dst_wstrb[13] VDD VSS BUF_X1
X_3835_ net577 dst_wstrb[14] VDD VSS BUF_X1
X_3836_ net578 dst_wstrb[15] VDD VSS BUF_X1
X_3837_ net579 src_addr[0] VDD VSS BUF_X1
X_3838_ net580 src_addr[1] VDD VSS BUF_X1
X_3839_ net581 src_addr[2] VDD VSS BUF_X1
X_3840_ net582 src_addr[3] VDD VSS BUF_X1
X_3841_ net583 src_addr[4] VDD VSS BUF_X1
X_3842_ net584 src_addr[5] VDD VSS BUF_X1
X_3843_ net585 src_addr[6] VDD VSS BUF_X1
X_3844_ net586 src_addr[7] VDD VSS BUF_X1
X_3845_ net587 src_addr[8] VDD VSS BUF_X1
X_3846_ net588 src_addr[9] VDD VSS BUF_X1
X_3847_ net589 src_addr[10] VDD VSS BUF_X1
X_3848_ net590 src_addr[11] VDD VSS BUF_X1
X_3849_ net591 src_addr[12] VDD VSS BUF_X1
X_3850_ net592 src_addr[13] VDD VSS BUF_X1
X_3851_ net593 src_addr[14] VDD VSS BUF_X1
X_3852_ net594 src_addr[15] VDD VSS BUF_X1
X_3853_ net595 src_addr[16] VDD VSS BUF_X1
X_3854_ net596 src_addr[17] VDD VSS BUF_X1
X_3855_ net597 src_addr[18] VDD VSS BUF_X1
X_3856_ net598 src_addr[19] VDD VSS BUF_X1
X_3857_ net599 src_addr[20] VDD VSS BUF_X1
X_3858_ net600 src_addr[21] VDD VSS BUF_X1
X_3859_ net601 src_addr[22] VDD VSS BUF_X1
X_3860_ net602 src_addr[23] VDD VSS BUF_X1
X_3861_ net603 src_addr[24] VDD VSS BUF_X1
X_3862_ net604 src_addr[25] VDD VSS BUF_X1
X_3863_ net605 src_addr[26] VDD VSS BUF_X1
X_3864_ net606 src_addr[27] VDD VSS BUF_X1
X_3865_ net607 src_addr[28] VDD VSS BUF_X1
X_3866_ net608 src_addr[29] VDD VSS BUF_X1
X_3867_ net609 src_addr[30] VDD VSS BUF_X1
X_3868_ net610 src_addr[31] VDD VSS BUF_X1
X_3869_ net611 src_addr[32] VDD VSS BUF_X1
X_3870_ net612 src_addr[33] VDD VSS BUF_X1
X_3871_ net613 src_addr[34] VDD VSS BUF_X1
X_3872_ net614 src_addr[35] VDD VSS BUF_X1
X_3873_ net615 src_addr[36] VDD VSS BUF_X1
X_3874_ net616 src_addr[37] VDD VSS BUF_X1
X_3875_ net617 src_addr[38] VDD VSS BUF_X1
X_3876_ net618 src_addr[39] VDD VSS BUF_X1
X_3877_ net619 src_addr[40] VDD VSS BUF_X1
X_3878_ net620 src_addr[41] VDD VSS BUF_X1
X_3879_ net621 src_addr[42] VDD VSS BUF_X1
X_3880_ net622 src_addr[43] VDD VSS BUF_X1
X_3881_ net623 src_addr[44] VDD VSS BUF_X1
X_3882_ net624 src_addr[45] VDD VSS BUF_X1
X_3883_ net625 src_addr[46] VDD VSS BUF_X1
X_3884_ net626 src_addr[47] VDD VSS BUF_X1
X_3885_ net627 src_addr[48] VDD VSS BUF_X1
X_3886_ net628 src_addr[49] VDD VSS BUF_X1
X_3887_ net629 src_addr[50] VDD VSS BUF_X1
X_3888_ net630 src_addr[51] VDD VSS BUF_X1
X_3889_ net631 src_addr[52] VDD VSS BUF_X1
X_3890_ net632 src_addr[53] VDD VSS BUF_X1
X_3891_ net633 src_addr[54] VDD VSS BUF_X1
X_3892_ net634 src_addr[55] VDD VSS BUF_X1
X_3893_ net635 src_addr[56] VDD VSS BUF_X1
X_3894_ net636 src_addr[57] VDD VSS BUF_X1
X_3895_ net637 src_addr[58] VDD VSS BUF_X1
X_3896_ net638 src_addr[59] VDD VSS BUF_X1
X_3897_ net639 src_addr[60] VDD VSS BUF_X1
X_3898_ net640 src_addr[61] VDD VSS BUF_X1
X_3899_ net641 src_addr[62] VDD VSS BUF_X1
X_3900_ net642 src_addr[63] VDD VSS BUF_X1
X_3901_ net643 src_addr[64] VDD VSS BUF_X1
X_3902_ net644 src_addr[65] VDD VSS BUF_X1
X_3903_ net645 src_addr[66] VDD VSS BUF_X1
X_3904_ net646 src_addr[67] VDD VSS BUF_X1
X_3905_ net647 src_addr[68] VDD VSS BUF_X1
X_3906_ net648 src_addr[69] VDD VSS BUF_X1
X_3907_ net649 src_addr[70] VDD VSS BUF_X1
X_3908_ net650 src_addr[71] VDD VSS BUF_X1
X_3909_ net651 src_addr[72] VDD VSS BUF_X1
X_3910_ net652 src_addr[73] VDD VSS BUF_X1
X_3911_ net653 src_addr[74] VDD VSS BUF_X1
X_3912_ net654 src_addr[75] VDD VSS BUF_X1
X_3913_ net655 src_addr[76] VDD VSS BUF_X1
X_3914_ net656 src_addr[77] VDD VSS BUF_X1
X_3915_ net657 src_addr[78] VDD VSS BUF_X1
X_3916_ net658 src_addr[79] VDD VSS BUF_X1
X_3917_ net659 src_addr[80] VDD VSS BUF_X1
X_3918_ net660 src_addr[81] VDD VSS BUF_X1
X_3919_ net661 src_addr[82] VDD VSS BUF_X1
X_3920_ net662 src_addr[83] VDD VSS BUF_X1
X_3921_ net663 src_addr[84] VDD VSS BUF_X1
X_3922_ net664 src_addr[85] VDD VSS BUF_X1
X_3923_ net665 src_addr[86] VDD VSS BUF_X1
X_3924_ net666 src_addr[87] VDD VSS BUF_X1
X_3925_ net667 src_addr[88] VDD VSS BUF_X1
X_3926_ net668 src_addr[89] VDD VSS BUF_X1
X_3927_ net669 src_addr[90] VDD VSS BUF_X1
X_3928_ net670 src_addr[91] VDD VSS BUF_X1
X_3929_ net671 src_addr[92] VDD VSS BUF_X1
X_3930_ net672 src_addr[93] VDD VSS BUF_X1
X_3931_ net673 src_addr[94] VDD VSS BUF_X1
X_3932_ net674 src_addr[95] VDD VSS BUF_X1
X_3933_ net675 src_addr[96] VDD VSS BUF_X1
X_3934_ net676 src_addr[97] VDD VSS BUF_X1
X_3935_ net677 src_addr[98] VDD VSS BUF_X1
X_3936_ net678 src_addr[99] VDD VSS BUF_X1
X_3937_ net679 src_addr[100] VDD VSS BUF_X1
X_3938_ net680 src_addr[101] VDD VSS BUF_X1
X_3939_ net681 src_addr[102] VDD VSS BUF_X1
X_3940_ net682 src_addr[103] VDD VSS BUF_X1
X_3941_ net683 src_addr[104] VDD VSS BUF_X1
X_3942_ net684 src_addr[105] VDD VSS BUF_X1
X_3943_ net685 src_addr[106] VDD VSS BUF_X1
X_3944_ net686 src_addr[107] VDD VSS BUF_X1
X_3945_ net687 src_addr[108] VDD VSS BUF_X1
X_3946_ net688 src_addr[109] VDD VSS BUF_X1
X_3947_ net689 src_addr[110] VDD VSS BUF_X1
X_3948_ net690 src_addr[111] VDD VSS BUF_X1
X_3949_ net691 src_addr[112] VDD VSS BUF_X1
X_3950_ net692 src_addr[113] VDD VSS BUF_X1
X_3951_ net693 src_addr[114] VDD VSS BUF_X1
X_3952_ net694 src_addr[115] VDD VSS BUF_X1
X_3953_ net695 src_addr[116] VDD VSS BUF_X1
X_3954_ net696 src_addr[117] VDD VSS BUF_X1
X_3955_ net697 src_addr[118] VDD VSS BUF_X1
X_3956_ net698 src_addr[119] VDD VSS BUF_X1
X_3957_ net699 src_addr[120] VDD VSS BUF_X1
X_3958_ net700 src_addr[121] VDD VSS BUF_X1
X_3959_ net701 src_addr[122] VDD VSS BUF_X1
X_3960_ net702 src_addr[123] VDD VSS BUF_X1
X_3961_ net703 src_addr[124] VDD VSS BUF_X1
X_3962_ net704 src_addr[125] VDD VSS BUF_X1
X_3963_ net705 src_addr[126] VDD VSS BUF_X1
X_3964_ net706 src_addr[127] VDD VSS BUF_X1
Xactive_channel_count\[0\]$_SDFF_PN0_ _0024_ clknet_4_6_0_clk
+ active_channel_count\[0\] _1861_ VDD VSS DFF_X2
Xactive_channel_count\[1\]$_SDFF_PN0_ _0025_ clknet_4_7_0_clk
+ active_channel_count\[1\] _1862_ VDD VSS DFF_X1
Xactive_channel_count\[2\]$_SDFF_PN0_ _0026_ clknet_4_7_0_clk
+ active_channel_count\[2\] _1440_ VDD VSS DFF_X1
Xactive_channel_count\[3\]$_SDFF_PN0_ _0027_ clknet_4_7_0_clk
+ active_channel_count\[3\] _1439_ VDD VSS DFF_X1
Xchannel_busy\[0\]$_SDFF_PN0_ _0028_ clknet_4_7_0_clk net138
+ _1438_ VDD VSS DFF_X2
Xchannel_busy\[1\]$_SDFF_PN0_ _0029_ clknet_4_0_0_clk net139
+ _1437_ VDD VSS DFF_X2
Xchannel_busy\[2\]$_SDFF_PN0_ _0030_ clknet_4_15_0_clk net140
+ _1436_ VDD VSS DFF_X2
Xchannel_busy\[3\]$_SDFF_PN0_ _0031_ clknet_4_8_0_clk net141
+ _1435_ VDD VSS DFF_X2
Xchannel_done\[0\]$_SDFF_PN0_ _0032_ clknet_4_7_0_clk net142
+ _1434_ VDD VSS DFF_X1
Xchannel_done\[1\]$_SDFF_PN0_ _0033_ clknet_4_0_0_clk net143
+ _1433_ VDD VSS DFF_X1
Xchannel_done\[2\]$_SDFF_PN0_ _0034_ clknet_4_9_0_clk net144
+ _1432_ VDD VSS DFF_X2
Xchannel_done\[3\]$_SDFF_PN0_ _0035_ clknet_4_10_0_clk net145
+ _1441_ VDD VSS DFF_X2
Xchannel_state\[0\]\[0\]$_DFF_P_ _0004_ clknet_4_7_0_clk channel_state\[0\]\[0\]
+ _1442_ VDD VSS DFF_X1
Xchannel_state\[0\]\[1\]$_DFF_P_ _0005_ clknet_4_7_0_clk channel_state\[0\]\[1\]
+ _1443_ VDD VSS DFF_X1
Xchannel_state\[0\]\[2\]$_DFF_P_ _0006_ clknet_4_7_0_clk channel_state\[0\]\[2\]
+ _1444_ VDD VSS DFF_X1
Xchannel_state\[0\]\[3\]$_DFF_P_ _0007_ clknet_4_7_0_clk channel_state\[0\]\[3\]
+ _1445_ VDD VSS DFF_X1
Xchannel_state\[0\]\[4\]$_DFF_P_ _0008_ clknet_4_7_0_clk channel_state\[0\]\[4\]
+ _1446_ VDD VSS DFF_X1
Xchannel_state\[0\]\[5\]$_DFF_P_ _0000_ clknet_4_7_0_clk channel_state\[0\]\[5\]
+ _1447_ VDD VSS DFF_X1
Xchannel_state\[1\]\[0\]$_DFF_P_ _0009_ clknet_4_3_0_clk channel_state\[1\]\[0\]
+ _1448_ VDD VSS DFF_X1
Xchannel_state\[1\]\[1\]$_DFF_P_ _0010_ clknet_4_2_0_clk channel_state\[1\]\[1\]
+ _1449_ VDD VSS DFF_X2
Xchannel_state\[1\]\[2\]$_DFF_P_ _0011_ clknet_4_3_0_clk channel_state\[1\]\[2\]
+ _1450_ VDD VSS DFF_X1
Xchannel_state\[1\]\[3\]$_DFF_P_ _0012_ clknet_4_0_0_clk channel_state\[1\]\[3\]
+ _1451_ VDD VSS DFF_X1
Xchannel_state\[1\]\[4\]$_DFF_P_ _0013_ clknet_4_3_0_clk channel_state\[1\]\[4\]
+ _1452_ VDD VSS DFF_X1
Xchannel_state\[1\]\[5\]$_DFF_P_ _0001_ clknet_4_3_0_clk channel_state\[1\]\[5\]
+ _1453_ VDD VSS DFF_X1
Xchannel_state\[2\]\[0\]$_DFF_P_ _0014_ clknet_4_6_0_clk channel_state\[2\]\[0\]
+ _1454_ VDD VSS DFF_X1
Xchannel_state\[2\]\[1\]$_DFF_P_ _0015_ clknet_4_9_0_clk channel_state\[2\]\[1\]
+ _1455_ VDD VSS DFF_X1
Xchannel_state\[2\]\[2\]$_DFF_P_ _0016_ clknet_4_6_0_clk channel_state\[2\]\[2\]
+ _1456_ VDD VSS DFF_X2
Xchannel_state\[2\]\[3\]$_DFF_P_ _0017_ clknet_4_15_0_clk
+ channel_state\[2\]\[3\] _1457_ VDD VSS DFF_X2
Xchannel_state\[2\]\[4\]$_DFF_P_ _0018_ clknet_4_9_0_clk channel_state\[2\]\[4\]
+ _1458_ VDD VSS DFF_X2
Xchannel_state\[2\]\[5\]$_DFF_P_ _0002_ clknet_4_6_0_clk channel_state\[2\]\[5\]
+ _1459_ VDD VSS DFF_X1
Xchannel_state\[3\]\[0\]$_DFF_P_ _0019_ clknet_4_8_0_clk channel_state\[3\]\[0\]
+ _1460_ VDD VSS DFF_X1
Xchannel_state\[3\]\[1\]$_DFF_P_ _0020_ clknet_4_8_0_clk channel_state\[3\]\[1\]
+ _1461_ VDD VSS DFF_X1
Xchannel_state\[3\]\[2\]$_DFF_P_ _0021_ clknet_4_8_0_clk channel_state\[3\]\[2\]
+ _1462_ VDD VSS DFF_X1
Xchannel_state\[3\]\[3\]$_DFF_P_ _0022_ clknet_4_8_0_clk channel_state\[3\]\[3\]
+ _1463_ VDD VSS DFF_X1
Xchannel_state\[3\]\[4\]$_DFF_P_ _0023_ clknet_4_8_0_clk channel_state\[3\]\[4\]
+ _1464_ VDD VSS DFF_X1
Xchannel_state\[3\]\[5\]$_DFF_P_ _0003_ clknet_4_8_0_clk channel_state\[3\]\[5\]
+ _1431_ VDD VSS DFF_X1
Xdebug_active_channels\[0\]$_SDFF_PN0_ _0036_ clknet_4_7_0_clk
+ net146 _1430_ VDD VSS DFF_X1
Xdebug_active_channels\[1\]$_SDFF_PN0_ _0037_ clknet_4_7_0_clk
+ net147 _1429_ VDD VSS DFF_X1
Xdebug_active_channels\[2\]$_SDFF_PN0_ _0038_ clknet_4_7_0_clk
+ net148 _1428_ VDD VSS DFF_X1
Xdebug_active_channels\[3\]$_SDFF_PN0_ _0039_ clknet_4_7_0_clk
+ net149 _1427_ VDD VSS DFF_X1
Xdebug_has_active_channels$_SDFF_PN0_ _0040_ clknet_4_7_0_clk
+ net150 _1426_ VDD VSS DFF_X1
Xdst_write\[0\]$_SDFFE_PN0P_ _0041_ clknet_4_7_0_clk net151
+ _1425_ VDD VSS DFF_X1
Xdst_write\[1\]$_SDFFE_PN0P_ _0042_ clknet_4_3_0_clk net152
+ _1424_ VDD VSS DFF_X2
Xdst_write\[2\]$_SDFFE_PN0P_ _0043_ clknet_4_6_0_clk net153
+ _1423_ VDD VSS DFF_X1
Xdst_write\[3\]$_SDFFE_PN0P_ _0044_ clknet_4_9_0_clk net154
+ _1422_ VDD VSS DFF_X2
Xsrc_read\[0\]$_SDFF_PN0_ _0045_ clknet_4_7_0_clk net155 _1421_
+ VDD VSS DFF_X1
Xsrc_read\[1\]$_SDFF_PN0_ _0046_ clknet_4_2_0_clk net156 _1420_
+ VDD VSS DFF_X1
Xsrc_read\[2\]$_SDFF_PN0_ _0047_ clknet_4_6_0_clk net157 _1419_
+ VDD VSS DFF_X1
Xsrc_read\[3\]$_SDFF_PN0_ _0048_ clknet_4_7_0_clk net158 _1418_
+ VDD VSS DFF_X1
Xsrc_rready\[0\]$_SDFFE_PN0P_ _0049_ clknet_4_7_0_clk net159
+ _1417_ VDD VSS DFF_X1
Xsrc_rready\[1\]$_SDFFE_PN0P_ _0050_ clknet_4_3_0_clk net160
+ _1416_ VDD VSS DFF_X2
Xsrc_rready\[2\]$_SDFFE_PN0P_ _0051_ clknet_4_6_0_clk net161
+ _1415_ VDD VSS DFF_X1
Xsrc_rready\[3\]$_SDFFE_PN0P_ _0052_ clknet_4_8_0_clk net162
+ _1414_ VDD VSS DFF_X2
Xtransfer_count\[0\]\[0\]$_SDFF_PN0_ _0053_ clknet_4_5_0_clk
+ transfer_count\[0\]\[0\] _1759_ VDD VSS DFF_X2
Xtransfer_count\[0\]\[10\]$_SDFF_PN0_ _0054_ clknet_4_5_0_clk
+ transfer_count\[0\]\[10\] _1413_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[11\]$_SDFF_PN0_ _0055_ clknet_4_5_0_clk
+ transfer_count\[0\]\[11\] _1412_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[12\]$_SDFF_PN0_ _0056_ clknet_4_4_0_clk
+ transfer_count\[0\]\[12\] _1411_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[13\]$_SDFF_PN0_ _0057_ clknet_4_4_0_clk
+ transfer_count\[0\]\[13\] _1410_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[14\]$_SDFF_PN0_ _0058_ clknet_4_5_0_clk
+ transfer_count\[0\]\[14\] _1409_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[15\]$_SDFF_PN0_ _0059_ clknet_4_5_0_clk
+ transfer_count\[0\]\[15\] _1408_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[16\]$_SDFF_PN0_ _0060_ clknet_4_4_0_clk
+ transfer_count\[0\]\[16\] _1407_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[17\]$_SDFF_PN0_ _0061_ clknet_4_4_0_clk
+ transfer_count\[0\]\[17\] _1406_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[18\]$_SDFF_PN0_ _0062_ clknet_4_4_0_clk
+ transfer_count\[0\]\[18\] _1405_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[19\]$_SDFF_PN0_ _0063_ clknet_4_4_0_clk
+ transfer_count\[0\]\[19\] _1404_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[1\]$_SDFF_PN0_ _0064_ clknet_4_5_0_clk
+ transfer_count\[0\]\[1\] _1403_ VDD VSS DFF_X2
Xtransfer_count\[0\]\[20\]$_SDFF_PN0_ _0065_ clknet_4_4_0_clk
+ transfer_count\[0\]\[20\] _1402_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[21\]$_SDFF_PN0_ _0066_ clknet_4_4_0_clk
+ transfer_count\[0\]\[21\] _1401_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[22\]$_SDFF_PN0_ _0067_ clknet_4_4_0_clk
+ transfer_count\[0\]\[22\] _1400_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[23\]$_SDFF_PN0_ _0068_ clknet_4_6_0_clk
+ transfer_count\[0\]\[23\] _1399_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[24\]$_SDFF_PN0_ _0069_ clknet_4_6_0_clk
+ transfer_count\[0\]\[24\] _1398_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[25\]$_SDFF_PN0_ _0070_ clknet_4_6_0_clk
+ transfer_count\[0\]\[25\] _1397_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[26\]$_SDFF_PN0_ _0071_ clknet_4_6_0_clk
+ transfer_count\[0\]\[26\] _1396_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[27\]$_SDFF_PN0_ _0072_ clknet_4_6_0_clk
+ transfer_count\[0\]\[27\] _1395_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[28\]$_SDFF_PN0_ _0073_ clknet_4_6_0_clk
+ transfer_count\[0\]\[28\] _1394_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[29\]$_SDFF_PN0_ _0074_ clknet_4_6_0_clk
+ transfer_count\[0\]\[29\] _1393_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[2\]$_SDFF_PN0_ _0075_ clknet_4_5_0_clk
+ transfer_count\[0\]\[2\] _1392_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[30\]$_SDFF_PN0_ _0076_ clknet_4_7_0_clk
+ transfer_count\[0\]\[30\] _1391_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[31\]$_SDFF_PN0_ _0077_ clknet_4_4_0_clk
+ transfer_count\[0\]\[31\] _1390_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[3\]$_SDFF_PN0_ _0078_ clknet_4_5_0_clk
+ transfer_count\[0\]\[3\] _1389_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[4\]$_SDFF_PN0_ _0079_ clknet_4_5_0_clk
+ transfer_count\[0\]\[4\] _1388_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[5\]$_SDFF_PN0_ _0080_ clknet_4_5_0_clk
+ transfer_count\[0\]\[5\] _1387_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[6\]$_SDFF_PN0_ _0081_ clknet_4_5_0_clk
+ transfer_count\[0\]\[6\] _1386_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[7\]$_SDFF_PN0_ _0082_ clknet_4_5_0_clk
+ transfer_count\[0\]\[7\] _1385_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[8\]$_SDFF_PN0_ _0083_ clknet_4_5_0_clk
+ transfer_count\[0\]\[8\] _1384_ VDD VSS DFF_X1
Xtransfer_count\[0\]\[9\]$_SDFF_PN0_ _0084_ clknet_4_5_0_clk
+ transfer_count\[0\]\[9\] _1383_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[0\]$_SDFF_PN0_ _0085_ clknet_4_1_0_clk
+ transfer_count\[1\]\[0\] _1660_ VDD VSS DFF_X2
Xtransfer_count\[1\]\[10\]$_SDFF_PN0_ _0086_ clknet_4_2_0_clk
+ transfer_count\[1\]\[10\] _1382_ VDD VSS DFF_X2
Xtransfer_count\[1\]\[11\]$_SDFF_PN0_ _0087_ clknet_4_0_0_clk
+ transfer_count\[1\]\[11\] _1381_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[12\]$_SDFF_PN0_ _0088_ clknet_4_3_0_clk
+ transfer_count\[1\]\[12\] _1380_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[13\]$_SDFF_PN0_ _0089_ clknet_4_3_0_clk
+ transfer_count\[1\]\[13\] _1379_ VDD VSS DFF_X2
Xtransfer_count\[1\]\[14\]$_SDFF_PN0_ _0090_ clknet_4_1_0_clk
+ transfer_count\[1\]\[14\] _1378_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[15\]$_SDFF_PN0_ _0091_ clknet_4_0_0_clk
+ transfer_count\[1\]\[15\] _1377_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[16\]$_SDFF_PN0_ _0092_ clknet_4_0_0_clk
+ transfer_count\[1\]\[16\] _1376_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[17\]$_SDFF_PN0_ _0093_ clknet_4_0_0_clk
+ transfer_count\[1\]\[17\] _1375_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[18\]$_SDFF_PN0_ _0094_ clknet_4_3_0_clk
+ transfer_count\[1\]\[18\] _1374_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[19\]$_SDFF_PN0_ _0095_ clknet_4_3_0_clk
+ transfer_count\[1\]\[19\] _1373_ VDD VSS DFF_X2
Xtransfer_count\[1\]\[1\]$_SDFF_PN0_ _0096_ clknet_4_1_0_clk
+ transfer_count\[1\]\[1\] _1372_ VDD VSS DFF_X2
Xtransfer_count\[1\]\[20\]$_SDFF_PN0_ _0097_ clknet_4_3_0_clk
+ transfer_count\[1\]\[20\] _1371_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[21\]$_SDFF_PN0_ _0098_ clknet_4_0_0_clk
+ transfer_count\[1\]\[21\] _1370_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[22\]$_SDFF_PN0_ _0099_ clknet_4_1_0_clk
+ transfer_count\[1\]\[22\] _1369_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[23\]$_SDFF_PN0_ _0100_ clknet_4_2_0_clk
+ transfer_count\[1\]\[23\] _1368_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[24\]$_SDFF_PN0_ _0101_ clknet_4_2_0_clk
+ transfer_count\[1\]\[24\] _1367_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[25\]$_SDFF_PN0_ _0102_ clknet_4_1_0_clk
+ transfer_count\[1\]\[25\] _1366_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[26\]$_SDFF_PN0_ _0103_ clknet_4_2_0_clk
+ transfer_count\[1\]\[26\] _1365_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[27\]$_SDFF_PN0_ _0104_ clknet_4_3_0_clk
+ transfer_count\[1\]\[27\] _1364_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[28\]$_SDFF_PN0_ _0105_ clknet_4_2_0_clk
+ transfer_count\[1\]\[28\] _1363_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[29\]$_SDFF_PN0_ _0106_ clknet_4_3_0_clk
+ transfer_count\[1\]\[29\] _1362_ VDD VSS DFF_X2
Xtransfer_count\[1\]\[2\]$_SDFF_PN0_ _0107_ clknet_4_1_0_clk
+ transfer_count\[1\]\[2\] _1361_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[30\]$_SDFF_PN0_ _0108_ clknet_4_3_0_clk
+ transfer_count\[1\]\[30\] _1360_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[31\]$_SDFF_PN0_ _0109_ clknet_4_1_0_clk
+ transfer_count\[1\]\[31\] _1359_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[3\]$_SDFF_PN0_ _0110_ clknet_4_2_0_clk
+ transfer_count\[1\]\[3\] _1358_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[4\]$_SDFF_PN0_ _0111_ clknet_4_2_0_clk
+ transfer_count\[1\]\[4\] _1357_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[5\]$_SDFF_PN0_ _0112_ clknet_4_2_0_clk
+ transfer_count\[1\]\[5\] _1356_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[6\]$_SDFF_PN0_ _0113_ clknet_4_1_0_clk
+ transfer_count\[1\]\[6\] _1355_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[7\]$_SDFF_PN0_ _0114_ clknet_4_1_0_clk
+ transfer_count\[1\]\[7\] _1354_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[8\]$_SDFF_PN0_ _0115_ clknet_4_1_0_clk
+ transfer_count\[1\]\[8\] _1353_ VDD VSS DFF_X1
Xtransfer_count\[1\]\[9\]$_SDFF_PN0_ _0116_ clknet_4_2_0_clk
+ transfer_count\[1\]\[9\] _1352_ VDD VSS DFF_X2
Xtransfer_count\[2\]\[0\]$_SDFF_PN0_ _0117_ clknet_4_12_0_clk
+ transfer_count\[2\]\[0\] _1466_ VDD VSS DFF_X2
Xtransfer_count\[2\]\[10\]$_SDFF_PN0_ _0118_ clknet_4_14_0_clk
+ transfer_count\[2\]\[10\] _1351_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[11\]$_SDFF_PN0_ _0119_ clknet_4_13_0_clk
+ transfer_count\[2\]\[11\] _1350_ VDD VSS DFF_X2
Xtransfer_count\[2\]\[12\]$_SDFF_PN0_ _0120_ clknet_4_15_0_clk
+ transfer_count\[2\]\[12\] _1349_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[13\]$_SDFF_PN0_ _0121_ clknet_4_14_0_clk
+ transfer_count\[2\]\[13\] _1348_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[14\]$_SDFF_PN0_ _0122_ clknet_4_13_0_clk
+ transfer_count\[2\]\[14\] _1347_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[15\]$_SDFF_PN0_ _0123_ clknet_4_13_0_clk
+ transfer_count\[2\]\[15\] _1346_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[16\]$_SDFF_PN0_ _0124_ clknet_4_14_0_clk
+ transfer_count\[2\]\[16\] _1345_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[17\]$_SDFF_PN0_ _0125_ clknet_4_14_0_clk
+ transfer_count\[2\]\[17\] _1344_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[18\]$_SDFF_PN0_ _0126_ clknet_4_13_0_clk
+ transfer_count\[2\]\[18\] _1343_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[19\]$_SDFF_PN0_ _0127_ clknet_4_14_0_clk
+ transfer_count\[2\]\[19\] _1342_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[1\]$_SDFF_PN0_ _0128_ clknet_4_12_0_clk
+ transfer_count\[2\]\[1\] _1341_ VDD VSS DFF_X2
Xtransfer_count\[2\]\[20\]$_SDFF_PN0_ _0129_ clknet_4_14_0_clk
+ transfer_count\[2\]\[20\] _1340_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[21\]$_SDFF_PN0_ _0130_ clknet_4_15_0_clk
+ transfer_count\[2\]\[21\] _1339_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[22\]$_SDFF_PN0_ _0131_ clknet_4_14_0_clk
+ transfer_count\[2\]\[22\] _1338_ VDD VSS DFF_X2
Xtransfer_count\[2\]\[23\]$_SDFF_PN0_ _0132_ clknet_4_15_0_clk
+ transfer_count\[2\]\[23\] _1337_ VDD VSS DFF_X2
Xtransfer_count\[2\]\[24\]$_SDFF_PN0_ _0133_ clknet_4_14_0_clk
+ transfer_count\[2\]\[24\] _1336_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[25\]$_SDFF_PN0_ _0134_ clknet_4_15_0_clk
+ transfer_count\[2\]\[25\] _1335_ VDD VSS DFF_X2
Xtransfer_count\[2\]\[26\]$_SDFF_PN0_ _0135_ clknet_4_15_0_clk
+ transfer_count\[2\]\[26\] _1334_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[27\]$_SDFF_PN0_ _0136_ clknet_4_13_0_clk
+ transfer_count\[2\]\[27\] _1333_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[28\]$_SDFF_PN0_ _0137_ clknet_4_15_0_clk
+ transfer_count\[2\]\[28\] _1332_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[29\]$_SDFF_PN0_ _0138_ clknet_4_15_0_clk
+ transfer_count\[2\]\[29\] _1331_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[2\]$_SDFF_PN0_ _0139_ clknet_4_12_0_clk
+ transfer_count\[2\]\[2\] _1330_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[30\]$_SDFF_PN0_ _0140_ clknet_4_15_0_clk
+ transfer_count\[2\]\[30\] _1329_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[31\]$_SDFF_PN0_ _0141_ clknet_4_15_0_clk
+ transfer_count\[2\]\[31\] _1328_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[3\]$_SDFF_PN0_ _0142_ clknet_4_12_0_clk
+ transfer_count\[2\]\[3\] _1327_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[4\]$_SDFF_PN0_ _0143_ clknet_4_12_0_clk
+ transfer_count\[2\]\[4\] _1326_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[5\]$_SDFF_PN0_ _0144_ clknet_4_12_0_clk
+ transfer_count\[2\]\[5\] _1325_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[6\]$_SDFF_PN0_ _0145_ clknet_4_12_0_clk
+ transfer_count\[2\]\[6\] _1324_ VDD VSS DFF_X2
Xtransfer_count\[2\]\[7\]$_SDFF_PN0_ _0146_ clknet_4_12_0_clk
+ transfer_count\[2\]\[7\] _1323_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[8\]$_SDFF_PN0_ _0147_ clknet_4_15_0_clk
+ transfer_count\[2\]\[8\] _1322_ VDD VSS DFF_X1
Xtransfer_count\[2\]\[9\]$_SDFF_PN0_ _0148_ clknet_4_13_0_clk
+ transfer_count\[2\]\[9\] _1321_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[0\]$_SDFF_PN0_ _0149_ clknet_4_8_0_clk
+ transfer_count\[3\]\[0\] _1763_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[10\]$_SDFF_PN0_ _0150_ clknet_4_11_0_clk
+ transfer_count\[3\]\[10\] _1320_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[11\]$_SDFF_PN0_ _0151_ clknet_4_11_0_clk
+ transfer_count\[3\]\[11\] _1319_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[12\]$_SDFF_PN0_ _0152_ clknet_4_11_0_clk
+ transfer_count\[3\]\[12\] _1318_ VDD VSS DFF_X2
Xtransfer_count\[3\]\[13\]$_SDFF_PN0_ _0153_ clknet_4_11_0_clk
+ transfer_count\[3\]\[13\] _1317_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[14\]$_SDFF_PN0_ _0154_ clknet_4_10_0_clk
+ transfer_count\[3\]\[14\] _1316_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[15\]$_SDFF_PN0_ _0155_ clknet_4_11_0_clk
+ transfer_count\[3\]\[15\] _1315_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[16\]$_SDFF_PN0_ _0156_ clknet_4_11_0_clk
+ transfer_count\[3\]\[16\] _1314_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[17\]$_SDFF_PN0_ _0157_ clknet_4_10_0_clk
+ transfer_count\[3\]\[17\] _1313_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[18\]$_SDFF_PN0_ _0158_ clknet_4_10_0_clk
+ transfer_count\[3\]\[18\] _1312_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[19\]$_SDFF_PN0_ _0159_ clknet_4_10_0_clk
+ transfer_count\[3\]\[19\] _1311_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[1\]$_SDFF_PN0_ _0160_ clknet_4_8_0_clk
+ transfer_count\[3\]\[1\] _1310_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[20\]$_SDFF_PN0_ _0161_ clknet_4_10_0_clk
+ transfer_count\[3\]\[20\] _1309_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[21\]$_SDFF_PN0_ _0162_ clknet_4_10_0_clk
+ transfer_count\[3\]\[21\] _1308_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[22\]$_SDFF_PN0_ _0163_ clknet_4_10_0_clk
+ transfer_count\[3\]\[22\] _1307_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[23\]$_SDFF_PN0_ _0164_ clknet_4_10_0_clk
+ transfer_count\[3\]\[23\] _1306_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[24\]$_SDFF_PN0_ _0165_ clknet_4_10_0_clk
+ transfer_count\[3\]\[24\] _1305_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[25\]$_SDFF_PN0_ _0166_ clknet_4_10_0_clk
+ transfer_count\[3\]\[25\] _1304_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[26\]$_SDFF_PN0_ _0167_ clknet_4_10_0_clk
+ transfer_count\[3\]\[26\] _1303_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[27\]$_SDFF_PN0_ _0168_ clknet_4_10_0_clk
+ transfer_count\[3\]\[27\] _1302_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[28\]$_SDFF_PN0_ _0169_ clknet_4_10_0_clk
+ transfer_count\[3\]\[28\] _1301_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[29\]$_SDFF_PN0_ _0170_ clknet_4_10_0_clk
+ transfer_count\[3\]\[29\] _1300_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[2\]$_SDFF_PN0_ _0171_ clknet_4_9_0_clk
+ transfer_count\[3\]\[2\] _1299_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[30\]$_SDFF_PN0_ _0172_ clknet_4_10_0_clk
+ transfer_count\[3\]\[30\] _1298_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[31\]$_SDFF_PN0_ _0173_ clknet_4_10_0_clk
+ transfer_count\[3\]\[31\] _1297_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[3\]$_SDFF_PN0_ _0174_ clknet_4_11_0_clk
+ transfer_count\[3\]\[3\] _1296_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[4\]$_SDFF_PN0_ _0175_ clknet_4_11_0_clk
+ transfer_count\[3\]\[4\] _1295_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[5\]$_SDFF_PN0_ _0176_ clknet_4_9_0_clk
+ transfer_count\[3\]\[5\] _1294_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[6\]$_SDFF_PN0_ _0177_ clknet_4_9_0_clk
+ transfer_count\[3\]\[6\] _1293_ VDD VSS DFF_X2
Xtransfer_count\[3\]\[7\]$_SDFF_PN0_ _0178_ clknet_4_9_0_clk
+ transfer_count\[3\]\[7\] _1292_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[8\]$_SDFF_PN0_ _0179_ clknet_4_11_0_clk
+ transfer_count\[3\]\[8\] _1291_ VDD VSS DFF_X1
Xtransfer_count\[3\]\[9\]$_SDFF_PN0_ _0180_ clknet_4_11_0_clk
+ transfer_count\[3\]\[9\] _1290_ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Right_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Right_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Right_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Right_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Right_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Right_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Right_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Right_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Right_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Right_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Right_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Right_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Right_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Right_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Right_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Right_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Right_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Right_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Right_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Right_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Right_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Right_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Right_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Right_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Right_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Right_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Right_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Right_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Right_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Right_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Right_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Right_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Right_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Right_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Right_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Right_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Right_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Right_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Right_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Right_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Right_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Right_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Right_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Right_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Right_89 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Right_90 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Right_91 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Right_92 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Right_93 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Right_94 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Right_95 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Right_96 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Right_97 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Right_98 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Right_99 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Right_100 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Right_101 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Right_102 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Right_103 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Right_104 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Right_105 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Right_106 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Right_107 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Right_108 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Right_109 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Right_110 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Right_111 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Right_112 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Right_113 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Right_114 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Right_115 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Right_116 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Right_117 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Right_118 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Right_119 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Right_120 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Right_121 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Right_122 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Right_123 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Right_124 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Right_125 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Right_126 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Right_127 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Right_128 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Right_129 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Right_130 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Right_131 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Right_132 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_133_Right_133 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_134_Right_134 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_135_Right_135 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_136_Right_136 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_137_Right_137 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_138_Right_138 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_139_Right_139 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_140_Right_140 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_141_Right_141 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_142_Right_142 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_143_Right_143 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_144_Right_144 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_145_Right_145 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_146_Right_146 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_147_Right_147 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_148_Right_148 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_149_Right_149 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_150_Right_150 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_151_Right_151 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_152_Right_152 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_153_Right_153 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_154_Right_154 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_155_Right_155 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_156_Right_156 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_157_Right_157 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_158_Right_158 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_159_Right_159 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_160_Right_160 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_161_Right_161 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_162_Right_162 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_163_Right_163 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_164_Right_164 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_165_Right_165 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_166_Right_166 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_167_Right_167 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_168_Right_168 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_169_Right_169 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_170_Right_170 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_171_Right_171 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_172_Right_172 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_173_Right_173 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_174_Right_174 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_175_Right_175 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_176_Right_176 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_177_Right_177 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_178_Right_178 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_179_Right_179 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_180 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_181 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_182 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_183 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_184 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_185 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_186 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_187 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_188 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_189 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_190 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_191 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_192 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_193 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_194 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_195 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_196 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_197 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_198 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_199 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_200 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_201 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_202 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_203 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_204 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_205 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_206 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_207 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_208 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_209 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_210 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_211 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_212 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_213 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_214 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_215 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_216 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_217 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_218 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_219 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_220 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_221 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_222 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_223 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_224 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Left_225 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Left_226 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Left_227 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Left_228 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Left_229 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Left_230 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Left_231 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Left_232 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Left_233 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Left_234 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Left_235 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Left_236 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Left_237 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Left_238 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Left_239 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Left_240 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Left_241 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Left_242 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Left_243 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Left_244 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Left_245 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Left_246 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Left_247 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Left_248 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Left_249 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Left_250 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Left_251 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Left_252 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Left_253 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Left_254 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Left_255 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Left_256 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Left_257 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Left_258 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Left_259 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Left_260 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Left_261 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Left_262 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Left_263 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Left_264 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Left_265 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Left_266 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Left_267 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Left_268 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Left_269 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Left_270 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Left_271 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Left_272 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Left_273 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Left_274 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Left_275 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Left_276 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Left_277 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Left_278 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Left_279 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Left_280 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Left_281 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Left_282 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Left_283 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Left_284 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Left_285 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Left_286 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Left_287 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Left_288 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Left_289 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Left_290 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Left_291 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Left_292 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Left_293 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Left_294 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Left_295 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Left_296 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Left_297 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Left_298 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Left_299 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Left_300 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Left_301 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Left_302 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Left_303 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Left_304 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Left_305 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Left_306 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Left_307 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Left_308 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Left_309 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Left_310 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Left_311 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Left_312 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_133_Left_313 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_134_Left_314 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_135_Left_315 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_136_Left_316 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_137_Left_317 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_138_Left_318 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_139_Left_319 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_140_Left_320 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_141_Left_321 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_142_Left_322 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_143_Left_323 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_144_Left_324 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_145_Left_325 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_146_Left_326 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_147_Left_327 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_148_Left_328 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_149_Left_329 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_150_Left_330 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_151_Left_331 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_152_Left_332 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_153_Left_333 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_154_Left_334 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_155_Left_335 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_156_Left_336 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_157_Left_337 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_158_Left_338 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_159_Left_339 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_160_Left_340 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_161_Left_341 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_162_Left_342 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_163_Left_343 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_164_Left_344 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_165_Left_345 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_166_Left_346 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_167_Left_347 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_168_Left_348 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_169_Left_349 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_170_Left_350 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_171_Left_351 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_172_Left_352 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_173_Left_353 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_174_Left_354 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_175_Left_355 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_176_Left_356 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_177_Left_357 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_178_Left_358 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_179_Left_359 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_360 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_361 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_1_362 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_2_363 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_3_364 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_4_365 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_5_366 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_6_367 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_7_368 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_8_369 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_9_370 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_10_371 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_11_372 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_12_373 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_13_374 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_14_375 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_15_376 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_16_377 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_17_378 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_18_379 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_19_380 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_20_381 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_21_382 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_22_383 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_23_384 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_24_385 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_25_386 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_26_387 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_27_388 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_28_389 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_29_390 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_30_391 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_31_392 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_32_393 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_33_394 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_34_395 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_35_396 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_36_397 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_37_398 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_38_399 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_39_400 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_40_401 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_41_402 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_42_403 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_43_404 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_44_405 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_45_406 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_46_407 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_47_408 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_48_409 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_49_410 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_50_411 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_51_412 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_52_413 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_53_414 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_54_415 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_55_416 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_56_417 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_57_418 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_58_419 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_59_420 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_60_421 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_61_422 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_62_423 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_63_424 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_64_425 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_65_426 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_66_427 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_67_428 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_68_429 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_69_430 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_70_431 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_71_432 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_72_433 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_73_434 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_74_435 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_75_436 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_76_437 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_77_438 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_78_439 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_79_440 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_80_441 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_81_442 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_82_443 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_83_444 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_84_445 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_85_446 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_86_447 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_87_448 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_88_449 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_89_450 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_90_451 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_91_452 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_92_453 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_93_454 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_94_455 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_95_456 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_96_457 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_97_458 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_98_459 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_99_460 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_100_461 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_101_462 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_102_463 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_103_464 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_104_465 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_105_466 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_106_467 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_107_468 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_108_469 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_109_470 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_110_471 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_111_472 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_112_473 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_113_474 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_114_475 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_115_476 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_116_477 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_117_478 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_118_479 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_119_480 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_120_481 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_121_482 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_122_483 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_123_484 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_124_485 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_125_486 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_126_487 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_127_488 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_128_489 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_129_490 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_130_491 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_131_492 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_132_493 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_133_494 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_134_495 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_135_496 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_136_497 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_137_498 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_138_499 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_139_500 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_140_501 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_141_502 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_142_503 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_143_504 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_144_505 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_145_506 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_146_507 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_147_508 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_148_509 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_149_510 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_150_511 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_151_512 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_152_513 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_153_514 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_154_515 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_155_516 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_156_517 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_157_518 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_158_519 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_159_520 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_160_521 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_161_522 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_162_523 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_163_524 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_164_525 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_165_526 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_166_527 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_167_528 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_168_529 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_169_530 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_170_531 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_171_532 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_172_533 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_173_534 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_174_535 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_175_536 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_176_537 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_177_538 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_178_539 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_179_540 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_179_541 VDD VSS TAPCELL_X1
Xinput1 channel_length[0] net1 VDD VSS BUF_X1
Xinput2 channel_length[100] net2 VDD VSS BUF_X2
Xinput3 channel_length[101] net3 VDD VSS BUF_X2
Xinput4 channel_length[102] net4 VDD VSS BUF_X2
Xinput5 channel_length[103] net5 VDD VSS BUF_X2
Xinput6 channel_length[104] net6 VDD VSS BUF_X2
Xinput7 channel_length[105] net7 VDD VSS BUF_X2
Xinput8 channel_length[106] net8 VDD VSS BUF_X2
Xinput9 channel_length[107] net9 VDD VSS BUF_X2
Xinput10 channel_length[108] net10 VDD VSS BUF_X2
Xinput11 channel_length[109] net11 VDD VSS CLKBUF_X2
Xinput12 channel_length[10] net12 VDD VSS BUF_X1
Xinput13 channel_length[110] net13 VDD VSS CLKBUF_X2
Xinput14 channel_length[111] net14 VDD VSS BUF_X2
Xinput15 channel_length[112] net15 VDD VSS BUF_X1
Xinput16 channel_length[113] net16 VDD VSS BUF_X1
Xinput17 channel_length[114] net17 VDD VSS BUF_X1
Xinput18 channel_length[115] net18 VDD VSS BUF_X1
Xinput19 channel_length[116] net19 VDD VSS CLKBUF_X2
Xinput20 channel_length[117] net20 VDD VSS CLKBUF_X2
Xinput21 channel_length[118] net21 VDD VSS CLKBUF_X2
Xinput22 channel_length[119] net22 VDD VSS CLKBUF_X2
Xinput23 channel_length[11] net23 VDD VSS BUF_X1
Xinput24 channel_length[120] net24 VDD VSS BUF_X2
Xinput25 channel_length[121] net25 VDD VSS BUF_X2
Xinput26 channel_length[122] net26 VDD VSS BUF_X2
Xinput27 channel_length[123] net27 VDD VSS BUF_X2
Xinput28 channel_length[124] net28 VDD VSS CLKBUF_X2
Xinput29 channel_length[125] net29 VDD VSS CLKBUF_X2
Xinput30 channel_length[126] net30 VDD VSS CLKBUF_X2
Xinput31 channel_length[127] net31 VDD VSS CLKBUF_X2
Xinput32 channel_length[12] net32 VDD VSS BUF_X1
Xinput33 channel_length[13] net33 VDD VSS BUF_X1
Xinput34 channel_length[14] net34 VDD VSS BUF_X1
Xinput35 channel_length[15] net35 VDD VSS BUF_X1
Xinput36 channel_length[16] net36 VDD VSS BUF_X1
Xinput37 channel_length[17] net37 VDD VSS BUF_X1
Xinput38 channel_length[18] net38 VDD VSS BUF_X1
Xinput39 channel_length[19] net39 VDD VSS BUF_X1
Xinput40 channel_length[1] net40 VDD VSS BUF_X1
Xinput41 channel_length[20] net41 VDD VSS BUF_X1
Xinput42 channel_length[21] net42 VDD VSS BUF_X1
Xinput43 channel_length[22] net43 VDD VSS BUF_X1
Xinput44 channel_length[23] net44 VDD VSS BUF_X1
Xinput45 channel_length[24] net45 VDD VSS BUF_X1
Xinput46 channel_length[25] net46 VDD VSS BUF_X1
Xinput47 channel_length[26] net47 VDD VSS BUF_X1
Xinput48 channel_length[27] net48 VDD VSS BUF_X1
Xinput49 channel_length[28] net49 VDD VSS BUF_X1
Xinput50 channel_length[29] net50 VDD VSS BUF_X1
Xinput51 channel_length[2] net51 VDD VSS BUF_X1
Xinput52 channel_length[30] net52 VDD VSS BUF_X1
Xinput53 channel_length[31] net53 VDD VSS BUF_X1
Xinput54 channel_length[32] net54 VDD VSS BUF_X1
Xinput55 channel_length[33] net55 VDD VSS BUF_X1
Xinput56 channel_length[34] net56 VDD VSS BUF_X1
Xinput57 channel_length[35] net57 VDD VSS BUF_X1
Xinput58 channel_length[36] net58 VDD VSS BUF_X1
Xinput59 channel_length[37] net59 VDD VSS BUF_X1
Xinput60 channel_length[38] net60 VDD VSS BUF_X1
Xinput61 channel_length[39] net61 VDD VSS BUF_X1
Xinput62 channel_length[3] net62 VDD VSS BUF_X1
Xinput63 channel_length[40] net63 VDD VSS BUF_X1
Xinput64 channel_length[41] net64 VDD VSS BUF_X1
Xinput65 channel_length[42] net65 VDD VSS BUF_X1
Xinput66 channel_length[43] net66 VDD VSS BUF_X1
Xinput67 channel_length[44] net67 VDD VSS BUF_X1
Xinput68 channel_length[45] net68 VDD VSS BUF_X1
Xinput69 channel_length[46] net69 VDD VSS BUF_X1
Xinput70 channel_length[47] net70 VDD VSS BUF_X1
Xinput71 channel_length[48] net71 VDD VSS BUF_X1
Xinput72 channel_length[49] net72 VDD VSS BUF_X1
Xinput73 channel_length[4] net73 VDD VSS BUF_X1
Xinput74 channel_length[50] net74 VDD VSS BUF_X1
Xinput75 channel_length[51] net75 VDD VSS BUF_X1
Xinput76 channel_length[52] net76 VDD VSS BUF_X1
Xinput77 channel_length[53] net77 VDD VSS BUF_X1
Xinput78 channel_length[54] net78 VDD VSS BUF_X1
Xinput79 channel_length[55] net79 VDD VSS BUF_X1
Xinput80 channel_length[56] net80 VDD VSS BUF_X1
Xinput81 channel_length[57] net81 VDD VSS BUF_X1
Xinput82 channel_length[58] net82 VDD VSS BUF_X1
Xinput83 channel_length[59] net83 VDD VSS BUF_X1
Xinput84 channel_length[5] net84 VDD VSS BUF_X1
Xinput85 channel_length[60] net85 VDD VSS BUF_X1
Xinput86 channel_length[61] net86 VDD VSS BUF_X1
Xinput87 channel_length[62] net87 VDD VSS BUF_X1
Xinput88 channel_length[63] net88 VDD VSS BUF_X1
Xinput89 channel_length[64] net89 VDD VSS BUF_X1
Xinput90 channel_length[65] net90 VDD VSS BUF_X1
Xinput91 channel_length[66] net91 VDD VSS BUF_X1
Xinput92 channel_length[67] net92 VDD VSS BUF_X1
Xinput93 channel_length[68] net93 VDD VSS BUF_X1
Xinput94 channel_length[69] net94 VDD VSS BUF_X1
Xinput95 channel_length[6] net95 VDD VSS BUF_X1
Xinput96 channel_length[70] net96 VDD VSS BUF_X1
Xinput97 channel_length[71] net97 VDD VSS BUF_X1
Xinput98 channel_length[72] net98 VDD VSS BUF_X1
Xinput99 channel_length[73] net99 VDD VSS BUF_X1
Xinput100 channel_length[74] net100 VDD VSS BUF_X1
Xinput101 channel_length[75] net101 VDD VSS BUF_X1
Xinput102 channel_length[76] net102 VDD VSS BUF_X1
Xinput103 channel_length[77] net103 VDD VSS BUF_X1
Xinput104 channel_length[78] net104 VDD VSS BUF_X1
Xinput105 channel_length[79] net105 VDD VSS BUF_X1
Xinput106 channel_length[7] net106 VDD VSS BUF_X1
Xinput107 channel_length[80] net107 VDD VSS BUF_X1
Xinput108 channel_length[81] net108 VDD VSS BUF_X1
Xinput109 channel_length[82] net109 VDD VSS BUF_X1
Xinput110 channel_length[83] net110 VDD VSS BUF_X1
Xinput111 channel_length[84] net111 VDD VSS BUF_X1
Xinput112 channel_length[85] net112 VDD VSS BUF_X1
Xinput113 channel_length[86] net113 VDD VSS BUF_X1
Xinput114 channel_length[87] net114 VDD VSS BUF_X1
Xinput115 channel_length[88] net115 VDD VSS BUF_X1
Xinput116 channel_length[89] net116 VDD VSS BUF_X1
Xinput117 channel_length[8] net117 VDD VSS BUF_X1
Xinput118 channel_length[90] net118 VDD VSS BUF_X1
Xinput119 channel_length[91] net119 VDD VSS BUF_X1
Xinput120 channel_length[92] net120 VDD VSS BUF_X1
Xinput121 channel_length[93] net121 VDD VSS BUF_X2
Xinput122 channel_length[94] net122 VDD VSS BUF_X2
Xinput123 channel_length[95] net123 VDD VSS BUF_X1
Xinput124 channel_length[96] net124 VDD VSS BUF_X1
Xinput125 channel_length[97] net125 VDD VSS BUF_X2
Xinput126 channel_length[98] net126 VDD VSS BUF_X2
Xinput127 channel_length[99] net127 VDD VSS BUF_X2
Xinput128 channel_length[9] net128 VDD VSS BUF_X2
Xinput129 channel_start[2] net129 VDD VSS CLKBUF_X3
Xinput130 dst_wready[0] net130 VDD VSS CLKBUF_X2
Xinput131 dst_wready[1] net131 VDD VSS BUF_X1
Xinput132 dst_wready[2] net132 VDD VSS CLKBUF_X3
Xinput133 dst_wready[3] net133 VDD VSS CLKBUF_X3
Xinput134 src_rvalid[0] net134 VDD VSS BUF_X1
Xinput135 src_rvalid[1] net135 VDD VSS BUF_X1
Xinput136 src_rvalid[2] net136 VDD VSS BUF_X1
Xinput137 src_rvalid[3] net137 VDD VSS BUF_X2
Xoutput138 net138 channel_busy[0] VDD VSS BUF_X1
Xoutput139 net139 channel_busy[1] VDD VSS BUF_X1
Xoutput140 net140 channel_busy[2] VDD VSS BUF_X1
Xoutput141 net141 channel_busy[3] VDD VSS BUF_X1
Xoutput142 net142 channel_done[0] VDD VSS BUF_X1
Xoutput143 net143 channel_done[1] VDD VSS BUF_X1
Xoutput144 net144 channel_done[2] VDD VSS BUF_X1
Xoutput145 net145 channel_done[3] VDD VSS BUF_X1
Xoutput146 net146 debug_active_channels[0] VDD VSS BUF_X1
Xoutput147 net147 debug_active_channels[1] VDD VSS BUF_X1
Xoutput148 net148 debug_active_channels[2] VDD VSS BUF_X1
Xoutput149 net149 debug_active_channels[3] VDD VSS BUF_X1
Xoutput150 net150 debug_has_active_channels VDD VSS BUF_X1
Xoutput151 net151 dst_write[0] VDD VSS BUF_X1
Xoutput152 net152 dst_write[1] VDD VSS BUF_X1
Xoutput153 net153 dst_write[2] VDD VSS BUF_X1
Xoutput154 net154 dst_write[3] VDD VSS BUF_X1
Xoutput155 net155 src_read[0] VDD VSS BUF_X1
Xoutput156 net156 src_read[1] VDD VSS BUF_X1
Xoutput157 net157 src_read[2] VDD VSS BUF_X1
Xoutput158 net158 src_read[3] VDD VSS BUF_X1
Xoutput159 net159 src_rready[0] VDD VSS BUF_X1
Xoutput160 net160 src_rready[1] VDD VSS BUF_X1
Xoutput161 net161 src_rready[2] VDD VSS BUF_X1
Xoutput162 net162 src_rready[3] VDD VSS BUF_X1
X_3421__163 net163 VDD VSS LOGIC0_X1
X_3422__164 net164 VDD VSS LOGIC0_X1
X_3423__165 net165 VDD VSS LOGIC0_X1
X_3424__166 net166 VDD VSS LOGIC0_X1
X_3425__167 net167 VDD VSS LOGIC0_X1
X_3426__168 net168 VDD VSS LOGIC0_X1
X_3427__169 net169 VDD VSS LOGIC0_X1
X_3428__170 net170 VDD VSS LOGIC0_X1
X_3429__171 net171 VDD VSS LOGIC0_X1
X_3430__172 net172 VDD VSS LOGIC0_X1
X_3431__173 net173 VDD VSS LOGIC0_X1
X_3432__174 net174 VDD VSS LOGIC0_X1
X_3433__175 net175 VDD VSS LOGIC0_X1
X_3434__176 net176 VDD VSS LOGIC0_X1
X_3435__177 net177 VDD VSS LOGIC0_X1
X_3436__178 net178 VDD VSS LOGIC0_X1
X_3437__179 net179 VDD VSS LOGIC0_X1
X_3438__180 net180 VDD VSS LOGIC0_X1
X_3439__181 net181 VDD VSS LOGIC0_X1
X_3440__182 net182 VDD VSS LOGIC0_X1
X_3441__183 net183 VDD VSS LOGIC0_X1
X_3442__184 net184 VDD VSS LOGIC0_X1
X_3443__185 net185 VDD VSS LOGIC0_X1
X_3444__186 net186 VDD VSS LOGIC0_X1
X_3445__187 net187 VDD VSS LOGIC0_X1
X_3446__188 net188 VDD VSS LOGIC0_X1
X_3447__189 net189 VDD VSS LOGIC0_X1
X_3448__190 net190 VDD VSS LOGIC0_X1
X_3449__191 net191 VDD VSS LOGIC0_X1
X_3450__192 net192 VDD VSS LOGIC0_X1
X_3451__193 net193 VDD VSS LOGIC0_X1
X_3452__194 net194 VDD VSS LOGIC0_X1
X_3453__195 net195 VDD VSS LOGIC0_X1
X_3454__196 net196 VDD VSS LOGIC0_X1
X_3455__197 net197 VDD VSS LOGIC0_X1
X_3456__198 net198 VDD VSS LOGIC0_X1
X_3457__199 net199 VDD VSS LOGIC0_X1
X_3458__200 net200 VDD VSS LOGIC0_X1
X_3459__201 net201 VDD VSS LOGIC0_X1
X_3460__202 net202 VDD VSS LOGIC0_X1
X_3461__203 net203 VDD VSS LOGIC0_X1
X_3462__204 net204 VDD VSS LOGIC0_X1
X_3463__205 net205 VDD VSS LOGIC0_X1
X_3464__206 net206 VDD VSS LOGIC0_X1
X_3465__207 net207 VDD VSS LOGIC0_X1
X_3466__208 net208 VDD VSS LOGIC0_X1
X_3467__209 net209 VDD VSS LOGIC0_X1
X_3468__210 net210 VDD VSS LOGIC0_X1
X_3469__211 net211 VDD VSS LOGIC0_X1
X_3470__212 net212 VDD VSS LOGIC0_X1
X_3471__213 net213 VDD VSS LOGIC0_X1
X_3472__214 net214 VDD VSS LOGIC0_X1
X_3473__215 net215 VDD VSS LOGIC0_X1
X_3474__216 net216 VDD VSS LOGIC0_X1
X_3475__217 net217 VDD VSS LOGIC0_X1
X_3476__218 net218 VDD VSS LOGIC0_X1
X_3477__219 net219 VDD VSS LOGIC0_X1
X_3478__220 net220 VDD VSS LOGIC0_X1
X_3479__221 net221 VDD VSS LOGIC0_X1
X_3480__222 net222 VDD VSS LOGIC0_X1
X_3481__223 net223 VDD VSS LOGIC0_X1
X_3482__224 net224 VDD VSS LOGIC0_X1
X_3483__225 net225 VDD VSS LOGIC0_X1
X_3484__226 net226 VDD VSS LOGIC0_X1
X_3485__227 net227 VDD VSS LOGIC0_X1
X_3486__228 net228 VDD VSS LOGIC0_X1
X_3487__229 net229 VDD VSS LOGIC0_X1
X_3488__230 net230 VDD VSS LOGIC0_X1
X_3489__231 net231 VDD VSS LOGIC0_X1
X_3490__232 net232 VDD VSS LOGIC0_X1
X_3491__233 net233 VDD VSS LOGIC0_X1
X_3492__234 net234 VDD VSS LOGIC0_X1
X_3493__235 net235 VDD VSS LOGIC0_X1
X_3494__236 net236 VDD VSS LOGIC0_X1
X_3495__237 net237 VDD VSS LOGIC0_X1
X_3496__238 net238 VDD VSS LOGIC0_X1
X_3497__239 net239 VDD VSS LOGIC0_X1
X_3498__240 net240 VDD VSS LOGIC0_X1
X_3499__241 net241 VDD VSS LOGIC0_X1
X_3500__242 net242 VDD VSS LOGIC0_X1
X_3501__243 net243 VDD VSS LOGIC0_X1
X_3502__244 net244 VDD VSS LOGIC0_X1
X_3503__245 net245 VDD VSS LOGIC0_X1
X_3504__246 net246 VDD VSS LOGIC0_X1
X_3505__247 net247 VDD VSS LOGIC0_X1
X_3506__248 net248 VDD VSS LOGIC0_X1
X_3507__249 net249 VDD VSS LOGIC0_X1
X_3508__250 net250 VDD VSS LOGIC0_X1
X_3509__251 net251 VDD VSS LOGIC0_X1
X_3510__252 net252 VDD VSS LOGIC0_X1
X_3511__253 net253 VDD VSS LOGIC0_X1
X_3512__254 net254 VDD VSS LOGIC0_X1
X_3513__255 net255 VDD VSS LOGIC0_X1
X_3514__256 net256 VDD VSS LOGIC0_X1
X_3515__257 net257 VDD VSS LOGIC0_X1
X_3516__258 net258 VDD VSS LOGIC0_X1
X_3517__259 net259 VDD VSS LOGIC0_X1
X_3518__260 net260 VDD VSS LOGIC0_X1
X_3519__261 net261 VDD VSS LOGIC0_X1
X_3520__262 net262 VDD VSS LOGIC0_X1
X_3521__263 net263 VDD VSS LOGIC0_X1
X_3522__264 net264 VDD VSS LOGIC0_X1
X_3523__265 net265 VDD VSS LOGIC0_X1
X_3524__266 net266 VDD VSS LOGIC0_X1
X_3525__267 net267 VDD VSS LOGIC0_X1
X_3526__268 net268 VDD VSS LOGIC0_X1
X_3527__269 net269 VDD VSS LOGIC0_X1
X_3528__270 net270 VDD VSS LOGIC0_X1
X_3529__271 net271 VDD VSS LOGIC0_X1
X_3530__272 net272 VDD VSS LOGIC0_X1
X_3531__273 net273 VDD VSS LOGIC0_X1
X_3532__274 net274 VDD VSS LOGIC0_X1
X_3533__275 net275 VDD VSS LOGIC0_X1
X_3534__276 net276 VDD VSS LOGIC0_X1
X_3535__277 net277 VDD VSS LOGIC0_X1
X_3536__278 net278 VDD VSS LOGIC0_X1
X_3537__279 net279 VDD VSS LOGIC0_X1
X_3538__280 net280 VDD VSS LOGIC0_X1
X_3539__281 net281 VDD VSS LOGIC0_X1
X_3540__282 net282 VDD VSS LOGIC0_X1
X_3541__283 net283 VDD VSS LOGIC0_X1
X_3542__284 net284 VDD VSS LOGIC0_X1
X_3543__285 net285 VDD VSS LOGIC0_X1
X_3544__286 net286 VDD VSS LOGIC0_X1
X_3545__287 net287 VDD VSS LOGIC0_X1
X_3546__288 net288 VDD VSS LOGIC0_X1
X_3547__289 net289 VDD VSS LOGIC0_X1
X_3548__290 net290 VDD VSS LOGIC0_X1
X_3549__291 net291 VDD VSS LOGIC0_X1
X_3550__292 net292 VDD VSS LOGIC0_X1
X_3551__293 net293 VDD VSS LOGIC0_X1
X_3552__294 net294 VDD VSS LOGIC0_X1
X_3553__295 net295 VDD VSS LOGIC0_X1
X_3554__296 net296 VDD VSS LOGIC0_X1
X_3555__297 net297 VDD VSS LOGIC0_X1
X_3556__298 net298 VDD VSS LOGIC0_X1
X_3557__299 net299 VDD VSS LOGIC0_X1
X_3558__300 net300 VDD VSS LOGIC0_X1
X_3559__301 net301 VDD VSS LOGIC0_X1
X_3560__302 net302 VDD VSS LOGIC0_X1
X_3561__303 net303 VDD VSS LOGIC0_X1
X_3562__304 net304 VDD VSS LOGIC0_X1
X_3563__305 net305 VDD VSS LOGIC0_X1
X_3564__306 net306 VDD VSS LOGIC0_X1
X_3565__307 net307 VDD VSS LOGIC0_X1
X_3566__308 net308 VDD VSS LOGIC0_X1
X_3567__309 net309 VDD VSS LOGIC0_X1
X_3568__310 net310 VDD VSS LOGIC0_X1
X_3569__311 net311 VDD VSS LOGIC0_X1
X_3570__312 net312 VDD VSS LOGIC0_X1
X_3571__313 net313 VDD VSS LOGIC0_X1
X_3572__314 net314 VDD VSS LOGIC0_X1
X_3573__315 net315 VDD VSS LOGIC0_X1
X_3574__316 net316 VDD VSS LOGIC0_X1
X_3575__317 net317 VDD VSS LOGIC0_X1
X_3576__318 net318 VDD VSS LOGIC0_X1
X_3577__319 net319 VDD VSS LOGIC0_X1
X_3578__320 net320 VDD VSS LOGIC0_X1
X_3579__321 net321 VDD VSS LOGIC0_X1
X_3580__322 net322 VDD VSS LOGIC0_X1
X_3581__323 net323 VDD VSS LOGIC0_X1
X_3582__324 net324 VDD VSS LOGIC0_X1
X_3583__325 net325 VDD VSS LOGIC0_X1
X_3584__326 net326 VDD VSS LOGIC0_X1
X_3585__327 net327 VDD VSS LOGIC0_X1
X_3586__328 net328 VDD VSS LOGIC0_X1
X_3587__329 net329 VDD VSS LOGIC0_X1
X_3588__330 net330 VDD VSS LOGIC0_X1
X_3589__331 net331 VDD VSS LOGIC0_X1
X_3590__332 net332 VDD VSS LOGIC0_X1
X_3591__333 net333 VDD VSS LOGIC0_X1
X_3592__334 net334 VDD VSS LOGIC0_X1
X_3593__335 net335 VDD VSS LOGIC0_X1
X_3594__336 net336 VDD VSS LOGIC0_X1
X_3595__337 net337 VDD VSS LOGIC0_X1
X_3596__338 net338 VDD VSS LOGIC0_X1
X_3597__339 net339 VDD VSS LOGIC0_X1
X_3598__340 net340 VDD VSS LOGIC0_X1
X_3599__341 net341 VDD VSS LOGIC0_X1
X_3600__342 net342 VDD VSS LOGIC0_X1
X_3601__343 net343 VDD VSS LOGIC0_X1
X_3602__344 net344 VDD VSS LOGIC0_X1
X_3603__345 net345 VDD VSS LOGIC0_X1
X_3604__346 net346 VDD VSS LOGIC0_X1
X_3605__347 net347 VDD VSS LOGIC0_X1
X_3606__348 net348 VDD VSS LOGIC0_X1
X_3607__349 net349 VDD VSS LOGIC0_X1
X_3608__350 net350 VDD VSS LOGIC0_X1
X_3609__351 net351 VDD VSS LOGIC0_X1
X_3610__352 net352 VDD VSS LOGIC0_X1
X_3611__353 net353 VDD VSS LOGIC0_X1
X_3612__354 net354 VDD VSS LOGIC0_X1
X_3613__355 net355 VDD VSS LOGIC0_X1
X_3614__356 net356 VDD VSS LOGIC0_X1
X_3615__357 net357 VDD VSS LOGIC0_X1
X_3616__358 net358 VDD VSS LOGIC0_X1
X_3617__359 net359 VDD VSS LOGIC0_X1
X_3618__360 net360 VDD VSS LOGIC0_X1
X_3619__361 net361 VDD VSS LOGIC0_X1
X_3620__362 net362 VDD VSS LOGIC0_X1
X_3621__363 net363 VDD VSS LOGIC0_X1
X_3622__364 net364 VDD VSS LOGIC0_X1
X_3623__365 net365 VDD VSS LOGIC0_X1
X_3624__366 net366 VDD VSS LOGIC0_X1
X_3625__367 net367 VDD VSS LOGIC0_X1
X_3626__368 net368 VDD VSS LOGIC0_X1
X_3627__369 net369 VDD VSS LOGIC0_X1
X_3628__370 net370 VDD VSS LOGIC0_X1
X_3629__371 net371 VDD VSS LOGIC0_X1
X_3630__372 net372 VDD VSS LOGIC0_X1
X_3631__373 net373 VDD VSS LOGIC0_X1
X_3632__374 net374 VDD VSS LOGIC0_X1
X_3633__375 net375 VDD VSS LOGIC0_X1
X_3634__376 net376 VDD VSS LOGIC0_X1
X_3635__377 net377 VDD VSS LOGIC0_X1
X_3636__378 net378 VDD VSS LOGIC0_X1
X_3637__379 net379 VDD VSS LOGIC0_X1
X_3638__380 net380 VDD VSS LOGIC0_X1
X_3639__381 net381 VDD VSS LOGIC0_X1
X_3640__382 net382 VDD VSS LOGIC0_X1
X_3641__383 net383 VDD VSS LOGIC0_X1
X_3642__384 net384 VDD VSS LOGIC0_X1
X_3643__385 net385 VDD VSS LOGIC0_X1
X_3644__386 net386 VDD VSS LOGIC0_X1
X_3645__387 net387 VDD VSS LOGIC0_X1
X_3646__388 net388 VDD VSS LOGIC0_X1
X_3647__389 net389 VDD VSS LOGIC0_X1
X_3648__390 net390 VDD VSS LOGIC0_X1
X_3649__391 net391 VDD VSS LOGIC0_X1
X_3650__392 net392 VDD VSS LOGIC0_X1
X_3651__393 net393 VDD VSS LOGIC0_X1
X_3652__394 net394 VDD VSS LOGIC0_X1
X_3653__395 net395 VDD VSS LOGIC0_X1
X_3654__396 net396 VDD VSS LOGIC0_X1
X_3655__397 net397 VDD VSS LOGIC0_X1
X_3656__398 net398 VDD VSS LOGIC0_X1
X_3657__399 net399 VDD VSS LOGIC0_X1
X_3658__400 net400 VDD VSS LOGIC0_X1
X_3659__401 net401 VDD VSS LOGIC0_X1
X_3660__402 net402 VDD VSS LOGIC0_X1
X_3661__403 net403 VDD VSS LOGIC0_X1
X_3662__404 net404 VDD VSS LOGIC0_X1
X_3663__405 net405 VDD VSS LOGIC0_X1
X_3664__406 net406 VDD VSS LOGIC0_X1
X_3665__407 net407 VDD VSS LOGIC0_X1
X_3666__408 net408 VDD VSS LOGIC0_X1
X_3667__409 net409 VDD VSS LOGIC0_X1
X_3668__410 net410 VDD VSS LOGIC0_X1
X_3669__411 net411 VDD VSS LOGIC0_X1
X_3670__412 net412 VDD VSS LOGIC0_X1
X_3671__413 net413 VDD VSS LOGIC0_X1
X_3672__414 net414 VDD VSS LOGIC0_X1
X_3673__415 net415 VDD VSS LOGIC0_X1
X_3674__416 net416 VDD VSS LOGIC0_X1
X_3675__417 net417 VDD VSS LOGIC0_X1
X_3676__418 net418 VDD VSS LOGIC0_X1
X_3677__419 net419 VDD VSS LOGIC0_X1
X_3678__420 net420 VDD VSS LOGIC0_X1
X_3679__421 net421 VDD VSS LOGIC0_X1
X_3680__422 net422 VDD VSS LOGIC0_X1
X_3681__423 net423 VDD VSS LOGIC0_X1
X_3682__424 net424 VDD VSS LOGIC0_X1
X_3683__425 net425 VDD VSS LOGIC0_X1
X_3684__426 net426 VDD VSS LOGIC0_X1
X_3685__427 net427 VDD VSS LOGIC0_X1
X_3686__428 net428 VDD VSS LOGIC0_X1
X_3687__429 net429 VDD VSS LOGIC0_X1
X_3688__430 net430 VDD VSS LOGIC0_X1
X_3689__431 net431 VDD VSS LOGIC0_X1
X_3690__432 net432 VDD VSS LOGIC0_X1
X_3691__433 net433 VDD VSS LOGIC0_X1
X_3692__434 net434 VDD VSS LOGIC0_X1
X_3693__435 net435 VDD VSS LOGIC0_X1
X_3694__436 net436 VDD VSS LOGIC0_X1
X_3695__437 net437 VDD VSS LOGIC0_X1
X_3696__438 net438 VDD VSS LOGIC0_X1
X_3697__439 net439 VDD VSS LOGIC0_X1
X_3698__440 net440 VDD VSS LOGIC0_X1
X_3699__441 net441 VDD VSS LOGIC0_X1
X_3700__442 net442 VDD VSS LOGIC0_X1
X_3701__443 net443 VDD VSS LOGIC0_X1
X_3702__444 net444 VDD VSS LOGIC0_X1
X_3703__445 net445 VDD VSS LOGIC0_X1
X_3704__446 net446 VDD VSS LOGIC0_X1
X_3705__447 net447 VDD VSS LOGIC0_X1
X_3706__448 net448 VDD VSS LOGIC0_X1
X_3707__449 net449 VDD VSS LOGIC0_X1
X_3708__450 net450 VDD VSS LOGIC0_X1
X_3709__451 net451 VDD VSS LOGIC0_X1
X_3710__452 net452 VDD VSS LOGIC0_X1
X_3711__453 net453 VDD VSS LOGIC0_X1
X_3712__454 net454 VDD VSS LOGIC0_X1
X_3713__455 net455 VDD VSS LOGIC0_X1
X_3714__456 net456 VDD VSS LOGIC0_X1
X_3715__457 net457 VDD VSS LOGIC0_X1
X_3716__458 net458 VDD VSS LOGIC0_X1
X_3717__459 net459 VDD VSS LOGIC0_X1
X_3718__460 net460 VDD VSS LOGIC0_X1
X_3719__461 net461 VDD VSS LOGIC0_X1
X_3720__462 net462 VDD VSS LOGIC0_X1
X_3721__463 net463 VDD VSS LOGIC0_X1
X_3722__464 net464 VDD VSS LOGIC0_X1
X_3723__465 net465 VDD VSS LOGIC0_X1
X_3724__466 net466 VDD VSS LOGIC0_X1
X_3725__467 net467 VDD VSS LOGIC0_X1
X_3726__468 net468 VDD VSS LOGIC0_X1
X_3727__469 net469 VDD VSS LOGIC0_X1
X_3728__470 net470 VDD VSS LOGIC0_X1
X_3729__471 net471 VDD VSS LOGIC0_X1
X_3730__472 net472 VDD VSS LOGIC0_X1
X_3731__473 net473 VDD VSS LOGIC0_X1
X_3732__474 net474 VDD VSS LOGIC0_X1
X_3733__475 net475 VDD VSS LOGIC0_X1
X_3734__476 net476 VDD VSS LOGIC0_X1
X_3735__477 net477 VDD VSS LOGIC0_X1
X_3736__478 net478 VDD VSS LOGIC0_X1
X_3737__479 net479 VDD VSS LOGIC0_X1
X_3738__480 net480 VDD VSS LOGIC0_X1
X_3739__481 net481 VDD VSS LOGIC0_X1
X_3740__482 net482 VDD VSS LOGIC0_X1
X_3741__483 net483 VDD VSS LOGIC0_X1
X_3742__484 net484 VDD VSS LOGIC0_X1
X_3743__485 net485 VDD VSS LOGIC0_X1
X_3744__486 net486 VDD VSS LOGIC0_X1
X_3745__487 net487 VDD VSS LOGIC0_X1
X_3746__488 net488 VDD VSS LOGIC0_X1
X_3747__489 net489 VDD VSS LOGIC0_X1
X_3748__490 net490 VDD VSS LOGIC0_X1
X_3749__491 net491 VDD VSS LOGIC0_X1
X_3750__492 net492 VDD VSS LOGIC0_X1
X_3751__493 net493 VDD VSS LOGIC0_X1
X_3752__494 net494 VDD VSS LOGIC0_X1
X_3753__495 net495 VDD VSS LOGIC0_X1
X_3754__496 net496 VDD VSS LOGIC0_X1
X_3755__497 net497 VDD VSS LOGIC0_X1
X_3756__498 net498 VDD VSS LOGIC0_X1
X_3757__499 net499 VDD VSS LOGIC0_X1
X_3758__500 net500 VDD VSS LOGIC0_X1
X_3759__501 net501 VDD VSS LOGIC0_X1
X_3760__502 net502 VDD VSS LOGIC0_X1
X_3761__503 net503 VDD VSS LOGIC0_X1
X_3762__504 net504 VDD VSS LOGIC0_X1
X_3763__505 net505 VDD VSS LOGIC0_X1
X_3764__506 net506 VDD VSS LOGIC0_X1
X_3765__507 net507 VDD VSS LOGIC0_X1
X_3766__508 net508 VDD VSS LOGIC0_X1
X_3767__509 net509 VDD VSS LOGIC0_X1
X_3768__510 net510 VDD VSS LOGIC0_X1
X_3769__511 net511 VDD VSS LOGIC0_X1
X_3770__512 net512 VDD VSS LOGIC0_X1
X_3771__513 net513 VDD VSS LOGIC0_X1
X_3772__514 net514 VDD VSS LOGIC0_X1
X_3773__515 net515 VDD VSS LOGIC0_X1
X_3774__516 net516 VDD VSS LOGIC0_X1
X_3775__517 net517 VDD VSS LOGIC0_X1
X_3776__518 net518 VDD VSS LOGIC0_X1
X_3777__519 net519 VDD VSS LOGIC0_X1
X_3778__520 net520 VDD VSS LOGIC0_X1
X_3779__521 net521 VDD VSS LOGIC0_X1
X_3780__522 net522 VDD VSS LOGIC0_X1
X_3781__523 net523 VDD VSS LOGIC0_X1
X_3782__524 net524 VDD VSS LOGIC0_X1
X_3783__525 net525 VDD VSS LOGIC0_X1
X_3784__526 net526 VDD VSS LOGIC0_X1
X_3785__527 net527 VDD VSS LOGIC0_X1
X_3786__528 net528 VDD VSS LOGIC0_X1
X_3787__529 net529 VDD VSS LOGIC0_X1
X_3788__530 net530 VDD VSS LOGIC0_X1
X_3789__531 net531 VDD VSS LOGIC0_X1
X_3790__532 net532 VDD VSS LOGIC0_X1
X_3791__533 net533 VDD VSS LOGIC0_X1
X_3792__534 net534 VDD VSS LOGIC0_X1
X_3793__535 net535 VDD VSS LOGIC0_X1
X_3794__536 net536 VDD VSS LOGIC0_X1
X_3795__537 net537 VDD VSS LOGIC0_X1
X_3796__538 net538 VDD VSS LOGIC0_X1
X_3797__539 net539 VDD VSS LOGIC0_X1
X_3798__540 net540 VDD VSS LOGIC0_X1
X_3799__541 net541 VDD VSS LOGIC0_X1
X_3800__542 net542 VDD VSS LOGIC0_X1
X_3801__543 net543 VDD VSS LOGIC0_X1
X_3802__544 net544 VDD VSS LOGIC0_X1
X_3803__545 net545 VDD VSS LOGIC0_X1
X_3804__546 net546 VDD VSS LOGIC0_X1
X_3805__547 net547 VDD VSS LOGIC0_X1
X_3806__548 net548 VDD VSS LOGIC0_X1
X_3807__549 net549 VDD VSS LOGIC0_X1
X_3808__550 net550 VDD VSS LOGIC0_X1
X_3809__551 net551 VDD VSS LOGIC0_X1
X_3810__552 net552 VDD VSS LOGIC0_X1
X_3811__553 net553 VDD VSS LOGIC0_X1
X_3812__554 net554 VDD VSS LOGIC0_X1
X_3813__555 net555 VDD VSS LOGIC0_X1
X_3814__556 net556 VDD VSS LOGIC0_X1
X_3815__557 net557 VDD VSS LOGIC0_X1
X_3816__558 net558 VDD VSS LOGIC0_X1
X_3817__559 net559 VDD VSS LOGIC0_X1
X_3818__560 net560 VDD VSS LOGIC0_X1
X_3819__561 net561 VDD VSS LOGIC0_X1
X_3820__562 net562 VDD VSS LOGIC0_X1
X_3821__563 net563 VDD VSS LOGIC0_X1
X_3822__564 net564 VDD VSS LOGIC0_X1
X_3823__565 net565 VDD VSS LOGIC0_X1
X_3824__566 net566 VDD VSS LOGIC0_X1
X_3825__567 net567 VDD VSS LOGIC0_X1
X_3826__568 net568 VDD VSS LOGIC0_X1
X_3827__569 net569 VDD VSS LOGIC0_X1
X_3828__570 net570 VDD VSS LOGIC0_X1
X_3829__571 net571 VDD VSS LOGIC0_X1
X_3830__572 net572 VDD VSS LOGIC0_X1
X_3831__573 net573 VDD VSS LOGIC0_X1
X_3832__574 net574 VDD VSS LOGIC0_X1
X_3833__575 net575 VDD VSS LOGIC0_X1
X_3834__576 net576 VDD VSS LOGIC0_X1
X_3835__577 net577 VDD VSS LOGIC0_X1
X_3836__578 net578 VDD VSS LOGIC0_X1
X_3837__579 net579 VDD VSS LOGIC0_X1
X_3838__580 net580 VDD VSS LOGIC0_X1
X_3839__581 net581 VDD VSS LOGIC0_X1
X_3840__582 net582 VDD VSS LOGIC0_X1
X_3841__583 net583 VDD VSS LOGIC0_X1
X_3842__584 net584 VDD VSS LOGIC0_X1
X_3843__585 net585 VDD VSS LOGIC0_X1
X_3844__586 net586 VDD VSS LOGIC0_X1
X_3845__587 net587 VDD VSS LOGIC0_X1
X_3846__588 net588 VDD VSS LOGIC0_X1
X_3847__589 net589 VDD VSS LOGIC0_X1
X_3848__590 net590 VDD VSS LOGIC0_X1
X_3849__591 net591 VDD VSS LOGIC0_X1
X_3850__592 net592 VDD VSS LOGIC0_X1
X_3851__593 net593 VDD VSS LOGIC0_X1
X_3852__594 net594 VDD VSS LOGIC0_X1
X_3853__595 net595 VDD VSS LOGIC0_X1
X_3854__596 net596 VDD VSS LOGIC0_X1
X_3855__597 net597 VDD VSS LOGIC0_X1
X_3856__598 net598 VDD VSS LOGIC0_X1
X_3857__599 net599 VDD VSS LOGIC0_X1
X_3858__600 net600 VDD VSS LOGIC0_X1
X_3859__601 net601 VDD VSS LOGIC0_X1
X_3860__602 net602 VDD VSS LOGIC0_X1
X_3861__603 net603 VDD VSS LOGIC0_X1
X_3862__604 net604 VDD VSS LOGIC0_X1
X_3863__605 net605 VDD VSS LOGIC0_X1
X_3864__606 net606 VDD VSS LOGIC0_X1
X_3865__607 net607 VDD VSS LOGIC0_X1
X_3866__608 net608 VDD VSS LOGIC0_X1
X_3867__609 net609 VDD VSS LOGIC0_X1
X_3868__610 net610 VDD VSS LOGIC0_X1
X_3869__611 net611 VDD VSS LOGIC0_X1
X_3870__612 net612 VDD VSS LOGIC0_X1
X_3871__613 net613 VDD VSS LOGIC0_X1
X_3872__614 net614 VDD VSS LOGIC0_X1
X_3873__615 net615 VDD VSS LOGIC0_X1
X_3874__616 net616 VDD VSS LOGIC0_X1
X_3875__617 net617 VDD VSS LOGIC0_X1
X_3876__618 net618 VDD VSS LOGIC0_X1
X_3877__619 net619 VDD VSS LOGIC0_X1
X_3878__620 net620 VDD VSS LOGIC0_X1
X_3879__621 net621 VDD VSS LOGIC0_X1
X_3880__622 net622 VDD VSS LOGIC0_X1
X_3881__623 net623 VDD VSS LOGIC0_X1
X_3882__624 net624 VDD VSS LOGIC0_X1
X_3883__625 net625 VDD VSS LOGIC0_X1
X_3884__626 net626 VDD VSS LOGIC0_X1
X_3885__627 net627 VDD VSS LOGIC0_X1
X_3886__628 net628 VDD VSS LOGIC0_X1
X_3887__629 net629 VDD VSS LOGIC0_X1
X_3888__630 net630 VDD VSS LOGIC0_X1
X_3889__631 net631 VDD VSS LOGIC0_X1
X_3890__632 net632 VDD VSS LOGIC0_X1
X_3891__633 net633 VDD VSS LOGIC0_X1
X_3892__634 net634 VDD VSS LOGIC0_X1
X_3893__635 net635 VDD VSS LOGIC0_X1
X_3894__636 net636 VDD VSS LOGIC0_X1
X_3895__637 net637 VDD VSS LOGIC0_X1
X_3896__638 net638 VDD VSS LOGIC0_X1
X_3897__639 net639 VDD VSS LOGIC0_X1
X_3898__640 net640 VDD VSS LOGIC0_X1
X_3899__641 net641 VDD VSS LOGIC0_X1
X_3900__642 net642 VDD VSS LOGIC0_X1
X_3901__643 net643 VDD VSS LOGIC0_X1
X_3902__644 net644 VDD VSS LOGIC0_X1
X_3903__645 net645 VDD VSS LOGIC0_X1
X_3904__646 net646 VDD VSS LOGIC0_X1
X_3905__647 net647 VDD VSS LOGIC0_X1
X_3906__648 net648 VDD VSS LOGIC0_X1
X_3907__649 net649 VDD VSS LOGIC0_X1
X_3908__650 net650 VDD VSS LOGIC0_X1
X_3909__651 net651 VDD VSS LOGIC0_X1
X_3910__652 net652 VDD VSS LOGIC0_X1
X_3911__653 net653 VDD VSS LOGIC0_X1
X_3912__654 net654 VDD VSS LOGIC0_X1
X_3913__655 net655 VDD VSS LOGIC0_X1
X_3914__656 net656 VDD VSS LOGIC0_X1
X_3915__657 net657 VDD VSS LOGIC0_X1
X_3916__658 net658 VDD VSS LOGIC0_X1
X_3917__659 net659 VDD VSS LOGIC0_X1
X_3918__660 net660 VDD VSS LOGIC0_X1
X_3919__661 net661 VDD VSS LOGIC0_X1
X_3920__662 net662 VDD VSS LOGIC0_X1
X_3921__663 net663 VDD VSS LOGIC0_X1
X_3922__664 net664 VDD VSS LOGIC0_X1
X_3923__665 net665 VDD VSS LOGIC0_X1
X_3924__666 net666 VDD VSS LOGIC0_X1
X_3925__667 net667 VDD VSS LOGIC0_X1
X_3926__668 net668 VDD VSS LOGIC0_X1
X_3927__669 net669 VDD VSS LOGIC0_X1
X_3928__670 net670 VDD VSS LOGIC0_X1
X_3929__671 net671 VDD VSS LOGIC0_X1
X_3930__672 net672 VDD VSS LOGIC0_X1
X_3931__673 net673 VDD VSS LOGIC0_X1
X_3932__674 net674 VDD VSS LOGIC0_X1
X_3933__675 net675 VDD VSS LOGIC0_X1
X_3934__676 net676 VDD VSS LOGIC0_X1
X_3935__677 net677 VDD VSS LOGIC0_X1
X_3936__678 net678 VDD VSS LOGIC0_X1
X_3937__679 net679 VDD VSS LOGIC0_X1
X_3938__680 net680 VDD VSS LOGIC0_X1
X_3939__681 net681 VDD VSS LOGIC0_X1
X_3940__682 net682 VDD VSS LOGIC0_X1
X_3941__683 net683 VDD VSS LOGIC0_X1
X_3942__684 net684 VDD VSS LOGIC0_X1
X_3943__685 net685 VDD VSS LOGIC0_X1
X_3944__686 net686 VDD VSS LOGIC0_X1
X_3945__687 net687 VDD VSS LOGIC0_X1
X_3946__688 net688 VDD VSS LOGIC0_X1
X_3947__689 net689 VDD VSS LOGIC0_X1
X_3948__690 net690 VDD VSS LOGIC0_X1
X_3949__691 net691 VDD VSS LOGIC0_X1
X_3950__692 net692 VDD VSS LOGIC0_X1
X_3951__693 net693 VDD VSS LOGIC0_X1
X_3952__694 net694 VDD VSS LOGIC0_X1
X_3953__695 net695 VDD VSS LOGIC0_X1
X_3954__696 net696 VDD VSS LOGIC0_X1
X_3955__697 net697 VDD VSS LOGIC0_X1
X_3956__698 net698 VDD VSS LOGIC0_X1
X_3957__699 net699 VDD VSS LOGIC0_X1
X_3958__700 net700 VDD VSS LOGIC0_X1
X_3959__701 net701 VDD VSS LOGIC0_X1
X_3960__702 net702 VDD VSS LOGIC0_X1
X_3961__703 net703 VDD VSS LOGIC0_X1
X_3962__704 net704 VDD VSS LOGIC0_X1
X_3963__705 net705 VDD VSS LOGIC0_X1
X_3964__706 net706 VDD VSS LOGIC0_X1
Xclkbuf_4_0_0_clk clknet_0_clk clknet_4_0_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_1_0_clk clknet_0_clk clknet_4_1_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_2_0_clk clknet_0_clk clknet_4_2_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_3_0_clk clknet_0_clk clknet_4_3_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_4_0_clk clknet_0_clk clknet_4_4_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_5_0_clk clknet_0_clk clknet_4_5_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_6_0_clk clknet_0_clk clknet_4_6_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_7_0_clk clknet_0_clk clknet_4_7_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_8_0_clk clknet_0_clk clknet_4_8_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_9_0_clk clknet_0_clk clknet_4_9_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_10_0_clk clknet_0_clk clknet_4_10_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_11_0_clk clknet_0_clk clknet_4_11_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_12_0_clk clknet_0_clk clknet_4_12_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_13_0_clk clknet_0_clk clknet_4_13_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_14_0_clk clknet_0_clk clknet_4_14_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_15_0_clk clknet_0_clk clknet_4_15_0_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_4_0_0_clk _unconnected_0 VDD VSS INV_X8
Xclkload1 clknet_4_1_0_clk _unconnected_1 VDD VSS INV_X8
Xclkload2 clknet_4_2_0_clk _unconnected_2 VDD VSS INV_X8
Xclkload3 clknet_4_3_0_clk _unconnected_3 VDD VSS INV_X4
Xclkload4 clknet_4_4_0_clk _unconnected_4 VDD VSS INV_X8
Xclkload5 clknet_4_5_0_clk _unconnected_5 VDD VSS INV_X4
Xclkload6 clknet_4_6_0_clk _unconnected_6 VDD VSS INV_X4
Xclkload7 clknet_4_8_0_clk _unconnected_7 VDD VSS INV_X8
Xclkload8 clknet_4_9_0_clk _unconnected_8 VDD VSS INV_X8
Xclkload9 clknet_4_10_0_clk _unconnected_9 VDD VSS INV_X2
Xclkload10 clknet_4_11_0_clk _unconnected_10 VDD VSS INV_X8
Xclkload11 clknet_4_12_0_clk _unconnected_11 VDD VSS INV_X8
Xclkload12 clknet_4_13_0_clk _unconnected_12 VDD VSS INV_X8
Xclkload13 clknet_4_14_0_clk _unconnected_13 VDD VSS INV_X8
Xclkload14 clknet_4_15_0_clk _unconnected_14 VDD VSS INV_X4
.ENDS dma_controller
