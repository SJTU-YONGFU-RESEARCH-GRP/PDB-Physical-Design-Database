* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_decade_counter clk count[0] count[1]
+ count[2] count[3] enable rst_n tc
X_22_ net5 _04_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_23_ net6 _18_ _05_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_24_ _04_ _05_ net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_25_ net4 _17_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_26_ net2 _06_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_27_ _04_ _05_ net3 _06_ _07_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_28_ _06_ net3 _08_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_29_ _07_ _08_ _00_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_30_ _04_ _05_ _19_ _09_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_31_ net4 _09_ net2 _01_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_32_ net2 _20_ _10_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_33_ _05_ _10_ _11_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_34_ _10_ _11_ _04_ _02_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_35_ net2 net4 net3 _12_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_36_ net4 net3 _13_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_37_ _12_ _13_ net6 _14_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_38_ net5 _18_ net2 _15_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_39_ net6 _15_ _16_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_40_ _04_ _14_ _16_ _03_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_41_ net3 _17_ _18_ _19_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_42_ net3 net4 _20_ _21_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
Xcount\[0\]$_DFFE_PN0P_ _00_ net1 clknet_1_0__leaf_clk net3
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcount\[1\]$_DFFE_PN0P_ _01_ net1 clknet_1_0__leaf_clk net4
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcount\[2\]$_DFFE_PN0P_ _02_ net1 clknet_1_1__leaf_clk net5
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcount\[3\]$_DFFE_PN0P_ _03_ net1 clknet_1_1__leaf_clk net6
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xhold1 net8 net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 enable net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xoutput2 net3 count[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput3 net4 count[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput4 net5 count[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput5 net6 count[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput6 net7 tc VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xhold2 rst_n net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
.ENDS parameterized_decade_counter
