* cell network_interface
* pin router_out_data[13]
* pin router_out_data[0]
* pin mem_rdata[13]
* pin mem_rdata[0]
* pin router_out_data[14]
* pin router_out_data[17]
* pin mem_rdata[14]
* pin mem_rdata[17]
* pin router_out_data[15]
* pin mem_rdata[15]
* pin router_out_data[11]
* pin router_out_data[10]
* pin mem_rdata[11]
* pin mem_rdata[10]
* pin mem_ready
* pin mem_rdata[8]
* pin router_out_valid
* pin router_out_ready
* pin rst_n
* pin mem_wdata[14]
* pin router_in_valid
* pin mem_addr[17]
* pin router_in_ready
* pin mem_wdata[17]
* pin mem_read
* pin mem_write
* pin mem_addr[20]
* pin router_in_data[23]
* pin mem_wdata[23]
* pin msg_type[2]
* pin router_in_data[25]
* pin router_in_data[20]
* pin router_out_data[12]
* pin mem_rdata[12]
* pin mem_wdata[26]
* pin mem_wdata[25]
* pin mem_addr[18]
* pin mem_wdata[20]
* pin dest_id[1]
* pin mem_wdata[18]
* pin router_in_data[22]
* pin dest_id[2]
* pin mem_wdata[1]
* pin router_in_data[18]
* pin mem_rdata[16]
* pin router_out_data[16]
* pin mem_wdata[22]
* pin mem_addr[1]
* pin msg_type[1]
* pin router_in_data[26]
* pin mem_rdata[28]
* pin mem_rdata[29]
* pin router_out_data[28]
* pin mem_rdata[5]
* pin router_in_data[1]
* pin mem_wdata[27]
* pin dest_id[3]
* pin router_out_data[29]
* pin router_out_data[5]
* pin router_out_data[30]
* pin router_in_data[17]
* pin dest_id[0]
* pin router_in_data[27]
* pin router_in_data[24]
* pin router_out_data[6]
* pin mem_rdata[6]
* pin router_out_data[8]
* pin mem_rdata[4]
* pin mem_addr[13]
* pin mem_wdata[13]
* pin mem_wdata[24]
* pin mem_addr[14]
* pin router_out_data[4]
* pin mem_rdata[30]
* pin mem_wdata[21]
* pin router_in_data[21]
* pin msg_type[0]
* pin router_in_data[13]
* pin clk
* pin mem_rdata[7]
* pin router_out_data[7]
* pin router_in_data[14]
* pin mem_rdata[31]
* pin router_out_data[31]
* pin router_out_data[3]
* pin mem_rdata[27]
* pin router_in_data[9]
* pin mem_addr[15]
* pin mem_wdata[15]
* pin mem_rdata[2]
* pin mem_rdata[3]
* pin router_out_data[27]
* pin router_in_data[15]
* pin mem_addr[9]
* pin router_in_data[30]
* pin mem_wdata[9]
* pin mem_wdata[10]
* pin mem_addr[10]
* pin router_in_data[10]
* pin router_out_data[2]
* pin router_out_data[9]
* pin mem_addr[11]
* pin dest_id[6]
* pin mem_wdata[11]
* pin router_out_data[18]
* pin router_out_data[25]
* pin mem_rdata[9]
* pin mem_wdata[12]
* pin mem_addr[12]
* pin router_in_data[12]
* pin router_in_data[11]
* pin mem_rdata[25]
* pin mem_rdata[21]
* pin mem_rdata[18]
* pin router_out_data[21]
* pin mem_addr[4]
* pin mem_rdata[22]
* pin router_out_data[26]
* pin mem_rdata[26]
* pin router_out_data[22]
* pin router_out_data[20]
* pin router_in_data[4]
* pin mem_wdata[4]
* pin mem_rdata[20]
* pin router_out_data[1]
* pin mem_rdata[1]
* pin router_out_data[24]
* pin router_out_data[19]
* pin mem_rdata[24]
* pin mem_rdata[19]
* pin router_in_data[8]
* pin router_in_data[2]
* pin router_in_data[5]
* pin mem_wdata[29]
* pin router_in_data[3]
* pin mem_wdata[2]
* pin router_in_data[19]
* pin mem_wdata[31]
* pin mem_addr[8]
* pin mem_wdata[28]
* pin mem_wdata[3]
* pin mem_wdata[7]
* pin mem_wdata[8]
* pin mem_wdata[16]
* pin mem_wdata[0]
* pin router_in_data[0]
* pin mem_wdata[6]
* pin mem_wdata[5]
* pin mem_wdata[19]
* pin router_in_data[28]
* pin dest_id[7]
* pin dest_id[5]
* pin mem_wdata[30]
* pin router_in_data[31]
* pin router_in_data[29]
* pin router_out_data[23]
* pin mem_rdata[23]
* pin router_in_data[16]
* pin mem_addr[16]
* pin mem_addr[0]
* pin mem_addr[5]
* pin mem_addr[2]
* pin mem_addr[19]
* pin mem_addr[6]
* pin dest_id[4]
* pin router_in_data[6]
* pin mem_addr[3]
* pin mem_addr[7]
* pin router_in_data[7]
* pin PWELL,gf180mcu_gnd
* pin NWELL
.SUBCKT network_interface 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 120 135 136 137 140 142 144 152 153 154 155 156 169 173 175
+ 178 180 185 186 193 195 196 197 202 203 204 205 213 214 215 223 224 225 232
+ 234 236 237 246 247 248 250 258 260 261 265 266 267 273 277 279 280 289 290
+ 291 292 293 294 295 298 304 305 306 312 313 314 325 326 327 328 331 332 333
+ 334 335 343 344 345 358 359 360 369 371 372 373 380 381 382 383 390 395 396
+ 397 398 399 409 410 415 416 417 418 429 430 431 486 490 491 493 495 509 515
+ 516 522 527 529 530 537 538 539 540 541 545 547 548 549 551 552 553 554 555
+ 556 557 558 559 560 561 562 563 564 565 566 567 568 569 570
* net 1 router_out_data[13]
* net 2 router_out_data[0]
* net 3 mem_rdata[13]
* net 4 mem_rdata[0]
* net 5 router_out_data[14]
* net 6 router_out_data[17]
* net 7 mem_rdata[14]
* net 8 mem_rdata[17]
* net 9 router_out_data[15]
* net 10 mem_rdata[15]
* net 11 router_out_data[11]
* net 12 router_out_data[10]
* net 13 mem_rdata[11]
* net 14 mem_rdata[10]
* net 15 mem_ready
* net 16 mem_rdata[8]
* net 17 router_out_valid
* net 18 router_out_ready
* net 19 rst_n
* net 20 mem_wdata[14]
* net 21 router_in_valid
* net 22 mem_addr[17]
* net 23 router_in_ready
* net 24 mem_wdata[17]
* net 25 mem_read
* net 26 mem_write
* net 27 mem_addr[20]
* net 120 router_in_data[23]
* net 135 mem_wdata[23]
* net 136 msg_type[2]
* net 137 router_in_data[25]
* net 140 router_in_data[20]
* net 142 router_out_data[12]
* net 144 mem_rdata[12]
* net 152 mem_wdata[26]
* net 153 mem_wdata[25]
* net 154 mem_addr[18]
* net 155 mem_wdata[20]
* net 156 dest_id[1]
* net 169 mem_wdata[18]
* net 173 router_in_data[22]
* net 175 dest_id[2]
* net 178 mem_wdata[1]
* net 180 router_in_data[18]
* net 185 mem_rdata[16]
* net 186 router_out_data[16]
* net 193 mem_wdata[22]
* net 195 mem_addr[1]
* net 196 msg_type[1]
* net 197 router_in_data[26]
* net 202 mem_rdata[28]
* net 203 mem_rdata[29]
* net 204 router_out_data[28]
* net 205 mem_rdata[5]
* net 213 router_in_data[1]
* net 214 mem_wdata[27]
* net 215 dest_id[3]
* net 223 router_out_data[29]
* net 224 router_out_data[5]
* net 225 router_out_data[30]
* net 232 router_in_data[17]
* net 234 dest_id[0]
* net 236 router_in_data[27]
* net 237 router_in_data[24]
* net 246 router_out_data[6]
* net 247 mem_rdata[6]
* net 248 router_out_data[8]
* net 250 mem_rdata[4]
* net 258 mem_addr[13]
* net 260 mem_wdata[13]
* net 261 mem_wdata[24]
* net 265 mem_addr[14]
* net 266 router_out_data[4]
* net 267 mem_rdata[30]
* net 273 mem_wdata[21]
* net 277 router_in_data[21]
* net 279 msg_type[0]
* net 280 router_in_data[13]
* net 289 clk
* net 290 mem_rdata[7]
* net 291 router_out_data[7]
* net 292 router_in_data[14]
* net 293 mem_rdata[31]
* net 294 router_out_data[31]
* net 295 router_out_data[3]
* net 298 mem_rdata[27]
* net 304 router_in_data[9]
* net 305 mem_addr[15]
* net 306 mem_wdata[15]
* net 312 mem_rdata[2]
* net 313 mem_rdata[3]
* net 314 router_out_data[27]
* net 325 router_in_data[15]
* net 326 mem_addr[9]
* net 327 router_in_data[30]
* net 328 mem_wdata[9]
* net 331 mem_wdata[10]
* net 332 mem_addr[10]
* net 333 router_in_data[10]
* net 334 router_out_data[2]
* net 335 router_out_data[9]
* net 343 mem_addr[11]
* net 344 dest_id[6]
* net 345 mem_wdata[11]
* net 358 router_out_data[18]
* net 359 router_out_data[25]
* net 360 mem_rdata[9]
* net 369 mem_wdata[12]
* net 371 mem_addr[12]
* net 372 router_in_data[12]
* net 373 router_in_data[11]
* net 380 mem_rdata[25]
* net 381 mem_rdata[21]
* net 382 mem_rdata[18]
* net 383 router_out_data[21]
* net 390 mem_addr[4]
* net 395 mem_rdata[22]
* net 396 router_out_data[26]
* net 397 mem_rdata[26]
* net 398 router_out_data[22]
* net 399 router_out_data[20]
* net 409 router_in_data[4]
* net 410 mem_wdata[4]
* net 415 mem_rdata[20]
* net 416 router_out_data[1]
* net 417 mem_rdata[1]
* net 418 router_out_data[24]
* net 429 router_out_data[19]
* net 430 mem_rdata[24]
* net 431 mem_rdata[19]
* net 486 router_in_data[8]
* net 490 router_in_data[2]
* net 491 router_in_data[5]
* net 493 mem_wdata[29]
* net 495 router_in_data[3]
* net 509 mem_wdata[2]
* net 515 router_in_data[19]
* net 516 mem_wdata[31]
* net 522 mem_addr[8]
* net 527 mem_wdata[28]
* net 529 mem_wdata[3]
* net 530 mem_wdata[7]
* net 537 mem_wdata[8]
* net 538 mem_wdata[16]
* net 539 mem_wdata[0]
* net 540 router_in_data[0]
* net 541 mem_wdata[6]
* net 545 mem_wdata[5]
* net 547 mem_wdata[19]
* net 548 router_in_data[28]
* net 549 dest_id[7]
* net 551 dest_id[5]
* net 552 mem_wdata[30]
* net 553 router_in_data[31]
* net 554 router_in_data[29]
* net 555 router_out_data[23]
* net 556 mem_rdata[23]
* net 557 router_in_data[16]
* net 558 mem_addr[16]
* net 559 mem_addr[0]
* net 560 mem_addr[5]
* net 561 mem_addr[2]
* net 562 mem_addr[19]
* net 563 mem_addr[6]
* net 564 dest_id[4]
* net 565 router_in_data[6]
* net 566 mem_addr[3]
* net 567 mem_addr[7]
* net 568 router_in_data[7]
* net 569 PWELL,gf180mcu_gnd
* net 570 NWELL
* cell instance $2 r0 *1 682.08,5.04
X$2 1 570 569 28 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7 m0 *1 712.32,25.2
X$7 2 570 569 56 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11 r0 *1 706.16,15.12
X$11 42 570 569 3 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14 r0 *1 690.48,5.04
X$14 31 570 569 4 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $19 m0 *1 729.12,25.2
X$19 5 570 569 59 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $23 r0 *1 706.16,5.04
X$23 6 570 569 32 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27 m0 *1 737.52,25.2
X$27 46 570 569 7 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $31 r0 *1 714.56,5.04
X$31 33 570 569 8 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $35 r0 *1 734.16,25.2
X$35 9 570 569 60 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $39 r0 *1 722.96,5.04
X$39 34 570 569 10 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $42 r0 *1 731.36,5.04
X$42 11 570 569 57 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $46 r0 *1 748.16,5.04
X$46 12 570 569 35 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $50 r0 *1 739.76,5.04
X$50 29 570 569 13 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $54 r0 *1 756.56,5.04
X$54 30 570 569 14 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $59 r0 *1 764.96,5.04
X$59 49 570 569 15 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $63 m0 *1 766.64,15.12
X$63 50 570 569 16 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66 r0 *1 773.36,5.04
X$66 569 37 17 570 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $71 r0 *1 785.68,5.04
X$71 38 570 569 18 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $75 m0 *1 779.52,15.12
X$75 569 52 19 570 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $78 m0 *1 780.08,25.2
X$78 569 570 20 51 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $82 r0 *1 782.88,15.12
X$82 53 570 569 21 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $86 r0 *1 809.2,5.04
X$86 569 570 22 36 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $91 m0 *1 790.72,25.2
X$91 569 570 23 80 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $94 r0 *1 792.4,15.12
X$94 569 570 24 105 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $98 r0 *1 801.36,5.04
X$98 569 570 25 69 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $102 m0 *1 802.48,15.12
X$102 569 26 76 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $106 r0 *1 839.44,5.04
X$106 569 570 27 93 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $111 r0 *1 690.48,15.12
X$111 569 570 40 28 43 42 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $115 r0 *1 743.12,15.12
X$115 569 570 47 57 43 29 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $118 m0 *1 736.4,15.12
X$118 569 41 29 39 47 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $123 m0 *1 755.44,15.12
X$123 569 570 48 35 43 30 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $125 r0 *1 752.08,15.12
X$125 569 41 30 39 48 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $131 m0 *1 703.92,25.2
X$131 569 570 55 56 43 31 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $133 m0 *1 684.88,25.2
X$133 569 41 31 39 55 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $140 r0 *1 715.12,15.12
X$140 569 570 44 32 43 33 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $146 m0 *1 709.52,15.12
X$146 569 41 33 39 44 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $151 m0 *1 734.72,35.28
X$151 569 570 58 60 43 34 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $153 r0 *1 729.12,35.28
X$153 569 41 34 39 58 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $163 r0 *1 794.08,761.04
X$163 569 570 36 191 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $170 m0 *1 772.24,25.2
X$170 569 570 37 78 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $176 m0 *1 775.04,670.32
X$176 569 73 63 570 38 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $180 m0 *1 690.48,15.12
X$180 569 41 42 39 40 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $183 m0 *1 791.84,317.52
X$183 569 570 39 571 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $190 r0 *1 723.52,15.12
X$190 569 41 46 39 45 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $196 r0 *1 791.84,307.44
X$196 569 61 39 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $207 m0 *1 769.44,811.44
X$207 569 41 299 301 288 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $210 r0 *1 780.64,630
X$210 569 54 41 570 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $213 m0 *1 767.2,710.64
X$213 569 41 53 62 123 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $216 m0 *1 747.6,791.28
X$216 569 41 50 301 226 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $219 m0 *1 750.96,831.6
X$219 569 41 337 301 356 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $221 m0 *1 827.68,781.2
X$221 569 41 230 62 229 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $223 r0 *1 868.56,730.8
X$223 569 41 132 62 141 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $226 r0 *1 25.76,771.12
X$226 569 41 207 157 208 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $229 m0 *1 6.72,771.12
X$229 569 41 162 157 198 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $233 r0 *1 6.72,771.12
X$233 569 41 206 157 188 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $236 m0 *1 35.28,841.68
X$236 569 41 362 315 363 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $238 r0 *1 7.28,750.96
X$238 569 41 165 157 163 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $240 r0 *1 776.72,1577.52
X$240 569 41 461 445 480 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $243 r0 *1 1575.84,821.52
X$243 569 41 368 287 321 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $245 r0 *1 801.36,680.4
X$245 569 41 81 62 84 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $247 m0 *1 766.08,1587.6
X$247 569 41 485 445 504 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $251 r0 *1 20.72,892.08
X$251 569 41 437 315 434 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $253 m0 *1 26.88,821.52
X$253 569 41 307 315 319 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $256 r0 *1 794.08,1567.44
X$256 569 41 451 445 459 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $259 m0 *1 1561.28,821.52
X$259 569 41 303 287 351 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $261 r0 *1 27.44,882
X$261 569 41 435 315 438 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $263 r0 *1 8.96,821.52
X$263 569 41 318 315 317 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $265 m0 *1 7.84,821.52
X$265 569 41 316 315 296 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $267 m0 *1 855.68,1587.6
X$267 569 41 475 301 479 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $270 m0 *1 875.84,1587.6
X$270 569 41 498 301 476 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $273 m0 *1 1540,831.6
X$273 569 41 320 287 353 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $275 r0 *1 1543.92,781.2
X$275 569 41 222 111 244 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $278 m0 *1 813.68,1567.44
X$278 569 41 448 445 446 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $283 m0 *1 888.72,1597.68
X$283 569 41 500 301 501 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $285 m0 *1 1564.64,761.04
X$285 569 41 171 111 201 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $287 r0 *1 1561.28,771.12
X$287 569 41 212 111 210 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $289 r0 *1 39.2,791.28
X$289 569 41 255 157 254 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $292 m0 *1 27.44,851.76
X$292 569 41 385 315 384 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $295 m0 *1 1576.4,861.84
X$295 569 41 407 287 406 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $297 m0 *1 824.32,1547.28
X$297 569 41 442 445 443 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $300 m0 *1 23.52,801.36
X$300 569 41 253 157 251 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $303 r0 *1 1562.96,781.2
X$303 569 41 231 111 242 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $307 m0 *1 1569.12,750.96
X$307 569 41 150 111 148 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $309 m0 *1 1575.84,720.72
X$309 569 41 116 111 113 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $311 r0 *1 809.76,720.72
X$311 569 41 128 62 106 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $313 r0 *1 1570.24,720.72
X$313 569 41 114 111 133 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $316 r0 *1 1545.6,750.96
X$316 569 41 168 111 166 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $318 m0 *1 751.52,660.24
X$318 569 41 49 62 66 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $320 r0 *1 1572.48,801.36
X$320 569 41 278 287 311 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $325 r0 *1 753.76,670.32
X$325 569 41 63 62 43 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $328 r0 *1 5.6,801.36
X$328 569 41 270 157 268 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $330 m0 *1 770,690.48
X$330 569 41 73 62 94 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $333 m0 *1 35.28,811.44
X$333 569 41 300 157 309 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $335 r0 *1 4.48,791.28
X$335 569 41 238 157 262 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $337 r0 *1 833.84,1567.44
X$337 569 41 447 445 449 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $340 m0 *1 1555.68,801.36
X$340 569 41 272 111 285 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $342 r0 *1 1560.72,861.84
X$342 569 41 405 287 424 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $344 m0 *1 828.24,700.56
X$344 569 41 91 62 92 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $348 m0 *1 8.4,841.68
X$348 569 41 377 315 361 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $350 m0 *1 827.12,1587.6
X$350 569 41 469 445 483 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $352 r0 *1 855.68,1567.44
X$352 569 41 457 301 456 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $354 r0 *1 15.68,740.88
X$354 569 41 146 157 143 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $356 r0 *1 6.16,861.84
X$356 569 41 420 315 419 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $359 r0 *1 19.04,871.92
X$359 569 41 423 315 421 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $361 m0 *1 750.96,1597.68
X$361 569 41 520 445 533 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $363 m0 *1 1567.44,851.76
X$363 569 41 388 287 386 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $365 m0 *1 5.04,892.08
X$365 569 41 439 315 432 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $367 r0 *1 9.52,841.68
X$367 569 41 393 315 401 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $369 r0 *1 25.2,861.84
X$369 569 41 403 315 428 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $372 m0 *1 809.2,1577.52
X$372 569 41 453 445 482 570 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $466 m0 *1 745.92,710.64
X$466 569 103 43 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $468 m0 *1 10.64,750.96
X$468 569 570 163 164 43 165 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $473 r0 *1 725.76,25.2
X$473 569 570 45 59 43 46 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $478 m0 *1 19.04,750.96
X$478 569 570 143 145 43 146 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $507 m0 *1 770.56,660.24
X$507 569 570 49 64 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $518 r0 *1 750.4,781.2
X$518 569 570 226 239 103 50 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $523 r0 *1 782.88,781.2
X$523 569 570 51 227 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $526 r0 *1 775.04,15.12
X$526 569 570 52 54 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $531 r0 *1 792.96,690.48
X$531 570 53 80 569 89 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $533 m0 *1 791.28,680.4
X$533 53 570 80 81 569 79 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $535 m0 *1 789.04,690.48
X$535 569 570 53 87 80 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $538 m0 *1 788.48,710.64
X$538 569 570 53 96 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $540 m0 *1 781.76,700.56
X$540 569 570 95 53 99 104 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $550 m0 *1 775.04,660.24
X$550 569 68 62 75 54 570 gf180mcu_fd_sc_mcu9t5v0__dffsnq_4
* cell instance $578 m0 *1 831.6,630
X$578 569 70 61 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $583 r0 *1 808.08,650.16
X$583 569 61 62 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $610 m0 *1 782.88,670.32
X$610 569 68 570 74 63 79 67 73 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $613 m0 *1 769.44,670.32
X$613 569 68 63 570 65 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $619 m0 *1 761.04,670.32
X$619 569 570 72 65 86 64 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $622 r0 *1 765.52,660.24
X$622 570 77 569 72 65 66 64 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $635 r0 *1 786.8,660.24
X$635 569 570 67 75 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $638 r0 *1 804.72,670.32
X$638 569 570 68 82 69 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $640 m0 *1 801.36,700.56
X$640 569 570 68 98 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $643 m0 *1 804.72,690.48
X$643 570 76 68 569 90 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $645 m0 *1 799.68,710.64
X$645 569 68 570 85 127 87 100 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $655 r0 *1 804.16,660.24
X$655 569 570 74 76 69 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $658 m0 *1 804.16,680.4
X$658 569 76 69 570 85 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $660 r0 *1 1302,660.24
X$660 569 70 71 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $663 r0 *1 791.84,801.36
X$663 569 289 70 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $665 m0 *1 686.56,1063.44
X$665 569 70 441 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $668 m0 *1 288.4,962.64
X$668 569 70 404 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $675 r0 *1 1554,761.04
X$675 569 71 111 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $678 m0 *1 1506.4,811.44
X$678 569 71 287 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $688 r0 *1 776.16,700.56
X$688 88 73 78 569 570 103 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $690 r0 *1 787.36,700.56
X$690 570 96 569 124 73 100 98 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $694 r0 *1 790.16,670.32
X$694 569 570 73 77 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $698 m0 *1 791.84,700.56
X$698 97 569 73 79 570 104 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $713 r0 *1 845.6,720.72
X$713 569 570 76 108 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $718 r0 *1 832.16,720.72
X$718 569 147 76 107 129 570 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $724 r0 *1 842.8,710.64
X$724 569 76 93 570 109 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $729 r0 *1 778.96,690.48
X$729 570 569 77 78 79 97 94 87 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $733 r0 *1 796.88,710.64
X$733 126 77 88 99 570 569 125 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $744 r0 *1 778.96,670.32
X$744 569 78 79 570 86 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $764 m0 *1 809.76,680.4
X$764 569 90 570 83 82 81 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $766 r0 *1 799.12,690.48
X$766 569 570 81 88 89 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $769 m0 *1 813.12,700.56
X$769 102 570 569 81 97 87 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $779 m0 *1 817.04,680.4
X$779 569 570 83 84 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $788 r0 *1 797.44,700.56
X$788 569 98 85 89 97 570 99 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $823 r0 *1 828.24,690.48
X$823 569 91 90 570 92 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $827 m0 *1 834.96,720.72
X$827 569 570 91 107 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $830 m0 *1 840,720.72
X$830 569 97 110 91 108 570 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $847 r0 *1 786.24,710.64
X$847 95 570 125 124 569 123 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $851 r0 *1 851.76,720.72
X$851 569 129 97 570 gf180mcu_fd_sc_mcu9t5v0__clkinv_16
* cell instance $857 m0 *1 808.64,710.64
X$857 569 101 98 97 99 102 570 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $861 r0 *1 870.8,720.72
X$861 569 570 130 109 97 112 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $891 r0 *1 814.24,1597.68
X$891 569 489 570 228 464 543 100 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $893 r0 *1 768.32,1597.68
X$893 569 534 570 228 460 521 100 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $895 r0 *1 749.28,821.52
X$895 569 357 570 228 330 355 100 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $897 r0 *1 774.48,791.28
X$897 569 286 570 228 271 227 100 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $899 m0 *1 831.6,761.04
X$899 569 129 100 570 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $902 m0 *1 775.6,1597.68
X$902 569 505 570 228 484 506 100 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $904 r0 *1 818.16,1587.6
X$904 569 513 570 228 452 511 100 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $907 m0 *1 816.48,1597.68
X$907 569 512 570 228 481 466 100 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $910 r0 *1 800.8,1587.6
X$910 569 487 570 228 462 488 100 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $925 m0 *1 843.36,821.52
X$925 569 101 302 570 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $928 m0 *1 822.08,821.52
X$928 569 101 338 570 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $933 m0 *1 1555.68,781.2
X$933 569 570 244 243 101 222 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $935 m0 *1 840.56,750.96
X$935 569 101 131 570 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $938 m0 *1 1552.32,761.04
X$938 569 570 166 167 101 168 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $948 m0 *1 65.52,841.68
X$948 569 103 402 570 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $950 m0 *1 44.24,781.2
X$950 569 570 103 190 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $957 r0 *1 41.44,811.44
X$957 569 570 309 310 103 300 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $959 r0 *1 40.32,831.6
X$959 569 570 363 378 103 362 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $971 m0 *1 801.92,771.12
X$971 569 570 105 209 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $975 m0 *1 812,720.72
X$975 569 570 127 106 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $985 r0 *1 856.24,821.52
X$985 569 110 348 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $987 m0 *1 1588.16,821.52
X$987 570 322 569 110 329 323 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $989 r0 *1 1593.2,720.72
X$989 570 134 569 110 121 117 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $991 r0 *1 1584.8,740.88
X$991 570 160 569 110 167 151 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $993 r0 *1 1576.4,750.96
X$993 570 184 569 110 149 170 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $995 m0 *1 1569.12,781.2
X$995 570 211 569 110 243 221 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $998 m0 *1 1588.16,750.96
X$998 570 172 569 110 181 174 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1000 r0 *1 1588.72,710.64
X$1000 570 115 569 110 122 119 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1002 m0 *1 1588.16,801.36
X$1002 570 275 569 110 274 283 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1038 m0 *1 1582.56,740.88
X$1038 569 570 155 112 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1042 r0 *1 1579.2,730.8
X$1042 569 570 113 121 131 116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1044 m0 *1 1575.84,730.8
X$1044 569 570 133 122 131 114 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1046 r0 *1 1601.04,720.72
X$1046 114 570 569 137 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1052 r0 *1 1587.6,730.8
X$1052 569 570 129 115 139 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1058 m0 *1 1601.04,720.72
X$1058 116 570 569 120 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1064 m0 *1 1597.12,720.72
X$1064 569 570 118 117 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1067 m0 *1 1601.04,730.8
X$1067 136 570 569 118 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1071 m0 *1 1597.68,730.8
X$1071 569 570 159 119 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1098 m0 *1 1537.2,841.68
X$1098 569 570 126 364 379 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1100 m0 *1 839.44,1577.52
X$1100 569 570 126 454 492 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1103 m0 *1 850.08,761.04
X$1103 569 129 126 570 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $1105 r0 *1 1592.08,781.2
X$1105 569 241 570 147 233 235 126 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1107 r0 *1 862.96,1577.52
X$1107 569 570 126 494 477 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1109 r0 *1 835.52,1587.6
X$1109 569 468 570 228 444 517 126 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1111 r0 *1 796.88,771.12
X$1111 569 191 570 228 245 209 126 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1113 r0 *1 1592.08,771.12
X$1113 569 176 570 147 220 177 126 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1115 m0 *1 853.44,1577.52
X$1115 569 570 126 470 455 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1118 m0 *1 1587.04,791.28
X$1118 569 263 570 147 264 256 126 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1137 m0 *1 820.96,730.8
X$1137 569 128 129 570 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $1140 m0 *1 1590.96,730.8
X$1140 569 570 129 134 138 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1142 m0 *1 1590.4,740.88
X$1142 569 570 129 160 161 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1151 r0 *1 1098.72,761.04
X$1151 569 129 192 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1155 m0 *1 1560.16,771.12
X$1155 569 570 129 211 217 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1168 m0 *1 870.8,730.8
X$1168 569 570 141 130 131 132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1175 m0 *1 1565.2,771.12
X$1175 569 570 210 220 131 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1177 r0 *1 829.92,781.2
X$1177 569 570 229 245 131 230 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1179 r0 *1 1568.56,740.88
X$1179 569 570 148 149 131 150 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1181 m0 *1 1576.96,781.2
X$1181 569 570 242 233 131 231 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1183 m0 *1 1576.4,771.12
X$1183 569 570 201 181 131 171 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1188 r0 *1 831.6,1537.2
X$1188 569 570 443 444 131 442 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1190 r0 *1 1564.08,801.36
X$1190 569 570 285 264 131 272 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1205 r0 *1 1570.8,730.8
X$1205 132 570 569 140 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1213 r0 *1 1601.04,730.8
X$1213 135 570 569 138 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1226 r0 *1 1592.64,730.8
X$1226 153 570 569 139 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1233 r0 *1 7.28,740.88
X$1233 142 570 569 145 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1238 m0 *1 17.36,740.88
X$1238 146 570 569 144 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1252 r0 *1 838.32,781.2
X$1252 569 147 228 570 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $1272 m0 *1 1597.12,750.96
X$1272 150 570 569 180 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1277 m0 *1 1592.08,761.04
X$1277 569 570 182 151 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1279 r0 *1 1592.64,740.88
X$1279 152 570 569 161 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1284 r0 *1 1601.04,740.88
X$1284 154 570 569 158 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1289 m0 *1 1601.04,740.88
X$1289 156 570 569 159 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1296 m0 *1 81.2,811.44
X$1296 569 404 157 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1298 r0 *1 81.2,811.44
X$1298 569 570 157 572 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $1318 r0 *1 1579.2,740.88
X$1318 569 570 158 170 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1333 r0 *1 2.24,761.04
X$1333 569 570 198 187 190 162 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1337 m0 *1 2.24,750.96
X$1337 162 570 569 203 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1344 m0 *1 2.8,761.04
X$1344 186 570 569 164 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1347 m0 *1 14,761.04
X$1347 165 570 569 185 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1359 m0 *1 1583.68,761.04
X$1359 168 570 569 197 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1365 r0 *1 1568,750.96
X$1365 169 570 569 183 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1371 r0 *1 1584.24,750.96
X$1371 171 570 569 173 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1375 r0 *1 1601.04,781.2
X$1375 569 570 192 172 194 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1383 m0 *1 1597.68,771.12
X$1383 569 570 199 174 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1388 r0 *1 1592.64,750.96
X$1388 175 570 569 182 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1392 m0 *1 1597.12,761.04
X$1392 569 570 200 176 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1397 m0 *1 1605.52,750.96
X$1397 569 570 179 177 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1401 r0 *1 1601.04,750.96
X$1401 178 570 569 179 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1416 m0 *1 1564.08,750.96
X$1416 569 570 192 184 183 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1430 r0 *1 2.24,781.2
X$1430 223 570 569 187 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1435 r0 *1 10.64,761.04
X$1435 569 570 188 189 190 206 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1438 m0 *1 2.24,781.2
X$1438 204 570 569 189 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1440 m0 *1 27.44,781.2
X$1440 569 570 208 216 190 207 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1444 m0 *1 10.64,791.28
X$1444 569 570 262 249 190 238 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1447 r0 *1 10.64,811.44
X$1447 569 570 296 297 190 316 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1449 r0 *1 10.64,831.6
X$1449 569 570 317 374 190 318 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1452 r0 *1 30.8,821.52
X$1452 569 570 319 336 190 307 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1454 r0 *1 24.08,791.28
X$1454 569 570 251 252 190 253 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1456 m0 *1 5.6,801.36
X$1456 569 570 268 269 190 270 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1458 m0 *1 39.2,791.28
X$1458 569 570 254 240 190 255 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1473 r0 *1 1591.52,801.36
X$1473 569 570 192 275 276 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1476 r0 *1 1587.6,831.6
X$1476 569 570 192 366 367 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1479 m0 *1 1590.96,871.92
X$1479 569 570 192 426 427 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1484 r0 *1 1579.76,841.68
X$1484 569 570 192 387 376 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1487 r0 *1 875.28,1587.6
X$1487 569 570 192 503 496 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1489 r0 *1 907.2,1597.68
X$1489 569 570 192 542 546 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1492 m0 *1 1583.12,831.6
X$1492 569 570 192 341 340 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1494 m0 *1 1583.12,821.52
X$1494 569 570 192 322 308 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1513 r0 *1 1588.72,761.04
X$1513 193 570 569 194 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1520 r0 *1 1601.04,761.04
X$1520 195 570 569 200 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1523 m0 *1 1601.04,761.04
X$1523 196 570 569 199 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1544 m0 *1 10.64,781.2
X$1544 206 570 569 202 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1551 m0 *1 25.76,771.12
X$1551 207 570 569 205 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1580 m0 *1 1584.8,771.12
X$1580 212 570 569 213 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1586 m0 *1 1601.04,771.12
X$1586 214 570 569 217 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1589 r0 *1 1601.04,771.12
X$1589 215 570 569 219 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1592 m0 *1 19.04,781.2
X$1592 224 570 569 216 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1601 m0 *1 1597.68,781.2
X$1601 569 570 218 241 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1604 m0 *1 1601.04,781.2
X$1604 234 570 569 218 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1607 r0 *1 1588.72,771.12
X$1607 569 570 219 221 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1622 r0 *1 1580.32,771.12
X$1622 222 570 569 236 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1630 r0 *1 26.88,781.2
X$1630 225 570 569 240 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1668 r0 *1 1583.68,781.2
X$1668 230 570 569 232 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1674 m0 *1 1587.6,781.2
X$1674 231 570 569 237 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1689 r0 *1 1606.08,781.2
X$1689 569 570 259 235 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1698 r0 *1 10.64,781.2
X$1698 238 570 569 247 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1706 r0 *1 19.04,781.2
X$1706 569 570 248 239 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1733 m0 *1 2.24,791.28
X$1733 246 570 569 249 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1742 m0 *1 19.04,791.28
X$1742 253 570 569 250 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1747 m0 *1 14,801.36
X$1747 266 570 569 252 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1764 m0 *1 27.44,791.28
X$1764 255 570 569 267 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1769 r0 *1 1593.76,811.44
X$1769 569 570 284 256 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1771 m0 *1 1597.68,801.36
X$1771 569 570 257 283 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1773 r0 *1 1592.64,791.28
X$1773 258 570 569 257 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1778 r0 *1 1601.04,791.28
X$1778 261 570 569 259 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1780 m0 *1 1599.92,791.28
X$1780 260 570 569 276 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1792 r0 *1 1597.68,801.36
X$1792 569 570 282 263 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1800 m0 *1 42.56,801.36
X$1800 569 570 265 281 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1812 m0 *1 2.24,811.44
X$1812 294 570 569 269 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1817 m0 *1 10.64,811.44
X$1817 270 570 569 293 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1820 r0 *1 776.72,801.36
X$1820 569 570 288 271 302 299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1826 m0 *1 1579.2,801.36
X$1826 272 570 569 277 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1830 r0 *1 1584.24,791.28
X$1830 273 570 569 284 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1833 r0 *1 1584.8,811.44
X$1833 569 570 311 274 302 278 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1849 m0 *1 1601.04,801.36
X$1849 278 570 569 280 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1852 r0 *1 1601.04,801.36
X$1852 279 570 569 282 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1857 m0 *1 753.76,801.36
X$1857 569 570 281 286 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1893 r0 *1 1506.4,801.36
X$1893 569 570 287 574 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1913 m0 *1 20.72,831.6
X$1913 300 570 569 290 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1916 r0 *1 27.44,811.44
X$1916 291 570 569 310 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1919 m0 *1 19.04,811.44
X$1919 299 570 569 292 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1926 m0 *1 2.24,831.6
X$1926 295 570 569 297 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1935 r0 *1 19.04,811.44
X$1935 307 570 569 298 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1951 m0 *1 844.48,1254.96
X$1951 569 570 301 573 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1961 r0 *1 844.48,1254.96
X$1961 569 441 301 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1974 r0 *1 1584.24,851.76
X$1974 569 570 406 389 302 407 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1976 m0 *1 799.68,1577.52
X$1976 569 570 459 462 302 451 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1978 r0 *1 775.04,1587.6
X$1978 569 570 504 484 302 485 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1981 m0 *1 1573.6,831.6
X$1981 569 570 351 350 302 303 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1984 r0 *1 768.32,1577.52
X$1984 569 570 480 460 302 461 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1986 r0 *1 1579.2,831.6
X$1986 569 570 321 329 302 368 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1988 r0 *1 758.24,821.52
X$1988 569 570 356 330 302 337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1992 r0 *1 1571.36,841.68
X$1992 569 570 386 365 302 388 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2012 m0 *1 1579.2,811.44
X$2012 303 570 569 304 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2016 m0 *1 1597.12,821.52
X$2016 305 570 569 324 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2019 r0 *1 1601.04,811.44
X$2019 306 570 569 308 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2045 m0 *1 2.24,851.76
X$2045 318 570 569 312 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2048 m0 *1 10.64,831.6
X$2048 316 570 569 313 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2051 r0 *1 19.04,831.6
X$2051 314 570 569 336 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2068 m0 *1 35.84,861.84
X$2068 569 404 315 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2100 r0 *1 1542.24,821.52
X$2100 569 570 353 339 338 320 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2102 r0 *1 1601.04,821.52
X$2102 320 570 569 327 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2112 r0 *1 1597.68,821.52
X$2112 569 570 324 323 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2119 r0 *1 1592.64,831.6
X$2119 368 570 569 325 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2122 r0 *1 1601.04,831.6
X$2122 326 570 569 375 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2127 m0 *1 1579.2,841.68
X$2127 328 570 569 340 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2138 m0 *1 35.28,831.6
X$2138 569 570 331 349 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $2141 m0 *1 27.44,841.68
X$2141 569 570 332 354 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $2144 m0 *1 19.04,851.76
X$2144 337 570 569 333 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2147 r0 *1 2.24,831.6
X$2147 334 570 569 374 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2150 r0 *1 27.44,831.6
X$2150 335 570 569 378 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2164 r0 *1 817.04,1567.44
X$2164 569 570 446 452 338 448 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2167 r0 *1 824.88,1577.52
X$2167 569 570 483 481 338 469 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2170 m0 *1 880.32,1597.68
X$2170 569 570 476 497 338 498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2173 r0 *1 902.16,1587.6
X$2173 569 570 501 499 338 500 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2175 m0 *1 838.88,1567.44
X$2175 569 570 449 450 338 447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2177 m0 *1 1567.44,871.92
X$2177 569 570 424 425 338 405 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2179 m0 *1 858.48,1577.52
X$2179 569 570 456 473 338 457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2181 r0 *1 816.48,1577.52
X$2181 569 570 482 464 338 453 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2184 m0 *1 862.96,1597.68
X$2184 569 570 479 508 338 475 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2199 r0 *1 1541.12,831.6
X$2199 570 364 569 348 339 352 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2204 m0 *1 1588.16,831.6
X$2204 570 341 569 348 350 342 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2207 m0 *1 1597.12,841.68
X$2207 569 570 375 342 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2212 m0 *1 1601.04,841.68
X$2212 343 570 569 370 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2215 m0 *1 1601.04,831.6
X$2215 344 570 569 346 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2218 r0 *1 1592.64,841.68
X$2218 345 570 569 367 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2221 r0 *1 1560.72,821.52
X$2221 569 570 346 352 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2226 m0 *1 1605.52,821.52
X$2226 569 570 370 347 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2228 m0 *1 1587.6,841.68
X$2228 570 366 569 348 365 347 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2234 m0 *1 844.48,1577.52
X$2234 570 454 569 348 450 458 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2240 r0 *1 856.24,1587.6
X$2240 570 470 569 348 473 472 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2242 r0 *1 881.44,1587.6
X$2242 570 503 569 348 497 502 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2245 r0 *1 899.36,1597.68
X$2245 570 542 569 348 499 550 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2247 r0 *1 865.76,1587.6
X$2247 570 494 569 348 508 474 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2250 r0 *1 1593.2,861.84
X$2250 570 426 569 348 425 408 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2252 m0 *1 1586.48,851.76
X$2252 570 387 569 348 389 394 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2270 r0 *1 739.76,821.52
X$2270 569 570 349 355 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2289 r0 *1 743.68,821.52
X$2289 569 570 354 357 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2306 m0 *1 10.64,851.76
X$2306 358 570 569 391 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2311 r0 *1 2.24,851.76
X$2311 359 570 569 412 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2314 r0 *1 28.56,841.68
X$2314 362 570 569 360 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2318 r0 *1 10.64,851.76
X$2318 569 570 361 412 402 377 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2347 r0 *1 1601.04,841.68
X$2347 369 570 569 376 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2352 m0 *1 1601.04,851.76
X$2352 371 570 569 392 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2355 r0 *1 1601.04,851.76
X$2355 407 570 569 372 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2358 r0 *1 1592.64,851.76
X$2358 388 570 569 373 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2376 r0 *1 19.04,851.76
X$2376 377 570 569 380 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2384 m0 *1 861.84,1607.76
X$2384 569 552 379 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2390 r0 *1 35.84,851.76
X$2390 385 570 569 381 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2393 m0 *1 19.04,861.84
X$2393 393 570 569 382 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2396 m0 *1 11.2,871.92
X$2396 383 570 569 413 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2400 r0 *1 27.44,851.76
X$2400 569 570 384 413 402 385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2422 m0 *1 1601.04,861.84
X$2422 390 570 569 411 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2425 m0 *1 10.64,861.84
X$2425 569 570 401 391 402 393 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2430 m0 *1 1597.68,851.76
X$2430 569 570 392 394 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2446 m0 *1 2.24,882
X$2446 403 570 569 395 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2451 m0 *1 2.24,861.84
X$2451 396 570 569 400 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2454 r0 *1 2.24,871.92
X$2454 420 570 569 397 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2457 m0 *1 27.44,882
X$2457 398 570 569 414 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2462 m0 *1 10.64,882
X$2462 399 570 569 422 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2466 r0 *1 10.64,871.92
X$2466 569 570 419 400 402 420 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2472 m0 *1 24.08,892.08
X$2472 569 570 434 436 402 437 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2476 m0 *1 27.44,861.84
X$2476 569 570 428 414 402 403 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2478 r0 *1 755.44,1597.68
X$2478 569 570 533 519 402 520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2480 m0 *1 23.52,871.92
X$2480 569 570 421 422 402 423 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2482 m0 *1 19.04,882
X$2482 569 570 438 433 402 435 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2485 m0 *1 6.72,902.16
X$2485 569 570 432 440 402 439 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2511 r0 *1 1601.04,861.84
X$2511 405 570 569 409 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2525 m0 *1 1597.12,861.84
X$2525 569 570 411 408 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2530 m0 *1 1601.04,871.92
X$2530 410 570 569 427 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2549 m0 *1 31.92,871.92
X$2549 423 570 569 415 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2552 r0 *1 2.24,892.08
X$2552 416 570 569 433 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2555 r0 *1 10.64,882
X$2555 435 570 569 417 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2558 m0 *1 2.24,912.24
X$2558 418 570 569 440 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2595 r0 *1 19.04,882
X$2595 429 570 569 436 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2598 r0 *1 4.48,902.16
X$2598 439 570 569 430 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2601 r0 *1 10.64,892.08
X$2601 437 570 569 431 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2642 r0 *1 734.72,1365.84
X$2642 569 441 445 570 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2651 m0 *1 843.92,1597.68
X$2651 442 570 569 515 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2692 r0 *1 837.2,1577.52
X$2692 447 570 569 548 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2700 r0 *1 827.12,1587.6
X$2700 448 570 569 490 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2715 m0 *1 808.08,1597.68
X$2715 451 570 569 540 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2723 m0 *1 827.12,1597.68
X$2723 453 570 569 491 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2729 m0 *1 847.28,1587.6
X$2729 516 570 569 455 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2735 m0 *1 854,1597.68
X$2735 457 570 569 553 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2742 m0 *1 866.88,1577.52
X$2742 569 570 478 458 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2754 m0 *1 787.92,1607.76
X$2754 461 570 569 557 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2762 m0 *1 816.48,1587.6
X$2762 569 570 463 511 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2764 m0 *1 808.08,1587.6
X$2764 509 570 569 463 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2768 m0 *1 823.2,1587.6
X$2768 569 570 465 466 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2770 r0 *1 823.2,1597.68
X$2770 541 570 569 465 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2774 r0 *1 833.28,1577.52
X$2774 569 570 467 468 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2776 m0 *1 824.88,1607.76
X$2776 562 570 569 467 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2783 m0 *1 845.04,1607.76
X$2783 469 570 569 565 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2788 r0 *1 856.8,1577.52
X$2788 569 570 471 472 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2790 r0 *1 851.76,1597.68
X$2790 549 570 569 471 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2797 r0 *1 868,1577.52
X$2797 569 570 510 474 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2800 r0 *1 868.56,1597.68
X$2800 475 570 569 554 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2808 r0 *1 846.72,1587.6
X$2808 493 570 569 477 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2813 m0 *1 853.44,1607.76
X$2813 564 570 569 478 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2841 r0 *1 783.44,1587.6
X$2841 485 570 569 486 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2847 m0 *1 804.72,1597.68
X$2847 569 570 524 487 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2850 r0 *1 810.32,1587.6
X$2850 569 570 525 488 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2853 r0 *1 814.24,1587.6
X$2853 569 570 526 489 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2864 m0 *1 835.52,1597.68
X$2864 527 570 569 492 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2871 m0 *1 871.36,1597.68
X$2871 498 570 569 495 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2875 r0 *1 876.96,1597.68
X$2875 529 570 569 496 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2892 m0 *1 901.04,1607.76
X$2892 500 570 569 568 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2902 r0 *1 889.28,1587.6
X$2902 569 570 531 502 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2915 m0 *1 784.56,1597.68
X$2915 569 570 523 505 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2920 m0 *1 787.92,1597.68
X$2920 569 570 507 506 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2927 r0 *1 789.04,1597.68
X$2927 537 570 569 507 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2938 r0 *1 860.16,1597.68
X$2938 551 570 569 510 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2946 m0 *1 841.68,1607.76
X$2946 569 570 528 512 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2952 m0 *1 819.84,1587.6
X$2952 569 570 514 513 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2955 m0 *1 816.48,1607.76
X$2955 561 570 569 514 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2967 r0 *1 845.6,1577.52
X$2967 569 570 518 517 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2971 r0 *1 843.36,1597.68
X$2971 547 570 569 518 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2976 m0 *1 752.64,1607.76
X$2976 555 570 569 519 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2981 m0 *1 761.6,1607.76
X$2981 520 570 569 556 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2985 r0 *1 777.28,1597.68
X$2985 569 570 536 521 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2987 r0 *1 780.64,1597.68
X$2987 522 570 569 523 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2994 m0 *1 799.68,1607.76
X$2994 559 570 569 524 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2997 r0 *1 805.84,1597.68
X$2997 539 570 569 525 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3000 m0 *1 808.08,1607.76
X$3000 560 570 569 526 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3005 m0 *1 833.28,1607.76
X$3005 563 570 569 528 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3011 r0 *1 885.36,1597.68
X$3011 530 570 569 546 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3016 m0 *1 878.08,1607.76
X$3016 566 570 569 531 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3018 m0 *1 886.48,1607.76
X$3018 567 570 569 532 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3020 m0 *1 894.88,1607.76
X$3020 569 570 532 550 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $148160 m0 *1 775.04,1607.76
X$148160 569 570 535 534 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $148163 m0 *1 778.4,1607.76
X$148163 558 570 569 535 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $148168 r0 *1 797.44,1597.68
X$148168 538 570 569 536 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $192848 r0 *1 831.6,1597.68
X$192848 569 570 544 543 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $192855 r0 *1 834.96,1597.68
X$192855 545 570 569 544 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS network_interface

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_2
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_2 1 2 3 4 5 6
* net 1 ZN
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A1
* net 6 A3
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 6 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 9 4 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 1 5 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 8 5 1 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 4 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 6 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 3 6 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.553P PS=3.77U PD=3.77U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 1 4 3 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 3 5 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin A2
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_4 1 2 3 4 5 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 A2
* net 5 B
* net 11 NWELL,VDD
* device instance $1 r0 *1 1.07,3.785 pmos_5p0
M$1 2 4 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1594P PS=11.59U PD=9.68U
* device instance $2 r0 *1 2.09,3.785 pmos_5p0
M$2 10 3 2 11 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.51,3.785 pmos_5p0
M$9 11 5 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $13 r0 *1 1.14,1 nmos_5p0
M$13 7 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $14 r0 *1 1.98,1 nmos_5p0
M$14 2 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $15 r0 *1 3.1,1 nmos_5p0
M$15 6 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $16 r0 *1 3.94,1 nmos_5p0
M$16 1 4 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 5.06,1 nmos_5p0
M$17 8 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $18 r0 *1 5.9,1 nmos_5p0
M$18 2 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $19 r0 *1 7.02,1 nmos_5p0
M$19 9 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $20 r0 *1 7.86,1 nmos_5p0
M$20 1 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.402P PS=1.56U PD=2.02U
* device instance $21 r0 *1 9.16,1.2 nmos_5p0
M$21 2 5 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1196P AD=1.1224P PS=6.34U PD=7.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 4 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 10 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 7 5 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 9 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 4 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 11 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 7 5 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6292P PS=2.4U PD=2.55U
* device instance $9 r0 *1 9.93,3.872 pmos_5p0
M$9 4 2 7 7 pmos_5p0 L=0.5U W=6.58U AS=2.117925P AD=2.212525P PS=9.295U
+ PD=10.915U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 4 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 2.04,1.005 nmos_5p0
M$14 3 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $21 r0 *1 9.88,1.005 nmos_5p0
M$21 1 2 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.2692P PS=11.89U PD=9.8U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.5384P AD=4.7763P PS=19.6U PD=21.69U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $17 r0 *1 5.4,1.005 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.7456P AD=2.9832P PS=14.72U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_8

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_16 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=29.28U AS=9.3147P AD=9.3147P PS=41.29U PD=41.29U
* device instance $17 r0 *1 0.92,1.3 nmos_5p0
M$17 3 2 1 1 nmos_5p0 L=0.6U W=11.68U AS=3.1682P AD=3.1682P PS=21.09U PD=21.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_16

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_4 1 2 3 4 5 6 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A2
* net 4 A1
* net 5 B
* net 6 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 1.54,3.78 pmos_5p0
M$1 2 3 11 12 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1411P PS=11.59U PD=9.66U
* device instance $2 r0 *1 2.56,3.78 pmos_5p0
M$2 11 4 2 12 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.96,3.78 pmos_5p0
M$9 13 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.5673P PS=2.61U PD=2.45U
* device instance $10 r0 *1 11.08,3.78 pmos_5p0
M$10 12 6 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $11 r0 *1 12.62,3.78 pmos_5p0
M$11 14 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $12 r0 *1 13.74,3.78 pmos_5p0
M$12 11 5 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $13 r0 *1 15.28,3.78 pmos_5p0
M$13 16 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $14 r0 *1 16.4,3.78 pmos_5p0
M$14 12 6 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $15 r0 *1 17.94,3.78 pmos_5p0
M$15 15 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $16 r0 *1 19.06,3.78 pmos_5p0
M$16 11 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $17 r0 *1 9.96,1.08 nmos_5p0
M$17 2 5 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.33065P AD=0.9638P PS=6.745U PD=6.39U
* device instance $18 r0 *1 11.08,1.08 nmos_5p0
M$18 2 6 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.5056P AD=0.8216P PS=7.04U PD=5.24U
* device instance $25 r0 *1 1.54,0.937 nmos_5p0
M$25 7 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.74655P AD=0.219225P PS=3.63U
+ PD=1.555U
* device instance $26 r0 *1 2.51,0.937 nmos_5p0
M$26 2 4 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.63,0.937 nmos_5p0
M$27 9 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 4.55,0.937 nmos_5p0
M$28 1 3 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.67,0.937 nmos_5p0
M$29 8 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 6.59,0.937 nmos_5p0
M$30 2 4 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.71,0.937 nmos_5p0
M$31 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $32 r0 *1 8.63,0.937 nmos_5p0
M$32 1 3 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.37245P PS=1.505U
+ PD=1.915U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_4

* cell gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyc_2 1 7 11 13
* net 1 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* net 11 I
* net 13 NWELL,VDD
* device instance $1 r0 *1 8.34,3.365 pmos_5p0
M$1 6 5 17 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 8.34,4.085 pmos_5p0
M$2 17 5 13 13 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 10.14,3.785 pmos_5p0
M$3 7 6 13 13 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 4.34,3.365 pmos_5p0
M$5 4 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $6 r0 *1 6.18,3.365 pmos_5p0
M$6 16 4 5 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $7 r0 *1 4.34,4.085 pmos_5p0
M$7 13 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $8 r0 *1 6.18,4.085 pmos_5p0
M$8 13 4 16 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $9 r0 *1 2.18,3.365 pmos_5p0
M$9 15 2 3 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $10 r0 *1 0.87,4.085 pmos_5p0
M$10 13 11 2 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $11 r0 *1 2.18,4.085 pmos_5p0
M$11 13 2 15 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $12 r0 *1 0.92,0.795 nmos_5p0
M$12 1 11 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $13 r0 *1 2.23,0.795 nmos_5p0
M$13 12 2 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $14 r0 *1 2.23,1.515 nmos_5p0
M$14 3 2 12 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $15 r0 *1 4.39,0.52 nmos_5p0
M$15 1 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.2232P PS=1.98U PD=1.6U
* device instance $16 r0 *1 6.23,0.52 nmos_5p0
M$16 10 4 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.2232P AD=0.27P PS=1.6U PD=1.98U
* device instance $17 r0 *1 4.39,1.24 nmos_5p0
M$17 4 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $18 r0 *1 6.23,1.24 nmos_5p0
M$18 5 4 10 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $19 r0 *1 8.39,0.525 nmos_5p0
M$19 1 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $20 r0 *1 8.39,1.245 nmos_5p0
M$20 6 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $21 r0 *1 10.19,1.005 nmos_5p0
M$21 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyc_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_2
* pin NWELL,VDD
* pin B2
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B2
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.4758P PS=4.54U PD=2.35U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 6 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $5 r0 *1 5.45,3.78 pmos_5p0
M$5 11 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 6 7 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 10 7 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 6 5 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $14 r0 *1 6.52,1.005 nmos_5p0
M$14 8 7 6 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 A3
* device instance $1 r0 *1 0.92,3.872 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.93765P PS=6.72U PD=4.43U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 11 5 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 4 6 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 6 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 9 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 7 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $11 r0 *1 3.16,1.005 nmos_5p0
M$11 4 7 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2342P PS=3.68U PD=5.83U
* device instance $12 r0 *1 4.28,1.005 nmos_5p0
M$12 8 5 4 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 4 6 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_2

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_4 1 2 3 4 5 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS,gf180mcu_gnd
* net 5 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.87,3.595 pmos_5p0
M$1 6 1 5 5 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.0012P PS=5.78U PD=4.55U
* device instance $2 r0 *1 1.89,3.595 pmos_5p0
M$2 5 2 6 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.595 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 7 6 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.049P AD=2.2326P PS=9.62U PD=11.59U
* device instance $11 r0 *1 1,1.005 nmos_5p0
M$11 11 1 4 4 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $12 r0 *1 1.84,1.005 nmos_5p0
M$12 10 2 11 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.2772P PS=1.56U PD=1.74U
* device instance $13 r0 *1 2.86,1.005 nmos_5p0
M$13 6 3 10 4 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $14 r0 *1 3.98,1.005 nmos_5p0
M$14 9 3 6 4 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $15 r0 *1 4.9,1.005 nmos_5p0
M$15 8 2 9 4 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.1584P PS=1.64U PD=1.56U
* device instance $16 r0 *1 5.74,1.005 nmos_5p0
M$16 4 1 8 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 6.86,1.005 nmos_5p0
M$17 7 6 4 4 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin C
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_2 1 3 4 5 6 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 NWELL,VDD
* net 5 B1
* net 6 C
* net 8 A2
* net 9 ZN
* net 10 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 2 6 7 4 pmos_5p0 L=0.5U W=3.66U AS=1.4457P AD=0.983625P PS=7.07U PD=4.735U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.1163P PS=4.7U PD=4.88U
* device instance $3 r0 *1 3.01,3.78 pmos_5p0
M$3 2 5 4 4 pmos_5p0 L=0.5U W=3.66U AS=0.9699P AD=0.9699P PS=4.72U PD=4.72U
* device instance $7 r0 *1 7.325,3.78 pmos_5p0
M$7 9 10 7 4 pmos_5p0 L=0.5U W=3.66U AS=0.983625P AD=1.281P PS=4.735U PD=6.89U
* device instance $8 r0 *1 8.345,3.78 pmos_5p0
M$8 7 8 9 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $11 r0 *1 6.32,0.875 nmos_5p0
M$11 9 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.711P AD=0.709025P PS=3.77U PD=4.36U
* device instance $13 r0 *1 2.22,1.072 nmos_5p0
M$13 14 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1422P PS=1.885U PD=1.425U
* device instance $14 r0 *1 3.06,1.072 nmos_5p0
M$14 9 5 14 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 4.18,1.072 nmos_5p0
M$15 12 5 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 5.02,1.072 nmos_5p0
M$16 1 3 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
* device instance $17 r0 *1 7.635,1.072 nmos_5p0
M$17 13 10 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.361425P AD=0.1422P PS=1.9U
+ PD=1.425U
* device instance $18 r0 *1 8.475,1.072 nmos_5p0
M$18 1 8 13 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $19 r0 *1 9.595,1.072 nmos_5p0
M$19 11 8 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $20 r0 *1 10.435,1.072 nmos_5p0
M$20 9 10 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.5214P PS=1.425U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai32_2
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
* pin B2
* pin ZN
* pin B1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai32_2 1 2 3 4 5 7 8 9
* net 1 NWELL,VDD
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 A1
* net 5 A3
* net 7 B2
* net 8 ZN
* net 9 B1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 15 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 14 3 15 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 14 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 13 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 11 3 13 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 5 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.6588P PS=2.45U PD=2.55U
* device instance $7 r0 *1 7.69,3.78 pmos_5p0
M$7 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 8 9 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.88,3.78 pmos_5p0
M$9 10 9 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $10 r0 *1 10.95,3.78 pmos_5p0
M$10 1 7 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $11 r0 *1 0.92,1.005 nmos_5p0
M$11 2 5 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $12 r0 *1 2.04,1.005 nmos_5p0
M$12 6 3 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 3.16,1.005 nmos_5p0
M$13 2 4 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 7.64,1.005 nmos_5p0
M$17 8 7 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2408P PS=3.68U PD=5.84U
* device instance $18 r0 *1 8.76,1.005 nmos_5p0
M$18 6 9 8 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai32_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffsnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin SETN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffsnq_4 1 10 11 12 13 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 10 Q
* net 11 CLK
* net 12 D
* net 13 SETN
* net 17 NWELL,VDD
* device instance $1 r0 *1 14.415,3.365 pmos_5p0
M$1 8 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $2 r0 *1 15.435,3.365 pmos_5p0
M$2 17 9 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.536P PS=1.52U PD=2.57U
* device instance $3 r0 *1 16.675,3.78 pmos_5p0
M$3 9 2 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.0118P AD=0.9516P PS=4.92U PD=4.7U
* device instance $5 r0 *1 18.715,3.78 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=2.2326P PS=9.4U PD=11.59U
* device instance $9 r0 *1 11.335,3.365 pmos_5p0
M$9 2 3 7 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.42P PS=2.88U PD=1.84U
* device instance $10 r0 *1 12.675,3.365 pmos_5p0
M$10 8 4 2 17 pmos_5p0 L=0.5U W=1U AS=0.42P AD=0.44P PS=1.84U PD=2.88U
* device instance $11 r0 *1 0.97,3.555 pmos_5p0
M$11 17 11 3 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $12 r0 *1 1.99,3.555 pmos_5p0
M$12 4 3 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $13 r0 *1 3.93,3.465 pmos_5p0
M$13 5 12 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.3825P PS=2.88U PD=1.765U
* device instance $14 r0 *1 5.195,3.465 pmos_5p0
M$14 6 4 5 17 pmos_5p0 L=0.5U W=1U AS=0.3825P AD=0.26P PS=1.765U PD=1.52U
* device instance $15 r0 *1 6.215,3.465 pmos_5p0
M$15 18 3 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2P PS=1.52U PD=1.4U
* device instance $16 r0 *1 7.115,3.465 pmos_5p0
M$16 17 7 18 17 pmos_5p0 L=0.5U W=1U AS=0.2P AD=0.26P PS=1.4U PD=1.52U
* device instance $17 r0 *1 8.135,3.465 pmos_5p0
M$17 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $18 r0 *1 9.155,3.465 pmos_5p0
M$18 17 13 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.7374P PS=1.52U PD=3.75U
* device instance $19 r0 *1 14.545,1.37 nmos_5p0
M$19 16 13 8 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.0708P PS=2.06U PD=0.83U
* device instance $20 r0 *1 15.385,1.37 nmos_5p0
M$20 16 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.3789P AD=0.0708P PS=2.06U PD=0.83U
* device instance $21 r0 *1 16.725,1.005 nmos_5p0
M$21 9 2 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7221P AD=0.6864P PS=3.9U PD=3.68U
* device instance $23 r0 *1 18.965,1.005 nmos_5p0
M$23 10 9 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
* device instance $27 r0 *1 0.92,1.27 nmos_5p0
M$27 1 11 3 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $28 r0 *1 2.04,1.27 nmos_5p0
M$28 4 3 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $29 r0 *1 3.88,1.37 nmos_5p0
M$29 5 12 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $30 r0 *1 5,1.37 nmos_5p0
M$30 6 3 5 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 6.12,1.37 nmos_5p0
M$31 14 4 6 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.101775P PS=1.11U PD=0.935U
* device instance $32 r0 *1 7.065,1.37 nmos_5p0
M$32 1 7 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.101775P AD=0.1534P PS=0.935U PD=1.11U
* device instance $33 r0 *1 8.185,1.37 nmos_5p0
M$33 15 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0944P PS=1.11U PD=0.91U
* device instance $34 r0 *1 9.105,1.37 nmos_5p0
M$34 7 13 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0944P AD=0.1652P PS=0.91U PD=1.15U
* device instance $35 r0 *1 10.265,1.37 nmos_5p0
M$35 2 4 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1652P AD=0.1534P PS=1.15U PD=1.11U
* device instance $36 r0 *1 11.385,1.37 nmos_5p0
M$36 8 3 2 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.2596P PS=1.11U PD=2.06U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffsnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__buf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.4038P PS=16.79U PD=14.7U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.8076P AD=7.0455P PS=29.4U PD=31.49U
* device instance $19 r0 *1 0.97,1.005 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=7.92U AS=2.2968P AD=2.0592P PS=12.72U PD=11.04U
* device instance $25 r0 *1 7.69,1.005 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=15.84U AS=4.1184P AD=4.356P PS=22.08U PD=23.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_12

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_4 1 3 4 5 6 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 RN
* net 4 Q
* net 5 CLK
* net 6 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 16.975,3.78 pmos_5p0
M$1 4 13 17 17 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U PD=11.59U
* device instance $5 r0 *1 9.55,3.71 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.285P PS=2.88U PD=1.57U
* device instance $6 r0 *1 10.62,3.71 pmos_5p0
M$6 11 2 10 17 pmos_5p0 L=0.5U W=1U AS=0.285P AD=0.26P PS=1.57U PD=1.52U
* device instance $7 r0 *1 11.64,3.71 pmos_5p0
M$7 12 8 11 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2875P PS=1.52U PD=1.575U
* device instance $8 r0 *1 12.715,3.71 pmos_5p0
M$8 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.5457P AD=0.2875P PS=2.57U PD=1.575U
* device instance $9 r0 *1 13.955,3.78 pmos_5p0
M$9 13 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5457P AD=0.4758P PS=2.57U PD=2.35U
* device instance $10 r0 *1 14.975,3.78 pmos_5p0
M$10 17 11 13 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $11 r0 *1 3.73,3.41 pmos_5p0
M$11 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $12 r0 *1 4.75,3.41 pmos_5p0
M$12 9 8 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 5.77,3.41 pmos_5p0
M$13 18 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $14 r0 *1 6.79,3.41 pmos_5p0
M$14 17 10 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $15 r0 *1 7.81,3.41 pmos_5p0
M$15 18 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $16 r0 *1 0.97,3.555 pmos_5p0
M$16 17 5 2 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $17 r0 *1 1.99,3.555 pmos_5p0
M$17 8 2 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $18 r0 *1 16.925,1.005 nmos_5p0
M$18 4 13 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $22 r0 *1 3.9,1.315 nmos_5p0
M$22 7 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $23 r0 *1 5.02,1.315 nmos_5p0
M$23 9 2 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $24 r0 *1 6.14,1.315 nmos_5p0
M$24 15 8 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0708P PS=1.11U PD=0.83U
* device instance $25 r0 *1 6.98,1.315 nmos_5p0
M$25 14 10 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.0826P PS=0.83U PD=0.87U
* device instance $26 r0 *1 7.86,1.315 nmos_5p0
M$26 1 3 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.0826P AD=0.2124P PS=0.87U PD=1.31U
* device instance $27 r0 *1 9.18,1.315 nmos_5p0
M$27 10 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2124P AD=0.190275P PS=1.31U PD=1.235U
* device instance $28 r0 *1 10.425,1.315 nmos_5p0
M$28 11 8 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.190275P AD=0.1534P PS=1.235U
+ PD=1.11U
* device instance $29 r0 *1 11.545,1.315 nmos_5p0
M$29 12 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $30 r0 *1 12.665,1.315 nmos_5p0
M$30 1 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 13.785,1.315 nmos_5p0
M$31 1 3 16 1 nmos_5p0 L=0.6U W=0.59U AS=0.3525P AD=0.1534P PS=2.02U PD=1.11U
* device instance $32 r0 *1 15.085,1.005 nmos_5p0
M$32 13 11 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3525P AD=0.5808P PS=2.02U PD=3.52U
* device instance $33 r0 *1 0.92,1.27 nmos_5p0
M$33 1 5 2 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $34 r0 *1 2.04,1.27 nmos_5p0
M$34 8 2 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 8 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 8 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 9 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 9 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 10 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 10 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.673P PS=26.59U PD=24.5U
* device instance $11 r0 *1 12.07,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.346P AD=11.5839P PS=49U PD=51.09U
* device instance $31 r0 *1 0.92,1.005 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=13.2U AS=3.6696P AD=3.432P PS=20.08U PD=18.4U
* device instance $41 r0 *1 12.12,1.005 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=26.4U AS=6.864P AD=7.1016P PS=36.8U PD=38.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_20

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.2993P PS=6.99U PD=5.08U
* device instance $3 r0 *1 3.29,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.5071P PS=9.98U PD=11.89U
* device instance $7 r0 *1 0.92,1.23 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.4593P PS=3.59U PD=2.75U
* device instance $9 r0 *1 3.34,1.265 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=3.2U AS=0.8935P AD=0.976P PS=5.46U PD=6.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.8377P PS=26.59U PD=24.68U
* device instance $11 r0 *1 12.25,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.5107P AD=11.5839P PS=49.18U PD=51.09U
* device instance $31 r0 *1 0.92,1.3 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=7.3U AS=2.1091P AD=1.898P PS=13.84U PD=12.5U
* device instance $41 r0 *1 12.3,1.265 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=16U AS=4.2215P AD=4.304P PS=26.58U PD=27.56U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 10 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 9 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 11 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin B1
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_4 1 3 4 5 6 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 B1
* net 5 A2
* net 6 A1
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 8 4 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 11 4 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 7 3 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 10 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 8 4 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 12 4 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 7 3 12 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $9 r0 *1 9.93,3.78 pmos_5p0
M$9 13 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $10 r0 *1 11,3.78 pmos_5p0
M$10 8 6 13 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $11 r0 *1 12.12,3.78 pmos_5p0
M$11 15 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $12 r0 *1 13.24,3.78 pmos_5p0
M$12 7 5 15 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $13 r0 *1 14.36,3.78 pmos_5p0
M$13 14 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $14 r0 *1 15.48,3.78 pmos_5p0
M$14 8 6 14 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $15 r0 *1 16.6,3.78 pmos_5p0
M$15 16 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $16 r0 *1 17.67,3.78 pmos_5p0
M$16 7 5 16 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 1 3 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $18 r0 *1 2.04,1.005 nmos_5p0
M$18 2 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $25 r0 *1 9.88,1.005 nmos_5p0
M$25 8 5 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.9272P PS=7.36U PD=9.52U
* device instance $26 r0 *1 11,1.005 nmos_5p0
M$26 2 6 8 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,0.995 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=2.19U AS=0.7008P AD=0.7008P PS=4.84U PD=4.84U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_3

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_2 1 2 3 4 5 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 NWELL,VDD
* net 4 B1
* net 5 ZN
* net 7 A2
* net 8 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 6 3 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.9516P PS=6.89U PD=4.7U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 6 4 3 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 4.95,3.78 pmos_5p0
M$5 5 7 6 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.281P PS=4.7U PD=6.89U
* device instance $6 r0 *1 5.97,3.78 pmos_5p0
M$6 6 8 5 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 12 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 5 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 11 4 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 1 2 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 10 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 5 8 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 9 8 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_2

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
