* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT shift_register_left clk en load parallel_in[0] parallel_in[1]
+ parallel_in[2] parallel_in[3] parallel_in[4] parallel_in[5]
+ parallel_in[6] parallel_in[7] parallel_out[0] parallel_out[1]
+ parallel_out[2] parallel_out[3] parallel_out[4] parallel_out[5]
+ parallel_out[6] parallel_out[7] rst_n serial_in serial_out
X_35_ rst_n _08_ VDD VSS CLKBUF_X2
X_36_ en _09_ VDD VSS BUF_X4
X_37_ net10 net9 _09_ _10_ VDD VSS MUX2_X1
X_38_ load _11_ VDD VSS CLKBUF_X3
X_39_ _10_ net1 _11_ _12_ VDD VSS MUX2_X1
X_40_ _08_ _12_ _00_ VDD VSS AND2_X1
X_41_ net11 net10 _09_ _13_ VDD VSS MUX2_X1
X_42_ _13_ net2 _11_ _14_ VDD VSS MUX2_X1
X_43_ _08_ _14_ _01_ VDD VSS AND2_X1
X_44_ net12 net11 _09_ _15_ VDD VSS MUX2_X1
X_45_ _15_ net3 _11_ _16_ VDD VSS MUX2_X1
X_46_ _08_ _16_ _02_ VDD VSS AND2_X1
X_47_ net13 net12 _09_ _17_ VDD VSS MUX2_X1
X_48_ _17_ net4 _11_ _18_ VDD VSS MUX2_X1
X_49_ _08_ _18_ _03_ VDD VSS AND2_X1
X_50_ net14 net13 _09_ _19_ VDD VSS MUX2_X1
X_51_ _19_ net5 _11_ _20_ VDD VSS MUX2_X1
X_52_ _08_ _20_ _04_ VDD VSS AND2_X1
X_53_ net15 net14 _09_ _21_ VDD VSS MUX2_X1
X_54_ _21_ net6 _11_ _22_ VDD VSS MUX2_X1
X_55_ _08_ _22_ _05_ VDD VSS AND2_X1
X_56_ net16 net15 _09_ _23_ VDD VSS MUX2_X1
X_57_ _23_ net7 _11_ _24_ VDD VSS MUX2_X1
X_58_ _08_ _24_ _06_ VDD VSS AND2_X1
X_59_ net18 net16 _09_ _25_ VDD VSS MUX2_X1
X_60_ _25_ net8 _11_ _26_ VDD VSS MUX2_X1
X_61_ _08_ _26_ _07_ VDD VSS AND2_X1
X_62_ net18 net17 VDD VSS BUF_X1
Xparallel_out\[0\]$_SDFFE_PN0P_ _00_ clknet_1_0__leaf_clk
+ net10 _34_ VDD VSS DFF_X1
Xparallel_out\[1\]$_SDFFE_PN0P_ _01_ clknet_1_0__leaf_clk
+ net11 _33_ VDD VSS DFF_X1
Xparallel_out\[2\]$_SDFFE_PN0P_ _02_ clknet_1_0__leaf_clk
+ net12 _32_ VDD VSS DFF_X1
Xparallel_out\[3\]$_SDFFE_PN0P_ _03_ clknet_1_0__leaf_clk
+ net13 _31_ VDD VSS DFF_X1
Xparallel_out\[4\]$_SDFFE_PN0P_ _04_ clknet_1_1__leaf_clk
+ net14 _30_ VDD VSS DFF_X1
Xparallel_out\[5\]$_SDFFE_PN0P_ _05_ clknet_1_1__leaf_clk
+ net15 _29_ VDD VSS DFF_X1
Xparallel_out\[6\]$_SDFFE_PN0P_ _06_ clknet_1_1__leaf_clk
+ net16 _28_ VDD VSS DFF_X1
Xparallel_out\[7\]$_SDFFE_PN0P_ _07_ clknet_1_1__leaf_clk
+ net18 _27_ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_57 VDD VSS TAPCELL_X1
Xinput1 parallel_in[0] net1 VDD VSS BUF_X1
Xinput2 parallel_in[1] net2 VDD VSS BUF_X1
Xinput3 parallel_in[2] net3 VDD VSS BUF_X1
Xinput4 parallel_in[3] net4 VDD VSS BUF_X1
Xinput5 parallel_in[4] net5 VDD VSS BUF_X1
Xinput6 parallel_in[5] net6 VDD VSS BUF_X1
Xinput7 parallel_in[6] net7 VDD VSS BUF_X1
Xinput8 parallel_in[7] net8 VDD VSS BUF_X1
Xinput9 serial_in net9 VDD VSS BUF_X1
Xoutput10 net10 parallel_out[0] VDD VSS BUF_X1
Xoutput11 net11 parallel_out[1] VDD VSS BUF_X1
Xoutput12 net12 parallel_out[2] VDD VSS BUF_X1
Xoutput13 net13 parallel_out[3] VDD VSS BUF_X1
Xoutput14 net14 parallel_out[4] VDD VSS BUF_X1
Xoutput15 net15 parallel_out[5] VDD VSS BUF_X1
Xoutput16 net16 parallel_out[6] VDD VSS BUF_X1
Xoutput17 net17 parallel_out[7] VDD VSS BUF_X1
Xoutput18 net18 serial_out VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ CLKBUF_X3
.ENDS shift_register_left
