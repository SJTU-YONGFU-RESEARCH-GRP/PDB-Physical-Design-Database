* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT bsg_async_credit_counter r_clk_i r_credits_avail_o
+ r_dec_credit_i r_infinite_credits_i r_reset_i w_clk_i w_inc_token_i
+ w_reset_i
X_29_ net5 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__buf_4
X_30_ bapg.w_ptr_n\[0\] bapg.w_ptr_n\[1\] VSS VSS VDD VDD
+ _09_ sky130_fd_sc_hd__xnor2_1
X_31_ bapg.w_ptr_gray_r\[0\] _08_ VSS VSS VDD VDD _10_ sky130_fd_sc_hd__nor2_1
X_32_ _08_ _09_ _10_ net6 VSS VSS VDD VDD _00_ sky130_fd_sc_hd__a211oi_1
X_33_ bapg.w_ptr_binary_r_o\[2\] bapg.w_ptr_n\[1\] _27_ VSS
+ VSS VDD VDD _11_ sky130_fd_sc_hd__xor3_1
X_34_ bapg.w_ptr_gray_r\[1\] _11_ _08_ VSS VSS VDD VDD _12_
+ sky130_fd_sc_hd__mux2i_1
X_35_ net6 _12_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__nor2_1
X_36_ _08_ _27_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__nand2_1
X_37_ bapg.w_ptr_binary_r_o\[2\] _13_ VSS VSS VDD VDD _14_
+ sky130_fd_sc_hd__xor2_1
X_38_ net6 _14_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__nor2_1
X_39_ bapg.w_ptr_binary_r_o\[0\] bapg.w_ptr_n\[0\] _08_ VSS
+ VSS VDD VDD _15_ sky130_fd_sc_hd__mux2i_1
X_40_ net6 _15_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__nor2_1
X_41_ bapg.w_ptr_binary_r_o\[1\] bapg.w_ptr_n\[1\] _08_ VSS
+ VSS VDD VDD _16_ sky130_fd_sc_hd__mux2i_1
X_42_ net6 _16_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__nor2_1
X_43_ r_counter_r\[0\] net2 VSS VSS VDD VDD _17_ sky130_fd_sc_hd__xnor2_1
X_44_ net4 _17_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__nor2_1
X_45_ r_counter_r\[1\] r_counter_r_hi_bits_gray\[0\] net2
+ VSS VSS VDD VDD _18_ sky130_fd_sc_hd__mux2i_1
X_46_ net4 _18_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__nor2_1
X_47_ _28_ net2 r_counter_r\[2\] VSS VSS VDD VDD _19_ sky130_fd_sc_hd__a21oi_1
X_48_ r_counter_r\[2\] _28_ net2 VSS VSS VDD VDD _20_ sky130_fd_sc_hd__and3_1
X_49_ _19_ _20_ net4 VSS VSS VDD VDD _07_ sky130_fd_sc_hd__o21bai_1
X_50_ r_counter_r\[1\] bapg.w_ptr_gray_r_rsync_o\[1\] VSS
+ VSS VDD VDD _21_ sky130_fd_sc_hd__xor2_1
X_51_ r_counter_r\[2\] bapg.w_ptr_gray_r_rsync_o\[2\] _21_
+ VSS VSS VDD VDD _22_ sky130_fd_sc_hd__and3_1
X_52_ r_counter_r\[2\] bapg.w_ptr_gray_r_rsync_o\[2\] _21_
+ VSS VSS VDD VDD _23_ sky130_fd_sc_hd__nor3_1
X_53_ r_counter_r_hi_bits_gray\[0\] bapg.w_ptr_gray_r_rsync_o\[0\]
+ VSS VSS VDD VDD _24_ sky130_fd_sc_hd__xor2_1
X_54_ net3 _24_ VSS VSS VDD VDD _25_ sky130_fd_sc_hd__nor2_1
X_55_ _22_ _23_ _25_ VSS VSS VDD VDD net7 sky130_fd_sc_hd__o21ai_0
X_56_ net5 bapg.w_ptr_binary_r_o\[0\] VSS VSS VDD VDD _26_
+ bapg.w_ptr_n\[0\] sky130_fd_sc_hd__ha_1
X_57_ bapg.w_ptr_binary_r_o\[1\] _26_ VSS VSS VDD VDD _27_
+ bapg.w_ptr_n\[1\] sky130_fd_sc_hd__ha_1
X_58_ r_counter_r\[0\] r_counter_r\[1\] VSS VSS VDD VDD _28_
+ r_counter_r_hi_bits_gray\[0\] sky130_fd_sc_hd__ha_1
Xbapg.w_ptr_gray_r\[0\]$_SDFFE_PP0P_ clknet_1_1__leaf_w_clk_i
+ _00_ VSS VSS VDD VDD bapg.w_ptr_gray_r\[0\] sky130_fd_sc_hd__dfxtp_1
Xbapg.w_ptr_gray_r\[1\]$_SDFFE_PP0P_ clknet_1_1__leaf_w_clk_i
+ _01_ VSS VSS VDD VDD bapg.w_ptr_gray_r\[1\] sky130_fd_sc_hd__dfxtp_1
Xbapg.w_ptr_gray_r\[2\]$_SDFFE_PP0P_ clknet_1_1__leaf_w_clk_i
+ _02_ VSS VSS VDD VDD bapg.w_ptr_binary_r_o\[2\] sky130_fd_sc_hd__dfxtp_1
Xbapg.w_ptr_gray_r_rsync_r\[0\]\[0\]$_DFF_P_ net1 bapg.w_ptr_gray_r\[0\]
+ VSS VSS VDD VDD bapg.w_ptr_gray_r_rsync_r\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xbapg.w_ptr_gray_r_rsync_r\[0\]\[1\]$_DFF_P_ net1 bapg.w_ptr_gray_r\[1\]
+ VSS VSS VDD VDD bapg.w_ptr_gray_r_rsync_r\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xbapg.w_ptr_gray_r_rsync_r\[0\]\[2\]$_DFF_P_ net1 bapg.w_ptr_binary_r_o\[2\]
+ VSS VSS VDD VDD bapg.w_ptr_gray_r_rsync_r\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xbapg.w_ptr_gray_r_rsync_r\[1\]\[0\]$_DFF_P_ net1 bapg.w_ptr_gray_r_rsync_r\[0\]\[0\]
+ VSS VSS VDD VDD bapg.w_ptr_gray_r_rsync_o\[0\] sky130_fd_sc_hd__dfxtp_1
Xbapg.w_ptr_gray_r_rsync_r\[1\]\[1\]$_DFF_P_ net1 bapg.w_ptr_gray_r_rsync_r\[0\]\[1\]
+ VSS VSS VDD VDD bapg.w_ptr_gray_r_rsync_o\[1\] sky130_fd_sc_hd__dfxtp_1
Xbapg.w_ptr_gray_r_rsync_r\[1\]\[2\]$_DFF_P_ net1 bapg.w_ptr_gray_r_rsync_r\[0\]\[2\]
+ VSS VSS VDD VDD bapg.w_ptr_gray_r_rsync_o\[2\] sky130_fd_sc_hd__dfxtp_1
Xbapg.w_ptr_r\[0\]$_SDFFE_PP0P_ clknet_1_0__leaf_w_clk_i _03_
+ VSS VSS VDD VDD bapg.w_ptr_binary_r_o\[0\] sky130_fd_sc_hd__dfxtp_1
Xbapg.w_ptr_r\[1\]$_SDFFE_PP0P_ clknet_1_0__leaf_w_clk_i _04_
+ VSS VSS VDD VDD bapg.w_ptr_binary_r_o\[1\] sky130_fd_sc_hd__dfxtp_1
Xr_counter_r\[0\]$_SDFFE_PP0P_ net1 _05_ VSS VSS VDD VDD r_counter_r\[0\]
+ sky130_fd_sc_hd__dfxtp_1
Xr_counter_r\[1\]$_SDFFE_PP0P_ net1 _06_ VSS VSS VDD VDD r_counter_r\[1\]
+ sky130_fd_sc_hd__dfxtp_1
Xr_counter_r\[2\]$_SDFFE_PP1P_ net1 _07_ VSS VSS VDD VDD r_counter_r\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 r_clk_i VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_2
Xinput2 r_dec_credit_i VSS VSS VDD VDD net2 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput3 r_infinite_credits_i VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput4 r_reset_i VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput5 w_inc_token_i VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput6 w_reset_i VSS VSS VDD VDD net6 sky130_fd_sc_hd__dlymetal6s2s_1
Xoutput7 net7 VSS VSS VDD VDD r_credits_avail_o sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_w_clk_i w_clk_i VSS VSS VDD VDD clknet_0_w_clk_i
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_w_clk_i clknet_0_w_clk_i VSS VSS VDD VDD clknet_1_0__leaf_w_clk_i
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_w_clk_i clknet_0_w_clk_i VSS VSS VDD VDD clknet_1_1__leaf_w_clk_i
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_1_0__leaf_w_clk_i VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
.ENDS bsg_async_credit_counter
