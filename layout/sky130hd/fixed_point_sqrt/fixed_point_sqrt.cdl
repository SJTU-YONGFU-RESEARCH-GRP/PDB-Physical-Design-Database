* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT fixed_point_sqrt clk enable reset x[0] x[10] x[11]
+ x[12] x[13] x[14] x[15] x[1] x[2] x[3] x[4] x[5] x[6] x[7]
+ x[8] x[9] y[0] y[10] y[11] y[12] y[13] y[14] y[15] y[1] y[2]
+ y[3] y[4] y[5] y[6] y[7] y[8] y[9] VSS VDD
Xinput13 x[15] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkdlybuf4s50_1
X_112_ net9 net10 net11 net12 VSS VSS VDD VDD _052_ sky130_fd_sc_hd__nor4_2
X_113_ net23 net4 VSS VSS VDD VDD _053_ sky130_fd_sc_hd__nor2_1
X_114_ net4 _052_ _053_ net5 VSS VSS VDD VDD _000_ sky130_fd_sc_hd__a211oi_1
Xinput12 x[14] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput11 x[13] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkdlybuf4s50_1
X_117_ net11 net12 VSS VSS VDD VDD _056_ sky130_fd_sc_hd__or2_2
X_118_ net9 net10 _056_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__or3_1
Xinput10 x[12] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput9 x[11] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkdlybuf4s50_1
X_121_ net6 net15 net14 net17 VSS VSS VDD VDD _060_ sky130_fd_sc_hd__nor4_2
X_122_ net18 net19 net21 VSS VSS VDD VDD _061_ sky130_fd_sc_hd__nor3_1
X_123_ net13 net16 VSS VSS VDD VDD _062_ sky130_fd_sc_hd__nor2_1
X_124_ net20 _060_ _061_ _062_ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__nand4_1
X_125_ net8 net7 _057_ _063_ net4 VSS VSS VDD VDD _064_ sky130_fd_sc_hd__o41a_1
X_126_ net20 net8 net7 VSS VSS VDD VDD _065_ sky130_fd_sc_hd__nor3_1
X_127_ _052_ _065_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nand2_1
X_128_ net19 net21 VSS VSS VDD VDD _067_ sky130_fd_sc_hd__nand2_1
X_129_ net18 _067_ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__nor2_1
X_130_ _060_ _062_ _068_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__nand3_1
X_131_ net14 net17 VSS VSS VDD VDD _070_ sky130_fd_sc_hd__nand2_2
X_132_ net6 net15 VSS VSS VDD VDD _071_ sky130_fd_sc_hd__nand2_1
X_133_ _070_ _067_ _071_ VSS VSS VDD VDD _072_ sky130_fd_sc_hd__or3_1
X_134_ net9 net11 net12 VSS VSS VDD VDD _073_ sky130_fd_sc_hd__nand3_1
X_135_ net20 net7 net10 VSS VSS VDD VDD _074_ sky130_fd_sc_hd__nand3_1
X_136_ net13 net16 net18 net8 VSS VSS VDD VDD _075_ sky130_fd_sc_hd__nand4_1
X_137_ _072_ _073_ _074_ _075_ VSS VSS VDD VDD _076_ sky130_fd_sc_hd__or4_4
X_138_ _066_ _069_ _076_ VSS VSS VDD VDD _077_ sky130_fd_sc_hd__o21ai_4
X_139_ net4 net25 VSS VSS VDD VDD _078_ sky130_fd_sc_hd__nor2b_1
X_140_ _064_ _077_ _078_ VSS VSS VDD VDD _079_ sky130_fd_sc_hd__a21oi_1
X_141_ net5 _079_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__nor2_1
X_142_ _072_ _073_ _074_ _075_ VSS VSS VDD VDD _080_ sky130_fd_sc_hd__nor4_1
X_143_ net4 net24 VSS VSS VDD VDD _081_ sky130_fd_sc_hd__nor2b_1
X_144_ _064_ _080_ _081_ VSS VSS VDD VDD _082_ sky130_fd_sc_hd__a21oi_1
X_145_ net5 _082_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__nor2_1
X_146_ net4 net28 VSS VSS VDD VDD _083_ sky130_fd_sc_hd__nand2b_1
X_147_ net14 net17 VSS VSS VDD VDD _084_ sky130_fd_sc_hd__or2_2
X_148_ _052_ _061_ _065_ VSS VSS VDD VDD _085_ sky130_fd_sc_hd__nand3_1
X_149_ net13 _084_ _071_ _085_ VSS VSS VDD VDD _086_ sky130_fd_sc_hd__nor4_1
X_150_ _077_ _086_ _064_ VSS VSS VDD VDD _087_ sky130_fd_sc_hd__o21ai_0
X_151_ _083_ _087_ net5 VSS VSS VDD VDD _003_ sky130_fd_sc_hd__a21oi_1
X_152_ _061_ _062_ VSS VSS VDD VDD _088_ sky130_fd_sc_hd__nand2_1
X_153_ _070_ _084_ net15 VSS VSS VDD VDD _089_ sky130_fd_sc_hd__mux2i_1
X_154_ net6 net15 net17 net14 VSS VSS VDD VDD _090_ sky130_fd_sc_hd__nor4b_1
X_155_ net6 _089_ _090_ VSS VSS VDD VDD _091_ sky130_fd_sc_hd__a21oi_1
X_156_ _088_ _066_ _091_ VSS VSS VDD VDD _092_ sky130_fd_sc_hd__nor3_1
X_157_ net20 net21 net8 net7 VSS VSS VDD VDD _093_ sky130_fd_sc_hd__nor4_1
X_158_ net6 net15 net19 net18 VSS VSS VDD VDD _094_ sky130_fd_sc_hd__nor4b_1
X_159_ _052_ _062_ _093_ _094_ VSS VSS VDD VDD _095_ sky130_fd_sc_hd__nand4_1
X_160_ net4 net5 VSS VSS VDD VDD _096_ sky130_fd_sc_hd__nor2_1
X_161_ net29 _096_ VSS VSS VDD VDD _097_ sky130_fd_sc_hd__nand2_1
X_162_ _070_ _095_ _097_ _076_ VSS VSS VDD VDD _098_ sky130_fd_sc_hd__o211ai_1
X_163_ net10 net9 VSS VSS VDD VDD _099_ sky130_fd_sc_hd__nand2b_1
X_164_ net20 net7 _099_ _074_ net9 VSS VSS VDD VDD _100_ sky130_fd_sc_hd__o32a_1
X_165_ net8 net11 net12 VSS VSS VDD VDD _101_ sky130_fd_sc_hd__nor3_1
X_166_ _060_ _061_ _062_ _101_ VSS VSS VDD VDD _102_ sky130_fd_sc_hd__nand4_1
X_167_ _100_ _102_ VSS VSS VDD VDD _103_ sky130_fd_sc_hd__nor2_1
X_168_ net15 net16 VSS VSS VDD VDD _104_ sky130_fd_sc_hd__nand2_1
X_169_ _084_ _104_ VSS VSS VDD VDD _105_ sky130_fd_sc_hd__nor2_1
X_170_ net15 net16 _070_ VSS VSS VDD VDD _106_ sky130_fd_sc_hd__nor3_1
X_171_ _105_ _106_ net6 VSS VSS VDD VDD _107_ sky130_fd_sc_hd__o21ai_0
X_172_ net16 _060_ VSS VSS VDD VDD _108_ sky130_fd_sc_hd__nand2_1
X_173_ _107_ _108_ net13 _085_ VSS VSS VDD VDD _109_ sky130_fd_sc_hd__a211oi_1
X_174_ _060_ _061_ _062_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__nand3_1
X_175_ net20 net8 net7 VSS VSS VDD VDD _010_ sky130_fd_sc_hd__nor3b_1
X_176_ net7 net8 net20 VSS VSS VDD VDD _011_ sky130_fd_sc_hd__and3b_1
X_177_ _010_ _011_ _052_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__o21ai_0
X_178_ _084_ _070_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__and2_2
X_179_ _009_ _012_ _095_ _013_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__o22ai_1
X_180_ net15 net14 net6 VSS VSS VDD VDD _015_ sky130_fd_sc_hd__mux2_2
X_181_ net17 _088_ _066_ _015_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__nor4_1
X_182_ _014_ _016_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__nor2_1
X_183_ _077_ _103_ _109_ _017_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__nor4b_1
X_184_ net5 _064_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__nand2b_1
X_185_ _100_ _102_ _085_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__o21ai_0
X_186_ _080_ _014_ _020_ _097_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__nor4b_1
X_187_ net19 net21 _060_ _062_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__nand4_1
X_188_ net18 _066_ _022_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__or3_1
X_189_ _097_ _019_ _021_ _023_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__a22oi_1
X_190_ _092_ _098_ _018_ _024_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__o31a_1
X_191_ _052_ _093_ _017_ _109_ _080_ VSS VSS VDD VDD _025_
+ sky130_fd_sc_hd__a311oi_1
X_192_ net30 _096_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__nand2_1
X_193_ _019_ _025_ _026_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__o21ai_0
X_194_ _095_ _013_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nor2_1
X_195_ net8 net9 VSS VSS VDD VDD _028_ sky130_fd_sc_hd__nor2_1
X_196_ net20 net21 net7 VSS VSS VDD VDD _029_ sky130_fd_sc_hd__o21ai_0
X_197_ _028_ _029_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__nand2_1
X_198_ _009_ _012_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__nor2_1
X_199_ net10 _030_ _020_ _031_ _056_ VSS VSS VDD VDD _032_
+ sky130_fd_sc_hd__a2111oi_0
X_200_ _077_ _027_ _032_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__nor3_1
X_201_ net31 _096_ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__nand2_1
X_202_ _019_ _033_ _034_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__o21ai_0
X_203_ net8 net7 VSS VSS VDD VDD _035_ sky130_fd_sc_hd__nand2b_1
X_204_ net20 net21 net7 VSS VSS VDD VDD _036_ sky130_fd_sc_hd__nor3_1
X_205_ _057_ _036_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__nor2_1
X_206_ net7 _035_ net10 VSS VSS VDD VDD _038_ sky130_fd_sc_hd__mux2_2
X_207_ net9 _056_ _063_ _038_ net4 VSS VSS VDD VDD _039_ sky130_fd_sc_hd__o41ai_1
X_208_ _035_ _017_ _037_ _039_ _077_ VSS VSS VDD VDD _040_
+ sky130_fd_sc_hd__a311oi_1
X_209_ net4 net32 VSS VSS VDD VDD _041_ sky130_fd_sc_hd__nor2_1
X_210_ net5 _040_ _041_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__nor3_1
X_211_ net7 _057_ _063_ VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nor3_1
X_212_ net10 _028_ _029_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nand3_1
X_213_ _099_ _043_ _056_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__a21oi_1
X_214_ _103_ _042_ _044_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__nor3_1
X_215_ net8 _057_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__nor2_1
X_216_ net20 _009_ net7 VSS VSS VDD VDD _047_ sky130_fd_sc_hd__o21ai_0
X_217_ _046_ _047_ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__nand2_1
X_218_ _045_ _048_ _080_ _031_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__a211oi_1
X_219_ net33 _096_ VSS VSS VDD VDD _050_ sky130_fd_sc_hd__nand2_1
X_220_ _019_ _049_ _050_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xinput8 x[10] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput7 x[0] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput6 reset VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput5 enable VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkdlybuf4s50_1
Xy\[10\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _000_ VSS VSS VDD
+ VDD net23 sky130_fd_sc_hd__dfxtp_1
Xy\[1\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _001_ VSS VSS VDD
+ VDD net25 sky130_fd_sc_hd__dfxtp_1
Xy\[3\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _002_ VSS VSS VDD
+ VDD net24 sky130_fd_sc_hd__dfxtp_1
Xy\[4\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _003_ VSS VSS VDD
+ VDD net28 sky130_fd_sc_hd__dfxtp_1
Xy\[5\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _004_ VSS VSS VDD
+ VDD net29 sky130_fd_sc_hd__dfxtp_1
Xy\[6\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _005_ VSS VSS VDD
+ VDD net30 sky130_fd_sc_hd__dfxtp_1
Xy\[7\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _006_ VSS VSS VDD
+ VDD net31 sky130_fd_sc_hd__dfxtp_1
Xy\[8\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _007_ VSS VSS VDD
+ VDD net32 sky130_fd_sc_hd__dfxtp_1
Xy\[9\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _008_ VSS VSS VDD
+ VDD net33 sky130_fd_sc_hd__dfxtp_1
X_225__1 VSS VSS VDD VDD _unconnected_0 y[12] sky130_fd_sc_hd__conb_1
X_226__2 VSS VSS VDD VDD _unconnected_1 y[13] sky130_fd_sc_hd__conb_1
X_227__3 VSS VSS VDD VDD _unconnected_2 y[14] sky130_fd_sc_hd__conb_1
X_228__4 VSS VSS VDD VDD _unconnected_3 y[15] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput14 x[1] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput15 x[2] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput16 x[3] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput17 x[4] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput18 x[5] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput19 x[6] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput20 x[7] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput21 x[8] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput22 x[9] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput23 net24 VSS VSS VDD VDD y[0] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput24 net23 VSS VSS VDD VDD y[10] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput25 net24 VSS VSS VDD VDD y[11] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput26 net25 VSS VSS VDD VDD y[1] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput27 net24 VSS VSS VDD VDD y[2] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput28 net24 VSS VSS VDD VDD y[3] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput29 net28 VSS VSS VDD VDD y[4] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput30 net29 VSS VSS VDD VDD y[5] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput31 net30 VSS VSS VDD VDD y[6] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput32 net31 VSS VSS VDD VDD y[7] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput33 net32 VSS VSS VDD VDD y[8] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput34 net33 VSS VSS VDD VDD y[9] sky130_fd_sc_hd__clkdlybuf4s50_1
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_4
+ sky130_fd_sc_hd__clkbuf_1
.ENDS fixed_point_sqrt
