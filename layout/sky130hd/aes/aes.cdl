* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT aes_cipher_top clk done key[0] key[100] key[101] key[102]
+ key[103] key[104] key[105] key[106] key[107] key[108] key[109]
+ key[10] key[110] key[111] key[112] key[113] key[114] key[115]
+ key[116] key[117] key[118] key[119] key[11] key[120] key[121]
+ key[122] key[123] key[124] key[125] key[126] key[127] key[12]
+ key[13] key[14] key[15] key[16] key[17] key[18] key[19] key[1]
+ key[20] key[21] key[22] key[23] key[24] key[25] key[26] key[27]
+ key[28] key[29] key[2] key[30] key[31] key[32] key[33] key[34]
+ key[35] key[36] key[37] key[38] key[39] key[3] key[40] key[41]
+ key[42] key[43] key[44] key[45] key[46] key[47] key[48] key[49]
+ key[4] key[50] key[51] key[52] key[53] key[54] key[55] key[56]
+ key[57] key[58] key[59] key[5] key[60] key[61] key[62] key[63]
+ key[64] key[65] key[66] key[67] key[68] key[69] key[6] key[70]
+ key[71] key[72] key[73] key[74] key[75] key[76] key[77] key[78]
+ key[79] key[7] key[80] key[81] key[82] key[83] key[84] key[85]
+ key[86] key[87] key[88] key[89] key[8] key[90] key[91] key[92]
+ key[93] key[94] key[95] key[96] key[97] key[98] key[99] key[9]
+ ld rst text_in[0] text_in[100] text_in[101] text_in[102] text_in[103]
+ text_in[104] text_in[105] text_in[106] text_in[107] text_in[108]
+ text_in[109] text_in[10] text_in[110] text_in[111] text_in[112]
+ text_in[113] text_in[114] text_in[115] text_in[116] text_in[117]
+ text_in[118] text_in[119] text_in[11] text_in[120] text_in[121]
+ text_in[122] text_in[123] text_in[124] text_in[125] text_in[126]
+ text_in[127] text_in[12] text_in[13] text_in[14] text_in[15]
+ text_in[16] text_in[17] text_in[18] text_in[19] text_in[1]
+ text_in[20] text_in[21] text_in[22] text_in[23] text_in[24]
+ text_in[25] text_in[26] text_in[27] text_in[28] text_in[29]
+ text_in[2] text_in[30] text_in[31] text_in[32] text_in[33]
+ text_in[34] text_in[35] text_in[36] text_in[37] text_in[38]
+ text_in[39] text_in[3] text_in[40] text_in[41] text_in[42]
+ text_in[43] text_in[44] text_in[45] text_in[46] text_in[47]
+ text_in[48] text_in[49] text_in[4] text_in[50] text_in[51]
+ text_in[52] text_in[53] text_in[54] text_in[55] text_in[56]
+ text_in[57] text_in[58] text_in[59] text_in[5] text_in[60]
+ text_in[61] text_in[62] text_in[63] text_in[64] text_in[65]
+ text_in[66] text_in[67] text_in[68] text_in[69] text_in[6]
+ text_in[70] text_in[71] text_in[72] text_in[73] text_in[74]
+ text_in[75] text_in[76] text_in[77] text_in[78] text_in[79]
+ text_in[7] text_in[80] text_in[81] text_in[82] text_in[83]
+ text_in[84] text_in[85] text_in[86] text_in[87] text_in[88]
+ text_in[89] text_in[8] text_in[90] text_in[91] text_in[92]
+ text_in[93] text_in[94] text_in[95] text_in[96] text_in[97]
+ text_in[98] text_in[99] text_in[9] text_out[0] text_out[100]
+ text_out[101] text_out[102] text_out[103] text_out[104] text_out[105]
+ text_out[106] text_out[107] text_out[108] text_out[109] text_out[10]
+ text_out[110] text_out[111] text_out[112] text_out[113] text_out[114]
+ text_out[115] text_out[116] text_out[117] text_out[118] text_out[119]
+ text_out[11] text_out[120] text_out[121] text_out[122] text_out[123]
+ text_out[124] text_out[125] text_out[126] text_out[127] text_out[12]
+ text_out[13] text_out[14] text_out[15] text_out[16] text_out[17]
+ text_out[18] text_out[19] text_out[1] text_out[20] text_out[21]
+ text_out[22] text_out[23] text_out[24] text_out[25] text_out[26]
+ text_out[27] text_out[28] text_out[29] text_out[2] text_out[30]
+ text_out[31] text_out[32] text_out[33] text_out[34] text_out[35]
+ text_out[36] text_out[37] text_out[38] text_out[39] text_out[3]
+ text_out[40] text_out[41] text_out[42] text_out[43] text_out[44]
+ text_out[45] text_out[46] text_out[47] text_out[48] text_out[49]
+ text_out[4] text_out[50] text_out[51] text_out[52] text_out[53]
+ text_out[54] text_out[55] text_out[56] text_out[57] text_out[58]
+ text_out[59] text_out[5] text_out[60] text_out[61] text_out[62]
+ text_out[63] text_out[64] text_out[65] text_out[66] text_out[67]
+ text_out[68] text_out[69] text_out[6] text_out[70] text_out[71]
+ text_out[72] text_out[73] text_out[74] text_out[75] text_out[76]
+ text_out[77] text_out[78] text_out[79] text_out[7] text_out[80]
+ text_out[81] text_out[82] text_out[83] text_out[84] text_out[85]
+ text_out[86] text_out[87] text_out[88] text_out[89] text_out[8]
+ text_out[90] text_out[91] text_out[92] text_out[93] text_out[94]
+ text_out[95] text_out[96] text_out[97] text_out[98] text_out[99]
+ text_out[9]
XTAP_TAPCELL_ROW_58_1403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12504_ u0.w\[0\]\[19\] u0.w\[1\]\[19\] u0.subword\[19\]
+ VSS VSS VDD VDD _03574_ sky130_fd_sc_hd__xor3_4
X_12505_ u0.tmp_w\[19\] u0.w\[2\]\[19\] _03574_ VSS VSS VDD
+ VDD _03575_ sky130_fd_sc_hd__xnor3_4
XTAP_TAPCELL_ROW_58_1399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12507_ net495 net39 VSS VSS VDD VDD _03577_ sky130_fd_sc_hd__nand2_4
X_12508_ net495 _03575_ _03577_ VSS VSS VDD VDD _03578_ sky130_fd_sc_hd__o21a_4
X_12509_ _03578_ VSS VSS VDD VDD _03579_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_58_1398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12512_ u0.w\[0\]\[16\] u0.subword\[16\] VSS VSS VDD VDD
+ _03581_ sky130_fd_sc_hd__xor2_4
X_12513_ u0.w\[2\]\[16\] u0.w\[1\]\[16\] VSS VSS VDD VDD _03582_
+ sky130_fd_sc_hd__xor2_2
X_12514_ u0.tmp_w\[16\] _03581_ _03582_ VSS VSS VDD VDD _03583_
+ sky130_fd_sc_hd__xnor3_4
X_12515_ net497 net36 VSS VSS VDD VDD _03584_ sky130_fd_sc_hd__nand2_2
X_12516_ _03583_ net497 _03584_ VSS VSS VDD VDD _03585_ sky130_fd_sc_hd__o21ai_4
X_12517_ net702 VSS VSS VDD VDD _03586_ sky130_fd_sc_hd__clkinv_8
XTAP_TAPCELL_ROW_58_1396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12519_ u0.w\[0\]\[17\] u0.subword\[17\] VSS VSS VDD VDD
+ _03587_ sky130_fd_sc_hd__xor2_4
X_12520_ u0.w\[2\]\[17\] u0.w\[1\]\[17\] VSS VSS VDD VDD _03588_
+ sky130_fd_sc_hd__xor2_1
X_12521_ u0.tmp_w\[17\] _03587_ _03588_ VSS VSS VDD VDD _03589_
+ sky130_fd_sc_hd__xnor3_1
XTAP_TAPCELL_ROW_58_1395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12523_ net497 net37 VSS VSS VDD VDD _03591_ sky130_fd_sc_hd__nand2_1
X_12524_ net497 _03589_ _03591_ VSS VSS VDD VDD _03592_ sky130_fd_sc_hd__o21ai_1
X_12525_ net489 VSS VSS VDD VDD _03593_ sky130_fd_sc_hd__clkinv_8
XTAP_TAPCELL_ROW_58_1394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12531_ u0.w\[0\]\[21\] u0.w\[1\]\[21\] u0.subword\[21\]
+ VSS VSS VDD VDD _03598_ sky130_fd_sc_hd__xnor3_4
X_12532_ u0.tmp_w\[21\] u0.w\[2\]\[21\] _03598_ VSS VSS VDD
+ VDD _03599_ sky130_fd_sc_hd__xor3_1
X_12533_ net495 _03599_ VSS VSS VDD VDD _03600_ sky130_fd_sc_hd__nor2_1
X_12534_ net495 net42 _03600_ VSS VSS VDD VDD _03601_ sky130_fd_sc_hd__a21oi_4
X_12535_ _03601_ VSS VSS VDD VDD _03602_ sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_58_1389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12541_ u0.w\[0\]\[20\] u0.w\[1\]\[20\] u0.subword\[20\]
+ VSS VSS VDD VDD _03607_ sky130_fd_sc_hd__xnor3_4
X_12542_ u0.tmp_w\[20\] u0.w\[2\]\[20\] _03607_ VSS VSS VDD
+ VDD _03608_ sky130_fd_sc_hd__xor3_1
X_12543_ net495 net41 VSS VSS VDD VDD _03609_ sky130_fd_sc_hd__nand2_4
X_12544_ net495 _03608_ _03609_ VSS VSS VDD VDD _03610_ sky130_fd_sc_hd__o21a_4
X_12545_ _03610_ VSS VSS VDD VDD _03611_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_57_1384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12548_ u0.subword\[18\] u0.w\[0\]\[18\] VSS VSS VDD VDD
+ _03613_ sky130_fd_sc_hd__xor2_4
X_12549_ u0.w\[2\]\[18\] u0.w\[1\]\[18\] VSS VSS VDD VDD _03614_
+ sky130_fd_sc_hd__xor2_4
X_12550_ u0.tmp_w\[18\] _03613_ _03614_ VSS VSS VDD VDD _03615_
+ sky130_fd_sc_hd__xnor3_4
X_12551_ net495 net38 VSS VSS VDD VDD _03616_ sky130_fd_sc_hd__nand2_4
X_12552_ net495 _03615_ _03616_ VSS VSS VDD VDD _03617_ sky130_fd_sc_hd__o21a_4
X_12553_ _03617_ VSS VSS VDD VDD _03618_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_57_1382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12556_ u0.w\[0\]\[0\] u0.subword\[0\] VSS VSS VDD VDD _03620_
+ sky130_fd_sc_hd__xor2_4
X_12557_ u0.w\[2\]\[0\] u0.w\[1\]\[0\] VSS VSS VDD VDD _03621_
+ sky130_fd_sc_hd__xor2_1
X_12558_ u0.tmp_w\[0\] _03620_ _03621_ VSS VSS VDD VDD _03622_
+ sky130_fd_sc_hd__xnor3_1
X_12559_ net129 net1 VSS VSS VDD VDD _03623_ sky130_fd_sc_hd__nand2_2
X_12560_ net497 _03622_ _03623_ VSS VSS VDD VDD _03624_ sky130_fd_sc_hd__o21ai_4
X_12561_ _03624_ VSS VSS VDD VDD _03625_ sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_57_1380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12563_ u0.w\[0\]\[1\] u0.subword\[1\] VSS VSS VDD VDD _03626_
+ sky130_fd_sc_hd__xor2_4
X_12564_ u0.w\[2\]\[1\] u0.w\[1\]\[1\] VSS VSS VDD VDD _03627_
+ sky130_fd_sc_hd__xor2_1
X_12565_ u0.tmp_w\[1\] _03626_ _03627_ VSS VSS VDD VDD _03628_
+ sky130_fd_sc_hd__xnor3_4
X_12566_ net497 net40 VSS VSS VDD VDD _03629_ sky130_fd_sc_hd__nand2_1
X_12567_ net497 _03628_ _03629_ VSS VSS VDD VDD _03630_ sky130_fd_sc_hd__o21ai_4
X_12568_ _03630_ VSS VSS VDD VDD _03631_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_57_1379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12572_ u0.subword\[2\] u0.w\[0\]\[2\] u0.w\[1\]\[2\] VSS
+ VSS VDD VDD _03634_ sky130_fd_sc_hd__xnor3_4
X_12573_ u0.tmp_w\[2\] u0.w\[2\]\[2\] _03634_ VSS VSS VDD
+ VDD _03635_ sky130_fd_sc_hd__xor3_1
X_12574_ net497 net51 VSS VSS VDD VDD _03636_ sky130_fd_sc_hd__nand2_1
X_12575_ net497 _03635_ _03636_ VSS VSS VDD VDD _03637_ sky130_fd_sc_hd__o21a_4
XTAP_TAPCELL_ROW_57_1376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12577_ _03637_ VSS VSS VDD VDD _03639_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_57_1375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12583_ u0.w\[0\]\[3\] u0.w\[1\]\[3\] u0.subword\[3\] VSS
+ VSS VDD VDD _03644_ sky130_fd_sc_hd__xnor3_4
X_12584_ u0.tmp_w\[3\] u0.w\[2\]\[3\] _03644_ VSS VSS VDD
+ VDD _03645_ sky130_fd_sc_hd__xnor3_1
X_12585_ net62 net496 VSS VSS VDD VDD _03646_ sky130_fd_sc_hd__nand2b_1
X_12586_ _03645_ net497 _03646_ VSS VSS VDD VDD _03647_ sky130_fd_sc_hd__o21ai_4
X_12587_ net753 VSS VSS VDD VDD _03648_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_57_1370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12593_ u0.w\[0\]\[4\] u0.w\[1\]\[4\] u0.subword\[4\] VSS
+ VSS VDD VDD _03653_ sky130_fd_sc_hd__xnor3_4
X_12594_ u0.tmp_w\[4\] u0.w\[2\]\[4\] _03653_ VSS VSS VDD
+ VDD _03654_ sky130_fd_sc_hd__xor3_1
X_12595_ net497 net73 VSS VSS VDD VDD _03655_ sky130_fd_sc_hd__nand2_1
X_12596_ net497 _03654_ _03655_ VSS VSS VDD VDD _03656_ sky130_fd_sc_hd__o21a_4
XTAP_TAPCELL_ROW_57_1365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12598_ _03656_ VSS VSS VDD VDD _03658_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_57_1364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12603_ u0.w\[0\]\[5\] u0.w\[1\]\[5\] u0.subword\[5\] VSS
+ VSS VDD VDD _03662_ sky130_fd_sc_hd__xnor3_2
X_12604_ u0.w\[2\]\[5\] _03662_ VSS VSS VDD VDD _03663_ sky130_fd_sc_hd__xor2_4
X_12605_ u0.tmp_w\[5\] _03663_ VSS VSS VDD VDD _03664_ sky130_fd_sc_hd__xor2_1
X_12606_ net129 net84 VSS VSS VDD VDD _03665_ sky130_fd_sc_hd__nand2_1
X_12607_ net497 _03664_ _03665_ VSS VSS VDD VDD _03666_ sky130_fd_sc_hd__o21a_4
X_12608_ _03666_ VSS VSS VDD VDD _03667_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_56_1360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12613_ u0.w\[0\]\[6\] u0.w\[1\]\[6\] u0.subword\[6\] VSS
+ VSS VDD VDD _03671_ sky130_fd_sc_hd__xnor3_4
X_12614_ u0.w\[2\]\[6\] _03671_ VSS VSS VDD VDD _03672_ sky130_fd_sc_hd__xor2_4
X_12615_ u0.tmp_w\[6\] _03672_ VSS VSS VDD VDD _03673_ sky130_fd_sc_hd__xor2_1
X_12616_ net497 net95 VSS VSS VDD VDD _03674_ sky130_fd_sc_hd__nand2_1
X_12617_ net497 _03673_ _03674_ VSS VSS VDD VDD _03675_ sky130_fd_sc_hd__o21a_4
X_12618_ _03675_ VSS VSS VDD VDD _03676_ sky130_fd_sc_hd__inv_16
XTAP_TAPCELL_ROW_56_1356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12622_ u0.w\[0\]\[7\] u0.subword\[7\] VSS VSS VDD VDD _03679_
+ sky130_fd_sc_hd__xor2_2
X_12623_ u0.w\[1\]\[7\] _03679_ VSS VSS VDD VDD _03680_ sky130_fd_sc_hd__xnor2_2
X_12624_ u0.w\[2\]\[7\] _03680_ VSS VSS VDD VDD _03681_ sky130_fd_sc_hd__xnor2_4
X_12625_ u0.tmp_w\[7\] _03681_ VSS VSS VDD VDD _03682_ sky130_fd_sc_hd__xnor2_1
X_12626_ net495 _03682_ VSS VSS VDD VDD _03683_ sky130_fd_sc_hd__nor2_1
X_12627_ net495 net106 _03683_ VSS VSS VDD VDD _03684_ sky130_fd_sc_hd__a21oi_4
X_12628_ _03684_ VSS VSS VDD VDD _03685_ sky130_fd_sc_hd__clkinv_8
XTAP_TAPCELL_ROW_56_1353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12631_ u0.w\[0\]\[8\] u0.w\[1\]\[8\] u0.subword\[8\] VSS
+ VSS VDD VDD _03687_ sky130_fd_sc_hd__xnor3_1
X_12632_ u0.tmp_w\[8\] u0.w\[2\]\[8\] _03687_ VSS VSS VDD
+ VDD _03688_ sky130_fd_sc_hd__xor3_1
X_12633_ net494 net117 VSS VSS VDD VDD _03689_ sky130_fd_sc_hd__nand2_2
X_12634_ net494 _03688_ _03689_ VSS VSS VDD VDD _03690_ sky130_fd_sc_hd__o21ai_4
X_12635_ net484 VSS VSS VDD VDD _03691_ sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_56_1351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12638_ u0.w\[0\]\[9\] u0.w\[1\]\[9\] u0.subword\[9\] VSS
+ VSS VDD VDD _03693_ sky130_fd_sc_hd__xnor3_4
X_12639_ u0.tmp_w\[9\] u0.w\[2\]\[9\] _03693_ VSS VSS VDD
+ VDD _03694_ sky130_fd_sc_hd__xor3_1
X_12640_ net496 net128 VSS VSS VDD VDD _03695_ sky130_fd_sc_hd__nand2_2
X_12641_ net497 _03694_ _03695_ VSS VSS VDD VDD _11860_ sky130_fd_sc_hd__o21ai_4
X_12642_ net483 VSS VSS VDD VDD _03696_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_56_1349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12646_ u0.subword\[10\] u0.w\[0\]\[10\] u0.w\[1\]\[10\]
+ VSS VSS VDD VDD _03699_ sky130_fd_sc_hd__xor3_2
X_12647_ u0.tmp_w\[10\] u0.w\[2\]\[10\] _03699_ VSS VSS VDD
+ VDD _03700_ sky130_fd_sc_hd__xnor3_1
X_12648_ net495 net12 VSS VSS VDD VDD _03701_ sky130_fd_sc_hd__nand2_1
X_12649_ net495 _03700_ _03701_ VSS VSS VDD VDD _03702_ sky130_fd_sc_hd__o21a_4
XTAP_TAPCELL_ROW_56_1346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12651_ _03702_ VSS VSS VDD VDD _03704_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_56_1345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12659_ u0.w\[0\]\[11\] u0.w\[1\]\[11\] u0.subword\[11\]
+ VSS VSS VDD VDD _03711_ sky130_fd_sc_hd__xor3_4
X_12660_ u0.tmp_w\[11\] u0.w\[2\]\[11\] _03711_ VSS VSS VDD
+ VDD _03712_ sky130_fd_sc_hd__xnor3_1
X_12661_ net494 net23 VSS VSS VDD VDD _03713_ sky130_fd_sc_hd__nand2_1
X_12662_ _03712_ net494 _03713_ VSS VSS VDD VDD _03714_ sky130_fd_sc_hd__o21a_4
X_12663_ _03714_ VSS VSS VDD VDD _03715_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_55_1338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12670_ u0.w\[0\]\[12\] u0.w\[1\]\[12\] u0.subword\[12\]
+ VSS VSS VDD VDD _03721_ sky130_fd_sc_hd__xnor3_1
X_12671_ u0.tmp_w\[12\] u0.w\[2\]\[12\] _03721_ VSS VSS VDD
+ VDD _03722_ sky130_fd_sc_hd__xor3_1
X_12672_ net494 _03722_ VSS VSS VDD VDD _03723_ sky130_fd_sc_hd__nor2_1
X_12673_ net494 net32 _03723_ VSS VSS VDD VDD _03724_ sky130_fd_sc_hd__a21oi_4
X_12674_ _03724_ VSS VSS VDD VDD _03725_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_55_1332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12680_ u0.w\[0\]\[13\] u0.w\[1\]\[13\] u0.subword\[13\]
+ VSS VSS VDD VDD _03730_ sky130_fd_sc_hd__xnor3_1
X_12681_ u0.w\[2\]\[13\] _03730_ VSS VSS VDD VDD _03731_ sky130_fd_sc_hd__xnor2_1
X_12682_ u0.tmp_w\[13\] _03731_ VSS VSS VDD VDD _03732_ sky130_fd_sc_hd__xnor2_1
X_12683_ net494 net33 VSS VSS VDD VDD _03733_ sky130_fd_sc_hd__nand2_1
X_12684_ net494 _03732_ _03733_ VSS VSS VDD VDD _03734_ sky130_fd_sc_hd__o21a_4
X_12685_ _03734_ VSS VSS VDD VDD _03735_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_55_1327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12690_ u0.w\[0\]\[14\] u0.w\[1\]\[14\] u0.subword\[14\]
+ VSS VSS VDD VDD _03739_ sky130_fd_sc_hd__xnor3_2
X_12691_ u0.w\[2\]\[14\] _03739_ VSS VSS VDD VDD _03740_ sky130_fd_sc_hd__xor2_1
X_12692_ u0.tmp_w\[14\] _03740_ VSS VSS VDD VDD _03741_ sky130_fd_sc_hd__xor2_1
X_12693_ net494 _03741_ VSS VSS VDD VDD _03742_ sky130_fd_sc_hd__nor2_1
X_12694_ net494 net34 _03742_ VSS VSS VDD VDD _03743_ sky130_fd_sc_hd__a21oi_4
X_12695_ _03743_ VSS VSS VDD VDD _03744_ sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_55_1323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12697_ u0.w\[0\]\[15\] u0.subword\[15\] VSS VSS VDD VDD
+ _03745_ sky130_fd_sc_hd__xor2_1
X_12698_ u0.w\[1\]\[15\] _03745_ VSS VSS VDD VDD _03746_ sky130_fd_sc_hd__xnor2_2
X_12699_ u0.w\[2\]\[15\] _03746_ VSS VSS VDD VDD _03747_ sky130_fd_sc_hd__xnor2_2
X_12700_ u0.tmp_w\[15\] _03747_ VSS VSS VDD VDD _03748_ sky130_fd_sc_hd__xnor2_1
X_12701_ net494 _03748_ VSS VSS VDD VDD _03749_ sky130_fd_sc_hd__nor2_1
X_12702_ net494 net35 _03749_ VSS VSS VDD VDD _03750_ sky130_fd_sc_hd__a21oi_4
X_12703_ _03750_ VSS VSS VDD VDD _03751_ sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_55_1322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12708_ u0.w\[0\]\[22\] u0.w\[1\]\[22\] u0.subword\[22\]
+ VSS VSS VDD VDD _03755_ sky130_fd_sc_hd__xnor3_4
X_12709_ u0.tmp_w\[22\] u0.w\[2\]\[22\] _03755_ VSS VSS VDD
+ VDD _03756_ sky130_fd_sc_hd__xor3_4
X_12710_ net495 net43 VSS VSS VDD VDD _03757_ sky130_fd_sc_hd__nand2_4
X_12711_ net495 _03756_ _03757_ VSS VSS VDD VDD _03758_ sky130_fd_sc_hd__o21a_4
X_12712_ _03758_ VSS VSS VDD VDD _03759_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_55_1318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12715_ u0.w\[0\]\[23\] u0.subword\[23\] VSS VSS VDD VDD
+ _03761_ sky130_fd_sc_hd__xor2_2
X_12716_ u0.w\[1\]\[23\] _03761_ VSS VSS VDD VDD _03762_ sky130_fd_sc_hd__xnor2_4
X_12717_ u0.w\[2\]\[23\] _03762_ VSS VSS VDD VDD _03763_ sky130_fd_sc_hd__xnor2_1
X_12718_ u0.tmp_w\[23\] _03763_ VSS VSS VDD VDD _03764_ sky130_fd_sc_hd__xnor2_1
X_12719_ net497 _03764_ VSS VSS VDD VDD _03765_ sky130_fd_sc_hd__nor2_4
X_12720_ net495 net44 _03765_ VSS VSS VDD VDD _03766_ sky130_fd_sc_hd__a21oi_4
X_12721_ _03766_ VSS VSS VDD VDD _03767_ sky130_fd_sc_hd__clkinv_8
XTAP_TAPCELL_ROW_55_1316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12724_ u0.w\[0\]\[24\] u0.subword\[24\] u0.r0.out\[24\]
+ VSS VSS VDD VDD _03769_ sky130_fd_sc_hd__xnor3_2
X_12725_ u0.tmp_w\[24\] u0.w\[2\]\[24\] VSS VSS VDD VDD _03770_
+ sky130_fd_sc_hd__xor2_1
X_12726_ u0.w\[1\]\[24\] _03769_ _03770_ VSS VSS VDD VDD _03771_
+ sky130_fd_sc_hd__xnor3_1
X_12727_ _03771_ net45 net497 VSS VSS VDD VDD _03772_ sky130_fd_sc_hd__mux2_8
X_12728_ _03772_ VSS VSS VDD VDD _03773_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_54_1314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12730_ u0.w\[0\]\[25\] u0.subword\[25\] u0.r0.out\[25\]
+ VSS VSS VDD VDD _03774_ sky130_fd_sc_hd__xnor3_2
X_12731_ u0.tmp_w\[25\] u0.w\[2\]\[25\] VSS VSS VDD VDD _03775_
+ sky130_fd_sc_hd__xor2_1
X_12732_ u0.w\[1\]\[25\] _03774_ _03775_ VSS VSS VDD VDD _03776_
+ sky130_fd_sc_hd__xnor3_1
X_12733_ _03776_ net46 net497 VSS VSS VDD VDD _03777_ sky130_fd_sc_hd__mux2_8
X_12734_ _03777_ VSS VSS VDD VDD _03778_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_54_1313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12736_ u0.w\[0\]\[26\] u0.subword\[26\] u0.r0.out\[26\]
+ VSS VSS VDD VDD _03779_ sky130_fd_sc_hd__xnor3_4
X_12737_ u0.tmp_w\[26\] u0.w\[2\]\[26\] VSS VSS VDD VDD _03780_
+ sky130_fd_sc_hd__xnor2_1
X_12738_ u0.w\[1\]\[26\] _03779_ _03780_ VSS VSS VDD VDD _03781_
+ sky130_fd_sc_hd__xnor3_4
X_12739_ net47 VSS VSS VDD VDD _03782_ sky130_fd_sc_hd__inv_1
X_12740_ _03781_ _03782_ net497 VSS VSS VDD VDD _03783_ sky130_fd_sc_hd__mux2i_4
X_12741_ net481 VSS VSS VDD VDD _03784_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_54_1312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12745_ u0.w\[0\]\[27\] u0.subword\[27\] u0.r0.out\[27\]
+ VSS VSS VDD VDD _03787_ sky130_fd_sc_hd__xnor3_4
XTAP_TAPCELL_ROW_54_1309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12747_ u0.tmp_w\[27\] u0.w\[2\]\[27\] VSS VSS VDD VDD _03789_
+ sky130_fd_sc_hd__xor2_1
X_12748_ u0.w\[1\]\[27\] _03787_ _03789_ VSS VSS VDD VDD _03790_
+ sky130_fd_sc_hd__xnor3_1
X_12749_ _03790_ net48 net497 VSS VSS VDD VDD _03791_ sky130_fd_sc_hd__mux2i_4
X_12750_ net479 VSS VSS VDD VDD _03792_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_54_1308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12755_ u0.w\[0\]\[28\] u0.subword\[28\] u0.r0.out\[28\]
+ VSS VSS VDD VDD _03796_ sky130_fd_sc_hd__xnor3_2
XTAP_TAPCELL_ROW_54_1304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12757_ u0.tmp_w\[28\] u0.w\[2\]\[28\] VSS VSS VDD VDD _03798_
+ sky130_fd_sc_hd__xor2_1
X_12758_ u0.w\[1\]\[28\] _03796_ _03798_ VSS VSS VDD VDD _03799_
+ sky130_fd_sc_hd__xnor3_1
X_12759_ _03799_ net49 net497 VSS VSS VDD VDD _03800_ sky130_fd_sc_hd__mux2i_4
X_12760_ _03800_ VSS VSS VDD VDD _03801_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_54_1303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12765_ u0.w\[0\]\[29\] u0.subword\[29\] VSS VSS VDD VDD
+ _03805_ sky130_fd_sc_hd__xnor2_1
X_12766_ u0.w\[1\]\[29\] u0.r0.out\[29\] _03805_ VSS VSS VDD
+ VDD _03806_ sky130_fd_sc_hd__xnor3_4
X_12767_ u0.tmp_w\[29\] u0.w\[2\]\[29\] _03806_ VSS VSS VDD
+ VDD _03807_ sky130_fd_sc_hd__xnor3_1
X_12768_ net496 net50 VSS VSS VDD VDD _03808_ sky130_fd_sc_hd__nand2_4
X_12769_ net497 _03807_ _03808_ VSS VSS VDD VDD _03809_ sky130_fd_sc_hd__o21a_4
X_12770_ _03809_ VSS VSS VDD VDD _03810_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_54_1299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12774_ u0.w\[0\]\[30\] u0.subword\[30\] u0.r0.out\[30\]
+ VSS VSS VDD VDD _03813_ sky130_fd_sc_hd__xnor3_4
X_12775_ u0.w\[2\]\[30\] u0.w\[1\]\[30\] _03813_ VSS VSS VDD
+ VDD _03814_ sky130_fd_sc_hd__xnor3_1
X_12776_ u0.tmp_w\[30\] _03814_ VSS VSS VDD VDD _03815_ sky130_fd_sc_hd__xnor2_1
X_12777_ net496 net52 VSS VSS VDD VDD _03816_ sky130_fd_sc_hd__nand2_1
X_12778_ net497 _03815_ _03816_ VSS VSS VDD VDD _03817_ sky130_fd_sc_hd__o21a_4
X_12779_ _03817_ VSS VSS VDD VDD _00398_ sky130_fd_sc_hd__inv_6
X_12780_ u0.subword\[31\] u0.r0.out\[31\] VSS VSS VDD VDD
+ _03818_ sky130_fd_sc_hd__xor2_4
X_12781_ u0.w\[0\]\[31\] _03818_ VSS VSS VDD VDD _03819_ sky130_fd_sc_hd__xnor2_2
X_12782_ u0.w\[1\]\[31\] _03819_ VSS VSS VDD VDD _03820_ sky130_fd_sc_hd__xnor2_4
X_12783_ u0.w\[2\]\[31\] _03820_ VSS VSS VDD VDD _03821_ sky130_fd_sc_hd__xnor2_1
X_12784_ u0.tmp_w\[31\] _03821_ VSS VSS VDD VDD _03822_ sky130_fd_sc_hd__xor2_2
X_12785_ net496 net53 VSS VSS VDD VDD _03823_ sky130_fd_sc_hd__nand2_1
X_12786_ net497 _03822_ _03823_ VSS VSS VDD VDD _03824_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_54_1296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12789_ _03620_ _03621_ VSS VSS VDD VDD _03826_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_54_1294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12792_ _03826_ net54 net496 VSS VSS VDD VDD _00353_ sky130_fd_sc_hd__mux2_1
X_12793_ _03626_ _03627_ VSS VSS VDD VDD _03829_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_54_1292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12795_ _03829_ net55 net496 VSS VSS VDD VDD _00364_ sky130_fd_sc_hd__mux2_1
X_12796_ u0.w\[2\]\[2\] _03634_ VSS VSS VDD VDD _03831_ sky130_fd_sc_hd__xnor2_1
X_12797_ _03831_ net56 net497 VSS VSS VDD VDD _00375_ sky130_fd_sc_hd__mux2_1
X_12798_ u0.w\[2\]\[3\] _03644_ VSS VSS VDD VDD _03832_ sky130_fd_sc_hd__xnor2_1
X_12799_ _03832_ net57 net497 VSS VSS VDD VDD _00378_ sky130_fd_sc_hd__mux2_1
X_12800_ u0.w\[2\]\[4\] _03653_ VSS VSS VDD VDD _03833_ sky130_fd_sc_hd__xnor2_1
X_12801_ _03833_ net58 net497 VSS VSS VDD VDD _00379_ sky130_fd_sc_hd__mux2_1
X_12802_ net59 VSS VSS VDD VDD _03834_ sky130_fd_sc_hd__clkinvlp_4
X_12803_ _03663_ _03834_ net496 VSS VSS VDD VDD _00380_ sky130_fd_sc_hd__mux2i_1
X_12804_ net60 VSS VSS VDD VDD _03835_ sky130_fd_sc_hd__inv_1
X_12805_ _03672_ _03835_ net496 VSS VSS VDD VDD _00381_ sky130_fd_sc_hd__mux2i_1
X_12806_ _03681_ net61 net497 VSS VSS VDD VDD _00382_ sky130_fd_sc_hd__mux2_1
X_12807_ u0.w\[2\]\[8\] _03687_ VSS VSS VDD VDD _03836_ sky130_fd_sc_hd__xnor2_1
X_12808_ _03836_ net63 net494 VSS VSS VDD VDD _00383_ sky130_fd_sc_hd__mux2_1
X_12809_ u0.w\[2\]\[9\] _03693_ VSS VSS VDD VDD _03837_ sky130_fd_sc_hd__xnor2_1
X_12810_ _03837_ net64 net497 VSS VSS VDD VDD _00384_ sky130_fd_sc_hd__mux2_1
X_12811_ u0.w\[2\]\[10\] _03699_ VSS VSS VDD VDD _03838_ sky130_fd_sc_hd__xor2_1
X_12812_ _03838_ net65 net495 VSS VSS VDD VDD _00354_ sky130_fd_sc_hd__mux2_1
X_12813_ u0.w\[2\]\[11\] _03711_ VSS VSS VDD VDD _03839_ sky130_fd_sc_hd__xor2_1
X_12814_ _03839_ net66 net494 VSS VSS VDD VDD _00355_ sky130_fd_sc_hd__mux2_1
X_12815_ u0.w\[2\]\[12\] _03721_ VSS VSS VDD VDD _03840_ sky130_fd_sc_hd__xnor2_1
X_12816_ _03840_ net67 net494 VSS VSS VDD VDD _00356_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_1291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12818_ _03731_ net68 net494 VSS VSS VDD VDD _00357_ sky130_fd_sc_hd__mux2_1
X_12819_ net69 VSS VSS VDD VDD _03842_ sky130_fd_sc_hd__clkinvlp_4
X_12820_ _03740_ _03842_ net652 VSS VSS VDD VDD _00358_ sky130_fd_sc_hd__mux2i_1
X_12821_ _03747_ net70 net494 VSS VSS VDD VDD _00359_ sky130_fd_sc_hd__mux2_1
X_12822_ _03581_ _03582_ VSS VSS VDD VDD _03843_ sky130_fd_sc_hd__xor2_1
X_12823_ _03843_ net71 net497 VSS VSS VDD VDD _00360_ sky130_fd_sc_hd__mux2_1
X_12824_ _03587_ _03588_ VSS VSS VDD VDD _03844_ sky130_fd_sc_hd__xor2_1
X_12825_ _03844_ net72 net497 VSS VSS VDD VDD _00361_ sky130_fd_sc_hd__mux2_1
X_12826_ _03613_ _03614_ VSS VSS VDD VDD _03845_ sky130_fd_sc_hd__xor2_1
X_12827_ _03845_ net74 net497 VSS VSS VDD VDD _00362_ sky130_fd_sc_hd__mux2_1
X_12828_ u0.w\[2\]\[19\] _03574_ VSS VSS VDD VDD _03846_ sky130_fd_sc_hd__xor2_1
X_12829_ _03846_ net75 net497 VSS VSS VDD VDD _00363_ sky130_fd_sc_hd__mux2_1
X_12830_ u0.w\[2\]\[20\] _03607_ VSS VSS VDD VDD _03847_ sky130_fd_sc_hd__xnor2_1
X_12831_ _03847_ net76 net495 VSS VSS VDD VDD _00365_ sky130_fd_sc_hd__mux2_1
X_12832_ u0.w\[2\]\[21\] _03598_ VSS VSS VDD VDD _03848_ sky130_fd_sc_hd__xnor2_1
X_12833_ _03848_ net77 net495 VSS VSS VDD VDD _00366_ sky130_fd_sc_hd__mux2_1
X_12834_ u0.w\[2\]\[22\] _03755_ VSS VSS VDD VDD _03849_ sky130_fd_sc_hd__xnor2_1
X_12835_ _03849_ net78 net497 VSS VSS VDD VDD _00367_ sky130_fd_sc_hd__mux2_1
X_12836_ _03763_ net79 net497 VSS VSS VDD VDD _00368_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_1290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12838_ u0.w\[1\]\[24\] _03769_ VSS VSS VDD VDD _03851_ sky130_fd_sc_hd__xnor2_2
X_12839_ u0.w\[2\]\[24\] _03851_ VSS VSS VDD VDD _03852_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_53_1289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12842_ net497 net80 VSS VSS VDD VDD _03855_ sky130_fd_sc_hd__nand2_1
X_12843_ net497 _03852_ _03855_ VSS VSS VDD VDD _00369_ sky130_fd_sc_hd__o21ai_0
X_12844_ u0.w\[1\]\[25\] _03774_ VSS VSS VDD VDD _03856_ sky130_fd_sc_hd__xnor2_1
X_12845_ u0.w\[2\]\[25\] _03856_ VSS VSS VDD VDD _03857_ sky130_fd_sc_hd__xnor2_1
X_12846_ net129 net81 VSS VSS VDD VDD _03858_ sky130_fd_sc_hd__nand2_4
X_12847_ net497 _03857_ _03858_ VSS VSS VDD VDD _00370_ sky130_fd_sc_hd__o21ai_0
X_12848_ u0.w\[1\]\[26\] _03779_ VSS VSS VDD VDD _03859_ sky130_fd_sc_hd__xnor2_1
X_12849_ u0.w\[2\]\[26\] _03859_ VSS VSS VDD VDD _03860_ sky130_fd_sc_hd__xnor2_1
X_12850_ net496 net82 VSS VSS VDD VDD _03861_ sky130_fd_sc_hd__nand2_1
X_12851_ net497 _03860_ _03861_ VSS VSS VDD VDD _00371_ sky130_fd_sc_hd__o21ai_0
X_12852_ u0.w\[1\]\[27\] _03787_ VSS VSS VDD VDD _03862_ sky130_fd_sc_hd__xnor2_1
X_12853_ u0.w\[2\]\[27\] _03862_ VSS VSS VDD VDD _03863_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_53_1287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12855_ net496 net83 VSS VSS VDD VDD _03865_ sky130_fd_sc_hd__nand2_1
X_12856_ net497 _03863_ _03865_ VSS VSS VDD VDD _00372_ sky130_fd_sc_hd__o21ai_0
X_12857_ u0.w\[1\]\[28\] _03796_ VSS VSS VDD VDD _03866_ sky130_fd_sc_hd__xnor2_1
X_12858_ u0.w\[2\]\[28\] _03866_ VSS VSS VDD VDD _03867_ sky130_fd_sc_hd__xnor2_1
X_12859_ net496 net85 VSS VSS VDD VDD _03868_ sky130_fd_sc_hd__nand2_1
X_12860_ net497 _03867_ _03868_ VSS VSS VDD VDD _00373_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_53_1286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12862_ u0.w\[2\]\[29\] _03806_ VSS VSS VDD VDD _03870_ sky130_fd_sc_hd__xnor2_1
X_12863_ net496 net86 VSS VSS VDD VDD _03871_ sky130_fd_sc_hd__nand2_2
X_12864_ net496 _03870_ _03871_ VSS VSS VDD VDD _00374_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_53_1285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12866_ _03814_ net87 net497 VSS VSS VDD VDD _00376_ sky130_fd_sc_hd__mux2_1
X_12867_ net497 net88 VSS VSS VDD VDD _03873_ sky130_fd_sc_hd__nand2_1
X_12868_ net497 _03821_ _03873_ VSS VSS VDD VDD _00377_ sky130_fd_sc_hd__o21ai_0
X_12869_ u0.w\[1\]\[0\] _03620_ VSS VSS VDD VDD _03874_ sky130_fd_sc_hd__xnor2_1
X_12870_ net129 net89 VSS VSS VDD VDD _03875_ sky130_fd_sc_hd__nand2_2
X_12871_ net496 _03874_ _03875_ VSS VSS VDD VDD _00321_ sky130_fd_sc_hd__o21ai_0
X_12872_ u0.w\[1\]\[1\] _03626_ VSS VSS VDD VDD _03876_ sky130_fd_sc_hd__xnor2_1
X_12873_ net496 net90 VSS VSS VDD VDD _03877_ sky130_fd_sc_hd__nand2_1
X_12874_ net496 _03876_ _03877_ VSS VSS VDD VDD _00332_ sky130_fd_sc_hd__o21ai_0
X_12875_ net496 net91 VSS VSS VDD VDD _03878_ sky130_fd_sc_hd__nand2_2
X_12876_ net496 _03634_ _03878_ VSS VSS VDD VDD _00343_ sky130_fd_sc_hd__o21ai_0
X_12877_ net496 net92 VSS VSS VDD VDD _03879_ sky130_fd_sc_hd__nand2_1
X_12878_ net496 _03644_ _03879_ VSS VSS VDD VDD _00346_ sky130_fd_sc_hd__o21ai_0
X_12879_ net496 net93 VSS VSS VDD VDD _03880_ sky130_fd_sc_hd__nand2_1
X_12880_ net496 _03653_ _03880_ VSS VSS VDD VDD _00347_ sky130_fd_sc_hd__o21ai_0
X_12881_ net496 net94 VSS VSS VDD VDD _03881_ sky130_fd_sc_hd__nand2_1
X_12882_ net496 _03662_ _03881_ VSS VSS VDD VDD _00348_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_53_1284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12884_ net496 net96 VSS VSS VDD VDD _03883_ sky130_fd_sc_hd__nand2_1
X_12885_ net496 _03671_ _03883_ VSS VSS VDD VDD _00349_ sky130_fd_sc_hd__o21ai_0
X_12886_ net496 net97 VSS VSS VDD VDD _03884_ sky130_fd_sc_hd__nand2_1
X_12887_ net496 _03680_ _03884_ VSS VSS VDD VDD _00350_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_53_1283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12889_ net652 net98 VSS VSS VDD VDD _03886_ sky130_fd_sc_hd__nand2_1
X_12890_ net652 _03687_ _03886_ VSS VSS VDD VDD _00351_ sky130_fd_sc_hd__o21ai_0
X_12891_ net495 net99 VSS VSS VDD VDD _03887_ sky130_fd_sc_hd__nand2_2
X_12892_ net495 _03693_ _03887_ VSS VSS VDD VDD _00352_ sky130_fd_sc_hd__o21ai_0
X_12893_ _03699_ net100 net495 VSS VSS VDD VDD _00322_ sky130_fd_sc_hd__mux2_1
X_12894_ _03711_ net101 net494 VSS VSS VDD VDD _00323_ sky130_fd_sc_hd__mux2_1
X_12895_ net494 net102 VSS VSS VDD VDD _03888_ sky130_fd_sc_hd__nand2_2
X_12896_ net652 _03721_ _03888_ VSS VSS VDD VDD _00324_ sky130_fd_sc_hd__o21ai_0
X_12897_ net494 net103 VSS VSS VDD VDD _03889_ sky130_fd_sc_hd__nand2_2
X_12898_ net652 _03730_ _03889_ VSS VSS VDD VDD _00325_ sky130_fd_sc_hd__o21ai_0
X_12899_ net494 net104 VSS VSS VDD VDD _03890_ sky130_fd_sc_hd__nand2_2
X_12900_ net652 _03739_ _03890_ VSS VSS VDD VDD _00326_ sky130_fd_sc_hd__o21ai_0
X_12901_ net652 net105 VSS VSS VDD VDD _03891_ sky130_fd_sc_hd__nand2_2
X_12902_ net652 _03746_ _03891_ VSS VSS VDD VDD _00327_ sky130_fd_sc_hd__o21ai_0
X_12903_ u0.w\[1\]\[16\] _03581_ VSS VSS VDD VDD _03892_ sky130_fd_sc_hd__xnor2_1
X_12904_ net497 net107 VSS VSS VDD VDD _03893_ sky130_fd_sc_hd__nand2_1
X_12905_ net497 _03892_ _03893_ VSS VSS VDD VDD _00328_ sky130_fd_sc_hd__o21ai_0
X_12906_ u0.w\[1\]\[17\] _03587_ VSS VSS VDD VDD _03894_ sky130_fd_sc_hd__xnor2_1
X_12907_ net497 net108 VSS VSS VDD VDD _03895_ sky130_fd_sc_hd__nand2_1
X_12908_ net497 _03894_ _03895_ VSS VSS VDD VDD _00329_ sky130_fd_sc_hd__o21ai_0
X_12909_ u0.w\[1\]\[18\] _03613_ VSS VSS VDD VDD _03896_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_53_1282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12911_ net497 net109 VSS VSS VDD VDD _03898_ sky130_fd_sc_hd__nand2_1
X_12912_ net497 _03896_ _03898_ VSS VSS VDD VDD _00330_ sky130_fd_sc_hd__o21ai_0
X_12913_ _03574_ net110 net494 VSS VSS VDD VDD _00331_ sky130_fd_sc_hd__mux2_1
X_12914_ net494 net111 VSS VSS VDD VDD _03899_ sky130_fd_sc_hd__nand2_2
X_12915_ net652 _03607_ _03899_ VSS VSS VDD VDD _00333_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_53_1281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12917_ net494 net112 VSS VSS VDD VDD _03901_ sky130_fd_sc_hd__nand2_2
X_12918_ net652 _03598_ _03901_ VSS VSS VDD VDD _00334_ sky130_fd_sc_hd__o21ai_0
X_12919_ net495 net113 VSS VSS VDD VDD _03902_ sky130_fd_sc_hd__nand2_1
X_12920_ net495 _03755_ _03902_ VSS VSS VDD VDD _00335_ sky130_fd_sc_hd__o21ai_0
X_12921_ net494 net114 VSS VSS VDD VDD _03903_ sky130_fd_sc_hd__nand2_1
X_12922_ net652 _03762_ _03903_ VSS VSS VDD VDD _00336_ sky130_fd_sc_hd__o21ai_0
X_12923_ _03851_ net115 net497 VSS VSS VDD VDD _00337_ sky130_fd_sc_hd__mux2_1
X_12924_ _03856_ net116 net497 VSS VSS VDD VDD _00338_ sky130_fd_sc_hd__mux2_1
X_12925_ _03859_ net118 net497 VSS VSS VDD VDD _00339_ sky130_fd_sc_hd__mux2_1
X_12926_ _03862_ net119 net497 VSS VSS VDD VDD _00340_ sky130_fd_sc_hd__mux2_1
X_12927_ _03866_ net120 net497 VSS VSS VDD VDD _00341_ sky130_fd_sc_hd__mux2_1
X_12928_ _03806_ net121 net497 VSS VSS VDD VDD _00342_ sky130_fd_sc_hd__mux2_1
X_12929_ u0.w\[1\]\[30\] _03813_ VSS VSS VDD VDD _03904_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_53_1280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12931_ _03904_ net122 net497 VSS VSS VDD VDD _00344_ sky130_fd_sc_hd__mux2_1
X_12932_ _03820_ net123 net652 VSS VSS VDD VDD _00345_ sky130_fd_sc_hd__mux2_1
X_12933_ _03620_ net124 net496 VSS VSS VDD VDD _00289_ sky130_fd_sc_hd__mux2_1
X_12934_ _03626_ net125 net496 VSS VSS VDD VDD _00300_ sky130_fd_sc_hd__mux2_1
X_12935_ u0.subword\[2\] u0.w\[0\]\[2\] VSS VSS VDD VDD _03906_
+ sky130_fd_sc_hd__xor2_1
X_12936_ _03906_ net126 net496 VSS VSS VDD VDD _00311_ sky130_fd_sc_hd__mux2_1
X_12937_ u0.w\[0\]\[3\] u0.subword\[3\] VSS VSS VDD VDD _03907_
+ sky130_fd_sc_hd__xor2_1
X_12938_ _03907_ net127 net496 VSS VSS VDD VDD _00314_ sky130_fd_sc_hd__mux2_1
X_12939_ u0.w\[0\]\[4\] u0.subword\[4\] VSS VSS VDD VDD _03908_
+ sky130_fd_sc_hd__xor2_1
X_12940_ _03908_ net2 net496 VSS VSS VDD VDD _00315_ sky130_fd_sc_hd__mux2_1
X_12941_ u0.w\[0\]\[5\] u0.subword\[5\] VSS VSS VDD VDD _03909_
+ sky130_fd_sc_hd__xor2_1
X_12942_ _03909_ net3 net496 VSS VSS VDD VDD _00316_ sky130_fd_sc_hd__mux2_1
X_12943_ u0.w\[0\]\[6\] u0.subword\[6\] VSS VSS VDD VDD _03910_
+ sky130_fd_sc_hd__xor2_1
X_12944_ _03910_ net4 net496 VSS VSS VDD VDD _00317_ sky130_fd_sc_hd__mux2_1
X_12945_ _03679_ net5 net496 VSS VSS VDD VDD _00318_ sky130_fd_sc_hd__mux2_1
X_12946_ u0.w\[0\]\[8\] u0.subword\[8\] VSS VSS VDD VDD _03911_
+ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_53_1279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12948_ _03911_ net6 net494 VSS VSS VDD VDD _00319_ sky130_fd_sc_hd__mux2_1
X_12949_ u0.w\[0\]\[9\] u0.subword\[9\] VSS VSS VDD VDD _03913_
+ sky130_fd_sc_hd__xor2_1
X_12950_ _03913_ net7 net495 VSS VSS VDD VDD _00320_ sky130_fd_sc_hd__mux2_1
X_12951_ u0.subword\[10\] u0.w\[0\]\[10\] VSS VSS VDD VDD
+ _03914_ sky130_fd_sc_hd__xor2_1
X_12952_ _03914_ net8 net495 VSS VSS VDD VDD _00290_ sky130_fd_sc_hd__mux2_1
X_12953_ u0.w\[0\]\[11\] u0.subword\[11\] VSS VSS VDD VDD
+ _03915_ sky130_fd_sc_hd__xor2_1
X_12954_ _03915_ net9 net652 VSS VSS VDD VDD _00291_ sky130_fd_sc_hd__mux2_1
X_12955_ u0.w\[0\]\[12\] u0.subword\[12\] VSS VSS VDD VDD
+ _03916_ sky130_fd_sc_hd__xor2_1
X_12956_ _03916_ net10 net494 VSS VSS VDD VDD _00292_ sky130_fd_sc_hd__mux2_1
X_12957_ u0.w\[0\]\[13\] u0.subword\[13\] VSS VSS VDD VDD
+ _03917_ sky130_fd_sc_hd__xor2_1
X_12958_ _03917_ net11 net652 VSS VSS VDD VDD _00293_ sky130_fd_sc_hd__mux2_1
X_12959_ u0.w\[0\]\[14\] u0.subword\[14\] VSS VSS VDD VDD
+ _03918_ sky130_fd_sc_hd__xor2_1
X_12960_ _03918_ net13 net494 VSS VSS VDD VDD _00294_ sky130_fd_sc_hd__mux2_1
X_12961_ _03745_ net14 net494 VSS VSS VDD VDD _00295_ sky130_fd_sc_hd__mux2_1
X_12962_ _03581_ net15 net495 VSS VSS VDD VDD _00296_ sky130_fd_sc_hd__mux2_1
X_12963_ _03587_ net16 net497 VSS VSS VDD VDD _00297_ sky130_fd_sc_hd__mux2_1
X_12964_ _03613_ net17 net495 VSS VSS VDD VDD _00298_ sky130_fd_sc_hd__mux2_1
X_12965_ u0.w\[0\]\[19\] u0.subword\[19\] VSS VSS VDD VDD
+ _03919_ sky130_fd_sc_hd__xor2_1
X_12966_ _03919_ net18 net494 VSS VSS VDD VDD _00299_ sky130_fd_sc_hd__mux2_1
X_12967_ u0.w\[0\]\[20\] u0.subword\[20\] VSS VSS VDD VDD
+ _03920_ sky130_fd_sc_hd__xor2_1
X_12968_ _03920_ net19 net494 VSS VSS VDD VDD _00301_ sky130_fd_sc_hd__mux2_1
X_12969_ u0.w\[0\]\[21\] u0.subword\[21\] VSS VSS VDD VDD
+ _03921_ sky130_fd_sc_hd__xor2_1
X_12970_ _03921_ net20 net494 VSS VSS VDD VDD _00302_ sky130_fd_sc_hd__mux2_1
X_12971_ u0.w\[0\]\[22\] u0.subword\[22\] VSS VSS VDD VDD
+ _03922_ sky130_fd_sc_hd__xor2_1
X_12972_ _03922_ net21 net494 VSS VSS VDD VDD _00303_ sky130_fd_sc_hd__mux2_1
X_12973_ _03761_ net22 net494 VSS VSS VDD VDD _00304_ sky130_fd_sc_hd__mux2_1
X_12974_ net497 net24 VSS VSS VDD VDD _03923_ sky130_fd_sc_hd__nand2_1
X_12975_ net497 _03769_ _03923_ VSS VSS VDD VDD _00305_ sky130_fd_sc_hd__o21ai_0
X_12976_ net496 net25 VSS VSS VDD VDD _03924_ sky130_fd_sc_hd__nand2_1
X_12977_ net497 _03774_ _03924_ VSS VSS VDD VDD _00306_ sky130_fd_sc_hd__o21ai_0
X_12978_ net497 net26 VSS VSS VDD VDD _03925_ sky130_fd_sc_hd__nand2_1
X_12979_ net497 _03779_ _03925_ VSS VSS VDD VDD _00307_ sky130_fd_sc_hd__o21ai_0
X_12980_ net497 net27 VSS VSS VDD VDD _03926_ sky130_fd_sc_hd__nand2_2
X_12981_ net497 _03787_ _03926_ VSS VSS VDD VDD _00308_ sky130_fd_sc_hd__o21ai_0
X_12982_ net497 net28 VSS VSS VDD VDD _03927_ sky130_fd_sc_hd__nand2_2
X_12983_ net497 _03796_ _03927_ VSS VSS VDD VDD _00309_ sky130_fd_sc_hd__o21ai_0
X_12984_ u0.r0.out\[29\] _03805_ VSS VSS VDD VDD _03928_ sky130_fd_sc_hd__xor2_1
X_12985_ net129 net29 VSS VSS VDD VDD _03929_ sky130_fd_sc_hd__nand2_4
X_12986_ net497 _03928_ _03929_ VSS VSS VDD VDD _00310_ sky130_fd_sc_hd__o21ai_0
X_12987_ net495 net30 VSS VSS VDD VDD _03930_ sky130_fd_sc_hd__nand2_8
X_12988_ net495 _03813_ _03930_ VSS VSS VDD VDD _00312_ sky130_fd_sc_hd__o21ai_0
X_12989_ net494 net31 VSS VSS VDD VDD _03931_ sky130_fd_sc_hd__nand2_2
X_12990_ net652 _03819_ _03931_ VSS VSS VDD VDD _00313_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_53_1278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13004_ _03593_ _03617_ VSS VSS VDD VDD _03942_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_52_1265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13006_ _11829_ VSS VSS VDD VDD _03944_ sky130_fd_sc_hd__inv_2
X_13007_ _03944_ _03617_ VSS VSS VDD VDD _03945_ sky130_fd_sc_hd__nand2_4
X_13008_ net709 _03593_ _03945_ VSS VSS VDD VDD _03946_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_52_1264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13011_ _11829_ net709 _03942_ _03946_ _03610_ VSS VSS VDD
+ VDD _03949_ sky130_fd_sc_hd__a311oi_1
X_13012_ _03578_ _03617_ VSS VSS VDD VDD _03950_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_52_1262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13014_ _03578_ _03617_ VSS VSS VDD VDD _03952_ sky130_fd_sc_hd__nand2_1
X_13015_ _11838_ _03952_ VSS VSS VDD VDD _03953_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_52_1261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13017_ _03579_ _03617_ VSS VSS VDD VDD _03955_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_52_1260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13019_ _03578_ _03618_ VSS VSS VDD VDD _03957_ sky130_fd_sc_hd__nor2_4
X_13020_ _03955_ _03957_ VSS VSS VDD VDD _03958_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_52_1259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13022_ _11842_ _03958_ _03610_ VSS VSS VDD VDD _03960_ sky130_fd_sc_hd__o21ai_0
X_13023_ _11829_ _03950_ _03953_ _03960_ VSS VSS VDD VDD _03961_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_52_1258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13026_ _03949_ _03961_ _03758_ VSS VSS VDD VDD _03964_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_52_1256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13028_ _11833_ _03617_ VSS VSS VDD VDD _03966_ sky130_fd_sc_hd__nand2_8
X_13029_ _03593_ _03618_ VSS VSS VDD VDD _03967_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_52_1255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13031_ net705 _03618_ VSS VSS VDD VDD _03969_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_52_1254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13034_ _11830_ _03617_ VSS VSS VDD VDD _03972_ sky130_fd_sc_hd__nor2_1
X_13035_ net709 _03969_ _03972_ VSS VSS VDD VDD _03973_ sky130_fd_sc_hd__nor3_1
X_13036_ net709 _03966_ _03967_ _03973_ _03610_ VSS VSS VDD
+ VDD _03974_ sky130_fd_sc_hd__a311oi_1
XTAP_TAPCELL_ROW_52_1252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13039_ _03586_ _03617_ VSS VSS VDD VDD _03977_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_52_1250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13042_ _11828_ _03618_ VSS VSS VDD VDD _03980_ sky130_fd_sc_hd__nand2_4
X_13043_ _03579_ _03977_ _03980_ VSS VSS VDD VDD _03981_ sky130_fd_sc_hd__nand3_1
X_13044_ _03610_ _03981_ VSS VSS VDD VDD _03982_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_52_1248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13046_ _11844_ _03618_ VSS VSS VDD VDD _03984_ sky130_fd_sc_hd__nand2_1
X_13047_ _03942_ _03984_ _03579_ VSS VSS VDD VDD _03985_ sky130_fd_sc_hd__a21oi_1
X_13048_ _03982_ _03985_ VSS VSS VDD VDD _03986_ sky130_fd_sc_hd__nor2_1
X_13049_ _03974_ _03986_ _03759_ VSS VSS VDD VDD _03987_ sky130_fd_sc_hd__o21ai_0
X_13050_ _03766_ _03964_ _03987_ VSS VSS VDD VDD _03988_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_52_1247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13053_ _03579_ _03759_ VSS VSS VDD VDD _03991_ sky130_fd_sc_hd__nor2_1
X_13054_ _03759_ _03950_ _03991_ VSS VSS VDD VDD _03992_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_52_1245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13057_ _03579_ _03758_ VSS VSS VDD VDD _03995_ sky130_fd_sc_hd__nand2_1
X_13058_ _11840_ _03618_ VSS VSS VDD VDD _03996_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_51_1243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13060_ _11835_ _03758_ _03617_ VSS VSS VDD VDD _03998_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_51_1242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13063_ _03758_ _03996_ _03998_ net709 VSS VSS VDD VDD _04001_
+ sky130_fd_sc_hd__o211ai_1
X_13064_ _11829_ _03992_ _03995_ _11854_ _04001_ VSS VSS VDD
+ VDD _04002_ sky130_fd_sc_hd__o221ai_1
XTAP_TAPCELL_ROW_51_1240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13066_ _11842_ _03618_ VSS VSS VDD VDD _04004_ sky130_fd_sc_hd__nand2_4
X_13067_ _11833_ _03617_ VSS VSS VDD VDD _04005_ sky130_fd_sc_hd__nor2_1
X_13068_ _03969_ _04005_ VSS VSS VDD VDD _04006_ sky130_fd_sc_hd__nor2_1
X_13069_ _03579_ _04006_ VSS VSS VDD VDD _04007_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_51_1239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13071_ _03579_ _03977_ _04004_ _04007_ _03611_ VSS VSS VDD
+ VDD _04009_ sky130_fd_sc_hd__a311oi_1
X_13072_ _11835_ net709 _03617_ _03758_ _03982_ VSS VSS VDD
+ VDD _04010_ sky130_fd_sc_hd__a311oi_1
X_13073_ _03611_ _04002_ _04009_ _03758_ _04010_ VSS VSS VDD
+ VDD _04011_ sky130_fd_sc_hd__a221oi_1
X_13074_ _03767_ _04011_ VSS VSS VDD VDD _04012_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_51_1238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13076_ _11835_ _03617_ _03966_ _03579_ VSS VSS VDD VDD _04014_
+ sky130_fd_sc_hd__o211ai_1
X_13077_ _03578_ _03977_ VSS VSS VDD VDD _04015_ sky130_fd_sc_hd__nand2_1
X_13078_ _03944_ _03617_ VSS VSS VDD VDD _04016_ sky130_fd_sc_hd__nor2_1
X_13079_ _11828_ _03618_ VSS VSS VDD VDD _04017_ sky130_fd_sc_hd__nor2_1
X_13080_ _03579_ _04016_ _04017_ VSS VSS VDD VDD _04018_ sky130_fd_sc_hd__or3_1
X_13081_ _11842_ _03617_ VSS VSS VDD VDD _04019_ sky130_fd_sc_hd__nand2b_1
X_13082_ _11838_ _03617_ _04019_ _03579_ VSS VSS VDD VDD _04020_
+ sky130_fd_sc_hd__o211ai_1
X_13083_ _04018_ _04020_ _03759_ VSS VSS VDD VDD _04021_ sky130_fd_sc_hd__a21oi_1
X_13084_ _03759_ _04014_ _04015_ _04021_ _03611_ VSS VSS VDD
+ VDD _04022_ sky130_fd_sc_hd__a311o_1
XTAP_TAPCELL_ROW_51_1237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13086_ _03944_ _03618_ VSS VSS VDD VDD _04024_ sky130_fd_sc_hd__nand2_4
X_13087_ _11830_ VSS VSS VDD VDD _04025_ sky130_fd_sc_hd__inv_1
X_13088_ _04025_ _03617_ VSS VSS VDD VDD _04026_ sky130_fd_sc_hd__nand2_4
X_13089_ _04024_ _04026_ VSS VSS VDD VDD _04027_ sky130_fd_sc_hd__nand2_1
X_13090_ _03586_ _03618_ VSS VSS VDD VDD _04028_ sky130_fd_sc_hd__nand2_4
X_13091_ _03966_ _04028_ _03579_ VSS VSS VDD VDD _04029_ sky130_fd_sc_hd__a21oi_1
X_13092_ _03579_ _04027_ _04029_ _03758_ VSS VSS VDD VDD _04030_
+ sky130_fd_sc_hd__a211oi_1
X_13093_ net702 _03617_ VSS VSS VDD VDD _04031_ sky130_fd_sc_hd__nand2_1
X_13094_ _03586_ net489 VSS VSS VDD VDD _04032_ sky130_fd_sc_hd__nand2_2
X_13095_ _04031_ _04032_ _03579_ VSS VSS VDD VDD _04033_ sky130_fd_sc_hd__a21o_1
X_13096_ _03579_ _04031_ _04032_ VSS VSS VDD VDD _04034_ sky130_fd_sc_hd__nand3_1
X_13097_ _04033_ _04034_ _03759_ VSS VSS VDD VDD _04035_ sky130_fd_sc_hd__a21oi_1
X_13098_ _04030_ _04035_ _03611_ VSS VSS VDD VDD _04036_ sky130_fd_sc_hd__o21ai_0
X_13099_ _04022_ _04036_ _03767_ VSS VSS VDD VDD _04037_ sky130_fd_sc_hd__a21oi_1
X_13100_ _11829_ _03618_ VSS VSS VDD VDD _04038_ sky130_fd_sc_hd__nor2_2
X_13101_ net489 _03617_ VSS VSS VDD VDD _04039_ sky130_fd_sc_hd__nor2_2
X_13102_ _04038_ _04039_ _03578_ VSS VSS VDD VDD _04040_ sky130_fd_sc_hd__o21ai_2
X_13103_ _03586_ _03617_ VSS VSS VDD VDD _04041_ sky130_fd_sc_hd__nor2_4
X_13104_ _11838_ _03618_ VSS VSS VDD VDD _04042_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_51_1236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13106_ _04041_ _04042_ _03579_ VSS VSS VDD VDD _04044_ sky130_fd_sc_hd__o21ai_0
X_13107_ _11833_ _03618_ VSS VSS VDD VDD _04045_ sky130_fd_sc_hd__and2_1
X_13108_ _11840_ _03618_ VSS VSS VDD VDD _04046_ sky130_fd_sc_hd__nor2_4
X_13109_ _03578_ _04045_ _04046_ VSS VSS VDD VDD _04047_ sky130_fd_sc_hd__nor3_2
X_13110_ _11844_ _03955_ _04047_ _03759_ VSS VSS VDD VDD _04048_
+ sky130_fd_sc_hd__a211oi_1
X_13111_ _03759_ _04040_ _04044_ _04048_ _03611_ VSS VSS VDD
+ VDD _04049_ sky130_fd_sc_hd__a311oi_1
X_13112_ _04005_ _04042_ _03578_ VSS VSS VDD VDD _04050_ sky130_fd_sc_hd__o21ai_0
X_13113_ _11844_ _03950_ _03759_ VSS VSS VDD VDD _04051_ sky130_fd_sc_hd__a21oi_1
X_13114_ _03579_ _03618_ VSS VSS VDD VDD _04052_ sky130_fd_sc_hd__nand2_2
X_13115_ _11844_ _03617_ VSS VSS VDD VDD _04053_ sky130_fd_sc_hd__nor2_1
X_13116_ _11842_ _03617_ _04053_ VSS VSS VDD VDD _04054_ sky130_fd_sc_hd__a21oi_1
X_13117_ _11835_ _04052_ _04054_ _03579_ VSS VSS VDD VDD _04055_
+ sky130_fd_sc_hd__o22ai_1
X_13118_ _04050_ _04051_ _04055_ _03759_ _03610_ VSS VSS VDD
+ VDD _04056_ sky130_fd_sc_hd__a221oi_1
X_13119_ _04049_ _04056_ _03767_ VSS VSS VDD VDD _04057_ sky130_fd_sc_hd__o21a_1
X_13120_ net474 _04037_ _04057_ VSS VSS VDD VDD _04058_ sky130_fd_sc_hd__nor3_1
X_13121_ net474 _03988_ _04012_ _04058_ VSS VSS VDD VDD _00000_
+ sky130_fd_sc_hd__a31oi_2
XTAP_TAPCELL_ROW_51_1235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13123_ _11829_ _03618_ VSS VSS VDD VDD _04060_ sky130_fd_sc_hd__nand2_4
X_13124_ _11835_ _03617_ VSS VSS VDD VDD _04061_ sky130_fd_sc_hd__nand2b_4
X_13125_ _03578_ _03977_ _04004_ VSS VSS VDD VDD _04062_ sky130_fd_sc_hd__and3_1
X_13126_ _03579_ _04060_ _04061_ _04062_ _03758_ VSS VSS VDD
+ VDD _04063_ sky130_fd_sc_hd__a311oi_1
X_13127_ _11847_ _03579_ VSS VSS VDD VDD _04064_ sky130_fd_sc_hd__nand2_1
X_13128_ _11835_ _03617_ VSS VSS VDD VDD _04065_ sky130_fd_sc_hd__nand2_1
X_13129_ net709 _03967_ _04065_ VSS VSS VDD VDD _04066_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_51_1234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13131_ _04064_ _04066_ _03759_ VSS VSS VDD VDD _04068_ sky130_fd_sc_hd__a21oi_1
X_13132_ _04063_ _04068_ _03611_ VSS VSS VDD VDD _04069_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_51_1233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13134_ net706 net489 VSS VSS VDD VDD _04071_ sky130_fd_sc_hd__nand2_1
X_13135_ _03579_ _04028_ _04071_ VSS VSS VDD VDD _04072_ sky130_fd_sc_hd__nand3_1
X_13136_ _03579_ _04041_ _04038_ _04072_ VSS VSS VDD VDD _04073_
+ sky130_fd_sc_hd__o31ai_1
X_13137_ _04025_ _03618_ VSS VSS VDD VDD _04074_ sky130_fd_sc_hd__nand2_2
X_13138_ _03579_ _03945_ _04074_ _03759_ VSS VSS VDD VDD _04075_
+ sky130_fd_sc_hd__a31oi_1
X_13139_ _11833_ _03618_ VSS VSS VDD VDD _04076_ sky130_fd_sc_hd__nand2_2
X_13140_ _03578_ _04076_ _04061_ _03611_ VSS VSS VDD VDD _04077_
+ sky130_fd_sc_hd__a31oi_2
X_13141_ _03610_ _03759_ _04073_ _04075_ _04077_ VSS VSS VDD
+ VDD _04078_ sky130_fd_sc_hd__a32oi_1
X_13142_ _11835_ _03618_ VSS VSS VDD VDD _04079_ sky130_fd_sc_hd__nand2_1
X_13143_ _03977_ _04024_ _03578_ VSS VSS VDD VDD _04080_ sky130_fd_sc_hd__a21oi_1
X_13144_ net709 _03977_ _04079_ _04080_ VSS VSS VDD VDD _04081_
+ sky130_fd_sc_hd__a31oi_1
X_13145_ _03578_ _03618_ VSS VSS VDD VDD _04082_ sky130_fd_sc_hd__nand2_2
X_13146_ _03579_ _04026_ _03967_ VSS VSS VDD VDD _04083_ sky130_fd_sc_hd__nand3_1
X_13147_ _11828_ _04082_ _04083_ _03759_ VSS VSS VDD VDD _04084_
+ sky130_fd_sc_hd__o211ai_1
X_13148_ _03759_ _04081_ _04084_ VSS VSS VDD VDD _04085_ sky130_fd_sc_hd__o21ai_0
X_13149_ _11835_ _03955_ VSS VSS VDD VDD _04086_ sky130_fd_sc_hd__nand2_1
X_13150_ _11828_ _03617_ VSS VSS VDD VDD _04087_ sky130_fd_sc_hd__nand2_4
X_13151_ _03579_ _04060_ _04087_ VSS VSS VDD VDD _04088_ sky130_fd_sc_hd__nand3_1
X_13152_ _03759_ _04086_ _04088_ VSS VSS VDD VDD _04089_ sky130_fd_sc_hd__nand3_1
X_13153_ _03579_ _03617_ VSS VSS VDD VDD _04090_ sky130_fd_sc_hd__nand2_2
X_13154_ _03593_ _03618_ VSS VSS VDD VDD _04091_ sky130_fd_sc_hd__nor2_1
X_13155_ _03586_ net489 VSS VSS VDD VDD _04092_ sky130_fd_sc_hd__nor2_1
X_13156_ _04091_ _04092_ _03578_ VSS VSS VDD VDD _04093_ sky130_fd_sc_hd__o21ai_2
X_13157_ _11833_ _04090_ _04093_ _03758_ VSS VSS VDD VDD _04094_
+ sky130_fd_sc_hd__o211ai_1
X_13158_ _04089_ _04094_ _03611_ VSS VSS VDD VDD _04095_ sky130_fd_sc_hd__a21oi_1
X_13159_ _03611_ _04085_ _04095_ net474 VSS VSS VDD VDD _04096_
+ sky130_fd_sc_hd__a211oi_1
X_13160_ net474 _04069_ _04078_ _04096_ VSS VSS VDD VDD _04097_
+ sky130_fd_sc_hd__a31oi_2
X_13161_ net489 _03617_ VSS VSS VDD VDD _04098_ sky130_fd_sc_hd__nand2_2
X_13162_ _03579_ _04098_ _04079_ VSS VSS VDD VDD _04099_ sky130_fd_sc_hd__and3_1
X_13163_ _03578_ _04019_ _04028_ _04099_ VSS VSS VDD VDD _04100_
+ sky130_fd_sc_hd__a31oi_1
X_13164_ _03579_ _03945_ _04004_ VSS VSS VDD VDD _04101_ sky130_fd_sc_hd__nand3_1
X_13165_ _03579_ _03969_ _04053_ _04101_ _03611_ VSS VSS VDD
+ VDD _04102_ sky130_fd_sc_hd__o311ai_4
X_13166_ _03611_ _04100_ _04102_ VSS VSS VDD VDD _04103_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_51_1232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13168_ _03977_ _03980_ VSS VSS VDD VDD _04105_ sky130_fd_sc_hd__nand2_1
X_13169_ _03578_ _04105_ VSS VSS VDD VDD _04106_ sky130_fd_sc_hd__nand2_1
X_13170_ _03944_ _03950_ _03611_ VSS VSS VDD VDD _04107_ sky130_fd_sc_hd__a21oi_1
X_13171_ _11844_ _03618_ _04074_ _03578_ VSS VSS VDD VDD _04108_
+ sky130_fd_sc_hd__o211ai_1
X_13172_ _04088_ _04108_ _03610_ VSS VSS VDD VDD _04109_ sky130_fd_sc_hd__a21oi_1
X_13173_ _04106_ _04107_ _04109_ _03602_ VSS VSS VDD VDD _04110_
+ sky130_fd_sc_hd__a211oi_1
X_13174_ _03602_ _04103_ _04110_ _03758_ VSS VSS VDD VDD _04111_
+ sky130_fd_sc_hd__a211oi_1
X_13175_ _11842_ _03618_ VSS VSS VDD VDD _04112_ sky130_fd_sc_hd__nor2_1
X_13176_ _03579_ _04112_ _04041_ VSS VSS VDD VDD _04113_ sky130_fd_sc_hd__nor3_1
X_13177_ _11833_ _03618_ VSS VSS VDD VDD _04114_ sky130_fd_sc_hd__nor2_1
X_13178_ _11828_ _03617_ VSS VSS VDD VDD _04115_ sky130_fd_sc_hd__nor2_1
X_13179_ _03578_ _04114_ _04115_ VSS VSS VDD VDD _04116_ sky130_fd_sc_hd__nor3_1
X_13180_ _04113_ _04116_ _03602_ VSS VSS VDD VDD _04117_ sky130_fd_sc_hd__o21ai_1
X_13181_ net702 _03618_ VSS VSS VDD VDD _04118_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_51_1231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13183_ _04118_ _04098_ _03579_ VSS VSS VDD VDD _04120_ sky130_fd_sc_hd__a21oi_1
X_13184_ _04099_ _04120_ net474 VSS VSS VDD VDD _04121_ sky130_fd_sc_hd__o21ai_0
X_13185_ _11838_ _03617_ VSS VSS VDD VDD _04122_ sky130_fd_sc_hd__nand2_2
X_13186_ _11856_ _03578_ VSS VSS VDD VDD _04123_ sky130_fd_sc_hd__nor2_1
X_13187_ net709 _04122_ _03980_ _04123_ net474 VSS VSS VDD
+ VDD _04124_ sky130_fd_sc_hd__a32oi_4
X_13188_ _03611_ _04124_ VSS VSS VDD VDD _04125_ sky130_fd_sc_hd__nor2_1
X_13189_ _03611_ _04117_ _04121_ _04125_ VSS VSS VDD VDD _04126_
+ sky130_fd_sc_hd__a31oi_1
X_13190_ _03759_ _04126_ VSS VSS VDD VDD _04127_ sky130_fd_sc_hd__nor2_1
X_13191_ _03767_ _04111_ _04127_ VSS VSS VDD VDD _04128_ sky130_fd_sc_hd__nor3_1
X_13192_ _03767_ _04097_ _04128_ VSS VSS VDD VDD _00001_ sky130_fd_sc_hd__a21oi_4
X_13193_ _03593_ _03617_ VSS VSS VDD VDD _04129_ sky130_fd_sc_hd__nor2_2
X_13194_ _11829_ _03617_ VSS VSS VDD VDD _04130_ sky130_fd_sc_hd__nand2_1
X_13195_ _11838_ _03617_ _04130_ _03579_ VSS VSS VDD VDD _04131_
+ sky130_fd_sc_hd__o211ai_1
X_13196_ _03579_ _04112_ _04129_ _04131_ _03759_ VSS VSS VDD
+ VDD _04132_ sky130_fd_sc_hd__o311ai_0
X_13197_ _03578_ _04114_ _04039_ VSS VSS VDD VDD _04133_ sky130_fd_sc_hd__or3_1
X_13198_ _11849_ _03579_ _03758_ _04133_ VSS VSS VDD VDD _04134_
+ sky130_fd_sc_hd__o211ai_1
X_13199_ _11856_ net709 VSS VSS VDD VDD _04135_ sky130_fd_sc_hd__nand2_1
X_13200_ _03578_ _04091_ _04092_ VSS VSS VDD VDD _04136_ sky130_fd_sc_hd__or3_1
X_13201_ _03579_ _03966_ VSS VSS VDD VDD _04137_ sky130_fd_sc_hd__nor2_1
X_13202_ _11852_ _03579_ _03759_ _04137_ VSS VSS VDD VDD _04138_
+ sky130_fd_sc_hd__a211oi_1
X_13203_ _03759_ _04135_ _04136_ _04138_ _03611_ VSS VSS VDD
+ VDD _04139_ sky130_fd_sc_hd__a311oi_2
X_13204_ _03611_ _04132_ _04134_ _04139_ VSS VSS VDD VDD _04140_
+ sky130_fd_sc_hd__a31oi_1
X_13205_ _03579_ _04129_ VSS VSS VDD VDD _04141_ sky130_fd_sc_hd__nand2_1
X_13206_ _03579_ _03618_ VSS VSS VDD VDD _04142_ sky130_fd_sc_hd__nor2_2
X_13207_ _04118_ _04065_ _03578_ VSS VSS VDD VDD _04143_ sky130_fd_sc_hd__a21oi_1
X_13208_ _11830_ _04142_ _04143_ _03610_ VSS VSS VDD VDD _04144_
+ sky130_fd_sc_hd__a211oi_1
X_13209_ _03610_ _04065_ _04141_ _04144_ VSS VSS VDD VDD _04145_
+ sky130_fd_sc_hd__a31oi_1
X_13210_ _03579_ _03996_ _03759_ VSS VSS VDD VDD _04146_ sky130_fd_sc_hd__o21ai_0
X_13211_ _11835_ _03617_ _04026_ VSS VSS VDD VDD _04147_ sky130_fd_sc_hd__o21ai_1
X_13212_ _03578_ _04147_ VSS VSS VDD VDD _04148_ sky130_fd_sc_hd__nand2_1
X_13213_ _04076_ _04061_ _03578_ VSS VSS VDD VDD _04149_ sky130_fd_sc_hd__a21oi_1
X_13214_ _03611_ _04149_ VSS VSS VDD VDD _04150_ sky130_fd_sc_hd__nor2_1
X_13215_ _03611_ _04133_ _04148_ _04150_ _04040_ VSS VSS VDD
+ VDD _04151_ sky130_fd_sc_hd__a32o_1
X_13216_ _04145_ _04146_ _04151_ _03759_ _03766_ VSS VSS VDD
+ VDD _04152_ sky130_fd_sc_hd__o221a_1
X_13217_ _03767_ _04140_ _04152_ VSS VSS VDD VDD _04153_ sky130_fd_sc_hd__a21oi_2
X_13218_ _11840_ _03617_ VSS VSS VDD VDD _04154_ sky130_fd_sc_hd__nand2_1
X_13219_ _03578_ _04016_ _04038_ VSS VSS VDD VDD _04155_ sky130_fd_sc_hd__nor3_2
X_13220_ net709 _04118_ _04154_ _04155_ VSS VSS VDD VDD _04156_
+ sky130_fd_sc_hd__a31oi_1
X_13221_ _04074_ _04087_ _03578_ VSS VSS VDD VDD _04157_ sky130_fd_sc_hd__a21oi_1
X_13222_ _04137_ _04157_ _03758_ VSS VSS VDD VDD _04158_ sky130_fd_sc_hd__o21ai_0
X_13223_ _03758_ _04156_ _04158_ VSS VSS VDD VDD _04159_ sky130_fd_sc_hd__o21ai_0
X_13224_ _04060_ _03942_ _03579_ VSS VSS VDD VDD _04160_ sky130_fd_sc_hd__a21oi_1
X_13225_ _11844_ _03617_ VSS VSS VDD VDD _04161_ sky130_fd_sc_hd__nand2_2
X_13226_ _04118_ _04161_ _03578_ VSS VSS VDD VDD _04162_ sky130_fd_sc_hd__a21oi_1
X_13227_ _04028_ _04026_ _03579_ VSS VSS VDD VDD _04163_ sky130_fd_sc_hd__a21oi_1
X_13228_ _03593_ _03617_ _03578_ VSS VSS VDD VDD _04164_ sky130_fd_sc_hd__a21oi_1
X_13229_ _03996_ _04164_ VSS VSS VDD VDD _04165_ sky130_fd_sc_hd__and2_0
X_13230_ _04163_ _04165_ _03759_ VSS VSS VDD VDD _04166_ sky130_fd_sc_hd__o21ai_0
X_13231_ _03759_ _04160_ _04162_ _04166_ _03611_ VSS VSS VDD
+ VDD _04167_ sky130_fd_sc_hd__o311ai_0
X_13232_ _03611_ _04159_ _04167_ VSS VSS VDD VDD _04168_ sky130_fd_sc_hd__o21ai_1
X_13233_ _11849_ _04041_ _03579_ VSS VSS VDD VDD _04169_ sky130_fd_sc_hd__o21ai_0
X_13234_ _03578_ _04028_ VSS VSS VDD VDD _04170_ sky130_fd_sc_hd__nor2_1
X_13235_ _11828_ _03958_ VSS VSS VDD VDD _04171_ sky130_fd_sc_hd__nor2_1
X_13236_ _03759_ _03953_ _04170_ _04171_ VSS VSS VDD VDD _04172_
+ sky130_fd_sc_hd__nor4_1
X_13237_ _03759_ _04040_ _04169_ _04172_ _03610_ VSS VSS VDD
+ VDD _04173_ sky130_fd_sc_hd__a311oi_2
X_13238_ _04060_ _04065_ _03578_ VSS VSS VDD VDD _04174_ sky130_fd_sc_hd__a21oi_1
X_13239_ _11842_ _04082_ VSS VSS VDD VDD _04175_ sky130_fd_sc_hd__nor2_1
X_13240_ _11854_ _03578_ VSS VSS VDD VDD _04176_ sky130_fd_sc_hd__nand2_1
X_13241_ net709 _04045_ _04038_ _04176_ _03759_ VSS VSS VDD
+ VDD _04177_ sky130_fd_sc_hd__o311ai_1
X_13242_ _03759_ _04174_ _04175_ _04177_ _03610_ VSS VSS VDD
+ VDD _04178_ sky130_fd_sc_hd__o311ai_0
X_13243_ _03767_ _04178_ VSS VSS VDD VDD _04179_ sky130_fd_sc_hd__nand2_1
X_13244_ _03767_ _04168_ _04173_ _04179_ _03602_ VSS VSS VDD
+ VDD _04180_ sky130_fd_sc_hd__o221ai_1
X_13245_ _03602_ _04153_ _04180_ VSS VSS VDD VDD _00002_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_51_1230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13247_ _03578_ _04041_ _03958_ _11840_ VSS VSS VDD VDD _04182_
+ sky130_fd_sc_hd__a22oi_1
X_13248_ _04060_ _04031_ _03579_ VSS VSS VDD VDD _04183_ sky130_fd_sc_hd__a21oi_1
X_13249_ _03579_ _04118_ _04026_ VSS VSS VDD VDD _04184_ sky130_fd_sc_hd__and3_1
X_13250_ _04183_ _04184_ net474 VSS VSS VDD VDD _04185_ sky130_fd_sc_hd__o21ai_0
X_13251_ net474 _04182_ _04185_ _03610_ VSS VSS VDD VDD _04186_
+ sky130_fd_sc_hd__o211ai_1
X_13252_ _03602_ _04090_ VSS VSS VDD VDD _04187_ sky130_fd_sc_hd__nor2_1
X_13253_ _03602_ _03955_ _04187_ VSS VSS VDD VDD _04188_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_51_1229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13255_ _04039_ _04042_ net709 net474 VSS VSS VDD VDD _04190_
+ sky130_fd_sc_hd__o211ai_2
X_13256_ _11844_ _03950_ VSS VSS VDD VDD _04191_ sky130_fd_sc_hd__nand2_1
X_13257_ _11829_ _04188_ _04190_ _04191_ _03611_ VSS VSS VDD
+ VDD _04192_ sky130_fd_sc_hd__o2111ai_4
X_13258_ _11849_ _03579_ _04041_ _04090_ _11829_ VSS VSS VDD
+ VDD _04193_ sky130_fd_sc_hd__o32a_1
X_13259_ _04118_ _04032_ _03579_ VSS VSS VDD VDD _04194_ sky130_fd_sc_hd__a21oi_1
X_13260_ _03579_ _04060_ _04098_ _04194_ _03611_ VSS VSS VDD
+ VDD _04195_ sky130_fd_sc_hd__a311oi_1
X_13261_ _03611_ _04193_ _04195_ VSS VSS VDD VDD _04196_ sky130_fd_sc_hd__a21oi_1
X_13262_ _11838_ _03618_ VSS VSS VDD VDD _04197_ sky130_fd_sc_hd__nand2_1
X_13263_ _03578_ _03977_ _04197_ VSS VSS VDD VDD _04198_ sky130_fd_sc_hd__and3_1
X_13264_ _03579_ _04004_ _04130_ _04198_ _03610_ VSS VSS VDD
+ VDD _04199_ sky130_fd_sc_hd__a311o_1
X_13265_ _04074_ _04061_ _03578_ VSS VSS VDD VDD _04200_ sky130_fd_sc_hd__a21oi_1
X_13266_ _04160_ _04200_ _03610_ VSS VSS VDD VDD _04201_ sky130_fd_sc_hd__o21ai_1
X_13267_ _04199_ _04201_ net474 VSS VSS VDD VDD _04202_ sky130_fd_sc_hd__a21oi_1
X_13268_ net474 _04196_ _04202_ _03766_ VSS VSS VDD VDD _04203_
+ sky130_fd_sc_hd__a211oi_1
X_13269_ _03766_ _04186_ _04192_ _04203_ VSS VSS VDD VDD _04204_
+ sky130_fd_sc_hd__a31oi_1
X_13270_ _03579_ _04028_ _04154_ VSS VSS VDD VDD _04205_ sky130_fd_sc_hd__and3_1
X_13271_ _04122_ _03980_ _03579_ VSS VSS VDD VDD _04206_ sky130_fd_sc_hd__a21oi_1
X_13272_ _04205_ _04206_ _03610_ VSS VSS VDD VDD _04207_ sky130_fd_sc_hd__o21a_1
X_13273_ _03611_ _04163_ _04207_ _03602_ VSS VSS VDD VDD _04208_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_51_1228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13275_ _04024_ _04026_ _03579_ VSS VSS VDD VDD _04210_ sky130_fd_sc_hd__a21oi_1
X_13276_ _03579_ _03977_ _03996_ _04210_ VSS VSS VDD VDD _04211_
+ sky130_fd_sc_hd__a31oi_1
X_13277_ _11842_ _04052_ _04093_ _03610_ _04031_ VSS VSS VDD
+ VDD _04212_ sky130_fd_sc_hd__o2111ai_1
X_13278_ _03610_ _04211_ _04212_ VSS VSS VDD VDD _04213_ sky130_fd_sc_hd__o21ai_0
X_13279_ net474 _04213_ VSS VSS VDD VDD _04214_ sky130_fd_sc_hd__nor2_1
X_13280_ _04208_ _04214_ _03766_ VSS VSS VDD VDD _04215_ sky130_fd_sc_hd__o21ai_0
X_13281_ _11833_ _03957_ _04194_ VSS VSS VDD VDD _04216_ sky130_fd_sc_hd__a21oi_1
X_13282_ _03579_ _04016_ _04046_ _04083_ _03611_ VSS VSS VDD
+ VDD _04217_ sky130_fd_sc_hd__o311ai_2
X_13283_ _03611_ _04216_ _04217_ VSS VSS VDD VDD _04218_ sky130_fd_sc_hd__o21ai_0
X_13284_ _04060_ _04122_ VSS VSS VDD VDD _04219_ sky130_fd_sc_hd__nand2_1
X_13285_ net709 _04219_ VSS VSS VDD VDD _04220_ sky130_fd_sc_hd__nand2_1
X_13286_ _03578_ _03945_ _03980_ VSS VSS VDD VDD _04221_ sky130_fd_sc_hd__nand3_1
X_13287_ _03579_ _03966_ _04197_ VSS VSS VDD VDD _04222_ sky130_fd_sc_hd__nand3_1
X_13288_ _04221_ _04222_ _03611_ VSS VSS VDD VDD _04223_ sky130_fd_sc_hd__a21oi_1
X_13289_ _03611_ _04034_ _04220_ _04223_ net474 VSS VSS VDD
+ VDD _04224_ sky130_fd_sc_hd__a311oi_1
X_13290_ net474 _04218_ _04224_ VSS VSS VDD VDD _04225_ sky130_fd_sc_hd__a21oi_1
X_13291_ _03767_ _04225_ _03758_ VSS VSS VDD VDD _04226_ sky130_fd_sc_hd__a21oi_1
X_13292_ _03758_ _04204_ _04215_ _04226_ VSS VSS VDD VDD _00003_
+ sky130_fd_sc_hd__a22oi_2
X_13293_ net709 _04041_ _04046_ VSS VSS VDD VDD _04227_ sky130_fd_sc_hd__nor3_1
X_13294_ net709 _04032_ _03942_ _04227_ VSS VSS VDD VDD _04228_
+ sky130_fd_sc_hd__a31oi_2
X_13295_ net709 _03610_ _04054_ VSS VSS VDD VDD _04229_ sky130_fd_sc_hd__nand3_1
X_13296_ _11840_ _03610_ _03586_ VSS VSS VDD VDD _04230_ sky130_fd_sc_hd__o21ai_0
X_13297_ _03617_ _04230_ VSS VSS VDD VDD _04231_ sky130_fd_sc_hd__nand2_1
X_13298_ _03586_ _03610_ _04032_ _04231_ _03579_ VSS VSS VDD
+ VDD _04232_ sky130_fd_sc_hd__o2111ai_2
X_13299_ _03610_ _04228_ _04229_ _03766_ _04232_ VSS VSS VDD
+ VDD _04233_ sky130_fd_sc_hd__o2111ai_4
X_13300_ _03579_ _04147_ VSS VSS VDD VDD _04234_ sky130_fd_sc_hd__nor2_1
X_13301_ _03579_ _04076_ _03942_ _04234_ _03610_ VSS VSS VDD
+ VDD _04235_ sky130_fd_sc_hd__a311oi_1
X_13302_ _04004_ _04164_ _04077_ VSS VSS VDD VDD _04236_ sky130_fd_sc_hd__a21boi_0
X_13303_ _04235_ _04236_ _03767_ VSS VSS VDD VDD _04237_ sky130_fd_sc_hd__o21ai_0
X_13304_ _04233_ _04237_ _03602_ VSS VSS VDD VDD _04238_ sky130_fd_sc_hd__a21oi_1
X_13305_ _03579_ _04038_ _03972_ VSS VSS VDD VDD _04239_ sky130_fd_sc_hd__nor3_1
X_13306_ _04047_ _04239_ _03767_ VSS VSS VDD VDD _04240_ sky130_fd_sc_hd__o21ai_0
X_13307_ _11828_ net709 _03957_ _11829_ _03767_ VSS VSS VDD
+ VDD _04241_ sky130_fd_sc_hd__a221o_1
X_13308_ _04240_ _04241_ _03611_ VSS VSS VDD VDD _04242_ sky130_fd_sc_hd__a21oi_1
X_13309_ _11840_ net489 _03618_ VSS VSS VDD VDD _04243_ sky130_fd_sc_hd__mux2i_4
X_13310_ _11833_ _04082_ _04243_ net709 VSS VSS VDD VDD _04244_
+ sky130_fd_sc_hd__o22ai_1
X_13311_ _03766_ _04244_ VSS VSS VDD VDD _04245_ sky130_fd_sc_hd__nand2_1
X_13312_ _11835_ net709 _03618_ VSS VSS VDD VDD _04246_ sky130_fd_sc_hd__a21oi_1
X_13313_ _03944_ net709 _04246_ VSS VSS VDD VDD _04247_ sky130_fd_sc_hd__o21ai_0
X_13314_ _11840_ _03617_ _03767_ _04247_ VSS VSS VDD VDD _04248_
+ sky130_fd_sc_hd__o211ai_1
X_13315_ _04245_ _04248_ _03610_ VSS VSS VDD VDD _04249_ sky130_fd_sc_hd__a21oi_1
X_13316_ net474 _04242_ _04249_ VSS VSS VDD VDD _04250_ sky130_fd_sc_hd__nor3_1
X_13317_ _11830_ _03579_ _03617_ VSS VSS VDD VDD _04251_ sky130_fd_sc_hd__o21ai_0
X_13318_ _03579_ _04028_ _04251_ VSS VSS VDD VDD _04252_ sky130_fd_sc_hd__o21ai_0
X_13319_ _04004_ _04098_ VSS VSS VDD VDD _04253_ sky130_fd_sc_hd__nand2_1
X_13320_ net709 _04253_ _04099_ _03610_ VSS VSS VDD VDD _04254_
+ sky130_fd_sc_hd__a211oi_1
X_13321_ _03610_ _04252_ _04254_ VSS VSS VDD VDD _04255_ sky130_fd_sc_hd__a21oi_1
X_13322_ _03611_ _03618_ VSS VSS VDD VDD _04256_ sky130_fd_sc_hd__nor2_1
X_13323_ net705 _03942_ _04256_ net489 _03579_ VSS VSS VDD
+ VDD _04257_ sky130_fd_sc_hd__a221oi_1
X_13324_ _03610_ _03618_ VSS VSS VDD VDD _04258_ sky130_fd_sc_hd__nor2_1
X_13325_ _03610_ _04129_ _04258_ _11842_ net709 VSS VSS VDD
+ VDD _04259_ sky130_fd_sc_hd__a221oi_1
X_13326_ _03579_ _03610_ VSS VSS VDD VDD _04260_ sky130_fd_sc_hd__nand2_1
X_13327_ _03610_ _03617_ _04260_ _03585_ VSS VSS VDD VDD _04261_
+ sky130_fd_sc_hd__o22ai_1
X_13328_ _03593_ _04261_ VSS VSS VDD VDD _04262_ sky130_fd_sc_hd__nand2_1
X_13329_ _04257_ _04259_ _03767_ _04262_ VSS VSS VDD VDD _04263_
+ sky130_fd_sc_hd__o211ai_1
X_13330_ _03767_ _04255_ _04263_ net474 VSS VSS VDD VDD _04264_
+ sky130_fd_sc_hd__o211ai_1
X_13331_ _11844_ _03579_ VSS VSS VDD VDD _04265_ sky130_fd_sc_hd__nor2_1
X_13332_ _11828_ _03579_ _04265_ VSS VSS VDD VDD _04266_ sky130_fd_sc_hd__a21oi_1
X_13333_ _03945_ _04079_ _03579_ VSS VSS VDD VDD _04267_ sky130_fd_sc_hd__a21oi_1
X_13334_ _03610_ _03618_ _04266_ _04267_ _03982_ VSS VSS VDD
+ VDD _04268_ sky130_fd_sc_hd__o32ai_1
X_13335_ _11858_ _03579_ VSS VSS VDD VDD _04269_ sky130_fd_sc_hd__nand2_1
X_13336_ _11842_ _03952_ _04269_ _03610_ _04118_ VSS VSS VDD
+ VDD _04270_ sky130_fd_sc_hd__o2111ai_1
X_13337_ net709 _04046_ _03984_ _03611_ VSS VSS VDD VDD _04271_
+ sky130_fd_sc_hd__o211ai_1
X_13338_ _03767_ _04270_ _04271_ VSS VSS VDD VDD _04272_ sky130_fd_sc_hd__nand3_1
X_13339_ _03767_ _04268_ _04272_ _03602_ VSS VSS VDD VDD _04273_
+ sky130_fd_sc_hd__o211ai_1
X_13340_ _03759_ _04264_ _04273_ VSS VSS VDD VDD _04274_ sky130_fd_sc_hd__nand3_1
X_13341_ _03759_ _04238_ _04250_ _04274_ VSS VSS VDD VDD _00004_
+ sky130_fd_sc_hd__o31ai_1
X_13342_ _03579_ _03977_ _03996_ _03955_ _03944_ VSS VSS VDD
+ VDD _04275_ sky130_fd_sc_hd__a32oi_1
X_13343_ _04019_ _04024_ _03578_ VSS VSS VDD VDD _04276_ sky130_fd_sc_hd__a21oi_1
X_13344_ _11830_ _04142_ _04276_ _03759_ VSS VSS VDD VDD _04277_
+ sky130_fd_sc_hd__a211o_1
X_13345_ _03758_ _04275_ _04277_ VSS VSS VDD VDD _04278_ sky130_fd_sc_hd__o21ai_0
X_13346_ _11835_ _03617_ VSS VSS VDD VDD _04279_ sky130_fd_sc_hd__nor2_1
X_13347_ _03579_ _04279_ VSS VSS VDD VDD _04280_ sky130_fd_sc_hd__nor2_1
X_13348_ _03967_ _04161_ _03579_ VSS VSS VDD VDD _04281_ sky130_fd_sc_hd__a21oi_1
X_13349_ _11829_ _03957_ _04281_ _03759_ VSS VSS VDD VDD _04282_
+ sky130_fd_sc_hd__a211o_1
X_13350_ _03758_ _04114_ _04280_ _04282_ _03611_ VSS VSS VDD
+ VDD _04283_ sky130_fd_sc_hd__o311ai_0
X_13351_ _03611_ _04278_ _04283_ VSS VSS VDD VDD _04284_ sky130_fd_sc_hd__o21ai_0
X_13352_ _04060_ _04026_ VSS VSS VDD VDD _04285_ sky130_fd_sc_hd__nand2_1
X_13353_ _03579_ _04024_ _04122_ VSS VSS VDD VDD _04286_ sky130_fd_sc_hd__nand3_1
X_13354_ _03579_ _04285_ _04286_ VSS VSS VDD VDD _04287_ sky130_fd_sc_hd__o21ai_0
X_13355_ _11838_ _03579_ VSS VSS VDD VDD _04288_ sky130_fd_sc_hd__nand2_1
X_13356_ _03579_ _03980_ _04288_ VSS VSS VDD VDD _04289_ sky130_fd_sc_hd__o21ai_0
X_13357_ _03610_ _04289_ VSS VSS VDD VDD _04290_ sky130_fd_sc_hd__nand2_1
X_13358_ _03610_ _04287_ _04290_ VSS VSS VDD VDD _04291_ sky130_fd_sc_hd__o21ai_0
X_13359_ net709 _04028_ _04061_ _03982_ VSS VSS VDD VDD _04292_
+ sky130_fd_sc_hd__a31oi_1
X_13360_ _11830_ _03617_ _04115_ VSS VSS VDD VDD _04293_ sky130_fd_sc_hd__a21oi_1
X_13361_ _11838_ _04090_ _04293_ _03579_ VSS VSS VDD VDD _04294_
+ sky130_fd_sc_hd__o22ai_1
X_13362_ _03610_ _04294_ _03759_ VSS VSS VDD VDD _04295_ sky130_fd_sc_hd__o21ai_0
X_13363_ _03759_ _04291_ _04292_ _04295_ _03766_ VSS VSS VDD
+ VDD _04296_ sky130_fd_sc_hd__o221ai_1
X_13364_ _03766_ _04284_ _04296_ VSS VSS VDD VDD _04297_ sky130_fd_sc_hd__o21ai_1
X_13365_ _03593_ _03611_ VSS VSS VDD VDD _04298_ sky130_fd_sc_hd__nor2_1
X_13366_ _03611_ _04122_ _03980_ _04298_ VSS VSS VDD VDD _04299_
+ sky130_fd_sc_hd__a31oi_1
X_13367_ _03586_ _03610_ net489 VSS VSS VDD VDD _04300_ sky130_fd_sc_hd__o21ai_0
X_13368_ net489 _04256_ _04300_ net709 VSS VSS VDD VDD _04301_
+ sky130_fd_sc_hd__o211ai_1
X_13369_ _04142_ _04298_ _03586_ VSS VSS VDD VDD _04302_ sky130_fd_sc_hd__o21ai_0
X_13370_ net709 _04299_ _04301_ _03758_ _04302_ VSS VSS VDD
+ VDD _04303_ sky130_fd_sc_hd__o2111ai_1
X_13371_ _03579_ _04045_ _04046_ VSS VSS VDD VDD _04304_ sky130_fd_sc_hd__nor3_1
X_13372_ _03579_ _04118_ _04061_ _04304_ _03610_ VSS VSS VDD
+ VDD _04305_ sky130_fd_sc_hd__a311oi_1
X_13373_ net709 _03942_ _03984_ VSS VSS VDD VDD _04306_ sky130_fd_sc_hd__nand3_1
X_13374_ _03579_ _04147_ VSS VSS VDD VDD _04307_ sky130_fd_sc_hd__nand2_1
X_13375_ _04306_ _04307_ _03611_ VSS VSS VDD VDD _04308_ sky130_fd_sc_hd__a21oi_1
X_13376_ _04305_ _04308_ _03759_ VSS VSS VDD VDD _04309_ sky130_fd_sc_hd__o21ai_0
X_13377_ _04303_ _04309_ _03766_ VSS VSS VDD VDD _04310_ sky130_fd_sc_hd__a21oi_1
X_13378_ _03586_ _03593_ VSS VSS VDD VDD _04311_ sky130_fd_sc_hd__nand2_1
X_13379_ net704 _03758_ VSS VSS VDD VDD _04312_ sky130_fd_sc_hd__nor2_1
X_13380_ _11828_ _03759_ VSS VSS VDD VDD _04313_ sky130_fd_sc_hd__nor2_1
X_13381_ _03617_ _04312_ _04313_ _03759_ _03966_ VSS VSS VDD
+ VDD _04314_ sky130_fd_sc_hd__o32ai_1
X_13382_ _03586_ _03759_ net709 VSS VSS VDD VDD _04315_ sky130_fd_sc_hd__a21oi_1
X_13383_ _03759_ _04118_ _04315_ VSS VSS VDD VDD _04316_ sky130_fd_sc_hd__o21ai_0
X_13384_ _03579_ _04314_ _04316_ VSS VSS VDD VDD _04317_ sky130_fd_sc_hd__o21ai_0
X_13385_ _03758_ _04311_ _04317_ VSS VSS VDD VDD _04318_ sky130_fd_sc_hd__o21ai_0
X_13386_ _03579_ _04243_ VSS VSS VDD VDD _04319_ sky130_fd_sc_hd__nor2_1
X_13387_ _03579_ _03966_ _04024_ _04319_ VSS VSS VDD VDD _04320_
+ sky130_fd_sc_hd__a31o_1
X_13388_ _04025_ _03957_ _04065_ net709 _03759_ VSS VSS VDD
+ VDD _04321_ sky130_fd_sc_hd__a221oi_1
X_13389_ _03759_ _04320_ _04321_ _03610_ VSS VSS VDD VDD _04322_
+ sky130_fd_sc_hd__a211oi_1
X_13390_ _03610_ _04318_ _04322_ VSS VSS VDD VDD _04323_ sky130_fd_sc_hd__a21oi_1
X_13391_ _03767_ _04323_ _03602_ VSS VSS VDD VDD _04324_ sky130_fd_sc_hd__o21ai_0
X_13392_ _03602_ _04297_ _04310_ _04324_ VSS VSS VDD VDD _00005_
+ sky130_fd_sc_hd__o22ai_1
X_13393_ _11847_ _03579_ _04029_ VSS VSS VDD VDD _04325_ sky130_fd_sc_hd__a21oi_1
X_13394_ _03977_ _03996_ _03578_ VSS VSS VDD VDD _04326_ sky130_fd_sc_hd__a21oi_1
X_13395_ _11829_ _03955_ _04326_ _03611_ VSS VSS VDD VDD _04327_
+ sky130_fd_sc_hd__a211o_1
X_13396_ _03610_ _04325_ _04327_ VSS VSS VDD VDD _04328_ sky130_fd_sc_hd__o21ai_0
X_13397_ _11830_ _04082_ _04311_ _03578_ _04031_ VSS VSS VDD
+ VDD _04329_ sky130_fd_sc_hd__o221ai_1
X_13398_ _03610_ _04329_ VSS VSS VDD VDD _04330_ sky130_fd_sc_hd__nor2_1
X_13399_ _04118_ _04032_ _03578_ VSS VSS VDD VDD _04331_ sky130_fd_sc_hd__a21oi_1
X_13400_ _03611_ _04129_ _04137_ _04331_ VSS VSS VDD VDD _04332_
+ sky130_fd_sc_hd__nor4_1
X_13401_ net474 _04330_ _04332_ VSS VSS VDD VDD _04333_ sky130_fd_sc_hd__nor3_1
X_13402_ net474 _04328_ _04333_ VSS VSS VDD VDD _04334_ sky130_fd_sc_hd__a21oi_1
X_13403_ _03996_ _04161_ _03578_ VSS VSS VDD VDD _04335_ sky130_fd_sc_hd__a21oi_1
X_13404_ net489 _03957_ _04071_ net709 _03610_ VSS VSS VDD
+ VDD _04336_ sky130_fd_sc_hd__o221ai_1
X_13405_ _03610_ _04175_ _04335_ _04336_ _03602_ VSS VSS VDD
+ VDD _04337_ sky130_fd_sc_hd__o311ai_1
X_13406_ _04028_ _03945_ _03579_ VSS VSS VDD VDD _04338_ sky130_fd_sc_hd__a21oi_1
X_13407_ _11844_ _03617_ _04087_ _03579_ VSS VSS VDD VDD _04339_
+ sky130_fd_sc_hd__o211ai_1
X_13408_ _03579_ _04046_ _03972_ _04339_ _03610_ VSS VSS VDD
+ VDD _04340_ sky130_fd_sc_hd__o311ai_0
X_13409_ _03610_ _04338_ _04326_ _04340_ net474 VSS VSS VDD
+ VDD _04341_ sky130_fd_sc_hd__o311ai_0
X_13410_ _04337_ _04341_ _03766_ VSS VSS VDD VDD _04342_ sky130_fd_sc_hd__a21oi_1
X_13411_ _03766_ _04334_ _04342_ VSS VSS VDD VDD _04343_ sky130_fd_sc_hd__a21oi_1
X_13412_ _11848_ net709 VSS VSS VDD VDD _04344_ sky130_fd_sc_hd__nor2_1
X_13413_ _03578_ net707 _03617_ _03610_ VSS VSS VDD VDD _04345_
+ sky130_fd_sc_hd__a31oi_1
X_13414_ net709 _04285_ _04345_ VSS VSS VDD VDD _04346_ sky130_fd_sc_hd__o21ai_0
X_13415_ _03611_ _04319_ _04344_ _04346_ _03602_ VSS VSS VDD
+ VDD _04347_ sky130_fd_sc_hd__o311ai_0
X_13416_ _11838_ _04142_ _04243_ _03579_ _03610_ VSS VSS VDD
+ VDD _04348_ sky130_fd_sc_hd__a221oi_1
X_13417_ _04150_ _04348_ net474 VSS VSS VDD VDD _04349_ sky130_fd_sc_hd__o21ai_0
X_13418_ net709 _04118_ _04130_ VSS VSS VDD VDD _04350_ sky130_fd_sc_hd__nand3_1
X_13419_ net709 _04006_ _04350_ _03610_ VSS VSS VDD VDD _04351_
+ sky130_fd_sc_hd__o211ai_1
X_13420_ _03579_ _04076_ _04098_ _03953_ _03610_ VSS VSS VDD
+ VDD _04352_ sky130_fd_sc_hd__a311o_1
X_13421_ _03579_ _03966_ _03967_ VSS VSS VDD VDD _04353_ sky130_fd_sc_hd__nand3_1
X_13422_ _11844_ _03618_ _04060_ _03578_ VSS VSS VDD VDD _04354_
+ sky130_fd_sc_hd__o211ai_1
X_13423_ _11852_ _03578_ VSS VSS VDD VDD _04355_ sky130_fd_sc_hd__nor2_1
X_13424_ _03578_ _03966_ _04024_ _04355_ _03610_ VSS VSS VDD
+ VDD _04356_ sky130_fd_sc_hd__a311oi_2
X_13425_ _03610_ _04353_ _04354_ _04356_ net474 VSS VSS VDD
+ VDD _04357_ sky130_fd_sc_hd__a311oi_1
X_13426_ net474 _04351_ _04352_ _04357_ _03766_ VSS VSS VDD
+ VDD _04358_ sky130_fd_sc_hd__a311oi_2
X_13427_ _03766_ _04347_ _04349_ _04358_ VSS VSS VDD VDD _04359_
+ sky130_fd_sc_hd__a31oi_1
X_13428_ _03759_ _04359_ VSS VSS VDD VDD _04360_ sky130_fd_sc_hd__nor2_1
X_13429_ _03759_ _04343_ _04360_ VSS VSS VDD VDD _00006_ sky130_fd_sc_hd__a21oi_2
X_13430_ _03602_ _04243_ VSS VSS VDD VDD _04361_ sky130_fd_sc_hd__nand2_1
X_13431_ _11849_ _03602_ _04041_ _04361_ _03579_ VSS VSS VDD
+ VDD _04362_ sky130_fd_sc_hd__o311ai_0
X_13432_ net474 _04046_ _03972_ VSS VSS VDD VDD _04363_ sky130_fd_sc_hd__a21oi_1
X_13433_ net709 _04363_ VSS VSS VDD VDD _04364_ sky130_fd_sc_hd__nand2_1
X_13434_ _04362_ _04364_ _03611_ VSS VSS VDD VDD _04365_ sky130_fd_sc_hd__a21oi_1
X_13435_ net709 _03969_ VSS VSS VDD VDD _04366_ sky130_fd_sc_hd__nand2_1
X_13436_ _11830_ _04052_ _03958_ _11829_ _04366_ VSS VSS VDD
+ VDD _04367_ sky130_fd_sc_hd__o221ai_1
X_13437_ _03579_ _04004_ _04087_ VSS VSS VDD VDD _04368_ sky130_fd_sc_hd__nand3_1
X_13438_ _03579_ _03969_ _04045_ _04368_ _03602_ VSS VSS VDD
+ VDD _04369_ sky130_fd_sc_hd__o311a_1
X_13439_ net474 _04367_ _04369_ _03610_ VSS VSS VDD VDD _04370_
+ sky130_fd_sc_hd__a211oi_1
X_13440_ _04365_ _04370_ _03766_ VSS VSS VDD VDD _04371_ sky130_fd_sc_hd__o21ai_2
X_13441_ _11835_ net709 _04032_ _04164_ _03610_ VSS VSS VDD
+ VDD _04372_ sky130_fd_sc_hd__a221oi_1
X_13442_ _03578_ _03593_ VSS VSS VDD VDD _04373_ sky130_fd_sc_hd__nor2_1
X_13443_ _04265_ _04373_ _03617_ VSS VSS VDD VDD _04374_ sky130_fd_sc_hd__o21ai_0
X_13444_ _04004_ _04374_ _03611_ VSS VSS VDD VDD _04375_ sky130_fd_sc_hd__a21oi_1
X_13445_ _04372_ _04375_ net474 VSS VSS VDD VDD _04376_ sky130_fd_sc_hd__o21ai_0
X_13446_ _03579_ _04017_ _04039_ VSS VSS VDD VDD _04377_ sky130_fd_sc_hd__nor3_1
X_13447_ _04004_ _04087_ _03579_ VSS VSS VDD VDD _04378_ sky130_fd_sc_hd__a21oi_1
X_13448_ _03579_ _04219_ _04378_ VSS VSS VDD VDD _04379_ sky130_fd_sc_hd__a21oi_1
X_13449_ _03610_ _04379_ VSS VSS VDD VDD _04380_ sky130_fd_sc_hd__nand2_1
X_13450_ _03610_ _04205_ _04377_ _04380_ _03602_ VSS VSS VDD
+ VDD _04381_ sky130_fd_sc_hd__o311ai_2
X_13451_ _03767_ _04376_ _04381_ _03758_ VSS VSS VDD VDD _04382_
+ sky130_fd_sc_hd__a31oi_2
X_13452_ _03585_ _03610_ _03617_ VSS VSS VDD VDD _04383_ sky130_fd_sc_hd__nor3_1
X_13453_ _04091_ _04383_ _03579_ VSS VSS VDD VDD _04384_ sky130_fd_sc_hd__o21ai_0
X_13454_ _04017_ _04129_ net709 _03610_ VSS VSS VDD VDD _04385_
+ sky130_fd_sc_hd__o211ai_1
X_13455_ net709 _03611_ VSS VSS VDD VDD _04386_ sky130_fd_sc_hd__nand2_1
X_13456_ net489 _04260_ _04386_ VSS VSS VDD VDD _04387_ sky130_fd_sc_hd__o21ai_0
X_13457_ _03585_ _04387_ net474 VSS VSS VDD VDD _04388_ sky130_fd_sc_hd__a21oi_1
X_13458_ _03952_ _04260_ VSS VSS VDD VDD _04389_ sky130_fd_sc_hd__nand2_1
X_13459_ _11829_ net709 VSS VSS VDD VDD _04390_ sky130_fd_sc_hd__nand2_1
X_13460_ _11833_ _03579_ _03611_ VSS VSS VDD VDD _04391_ sky130_fd_sc_hd__nand3_1
X_13461_ _04390_ _04391_ _03617_ VSS VSS VDD VDD _04392_ sky130_fd_sc_hd__a21oi_1
X_13462_ _11828_ _04389_ _04392_ _04256_ VSS VSS VDD VDD _04393_
+ sky130_fd_sc_hd__a211o_1
X_13463_ _04384_ _04385_ _04388_ _04393_ net474 VSS VSS VDD
+ VDD _04394_ sky130_fd_sc_hd__a32oi_1
X_13464_ _11828_ _03579_ VSS VSS VDD VDD _04395_ sky130_fd_sc_hd__nand2_1
X_13465_ net709 _04161_ VSS VSS VDD VDD _04396_ sky130_fd_sc_hd__nand2_1
X_13466_ _04076_ _04098_ _03579_ VSS VSS VDD VDD _04397_ sky130_fd_sc_hd__a21oi_1
X_13467_ _03610_ _04099_ _04397_ VSS VSS VDD VDD _04398_ sky130_fd_sc_hd__nor3_1
X_13468_ _03610_ _04395_ _04396_ _04398_ VSS VSS VDD VDD _04399_
+ sky130_fd_sc_hd__a31oi_1
X_13469_ _11858_ net709 VSS VSS VDD VDD _04400_ sky130_fd_sc_hd__nor2_1
X_13470_ net709 _03945_ _03996_ _04400_ _03611_ VSS VSS VDD
+ VDD _04401_ sky130_fd_sc_hd__a311oi_1
X_13471_ net705 _03617_ _11854_ VSS VSS VDD VDD _04402_ sky130_fd_sc_hd__a21oi_1
X_13472_ _03579_ _04402_ VSS VSS VDD VDD _04403_ sky130_fd_sc_hd__nor2_1
X_13473_ _04155_ _04403_ _03611_ VSS VSS VDD VDD _04404_ sky130_fd_sc_hd__o21a_1
X_13474_ _04401_ _04404_ net474 VSS VSS VDD VDD _04405_ sky130_fd_sc_hd__o21ai_0
X_13475_ net474 _04399_ _04405_ _03767_ VSS VSS VDD VDD _04406_
+ sky130_fd_sc_hd__o211ai_1
X_13476_ _03767_ _04394_ _04406_ VSS VSS VDD VDD _04407_ sky130_fd_sc_hd__o21ai_1
X_13477_ _04371_ _04382_ _04407_ _03758_ VSS VSS VDD VDD _00007_
+ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_51_1227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13483_ _03696_ _03715_ VSS VSS VDD VDD _04411_ sky130_fd_sc_hd__nor2_2
X_13484_ _03696_ _03715_ VSS VSS VDD VDD _04412_ sky130_fd_sc_hd__nand2_4
X_13485_ _04411_ _04412_ VSS VSS VDD VDD _04413_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_51_1222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13487_ _03704_ _03714_ VSS VSS VDD VDD _04415_ sky130_fd_sc_hd__xnor2_1
X_13488_ net484 _04415_ VSS VSS VDD VDD _04416_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_1221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13491_ net484 _04413_ _04416_ _03735_ VSS VSS VDD VDD _04419_
+ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_50_1219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13495_ _03702_ _03715_ VSS VSS VDD VDD _04423_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_50_1216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13499_ _11863_ _03714_ VSS VSS VDD VDD _04427_ sky130_fd_sc_hd__nor2_2
X_13500_ _03734_ _04427_ _04411_ VSS VSS VDD VDD _04428_ sky130_fd_sc_hd__a21oi_1
X_13501_ _03704_ _04428_ VSS VSS VDD VDD _04429_ sky130_fd_sc_hd__nor2_1
X_13502_ _11863_ _03734_ _04423_ _04429_ VSS VSS VDD VDD _04430_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_50_1213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13504_ _03704_ _03715_ VSS VSS VDD VDD _04432_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_50_1212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13506_ _03704_ _03715_ VSS VSS VDD VDD _04434_ sky130_fd_sc_hd__nand2_4
X_13507_ _11863_ _04434_ VSS VSS VDD VDD _04435_ sky130_fd_sc_hd__nor2_2
X_13508_ _11876_ _04415_ _04432_ _11872_ _04435_ VSS VSS VDD
+ VDD _04436_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_50_1211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13510_ _11876_ _03714_ VSS VSS VDD VDD _04438_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_50_1210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13512_ _11862_ _03715_ VSS VSS VDD VDD _04440_ sky130_fd_sc_hd__nor2_4
X_13513_ _03704_ _04438_ _04440_ VSS VSS VDD VDD _04441_ sky130_fd_sc_hd__nor3_1
X_13514_ _11872_ _03714_ VSS VSS VDD VDD _04442_ sky130_fd_sc_hd__nor2_2
X_13515_ _11863_ _03714_ VSS VSS VDD VDD _04443_ sky130_fd_sc_hd__nand2_4
X_13516_ _03702_ _04442_ _04443_ VSS VSS VDD VDD _04444_ sky130_fd_sc_hd__nor3b_1
X_13517_ _03734_ _04441_ _04444_ VSS VSS VDD VDD _04445_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_50_1209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13519_ _03734_ _04436_ _04445_ _03725_ VSS VSS VDD VDD _04447_
+ sky130_fd_sc_hd__a211oi_1
X_13520_ _03725_ _04419_ _04430_ _04447_ VSS VSS VDD VDD _04448_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_50_1208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13522_ _03702_ _03714_ VSS VSS VDD VDD _04450_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_50_1207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13524_ _11867_ _03715_ VSS VSS VDD VDD _04452_ sky130_fd_sc_hd__nor2_2
X_13525_ _11878_ _03715_ _04452_ VSS VSS VDD VDD _04453_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_50_1206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13527_ _11872_ _04450_ _04453_ _03702_ _03735_ VSS VSS VDD
+ VDD _04455_ sky130_fd_sc_hd__o221ai_1
X_13528_ _11888_ _03715_ _04432_ _11863_ _03735_ VSS VSS VDD
+ VDD _04456_ sky130_fd_sc_hd__a221o_1
X_13529_ _03725_ _04455_ _04456_ VSS VSS VDD VDD _04457_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_50_1205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13535_ _11867_ _03715_ VSS VSS VDD VDD _04463_ sky130_fd_sc_hd__nand2_1
X_13536_ _11878_ _03715_ _04463_ VSS VSS VDD VDD _04464_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_50_1200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13538_ _03704_ _03714_ VSS VSS VDD VDD _04466_ sky130_fd_sc_hd__nor2_4
X_13539_ _11874_ _04466_ VSS VSS VDD VDD _04467_ sky130_fd_sc_hd__nand2_1
X_13540_ _03702_ _04464_ _04467_ VSS VSS VDD VDD _04468_ sky130_fd_sc_hd__o21ai_0
X_13541_ net484 _03714_ VSS VSS VDD VDD _04469_ sky130_fd_sc_hd__nand2_2
X_13542_ _03691_ _03715_ VSS VSS VDD VDD _04470_ sky130_fd_sc_hd__nand2_2
X_13543_ _04469_ _04470_ _03704_ VSS VSS VDD VDD _04471_ sky130_fd_sc_hd__a21oi_1
X_13544_ _03702_ _04438_ _04452_ VSS VSS VDD VDD _04472_ sky130_fd_sc_hd__nor3_4
X_13545_ _04471_ _04472_ _03734_ VSS VSS VDD VDD _04473_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_50_1199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13548_ _03734_ _04468_ _04473_ net473 VSS VSS VDD VDD _04476_
+ sky130_fd_sc_hd__o211ai_1
X_13549_ _03751_ _04457_ _04476_ VSS VSS VDD VDD _04477_ sky130_fd_sc_hd__nand3_1
X_13550_ _03751_ _04448_ _04477_ VSS VSS VDD VDD _04478_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_49_1197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13552_ _11864_ _03715_ _04411_ _03702_ VSS VSS VDD VDD _04480_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_49_1196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13554_ _03691_ net616 VSS VSS VDD VDD _04482_ sky130_fd_sc_hd__nor2_4
X_13555_ _03704_ _04482_ _04452_ VSS VSS VDD VDD _04483_ sky130_fd_sc_hd__nor3_1
X_13556_ _11863_ _03715_ VSS VSS VDD VDD _04484_ sky130_fd_sc_hd__nand2_1
X_13557_ _11867_ net616 VSS VSS VDD VDD _04485_ sky130_fd_sc_hd__nand2_2
X_13558_ _11864_ _03715_ VSS VSS VDD VDD _04486_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_49_1195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13560_ _04485_ _04486_ _03704_ VSS VSS VDD VDD _04488_ sky130_fd_sc_hd__a21oi_1
X_13561_ _03704_ _04469_ _04484_ _04488_ _03734_ VSS VSS VDD
+ VDD _04489_ sky130_fd_sc_hd__a311o_1
X_13562_ _03735_ _04480_ _04483_ _04489_ _03725_ VSS VSS VDD
+ VDD _04490_ sky130_fd_sc_hd__o311ai_1
X_13563_ _03696_ _03702_ VSS VSS VDD VDD _04491_ sky130_fd_sc_hd__nand2_1
X_13564_ _11878_ _03704_ VSS VSS VDD VDD _04492_ sky130_fd_sc_hd__nand2_1
X_13565_ _04491_ _04492_ _03715_ VSS VSS VDD VDD _04493_ sky130_fd_sc_hd__a21oi_1
X_13566_ _03725_ _04493_ VSS VSS VDD VDD _04494_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_49_1194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13568_ _11862_ _03704_ VSS VSS VDD VDD _04496_ sky130_fd_sc_hd__nand2_1
X_13569_ net484 _03704_ _03715_ _04496_ VSS VSS VDD VDD _04497_
+ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_49_1193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13571_ _11867_ VSS VSS VDD VDD _04499_ sky130_fd_sc_hd__inv_1
X_13572_ _04499_ _03714_ VSS VSS VDD VDD _04500_ sky130_fd_sc_hd__nor2_4
X_13573_ _03690_ _03715_ VSS VSS VDD VDD _04501_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_49_1192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13575_ _04500_ _04501_ _03702_ VSS VSS VDD VDD _04503_ sky130_fd_sc_hd__o21ai_0
X_13576_ _11869_ _04434_ _04503_ VSS VSS VDD VDD _04504_ sky130_fd_sc_hd__o21ai_0
X_13577_ _03725_ _03734_ VSS VSS VDD VDD _04505_ sky130_fd_sc_hd__nor2_2
X_13578_ _03734_ _04494_ _04497_ _04504_ _04505_ VSS VSS VDD
+ VDD _04506_ sky130_fd_sc_hd__a32oi_2
X_13579_ _03750_ _04490_ _04506_ VSS VSS VDD VDD _04507_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_49_1191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13582_ net483 _03715_ VSS VSS VDD VDD _04510_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_49_1189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13584_ _04482_ _04510_ _03704_ VSS VSS VDD VDD _04512_ sky130_fd_sc_hd__o21ai_1
X_13585_ _11863_ _03715_ VSS VSS VDD VDD _04513_ sky130_fd_sc_hd__nor2_1
X_13586_ _04442_ _04513_ _03702_ VSS VSS VDD VDD _04514_ sky130_fd_sc_hd__o21ai_0
X_13587_ _11876_ _04432_ VSS VSS VDD VDD _04515_ sky130_fd_sc_hd__nand2_1
X_13588_ _11878_ _03715_ VSS VSS VDD VDD _04516_ sky130_fd_sc_hd__nor2_1
X_13589_ _11869_ _03714_ VSS VSS VDD VDD _04517_ sky130_fd_sc_hd__nor2_4
X_13590_ _04516_ _04517_ _03704_ VSS VSS VDD VDD _04518_ sky130_fd_sc_hd__o21ai_0
X_13591_ _04515_ _04518_ net473 VSS VSS VDD VDD _04519_ sky130_fd_sc_hd__a21oi_1
X_13592_ net473 _04512_ _04514_ _04519_ VSS VSS VDD VDD _04520_
+ sky130_fd_sc_hd__a31oi_1
X_13593_ _11874_ _03704_ _03715_ VSS VSS VDD VDD _04521_ sky130_fd_sc_hd__a21oi_1
X_13594_ net473 _04435_ _04521_ VSS VSS VDD VDD _04522_ sky130_fd_sc_hd__or3_1
X_13595_ _11869_ _04432_ VSS VSS VDD VDD _04523_ sky130_fd_sc_hd__nand2_1
X_13596_ _03725_ _04497_ _04522_ _04523_ _03734_ VSS VSS VDD
+ VDD _04524_ sky130_fd_sc_hd__o2111ai_1
X_13597_ _03734_ _04520_ _04524_ _03751_ VSS VSS VDD VDD _04525_
+ sky130_fd_sc_hd__o211ai_1
X_13598_ _03744_ _04507_ _04525_ VSS VSS VDD VDD _04526_ sky130_fd_sc_hd__nand3_1
X_13599_ _03743_ _04478_ _04526_ VSS VSS VDD VDD _00008_ sky130_fd_sc_hd__a21boi_4
XTAP_TAPCELL_ROW_49_1188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13602_ _11872_ _03702_ VSS VSS VDD VDD _04529_ sky130_fd_sc_hd__nand2_1
X_13603_ _11890_ net616 _03735_ VSS VSS VDD VDD _04530_ sky130_fd_sc_hd__nor3_1
X_13604_ net616 _04496_ _04529_ _04530_ VSS VSS VDD VDD _04531_
+ sky130_fd_sc_hd__a31oi_1
X_13605_ _03725_ _04531_ VSS VSS VDD VDD _04532_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_49_1186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13607_ _11867_ net616 VSS VSS VDD VDD _04534_ sky130_fd_sc_hd__nor2_1
X_13608_ _11876_ VSS VSS VDD VDD _04535_ sky130_fd_sc_hd__inv_1
X_13609_ _04535_ _03714_ VSS VSS VDD VDD _04536_ sky130_fd_sc_hd__nand2_4
X_13610_ _04534_ _04536_ _03702_ VSS VSS VDD VDD _04537_ sky130_fd_sc_hd__nand3b_1
X_13611_ _03691_ _03714_ VSS VSS VDD VDD _04538_ sky130_fd_sc_hd__nand2_2
X_13612_ _11862_ _03715_ VSS VSS VDD VDD _04539_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_49_1185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13614_ _04538_ _04539_ _03702_ VSS VSS VDD VDD _04541_ sky130_fd_sc_hd__a21o_1
X_13615_ _04537_ _04541_ _03734_ VSS VSS VDD VDD _04542_ sky130_fd_sc_hd__a21oi_1
X_13616_ _03691_ _03715_ VSS VSS VDD VDD _04543_ sky130_fd_sc_hd__nor2_2
X_13617_ _03702_ _04543_ _04517_ VSS VSS VDD VDD _04544_ sky130_fd_sc_hd__nor3_1
X_13618_ _03704_ _04413_ VSS VSS VDD VDD _04545_ sky130_fd_sc_hd__nor2_2
X_13619_ _03735_ _04544_ _04545_ VSS VSS VDD VDD _04546_ sky130_fd_sc_hd__nor3_1
X_13620_ net473 _04542_ _04546_ VSS VSS VDD VDD _04547_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_49_1184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13622_ _04532_ _04547_ _03750_ VSS VSS VDD VDD _04549_ sky130_fd_sc_hd__o21ai_1
X_13623_ _04411_ _04534_ _03702_ VSS VSS VDD VDD _04550_ sky130_fd_sc_hd__o21ai_0
X_13624_ net484 _04510_ VSS VSS VDD VDD _04551_ sky130_fd_sc_hd__nand2_1
X_13625_ _11869_ _03714_ VSS VSS VDD VDD _04552_ sky130_fd_sc_hd__nand2_4
X_13626_ _04484_ _04552_ _03704_ VSS VSS VDD VDD _04553_ sky130_fd_sc_hd__a21oi_1
X_13627_ _03704_ _04485_ _04486_ _04553_ _03735_ VSS VSS VDD
+ VDD _04554_ sky130_fd_sc_hd__a311oi_1
X_13628_ _03735_ _04550_ _04551_ _04554_ VSS VSS VDD VDD _04555_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_49_1183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13630_ _11881_ _03715_ VSS VSS VDD VDD _04557_ sky130_fd_sc_hd__nand2_1
X_13631_ _11869_ _03702_ VSS VSS VDD VDD _04558_ sky130_fd_sc_hd__nand2_1
X_13632_ _03696_ _03704_ VSS VSS VDD VDD _04559_ sky130_fd_sc_hd__nand2_1
X_13633_ net616 _04558_ _04559_ VSS VSS VDD VDD _04560_ sky130_fd_sc_hd__nand3_1
X_13634_ _03704_ _04484_ _04552_ _04471_ _03734_ VSS VSS VDD
+ VDD _04561_ sky130_fd_sc_hd__a311oi_1
X_13635_ _03734_ _04557_ _04560_ _04561_ net473 VSS VSS VDD
+ VDD _04562_ sky130_fd_sc_hd__a311o_1
X_13636_ _03725_ _04555_ _04562_ _03751_ VSS VSS VDD VDD _04563_
+ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_49_1182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13638_ _03702_ _03715_ VSS VSS VDD VDD _04565_ sky130_fd_sc_hd__nand2_2
X_13639_ _11869_ net616 _04427_ VSS VSS VDD VDD _04566_ sky130_fd_sc_hd__a21oi_1
X_13640_ _11862_ _04565_ _04566_ _03702_ VSS VSS VDD VDD _04567_
+ sky130_fd_sc_hd__o22ai_1
X_13641_ _03702_ _03714_ VSS VSS VDD VDD _04568_ sky130_fd_sc_hd__xnor2_1
X_13642_ _03690_ _04568_ VSS VSS VDD VDD _04569_ sky130_fd_sc_hd__nor2_2
X_13643_ _03691_ _04412_ VSS VSS VDD VDD _04570_ sky130_fd_sc_hd__nor2_1
X_13644_ _11863_ _04432_ _04569_ _04570_ _03735_ VSS VSS VDD
+ VDD _04571_ sky130_fd_sc_hd__a2111oi_1
X_13645_ _03735_ _04567_ _04571_ VSS VSS VDD VDD _04572_ sky130_fd_sc_hd__a21oi_1
X_13646_ _03704_ _04501_ _04517_ VSS VSS VDD VDD _04573_ sky130_fd_sc_hd__nor3_1
X_13647_ _11863_ _03715_ VSS VSS VDD VDD _04574_ sky130_fd_sc_hd__nand2b_4
X_13648_ _04574_ _04536_ _03702_ VSS VSS VDD VDD _04575_ sky130_fd_sc_hd__a21oi_1
X_13649_ _11864_ _04466_ VSS VSS VDD VDD _04576_ sky130_fd_sc_hd__nand2_1
X_13650_ _03696_ _03714_ VSS VSS VDD VDD _04577_ sky130_fd_sc_hd__nor2_2
X_13651_ _04440_ _04577_ _03704_ VSS VSS VDD VDD _04578_ sky130_fd_sc_hd__o21ai_0
X_13652_ _03735_ _04576_ _04578_ VSS VSS VDD VDD _04579_ sky130_fd_sc_hd__nand3_1
X_13653_ _03735_ _04573_ _04575_ _04579_ _03725_ VSS VSS VDD
+ VDD _04580_ sky130_fd_sc_hd__o311ai_0
X_13654_ _03725_ _04572_ _04580_ VSS VSS VDD VDD _04581_ sky130_fd_sc_hd__o21ai_1
X_13655_ _11863_ _03702_ _03715_ VSS VSS VDD VDD _04582_ sky130_fd_sc_hd__nand3_1
X_13656_ _03725_ _04582_ VSS VSS VDD VDD _04583_ sky130_fd_sc_hd__and2_1
X_13657_ _04535_ _03715_ VSS VSS VDD VDD _04584_ sky130_fd_sc_hd__nand2_1
X_13658_ _11878_ _03714_ VSS VSS VDD VDD _04585_ sky130_fd_sc_hd__nand2_1
X_13659_ _04584_ _04585_ VSS VSS VDD VDD _04586_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_49_1181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13661_ _03690_ _04432_ _04586_ _03704_ _03734_ VSS VSS VDD
+ VDD _04588_ sky130_fd_sc_hd__a221oi_1
X_13662_ net483 _03715_ VSS VSS VDD VDD _04589_ sky130_fd_sc_hd__nand2_4
X_13663_ _04536_ _04589_ _03704_ VSS VSS VDD VDD _04590_ sky130_fd_sc_hd__a21oi_1
X_13664_ _04544_ _04590_ _03735_ VSS VSS VDD VDD _04591_ sky130_fd_sc_hd__o21a_1
X_13665_ _11862_ _03714_ VSS VSS VDD VDD _04592_ sky130_fd_sc_hd__nand2_1
X_13666_ _04574_ _04592_ _03702_ VSS VSS VDD VDD _04593_ sky130_fd_sc_hd__a21oi_1
X_13667_ _03691_ _04432_ _04593_ _03735_ VSS VSS VDD VDD _04594_
+ sky130_fd_sc_hd__a211oi_1
X_13668_ _11878_ _03715_ _04539_ VSS VSS VDD VDD _04595_ sky130_fd_sc_hd__o21ai_2
X_13669_ _11864_ _03714_ VSS VSS VDD VDD _04596_ sky130_fd_sc_hd__nand2_1
X_13670_ _03704_ _04574_ _04596_ VSS VSS VDD VDD _04597_ sky130_fd_sc_hd__and3_1
X_13671_ _03702_ _04595_ _04597_ VSS VSS VDD VDD _04598_ sky130_fd_sc_hd__a21oi_1
X_13672_ _03725_ _03734_ VSS VSS VDD VDD _04599_ sky130_fd_sc_hd__nand2_2
X_13673_ _03725_ _04591_ _04594_ _04598_ _04599_ VSS VSS VDD
+ VDD _04600_ sky130_fd_sc_hd__o32ai_1
X_13674_ _04583_ _04588_ _03751_ _04600_ VSS VSS VDD VDD _04601_
+ sky130_fd_sc_hd__a211oi_2
X_13675_ _03751_ _04581_ _04601_ _03743_ VSS VSS VDD VDD _04602_
+ sky130_fd_sc_hd__a211oi_4
X_13676_ _03743_ _04549_ _04563_ _04602_ VSS VSS VDD VDD _00009_
+ sky130_fd_sc_hd__a31oi_4
X_13677_ _04484_ _04536_ _03702_ VSS VSS VDD VDD _04603_ sky130_fd_sc_hd__a21oi_1
X_13678_ _11869_ _04466_ _04603_ _03734_ VSS VSS VDD VDD _04604_
+ sky130_fd_sc_hd__a211oi_1
X_13679_ _04499_ _04450_ VSS VSS VDD VDD _04605_ sky130_fd_sc_hd__nor2_1
X_13680_ _11886_ _03715_ _04605_ VSS VSS VDD VDD _04606_ sky130_fd_sc_hd__a21oi_1
X_13681_ _03735_ _04606_ VSS VSS VDD VDD _04607_ sky130_fd_sc_hd__nor2_1
X_13682_ _03725_ _04604_ _04607_ VSS VSS VDD VDD _04608_ sky130_fd_sc_hd__nor3_1
X_13683_ _03691_ _04434_ VSS VSS VDD VDD _04609_ sky130_fd_sc_hd__nor2_2
X_13684_ _11862_ _04415_ _04432_ _11872_ _04609_ VSS VSS VDD
+ VDD _04610_ sky130_fd_sc_hd__a221oi_1
X_13685_ _03735_ _04610_ VSS VSS VDD VDD _04611_ sky130_fd_sc_hd__nand2_1
X_13686_ _11867_ _03704_ _03715_ _04559_ VSS VSS VDD VDD _04612_
+ sky130_fd_sc_hd__o211ai_1
X_13687_ _11883_ _03715_ _03734_ _04612_ VSS VSS VDD VDD _04613_
+ sky130_fd_sc_hd__o211ai_1
X_13688_ _04611_ _04613_ net473 VSS VSS VDD VDD _04614_ sky130_fd_sc_hd__a21oi_1
X_13689_ _03750_ _04608_ _04614_ VSS VSS VDD VDD _04615_ sky130_fd_sc_hd__nor3_1
X_13690_ _04485_ _04539_ _03704_ VSS VSS VDD VDD _04616_ sky130_fd_sc_hd__a21oi_1
X_13691_ _11864_ _04434_ _04505_ VSS VSS VDD VDD _04617_ sky130_fd_sc_hd__o21ai_0
X_13692_ _11867_ _03704_ VSS VSS VDD VDD _04618_ sky130_fd_sc_hd__nand2_1
X_13693_ _11869_ _03704_ _04618_ VSS VSS VDD VDD _04619_ sky130_fd_sc_hd__o21ai_0
X_13694_ _03715_ _04619_ _03725_ VSS VSS VDD VDD _04620_ sky130_fd_sc_hd__a21oi_1
X_13695_ net483 _03702_ VSS VSS VDD VDD _04621_ sky130_fd_sc_hd__nor2_2
X_13696_ _11863_ _03704_ VSS VSS VDD VDD _04622_ sky130_fd_sc_hd__nor2_1
X_13697_ _04621_ _04622_ net616 VSS VSS VDD VDD _04623_ sky130_fd_sc_hd__o21ai_1
X_13698_ _03734_ _04620_ _04623_ VSS VSS VDD VDD _04624_ sky130_fd_sc_hd__nand3_1
X_13699_ _04616_ _04617_ _04624_ VSS VSS VDD VDD _04625_ sky130_fd_sc_hd__o21ai_0
X_13700_ _11878_ _03715_ VSS VSS VDD VDD _04626_ sky130_fd_sc_hd__nand2_1
X_13701_ _03696_ net616 VSS VSS VDD VDD _04627_ sky130_fd_sc_hd__nand2_1
X_13702_ _03702_ _04626_ _04627_ VSS VSS VDD VDD _04628_ sky130_fd_sc_hd__nand3_1
X_13703_ net484 _03715_ VSS VSS VDD VDD _04629_ sky130_fd_sc_hd__nand2_4
X_13704_ _03704_ _04443_ _04629_ VSS VSS VDD VDD _04630_ sky130_fd_sc_hd__nand3_1
X_13705_ _04628_ _04630_ _03734_ VSS VSS VDD VDD _04631_ sky130_fd_sc_hd__a21oi_1
X_13706_ _11864_ _03715_ VSS VSS VDD VDD _04632_ sky130_fd_sc_hd__nor2_2
X_13707_ _04500_ _04632_ VSS VSS VDD VDD _04633_ sky130_fd_sc_hd__nor2_1
X_13708_ _11869_ _03715_ VSS VSS VDD VDD _04634_ sky130_fd_sc_hd__nor2_1
X_13709_ _03702_ _04577_ _04634_ VSS VSS VDD VDD _04635_ sky130_fd_sc_hd__nor3_1
X_13710_ _03702_ _04633_ _04635_ _03735_ VSS VSS VDD VDD _04636_
+ sky130_fd_sc_hd__a211oi_1
X_13711_ net473 _04631_ _04636_ VSS VSS VDD VDD _04637_ sky130_fd_sc_hd__nor3_1
X_13712_ _03751_ _04625_ _04637_ VSS VSS VDD VDD _04638_ sky130_fd_sc_hd__nor3_1
X_13713_ _11867_ _03704_ net616 _04622_ VSS VSS VDD VDD _04639_
+ sky130_fd_sc_hd__a211oi_1
X_13714_ _11888_ net616 _04639_ VSS VSS VDD VDD _04640_ sky130_fd_sc_hd__a21oi_1
X_13715_ _11890_ net616 VSS VSS VDD VDD _04641_ sky130_fd_sc_hd__nand2_1
X_13716_ _03696_ _03704_ VSS VSS VDD VDD _04642_ sky130_fd_sc_hd__nor2_1
X_13717_ _03690_ _03696_ net616 _04642_ VSS VSS VDD VDD _04643_
+ sky130_fd_sc_hd__a211o_1
X_13718_ _04641_ _04643_ _03735_ VSS VSS VDD VDD _04644_ sky130_fd_sc_hd__a21oi_1
X_13719_ _03735_ _04640_ _04644_ VSS VSS VDD VDD _04645_ sky130_fd_sc_hd__a21oi_1
X_13720_ _11876_ _04450_ VSS VSS VDD VDD _04646_ sky130_fd_sc_hd__nor2_1
X_13721_ _03735_ _04646_ VSS VSS VDD VDD _04647_ sky130_fd_sc_hd__nor2_1
X_13722_ _04411_ _04442_ _03704_ VSS VSS VDD VDD _04648_ sky130_fd_sc_hd__o21ai_0
X_13723_ _11863_ _04450_ VSS VSS VDD VDD _04649_ sky130_fd_sc_hd__nor2_1
X_13724_ _03725_ _03735_ VSS VSS VDD VDD _04650_ sky130_fd_sc_hd__nand2_2
X_13725_ _11883_ _03715_ _04649_ _04650_ VSS VSS VDD VDD _04651_
+ sky130_fd_sc_hd__a211oi_1
X_13726_ _04583_ _04647_ _04648_ _04651_ _04512_ VSS VSS VDD
+ VDD _04652_ sky130_fd_sc_hd__a32oi_1
X_13727_ _03725_ _04645_ _04652_ VSS VSS VDD VDD _04653_ sky130_fd_sc_hd__o21ai_1
X_13728_ _11863_ _03715_ VSS VSS VDD VDD _04654_ sky130_fd_sc_hd__and2_0
X_13729_ _11874_ _03715_ VSS VSS VDD VDD _04655_ sky130_fd_sc_hd__nor2_1
X_13730_ _03704_ _04574_ _04538_ VSS VSS VDD VDD _04656_ sky130_fd_sc_hd__nand3_1
X_13731_ _03704_ _04654_ _04655_ _04656_ VSS VSS VDD VDD _04657_
+ sky130_fd_sc_hd__o31ai_1
X_13732_ _11869_ _03715_ VSS VSS VDD VDD _04658_ sky130_fd_sc_hd__nand2_1
X_13733_ _04658_ _04596_ _03704_ VSS VSS VDD VDD _04659_ sky130_fd_sc_hd__a21oi_1
X_13734_ _03704_ _04577_ _04632_ _03735_ VSS VSS VDD VDD _04660_
+ sky130_fd_sc_hd__o31ai_2
X_13735_ _11874_ _03714_ VSS VSS VDD VDD _04661_ sky130_fd_sc_hd__nor2_1
X_13736_ _03702_ _04501_ _04661_ VSS VSS VDD VDD _04662_ sky130_fd_sc_hd__nor3_1
X_13737_ _03735_ _04609_ _04659_ _04660_ _04662_ VSS VSS VDD
+ VDD _04663_ sky130_fd_sc_hd__o32ai_4
X_13738_ _03704_ _03725_ VSS VSS VDD VDD _04664_ sky130_fd_sc_hd__nor2_1
X_13739_ _03702_ _03725_ _04589_ VSS VSS VDD VDD _04665_ sky130_fd_sc_hd__nor3_1
X_13740_ _11874_ _04423_ _04664_ _11869_ _04665_ VSS VSS VDD
+ VDD _04666_ sky130_fd_sc_hd__a221oi_1
X_13741_ net473 _04663_ _04666_ _03735_ VSS VSS VDD VDD _04667_
+ sky130_fd_sc_hd__o22ai_1
X_13742_ _04505_ _04657_ _04667_ _03751_ VSS VSS VDD VDD _04668_
+ sky130_fd_sc_hd__a211oi_1
X_13743_ _03751_ _04653_ _04668_ _03743_ VSS VSS VDD VDD _04669_
+ sky130_fd_sc_hd__a211o_1
X_13744_ _03744_ _04615_ _04638_ _04669_ VSS VSS VDD VDD _00010_
+ sky130_fd_sc_hd__o31ai_1
X_13745_ _03735_ _04513_ _04626_ VSS VSS VDD VDD _04670_ sky130_fd_sc_hd__a21boi_0
X_13746_ _03702_ _04670_ _03725_ VSS VSS VDD VDD _04671_ sky130_fd_sc_hd__o21ai_0
X_13747_ _03704_ _03714_ VSS VSS VDD VDD _04672_ sky130_fd_sc_hd__nand2_2
X_13748_ net483 _04672_ VSS VSS VDD VDD _04673_ sky130_fd_sc_hd__nor2_1
X_13749_ _11872_ _03714_ VSS VSS VDD VDD _04674_ sky130_fd_sc_hd__nand2b_4
X_13750_ _04574_ _04674_ _03704_ VSS VSS VDD VDD _04675_ sky130_fd_sc_hd__a21oi_1
X_13751_ net484 _03734_ _03704_ VSS VSS VDD VDD _04676_ sky130_fd_sc_hd__o21ai_0
X_13752_ _04482_ _04513_ _04676_ net473 VSS VSS VDD VDD _04677_
+ sky130_fd_sc_hd__o31ai_1
X_13753_ _03691_ _03702_ VSS VSS VDD VDD _04678_ sky130_fd_sc_hd__nor2_2
X_13754_ _04538_ _04486_ VSS VSS VDD VDD _04679_ sky130_fd_sc_hd__nand2_1
X_13755_ _04678_ _04679_ _03734_ VSS VSS VDD VDD _04680_ sky130_fd_sc_hd__o21ai_0
X_13756_ _04671_ _04673_ _04675_ _04677_ _04680_ VSS VSS VDD
+ VDD _04681_ sky130_fd_sc_hd__o32ai_1
X_13757_ net484 _04423_ _04568_ _11874_ _04677_ VSS VSS VDD
+ VDD _04682_ sky130_fd_sc_hd__a221o_1
X_13758_ _04671_ _04682_ _03734_ VSS VSS VDD VDD _04683_ sky130_fd_sc_hd__a21oi_1
X_13759_ _03702_ _03714_ VSS VSS VDD VDD _04684_ sky130_fd_sc_hd__nor2_1
X_13760_ _04469_ _04589_ _03704_ VSS VSS VDD VDD _04685_ sky130_fd_sc_hd__a21oi_1
X_13761_ _11863_ _04684_ _04510_ _03691_ _04685_ VSS VSS VDD
+ VDD _04686_ sky130_fd_sc_hd__a221oi_1
X_13762_ _03704_ _04517_ _04510_ VSS VSS VDD VDD _04687_ sky130_fd_sc_hd__nor3_1
X_13763_ _03704_ _04443_ _04486_ _04687_ _03734_ VSS VSS VDD
+ VDD _04688_ sky130_fd_sc_hd__a311oi_1
X_13764_ _03734_ _04686_ _04688_ VSS VSS VDD VDD _04689_ sky130_fd_sc_hd__a21oi_2
X_13765_ _11883_ _03715_ _04678_ _04565_ _11863_ VSS VSS VDD
+ VDD _04690_ sky130_fd_sc_hd__o32ai_1
X_13766_ _03704_ _04427_ _04543_ VSS VSS VDD VDD _04691_ sky130_fd_sc_hd__nor3_1
X_13767_ _03704_ _04584_ _04674_ _04691_ _03734_ VSS VSS VDD
+ VDD _04692_ sky130_fd_sc_hd__a311o_1
X_13768_ _03735_ _04690_ _04692_ _03725_ VSS VSS VDD VDD _04693_
+ sky130_fd_sc_hd__o211ai_1
X_13769_ _03725_ _04689_ _04693_ _03751_ VSS VSS VDD VDD _04694_
+ sky130_fd_sc_hd__o211ai_1
X_13770_ _03751_ _04681_ _04683_ _04694_ VSS VSS VDD VDD _04695_
+ sky130_fd_sc_hd__o31ai_1
X_13771_ _03696_ _04450_ _04434_ _11876_ VSS VSS VDD VDD _04696_
+ sky130_fd_sc_hd__o22ai_1
X_13772_ _03704_ _04627_ _03691_ VSS VSS VDD VDD _04697_ sky130_fd_sc_hd__a21oi_1
X_13773_ _11874_ _03715_ VSS VSS VDD VDD _04698_ sky130_fd_sc_hd__nand2_4
X_13774_ _03702_ _04674_ _04698_ VSS VSS VDD VDD _04699_ sky130_fd_sc_hd__and3_1
X_13775_ _04629_ _04592_ _03702_ VSS VSS VDD VDD _04700_ sky130_fd_sc_hd__a21oi_2
X_13776_ _04699_ _04700_ _03734_ VSS VSS VDD VDD _04701_ sky130_fd_sc_hd__o21ai_0
X_13777_ _03734_ _04696_ _04697_ _04701_ net473 VSS VSS VDD
+ VDD _04702_ sky130_fd_sc_hd__o311ai_0
X_13778_ _03735_ _04443_ _04698_ VSS VSS VDD VDD _04703_ sky130_fd_sc_hd__nand3_1
X_13779_ _03735_ _04538_ _04703_ VSS VSS VDD VDD _04704_ sky130_fd_sc_hd__o21ai_0
X_13780_ _03735_ _04482_ _04632_ VSS VSS VDD VDD _04705_ sky130_fd_sc_hd__a21oi_1
X_13781_ _03702_ _04705_ VSS VSS VDD VDD _04706_ sky130_fd_sc_hd__nand2_1
X_13782_ _03702_ _04704_ _04706_ VSS VSS VDD VDD _04707_ sky130_fd_sc_hd__o21ai_0
X_13783_ _03725_ _04707_ _03751_ VSS VSS VDD VDD _04708_ sky130_fd_sc_hd__a21oi_1
X_13784_ _11874_ _03715_ _04486_ VSS VSS VDD VDD _04709_ sky130_fd_sc_hd__o21ai_0
X_13785_ _04412_ _04443_ _03702_ VSS VSS VDD VDD _04710_ sky130_fd_sc_hd__a21oi_1
X_13786_ _03702_ _04709_ _04710_ VSS VSS VDD VDD _04711_ sky130_fd_sc_hd__a21oi_1
X_13787_ _04629_ _04674_ _03704_ VSS VSS VDD VDD _04712_ sky130_fd_sc_hd__a21oi_1
X_13788_ _11863_ _04672_ _04589_ net484 VSS VSS VDD VDD _04713_
+ sky130_fd_sc_hd__o22ai_1
X_13789_ _04650_ _04712_ _04713_ VSS VSS VDD VDD _04714_ sky130_fd_sc_hd__or3_1
X_13790_ _11867_ _04466_ VSS VSS VDD VDD _04715_ sky130_fd_sc_hd__nand2_1
X_13791_ _03690_ _03696_ VSS VSS VDD VDD _04716_ sky130_fd_sc_hd__nor2_1
X_13792_ _04678_ _04716_ net616 VSS VSS VDD VDD _04717_ sky130_fd_sc_hd__o21ai_0
X_13793_ _04715_ _04717_ _03735_ VSS VSS VDD VDD _04718_ sky130_fd_sc_hd__a21oi_1
X_13794_ _04440_ _04442_ _03704_ VSS VSS VDD VDD _04719_ sky130_fd_sc_hd__o21ai_0
X_13795_ _03704_ _04500_ _04513_ _04719_ _03735_ VSS VSS VDD
+ VDD _04720_ sky130_fd_sc_hd__o311a_1
X_13796_ _04718_ _04720_ net473 VSS VSS VDD VDD _04721_ sky130_fd_sc_hd__o21ai_0
X_13797_ _04599_ _04711_ _04714_ _04721_ VSS VSS VDD VDD _04722_
+ sky130_fd_sc_hd__o211ai_1
X_13798_ _04702_ _04708_ _04722_ _03751_ _03743_ VSS VSS VDD
+ VDD _04723_ sky130_fd_sc_hd__a221oi_1
X_13799_ _03743_ _04695_ _04723_ VSS VSS VDD VDD _00011_ sky130_fd_sc_hd__a21o_1
X_13800_ _04452_ _04577_ _03704_ VSS VSS VDD VDD _04724_ sky130_fd_sc_hd__o21ai_0
X_13801_ _03743_ _04467_ _04724_ VSS VSS VDD VDD _04725_ sky130_fd_sc_hd__nand3_1
X_13802_ _03702_ _03744_ _04595_ VSS VSS VDD VDD _04726_ sky130_fd_sc_hd__nand3_1
X_13803_ _11869_ _03704_ VSS VSS VDD VDD _04727_ sky130_fd_sc_hd__and2_0
X_13804_ _04622_ _04727_ net616 VSS VSS VDD VDD _04728_ sky130_fd_sc_hd__o21ai_0
X_13805_ _04592_ _04582_ _03744_ VSS VSS VDD VDD _04729_ sky130_fd_sc_hd__a21oi_1
X_13806_ _03744_ _04497_ _04728_ _04729_ _03725_ VSS VSS VDD
+ VDD _04730_ sky130_fd_sc_hd__a311oi_1
X_13807_ _03725_ _04725_ _04726_ _04730_ VSS VSS VDD VDD _04731_
+ sky130_fd_sc_hd__a31oi_1
X_13808_ _11892_ _03715_ VSS VSS VDD VDD _04732_ sky130_fd_sc_hd__nand2_1
X_13809_ _03743_ _04646_ _04678_ _04732_ VSS VSS VDD VDD _04733_
+ sky130_fd_sc_hd__nor4b_1
X_13810_ _04443_ _04698_ _03704_ VSS VSS VDD VDD _04734_ sky130_fd_sc_hd__a21oi_1
X_13811_ _03704_ _04633_ _04734_ _03744_ VSS VSS VDD VDD _04735_
+ sky130_fd_sc_hd__a211oi_1
X_13812_ _04733_ _04735_ net473 VSS VSS VDD VDD _04736_ sky130_fd_sc_hd__o21ai_0
X_13813_ _03702_ _04516_ _04698_ _03725_ _03744_ VSS VSS VDD
+ VDD _04737_ sky130_fd_sc_hd__o2111ai_1
X_13814_ _11874_ _03704_ _03744_ VSS VSS VDD VDD _04738_ sky130_fd_sc_hd__a21oi_1
X_13815_ _04523_ _04583_ _04738_ VSS VSS VDD VDD _04739_ sky130_fd_sc_hd__nand3_1
X_13816_ _03751_ _04736_ _04737_ _04739_ VSS VSS VDD VDD _04740_
+ sky130_fd_sc_hd__nand4_1
X_13817_ _03751_ _04731_ _04740_ VSS VSS VDD VDD _04741_ sky130_fd_sc_hd__o21ai_1
X_13818_ _03690_ _04412_ VSS VSS VDD VDD _04742_ sky130_fd_sc_hd__nor2_1
X_13819_ _04629_ _04585_ _03702_ VSS VSS VDD VDD _04743_ sky130_fd_sc_hd__a21oi_1
X_13820_ _04646_ _04742_ _04743_ VSS VSS VDD VDD _04744_ sky130_fd_sc_hd__nor3_1
X_13821_ _11864_ _04450_ _04501_ _03702_ _03744_ VSS VSS VDD
+ VDD _04745_ sky130_fd_sc_hd__o221ai_1
X_13822_ _03744_ _04744_ _04745_ VSS VSS VDD VDD _04746_ sky130_fd_sc_hd__o21ai_0
X_13823_ _03724_ _04746_ VSS VSS VDD VDD _04747_ sky130_fd_sc_hd__nand2_1
X_13824_ _04536_ _04658_ _03702_ VSS VSS VDD VDD _04748_ sky130_fd_sc_hd__a21oi_1
X_13825_ net484 _04411_ VSS VSS VDD VDD _04749_ sky130_fd_sc_hd__nor2_1
X_13826_ _04543_ _04749_ _03704_ VSS VSS VDD VDD _04750_ sky130_fd_sc_hd__o21ai_1
X_13827_ _03696_ _04469_ _04467_ _04750_ _03743_ VSS VSS VDD
+ VDD _04751_ sky130_fd_sc_hd__o2111ai_4
X_13828_ _03743_ _04545_ _04748_ _04751_ _03725_ VSS VSS VDD
+ VDD _04752_ sky130_fd_sc_hd__o311ai_4
X_13829_ _04747_ _04752_ _03751_ VSS VSS VDD VDD _04753_ sky130_fd_sc_hd__a21oi_1
X_13830_ _04432_ _04678_ net483 VSS VSS VDD VDD _04754_ sky130_fd_sc_hd__o21ai_0
X_13831_ _04470_ _04642_ _04754_ VSS VSS VDD VDD _04755_ sky130_fd_sc_hd__o21ai_0
X_13832_ _11876_ _04466_ _04621_ VSS VSS VDD VDD _04756_ sky130_fd_sc_hd__a21oi_1
X_13833_ _03724_ _04756_ VSS VSS VDD VDD _04757_ sky130_fd_sc_hd__nor2_1
X_13834_ _04543_ _04491_ _04755_ _03724_ _04757_ VSS VSS VDD
+ VDD _04758_ sky130_fd_sc_hd__a221oi_1
X_13835_ _11864_ _03715_ _04412_ VSS VSS VDD VDD _04759_ sky130_fd_sc_hd__o21ai_0
X_13836_ _03702_ _04759_ VSS VSS VDD VDD _04760_ sky130_fd_sc_hd__nand2_1
X_13837_ _04500_ _04634_ _03704_ VSS VSS VDD VDD _04761_ sky130_fd_sc_hd__o21ai_0
X_13838_ _03702_ _04552_ _04589_ _03725_ _04472_ VSS VSS VDD
+ VDD _04762_ sky130_fd_sc_hd__a311oi_4
X_13839_ _03725_ _04760_ _04761_ _03744_ _04762_ VSS VSS VDD
+ VDD _04763_ sky130_fd_sc_hd__a311o_1
X_13840_ _03743_ _04758_ _04763_ VSS VSS VDD VDD _04764_ sky130_fd_sc_hd__o21ai_0
X_13841_ _03750_ _04764_ _03734_ VSS VSS VDD VDD _04765_ sky130_fd_sc_hd__o21ai_0
X_13842_ _03734_ _04741_ _04753_ _04765_ VSS VSS VDD VDD _00012_
+ sky130_fd_sc_hd__o22a_1
X_13843_ _11872_ _04466_ VSS VSS VDD VDD _04766_ sky130_fd_sc_hd__nand2_1
X_13844_ net484 _04411_ _04450_ _03696_ _03725_ VSS VSS VDD
+ VDD _04767_ sky130_fd_sc_hd__a221oi_1
X_13845_ _03725_ _04541_ _04551_ _04766_ _04767_ VSS VSS VDD
+ VDD _04768_ sky130_fd_sc_hd__a41oi_2
X_13846_ _04584_ _04596_ _03704_ VSS VSS VDD VDD _04769_ sky130_fd_sc_hd__a21oi_1
X_13847_ _11878_ _03702_ _04621_ VSS VSS VDD VDD _04770_ sky130_fd_sc_hd__a21oi_1
X_13848_ _03715_ _04770_ _04583_ VSS VSS VDD VDD _04771_ sky130_fd_sc_hd__o21ai_0
X_13849_ _03725_ _04435_ _04769_ _04771_ _03734_ VSS VSS VDD
+ VDD _04772_ sky130_fd_sc_hd__o311ai_2
X_13850_ _03734_ _04768_ _04772_ VSS VSS VDD VDD _04773_ sky130_fd_sc_hd__o21ai_0
X_13851_ _03751_ _04773_ VSS VSS VDD VDD _04774_ sky130_fd_sc_hd__nand2_1
X_13852_ _11864_ _03704_ _03715_ VSS VSS VDD VDD _04775_ sky130_fd_sc_hd__o21ai_0
X_13853_ _11864_ net616 _04442_ VSS VSS VDD VDD _04776_ sky130_fd_sc_hd__a21oi_1
X_13854_ _04654_ _04513_ _03704_ VSS VSS VDD VDD _04777_ sky130_fd_sc_hd__o21ai_0
X_13855_ _03704_ _04776_ _04777_ VSS VSS VDD VDD _04778_ sky130_fd_sc_hd__o21ai_0
X_13856_ _03735_ _04778_ VSS VSS VDD VDD _04779_ sky130_fd_sc_hd__nor2_1
X_13857_ _03735_ _04523_ _04775_ _04779_ VSS VSS VDD VDD _04780_
+ sky130_fd_sc_hd__a31oi_1
X_13858_ _11872_ _03715_ _03735_ VSS VSS VDD VDD _04781_ sky130_fd_sc_hd__a21oi_1
X_13859_ _03715_ _04496_ _04781_ VSS VSS VDD VDD _04782_ sky130_fd_sc_hd__o21ai_0
X_13860_ _03734_ _04605_ _04700_ _04782_ net473 VSS VSS VDD
+ VDD _04783_ sky130_fd_sc_hd__o311ai_1
X_13861_ net473 _04780_ _04783_ _03750_ VSS VSS VDD VDD _04784_
+ sky130_fd_sc_hd__o211ai_2
X_13862_ net484 _04423_ _04749_ VSS VSS VDD VDD _04785_ sky130_fd_sc_hd__a21oi_1
X_13863_ _11862_ _04434_ _04523_ _03734_ _04416_ VSS VSS VDD
+ VDD _04786_ sky130_fd_sc_hd__o2111ai_1
X_13864_ _03734_ _04785_ _04786_ VSS VSS VDD VDD _04787_ sky130_fd_sc_hd__o21ai_1
X_13865_ _11862_ _04672_ _04776_ _03704_ _03734_ VSS VSS VDD
+ VDD _04788_ sky130_fd_sc_hd__o221ai_1
X_13866_ _03704_ _04574_ _04627_ VSS VSS VDD VDD _04789_ sky130_fd_sc_hd__nand3_1
X_13867_ _03704_ _04500_ _04655_ _04789_ _03735_ VSS VSS VDD
+ VDD _04790_ sky130_fd_sc_hd__o311ai_2
X_13868_ _03725_ _04788_ _04790_ VSS VSS VDD VDD _04791_ sky130_fd_sc_hd__nand3_1
X_13869_ _03725_ _04787_ _04791_ VSS VSS VDD VDD _04792_ sky130_fd_sc_hd__o21ai_0
X_13870_ _03750_ _04792_ VSS VSS VDD VDD _04793_ sky130_fd_sc_hd__nand2_1
X_13871_ _03704_ _04443_ _04698_ VSS VSS VDD VDD _04794_ sky130_fd_sc_hd__nand3_1
X_13872_ _03702_ _04482_ VSS VSS VDD VDD _04795_ sky130_fd_sc_hd__nand2_1
X_13873_ _04794_ _04795_ _03725_ _03735_ VSS VSS VDD VDD _04796_
+ sky130_fd_sc_hd__a211oi_1
X_13874_ _03704_ _04517_ _04655_ VSS VSS VDD VDD _04797_ sky130_fd_sc_hd__nor3_1
X_13875_ _03704_ _04629_ _04485_ _04650_ _04797_ VSS VSS VDD
+ VDD _04798_ sky130_fd_sc_hd__a311oi_1
X_13876_ _03704_ _04500_ _04552_ VSS VSS VDD VDD _04799_ sky130_fd_sc_hd__o21ai_0
X_13877_ _04599_ _04799_ VSS VSS VDD VDD _04800_ sky130_fd_sc_hd__nor2_1
X_13878_ _04796_ _04798_ _04800_ VSS VSS VDD VDD _04801_ sky130_fd_sc_hd__nor3_1
X_13879_ _11864_ _03702_ _04727_ VSS VSS VDD VDD _04802_ sky130_fd_sc_hd__a21oi_1
X_13880_ net616 _04802_ _04494_ _03735_ VSS VSS VDD VDD _04803_
+ sky130_fd_sc_hd__o211ai_1
X_13881_ _03751_ _04801_ _04803_ _03743_ VSS VSS VDD VDD _04804_
+ sky130_fd_sc_hd__a31oi_2
X_13882_ _03743_ _04774_ _04784_ _04793_ _04804_ VSS VSS VDD
+ VDD _00013_ sky130_fd_sc_hd__a32oi_4
X_13883_ _03702_ _04464_ _04710_ VSS VSS VDD VDD _04805_ sky130_fd_sc_hd__a21oi_1
X_13884_ _03734_ _04805_ VSS VSS VDD VDD _04806_ sky130_fd_sc_hd__nor2_1
X_13885_ _11867_ _04434_ VSS VSS VDD VDD _04807_ sky130_fd_sc_hd__nor2_1
X_13886_ _03735_ _04649_ _04569_ _04807_ VSS VSS VDD VDD _04808_
+ sky130_fd_sc_hd__nor4_1
X_13887_ _04412_ _04674_ _03704_ VSS VSS VDD VDD _04809_ sky130_fd_sc_hd__a21oi_1
X_13888_ _11867_ _03702_ VSS VSS VDD VDD _04810_ sky130_fd_sc_hd__nand2_1
X_13889_ _11863_ _03702_ net616 _04810_ VSS VSS VDD VDD _04811_
+ sky130_fd_sc_hd__o211ai_1
X_13890_ _11886_ net616 _03735_ _04811_ VSS VSS VDD VDD _04812_
+ sky130_fd_sc_hd__o211ai_1
X_13891_ _03735_ _04807_ _04809_ _04812_ _03725_ VSS VSS VDD
+ VDD _04813_ sky130_fd_sc_hd__o311ai_0
X_13892_ _03725_ _04806_ _04808_ _03751_ _04813_ VSS VSS VDD
+ VDD _04814_ sky130_fd_sc_hd__o311ai_1
X_13893_ _11882_ net616 VSS VSS VDD VDD _04815_ sky130_fd_sc_hd__nor2_1
X_13894_ _11874_ _03704_ VSS VSS VDD VDD _04816_ sky130_fd_sc_hd__nor2_1
X_13895_ _03715_ _04621_ _04816_ VSS VSS VDD VDD _04817_ sky130_fd_sc_hd__nor3_1
X_13896_ _03725_ _04815_ _04817_ VSS VSS VDD VDD _04818_ sky130_fd_sc_hd__nor3_1
X_13897_ _03704_ _04679_ VSS VSS VDD VDD _04819_ sky130_fd_sc_hd__nor2_1
X_13898_ net473 _04435_ _04819_ _03735_ VSS VSS VDD VDD _04820_
+ sky130_fd_sc_hd__o31ai_1
X_13899_ _03702_ _04674_ _04698_ VSS VSS VDD VDD _04821_ sky130_fd_sc_hd__nand3_1
X_13900_ _03696_ _04684_ net473 VSS VSS VDD VDD _04822_ sky130_fd_sc_hd__a21oi_1
X_13901_ _04821_ _04822_ _04620_ VSS VSS VDD VDD _04823_ sky130_fd_sc_hd__a21oi_1
X_13902_ _04818_ _04820_ _04823_ _03735_ _03750_ VSS VSS VDD
+ VDD _04824_ sky130_fd_sc_hd__o221ai_1
X_13903_ _03743_ _04814_ _04824_ VSS VSS VDD VDD _04825_ sky130_fd_sc_hd__nand3_1
X_13904_ _04536_ _04698_ _03702_ VSS VSS VDD VDD _04826_ sky130_fd_sc_hd__a21oi_1
X_13905_ _11878_ _04466_ _04826_ VSS VSS VDD VDD _04827_ sky130_fd_sc_hd__a21oi_1
X_13906_ _11874_ _04684_ _04649_ _04569_ _03735_ VSS VSS VDD
+ VDD _04828_ sky130_fd_sc_hd__a2111oi_0
X_13907_ _03735_ _04827_ _04828_ VSS VSS VDD VDD _04829_ sky130_fd_sc_hd__a21oi_1
X_13908_ _03696_ _04565_ VSS VSS VDD VDD _04830_ sky130_fd_sc_hd__nand2_1
X_13909_ _03696_ _04629_ _04830_ _04505_ VSS VSS VDD VDD _04831_
+ sky130_fd_sc_hd__o211ai_1
X_13910_ _11864_ _11874_ _03702_ VSS VSS VDD VDD _04832_ sky130_fd_sc_hd__mux2i_1
X_13911_ _11862_ _03704_ _04492_ VSS VSS VDD VDD _04833_ sky130_fd_sc_hd__o21ai_0
X_13912_ _03715_ _04833_ VSS VSS VDD VDD _04834_ sky130_fd_sc_hd__nand2_1
X_13913_ _03715_ _04832_ _04834_ net473 _03734_ VSS VSS VDD
+ VDD _04835_ sky130_fd_sc_hd__o2111ai_2
X_13914_ _03743_ _03750_ VSS VSS VDD VDD _04836_ sky130_fd_sc_hd__nor2_1
X_13915_ net473 _04829_ _04831_ _04835_ _04836_ VSS VSS VDD
+ VDD _04837_ sky130_fd_sc_hd__o2111ai_1
X_13916_ net484 _03702_ _04810_ VSS VSS VDD VDD _04838_ sky130_fd_sc_hd__o21ai_0
X_13917_ net616 _04838_ VSS VSS VDD VDD _04839_ sky130_fd_sc_hd__nand2_1
X_13918_ _03691_ _03704_ _04672_ _11864_ VSS VSS VDD VDD _04840_
+ sky130_fd_sc_hd__o22ai_1
X_13919_ _03734_ _04742_ _04840_ VSS VSS VDD VDD _04841_ sky130_fd_sc_hd__nor3_1
X_13920_ _03734_ _04557_ _04839_ _04841_ VSS VSS VDD VDD _04842_
+ sky130_fd_sc_hd__a31oi_1
X_13921_ _03702_ _04470_ VSS VSS VDD VDD _04843_ sky130_fd_sc_hd__nand2_1
X_13922_ net483 _04843_ _04605_ _04609_ _03734_ VSS VSS VDD
+ VDD _04844_ sky130_fd_sc_hd__a2111oi_0
X_13923_ _03734_ _04794_ _04843_ _04844_ _03725_ VSS VSS VDD
+ VDD _04845_ sky130_fd_sc_hd__a311oi_1
X_13924_ _03725_ _04842_ _04845_ VSS VSS VDD VDD _04846_ sky130_fd_sc_hd__a21oi_1
X_13925_ _03744_ _03750_ _04846_ VSS VSS VDD VDD _04847_ sky130_fd_sc_hd__nand3_1
X_13926_ _04825_ _04837_ _04847_ VSS VSS VDD VDD _00014_ sky130_fd_sc_hd__nand3_1
X_13927_ _03704_ _04440_ _04442_ VSS VSS VDD VDD _04848_ sky130_fd_sc_hd__nor3_1
X_13928_ _03704_ _04574_ _04536_ _04848_ VSS VSS VDD VDD _04849_
+ sky130_fd_sc_hd__a31oi_1
X_13929_ _04535_ _03702_ VSS VSS VDD VDD _04850_ sky130_fd_sc_hd__nor2_1
X_13930_ _03702_ _04412_ _04585_ _04850_ _03735_ VSS VSS VDD
+ VDD _04851_ sky130_fd_sc_hd__a311oi_1
X_13931_ _03735_ _04849_ _04851_ VSS VSS VDD VDD _04852_ sky130_fd_sc_hd__a21oi_1
X_13932_ _03704_ _04440_ _04698_ VSS VSS VDD VDD _04853_ sky130_fd_sc_hd__nor3b_1
X_13933_ _03704_ _04470_ _04627_ _04853_ VSS VSS VDD VDD _04854_
+ sky130_fd_sc_hd__a31oi_1
X_13934_ _03690_ _03696_ _03715_ _04491_ VSS VSS VDD VDD _04855_
+ sky130_fd_sc_hd__o211ai_1
X_13935_ _03734_ _04552_ _04855_ net473 VSS VSS VDD VDD _04856_
+ sky130_fd_sc_hd__a31oi_1
X_13936_ _03734_ _04854_ _04856_ VSS VSS VDD VDD _04857_ sky130_fd_sc_hd__o21ai_0
X_13937_ _03725_ _04852_ _04857_ VSS VSS VDD VDD _04858_ sky130_fd_sc_hd__o21ai_0
X_13938_ _04538_ _04539_ _03704_ VSS VSS VDD VDD _04859_ sky130_fd_sc_hd__a21oi_1
X_13939_ _04472_ _04859_ _03735_ VSS VSS VDD VDD _04860_ sky130_fd_sc_hd__o21ai_2
X_13940_ _03690_ _04450_ _04434_ _11864_ VSS VSS VDD VDD _04861_
+ sky130_fd_sc_hd__o22ai_1
X_13941_ _11863_ _04568_ VSS VSS VDD VDD _04862_ sky130_fd_sc_hd__nor2_1
X_13942_ _04861_ _04862_ _03734_ VSS VSS VDD VDD _04863_ sky130_fd_sc_hd__o21ai_0
X_13943_ _04860_ _04863_ net473 VSS VSS VDD VDD _04864_ sky130_fd_sc_hd__a21oi_1
X_13944_ _11874_ _04565_ VSS VSS VDD VDD _04865_ sky130_fd_sc_hd__nor2_1
X_13945_ _03704_ _04759_ _04865_ VSS VSS VDD VDD _04866_ sky130_fd_sc_hd__a21oi_1
X_13946_ _11883_ _04678_ _03715_ VSS VSS VDD VDD _04867_ sky130_fd_sc_hd__o21ai_0
X_13947_ _03715_ _04832_ _04867_ net473 _03734_ VSS VSS VDD
+ VDD _04868_ sky130_fd_sc_hd__o2111ai_1
X_13948_ _03725_ _03734_ _04866_ _04868_ VSS VSS VDD VDD _04869_
+ sky130_fd_sc_hd__o31ai_1
X_13949_ _04864_ _04869_ _03750_ VSS VSS VDD VDD _04870_ sky130_fd_sc_hd__o21ai_0
X_13950_ _03750_ _04858_ _04870_ VSS VSS VDD VDD _04871_ sky130_fd_sc_hd__o21ai_1
X_13951_ _03702_ net473 _04470_ VSS VSS VDD VDD _04872_ sky130_fd_sc_hd__nor3_1
X_13952_ _04440_ _04664_ _04872_ VSS VSS VDD VDD _04873_ sky130_fd_sc_hd__a21oi_1
X_13953_ _03725_ _04672_ _04565_ VSS VSS VDD VDD _04874_ sky130_fd_sc_hd__o21ai_0
X_13954_ _03696_ _03715_ net473 VSS VSS VDD VDD _04875_ sky130_fd_sc_hd__nand3_1
X_13955_ _03715_ net473 _04875_ VSS VSS VDD VDD _04876_ sky130_fd_sc_hd__o21ai_0
X_13956_ net483 _04874_ _04876_ net484 VSS VSS VDD VDD _04877_
+ sky130_fd_sc_hd__a22oi_1
X_13957_ _03714_ _03725_ _04450_ VSS VSS VDD VDD _04878_ sky130_fd_sc_hd__o21ai_0
X_13958_ net473 _04463_ _04443_ VSS VSS VDD VDD _04879_ sky130_fd_sc_hd__o21ai_0
X_13959_ _11862_ _04878_ _04879_ _03704_ _04664_ VSS VSS VDD
+ VDD _04880_ sky130_fd_sc_hd__a221oi_1
X_13960_ _03735_ _04880_ VSS VSS VDD VDD _04881_ sky130_fd_sc_hd__nor2_1
X_13961_ _03735_ _04873_ _04877_ _04881_ VSS VSS VDD VDD _04882_
+ sky130_fd_sc_hd__a31oi_1
X_13962_ _11874_ _03704_ _04622_ VSS VSS VDD VDD _04883_ sky130_fd_sc_hd__a21oi_1
X_13963_ _03715_ _04883_ _04732_ _03734_ VSS VSS VDD VDD _04884_
+ sky130_fd_sc_hd__o211ai_1
X_13964_ _11862_ net616 _04585_ _03704_ _03735_ VSS VSS VDD
+ VDD _04885_ sky130_fd_sc_hd__o221ai_1
X_13965_ _04884_ _04885_ _03725_ VSS VSS VDD VDD _04886_ sky130_fd_sc_hd__a21oi_1
X_13966_ _11867_ net616 _04517_ _03702_ VSS VSS VDD VDD _04887_
+ sky130_fd_sc_hd__a211oi_1
X_13967_ _04545_ _04650_ _04887_ VSS VSS VDD VDD _04888_ sky130_fd_sc_hd__nor3_1
X_13968_ _03704_ _04427_ _04501_ VSS VSS VDD VDD _04889_ sky130_fd_sc_hd__nor3_1
X_13969_ _11888_ net616 _04435_ _04599_ _04889_ VSS VSS VDD
+ VDD _04890_ sky130_fd_sc_hd__a2111oi_0
X_13970_ _03750_ _04886_ _04888_ _04890_ VSS VSS VDD VDD _04891_
+ sky130_fd_sc_hd__nor4_1
X_13971_ _03750_ _04882_ _04891_ _03744_ VSS VSS VDD VDD _04892_
+ sky130_fd_sc_hd__a211oi_2
X_13972_ _03744_ _04871_ _04892_ VSS VSS VDD VDD _00015_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_49_1180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13982_ net487 _03639_ VSS VSS VDD VDD _04899_ sky130_fd_sc_hd__nor2_2
X_13983_ _11912_ _03639_ _04899_ VSS VSS VDD VDD _04900_ sky130_fd_sc_hd__a21oi_1
X_13984_ _03648_ _04900_ _03656_ VSS VSS VDD VDD _04901_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_48_1171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13987_ _03631_ _03639_ VSS VSS VDD VDD _04904_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_48_1169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13990_ _11901_ _03637_ VSS VSS VDD VDD _04907_ sky130_fd_sc_hd__nand2_1
X_13991_ net486 _04904_ _04907_ _03656_ VSS VSS VDD VDD _04908_
+ sky130_fd_sc_hd__a31oi_2
XTAP_TAPCELL_ROW_48_1167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13994_ _11898_ net752 VSS VSS VDD VDD _04911_ sky130_fd_sc_hd__nor2_1
X_13995_ _11896_ _03639_ _04901_ _04908_ _04911_ VSS VSS VDD
+ VDD _04912_ sky130_fd_sc_hd__a32oi_1
XTAP_TAPCELL_ROW_48_1165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13997_ _03625_ _03637_ net486 VSS VSS VDD VDD _04914_ sky130_fd_sc_hd__a21oi_1
X_13998_ _04901_ _04908_ _04914_ VSS VSS VDD VDD _04915_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_48_1164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14000_ _04912_ _04915_ _03667_ VSS VSS VDD VDD _04917_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_48_1163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14006_ _03639_ _03648_ VSS VSS VDD VDD _04923_ sky130_fd_sc_hd__nand2_4
X_14007_ _11903_ _04923_ VSS VSS VDD VDD _04924_ sky130_fd_sc_hd__nor2_1
X_14008_ _11901_ _03648_ VSS VSS VDD VDD _04925_ sky130_fd_sc_hd__nand2_8
X_14009_ _03625_ net485 VSS VSS VDD VDD _04926_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_48_1158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14011_ _04925_ _04926_ _03639_ VSS VSS VDD VDD _04928_ sky130_fd_sc_hd__a21oi_1
X_14012_ _03658_ _04924_ _04928_ VSS VSS VDD VDD _04929_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_48_1157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14014_ _11901_ net485 VSS VSS VDD VDD _04931_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_48_1156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14016_ _11898_ _03648_ VSS VSS VDD VDD _04933_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_48_1155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14018_ _11897_ _03648_ VSS VSS VDD VDD _04935_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_48_1154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14020_ _04926_ _04935_ _03637_ VSS VSS VDD VDD _04937_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_48_1153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14022_ net752 _04931_ _04933_ _04937_ _03656_ VSS VSS VDD
+ VDD _04939_ sky130_fd_sc_hd__a311oi_1
X_14023_ _03666_ _04929_ _04939_ VSS VSS VDD VDD _04940_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_48_1152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14025_ _04917_ _04940_ _03684_ VSS VSS VDD VDD _04942_ sky130_fd_sc_hd__o21ai_0
X_14026_ _03639_ _03648_ VSS VSS VDD VDD _04943_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_48_1151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14029_ _11908_ _03639_ VSS VSS VDD VDD _04946_ sky130_fd_sc_hd__and2_0
X_14030_ _11897_ _04923_ _04946_ _03648_ VSS VSS VDD VDD _04947_
+ sky130_fd_sc_hd__o22ai_1
X_14031_ _11896_ _03639_ VSS VSS VDD VDD _04948_ sky130_fd_sc_hd__nand2_1
X_14032_ _04948_ _04914_ _03658_ VSS VSS VDD VDD _04949_ sky130_fd_sc_hd__a21oi_1
X_14033_ _03658_ _04947_ _04949_ VSS VSS VDD VDD _04950_ sky130_fd_sc_hd__a21oi_1
X_14034_ _11903_ _04943_ _04950_ VSS VSS VDD VDD _04951_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_47_1149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14037_ _11903_ _03648_ VSS VSS VDD VDD _04954_ sky130_fd_sc_hd__nand2b_4
X_14038_ _11912_ _03648_ _04954_ VSS VSS VDD VDD _04955_ sky130_fd_sc_hd__o21ai_0
X_14039_ _11910_ _04943_ _04955_ _03639_ _03656_ VSS VSS VDD
+ VDD _04956_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_47_1147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14042_ _11897_ net755 VSS VSS VDD VDD _04959_ sky130_fd_sc_hd__nand2b_2
X_14043_ _11906_ net755 _04959_ VSS VSS VDD VDD _04960_ sky130_fd_sc_hd__o21ai_0
X_14044_ _03624_ _03648_ VSS VSS VDD VDD _04961_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_47_1145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14046_ _03631_ net486 VSS VSS VDD VDD _04963_ sky130_fd_sc_hd__nand2_2
X_14047_ _04961_ _04963_ _03637_ VSS VSS VDD VDD _04964_ sky130_fd_sc_hd__a21oi_1
X_14048_ net752 _04960_ _04964_ VSS VSS VDD VDD _04965_ sky130_fd_sc_hd__a21oi_1
X_14049_ _03658_ _04965_ VSS VSS VDD VDD _04966_ sky130_fd_sc_hd__nor2_1
X_14050_ _04956_ _04966_ _03667_ VSS VSS VDD VDD _04967_ sky130_fd_sc_hd__o21ai_0
X_14051_ _03667_ _04951_ _04967_ _03685_ VSS VSS VDD VDD _04968_
+ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_47_1144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14053_ _03639_ net485 VSS VSS VDD VDD _04970_ sky130_fd_sc_hd__nor2_8
X_14054_ _11912_ net485 VSS VSS VDD VDD _04971_ sky130_fd_sc_hd__nand2_2
X_14055_ _11901_ net485 _04971_ VSS VSS VDD VDD _04972_ sky130_fd_sc_hd__o21ai_2
X_14056_ _11908_ _04970_ _04972_ _03639_ _03666_ VSS VSS VDD
+ VDD _04973_ sky130_fd_sc_hd__a221oi_1
X_14057_ _04961_ _04926_ _03639_ VSS VSS VDD VDD _04974_ sky130_fd_sc_hd__a21oi_1
X_14058_ _11910_ _03648_ VSS VSS VDD VDD _04975_ sky130_fd_sc_hd__nand2b_2
X_14059_ _04975_ _04931_ _03637_ VSS VSS VDD VDD _04976_ sky130_fd_sc_hd__a21oi_2
X_14060_ _03667_ _04974_ _04976_ VSS VSS VDD VDD _04977_ sky130_fd_sc_hd__nor3_1
X_14061_ _03658_ _04973_ _04977_ VSS VSS VDD VDD _04978_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_47_1143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14063_ _03637_ net755 VSS VSS VDD VDD _04980_ sky130_fd_sc_hd__nand2_4
X_14064_ _11906_ _04980_ VSS VSS VDD VDD _04981_ sky130_fd_sc_hd__nor2_1
X_14065_ _11912_ _03648_ VSS VSS VDD VDD _04982_ sky130_fd_sc_hd__nand2_1
X_14066_ _04931_ _04982_ net752 VSS VSS VDD VDD _04983_ sky130_fd_sc_hd__a21oi_1
X_14067_ _03666_ _04981_ _04983_ VSS VSS VDD VDD _04984_ sky130_fd_sc_hd__nor3_1
X_14068_ _11922_ _03648_ _04943_ _11897_ _03667_ VSS VSS VDD
+ VDD _04985_ sky130_fd_sc_hd__a221oi_4
X_14069_ _03656_ _04984_ _04985_ VSS VSS VDD VDD _04986_ sky130_fd_sc_hd__nor3_1
X_14070_ _04978_ _04986_ _03685_ VSS VSS VDD VDD _04987_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_47_1142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14072_ _03637_ _03648_ VSS VSS VDD VDD _04989_ sky130_fd_sc_hd__nor2_1
X_14073_ _04970_ _04989_ VSS VSS VDD VDD _04990_ sky130_fd_sc_hd__nor2_2
X_14074_ _03637_ net755 VSS VSS VDD VDD _04991_ sky130_fd_sc_hd__nor2_2
X_14075_ _11897_ _04991_ VSS VSS VDD VDD _04992_ sky130_fd_sc_hd__nand2_2
X_14076_ _11906_ _04980_ _04990_ _11910_ _04992_ VSS VSS VDD
+ VDD _04993_ sky130_fd_sc_hd__o221a_1
X_14077_ _11896_ _03648_ _04975_ net752 VSS VSS VDD VDD _04994_
+ sky130_fd_sc_hd__o211ai_1
X_14078_ _11897_ net486 VSS VSS VDD VDD _04995_ sky130_fd_sc_hd__nand2_4
X_14079_ _11906_ net485 _04995_ _03639_ VSS VSS VDD VDD _04996_
+ sky130_fd_sc_hd__o211ai_1
X_14080_ _03667_ _04994_ _04996_ VSS VSS VDD VDD _04997_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_47_1141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14082_ _03667_ _04993_ _04997_ _03656_ VSS VSS VDD VDD _04999_
+ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_47_1140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14084_ net487 net485 VSS VSS VDD VDD _05001_ sky130_fd_sc_hd__nand2_4
X_14085_ _03631_ _03648_ VSS VSS VDD VDD _05002_ sky130_fd_sc_hd__nand2_8
X_14086_ _05001_ _05002_ net488 VSS VSS VDD VDD _05003_ sky130_fd_sc_hd__a21oi_1
X_14087_ net488 _04990_ _05003_ VSS VSS VDD VDD _05004_ sky130_fd_sc_hd__a21oi_1
X_14088_ _03667_ _04935_ _05001_ VSS VSS VDD VDD _05005_ sky130_fd_sc_hd__o21ai_0
X_14089_ net752 _03667_ _04995_ VSS VSS VDD VDD _05006_ sky130_fd_sc_hd__nor3_1
X_14090_ net752 _05005_ _05006_ VSS VSS VDD VDD _05007_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_47_1139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14092_ _03666_ _05004_ _05007_ _03658_ VSS VSS VDD VDD _05009_
+ sky130_fd_sc_hd__o211ai_1
X_14093_ _03684_ _04999_ _05009_ VSS VSS VDD VDD _05010_ sky130_fd_sc_hd__nand3_1
X_14094_ _04987_ _05010_ _03676_ VSS VSS VDD VDD _05011_ sky130_fd_sc_hd__a21oi_1
X_14095_ _03676_ _04942_ _04968_ _05011_ VSS VSS VDD VDD _00016_
+ sky130_fd_sc_hd__a31o_4
X_14096_ _03624_ _04923_ VSS VSS VDD VDD _05012_ sky130_fd_sc_hd__nor2_1
X_14097_ _11897_ _04980_ VSS VSS VDD VDD _05013_ sky130_fd_sc_hd__nor2_1
X_14098_ _03639_ net755 VSS VSS VDD VDD _05014_ sky130_fd_sc_hd__nand2_2
X_14099_ net487 _03648_ VSS VSS VDD VDD _05015_ sky130_fd_sc_hd__nand2_8
X_14100_ _05014_ _05015_ _03625_ VSS VSS VDD VDD _05016_ sky130_fd_sc_hd__a21oi_1
X_14101_ _03667_ _05012_ _05013_ _05016_ VSS VSS VDD VDD _05017_
+ sky130_fd_sc_hd__nor4_1
X_14102_ _03637_ _03648_ VSS VSS VDD VDD _05018_ sky130_fd_sc_hd__nand2_2
X_14103_ _11896_ _05018_ VSS VSS VDD VDD _05019_ sky130_fd_sc_hd__nor2_1
X_14104_ _11903_ net755 VSS VSS VDD VDD _05020_ sky130_fd_sc_hd__nand2_2
X_14105_ _04935_ _05020_ net752 VSS VSS VDD VDD _05021_ sky130_fd_sc_hd__a21oi_1
X_14106_ _03666_ _05019_ _05021_ VSS VSS VDD VDD _05022_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_47_1138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14108_ _05017_ _05022_ _03656_ VSS VSS VDD VDD _05024_ sky130_fd_sc_hd__o21ai_2
X_14109_ _11896_ net485 VSS VSS VDD VDD _05025_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_47_1137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14111_ _03639_ _05002_ _05025_ _04970_ _11898_ VSS VSS VDD
+ VDD _05027_ sky130_fd_sc_hd__a32oi_1
X_14112_ _03658_ _03667_ _05027_ VSS VSS VDD VDD _05028_ sky130_fd_sc_hd__nand3_1
X_14113_ _11903_ _04970_ _03667_ VSS VSS VDD VDD _05029_ sky130_fd_sc_hd__a21oi_1
X_14114_ net488 _04943_ _03656_ VSS VSS VDD VDD _05030_ sky130_fd_sc_hd__a21oi_4
X_14115_ _11897_ net485 VSS VSS VDD VDD _05031_ sky130_fd_sc_hd__nor2_1
X_14116_ _11910_ _03648_ VSS VSS VDD VDD _05032_ sky130_fd_sc_hd__nor2_1
X_14117_ _05031_ _05032_ _03639_ VSS VSS VDD VDD _05033_ sky130_fd_sc_hd__o21ai_0
X_14118_ _05029_ _05030_ _05033_ _03684_ VSS VSS VDD VDD _05034_
+ sky130_fd_sc_hd__a31oi_1
X_14119_ _05024_ _05028_ _05034_ VSS VSS VDD VDD _05035_ sky130_fd_sc_hd__nand3_1
X_14120_ _03625_ _04943_ VSS VSS VDD VDD _05036_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_47_1136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14122_ _04935_ _05025_ VSS VSS VDD VDD _05038_ sky130_fd_sc_hd__nand2_1
X_14123_ _03639_ _05038_ VSS VSS VDD VDD _05039_ sky130_fd_sc_hd__nand2_1
X_14124_ _11910_ net485 VSS VSS VDD VDD _05040_ sky130_fd_sc_hd__nand2b_2
X_14125_ net488 net485 VSS VSS VDD VDD _05041_ sky130_fd_sc_hd__nand2_4
X_14126_ _05041_ _04954_ _03637_ VSS VSS VDD VDD _05042_ sky130_fd_sc_hd__a21oi_1
X_14127_ net752 _05040_ _05015_ _05042_ _03666_ VSS VSS VDD
+ VDD _05043_ sky130_fd_sc_hd__a311oi_4
X_14128_ _03666_ _05036_ _05039_ _05043_ VSS VSS VDD VDD _05044_
+ sky130_fd_sc_hd__a31oi_1
X_14129_ _11896_ net485 _04971_ VSS VSS VDD VDD _05045_ sky130_fd_sc_hd__o21ai_1
X_14130_ _11898_ net485 VSS VSS VDD VDD _05046_ sky130_fd_sc_hd__nand2_1
X_14131_ _04935_ _05046_ net752 VSS VSS VDD VDD _05047_ sky130_fd_sc_hd__a21oi_1
X_14132_ net752 _05045_ _05047_ _03656_ _03667_ VSS VSS VDD
+ VDD _05048_ sky130_fd_sc_hd__a2111oi_0
X_14133_ _03656_ _05044_ _05048_ VSS VSS VDD VDD _05049_ sky130_fd_sc_hd__a21oi_1
X_14134_ _04971_ _04975_ net752 VSS VSS VDD VDD _05050_ sky130_fd_sc_hd__a21oi_1
X_14135_ _11897_ _04970_ VSS VSS VDD VDD _05051_ sky130_fd_sc_hd__nand2_1
X_14136_ _05050_ _05030_ _03667_ _05051_ VSS VSS VDD VDD _05052_
+ sky130_fd_sc_hd__nand4b_1
X_14137_ _03684_ _05049_ _05052_ VSS VSS VDD VDD _05053_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_47_1135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14139_ _11906_ _03637_ _04948_ VSS VSS VDD VDD _05055_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_47_1134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14141_ _11924_ net486 _03667_ VSS VSS VDD VDD _05057_ sky130_fd_sc_hd__nor3_1
X_14142_ net486 _05055_ _05057_ VSS VSS VDD VDD _05058_ sky130_fd_sc_hd__a21oi_1
X_14143_ _11901_ net485 VSS VSS VDD VDD _05059_ sky130_fd_sc_hd__nor2_1
X_14144_ _03639_ _05059_ _05032_ VSS VSS VDD VDD _05060_ sky130_fd_sc_hd__nor3_1
X_14145_ _11896_ _03648_ VSS VSS VDD VDD _05061_ sky130_fd_sc_hd__nand2_2
X_14146_ _04926_ _05061_ net752 VSS VSS VDD VDD _05062_ sky130_fd_sc_hd__a21oi_1
X_14147_ _05060_ _05062_ _03667_ VSS VSS VDD VDD _05063_ sky130_fd_sc_hd__o21ai_0
X_14148_ _05001_ _05002_ _03639_ VSS VSS VDD VDD _05064_ sky130_fd_sc_hd__a21oi_1
X_14149_ _05042_ _05064_ _03666_ VSS VSS VDD VDD _05065_ sky130_fd_sc_hd__o21ai_0
X_14150_ _03658_ _05063_ _05065_ VSS VSS VDD VDD _05066_ sky130_fd_sc_hd__nand3_1
X_14151_ _03658_ _05058_ _05066_ VSS VSS VDD VDD _05067_ sky130_fd_sc_hd__o21ai_0
X_14152_ net487 _03637_ VSS VSS VDD VDD _05068_ sky130_fd_sc_hd__nor2_1
X_14153_ _11903_ _03637_ VSS VSS VDD VDD _05069_ sky130_fd_sc_hd__and2_1
X_14154_ _11915_ _03648_ VSS VSS VDD VDD _05070_ sky130_fd_sc_hd__nand2_1
X_14155_ _03648_ _05068_ _05069_ _05070_ VSS VSS VDD VDD _05071_
+ sky130_fd_sc_hd__o31ai_1
X_14156_ _03666_ _05071_ VSS VSS VDD VDD _05072_ sky130_fd_sc_hd__nand2_1
X_14157_ _11897_ _03648_ VSS VSS VDD VDD _05073_ sky130_fd_sc_hd__nand2_4
X_14158_ _05073_ _05020_ _03637_ VSS VSS VDD VDD _05074_ sky130_fd_sc_hd__a21oi_1
X_14159_ _03666_ _04974_ _05074_ VSS VSS VDD VDD _05075_ sky130_fd_sc_hd__or3_1
X_14160_ _05072_ _05075_ _03656_ VSS VSS VDD VDD _05076_ sky130_fd_sc_hd__a21oi_1
X_14161_ _11901_ _03639_ VSS VSS VDD VDD _05077_ sky130_fd_sc_hd__and2_0
X_14162_ _11903_ _03639_ net486 VSS VSS VDD VDD _05078_ sky130_fd_sc_hd__o21ai_1
X_14163_ _05077_ _05078_ _03656_ VSS VSS VDD VDD _05079_ sky130_fd_sc_hd__o21ai_1
X_14164_ _11897_ net752 VSS VSS VDD VDD _05080_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_47_1133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14166_ _11898_ _03639_ VSS VSS VDD VDD _05082_ sky130_fd_sc_hd__nand2_1
X_14167_ _05080_ _05082_ net486 VSS VSS VDD VDD _05083_ sky130_fd_sc_hd__a21oi_1
X_14168_ _03667_ _05079_ _05083_ VSS VSS VDD VDD _05084_ sky130_fd_sc_hd__nor3_1
X_14169_ net487 _05041_ _03667_ _03656_ VSS VSS VDD VDD _05085_
+ sky130_fd_sc_hd__o211ai_1
X_14170_ net752 _04925_ _04963_ _05085_ VSS VSS VDD VDD _05086_
+ sky130_fd_sc_hd__a31oi_1
X_14171_ _03684_ _05076_ _05084_ _05086_ VSS VSS VDD VDD _05087_
+ sky130_fd_sc_hd__nor4_1
X_14172_ _03684_ _05067_ _05087_ _03676_ VSS VSS VDD VDD _05088_
+ sky130_fd_sc_hd__a211oi_1
X_14173_ _03676_ _05035_ _05053_ _05088_ VSS VSS VDD VDD _00017_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_47_1132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14175_ net487 _03648_ VSS VSS VDD VDD _05090_ sky130_fd_sc_hd__nor2_1
X_14176_ _11912_ _03648_ _05090_ VSS VSS VDD VDD _05091_ sky130_fd_sc_hd__a21oi_1
X_14177_ _04961_ _04995_ net752 VSS VSS VDD VDD _05092_ sky130_fd_sc_hd__a21o_1
X_14178_ _03639_ _05091_ _05092_ VSS VSS VDD VDD _05093_ sky130_fd_sc_hd__o21ai_0
X_14179_ _03624_ _03648_ VSS VSS VDD VDD _05094_ sky130_fd_sc_hd__nor2_2
X_14180_ _11908_ net755 VSS VSS VDD VDD _05095_ sky130_fd_sc_hd__nor2_1
X_14181_ _11898_ net486 VSS VSS VDD VDD _05096_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_47_1131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14183_ net752 _05015_ _05096_ VSS VSS VDD VDD _05098_ sky130_fd_sc_hd__nand3_1
X_14184_ net752 _05094_ _05095_ _05098_ _03676_ VSS VSS VDD
+ VDD _05099_ sky130_fd_sc_hd__o311ai_0
X_14185_ _03676_ _05093_ _05099_ VSS VSS VDD VDD _05100_ sky130_fd_sc_hd__o21ai_0
X_14186_ _11908_ _03648_ VSS VSS VDD VDD _05101_ sky130_fd_sc_hd__nor2_2
X_14187_ _05101_ net752 _05073_ VSS VSS VDD VDD _05102_ sky130_fd_sc_hd__nand3b_1
X_14188_ net752 _05094_ _05031_ _05102_ _03676_ VSS VSS VDD
+ VDD _05103_ sky130_fd_sc_hd__o311ai_0
X_14189_ _11898_ _04923_ VSS VSS VDD VDD _05104_ sky130_fd_sc_hd__nor2_1
X_14190_ _11901_ net485 VSS VSS VDD VDD _05105_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_47_1130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14192_ _05105_ _05061_ _03639_ VSS VSS VDD VDD _05107_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_47_1129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14194_ _05104_ _05107_ _03675_ VSS VSS VDD VDD _05109_ sky130_fd_sc_hd__o21ai_0
X_14195_ _03656_ _05103_ _05109_ VSS VSS VDD VDD _05110_ sky130_fd_sc_hd__nand3_1
X_14196_ _03656_ _05100_ _05110_ VSS VSS VDD VDD _05111_ sky130_fd_sc_hd__o21ai_0
X_14197_ _11896_ _04990_ VSS VSS VDD VDD _05112_ sky130_fd_sc_hd__nor2_1
X_14198_ _03676_ _04981_ _05012_ _05112_ VSS VSS VDD VDD _05113_
+ sky130_fd_sc_hd__nor4_1
X_14199_ _11917_ _03648_ _03675_ _04964_ _05013_ VSS VSS VDD
+ VDD _05114_ sky130_fd_sc_hd__a2111oi_0
X_14200_ _11897_ _03639_ VSS VSS VDD VDD _05115_ sky130_fd_sc_hd__nor2_1
X_14201_ _11922_ net486 VSS VSS VDD VDD _05116_ sky130_fd_sc_hd__nand2_1
X_14202_ net486 _05077_ _05115_ _05116_ _03676_ VSS VSS VDD
+ VDD _05117_ sky130_fd_sc_hd__o311ai_2
X_14203_ _05073_ _05040_ VSS VSS VDD VDD _05118_ sky130_fd_sc_hd__nand2_1
X_14204_ _11903_ _04970_ _05118_ _03639_ _03676_ VSS VSS VDD
+ VDD _05119_ sky130_fd_sc_hd__a221o_1
X_14205_ _03656_ _05117_ _05119_ VSS VSS VDD VDD _05120_ sky130_fd_sc_hd__nand3_1
X_14206_ _03656_ _05113_ _05114_ _03685_ _05120_ VSS VSS VDD
+ VDD _05121_ sky130_fd_sc_hd__o311ai_1
X_14207_ _03685_ _05111_ _05121_ VSS VSS VDD VDD _05122_ sky130_fd_sc_hd__o21ai_1
X_14208_ _11901_ _03639_ _03648_ _04904_ VSS VSS VDD VDD _05123_
+ sky130_fd_sc_hd__o211ai_1
X_14209_ _11917_ _03648_ _03675_ _05123_ VSS VSS VDD VDD _05124_
+ sky130_fd_sc_hd__o211ai_1
X_14210_ _11906_ net486 _05001_ _03639_ VSS VSS VDD VDD _05125_
+ sky130_fd_sc_hd__o211ai_1
X_14211_ _03639_ _05118_ _05125_ _03676_ VSS VSS VDD VDD _05126_
+ sky130_fd_sc_hd__o211ai_1
X_14212_ _11924_ net486 VSS VSS VDD VDD _05127_ sky130_fd_sc_hd__nand2_1
X_14213_ _03624_ _03631_ VSS VSS VDD VDD _05128_ sky130_fd_sc_hd__nand2_1
X_14214_ _03631_ _03639_ _03648_ _05128_ VSS VSS VDD VDD _05129_
+ sky130_fd_sc_hd__o211ai_1
X_14215_ _11920_ _03648_ _04943_ _11901_ _03676_ VSS VSS VDD
+ VDD _05130_ sky130_fd_sc_hd__a221oi_1
X_14216_ _03676_ _05127_ _05129_ _05130_ _03658_ VSS VSS VDD
+ VDD _05131_ sky130_fd_sc_hd__a311oi_1
X_14217_ _03658_ _05124_ _05126_ _03684_ _05131_ VSS VSS VDD
+ VDD _05132_ sky130_fd_sc_hd__a311oi_1
X_14218_ net752 _04954_ _04959_ VSS VSS VDD VDD _05133_ sky130_fd_sc_hd__nand3_1
X_14219_ _03639_ _04925_ _04963_ VSS VSS VDD VDD _05134_ sky130_fd_sc_hd__nand3_1
X_14220_ net752 _05101_ VSS VSS VDD VDD _05135_ sky130_fd_sc_hd__nor2_1
X_14221_ _05002_ _05135_ _05069_ _03675_ VSS VSS VDD VDD _05136_
+ sky130_fd_sc_hd__a211oi_1
X_14222_ _03675_ _05133_ _05134_ _05136_ _03658_ VSS VSS VDD
+ VDD _05137_ sky130_fd_sc_hd__a311o_1
X_14223_ _03624_ net486 VSS VSS VDD VDD _05138_ sky130_fd_sc_hd__nor2_2
X_14224_ net752 _04954_ _05096_ VSS VSS VDD VDD _05139_ sky130_fd_sc_hd__nand3_1
X_14225_ net752 _05138_ _05101_ _05139_ _03676_ VSS VSS VDD
+ VDD _05140_ sky130_fd_sc_hd__o311ai_0
XTAP_TAPCELL_ROW_47_1128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14227_ net752 _04925_ _05096_ VSS VSS VDD VDD _05142_ sky130_fd_sc_hd__nand3_1
X_14228_ _11903_ _03648_ _05015_ _03639_ VSS VSS VDD VDD _05143_
+ sky130_fd_sc_hd__o211ai_1
X_14229_ _03675_ _05142_ _05143_ VSS VSS VDD VDD _05144_ sky130_fd_sc_hd__nand3_1
X_14230_ _03658_ _05140_ _05144_ VSS VSS VDD VDD _05145_ sky130_fd_sc_hd__nand3_1
X_14231_ _05137_ _05145_ _03685_ VSS VSS VDD VDD _05146_ sky130_fd_sc_hd__a21oi_1
X_14232_ _05132_ _05146_ _03666_ VSS VSS VDD VDD _05147_ sky130_fd_sc_hd__o21ai_1
X_14233_ _03666_ _05122_ _05147_ VSS VSS VDD VDD _00018_ sky130_fd_sc_hd__o21ai_4
X_14234_ _11908_ _03648_ VSS VSS VDD VDD _05148_ sky130_fd_sc_hd__nand2_4
X_14235_ _03667_ _04995_ _05148_ VSS VSS VDD VDD _05149_ sky130_fd_sc_hd__nand3_1
X_14236_ _03667_ _04926_ _05149_ _03639_ VSS VSS VDD VDD _05150_
+ sky130_fd_sc_hd__o211ai_1
X_14237_ _03666_ _04961_ _05096_ _03637_ VSS VSS VDD VDD _05151_
+ sky130_fd_sc_hd__o211ai_1
X_14238_ _05150_ _05151_ _03656_ VSS VSS VDD VDD _05152_ sky130_fd_sc_hd__a21oi_1
X_14239_ _11906_ net486 VSS VSS VDD VDD _05153_ sky130_fd_sc_hd__nand2b_2
X_14240_ _04961_ _05025_ _03637_ VSS VSS VDD VDD _05154_ sky130_fd_sc_hd__a21oi_1
X_14241_ net752 _05153_ _05148_ _05154_ VSS VSS VDD VDD _05155_
+ sky130_fd_sc_hd__a31oi_1
X_14242_ _03667_ _05155_ VSS VSS VDD VDD _05156_ sky130_fd_sc_hd__nor2_1
X_14243_ _03631_ _04980_ _04923_ _11910_ VSS VSS VDD VDD _05157_
+ sky130_fd_sc_hd__o22ai_1
X_14244_ _03639_ _04963_ _03625_ VSS VSS VDD VDD _05158_ sky130_fd_sc_hd__a21oi_1
X_14245_ _03666_ _05157_ _05158_ VSS VSS VDD VDD _05159_ sky130_fd_sc_hd__nor3_1
X_14246_ _03658_ _05156_ _05159_ VSS VSS VDD VDD _05160_ sky130_fd_sc_hd__nor3_1
X_14247_ _05152_ _05160_ _03684_ VSS VSS VDD VDD _05161_ sky130_fd_sc_hd__o21ai_1
X_14248_ net488 _05002_ VSS VSS VDD VDD _05162_ sky130_fd_sc_hd__nor2_2
X_14249_ _11906_ _04943_ _05162_ VSS VSS VDD VDD _05163_ sky130_fd_sc_hd__a21oi_1
X_14250_ _03667_ _05092_ _05163_ VSS VSS VDD VDD _05164_ sky130_fd_sc_hd__nand3_1
X_14251_ _03639_ _04959_ _05015_ VSS VSS VDD VDD _05165_ sky130_fd_sc_hd__nand3_1
X_14252_ _11898_ net755 VSS VSS VDD VDD _05166_ sky130_fd_sc_hd__nor2_1
X_14253_ _05101_ _05166_ net752 VSS VSS VDD VDD _05167_ sky130_fd_sc_hd__o21ai_0
X_14254_ _03666_ _05165_ _05167_ VSS VSS VDD VDD _05168_ sky130_fd_sc_hd__nand3_1
X_14255_ _05164_ _05168_ _03656_ VSS VSS VDD VDD _05169_ sky130_fd_sc_hd__a21oi_1
X_14256_ _11901_ _04970_ VSS VSS VDD VDD _05170_ sky130_fd_sc_hd__nand2_1
X_14257_ _03625_ _03637_ VSS VSS VDD VDD _05171_ sky130_fd_sc_hd__nor2_4
X_14258_ _03624_ _03631_ VSS VSS VDD VDD _05172_ sky130_fd_sc_hd__nor2_1
X_14259_ _05171_ _05172_ net755 VSS VSS VDD VDD _05173_ sky130_fd_sc_hd__o21ai_2
X_14260_ _03637_ _04925_ _04959_ VSS VSS VDD VDD _05174_ sky130_fd_sc_hd__nand3_1
X_14261_ _11906_ _03648_ VSS VSS VDD VDD _05175_ sky130_fd_sc_hd__nand2_1
X_14262_ _03639_ _05025_ _05175_ VSS VSS VDD VDD _05176_ sky130_fd_sc_hd__nand3_1
X_14263_ _05174_ _05176_ _03666_ VSS VSS VDD VDD _05177_ sky130_fd_sc_hd__a21oi_1
X_14264_ _03666_ _05170_ _05173_ _05177_ VSS VSS VDD VDD _05178_
+ sky130_fd_sc_hd__a31oi_1
X_14265_ _03658_ _05178_ VSS VSS VDD VDD _05179_ sky130_fd_sc_hd__nor2_1
X_14266_ _05169_ _05179_ _03685_ VSS VSS VDD VDD _05180_ sky130_fd_sc_hd__o21ai_2
X_14267_ _03666_ _04959_ _04982_ VSS VSS VDD VDD _05181_ sky130_fd_sc_hd__o21ai_0
X_14268_ _03639_ _05181_ _03656_ VSS VSS VDD VDD _05182_ sky130_fd_sc_hd__a21oi_1
X_14269_ _04935_ _05153_ _03639_ VSS VSS VDD VDD _05183_ sky130_fd_sc_hd__a21oi_1
X_14270_ _03631_ _04989_ _05183_ VSS VSS VDD VDD _05184_ sky130_fd_sc_hd__a21oi_1
X_14271_ _05182_ _05184_ _03667_ VSS VSS VDD VDD _05185_ sky130_fd_sc_hd__a21oi_1
X_14272_ _03624_ _03666_ _04961_ _04959_ _03639_ VSS VSS VDD
+ VDD _05186_ sky130_fd_sc_hd__o2111ai_1
X_14273_ net488 _04989_ VSS VSS VDD VDD _05187_ sky130_fd_sc_hd__nand2_1
X_14274_ _11908_ _04990_ VSS VSS VDD VDD _05188_ sky130_fd_sc_hd__nand2_1
X_14275_ _03656_ _05186_ _05187_ _05188_ _05182_ VSS VSS VDD
+ VDD _05189_ sky130_fd_sc_hd__a41oi_1
X_14276_ _05094_ _05166_ _05171_ VSS VSS VDD VDD _05190_ sky130_fd_sc_hd__nor3_1
X_14277_ _03667_ _05190_ VSS VSS VDD VDD _05191_ sky130_fd_sc_hd__nor2_1
X_14278_ _03656_ _05186_ _05191_ _03685_ VSS VSS VDD VDD _05192_
+ sky130_fd_sc_hd__a31oi_1
X_14279_ _05185_ _05189_ _05192_ VSS VSS VDD VDD _05193_ sky130_fd_sc_hd__o21ai_1
X_14280_ _11897_ net755 _05166_ net752 VSS VSS VDD VDD _05194_
+ sky130_fd_sc_hd__a211oi_1
X_14281_ _03637_ _04954_ _04963_ _05194_ VSS VSS VDD VDD _05195_
+ sky130_fd_sc_hd__a31oi_2
X_14282_ net487 _04926_ _04992_ VSS VSS VDD VDD _05196_ sky130_fd_sc_hd__o21ai_0
X_14283_ _05041_ _05015_ _03639_ VSS VSS VDD VDD _05197_ sky130_fd_sc_hd__a21oi_1
X_14284_ _03658_ _03667_ _05196_ _05197_ VSS VSS VDD VDD _05198_
+ sky130_fd_sc_hd__nor4_1
X_14285_ _03656_ _03667_ _05195_ _05198_ VSS VSS VDD VDD _05199_
+ sky130_fd_sc_hd__a31oi_1
X_14286_ _11917_ _03648_ _05171_ _05018_ _11897_ VSS VSS VDD
+ VDD _05200_ sky130_fd_sc_hd__o32ai_4
X_14287_ _05041_ _04935_ _03639_ VSS VSS VDD VDD _05201_ sky130_fd_sc_hd__a21oi_1
X_14288_ _04975_ _05153_ net752 VSS VSS VDD VDD _05202_ sky130_fd_sc_hd__a21oi_1
X_14289_ _05201_ _05202_ _03667_ VSS VSS VDD VDD _05203_ sky130_fd_sc_hd__o21ai_1
X_14290_ _03667_ _05200_ _05203_ _03658_ VSS VSS VDD VDD _05204_
+ sky130_fd_sc_hd__o211ai_1
X_14291_ _03685_ _05199_ _05204_ _03676_ VSS VSS VDD VDD _05205_
+ sky130_fd_sc_hd__a31oi_2
X_14292_ _03676_ _05161_ _05180_ _05193_ _05205_ VSS VSS VDD
+ VDD _00019_ sky130_fd_sc_hd__a32oi_4
X_14293_ _03637_ _05094_ _04980_ _11898_ VSS VSS VDD VDD _05206_
+ sky130_fd_sc_hd__o22ai_1
X_14294_ _03658_ _05206_ VSS VSS VDD VDD _05207_ sky130_fd_sc_hd__nor2_1
X_14295_ _11903_ _03648_ _05032_ _03637_ VSS VSS VDD VDD _05208_
+ sky130_fd_sc_hd__a211oi_1
X_14296_ _03656_ _05064_ _05208_ VSS VSS VDD VDD _05209_ sky130_fd_sc_hd__nor3_1
X_14297_ _05207_ _05209_ _03666_ VSS VSS VDD VDD _05210_ sky130_fd_sc_hd__o21ai_0
X_14298_ _11903_ _03639_ _05115_ VSS VSS VDD VDD _05211_ sky130_fd_sc_hd__a21oi_1
X_14299_ _03648_ _05211_ _04949_ VSS VSS VDD VDD _05212_ sky130_fd_sc_hd__o21ai_1
X_14300_ _03639_ _03656_ _05045_ _05212_ _03667_ VSS VSS VDD
+ VDD _05213_ sky130_fd_sc_hd__o311ai_0
X_14301_ _11910_ _04980_ VSS VSS VDD VDD _05214_ sky130_fd_sc_hd__nor2_1
X_14302_ _04971_ _04961_ _03637_ VSS VSS VDD VDD _05215_ sky130_fd_sc_hd__a21oi_1
X_14303_ _03667_ _05162_ _05214_ _05215_ VSS VSS VDD VDD _05216_
+ sky130_fd_sc_hd__nor4_1
X_14304_ _05025_ _05051_ _03666_ VSS VSS VDD VDD _05217_ sky130_fd_sc_hd__a21oi_1
X_14305_ _05216_ _05217_ _03656_ VSS VSS VDD VDD _05218_ sky130_fd_sc_hd__o21ai_0
X_14306_ _03639_ _05001_ net488 VSS VSS VDD VDD _05219_ sky130_fd_sc_hd__a21oi_1
X_14307_ _03666_ _04961_ VSS VSS VDD VDD _05220_ sky130_fd_sc_hd__nand2_1
X_14308_ _04931_ _05015_ net752 _03666_ VSS VSS VDD VDD _05221_
+ sky130_fd_sc_hd__a211oi_1
X_14309_ _11908_ _04970_ _05221_ VSS VSS VDD VDD _05222_ sky130_fd_sc_hd__a21oi_1
X_14310_ _04899_ _05219_ _05220_ _05222_ _03658_ VSS VSS VDD
+ VDD _05223_ sky130_fd_sc_hd__o311ai_1
X_14311_ _05218_ _05223_ _03676_ VSS VSS VDD VDD _05224_ sky130_fd_sc_hd__a21oi_1
X_14312_ _03676_ _05210_ _05213_ _05224_ VSS VSS VDD VDD _05225_
+ sky130_fd_sc_hd__a31o_1
X_14313_ _11926_ _03648_ VSS VSS VDD VDD _05226_ sky130_fd_sc_hd__nand2_1
X_14314_ _03656_ _03676_ _05226_ VSS VSS VDD VDD _05227_ sky130_fd_sc_hd__nand3_1
X_14315_ _05171_ _05214_ _05227_ VSS VSS VDD VDD _05228_ sky130_fd_sc_hd__nor3_1
X_14316_ _03666_ _05228_ VSS VSS VDD VDD _05229_ sky130_fd_sc_hd__nor2_1
X_14317_ _04995_ _05148_ _03639_ VSS VSS VDD VDD _05230_ sky130_fd_sc_hd__a21oi_1
X_14318_ _03639_ _04925_ _05096_ _05230_ VSS VSS VDD VDD _05231_
+ sky130_fd_sc_hd__a31oi_2
X_14319_ _03637_ _03675_ _05073_ _05020_ VSS VSS VDD VDD _05232_
+ sky130_fd_sc_hd__nand4_1
X_14320_ _03648_ _03675_ _11908_ VSS VSS VDD VDD _05233_ sky130_fd_sc_hd__o21ai_0
X_14321_ _03639_ _03676_ _05233_ VSS VSS VDD VDD _05234_ sky130_fd_sc_hd__o21ai_0
X_14322_ _11912_ _03648_ _03639_ VSS VSS VDD VDD _05235_ sky130_fd_sc_hd__o21ai_0
X_14323_ _03675_ _05235_ _03658_ VSS VSS VDD VDD _05236_ sky130_fd_sc_hd__o21ai_0
X_14324_ _05232_ _05234_ _05236_ VSS VSS VDD VDD _05237_ sky130_fd_sc_hd__a21oi_1
X_14325_ _03656_ _03675_ _05231_ _05237_ VSS VSS VDD VDD _05238_
+ sky130_fd_sc_hd__a31oi_4
X_14326_ _03631_ _03639_ _05138_ VSS VSS VDD VDD _05239_ sky130_fd_sc_hd__o21ai_0
X_14327_ _04943_ _05171_ net487 VSS VSS VDD VDD _05240_ sky130_fd_sc_hd__o21ai_0
X_14328_ _11910_ _04970_ _05068_ _03656_ VSS VSS VDD VDD _05241_
+ sky130_fd_sc_hd__a211oi_1
X_14329_ _03656_ _05239_ _05240_ _05241_ VSS VSS VDD VDD _05242_
+ sky130_fd_sc_hd__a31oi_1
X_14330_ _05041_ _04899_ _03676_ VSS VSS VDD VDD _05243_ sky130_fd_sc_hd__o21ai_1
X_14331_ _11903_ _03648_ _04925_ VSS VSS VDD VDD _05244_ sky130_fd_sc_hd__o21ai_0
X_14332_ _05002_ _05096_ _03639_ VSS VSS VDD VDD _05245_ sky130_fd_sc_hd__a21oi_1
X_14333_ _03639_ _05244_ _05245_ VSS VSS VDD VDD _05246_ sky130_fd_sc_hd__a21oi_1
X_14334_ _03630_ _03639_ _03648_ VSS VSS VDD VDD _05247_ sky130_fd_sc_hd__o21ai_0
X_14335_ _11910_ _03639_ _05247_ VSS VSS VDD VDD _05248_ sky130_fd_sc_hd__a21oi_1
X_14336_ _03656_ _05246_ _05248_ _05079_ VSS VSS VDD VDD _05249_
+ sky130_fd_sc_hd__o22ai_1
X_14337_ _05242_ _05243_ _05249_ _03676_ VSS VSS VDD VDD _05250_
+ sky130_fd_sc_hd__o22ai_2
X_14338_ _05229_ _05238_ _05250_ _03666_ _03684_ VSS VSS VDD
+ VDD _05251_ sky130_fd_sc_hd__a221oi_4
X_14339_ _03684_ _05225_ _05251_ VSS VSS VDD VDD _00020_ sky130_fd_sc_hd__a21oi_4
X_14340_ _05101_ _03639_ _04925_ VSS VSS VDD VDD _05252_ sky130_fd_sc_hd__nor3b_1
X_14341_ net752 _05031_ _05090_ VSS VSS VDD VDD _05253_ sky130_fd_sc_hd__nor3_1
X_14342_ _05252_ _05253_ _03676_ VSS VSS VDD VDD _05254_ sky130_fd_sc_hd__o21ai_0
X_14343_ _11898_ _05018_ _05069_ _03648_ _03675_ VSS VSS VDD
+ VDD _05255_ sky130_fd_sc_hd__o221ai_1
X_14344_ _03625_ _05001_ VSS VSS VDD VDD _05256_ sky130_fd_sc_hd__nand2_1
X_14345_ _11901_ _04943_ _05154_ _03676_ VSS VSS VDD VDD _05257_
+ sky130_fd_sc_hd__a211oi_1
X_14346_ _03676_ _05187_ _05256_ _05257_ _03658_ VSS VSS VDD
+ VDD _05258_ sky130_fd_sc_hd__a311oi_1
X_14347_ _03658_ _05254_ _05255_ _05258_ VSS VSS VDD VDD _05259_
+ sky130_fd_sc_hd__a31oi_1
X_14348_ _03685_ _05259_ VSS VSS VDD VDD _05260_ sky130_fd_sc_hd__nor2_1
X_14349_ _05101_ _03637_ _04954_ VSS VSS VDD VDD _05261_ sky130_fd_sc_hd__nand3b_1
X_14350_ _03639_ _04961_ _05105_ VSS VSS VDD VDD _05262_ sky130_fd_sc_hd__nand3_1
X_14351_ _03658_ _05261_ _05262_ VSS VSS VDD VDD _05263_ sky130_fd_sc_hd__nand3_1
X_14352_ _11898_ _03637_ VSS VSS VDD VDD _05264_ sky130_fd_sc_hd__nand2_1
X_14353_ _11903_ _03639_ _05264_ VSS VSS VDD VDD _05265_ sky130_fd_sc_hd__a21boi_0
X_14354_ net486 _05265_ _04901_ VSS VSS VDD VDD _05266_ sky130_fd_sc_hd__o21ai_1
X_14355_ net486 _03658_ VSS VSS VDD VDD _05267_ sky130_fd_sc_hd__nor2_1
X_14356_ _03656_ _05041_ VSS VSS VDD VDD _05268_ sky130_fd_sc_hd__nor2_1
X_14357_ _05267_ _05268_ net487 VSS VSS VDD VDD _05269_ sky130_fd_sc_hd__o21ai_0
X_14358_ _03631_ _03658_ _04980_ VSS VSS VDD VDD _05270_ sky130_fd_sc_hd__o21ai_0
X_14359_ _03648_ _03658_ VSS VSS VDD VDD _05271_ sky130_fd_sc_hd__nor2_1
X_14360_ net485 _03656_ VSS VSS VDD VDD _05272_ sky130_fd_sc_hd__nor2_1
X_14361_ _03625_ _05270_ _05271_ _04899_ _05272_ _05055_ VSS
+ VSS VDD VDD _05273_ sky130_fd_sc_hd__a222oi_1
X_14362_ _05269_ _05273_ _03676_ VSS VSS VDD VDD _05274_ sky130_fd_sc_hd__a21oi_2
X_14363_ _03676_ _05263_ _05266_ _03684_ _05274_ VSS VSS VDD
+ VDD _05275_ sky130_fd_sc_hd__a311oi_4
X_14364_ _11896_ _03639_ net486 VSS VSS VDD VDD _05276_ sky130_fd_sc_hd__nand3_1
X_14365_ _03637_ _05096_ _05175_ VSS VSS VDD VDD _05277_ sky130_fd_sc_hd__nand3_1
X_14366_ _05073_ _04959_ net752 VSS VSS VDD VDD _05278_ sky130_fd_sc_hd__a21o_1
X_14367_ _05277_ _05278_ _03656_ VSS VSS VDD VDD _05279_ sky130_fd_sc_hd__a21oi_1
X_14368_ _03656_ _05175_ _05276_ _05279_ _03676_ VSS VSS VDD
+ VDD _05280_ sky130_fd_sc_hd__a311oi_1
X_14369_ net488 _03637_ VSS VSS VDD VDD _05281_ sky130_fd_sc_hd__nor2_1
X_14370_ _05078_ _05281_ _04949_ VSS VSS VDD VDD _05282_ sky130_fd_sc_hd__o21ai_2
X_14371_ _11896_ _05014_ _05277_ _03658_ VSS VSS VDD VDD _05283_
+ sky130_fd_sc_hd__o211ai_1
X_14372_ _05282_ _05283_ _03675_ VSS VSS VDD VDD _05284_ sky130_fd_sc_hd__a21oi_1
X_14373_ _05280_ _05284_ _03684_ VSS VSS VDD VDD _05285_ sky130_fd_sc_hd__o21ai_0
X_14374_ _03639_ _05020_ VSS VSS VDD VDD _05286_ sky130_fd_sc_hd__nand2_1
X_14375_ _04925_ _05286_ _03675_ VSS VSS VDD VDD _05287_ sky130_fd_sc_hd__a21oi_1
X_14376_ _04971_ _05073_ _03639_ VSS VSS VDD VDD _05288_ sky130_fd_sc_hd__a21oi_1
X_14377_ _03631_ _04989_ _05288_ _03676_ VSS VSS VDD VDD _05289_
+ sky130_fd_sc_hd__a211oi_1
X_14378_ _04975_ _05046_ _03639_ VSS VSS VDD VDD _05290_ sky130_fd_sc_hd__a21oi_1
X_14379_ _11897_ _04923_ _03675_ VSS VSS VDD VDD _05291_ sky130_fd_sc_hd__o21ai_0
X_14380_ _03639_ _04961_ VSS VSS VDD VDD _05292_ sky130_fd_sc_hd__nor2_1
X_14381_ _03639_ _04995_ _05148_ _05292_ VSS VSS VDD VDD _05293_
+ sky130_fd_sc_hd__a31oi_1
X_14382_ _05290_ _05291_ _05293_ _03675_ _03656_ VSS VSS VDD
+ VDD _05294_ sky130_fd_sc_hd__o221ai_1
X_14383_ _03656_ _05287_ _05289_ _03685_ _05294_ VSS VSS VDD
+ VDD _05295_ sky130_fd_sc_hd__o311ai_0
X_14384_ _03666_ _05285_ _05295_ VSS VSS VDD VDD _05296_ sky130_fd_sc_hd__nand3_1
X_14385_ _03666_ _05260_ _05275_ _05296_ VSS VSS VDD VDD _00021_
+ sky130_fd_sc_hd__o31ai_4
X_14386_ _03639_ _04972_ _05165_ VSS VSS VDD VDD _05297_ sky130_fd_sc_hd__o21ai_1
X_14387_ _05018_ _05014_ VSS VSS VDD VDD _05298_ sky130_fd_sc_hd__nand2_1
X_14388_ _11901_ _04923_ VSS VSS VDD VDD _05299_ sky130_fd_sc_hd__nor2_1
X_14389_ _03625_ _05298_ _05013_ _05299_ _03667_ VSS VSS VDD
+ VDD _05300_ sky130_fd_sc_hd__a2111oi_0
X_14390_ _03667_ _05297_ _05300_ _03658_ VSS VSS VDD VDD _05301_
+ sky130_fd_sc_hd__a211oi_1
X_14391_ _05002_ _05153_ _03639_ VSS VSS VDD VDD _05302_ sky130_fd_sc_hd__a21oi_1
X_14392_ _11897_ _03637_ net486 _04907_ VSS VSS VDD VDD _05303_
+ sky130_fd_sc_hd__o211ai_1
X_14393_ _11920_ net486 _03667_ _05303_ VSS VSS VDD VDD _05304_
+ sky130_fd_sc_hd__o211ai_1
X_14394_ _03667_ _05299_ _05302_ _05304_ _03658_ VSS VSS VDD
+ VDD _05305_ sky130_fd_sc_hd__o311a_1
X_14395_ _05301_ _05305_ _03685_ VSS VSS VDD VDD _05306_ sky130_fd_sc_hd__o21ai_1
X_14396_ _11903_ _03639_ VSS VSS VDD VDD _05307_ sky130_fd_sc_hd__nor2_1
X_14397_ _05077_ _05307_ _03648_ VSS VSS VDD VDD _05308_ sky130_fd_sc_hd__o21ai_0
X_14398_ _11908_ _03639_ net486 _04904_ VSS VSS VDD VDD _05309_
+ sky130_fd_sc_hd__o211ai_1
X_14399_ _11916_ net486 _03667_ _05309_ VSS VSS VDD VDD _05310_
+ sky130_fd_sc_hd__o211ai_1
X_14400_ _03667_ _05308_ _05310_ VSS VSS VDD VDD _05311_ sky130_fd_sc_hd__o21ai_0
X_14401_ _03656_ _05311_ VSS VSS VDD VDD _05312_ sky130_fd_sc_hd__nand2_1
X_14402_ _11897_ net752 _05264_ VSS VSS VDD VDD _05313_ sky130_fd_sc_hd__o21ai_0
X_14403_ _03648_ _05313_ VSS VSS VDD VDD _05314_ sky130_fd_sc_hd__nand2_1
X_14404_ net752 _05153_ _05148_ _04991_ _03631_ VSS VSS VDD
+ VDD _05315_ sky130_fd_sc_hd__a32oi_1
X_14405_ _03656_ _03667_ _05315_ VSS VSS VDD VDD _05316_ sky130_fd_sc_hd__nor3_1
X_14406_ _03667_ _05030_ _05314_ _05316_ VSS VSS VDD VDD _05317_
+ sky130_fd_sc_hd__a31oi_1
X_14407_ _03684_ _05312_ _05317_ VSS VSS VDD VDD _05318_ sky130_fd_sc_hd__nand3_2
X_14408_ _11908_ _03648_ _05061_ VSS VSS VDD VDD _05319_ sky130_fd_sc_hd__o21ai_0
X_14409_ _11912_ net755 _05096_ _03639_ VSS VSS VDD VDD _05320_
+ sky130_fd_sc_hd__o211ai_1
X_14410_ _03639_ _05319_ _05320_ VSS VSS VDD VDD _05321_ sky130_fd_sc_hd__o21ai_0
X_14411_ _03630_ _04970_ _05015_ _03625_ _03667_ VSS VSS VDD
+ VDD _05322_ sky130_fd_sc_hd__o221ai_1
X_14412_ _03667_ _05321_ _05322_ VSS VSS VDD VDD _05323_ sky130_fd_sc_hd__o21ai_0
X_14413_ _03658_ _05323_ VSS VSS VDD VDD _05324_ sky130_fd_sc_hd__nor2_1
X_14414_ _11908_ _04991_ _05298_ _03625_ _05013_ VSS VSS VDD
+ VDD _05325_ sky130_fd_sc_hd__a221oi_1
X_14415_ _05040_ _05148_ _03637_ VSS VSS VDD VDD _05326_ sky130_fd_sc_hd__a21oi_1
X_14416_ _11912_ _04970_ _05326_ _03666_ VSS VSS VDD VDD _05327_
+ sky130_fd_sc_hd__a211oi_1
X_14417_ _03666_ _05325_ _05327_ _03656_ VSS VSS VDD VDD _05328_
+ sky130_fd_sc_hd__a211oi_1
X_14418_ _05324_ _05328_ _03685_ VSS VSS VDD VDD _05329_ sky130_fd_sc_hd__o21ai_1
X_14419_ _03624_ _03637_ _04907_ VSS VSS VDD VDD _05330_ sky130_fd_sc_hd__o21ai_0
X_14420_ net486 _05330_ VSS VSS VDD VDD _05331_ sky130_fd_sc_hd__nand2_1
X_14421_ _03625_ _03639_ _05014_ _11898_ VSS VSS VDD VDD _05332_
+ sky130_fd_sc_hd__o22ai_1
X_14422_ _03666_ _05162_ _05332_ VSS VSS VDD VDD _05333_ sky130_fd_sc_hd__nor3_1
X_14423_ _03666_ _05070_ _05331_ _05333_ VSS VSS VDD VDD _05334_
+ sky130_fd_sc_hd__a31oi_1
X_14424_ _03639_ _05138_ net487 VSS VSS VDD VDD _05335_ sky130_fd_sc_hd__o21ai_0
X_14425_ _11901_ _04943_ _04991_ _03624_ VSS VSS VDD VDD _05336_
+ sky130_fd_sc_hd__a22oi_1
X_14426_ _03639_ _05138_ _03666_ VSS VSS VDD VDD _05337_ sky130_fd_sc_hd__o21ai_0
X_14427_ _03639_ _04995_ _05148_ _05337_ VSS VSS VDD VDD _05338_
+ sky130_fd_sc_hd__a31oi_1
X_14428_ _03667_ _05335_ _05336_ _05338_ _03658_ VSS VSS VDD
+ VDD _05339_ sky130_fd_sc_hd__a311oi_1
X_14429_ _03658_ _05334_ _05339_ VSS VSS VDD VDD _05340_ sky130_fd_sc_hd__a21oi_1
X_14430_ _03684_ _05340_ _03675_ VSS VSS VDD VDD _05341_ sky130_fd_sc_hd__a21oi_1
X_14431_ _03675_ _05306_ _05318_ _05329_ _05341_ VSS VSS VDD
+ VDD _00022_ sky130_fd_sc_hd__a32oi_4
X_14432_ _05105_ _04954_ _03637_ VSS VSS VDD VDD _05342_ sky130_fd_sc_hd__a21oi_1
X_14433_ _11896_ _03648_ _05148_ net752 VSS VSS VDD VDD _05343_
+ sky130_fd_sc_hd__o211ai_1
X_14434_ net752 _05138_ _05090_ _05343_ _03676_ VSS VSS VDD
+ VDD _05344_ sky130_fd_sc_hd__o311ai_2
X_14435_ _03676_ _05064_ _05342_ _05344_ _03658_ VSS VSS VDD
+ VDD _05345_ sky130_fd_sc_hd__o311ai_0
X_14436_ _11896_ net485 _04971_ _03639_ VSS VSS VDD VDD _05346_
+ sky130_fd_sc_hd__o22ai_1
X_14437_ _03637_ _05025_ _05175_ VSS VSS VDD VDD _05347_ sky130_fd_sc_hd__nand3_1
X_14438_ _03676_ _05033_ _05347_ VSS VSS VDD VDD _05348_ sky130_fd_sc_hd__nand3_1
X_14439_ _03676_ _05346_ _05348_ VSS VSS VDD VDD _05349_ sky130_fd_sc_hd__o21ai_0
X_14440_ _03656_ _05349_ VSS VSS VDD VDD _05350_ sky130_fd_sc_hd__nand2_1
X_14441_ _03685_ _05345_ _05350_ VSS VSS VDD VDD _05351_ sky130_fd_sc_hd__nand3_1
X_14442_ net752 _04926_ _05061_ _04976_ VSS VSS VDD VDD _05352_
+ sky130_fd_sc_hd__a31oi_1
X_14443_ _03656_ _05352_ VSS VSS VDD VDD _05353_ sky130_fd_sc_hd__nor2_1
X_14444_ _05002_ _05096_ _03637_ VSS VSS VDD VDD _05354_ sky130_fd_sc_hd__a21oi_1
X_14445_ _11908_ _05018_ VSS VSS VDD VDD _05355_ sky130_fd_sc_hd__nor2_1
X_14446_ _03658_ _05354_ _05355_ VSS VSS VDD VDD _05356_ sky130_fd_sc_hd__nor3_2
X_14447_ _03639_ _05271_ _04970_ VSS VSS VDD VDD _05357_ sky130_fd_sc_hd__a21oi_1
X_14448_ _11896_ _03639_ _03648_ _03658_ VSS VSS VDD VDD _05358_
+ sky130_fd_sc_hd__nor4_1
X_14449_ _05281_ _05272_ _05358_ VSS VSS VDD VDD _05359_ sky130_fd_sc_hd__a21oi_1
X_14450_ net488 _03631_ _05267_ _05268_ VSS VSS VDD VDD _05360_
+ sky130_fd_sc_hd__a31oi_2
X_14451_ _03631_ _05357_ _05359_ _03675_ _05360_ VSS VSS VDD
+ VDD _05361_ sky130_fd_sc_hd__o2111ai_4
X_14452_ _03675_ _05353_ _05356_ _05361_ _03684_ VSS VSS VDD
+ VDD _05362_ sky130_fd_sc_hd__o311ai_4
X_14453_ _11898_ _04923_ _04990_ _11897_ _05036_ VSS VSS VDD
+ VDD _05363_ sky130_fd_sc_hd__o221ai_1
X_14454_ _04961_ _05046_ net752 VSS VSS VDD VDD _05364_ sky130_fd_sc_hd__a21oi_1
X_14455_ _11917_ _03648_ _04943_ _11908_ VSS VSS VDD VDD _05365_
+ sky130_fd_sc_hd__a22o_1
X_14456_ _03658_ _05364_ _05365_ VSS VSS VDD VDD _05366_ sky130_fd_sc_hd__nor3_1
X_14457_ _03658_ _05363_ _05366_ _03675_ VSS VSS VDD VDD _05367_
+ sky130_fd_sc_hd__a211o_1
X_14458_ _11901_ _03648_ _03658_ VSS VSS VDD VDD _05368_ sky130_fd_sc_hd__nand3_1
X_14459_ _03639_ _04995_ _05368_ VSS VSS VDD VDD _05369_ sky130_fd_sc_hd__nand3_1
X_14460_ _03639_ _03656_ _05369_ VSS VSS VDD VDD _05370_ sky130_fd_sc_hd__o21ai_0
X_14461_ _04943_ _05267_ _11896_ VSS VSS VDD VDD _05371_ sky130_fd_sc_hd__o21ai_0
X_14462_ _03675_ _05370_ _05371_ VSS VSS VDD VDD _05372_ sky130_fd_sc_hd__nand3_1
X_14463_ _05367_ _05372_ _03685_ VSS VSS VDD VDD _05373_ sky130_fd_sc_hd__a21oi_1
X_14464_ _11897_ _03639_ VSS VSS VDD VDD _05374_ sky130_fd_sc_hd__xnor2_1
X_14465_ net486 _05374_ _05116_ _05030_ _03675_ VSS VSS VDD
+ VDD _05375_ sky130_fd_sc_hd__o2111ai_1
X_14466_ _04946_ _05115_ net486 VSS VSS VDD VDD _05376_ sky130_fd_sc_hd__o21ai_0
X_14467_ _05226_ _05376_ VSS VSS VDD VDD _05377_ sky130_fd_sc_hd__nand2_1
X_14468_ _11912_ net755 _03639_ VSS VSS VDD VDD _05378_ sky130_fd_sc_hd__a21oi_1
X_14469_ _11910_ _03639_ _05002_ _05378_ _03675_ VSS VSS VDD
+ VDD _05379_ sky130_fd_sc_hd__a221oi_1
X_14470_ _03675_ _05377_ _05379_ _03658_ VSS VSS VDD VDD _05380_
+ sky130_fd_sc_hd__a211o_1
X_14471_ _05172_ _05247_ _03658_ _03676_ _05020_ VSS VSS VDD
+ VDD _05381_ sky130_fd_sc_hd__o2111ai_1
X_14472_ _03685_ _05375_ _05380_ _05381_ VSS VSS VDD VDD _05382_
+ sky130_fd_sc_hd__and4_1
X_14473_ _03667_ _05373_ _05382_ VSS VSS VDD VDD _05383_ sky130_fd_sc_hd__nor3_2
X_14474_ _03667_ _05351_ _05362_ _05383_ VSS VSS VDD VDD _00023_
+ sky130_fd_sc_hd__a31oi_4
XTAP_TAPCELL_ROW_46_1127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14482_ _03817_ _03824_ VSS VSS VDD VDD _05388_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_46_1120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14487_ _03773_ _03792_ VSS VSS VDD VDD _05393_ sky130_fd_sc_hd__nand2_2
X_14488_ _03772_ net479 VSS VSS VDD VDD _05394_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_46_1116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14490_ _05393_ _05394_ net481 VSS VSS VDD VDD _05396_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_46_1115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14492_ _11944_ _03792_ VSS VSS VDD VDD _05398_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_46_1114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14495_ _11935_ net478 VSS VSS VDD VDD _05401_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_46_1112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14498_ _05398_ _05401_ _03784_ VSS VSS VDD VDD _05404_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_46_1110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14501_ _05396_ _05404_ _03809_ VSS VSS VDD VDD _05407_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_46_1108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14503_ _11935_ _03792_ VSS VSS VDD VDD _05409_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_46_1107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14505_ _11946_ _03792_ VSS VSS VDD VDD _05411_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_46_1106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14507_ net482 net477 VSS VSS VDD VDD _05413_ sky130_fd_sc_hd__nor2_8
X_14508_ _11942_ _05413_ _03809_ VSS VSS VDD VDD _05414_ sky130_fd_sc_hd__a21oi_2
X_14509_ _03784_ _05409_ _05411_ _05414_ VSS VSS VDD VDD _05415_
+ sky130_fd_sc_hd__o31ai_1
X_14510_ net476 _05407_ _05415_ VSS VSS VDD VDD _05416_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_46_1105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14512_ _03784_ net477 VSS VSS VDD VDD _05418_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_46_1104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14514_ _11935_ _03792_ VSS VSS VDD VDD _05420_ sky130_fd_sc_hd__nor2_1
X_14515_ _11946_ _03792_ _05420_ VSS VSS VDD VDD _05421_ sky130_fd_sc_hd__a21oi_1
X_14516_ _11940_ _05418_ _05421_ _03784_ _03810_ VSS VSS VDD
+ VDD _05422_ sky130_fd_sc_hd__o221ai_2
X_14517_ net480 _03792_ VSS VSS VDD VDD _05423_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_45_1103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14520_ _11951_ _03792_ _05423_ _11931_ _03810_ VSS VSS VDD
+ VDD _05426_ sky130_fd_sc_hd__a221o_1
X_14521_ _03801_ _05422_ _05426_ VSS VSS VDD VDD _05427_ sky130_fd_sc_hd__nand3_1
X_14522_ _00398_ _03824_ VSS VSS VDD VDD _05428_ sky130_fd_sc_hd__nand2_4
X_14523_ net477 net476 VSS VSS VDD VDD _05429_ sky130_fd_sc_hd__nor2_4
X_14524_ _11931_ _03784_ _05429_ VSS VSS VDD VDD _05430_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_45_1101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14527_ _03772_ _03792_ VSS VSS VDD VDD _05433_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_45_1099 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1098 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1097 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14531_ _11937_ net477 VSS VSS VDD VDD _05437_ sky130_fd_sc_hd__nand2_2
X_14532_ _03801_ _05433_ _05437_ VSS VSS VDD VDD _05438_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_45_1096 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1095 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14535_ _03792_ net475 VSS VSS VDD VDD _05441_ sky130_fd_sc_hd__nand2_2
X_14536_ _03791_ _03801_ VSS VSS VDD VDD _05442_ sky130_fd_sc_hd__nand2_2
X_14537_ _11942_ VSS VSS VDD VDD _05443_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_45_1094 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14539_ _11930_ _05441_ _05442_ _05443_ net482 VSS VSS VDD
+ VDD _05445_ sky130_fd_sc_hd__o221ai_4
X_14540_ net480 _05438_ _05445_ VSS VSS VDD VDD _05446_ sky130_fd_sc_hd__o21ai_0
X_14541_ _03778_ net478 VSS VSS VDD VDD _05447_ sky130_fd_sc_hd__nand2_2
X_14542_ _11940_ net479 VSS VSS VDD VDD _05448_ sky130_fd_sc_hd__nor2_2
X_14543_ _11931_ _03792_ VSS VSS VDD VDD _05449_ sky130_fd_sc_hd__nor2_4
X_14544_ net480 _05448_ _05449_ VSS VSS VDD VDD _05450_ sky130_fd_sc_hd__nor3_1
X_14545_ net480 _05447_ _05433_ _05450_ VSS VSS VDD VDD _05451_
+ sky130_fd_sc_hd__a31oi_1
X_14546_ _11937_ net478 VSS VSS VDD VDD _05452_ sky130_fd_sc_hd__nor2_2
X_14547_ _05452_ _05411_ net480 VSS VSS VDD VDD _05453_ sky130_fd_sc_hd__o21ai_0
X_14548_ _11944_ _05423_ net476 VSS VSS VDD VDD _05454_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_45_1093 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14550_ net476 _05451_ _05453_ _05454_ _03809_ VSS VSS VDD
+ VDD _05456_ sky130_fd_sc_hd__a221oi_1
X_14551_ _03809_ _05430_ _05446_ _05456_ VSS VSS VDD VDD _05457_
+ sky130_fd_sc_hd__a31oi_1
X_14552_ _05428_ _05457_ VSS VSS VDD VDD _05458_ sky130_fd_sc_hd__nor2_1
X_14553_ _03784_ _03792_ VSS VSS VDD VDD _05459_ sky130_fd_sc_hd__xnor2_4
X_14554_ net482 _03792_ VSS VSS VDD VDD _05460_ sky130_fd_sc_hd__nand2_4
X_14555_ _11931_ _05460_ VSS VSS VDD VDD _05461_ sky130_fd_sc_hd__nor2_2
X_14556_ _11940_ _05423_ _05459_ _11944_ _05461_ VSS VSS VDD
+ VDD _05462_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_45_1092 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14558_ _03778_ _03784_ VSS VSS VDD VDD _05464_ sky130_fd_sc_hd__nand2_2
X_14559_ _11931_ net480 VSS VSS VDD VDD _05465_ sky130_fd_sc_hd__nor2_1
X_14560_ _11931_ net478 _05464_ _05447_ _05465_ VSS VSS VDD
+ VDD _05466_ sky130_fd_sc_hd__a32oi_1
X_14561_ _03801_ _05466_ VSS VSS VDD VDD _05467_ sky130_fd_sc_hd__nand2_1
X_14562_ _03801_ _05462_ _05467_ VSS VSS VDD VDD _05468_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_45_1091 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14564_ _03809_ _03817_ VSS VSS VDD VDD _05470_ sky130_fd_sc_hd__nand2_1
X_14565_ _03773_ _03784_ VSS VSS VDD VDD _05471_ sky130_fd_sc_hd__nor2_2
X_14566_ _03773_ _03778_ _05471_ VSS VSS VDD VDD _05472_ sky130_fd_sc_hd__a21oi_1
X_14567_ net478 _05472_ VSS VSS VDD VDD _05473_ sky130_fd_sc_hd__xnor2_1
X_14568_ _11931_ VSS VSS VDD VDD _05474_ sky130_fd_sc_hd__clkinv_4
X_14569_ _05474_ _03792_ VSS VSS VDD VDD _05475_ sky130_fd_sc_hd__nor2_1
X_14570_ _05448_ _05475_ _03783_ VSS VSS VDD VDD _05476_ sky130_fd_sc_hd__o21ai_0
X_14571_ _11930_ net479 VSS VSS VDD VDD _05477_ sky130_fd_sc_hd__nand2_1
X_14572_ _03784_ _05398_ _05477_ VSS VSS VDD VDD _05478_ sky130_fd_sc_hd__nand3_1
X_14573_ net476 _05476_ _05478_ VSS VSS VDD VDD _05479_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_45_1090 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14575_ net476 _05473_ _05479_ _03810_ _03817_ VSS VSS VDD
+ VDD _05481_ sky130_fd_sc_hd__o2111ai_1
X_14576_ _05468_ _05470_ _05481_ VSS VSS VDD VDD _05482_ sky130_fd_sc_hd__o21ai_2
X_14577_ _03809_ _00398_ VSS VSS VDD VDD _05483_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_45_1089 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14579_ _03777_ _03784_ VSS VSS VDD VDD _05485_ sky130_fd_sc_hd__nand2_2
X_14580_ _11946_ _03783_ VSS VSS VDD VDD _05486_ sky130_fd_sc_hd__nand2b_1
X_14581_ _11930_ _03784_ VSS VSS VDD VDD _05487_ sky130_fd_sc_hd__nor2_1
X_14582_ _03772_ _03784_ _05487_ VSS VSS VDD VDD _05488_ sky130_fd_sc_hd__a21oi_1
X_14583_ net478 _05488_ net475 VSS VSS VDD VDD _05489_ sky130_fd_sc_hd__o21ai_1
X_14584_ net478 _05485_ _05486_ _05489_ VSS VSS VDD VDD _05490_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_45_1088 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1087 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14587_ _11932_ _03792_ VSS VSS VDD VDD _05493_ sky130_fd_sc_hd__nand2_1
X_14588_ _03777_ net479 VSS VSS VDD VDD _05494_ sky130_fd_sc_hd__nand2_1
X_14589_ _05493_ _05494_ _03784_ VSS VSS VDD VDD _05495_ sky130_fd_sc_hd__a21oi_1
X_14590_ _03784_ _05393_ _05401_ net476 _05495_ VSS VSS VDD
+ VDD _05496_ sky130_fd_sc_hd__a311oi_4
X_14591_ _05483_ _05490_ _05496_ VSS VSS VDD VDD _05497_ sky130_fd_sc_hd__nor3_1
X_14592_ _11932_ net477 VSS VSS VDD VDD _05498_ sky130_fd_sc_hd__nor2_1
X_14593_ _11935_ net477 VSS VSS VDD VDD _05499_ sky130_fd_sc_hd__and2_1
X_14594_ net481 _05498_ _05499_ VSS VSS VDD VDD _05500_ sky130_fd_sc_hd__nor3_1
X_14595_ _11931_ _03792_ VSS VSS VDD VDD _05501_ sky130_fd_sc_hd__nand2_4
X_14596_ _05394_ _05501_ _03784_ VSS VSS VDD VDD _05502_ sky130_fd_sc_hd__a21oi_1
X_14597_ _03810_ _00398_ VSS VSS VDD VDD _05503_ sky130_fd_sc_hd__nand2_2
X_14598_ net475 _05503_ VSS VSS VDD VDD _05504_ sky130_fd_sc_hd__nor2_1
X_14599_ _05500_ _05502_ _05504_ VSS VSS VDD VDD _05505_ sky130_fd_sc_hd__o21ai_0
X_14600_ _03801_ _05503_ VSS VSS VDD VDD _05506_ sky130_fd_sc_hd__nor2_1
X_14601_ _11935_ _03792_ VSS VSS VDD VDD _05507_ sky130_fd_sc_hd__nand2b_4
X_14602_ _03784_ _05394_ _05507_ VSS VSS VDD VDD _05508_ sky130_fd_sc_hd__nand3_1
X_14603_ _11937_ _05460_ _05506_ _05508_ VSS VSS VDD VDD _05509_
+ sky130_fd_sc_hd__o211ai_1
X_14604_ _05505_ _05509_ VSS VSS VDD VDD _05510_ sky130_fd_sc_hd__nand2_1
X_14605_ _03824_ _05482_ _05497_ _05510_ VSS VSS VDD VDD _05511_
+ sky130_fd_sc_hd__nor4_2
X_14606_ _05388_ _05416_ _05427_ _05458_ _05511_ VSS VSS VDD
+ VDD _00024_ sky130_fd_sc_hd__a311oi_1
X_14607_ net481 _05501_ _05437_ _05396_ VSS VSS VDD VDD _05512_
+ sky130_fd_sc_hd__a31oi_1
X_14608_ _11954_ net477 _03809_ VSS VSS VDD VDD _05513_ sky130_fd_sc_hd__o21ai_0
X_14609_ _03778_ _03784_ VSS VSS VDD VDD _05514_ sky130_fd_sc_hd__nor2_1
X_14610_ _11937_ net481 VSS VSS VDD VDD _05515_ sky130_fd_sc_hd__nor2_1
X_14611_ _03792_ _05514_ _05515_ VSS VSS VDD VDD _05516_ sky130_fd_sc_hd__nor3_1
X_14612_ _03809_ _05512_ _05513_ _05516_ _03801_ VSS VSS VDD
+ VDD _05517_ sky130_fd_sc_hd__o221ai_2
X_14613_ net476 _03809_ VSS VSS VDD VDD _05518_ sky130_fd_sc_hd__nand2_2
X_14614_ _05498_ _05499_ net480 VSS VSS VDD VDD _05519_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_45_1086 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14616_ _03784_ _05501_ _05437_ VSS VSS VDD VDD _05521_ sky130_fd_sc_hd__nand3_1
X_14617_ _05519_ _05521_ VSS VSS VDD VDD _05522_ sky130_fd_sc_hd__nand2_1
X_14618_ _03773_ _05447_ VSS VSS VDD VDD _05523_ sky130_fd_sc_hd__nor2_1
X_14619_ _05494_ _05507_ net480 VSS VSS VDD VDD _05524_ sky130_fd_sc_hd__a21oi_1
X_14620_ _03801_ _03809_ VSS VSS VDD VDD _05525_ sky130_fd_sc_hd__nor2_8
X_14621_ _05523_ _05524_ _05525_ VSS VSS VDD VDD _05526_ sky130_fd_sc_hd__o21ai_1
X_14622_ _05518_ _05522_ _05526_ VSS VSS VDD VDD _05527_ sky130_fd_sc_hd__o21a_1
X_14623_ net476 _03809_ VSS VSS VDD VDD _05528_ sky130_fd_sc_hd__nor2_4
X_14624_ _11930_ net479 _05394_ VSS VSS VDD VDD _05529_ sky130_fd_sc_hd__o21ai_2
X_14625_ _11944_ _03792_ _05507_ _03784_ VSS VSS VDD VDD _05530_
+ sky130_fd_sc_hd__o211ai_1
X_14626_ _03784_ _05529_ _05530_ VSS VSS VDD VDD _05531_ sky130_fd_sc_hd__o21ai_0
X_14627_ _05528_ _05531_ _00398_ VSS VSS VDD VDD _05532_ sky130_fd_sc_hd__a21oi_1
X_14628_ _05452_ net480 _05394_ VSS VSS VDD VDD _05533_ sky130_fd_sc_hd__nand3b_1
X_14629_ net476 _03810_ VSS VSS VDD VDD _05534_ sky130_fd_sc_hd__nor2_4
X_14630_ _03778_ _03792_ VSS VSS VDD VDD _05535_ sky130_fd_sc_hd__nand2_2
X_14631_ _03784_ _05494_ _05535_ VSS VSS VDD VDD _05536_ sky130_fd_sc_hd__nand3_1
X_14632_ _05533_ _05534_ _05536_ VSS VSS VDD VDD _05537_ sky130_fd_sc_hd__nand3_1
X_14633_ _11930_ _11940_ _03784_ VSS VSS VDD VDD _05538_ sky130_fd_sc_hd__mux2i_1
X_14634_ net477 _05538_ _03801_ VSS VSS VDD VDD _05539_ sky130_fd_sc_hd__a21oi_2
X_14635_ _11958_ net477 _03810_ _05539_ VSS VSS VDD VDD _05540_
+ sky130_fd_sc_hd__o31ai_4
X_14636_ _11946_ net479 VSS VSS VDD VDD _05541_ sky130_fd_sc_hd__nand2b_1
X_14637_ _05394_ _05501_ net480 VSS VSS VDD VDD _05542_ sky130_fd_sc_hd__a21oi_1
X_14638_ net480 _05398_ _05541_ _05542_ VSS VSS VDD VDD _05543_
+ sky130_fd_sc_hd__a31oi_1
X_14639_ _05474_ _03792_ VSS VSS VDD VDD _05544_ sky130_fd_sc_hd__nand2_4
X_14640_ _05477_ _05544_ _03784_ VSS VSS VDD VDD _05545_ sky130_fd_sc_hd__a21oi_1
X_14641_ _03773_ _05423_ _05545_ _03810_ VSS VSS VDD VDD _05546_
+ sky130_fd_sc_hd__a211oi_1
X_14642_ _11944_ net479 VSS VSS VDD VDD _05547_ sky130_fd_sc_hd__nand2_4
X_14643_ _03784_ _05547_ _05535_ VSS VSS VDD VDD _05548_ sky130_fd_sc_hd__nand3_1
X_14644_ _05533_ _05548_ _03809_ VSS VSS VDD VDD _05549_ sky130_fd_sc_hd__a21oi_1
X_14645_ _03801_ _05546_ _05549_ VSS VSS VDD VDD _05550_ sky130_fd_sc_hd__nor3_1
X_14646_ _11930_ _03792_ _05411_ VSS VSS VDD VDD _05551_ sky130_fd_sc_hd__a21oi_1
X_14647_ _11932_ net477 VSS VSS VDD VDD _05552_ sky130_fd_sc_hd__nand2_1
X_14648_ _05544_ _05552_ _03784_ VSS VSS VDD VDD _05553_ sky130_fd_sc_hd__a21oi_1
X_14649_ _03784_ _05551_ _05553_ net475 _03810_ VSS VSS VDD
+ VDD _05554_ sky130_fd_sc_hd__a2111oi_2
X_14650_ _05528_ _05543_ _05550_ _05554_ _03817_ VSS VSS VDD
+ VDD _05555_ sky130_fd_sc_hd__a2111oi_2
X_14651_ _05532_ _05537_ _05540_ _05555_ _03824_ VSS VSS VDD
+ VDD _05556_ sky130_fd_sc_hd__a311oi_4
X_14652_ _03773_ _05459_ VSS VSS VDD VDD _05557_ sky130_fd_sc_hd__nand2_1
X_14653_ _05474_ _05418_ _05535_ _03773_ _05557_ VSS VSS VDD
+ VDD _05558_ sky130_fd_sc_hd__o221ai_2
X_14654_ _05544_ _05437_ _03784_ VSS VSS VDD VDD _05559_ sky130_fd_sc_hd__a21oi_1
X_14655_ _03784_ _03792_ VSS VSS VDD VDD _05560_ sky130_fd_sc_hd__nand2_1
X_14656_ _11930_ _05560_ _03810_ VSS VSS VDD VDD _05561_ sky130_fd_sc_hd__o21ai_1
X_14657_ _05559_ _05561_ VSS VSS VDD VDD _05562_ sky130_fd_sc_hd__nor2_1
X_14658_ _03809_ _05558_ _05562_ VSS VSS VDD VDD _05563_ sky130_fd_sc_hd__a21oi_1
X_14659_ _11932_ _05413_ VSS VSS VDD VDD _05564_ sky130_fd_sc_hd__nand2_1
X_14660_ _11930_ _03792_ VSS VSS VDD VDD _05565_ sky130_fd_sc_hd__nor2_1
X_14661_ _03778_ net477 VSS VSS VDD VDD _05566_ sky130_fd_sc_hd__nor2_4
X_14662_ _05565_ _05566_ net480 VSS VSS VDD VDD _05567_ sky130_fd_sc_hd__o21ai_0
X_14663_ _03772_ _03792_ VSS VSS VDD VDD _05568_ sky130_fd_sc_hd__nor2_1
X_14664_ net480 _05501_ _05547_ VSS VSS VDD VDD _05569_ sky130_fd_sc_hd__nand3_1
X_14665_ net480 _05568_ _05452_ _05569_ _03809_ VSS VSS VDD
+ VDD _05570_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_45_1085 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14667_ _03810_ _05564_ _05567_ _05570_ net476 VSS VSS VDD
+ VDD _05572_ sky130_fd_sc_hd__a311oi_1
X_14668_ net476 _05563_ _05572_ _05428_ VSS VSS VDD VDD _05573_
+ sky130_fd_sc_hd__a211oi_1
X_14669_ _05388_ _05517_ _05527_ _05556_ _05573_ VSS VSS VDD
+ VDD _00025_ sky130_fd_sc_hd__a311oi_2
X_14670_ _11930_ _03792_ _05499_ VSS VSS VDD VDD _05574_ sky130_fd_sc_hd__a21oi_1
X_14671_ _11932_ _05460_ _05574_ net482 _05525_ VSS VSS VDD
+ VDD _05575_ sky130_fd_sc_hd__o221ai_1
XTAP_TAPCELL_ROW_45_1084 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14673_ _05474_ _03776_ _03781_ VSS VSS VDD VDD _05577_ sky130_fd_sc_hd__mux2i_1
X_14674_ net47 _11931_ VSS VSS VDD VDD _05578_ sky130_fd_sc_hd__nand2_1
X_14675_ net46 net47 _05578_ net497 VSS VSS VDD VDD _05579_
+ sky130_fd_sc_hd__o211ai_1
X_14676_ net497 _05577_ _05579_ VSS VSS VDD VDD _05580_ sky130_fd_sc_hd__o21ai_1
X_14677_ _11946_ _03784_ net478 VSS VSS VDD VDD _05581_ sky130_fd_sc_hd__a21oi_1
X_14678_ _03772_ net482 VSS VSS VDD VDD _05582_ sky130_fd_sc_hd__nand2_1
X_14679_ net478 _05580_ _05581_ _05582_ VSS VSS VDD VDD _05583_
+ sky130_fd_sc_hd__a22oi_1
X_14680_ _05528_ _05583_ VSS VSS VDD VDD _05584_ sky130_fd_sc_hd__nand2_1
X_14681_ _05474_ net482 net477 VSS VSS VDD VDD _05585_ sky130_fd_sc_hd__o21ai_0
X_14682_ _11935_ net481 _05515_ VSS VSS VDD VDD _05586_ sky130_fd_sc_hd__a21o_1
X_14683_ _03792_ _05586_ _03801_ VSS VSS VDD VDD _05587_ sky130_fd_sc_hd__a21oi_1
X_14684_ _05585_ _05514_ _05587_ _03809_ VSS VSS VDD VDD _05588_
+ sky130_fd_sc_hd__o211ai_1
X_14685_ _11937_ _03792_ VSS VSS VDD VDD _05589_ sky130_fd_sc_hd__nor2_2
X_14686_ _03784_ _05566_ _05589_ VSS VSS VDD VDD _05590_ sky130_fd_sc_hd__nor3_1
X_14687_ _05507_ _05552_ net482 VSS VSS VDD VDD _05591_ sky130_fd_sc_hd__a21oi_1
X_14688_ _05590_ _05591_ _05534_ VSS VSS VDD VDD _05592_ sky130_fd_sc_hd__o21ai_0
X_14689_ _05575_ _05584_ _05588_ _05592_ VSS VSS VDD VDD _05593_
+ sky130_fd_sc_hd__nand4_1
X_14690_ _11942_ net478 VSS VSS VDD VDD _05594_ sky130_fd_sc_hd__nand2_1
X_14691_ _05544_ _05594_ net481 VSS VSS VDD VDD _05595_ sky130_fd_sc_hd__a21oi_1
X_14692_ _05502_ _05595_ _05525_ VSS VSS VDD VDD _05596_ sky130_fd_sc_hd__o21ai_0
X_14693_ _03777_ _03792_ VSS VSS VDD VDD _05597_ sky130_fd_sc_hd__nand2_4
X_14694_ net481 _05597_ _05594_ _05518_ _05515_ VSS VSS VDD
+ VDD _05598_ sky130_fd_sc_hd__a311oi_1
X_14695_ _03817_ _03824_ _05598_ VSS VSS VDD VDD _05599_ sky130_fd_sc_hd__nor3_1
X_14696_ _11942_ net477 VSS VSS VDD VDD _05600_ sky130_fd_sc_hd__nor2_2
X_14697_ _03784_ _05568_ _05600_ VSS VSS VDD VDD _05601_ sky130_fd_sc_hd__nor3_1
X_14698_ _11932_ _03792_ VSS VSS VDD VDD _05602_ sky130_fd_sc_hd__nor2_2
X_14699_ net480 _05602_ _05566_ VSS VSS VDD VDD _05603_ sky130_fd_sc_hd__nor3_1
X_14700_ _05601_ _05603_ _05528_ VSS VSS VDD VDD _05604_ sky130_fd_sc_hd__o21ai_1
X_14701_ _05433_ _05594_ _03784_ VSS VSS VDD VDD _05605_ sky130_fd_sc_hd__a21oi_1
X_14702_ net481 _05452_ _05602_ VSS VSS VDD VDD _05606_ sky130_fd_sc_hd__nor3_1
X_14703_ _05605_ _05606_ _05534_ VSS VSS VDD VDD _05607_ sky130_fd_sc_hd__o21ai_0
X_14704_ _03777_ net481 VSS VSS VDD VDD _05608_ sky130_fd_sc_hd__nand2_1
X_14705_ _03772_ _03777_ _03792_ _05608_ VSS VSS VDD VDD _05609_
+ sky130_fd_sc_hd__o211ai_1
X_14706_ _11958_ _03792_ net475 _05609_ VSS VSS VDD VDD _05610_
+ sky130_fd_sc_hd__o211ai_1
X_14707_ _11944_ _03792_ _05501_ VSS VSS VDD VDD _05611_ sky130_fd_sc_hd__o21ai_1
X_14708_ net481 _05611_ VSS VSS VDD VDD _05612_ sky130_fd_sc_hd__nor2_1
X_14709_ _03778_ _03792_ VSS VSS VDD VDD _05613_ sky130_fd_sc_hd__nor2_1
X_14710_ _03784_ _05448_ _05613_ VSS VSS VDD VDD _05614_ sky130_fd_sc_hd__nor3_1
X_14711_ _05612_ _05614_ _03801_ VSS VSS VDD VDD _05615_ sky130_fd_sc_hd__o21ai_0
X_14712_ net477 net476 VSS VSS VDD VDD _05616_ sky130_fd_sc_hd__nand2_2
X_14713_ _03777_ _05429_ VSS VSS VDD VDD _05617_ sky130_fd_sc_hd__nand2_1
X_14714_ _03777_ net476 _05507_ VSS VSS VDD VDD _05618_ sky130_fd_sc_hd__o21ai_0
X_14715_ _11931_ net476 _05449_ net481 VSS VSS VDD VDD _05619_
+ sky130_fd_sc_hd__a211o_1
X_14716_ _03784_ _05618_ _05619_ VSS VSS VDD VDD _05620_ sky130_fd_sc_hd__o21ai_0
X_14717_ _03777_ _03791_ VSS VSS VDD VDD _05621_ sky130_fd_sc_hd__nor2_4
X_14718_ _05621_ _05514_ _03773_ _03801_ VSS VSS VDD VDD _05622_
+ sky130_fd_sc_hd__o211ai_1
X_14719_ _11951_ _05616_ _05622_ _03810_ VSS VSS VDD VDD _05623_
+ sky130_fd_sc_hd__o211ai_1
X_14720_ _05616_ _05617_ _05620_ _05623_ VSS VSS VDD VDD _05624_
+ sky130_fd_sc_hd__a31oi_1
X_14721_ _03809_ _05610_ _05615_ _05428_ _05624_ VSS VSS VDD
+ VDD _05625_ sky130_fd_sc_hd__a311oi_2
X_14722_ _05596_ _05599_ _05604_ _05607_ _05625_ VSS VSS VDD
+ VDD _05626_ sky130_fd_sc_hd__a41oi_2
X_14723_ _11937_ _05413_ _05611_ net481 _03809_ VSS VSS VDD
+ VDD _05627_ sky130_fd_sc_hd__a221oi_1
X_14724_ _11949_ _03792_ VSS VSS VDD VDD _05628_ sky130_fd_sc_hd__nand2_1
X_14725_ _11935_ _05423_ VSS VSS VDD VDD _05629_ sky130_fd_sc_hd__nand2_1
X_14726_ _05628_ _05629_ _03810_ VSS VSS VDD VDD _05630_ sky130_fd_sc_hd__a21oi_1
X_14727_ _03773_ _05460_ VSS VSS VDD VDD _05631_ sky130_fd_sc_hd__nor2_1
X_14728_ _11940_ _05423_ _05459_ _11930_ _05631_ VSS VSS VDD
+ VDD _05632_ sky130_fd_sc_hd__a221oi_1
X_14729_ _11935_ _03784_ VSS VSS VDD VDD _05633_ sky130_fd_sc_hd__and2_1
X_14730_ _11956_ net477 VSS VSS VDD VDD _05634_ sky130_fd_sc_hd__nand2_1
X_14731_ net477 _05514_ _05633_ _05634_ _03809_ VSS VSS VDD
+ VDD _05635_ sky130_fd_sc_hd__o311ai_0
X_14732_ _03809_ _05632_ _05635_ _03801_ VSS VSS VDD VDD _05636_
+ sky130_fd_sc_hd__o211ai_1
X_14733_ _03801_ _05627_ _05630_ _05388_ _05636_ VSS VSS VDD
+ VDD _05637_ sky130_fd_sc_hd__o311ai_1
X_14734_ _00398_ _03824_ _05593_ _05626_ _05637_ VSS VSS VDD
+ VDD _00026_ sky130_fd_sc_hd__o311a_1
X_14735_ _11944_ net479 VSS VSS VDD VDD _05638_ sky130_fd_sc_hd__nor2_1
X_14736_ _11940_ _03792_ VSS VSS VDD VDD _05639_ sky130_fd_sc_hd__nor2_1
X_14737_ _03784_ _05544_ _05394_ VSS VSS VDD VDD _05640_ sky130_fd_sc_hd__nand3_1
X_14738_ _03784_ _05638_ _05639_ _05640_ _05528_ VSS VSS VDD
+ VDD _05641_ sky130_fd_sc_hd__o311ai_1
X_14739_ _03784_ _03792_ VSS VSS VDD VDD _05642_ sky130_fd_sc_hd__nor2_1
X_14740_ _03773_ _05642_ VSS VSS VDD VDD _05643_ sky130_fd_sc_hd__nand2_1
X_14741_ _03777_ _03792_ VSS VSS VDD VDD _05644_ sky130_fd_sc_hd__nor2_1
X_14742_ _11931_ net478 VSS VSS VDD VDD _05645_ sky130_fd_sc_hd__nor2_1
X_14743_ _05644_ _05645_ _03784_ VSS VSS VDD VDD _05646_ sky130_fd_sc_hd__o21ai_0
X_14744_ _05534_ _05643_ _05646_ _00398_ VSS VSS VDD VDD _05647_
+ sky130_fd_sc_hd__a31oi_1
X_14745_ _11937_ _03784_ VSS VSS VDD VDD _05648_ sky130_fd_sc_hd__nand2_1
X_14746_ _11932_ _03783_ net478 VSS VSS VDD VDD _05649_ sky130_fd_sc_hd__a21oi_1
X_14747_ net475 _03810_ VSS VSS VDD VDD _05650_ sky130_fd_sc_hd__nand2_1
X_14748_ _05648_ _05649_ _05650_ VSS VSS VDD VDD _05651_ sky130_fd_sc_hd__a21oi_1
X_14749_ _03792_ _05580_ _05651_ VSS VSS VDD VDD _05652_ sky130_fd_sc_hd__o21ai_1
X_14750_ _05474_ _05460_ VSS VSS VDD VDD _05653_ sky130_fd_sc_hd__nor2_1
X_14751_ _03772_ _05447_ VSS VSS VDD VDD _05654_ sky130_fd_sc_hd__nor2_1
X_14752_ _05394_ _05597_ _03783_ VSS VSS VDD VDD _05655_ sky130_fd_sc_hd__a21oi_1
X_14753_ _05653_ _05654_ _05655_ _03809_ net476 VSS VSS VDD
+ VDD _05656_ sky130_fd_sc_hd__o311ai_0
X_14754_ _05641_ _05647_ _05652_ _05656_ VSS VSS VDD VDD _05657_
+ sky130_fd_sc_hd__nand4_1
X_14755_ _03784_ _05493_ _05594_ VSS VSS VDD VDD _05658_ sky130_fd_sc_hd__nand3_1
X_14756_ _03784_ _05449_ _05566_ _05534_ _05658_ VSS VSS VDD
+ VDD _05659_ sky130_fd_sc_hd__o311ai_1
X_14757_ _11940_ _05423_ VSS VSS VDD VDD _05660_ sky130_fd_sc_hd__nand2_1
X_14758_ _03773_ net478 VSS VSS VDD VDD _05661_ sky130_fd_sc_hd__nor2_1
X_14759_ _05475_ _05661_ _03783_ VSS VSS VDD VDD _05662_ sky130_fd_sc_hd__o21ai_0
X_14760_ _03773_ _05621_ VSS VSS VDD VDD _05663_ sky130_fd_sc_hd__nand2_1
X_14761_ _05660_ _05528_ _05662_ _05663_ VSS VSS VDD VDD _05664_
+ sky130_fd_sc_hd__nand4_1
X_14762_ _11930_ net479 VSS VSS VDD VDD _05665_ sky130_fd_sc_hd__and2_1
X_14763_ _11940_ _03792_ _05665_ VSS VSS VDD VDD _05666_ sky130_fd_sc_hd__a21oi_1
X_14764_ _05449_ _05409_ _03784_ VSS VSS VDD VDD _05667_ sky130_fd_sc_hd__o21ai_0
X_14765_ _03784_ _05666_ _05667_ _05525_ VSS VSS VDD VDD _05668_
+ sky130_fd_sc_hd__o211ai_1
X_14766_ _11935_ _05413_ _05518_ VSS VSS VDD VDD _05669_ sky130_fd_sc_hd__a21oi_1
X_14767_ _03772_ _03778_ VSS VSS VDD VDD _05670_ sky130_fd_sc_hd__nor2_1
X_14768_ _05471_ _05670_ net478 VSS VSS VDD VDD _05671_ sky130_fd_sc_hd__o21ai_1
X_14769_ _05669_ _05671_ _03817_ VSS VSS VDD VDD _05672_ sky130_fd_sc_hd__a21oi_1
X_14770_ _05659_ _05664_ _05668_ _05672_ VSS VSS VDD VDD _05673_
+ sky130_fd_sc_hd__nand4_1
X_14771_ _05657_ _05673_ VSS VSS VDD VDD _05674_ sky130_fd_sc_hd__nand2_1
X_14772_ _03792_ _03810_ VSS VSS VDD VDD _05675_ sky130_fd_sc_hd__nor2_1
X_14773_ _11946_ _03792_ _05675_ _03778_ VSS VSS VDD VDD _05676_
+ sky130_fd_sc_hd__a22oi_1
X_14774_ _03792_ _03809_ VSS VSS VDD VDD _05677_ sky130_fd_sc_hd__nor2_1
X_14775_ net482 net477 _03810_ VSS VSS VDD VDD _05678_ sky130_fd_sc_hd__nor3_1
X_14776_ net482 _05677_ _05678_ VSS VSS VDD VDD _05679_ sky130_fd_sc_hd__a21oi_1
X_14777_ _11940_ net482 VSS VSS VDD VDD _05680_ sky130_fd_sc_hd__nor2_1
X_14778_ _05675_ _05680_ net475 VSS VSS VDD VDD _05681_ sky130_fd_sc_hd__a21oi_1
X_14779_ _03784_ _05676_ _05679_ _11931_ _05681_ VSS VSS VDD
+ VDD _05682_ sky130_fd_sc_hd__o221ai_1
X_14780_ _03772_ _03809_ _03791_ VSS VSS VDD VDD _05683_ sky130_fd_sc_hd__a21oi_1
X_14781_ _11932_ _03809_ _05560_ VSS VSS VDD VDD _05684_ sky130_fd_sc_hd__a21oi_1
X_14782_ _03773_ _05675_ _05684_ VSS VSS VDD VDD _05685_ sky130_fd_sc_hd__a21oi_1
X_14783_ _11942_ _03809_ _05683_ _03784_ _05685_ VSS VSS VDD
+ VDD _05686_ sky130_fd_sc_hd__o221ai_1
X_14784_ _03773_ _03784_ _05661_ VSS VSS VDD VDD _05687_ sky130_fd_sc_hd__a21oi_1
X_14785_ _11931_ _03809_ _05687_ _05677_ _05471_ VSS VSS VDD
+ VDD _05688_ sky130_fd_sc_hd__a32oi_1
X_14786_ net475 _05686_ _05688_ VSS VSS VDD VDD _05689_ sky130_fd_sc_hd__nand3_1
X_14787_ _03784_ _05644_ _03772_ VSS VSS VDD VDD _05690_ sky130_fd_sc_hd__o21ai_0
X_14788_ _11944_ _05460_ _05418_ _03778_ _05690_ VSS VSS VDD
+ VDD _05691_ sky130_fd_sc_hd__o221ai_1
X_14789_ _05449_ _05600_ VSS VSS VDD VDD _05692_ sky130_fd_sc_hd__nor2_1
X_14790_ _03784_ _05692_ VSS VSS VDD VDD _05693_ sky130_fd_sc_hd__nor2_1
X_14791_ _03784_ _05393_ _05552_ _05693_ VSS VSS VDD VDD _05694_
+ sky130_fd_sc_hd__a31oi_1
X_14792_ _11942_ net482 _03792_ _05582_ VSS VSS VDD VDD _05695_
+ sky130_fd_sc_hd__o211ai_1
X_14793_ _11932_ _03784_ VSS VSS VDD VDD _05696_ sky130_fd_sc_hd__nand2_1
X_14794_ _05471_ _05442_ VSS VSS VDD VDD _05697_ sky130_fd_sc_hd__nor2_1
X_14795_ _05539_ _05695_ _05696_ _05697_ _05483_ VSS VSS VDD
+ VDD _05698_ sky130_fd_sc_hd__a221oi_1
X_14796_ _05506_ _05691_ _05694_ _05504_ _05698_ VSS VSS VDD
+ VDD _05699_ sky130_fd_sc_hd__a221o_1
X_14797_ _03817_ _05682_ _05689_ _03824_ _05699_ VSS VSS VDD
+ VDD _05700_ sky130_fd_sc_hd__a311oi_2
X_14798_ _03824_ _05674_ _05700_ VSS VSS VDD VDD _00027_ sky130_fd_sc_hd__a21oi_2
X_14799_ _11931_ _03784_ _03792_ _05665_ VSS VSS VDD VDD _05701_
+ sky130_fd_sc_hd__a31oi_2
X_14800_ _03778_ net482 VSS VSS VDD VDD _05702_ sky130_fd_sc_hd__nand2_1
X_14801_ _03772_ _03777_ VSS VSS VDD VDD _05703_ sky130_fd_sc_hd__nand2_1
X_14802_ _03791_ _05702_ _05703_ _05631_ VSS VSS VDD VDD _05704_
+ sky130_fd_sc_hd__a31oi_1
X_14803_ _11942_ _05687_ _05704_ VSS VSS VDD VDD _05705_ sky130_fd_sc_hd__o21ai_2
X_14804_ _05420_ _05566_ net481 VSS VSS VDD VDD _05706_ sky130_fd_sc_hd__o21ai_1
X_14805_ _03809_ _05705_ _05706_ _05414_ net475 VSS VSS VDD
+ VDD _05707_ sky130_fd_sc_hd__a221oi_4
X_14806_ _05433_ _05547_ net480 VSS VSS VDD VDD _05708_ sky130_fd_sc_hd__a21oi_1
X_14807_ net481 net478 VSS VSS VDD VDD _05709_ sky130_fd_sc_hd__nand2_1
X_14808_ _11946_ _05709_ _05597_ _03772_ VSS VSS VDD VDD _05710_
+ sky130_fd_sc_hd__o22ai_1
X_14809_ _05518_ _05708_ _05710_ VSS VSS VDD VDD _05711_ sky130_fd_sc_hd__nor3_1
X_14810_ _05525_ _05701_ _05707_ _03824_ _05711_ VSS VSS VDD
+ VDD _05712_ sky130_fd_sc_hd__a2111oi_4
X_14811_ _11935_ _03784_ _05485_ _05429_ VSS VSS VDD VDD _05713_
+ sky130_fd_sc_hd__o211ai_2
X_14812_ _05621_ _05589_ net475 VSS VSS VDD VDD _05714_ sky130_fd_sc_hd__o21ai_0
X_14813_ _11932_ _05442_ _05714_ VSS VSS VDD VDD _05715_ sky130_fd_sc_hd__o21ai_1
X_14814_ _03801_ _05589_ _05696_ VSS VSS VDD VDD _05716_ sky130_fd_sc_hd__and3_1
X_14815_ net475 _05404_ _05715_ _03784_ _05716_ VSS VSS VDD
+ VDD _05717_ sky130_fd_sc_hd__a221oi_4
X_14816_ _11942_ _03784_ _05528_ _05521_ VSS VSS VDD VDD _05718_
+ sky130_fd_sc_hd__o211ai_2
X_14817_ net482 _05507_ _05552_ VSS VSS VDD VDD _05719_ sky130_fd_sc_hd__nand3_1
X_14818_ net482 _05692_ _05719_ _05525_ VSS VSS VDD VDD _05720_
+ sky130_fd_sc_hd__o211ai_2
X_14819_ _03824_ _05718_ _05720_ _00398_ VSS VSS VDD VDD _05721_
+ sky130_fd_sc_hd__a31oi_4
X_14820_ _03809_ _03817_ _05713_ _05717_ _05721_ VSS VSS VDD
+ VDD _05722_ sky130_fd_sc_hd__a41oi_4
X_14821_ _11942_ _03792_ net481 VSS VSS VDD VDD _05723_ sky130_fd_sc_hd__a21oi_1
X_14822_ _05411_ _05723_ _03801_ VSS VSS VDD VDD _05724_ sky130_fd_sc_hd__o21ai_0
X_14823_ _03784_ _05547_ _05597_ _03801_ _05471_ VSS VSS VDD
+ VDD _05725_ sky130_fd_sc_hd__a311oi_1
X_14824_ _05503_ _05725_ _03824_ VSS VSS VDD VDD _05726_ sky130_fd_sc_hd__nor3b_1
X_14825_ _03783_ _05602_ _05643_ VSS VSS VDD VDD _05727_ sky130_fd_sc_hd__o21ai_0
X_14826_ _05452_ _05547_ net480 VSS VSS VDD VDD _05728_ sky130_fd_sc_hd__nand3b_1
X_14827_ _05536_ _05728_ net476 VSS VSS VDD VDD _05729_ sky130_fd_sc_hd__a21oi_1
X_14828_ net475 _05727_ _05729_ VSS VSS VDD VDD _05730_ sky130_fd_sc_hd__a21oi_1
X_14829_ _03824_ _05483_ _05730_ VSS VSS VDD VDD _05731_ sky130_fd_sc_hd__nor3_1
X_14830_ _05724_ _05726_ _05731_ VSS VSS VDD VDD _05732_ sky130_fd_sc_hd__a21oi_1
X_14831_ _03778_ _05413_ _05663_ VSS VSS VDD VDD _05733_ sky130_fd_sc_hd__o21ai_0
X_14832_ net475 _05643_ _05733_ VSS VSS VDD VDD _05734_ sky130_fd_sc_hd__nand3_1
X_14833_ _11944_ _03784_ _03792_ VSS VSS VDD VDD _05735_ sky130_fd_sc_hd__nand3_1
X_14834_ _05702_ _05735_ net475 VSS VSS VDD VDD _05736_ sky130_fd_sc_hd__a21oi_1
X_14835_ _03772_ net477 _05464_ _05483_ _05736_ VSS VSS VDD
+ VDD _05737_ sky130_fd_sc_hd__a311oi_2
X_14836_ _11937_ _03783_ _05465_ VSS VSS VDD VDD _05738_ sky130_fd_sc_hd__a21o_1
X_14837_ net478 _05738_ _05489_ VSS VSS VDD VDD _05739_ sky130_fd_sc_hd__a21oi_1
X_14838_ net481 net475 _05551_ VSS VSS VDD VDD _05740_ sky130_fd_sc_hd__nor3_1
X_14839_ _03824_ _05503_ _05739_ _05740_ VSS VSS VDD VDD _05741_
+ sky130_fd_sc_hd__nor4_1
X_14840_ _03824_ _05734_ _05737_ _05741_ VSS VSS VDD VDD _05742_
+ sky130_fd_sc_hd__a31oi_2
X_14841_ _05712_ _05722_ _05732_ _05742_ VSS VSS VDD VDD _00028_
+ sky130_fd_sc_hd__o211ai_4
X_14842_ net480 _05437_ _05409_ VSS VSS VDD VDD _05743_ sky130_fd_sc_hd__a21oi_1
X_14843_ _11942_ _03792_ VSS VSS VDD VDD _05744_ sky130_fd_sc_hd__nor2_1
X_14844_ net480 _05401_ _05433_ VSS VSS VDD VDD _05745_ sky130_fd_sc_hd__nand3_1
X_14845_ net480 _05452_ _05744_ _05745_ _03810_ VSS VSS VDD
+ VDD _05746_ sky130_fd_sc_hd__o311ai_1
X_14846_ _03810_ _05743_ _05746_ _03801_ VSS VSS VDD VDD _05747_
+ sky130_fd_sc_hd__o211ai_1
X_14847_ _03772_ _05413_ _05518_ _05693_ VSS VSS VDD VDD _05748_
+ sky130_fd_sc_hd__a211oi_1
X_14848_ _05498_ _05613_ _03784_ VSS VSS VDD VDD _05749_ sky130_fd_sc_hd__o21ai_0
X_14849_ _05453_ _05525_ _05749_ VSS VSS VDD VDD _05750_ sky130_fd_sc_hd__and3_1
X_14850_ _05428_ _05748_ _05750_ VSS VSS VDD VDD _05751_ sky130_fd_sc_hd__nor3_1
X_14851_ _03778_ _05441_ _05442_ _05703_ VSS VSS VDD VDD _05752_
+ sky130_fd_sc_hd__o22ai_1
X_14852_ _05429_ _05538_ VSS VSS VDD VDD _05753_ sky130_fd_sc_hd__nand2_1
X_14853_ _03778_ _03801_ VSS VSS VDD VDD _05754_ sky130_fd_sc_hd__nor2_1
X_14854_ _05423_ _05754_ _03773_ VSS VSS VDD VDD _05755_ sky130_fd_sc_hd__o21ai_0
X_14855_ _05464_ _05616_ _05753_ _05755_ VSS VSS VDD VDD _05756_
+ sky130_fd_sc_hd__o211ai_1
X_14856_ _05752_ _05756_ _03810_ VSS VSS VDD VDD _05757_ sky130_fd_sc_hd__o21ai_0
X_14857_ _11946_ net479 VSS VSS VDD VDD _05758_ sky130_fd_sc_hd__nand2_1
X_14858_ _05501_ _05758_ _03783_ VSS VSS VDD VDD _05759_ sky130_fd_sc_hd__a21oi_1
X_14859_ _03778_ _05642_ _05759_ VSS VSS VDD VDD _05760_ sky130_fd_sc_hd__a21oi_1
X_14860_ _11932_ net479 VSS VSS VDD VDD _05761_ sky130_fd_sc_hd__and2_0
X_14861_ _05638_ _05761_ _03784_ VSS VSS VDD VDD _05762_ sky130_fd_sc_hd__o21ai_0
X_14862_ _03801_ _05461_ VSS VSS VDD VDD _05763_ sky130_fd_sc_hd__nor2_1
X_14863_ _03801_ _05760_ _05762_ _05763_ _03810_ VSS VSS VDD
+ VDD _05764_ sky130_fd_sc_hd__a221o_1
X_14864_ net478 _03810_ VSS VSS VDD VDD _05765_ sky130_fd_sc_hd__nor2_1
X_14865_ _03809_ _05433_ _05477_ VSS VSS VDD VDD _05766_ sky130_fd_sc_hd__o21ai_2
X_14866_ _11940_ _05765_ _05633_ _05677_ _05766_ net482 VSS
+ VSS VDD VDD _05767_ sky130_fd_sc_hd__a222oi_1
X_14867_ _05448_ _05761_ _03784_ VSS VSS VDD VDD _05768_ sky130_fd_sc_hd__o21ai_1
X_14868_ _03784_ _05475_ _05645_ _05768_ _03809_ VSS VSS VDD
+ VDD _05769_ sky130_fd_sc_hd__o311ai_1
X_14869_ net478 _05648_ _05560_ _11932_ VSS VSS VDD VDD _05770_
+ sky130_fd_sc_hd__o2bb2ai_1
X_14870_ _03810_ _05770_ net475 VSS VSS VDD VDD _05771_ sky130_fd_sc_hd__a21oi_1
X_14871_ net475 _05767_ _05769_ _05771_ _03824_ VSS VSS VDD
+ VDD _05772_ sky130_fd_sc_hd__a221oi_1
X_14872_ _03824_ _05757_ _05764_ _05772_ VSS VSS VDD VDD _05773_
+ sky130_fd_sc_hd__a31oi_1
X_14873_ _00398_ _05773_ VSS VSS VDD VDD _05774_ sky130_fd_sc_hd__nor2_1
X_14874_ net480 _05409_ _05744_ VSS VSS VDD VDD _05775_ sky130_fd_sc_hd__nor3_1
X_14875_ net480 _05447_ _05544_ _05775_ VSS VSS VDD VDD _05776_
+ sky130_fd_sc_hd__a31oi_2
X_14876_ _03772_ _05613_ VSS VSS VDD VDD _05777_ sky130_fd_sc_hd__nor2_1
X_14877_ _03772_ _05642_ _05777_ VSS VSS VDD VDD _05778_ sky130_fd_sc_hd__a21oi_1
X_14878_ _11930_ _05709_ _05534_ _05768_ VSS VSS VDD VDD _05779_
+ sky130_fd_sc_hd__o211ai_1
X_14879_ _05650_ _05778_ _05779_ VSS VSS VDD VDD _05780_ sky130_fd_sc_hd__o21ai_0
X_14880_ _05582_ _05648_ _03792_ VSS VSS VDD VDD _05781_ sky130_fd_sc_hd__a21oi_1
X_14881_ _03810_ _05489_ _05781_ VSS VSS VDD VDD _05782_ sky130_fd_sc_hd__nor3_1
X_14882_ _05528_ _05776_ _05780_ _05782_ VSS VSS VDD VDD _05783_
+ sky130_fd_sc_hd__a211oi_1
X_14883_ _03817_ _03824_ _05783_ VSS VSS VDD VDD _05784_ sky130_fd_sc_hd__nor3_1
X_14884_ _05747_ _05751_ _05774_ _05784_ VSS VSS VDD VDD _00029_
+ sky130_fd_sc_hd__a211oi_1
X_14885_ _03784_ _05393_ _03778_ VSS VSS VDD VDD _05785_ sky130_fd_sc_hd__a21oi_1
X_14886_ _05506_ _05629_ VSS VSS VDD VDD _05786_ sky130_fd_sc_hd__nand2_1
X_14887_ _05631_ _05785_ _05786_ VSS VSS VDD VDD _05787_ sky130_fd_sc_hd__nor3_1
X_14888_ _11935_ net482 _05697_ VSS VSS VDD VDD _05788_ sky130_fd_sc_hd__o21a_1
X_14889_ _03773_ _05413_ _05692_ net482 _03801_ VSS VSS VDD
+ VDD _05789_ sky130_fd_sc_hd__a221oi_1
X_14890_ _11954_ _05429_ _05788_ _05789_ _05483_ VSS VSS VDD
+ VDD _05790_ sky130_fd_sc_hd__a2111oi_0
X_14891_ _11932_ _03784_ _03792_ _05663_ VSS VSS VDD VDD _05791_
+ sky130_fd_sc_hd__o31ai_1
X_14892_ _03773_ net482 _05504_ VSS VSS VDD VDD _05792_ sky130_fd_sc_hd__o21ai_0
X_14893_ _05791_ _05792_ VSS VSS VDD VDD _05793_ sky130_fd_sc_hd__nor2_1
X_14894_ _03824_ _05787_ _05790_ _05793_ VSS VSS VDD VDD _05794_
+ sky130_fd_sc_hd__nor4_1
X_14895_ _05493_ _05394_ net480 VSS VSS VDD VDD _05795_ sky130_fd_sc_hd__a21oi_1
X_14896_ _05461_ _05795_ _03801_ VSS VSS VDD VDD _05796_ sky130_fd_sc_hd__o21ai_1
X_14897_ _11942_ _03784_ VSS VSS VDD VDD _05797_ sky130_fd_sc_hd__nand2_1
X_14898_ net477 _05608_ _05797_ VSS VSS VDD VDD _05798_ sky130_fd_sc_hd__nand3_1
X_14899_ _11950_ net477 net475 _05798_ VSS VSS VDD VDD _05799_
+ sky130_fd_sc_hd__o211ai_1
X_14900_ _11940_ net477 _05600_ VSS VSS VDD VDD _05800_ sky130_fd_sc_hd__a21oi_1
X_14901_ _03777_ _05460_ _05800_ net482 _03801_ VSS VSS VDD
+ VDD _05801_ sky130_fd_sc_hd__o221ai_1
X_14902_ _03810_ _05587_ VSS VSS VDD VDD _05802_ sky130_fd_sc_hd__nor2_1
X_14903_ _03810_ _05796_ _05799_ _05801_ _05802_ VSS VSS VDD
+ VDD _05803_ sky130_fd_sc_hd__a32oi_1
X_14904_ _03817_ _05803_ VSS VSS VDD VDD _05804_ sky130_fd_sc_hd__nand2_1
X_14905_ _03817_ _03824_ VSS VSS VDD VDD _05805_ sky130_fd_sc_hd__nand2_1
X_14906_ _11935_ _05460_ VSS VSS VDD VDD _05806_ sky130_fd_sc_hd__nor2_1
X_14907_ _11931_ _05418_ _05557_ VSS VSS VDD VDD _05807_ sky130_fd_sc_hd__o21ai_0
X_14908_ _05806_ _05807_ _03809_ VSS VSS VDD VDD _05808_ sky130_fd_sc_hd__o21ai_0
X_14909_ _05409_ _05411_ _03784_ VSS VSS VDD VDD _05809_ sky130_fd_sc_hd__o21ai_0
X_14910_ _03784_ _05449_ _05566_ _05809_ _03810_ VSS VSS VDD
+ VDD _05810_ sky130_fd_sc_hd__o311ai_2
X_14911_ _05621_ _05639_ _03784_ VSS VSS VDD VDD _05811_ sky130_fd_sc_hd__o21ai_0
X_14912_ _05806_ _05811_ _03809_ VSS VSS VDD VDD _05812_ sky130_fd_sc_hd__nand3b_1
X_14913_ _11931_ _03784_ net477 VSS VSS VDD VDD _05813_ sky130_fd_sc_hd__o21ai_0
X_14914_ _11949_ net477 _05633_ _05813_ _03810_ VSS VSS VDD
+ VDD _05814_ sky130_fd_sc_hd__o221ai_1
X_14915_ _05812_ _05814_ net475 VSS VSS VDD VDD _05815_ sky130_fd_sc_hd__a21oi_1
X_14916_ net475 _05808_ _05810_ _05815_ VSS VSS VDD VDD _05816_
+ sky130_fd_sc_hd__a31oi_1
X_14917_ _11946_ _03810_ _05413_ net475 VSS VSS VDD VDD _05817_
+ sky130_fd_sc_hd__a31oi_1
X_14918_ _05443_ _05460_ VSS VSS VDD VDD _05818_ sky130_fd_sc_hd__nor2_1
X_14919_ _05807_ _05818_ _03809_ VSS VSS VDD VDD _05819_ sky130_fd_sc_hd__o21ai_0
X_14920_ _03784_ _03809_ _05600_ VSS VSS VDD VDD _05820_ sky130_fd_sc_hd__nor3_1
X_14921_ _05547_ _05820_ VSS VSS VDD VDD _05821_ sky130_fd_sc_hd__nand2_1
X_14922_ _11932_ net482 _05797_ VSS VSS VDD VDD _05822_ sky130_fd_sc_hd__a21boi_0
X_14923_ _03792_ _05822_ net475 VSS VSS VDD VDD _05823_ sky130_fd_sc_hd__o21ai_1
X_14924_ _03792_ _05486_ VSS VSS VDD VDD _05824_ sky130_fd_sc_hd__nand2_1
X_14925_ _11930_ _03784_ _05824_ VSS VSS VDD VDD _05825_ sky130_fd_sc_hd__a21oi_1
X_14926_ _03778_ _05661_ VSS VSS VDD VDD _05826_ sky130_fd_sc_hd__nor2_1
X_14927_ _03778_ _05413_ _05826_ VSS VSS VDD VDD _05827_ sky130_fd_sc_hd__a21oi_1
X_14928_ _03810_ _05823_ _05825_ _05827_ _05650_ VSS VSS VDD
+ VDD _05828_ sky130_fd_sc_hd__o32ai_2
X_14929_ _05817_ _05819_ _05821_ _05828_ VSS VSS VDD VDD _05829_
+ sky130_fd_sc_hd__a31oi_1
X_14930_ _05805_ _05816_ _05829_ _05428_ VSS VSS VDD VDD _05830_
+ sky130_fd_sc_hd__o22ai_1
X_14931_ _05794_ _05804_ _05830_ VSS VSS VDD VDD _00030_ sky130_fd_sc_hd__a21oi_1
X_14932_ _03784_ _05499_ _05452_ VSS VSS VDD VDD _05831_ sky130_fd_sc_hd__or3_1
X_14933_ _11951_ net479 _03810_ _05461_ _05542_ VSS VSS VDD
+ VDD _05832_ sky130_fd_sc_hd__a2111oi_0
X_14934_ _03810_ _05536_ _05831_ _05832_ VSS VSS VDD VDD _05833_
+ sky130_fd_sc_hd__a31oi_1
X_14935_ _11960_ net478 VSS VSS VDD VDD _05834_ sky130_fd_sc_hd__nor2_1
X_14936_ _11942_ net480 _03792_ _05465_ VSS VSS VDD VDD _05835_
+ sky130_fd_sc_hd__a211oi_1
X_14937_ _11946_ _03784_ net478 VSS VSS VDD VDD _05836_ sky130_fd_sc_hd__nand3_1
X_14938_ _11930_ net478 _05836_ VSS VSS VDD VDD _05837_ sky130_fd_sc_hd__o21ai_0
X_14939_ _05525_ _05837_ VSS VSS VDD VDD _05838_ sky130_fd_sc_hd__nand2_1
X_14940_ _05518_ _05834_ _05835_ _05838_ _05388_ VSS VSS VDD
+ VDD _05839_ sky130_fd_sc_hd__o311ai_1
X_14941_ _03801_ _05833_ _05839_ VSS VSS VDD VDD _05840_ sky130_fd_sc_hd__a21oi_1
X_14942_ _03777_ _05459_ VSS VSS VDD VDD _05841_ sky130_fd_sc_hd__nand2_1
X_14943_ _11930_ _05418_ _05535_ _03773_ _05841_ VSS VSS VDD
+ VDD _05842_ sky130_fd_sc_hd__o221ai_1
X_14944_ _03792_ _05464_ _03772_ VSS VSS VDD VDD _05843_ sky130_fd_sc_hd__a21oi_1
X_14945_ _05485_ _05661_ _05843_ VSS VSS VDD VDD _05844_ sky130_fd_sc_hd__a21oi_1
X_14946_ _05525_ _05842_ _05844_ _05528_ VSS VSS VDD VDD _05845_
+ sky130_fd_sc_hd__a22oi_1
X_14947_ _00398_ _05845_ VSS VSS VDD VDD _05846_ sky130_fd_sc_hd__nor2_1
X_14948_ _05418_ _05441_ VSS VSS VDD VDD _05847_ sky130_fd_sc_hd__nand2_1
X_14949_ _11935_ _05429_ _05475_ _03784_ VSS VSS VDD VDD _05848_
+ sky130_fd_sc_hd__a211oi_1
X_14950_ _03784_ _03801_ _05848_ VSS VSS VDD VDD _05849_ sky130_fd_sc_hd__a21oi_1
X_14951_ _11930_ _05847_ _05849_ _05470_ VSS VSS VDD VDD _05850_
+ sky130_fd_sc_hd__a211oi_1
X_14952_ _05582_ _05485_ _03791_ VSS VSS VDD VDD _05851_ sky130_fd_sc_hd__a21oi_1
X_14953_ _05823_ _05851_ VSS VSS VDD VDD _05852_ sky130_fd_sc_hd__nor2_1
X_14954_ _11932_ _05460_ _05418_ _03772_ VSS VSS VDD VDD _05853_
+ sky130_fd_sc_hd__o22ai_1
X_14955_ _05474_ _05459_ _05853_ VSS VSS VDD VDD _05854_ sky130_fd_sc_hd__a21oi_1
X_14956_ net475 _05854_ VSS VSS VDD VDD _05855_ sky130_fd_sc_hd__nor2_1
X_14957_ _03783_ _05529_ VSS VSS VDD VDD _05856_ sky130_fd_sc_hd__nor2_1
X_14958_ _05602_ _05621_ _03783_ VSS VSS VDD VDD _05857_ sky130_fd_sc_hd__o21ai_0
X_14959_ _11942_ _05560_ _05857_ net475 VSS VSS VDD VDD _05858_
+ sky130_fd_sc_hd__o211ai_1
X_14960_ net475 _05404_ _05856_ _05858_ VSS VSS VDD VDD _05859_
+ sky130_fd_sc_hd__o31a_1
X_14961_ _05483_ _05852_ _05855_ _05503_ _05859_ VSS VSS VDD
+ VDD _05860_ sky130_fd_sc_hd__o32ai_2
X_14962_ _03824_ _05846_ _05850_ _05860_ VSS VSS VDD VDD _05861_
+ sky130_fd_sc_hd__nor4_2
X_14963_ net480 _05665_ _05600_ VSS VSS VDD VDD _05862_ sky130_fd_sc_hd__nor3_1
X_14964_ net480 _05494_ _05433_ _05862_ _03809_ VSS VSS VDD
+ VDD _05863_ sky130_fd_sc_hd__a311oi_1
X_14965_ _03792_ _05702_ _05703_ _05589_ VSS VSS VDD VDD _05864_
+ sky130_fd_sc_hd__a31oi_2
X_14966_ _03810_ _05864_ VSS VSS VDD VDD _05865_ sky130_fd_sc_hd__nor2_1
X_14967_ net476 _05863_ _05865_ VSS VSS VDD VDD _05866_ sky130_fd_sc_hd__nor3_1
X_14968_ _03784_ _05666_ VSS VSS VDD VDD _05867_ sky130_fd_sc_hd__nand2_1
X_14969_ _11944_ _03784_ VSS VSS VDD VDD _05868_ sky130_fd_sc_hd__nor2_1
X_14970_ _03784_ _05541_ _05597_ _05868_ _03810_ VSS VSS VDD
+ VDD _05869_ sky130_fd_sc_hd__a311oi_1
X_14971_ _03810_ _05569_ _05867_ _05869_ _03801_ VSS VSS VDD
+ VDD _05870_ sky130_fd_sc_hd__a311oi_1
X_14972_ _05428_ _05866_ _05870_ VSS VSS VDD VDD _05871_ sky130_fd_sc_hd__nor3_1
X_14973_ _05840_ _05861_ _05871_ VSS VSS VDD VDD _00031_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_45_1083 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1082 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14976_ sa00_sr\[7\] sa00_sr\[0\] VSS VSS VDD VDD _05874_
+ sky130_fd_sc_hd__xnor2_1
X_14977_ sa20_sr\[1\] sa30_sr\[1\] VSS VSS VDD VDD _05875_
+ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_45_1081 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14979_ sa10_sr\[7\] sa10_sr\[0\] sa10_sr\[1\] VSS VSS VDD
+ VDD _05877_ sky130_fd_sc_hd__xor3_1
X_14980_ _05874_ _05875_ _05877_ VSS VSS VDD VDD _05878_ sky130_fd_sc_hd__xnor3_1
X_14981_ ld_r VSS VSS VDD VDD _05879_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_44_1080 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1079 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14984_ text_in_r\[121\] _05878_ net663 VSS VSS VDD VDD _05882_
+ sky130_fd_sc_hd__mux2i_4
X_14985_ _05882_ u0.w\[0\]\[25\] VSS VSS VDD VDD _05883_ sky130_fd_sc_hd__xor2_4
X_14986_ net472 VSS VSS VDD VDD _05884_ sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_44_1078 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14988_ sa10_sr\[0\] sa20_sr\[0\] VSS VSS VDD VDD _05885_
+ sky130_fd_sc_hd__xor2_4
X_14989_ sa00_sr\[7\] sa10_sr\[7\] sa30_sr\[0\] VSS VSS VDD
+ VDD _05886_ sky130_fd_sc_hd__xnor3_1
X_14990_ _05885_ _05886_ VSS VSS VDD VDD _05887_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_44_1077 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14992_ text_in_r\[120\] _05887_ net660 VSS VSS VDD VDD _05889_
+ sky130_fd_sc_hd__mux2i_4
X_14993_ u0.w\[0\]\[24\] _05889_ VSS VSS VDD VDD _05890_ sky130_fd_sc_hd__xor2_4
X_14994_ net732 VSS VSS VDD VDD _05891_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_44_1076 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1075 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14997_ sa00_sr\[1\] sa10_sr\[2\] sa20_sr\[2\] VSS VSS VDD
+ VDD _05893_ sky130_fd_sc_hd__xnor3_2
XTAP_TAPCELL_ROW_44_1074 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14999_ sa10_sr\[1\] sa30_sr\[2\] VSS VSS VDD VDD _05895_
+ sky130_fd_sc_hd__xor2_2
X_15000_ _05893_ _05895_ VSS VSS VDD VDD _05896_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_44_1073 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15002_ text_in_r\[122\] _05896_ net660 VSS VSS VDD VDD _05898_
+ sky130_fd_sc_hd__mux2i_4
X_15003_ u0.w\[0\]\[26\] _05898_ VSS VSS VDD VDD _05899_ sky130_fd_sc_hd__xnor2_4
X_15004_ net471 VSS VSS VDD VDD _05900_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_44_1072 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1071 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1070 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1069 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1068 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1067 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1066 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1065 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1064 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1063 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1062 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1061 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1060 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15018_ sa10_sr\[4\] sa20_sr\[5\] sa30_sr\[5\] VSS VSS VDD
+ VDD _05911_ sky130_fd_sc_hd__xnor3_2
XTAP_TAPCELL_ROW_44_1059 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15020_ sa00_sr\[4\] sa10_sr\[5\] VSS VSS VDD VDD _05913_
+ sky130_fd_sc_hd__xnor2_1
X_15021_ _05911_ _05913_ VSS VSS VDD VDD _05914_ sky130_fd_sc_hd__xnor2_2
X_15022_ net492 _05914_ VSS VSS VDD VDD _05915_ sky130_fd_sc_hd__nor2_1
X_15023_ net492 text_in_r\[125\] _05915_ VSS VSS VDD VDD _05916_
+ sky130_fd_sc_hd__a21oi_4
X_15024_ u0.w\[0\]\[29\] _05916_ VSS VSS VDD VDD _05917_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_44_1058 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1057 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1056 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15028_ net726 net471 VSS VSS VDD VDD _05921_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_43_1055 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15030_ net492 u0.w\[0\]\[27\] VSS VSS VDD VDD _05923_ sky130_fd_sc_hd__nor2b_1
X_15031_ u0.w\[0\]\[27\] net492 VSS VSS VDD VDD _05924_ sky130_fd_sc_hd__nor2_1
X_15032_ sa10_sr\[7\] sa10_sr\[3\] VSS VSS VDD VDD _05925_
+ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_43_1054 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15034_ sa00_sr\[7\] sa00_sr\[2\] sa20_sr\[3\] VSS VSS VDD
+ VDD _05927_ sky130_fd_sc_hd__xnor3_2
XTAP_TAPCELL_ROW_43_1053 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15036_ sa10_sr\[2\] sa30_sr\[3\] VSS VSS VDD VDD _05929_
+ sky130_fd_sc_hd__xnor2_1
X_15037_ _05925_ _05927_ _05929_ VSS VSS VDD VDD _05930_ sky130_fd_sc_hd__xnor3_4
X_15038_ _05923_ _05924_ _05930_ VSS VSS VDD VDD _05931_ sky130_fd_sc_hd__mux2_4
XTAP_TAPCELL_ROW_43_1052 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1051 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15041_ u0.w\[0\]\[27\] net492 VSS VSS VDD VDD _05934_ sky130_fd_sc_hd__nand2_1
X_15042_ u0.w\[0\]\[27\] net492 text_in_r\[123\] VSS VSS VDD
+ VDD _05935_ sky130_fd_sc_hd__nand3b_1
X_15043_ text_in_r\[123\] _05934_ _05935_ VSS VSS VDD VDD
+ _05936_ sky130_fd_sc_hd__o21ai_4
X_15044_ _05931_ _05936_ VSS VSS VDD VDD _05937_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_43_1050 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1049 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15047_ _11966_ _05900_ _05937_ VSS VSS VDD VDD _05940_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_43_1048 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15049_ net731 _05900_ VSS VSS VDD VDD _05942_ sky130_fd_sc_hd__nand2_1
X_15050_ _05923_ _05924_ _05930_ VSS VSS VDD VDD _05943_ sky130_fd_sc_hd__mux2i_4
X_15051_ text_in_r\[123\] _05934_ _05935_ VSS VSS VDD VDD
+ _05944_ sky130_fd_sc_hd__o21a_1
X_15052_ _05943_ _05944_ VSS VSS VDD VDD _05945_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_43_1047 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15054_ _05884_ _05891_ _05899_ VSS VSS VDD VDD _05947_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_43_1046 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15056_ sa00_sr\[7\] sa00_sr\[3\] sa20_sr\[4\] VSS VSS VDD
+ VDD _05949_ sky130_fd_sc_hd__xnor3_1
X_15057_ sa10_sr\[4\] sa30_sr\[4\] VSS VSS VDD VDD _05950_
+ sky130_fd_sc_hd__xnor2_1
X_15058_ _05949_ _05925_ _05950_ VSS VSS VDD VDD _05951_ sky130_fd_sc_hd__xnor3_4
XTAP_TAPCELL_ROW_43_1045 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15060_ text_in_r\[124\] _05951_ net512 VSS VSS VDD VDD _05953_
+ sky130_fd_sc_hd__mux2i_4
X_15061_ u0.w\[0\]\[28\] _05953_ VSS VSS VDD VDD _05954_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_43_1044 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15063_ _05942_ _05945_ _05947_ net469 VSS VSS VDD VDD _05956_
+ sky130_fd_sc_hd__a31oi_4
X_15064_ _05921_ _05940_ _05956_ VSS VSS VDD VDD _05957_ sky130_fd_sc_hd__o21ai_0
X_15065_ u0.w\[0\]\[28\] _05953_ VSS VSS VDD VDD _05958_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_43_1043 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15067_ _05917_ _05958_ VSS VSS VDD VDD _05960_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_43_1042 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15069_ _05884_ _05937_ VSS VSS VDD VDD _05962_ sky130_fd_sc_hd__nor2_1
X_15070_ net471 _05945_ VSS VSS VDD VDD _05963_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_43_1041 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15072_ _05942_ _05962_ _05963_ _11969_ VSS VSS VDD VDD _05965_
+ sky130_fd_sc_hd__o22a_1
X_15073_ _05917_ _05957_ _05960_ _05965_ VSS VSS VDD VDD _05966_
+ sky130_fd_sc_hd__o22ai_1
XTAP_TAPCELL_ROW_43_1040 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1039 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1038 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15077_ sa10_sr\[7\] sa20_sr\[7\] VSS VSS VDD VDD _05970_
+ sky130_fd_sc_hd__xnor2_4
X_15078_ sa00_sr\[6\] _05970_ VSS VSS VDD VDD _05971_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_43_1037 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1036 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15081_ sa10_sr\[6\] sa30_sr\[7\] VSS VSS VDD VDD _05974_
+ sky130_fd_sc_hd__xnor2_2
X_15082_ _05971_ _05974_ VSS VSS VDD VDD _05975_ sky130_fd_sc_hd__xnor2_1
X_15083_ net547 _05975_ VSS VSS VDD VDD _05976_ sky130_fd_sc_hd__nand2_4
X_15084_ net512 text_in_r\[127\] _05976_ VSS VSS VDD VDD _05977_
+ sky130_fd_sc_hd__o21ai_4
X_15085_ u0.w\[0\]\[31\] _05977_ VSS VSS VDD VDD _05978_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_43_1035 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1034 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_1033 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15089_ sa10_sr\[5\] sa20_sr\[6\] sa30_sr\[6\] VSS VSS VDD
+ VDD _05982_ sky130_fd_sc_hd__xnor3_1
XTAP_TAPCELL_ROW_42_1032 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15091_ sa00_sr\[5\] sa10_sr\[6\] VSS VSS VDD VDD _05984_
+ sky130_fd_sc_hd__xnor2_1
X_15092_ _05982_ _05984_ VSS VSS VDD VDD _05985_ sky130_fd_sc_hd__xnor2_1
X_15093_ net492 _05985_ VSS VSS VDD VDD _05986_ sky130_fd_sc_hd__nor2_2
X_15094_ net492 text_in_r\[126\] _05986_ VSS VSS VDD VDD _05987_
+ sky130_fd_sc_hd__a21oi_4
X_15095_ u0.w\[0\]\[30\] _05987_ VSS VSS VDD VDD _05988_ sky130_fd_sc_hd__xnor2_4
X_15096_ _05978_ _05988_ VSS VSS VDD VDD _05989_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_42_1031 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15098_ _05900_ _05937_ VSS VSS VDD VDD _05991_ sky130_fd_sc_hd__nor2_8
X_15099_ net472 _05937_ VSS VSS VDD VDD _05992_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_42_1030 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15101_ _11978_ _05945_ VSS VSS VDD VDD _05994_ sky130_fd_sc_hd__nand2_4
X_15102_ _05992_ _05994_ _05899_ VSS VSS VDD VDD _05995_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_42_1029 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15104_ net738 _05945_ VSS VSS VDD VDD _05997_ sky130_fd_sc_hd__nor2_4
X_15105_ _11965_ _05991_ _05995_ _05997_ VSS VSS VDD VDD _05998_
+ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_42_1028 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15107_ _05884_ _05937_ VSS VSS VDD VDD _06000_ sky130_fd_sc_hd__nand2_2
X_15108_ _05899_ _05994_ _06000_ VSS VSS VDD VDD _06001_ sky130_fd_sc_hd__nand3_1
X_15109_ net513 _05900_ _05992_ _05917_ VSS VSS VDD VDD _06002_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_42_1027 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15111_ _05917_ _05998_ _06001_ _06002_ _05958_ VSS VSS VDD
+ VDD _06004_ sky130_fd_sc_hd__a221oi_2
X_15112_ _05966_ _05989_ _06004_ VSS VSS VDD VDD _06005_ sky130_fd_sc_hd__or3_1
X_15113_ _05917_ _05978_ VSS VSS VDD VDD _06006_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_42_1026 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15115_ net724 _05891_ _05900_ VSS VSS VDD VDD _06008_ sky130_fd_sc_hd__nor3_2
X_15116_ _11969_ net471 VSS VSS VDD VDD _06009_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_42_1025 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15118_ _05945_ _06008_ _06009_ net468 VSS VSS VDD VDD _06011_
+ sky130_fd_sc_hd__o31ai_4
XTAP_TAPCELL_ROW_42_1024 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15120_ _11964_ _05963_ VSS VSS VDD VDD _06013_ sky130_fd_sc_hd__nor2_1
X_15121_ _05891_ _05945_ VSS VSS VDD VDD _06014_ sky130_fd_sc_hd__nand2_2
X_15122_ _11966_ _05937_ VSS VSS VDD VDD _06015_ sky130_fd_sc_hd__nand2_2
X_15123_ _06014_ _06015_ _05899_ VSS VSS VDD VDD _06016_ sky130_fd_sc_hd__a21oi_1
X_15124_ _06011_ _06013_ _06016_ VSS VSS VDD VDD _06017_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_42_1023 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15126_ _05899_ _05945_ VSS VSS VDD VDD _06019_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_42_1022 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15128_ _11985_ _05945_ _06019_ _11965_ _05958_ VSS VSS VDD
+ VDD _06021_ sky130_fd_sc_hd__a221oi_1
X_15129_ _05988_ _06017_ _06021_ VSS VSS VDD VDD _06022_ sky130_fd_sc_hd__nor3_1
X_15130_ net731 _05945_ VSS VSS VDD VDD _06023_ sky130_fd_sc_hd__nand2_4
X_15131_ net469 _06023_ VSS VSS VDD VDD _06024_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_42_1021 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15133_ _11969_ _05945_ VSS VSS VDD VDD _06026_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_42_1020 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15135_ _11965_ _05945_ VSS VSS VDD VDD _06028_ sky130_fd_sc_hd__nand2_2
X_15136_ _11974_ _05937_ VSS VSS VDD VDD _06029_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_42_1019 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_1018 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15139_ _06028_ _06029_ _05900_ VSS VSS VDD VDD _06032_ sky130_fd_sc_hd__a21oi_1
X_15140_ net468 _06032_ VSS VSS VDD VDD _06033_ sky130_fd_sc_hd__nor2_1
X_15141_ net470 _06024_ _06026_ _05956_ _06033_ VSS VSS VDD
+ VDD _06034_ sky130_fd_sc_hd__o32ai_2
X_15142_ u0.w\[0\]\[29\] _05916_ VSS VSS VDD VDD _06035_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_42_1017 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15144_ _06035_ _05988_ VSS VSS VDD VDD _06037_ sky130_fd_sc_hd__nand2_2
X_15145_ _05978_ _06037_ VSS VSS VDD VDD _06038_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_42_1016 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15147_ _05943_ _05944_ _11972_ VSS VSS VDD VDD _06040_ sky130_fd_sc_hd__a21oi_1
X_15148_ _11965_ _05931_ _05936_ VSS VSS VDD VDD _06041_ sky130_fd_sc_hd__nor3_4
X_15149_ net471 _06040_ _06041_ VSS VSS VDD VDD _06042_ sky130_fd_sc_hd__nor3_1
X_15150_ net470 _05992_ _06014_ _06042_ VSS VSS VDD VDD _06043_
+ sky130_fd_sc_hd__a31oi_1
X_15151_ _11969_ _05945_ VSS VSS VDD VDD _06044_ sky130_fd_sc_hd__nand2_2
X_15152_ _05899_ _06015_ _06044_ VSS VSS VDD VDD _06045_ sky130_fd_sc_hd__nand3_2
X_15153_ _11964_ _06019_ _05958_ VSS VSS VDD VDD _06046_ sky130_fd_sc_hd__a21oi_1
X_15154_ u0.w\[0\]\[30\] _05987_ VSS VSS VDD VDD _06047_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_42_1015 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15156_ _05958_ _06043_ _06045_ _06046_ _06047_ VSS VSS VDD
+ VDD _06049_ sky130_fd_sc_hd__a221oi_1
X_15157_ _11966_ _05945_ VSS VSS VDD VDD _06050_ sky130_fd_sc_hd__nand2_1
X_15158_ net472 _05891_ _05937_ VSS VSS VDD VDD _06051_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_42_1014 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15160_ _06050_ _06051_ _05900_ VSS VSS VDD VDD _06053_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_42_1013 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15162_ _05954_ _06047_ VSS VSS VDD VDD _06055_ sky130_fd_sc_hd__nand2_1
X_15163_ _05900_ _05937_ VSS VSS VDD VDD _06056_ sky130_fd_sc_hd__nand2_2
X_15164_ _11972_ _06056_ VSS VSS VDD VDD _06057_ sky130_fd_sc_hd__nor2_1
X_15165_ _06053_ _06055_ _06057_ VSS VSS VDD VDD _06058_ sky130_fd_sc_hd__nor3_1
X_15166_ u0.w\[0\]\[31\] _05977_ VSS VSS VDD VDD _06059_ sky130_fd_sc_hd__xnor2_4
X_15167_ _05917_ _06059_ VSS VSS VDD VDD _06060_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_42_1012 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15169_ net725 _05891_ VSS VSS VDD VDD _06062_ sky130_fd_sc_hd__nor2_1
X_15170_ _05900_ _05945_ VSS VSS VDD VDD _06063_ sky130_fd_sc_hd__nor2_2
X_15171_ _11966_ _06063_ _05988_ net469 VSS VSS VDD VDD _06064_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_42_1011 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15173_ _05899_ _05937_ VSS VSS VDD VDD _06066_ sky130_fd_sc_hd__nor2_4
X_15174_ _11974_ _06066_ VSS VSS VDD VDD _06067_ sky130_fd_sc_hd__nand2_1
X_15175_ _05963_ _06062_ _06064_ _06067_ VSS VSS VDD VDD _06068_
+ sky130_fd_sc_hd__o211a_1
X_15176_ _06049_ _06058_ _06060_ _06068_ VSS VSS VDD VDD _06069_
+ sky130_fd_sc_hd__nor4_1
X_15177_ _06006_ _06022_ _06034_ _06038_ _06069_ VSS VSS VDD
+ VDD _06070_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_42_1010 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15179_ _05917_ _05988_ VSS VSS VDD VDD _06072_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_41_1009 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15181_ _05884_ net470 VSS VSS VDD VDD _06074_ sky130_fd_sc_hd__nor2_1
X_15182_ _11965_ _05937_ VSS VSS VDD VDD _06075_ sky130_fd_sc_hd__nand2_2
X_15183_ _11965_ net470 VSS VSS VDD VDD _06076_ sky130_fd_sc_hd__nor2_2
X_15184_ _06074_ _06075_ _06076_ _05992_ VSS VSS VDD VDD _06077_
+ sky130_fd_sc_hd__a2bb2oi_1
X_15185_ _05900_ _05937_ VSS VSS VDD VDD _06078_ sky130_fd_sc_hd__xnor2_4
X_15186_ _11964_ _06078_ VSS VSS VDD VDD _06079_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_41_1008 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15188_ _11965_ _05991_ _06057_ _06079_ net469 VSS VSS VDD
+ VDD _06081_ sky130_fd_sc_hd__a2111oi_0
X_15189_ net469 _06077_ _06081_ VSS VSS VDD VDD _06082_ sky130_fd_sc_hd__a21oi_1
X_15190_ _11965_ VSS VSS VDD VDD _06083_ sky130_fd_sc_hd__clkinvlp_4
X_15191_ _06083_ _05937_ VSS VSS VDD VDD _06084_ sky130_fd_sc_hd__nand2_2
X_15192_ _11972_ _05945_ VSS VSS VDD VDD _06085_ sky130_fd_sc_hd__nand2_4
X_15193_ _05884_ _05997_ VSS VSS VDD VDD _06086_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_41_1007 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15195_ _11964_ _05945_ net471 VSS VSS VDD VDD _06088_ sky130_fd_sc_hd__a21oi_1
X_15196_ net471 _06084_ _06085_ _06086_ _06088_ VSS VSS VDD
+ VDD _06089_ sky130_fd_sc_hd__a32oi_1
X_15197_ _05891_ _05899_ VSS VSS VDD VDD _06090_ sky130_fd_sc_hd__nand2_4
X_15198_ net724 net731 VSS VSS VDD VDD _06091_ sky130_fd_sc_hd__nand2_2
X_15199_ _06090_ _06091_ _05937_ VSS VSS VDD VDD _06092_ sky130_fd_sc_hd__a21oi_1
X_15200_ _05937_ _06090_ _06091_ VSS VSS VDD VDD _06093_ sky130_fd_sc_hd__and3_1
X_15201_ _05958_ _06092_ _06093_ VSS VSS VDD VDD _06094_ sky130_fd_sc_hd__nor3_1
X_15202_ _05978_ _06047_ VSS VSS VDD VDD _06095_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_41_1006 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15204_ _05958_ _06089_ _06094_ _06095_ _06035_ VSS VSS VDD
+ VDD _06097_ sky130_fd_sc_hd__a2111oi_1
X_15205_ _05978_ _06072_ _06082_ _06097_ VSS VSS VDD VDD _06098_
+ sky130_fd_sc_hd__a31oi_1
X_15206_ _06005_ _06070_ _06098_ VSS VSS VDD VDD _00032_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_41_1005 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_1004 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_1003 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15210_ _06083_ _05899_ VSS VSS VDD VDD _06102_ sky130_fd_sc_hd__nor2_1
X_15211_ _11978_ _05899_ _06102_ VSS VSS VDD VDD _06103_ sky130_fd_sc_hd__a21oi_1
X_15212_ _05937_ _06103_ _06011_ VSS VSS VDD VDD _06104_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_41_1002 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15214_ _11969_ _06056_ _06078_ net472 VSS VSS VDD VDD _06105_
+ sky130_fd_sc_hd__o22ai_1
X_15215_ net469 _06105_ VSS VSS VDD VDD _06106_ sky130_fd_sc_hd__nand2_1
X_15216_ _05899_ _05958_ VSS VSS VDD VDD _06107_ sky130_fd_sc_hd__nand2_1
X_15217_ net513 _06066_ VSS VSS VDD VDD _06108_ sky130_fd_sc_hd__nand2_1
X_15218_ _06107_ _06108_ net472 VSS VSS VDD VDD _06109_ sky130_fd_sc_hd__a21oi_1
X_15219_ _05899_ _05958_ VSS VSS VDD VDD _06110_ sky130_fd_sc_hd__nor2_1
X_15220_ net469 _05945_ VSS VSS VDD VDD _06111_ sky130_fd_sc_hd__nor2_1
X_15221_ _05945_ _06110_ _06111_ net472 VSS VSS VDD VDD _06112_
+ sky130_fd_sc_hd__a22oi_1
X_15222_ _05891_ _06112_ VSS VSS VDD VDD _06113_ sky130_fd_sc_hd__nor2_1
X_15223_ _05891_ _05900_ VSS VSS VDD VDD _06114_ sky130_fd_sc_hd__nand2_4
X_15224_ net469 _05937_ VSS VSS VDD VDD _06115_ sky130_fd_sc_hd__nand2_1
X_15225_ _06083_ _05958_ _05945_ VSS VSS VDD VDD _06116_ sky130_fd_sc_hd__o21ai_0
X_15226_ _11969_ _06115_ _06116_ VSS VSS VDD VDD _06117_ sky130_fd_sc_hd__o21a_1
X_15227_ _06114_ _06115_ _06117_ _05900_ VSS VSS VDD VDD _06118_
+ sky130_fd_sc_hd__o22ai_1
X_15228_ _06060_ _06109_ _06113_ _06118_ VSS VSS VDD VDD _06119_
+ sky130_fd_sc_hd__nor4_1
X_15229_ _06006_ _06104_ _06106_ _06119_ VSS VSS VDD VDD _06120_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_41_1001 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15231_ _11972_ _05900_ _05945_ VSS VSS VDD VDD _06122_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_41_1000 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15233_ _05947_ _06122_ _05954_ VSS VSS VDD VDD _06124_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_41_999 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_998 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15236_ _11988_ _05937_ VSS VSS VDD VDD _06127_ sky130_fd_sc_hd__nor2_1
X_15237_ _06035_ _06127_ _05988_ VSS VSS VDD VDD _06128_ sky130_fd_sc_hd__a21oi_2
X_15238_ _05884_ _05945_ VSS VSS VDD VDD _06129_ sky130_fd_sc_hd__nand2_4
X_15239_ _05992_ _06129_ net470 VSS VSS VDD VDD _06130_ sky130_fd_sc_hd__a21oi_2
X_15240_ net736 _05937_ VSS VSS VDD VDD _06131_ sky130_fd_sc_hd__nand2_1
X_15241_ _06044_ _06131_ _05900_ VSS VSS VDD VDD _06132_ sky130_fd_sc_hd__a21oi_2
X_15242_ _06130_ _06132_ _06035_ VSS VSS VDD VDD _06133_ sky130_fd_sc_hd__o21ai_4
X_15243_ net731 net471 VSS VSS VDD VDD _06134_ sky130_fd_sc_hd__nand2_1
X_15244_ _11964_ _05900_ VSS VSS VDD VDD _06135_ sky130_fd_sc_hd__nand2_1
X_15245_ _06134_ _06135_ _05945_ VSS VSS VDD VDD _06136_ sky130_fd_sc_hd__a21o_1
X_15246_ net724 _05937_ VSS VSS VDD VDD _06137_ sky130_fd_sc_hd__nor2_2
X_15247_ _06134_ _06137_ _06114_ _06035_ VSS VSS VDD VDD _06138_
+ sky130_fd_sc_hd__a31oi_1
X_15248_ _06136_ _06138_ _06055_ VSS VSS VDD VDD _06139_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_41_997 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15250_ _06124_ _06128_ _06133_ _06139_ _06059_ VSS VSS VDD
+ VDD _06141_ sky130_fd_sc_hd__a221oi_4
X_15251_ _06047_ _06141_ VSS VSS VDD VDD _06142_ sky130_fd_sc_hd__nand2_1
X_15252_ _06059_ _05988_ VSS VSS VDD VDD _06143_ sky130_fd_sc_hd__nand2_2
X_15253_ net724 _05900_ VSS VSS VDD VDD _06144_ sky130_fd_sc_hd__nor2_2
X_15254_ _11978_ _05900_ _06144_ VSS VSS VDD VDD _06145_ sky130_fd_sc_hd__a21oi_1
X_15255_ net468 _05937_ _06145_ VSS VSS VDD VDD _06146_ sky130_fd_sc_hd__nor3_1
X_15256_ net728 net513 VSS VSS VDD VDD _06147_ sky130_fd_sc_hd__nor2_2
X_15257_ _11969_ _05954_ _06063_ VSS VSS VDD VDD _06148_ sky130_fd_sc_hd__o21ai_0
X_15258_ _06147_ _06148_ _05917_ VSS VSS VDD VDD _06149_ sky130_fd_sc_hd__o21ai_0
X_15259_ net728 net737 _05945_ VSS VSS VDD VDD _06150_ sky130_fd_sc_hd__o21ai_4
X_15260_ _06083_ _05945_ VSS VSS VDD VDD _06151_ sky130_fd_sc_hd__nand2_4
X_15261_ _11969_ _05937_ VSS VSS VDD VDD _06152_ sky130_fd_sc_hd__nand2_1
X_15262_ _05899_ _06151_ _06152_ VSS VSS VDD VDD _06153_ sky130_fd_sc_hd__and3_1
X_15263_ _05900_ _06150_ _06153_ _05954_ VSS VSS VDD VDD _06154_
+ sky130_fd_sc_hd__a211oi_1
X_15264_ _06146_ _06149_ _06154_ VSS VSS VDD VDD _06155_ sky130_fd_sc_hd__nor3_1
X_15265_ net735 _05937_ VSS VSS VDD VDD _06156_ sky130_fd_sc_hd__nor2_2
X_15266_ _05891_ _06078_ VSS VSS VDD VDD _06157_ sky130_fd_sc_hd__nor2_1
X_15267_ net472 _06156_ _06019_ _11965_ _06157_ VSS VSS VDD
+ VDD _06158_ sky130_fd_sc_hd__a221oi_1
X_15268_ _05891_ _05937_ VSS VSS VDD VDD _06159_ sky130_fd_sc_hd__nand2_4
X_15269_ _11964_ _05937_ VSS VSS VDD VDD _06160_ sky130_fd_sc_hd__nand2_4
X_15270_ _06028_ _06160_ _05900_ VSS VSS VDD VDD _06161_ sky130_fd_sc_hd__a21oi_1
X_15271_ _05900_ _06159_ _06044_ _06161_ net468 VSS VSS VDD
+ VDD _06162_ sky130_fd_sc_hd__a311oi_1
X_15272_ net468 _06158_ _06162_ _05917_ VSS VSS VDD VDD _06163_
+ sky130_fd_sc_hd__a211oi_1
X_15273_ _06143_ _06155_ _06163_ VSS VSS VDD VDD _06164_ sky130_fd_sc_hd__or3_1
X_15274_ _11965_ _05937_ VSS VSS VDD VDD _06165_ sky130_fd_sc_hd__nor2_1
X_15275_ _11978_ _05937_ VSS VSS VDD VDD _06166_ sky130_fd_sc_hd__nand2_2
X_15276_ _05899_ _06166_ VSS VSS VDD VDD _06167_ sky130_fd_sc_hd__nand2_1
X_15277_ _06165_ _06167_ _06035_ net469 VSS VSS VDD VDD _06168_
+ sky130_fd_sc_hd__o211ai_1
X_15278_ _05900_ _06015_ _06150_ _06168_ VSS VSS VDD VDD _06169_
+ sky130_fd_sc_hd__a31oi_1
X_15279_ _06086_ _06151_ _05900_ VSS VSS VDD VDD _06170_ sky130_fd_sc_hd__a21oi_1
X_15280_ net513 _06019_ _05917_ VSS VSS VDD VDD _06171_ sky130_fd_sc_hd__a21oi_1
X_15281_ net469 _06170_ _06171_ VSS VSS VDD VDD _06172_ sky130_fd_sc_hd__nor3b_1
X_15282_ _11964_ _05945_ _06129_ VSS VSS VDD VDD _06173_ sky130_fd_sc_hd__o21ai_0
X_15283_ _05900_ _06173_ _06132_ VSS VSS VDD VDD _06174_ sky130_fd_sc_hd__a21oi_1
X_15284_ _05917_ _05954_ VSS VSS VDD VDD _06175_ sky130_fd_sc_hd__nand2_4
X_15285_ _06159_ _06028_ VSS VSS VDD VDD _06176_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_41_996 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15287_ _11966_ _05945_ VSS VSS VDD VDD _06178_ sky130_fd_sc_hd__nor2_1
X_15288_ _11964_ _05945_ _06178_ _05900_ VSS VSS VDD VDD _06179_
+ sky130_fd_sc_hd__a211oi_1
X_15289_ _05900_ _06176_ _06179_ VSS VSS VDD VDD _06180_ sky130_fd_sc_hd__a21oi_1
X_15290_ _05960_ _06174_ _06175_ _06180_ VSS VSS VDD VDD _06181_
+ sky130_fd_sc_hd__o22ai_2
X_15291_ _06169_ _06172_ _06181_ _06141_ VSS VSS VDD VDD _06182_
+ sky130_fd_sc_hd__o31ai_1
X_15292_ _05988_ _06120_ _06142_ _06164_ _06182_ VSS VSS VDD
+ VDD _00033_ sky130_fd_sc_hd__o2111ai_2
X_15293_ _11978_ _05931_ _05936_ VSS VSS VDD VDD _06183_ sky130_fd_sc_hd__or3_1
X_15294_ _11974_ _05937_ VSS VSS VDD VDD _06184_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_41_995 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15296_ _06184_ _05900_ _06131_ VSS VSS VDD VDD _06186_ sky130_fd_sc_hd__nor3b_1
X_15297_ _05900_ _06129_ _06183_ _06186_ VSS VSS VDD VDD _06187_
+ sky130_fd_sc_hd__a31oi_1
X_15298_ net726 _05945_ VSS VSS VDD VDD _06188_ sky130_fd_sc_hd__nor2_1
X_15299_ _11966_ _05937_ VSS VSS VDD VDD _06189_ sky130_fd_sc_hd__nor2_1
X_15300_ net471 _06188_ _06189_ VSS VSS VDD VDD _06190_ sky130_fd_sc_hd__nor3_1
X_15301_ _06014_ _06075_ _05900_ VSS VSS VDD VDD _06191_ sky130_fd_sc_hd__a21oi_2
X_15302_ _05988_ _06190_ _06191_ VSS VSS VDD VDD _06192_ sky130_fd_sc_hd__nor3_1
X_15303_ _05988_ _06187_ _06192_ VSS VSS VDD VDD _06193_ sky130_fd_sc_hd__a21oi_1
X_15304_ _06008_ _06009_ _05945_ VSS VSS VDD VDD _06194_ sky130_fd_sc_hd__o21ai_0
X_15305_ net468 _06194_ VSS VSS VDD VDD _06195_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_41_994 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15307_ _05945_ _06102_ _06144_ VSS VSS VDD VDD _06197_ sky130_fd_sc_hd__nor3_1
X_15308_ _06137_ _06114_ net468 VSS VSS VDD VDD _06198_ sky130_fd_sc_hd__a21oi_1
X_15309_ _11969_ net470 VSS VSS VDD VDD _06199_ sky130_fd_sc_hd__nand2_1
X_15310_ _11978_ _05900_ _05945_ VSS VSS VDD VDD _06200_ sky130_fd_sc_hd__a21oi_1
X_15311_ _06199_ _06200_ VSS VSS VDD VDD _06201_ sky130_fd_sc_hd__nand2_1
X_15312_ _06198_ _06201_ VSS VSS VDD VDD _06202_ sky130_fd_sc_hd__nand2_1
X_15313_ _06195_ _06197_ _06072_ _06202_ VSS VSS VDD VDD _06203_
+ sky130_fd_sc_hd__o211ai_1
X_15314_ _06175_ _06193_ _06203_ VSS VSS VDD VDD _06204_ sky130_fd_sc_hd__o21ai_0
X_15315_ _05900_ _06176_ VSS VSS VDD VDD _06205_ sky130_fd_sc_hd__nor2_1
X_15316_ _05900_ _06029_ _06151_ _06205_ _06047_ VSS VSS VDD
+ VDD _06206_ sky130_fd_sc_hd__a311oi_1
X_15317_ _11978_ _05963_ _06047_ VSS VSS VDD VDD _06207_ sky130_fd_sc_hd__o21ai_0
X_15318_ _05921_ _06159_ _06023_ _06207_ VSS VSS VDD VDD _06208_
+ sky130_fd_sc_hd__a31oi_2
X_15319_ _11969_ _05937_ VSS VSS VDD VDD _06209_ sky130_fd_sc_hd__nor2_1
X_15320_ _11978_ _05945_ VSS VSS VDD VDD _06210_ sky130_fd_sc_hd__nor2_2
X_15321_ _11974_ _05945_ _06023_ net470 VSS VSS VDD VDD _06211_
+ sky130_fd_sc_hd__o211ai_1
X_15322_ net470 _06209_ _06210_ _06211_ VSS VSS VDD VDD _06212_
+ sky130_fd_sc_hd__o31ai_1
X_15323_ net471 _06029_ _06129_ _05954_ _06009_ VSS VSS VDD
+ VDD _06213_ sky130_fd_sc_hd__a311oi_1
X_15324_ _05954_ _06212_ _06213_ _06037_ VSS VSS VDD VDD _06214_
+ sky130_fd_sc_hd__a211o_1
X_15325_ _05960_ _06206_ _06208_ _06214_ _05978_ VSS VSS VDD
+ VDD _06215_ sky130_fd_sc_hd__o311ai_2
X_15326_ net471 _05992_ _06085_ VSS VSS VDD VDD _06216_ sky130_fd_sc_hd__nand3_1
X_15327_ _05900_ _06160_ _06151_ VSS VSS VDD VDD _06217_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_41_993 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15329_ _06216_ _06217_ net468 VSS VSS VDD VDD _06219_ sky130_fd_sc_hd__a21oi_1
X_15330_ _05958_ _05945_ VSS VSS VDD VDD _06220_ sky130_fd_sc_hd__nand2_1
X_15331_ _06220_ _06144_ VSS VSS VDD VDD _06221_ sky130_fd_sc_hd__nor2_1
X_15332_ _06091_ _06221_ _06037_ VSS VSS VDD VDD _06222_ sky130_fd_sc_hd__a21oi_1
X_15333_ _11988_ _05954_ _05945_ _06222_ VSS VSS VDD VDD _06223_
+ sky130_fd_sc_hd__o31ai_1
X_15334_ _06188_ _06074_ _11965_ VSS VSS VDD VDD _06224_ sky130_fd_sc_hd__o21ai_0
X_15335_ _05962_ _06090_ _06014_ _06144_ VSS VSS VDD VDD _06225_
+ sky130_fd_sc_hd__a22oi_1
X_15336_ _06224_ _06225_ net468 VSS VSS VDD VDD _06226_ sky130_fd_sc_hd__a21oi_1
X_15337_ _05937_ _06008_ _06076_ VSS VSS VDD VDD _06227_ sky130_fd_sc_hd__nor3_1
X_15338_ _11985_ _05937_ _06227_ _05954_ VSS VSS VDD VDD _06228_
+ sky130_fd_sc_hd__a211oi_1
X_15339_ _06035_ _06047_ VSS VSS VDD VDD _06229_ sky130_fd_sc_hd__nor2_1
X_15340_ _06226_ _06228_ _06229_ VSS VSS VDD VDD _06230_ sky130_fd_sc_hd__o21ai_0
X_15341_ _06219_ _06223_ _06230_ _06059_ VSS VSS VDD VDD _06231_
+ sky130_fd_sc_hd__o211ai_1
X_15342_ net471 _06160_ _06151_ _06066_ _11969_ VSS VSS VDD
+ VDD _06232_ sky130_fd_sc_hd__a32oi_1
X_15343_ _11983_ _05937_ VSS VSS VDD VDD _06233_ sky130_fd_sc_hd__nor2_1
X_15344_ _05900_ _06062_ _05945_ VSS VSS VDD VDD _06234_ sky130_fd_sc_hd__a21oi_1
X_15345_ _06233_ _06234_ _06035_ VSS VSS VDD VDD _06235_ sky130_fd_sc_hd__o21ai_0
X_15346_ _06035_ _06232_ _06235_ VSS VSS VDD VDD _06236_ sky130_fd_sc_hd__o21ai_0
X_15347_ _05945_ _06147_ VSS VSS VDD VDD _06237_ sky130_fd_sc_hd__nor2_1
X_15348_ _11966_ _11969_ VSS VSS VDD VDD _06238_ sky130_fd_sc_hd__nor2_4
X_15349_ _05937_ _06238_ VSS VSS VDD VDD _06239_ sky130_fd_sc_hd__nor2_2
X_15350_ _05900_ _06237_ _06239_ VSS VSS VDD VDD _06240_ sky130_fd_sc_hd__nor3_1
X_15351_ _11972_ _05945_ _06150_ VSS VSS VDD VDD _06241_ sky130_fd_sc_hd__o21ai_0
X_15352_ net471 _06241_ VSS VSS VDD VDD _06242_ sky130_fd_sc_hd__nor2_1
X_15353_ _11992_ _05945_ _06198_ _06035_ VSS VSS VDD VDD _06243_
+ sky130_fd_sc_hd__o211ai_1
X_15354_ _06175_ _06240_ _06242_ _06243_ _06047_ VSS VSS VDD
+ VDD _06244_ sky130_fd_sc_hd__o311ai_0
X_15355_ net468 _06236_ _06244_ VSS VSS VDD VDD _06245_ sky130_fd_sc_hd__a21oi_1
X_15356_ _06204_ _06215_ _06231_ _06245_ VSS VSS VDD VDD _00034_
+ sky130_fd_sc_hd__o22ai_1
X_15357_ _05900_ _05958_ VSS VSS VDD VDD _06246_ sky130_fd_sc_hd__nand2_1
X_15358_ _05900_ net469 VSS VSS VDD VDD _06247_ sky130_fd_sc_hd__nor2_1
X_15359_ _06110_ _06247_ VSS VSS VDD VDD _06248_ sky130_fd_sc_hd__nor2_1
X_15360_ _05884_ _06246_ _06248_ _11965_ _05945_ VSS VSS VDD
+ VDD _06249_ sky130_fd_sc_hd__o221ai_1
X_15361_ net513 _05958_ _05899_ VSS VSS VDD VDD _06250_ sky130_fd_sc_hd__a21oi_1
X_15362_ net472 net469 VSS VSS VDD VDD _06251_ sky130_fd_sc_hd__nand2_1
X_15363_ net472 _06250_ _06251_ _05937_ _06090_ VSS VSS VDD
+ VDD _06252_ sky130_fd_sc_hd__o2111ai_1
X_15364_ _05958_ _06090_ _06006_ _06249_ _06252_ VSS VSS VDD
+ VDD _06253_ sky130_fd_sc_hd__o2111ai_1
X_15365_ _11964_ _05937_ VSS VSS VDD VDD _06254_ sky130_fd_sc_hd__nor2_1
X_15366_ _11972_ _05945_ VSS VSS VDD VDD _06255_ sky130_fd_sc_hd__nor2_1
X_15367_ _05900_ _06254_ _06255_ VSS VSS VDD VDD _06256_ sky130_fd_sc_hd__nor3_1
X_15368_ _05900_ _06159_ _06151_ _06256_ _05958_ VSS VSS VDD
+ VDD _06257_ sky130_fd_sc_hd__a311oi_1
X_15369_ _05994_ _06084_ _06107_ VSS VSS VDD VDD _06258_ sky130_fd_sc_hd__a21oi_1
X_15370_ _06000_ _06044_ _06246_ VSS VSS VDD VDD _06259_ sky130_fd_sc_hd__a21oi_1
X_15371_ _06060_ _06257_ _06258_ _06259_ VSS VSS VDD VDD _06260_
+ sky130_fd_sc_hd__or4_1
X_15372_ _06253_ _06260_ _05988_ VSS VSS VDD VDD _06261_ sky130_fd_sc_hd__a21oi_1
X_15373_ _06041_ _06184_ net470 VSS VSS VDD VDD _06262_ sky130_fd_sc_hd__o21ai_1
X_15374_ _06156_ _06210_ _05900_ VSS VSS VDD VDD _06263_ sky130_fd_sc_hd__o21ai_0
X_15375_ _06262_ _06263_ VSS VSS VDD VDD _06264_ sky130_fd_sc_hd__nand2_2
X_15376_ _05899_ _05992_ net513 VSS VSS VDD VDD _06265_ sky130_fd_sc_hd__a21oi_1
X_15377_ _05884_ _06019_ _06013_ _06265_ VSS VSS VDD VDD _06266_
+ sky130_fd_sc_hd__a211oi_1
X_15378_ _06175_ _06264_ _06266_ _05960_ VSS VSS VDD VDD _06267_
+ sky130_fd_sc_hd__o22ai_1
X_15379_ _05899_ _06238_ _05937_ VSS VSS VDD VDD _06268_ sky130_fd_sc_hd__a21oi_1
X_15380_ _11974_ _05899_ _06268_ VSS VSS VDD VDD _06269_ sky130_fd_sc_hd__o21ai_0
X_15381_ net733 _05900_ VSS VSS VDD VDD _06270_ sky130_fd_sc_hd__nor2_4
X_15382_ _11978_ _05900_ _06270_ _06115_ VSS VSS VDD VDD _06271_
+ sky130_fd_sc_hd__a211oi_1
X_15383_ _06124_ _06269_ _06271_ _05917_ VSS VSS VDD VDD _06272_
+ sky130_fd_sc_hd__a211oi_1
X_15384_ _05989_ _06267_ _06272_ VSS VSS VDD VDD _06273_ sky130_fd_sc_hd__nor3_1
X_15385_ _05900_ _05958_ VSS VSS VDD VDD _06274_ sky130_fd_sc_hd__nor2_1
X_15386_ _06035_ _06084_ _06050_ VSS VSS VDD VDD _06275_ sky130_fd_sc_hd__o21ai_0
X_15387_ _05937_ _06270_ VSS VSS VDD VDD _06276_ sky130_fd_sc_hd__nand2_1
X_15388_ _11974_ _06078_ VSS VSS VDD VDD _06277_ sky130_fd_sc_hd__nand2_1
X_15389_ _05945_ _06238_ _06041_ _05900_ VSS VSS VDD VDD _06278_
+ sky130_fd_sc_hd__a211oi_1
X_15390_ _05994_ _06159_ _05899_ VSS VSS VDD VDD _06279_ sky130_fd_sc_hd__a21oi_1
X_15391_ _05917_ _06278_ _06279_ VSS VSS VDD VDD _06280_ sky130_fd_sc_hd__nor3_1
X_15392_ _05917_ _06276_ _06277_ net469 _06280_ VSS VSS VDD
+ VDD _06281_ sky130_fd_sc_hd__a311oi_1
X_15393_ net472 _06063_ VSS VSS VDD VDD _06282_ sky130_fd_sc_hd__nand2_1
X_15394_ _06165_ _06255_ _05900_ VSS VSS VDD VDD _06283_ sky130_fd_sc_hd__o21ai_0
X_15395_ _06282_ _06283_ _05917_ _05958_ VSS VSS VDD VDD _06284_
+ sky130_fd_sc_hd__a211oi_1
X_15396_ _06274_ _06275_ _06281_ _06284_ _06095_ VSS VSS VDD
+ VDD _06285_ sky130_fd_sc_hd__a2111oi_1
X_15397_ _05900_ _06041_ _06137_ VSS VSS VDD VDD _06286_ sky130_fd_sc_hd__nor3_2
X_15398_ _05900_ _05994_ _06029_ _06286_ VSS VSS VDD VDD _06287_
+ sky130_fd_sc_hd__a31oi_1
X_15399_ _05963_ _06091_ _06114_ _05954_ VSS VSS VDD VDD _06288_
+ sky130_fd_sc_hd__a31oi_1
X_15400_ _05954_ _06287_ _06288_ VSS VSS VDD VDD _06289_ sky130_fd_sc_hd__a21o_1
X_15401_ _11965_ _06056_ VSS VSS VDD VDD _06290_ sky130_fd_sc_hd__nor2_1
X_15402_ _06108_ _06276_ net472 VSS VSS VDD VDD _06291_ sky130_fd_sc_hd__a21oi_1
X_15403_ _11972_ _05991_ _05960_ _06290_ _06291_ VSS VSS VDD
+ VDD _06292_ sky130_fd_sc_hd__a2111oi_1
X_15404_ _05945_ _06091_ _06122_ VSS VSS VDD VDD _06293_ sky130_fd_sc_hd__a21oi_1
X_15405_ _06175_ _06191_ _06293_ VSS VSS VDD VDD _06294_ sky130_fd_sc_hd__nor3_1
X_15406_ _06035_ _06289_ _06292_ _06294_ _06143_ VSS VSS VDD
+ VDD _06295_ sky130_fd_sc_hd__a2111oi_0
X_15407_ _06261_ _06273_ _06285_ _06295_ VSS VSS VDD VDD _00035_
+ sky130_fd_sc_hd__nor4_1
X_15408_ _11964_ _05900_ _05940_ VSS VSS VDD VDD _06296_ sky130_fd_sc_hd__a21oi_1
X_15409_ _05954_ _06067_ _06086_ VSS VSS VDD VDD _06297_ sky130_fd_sc_hd__nand3_1
X_15410_ _05992_ _06023_ _05900_ VSS VSS VDD VDD _06298_ sky130_fd_sc_hd__a21oi_1
X_15411_ _05954_ _06092_ _06296_ _06297_ _06298_ VSS VSS VDD
+ VDD _06299_ sky130_fd_sc_hd__o32a_1
X_15412_ net728 _05891_ _05937_ VSS VSS VDD VDD _06300_ sky130_fd_sc_hd__nor3_4
X_15413_ _05900_ _06026_ _06300_ VSS VSS VDD VDD _06301_ sky130_fd_sc_hd__nor3_1
X_15414_ _06129_ _06166_ net470 VSS VSS VDD VDD _06302_ sky130_fd_sc_hd__a21oi_1
X_15415_ _11964_ _05900_ VSS VSS VDD VDD _06303_ sky130_fd_sc_hd__nor2_1
X_15416_ _05921_ _06303_ _05945_ VSS VSS VDD VDD _06304_ sky130_fd_sc_hd__o21a_1
X_15417_ net468 _06301_ _06302_ _06304_ _06011_ VSS VSS VDD
+ VDD _06305_ sky130_fd_sc_hd__o32ai_4
X_15418_ _06059_ _06305_ VSS VSS VDD VDD _06306_ sky130_fd_sc_hd__nand2_1
X_15419_ _06059_ _06299_ _06306_ VSS VSS VDD VDD _06307_ sky130_fd_sc_hd__o21ai_0
X_15420_ _11966_ _05931_ _05936_ VSS VSS VDD VDD _06308_ sky130_fd_sc_hd__or3_1
X_15421_ _11974_ _05945_ VSS VSS VDD VDD _06309_ sky130_fd_sc_hd__nand2_1
X_15422_ _05900_ _06309_ VSS VSS VDD VDD _06310_ sky130_fd_sc_hd__nand2_1
X_15423_ _06308_ _06310_ net468 VSS VSS VDD VDD _06311_ sky130_fd_sc_hd__a21oi_1
X_15424_ _05900_ _06160_ _06129_ _05954_ _06270_ VSS VSS VDD
+ VDD _06312_ sky130_fd_sc_hd__a311oi_1
X_15425_ _06035_ _06311_ _06312_ VSS VSS VDD VDD _06313_ sky130_fd_sc_hd__nor3_1
X_15426_ _11964_ _06110_ _06247_ _05884_ VSS VSS VDD VDD _06314_
+ sky130_fd_sc_hd__a22oi_1
X_15427_ net513 _06246_ net472 VSS VSS VDD VDD _06315_ sky130_fd_sc_hd__a21oi_1
X_15428_ _06270_ _06315_ _05937_ VSS VSS VDD VDD _06316_ sky130_fd_sc_hd__o21ai_0
X_15429_ _06024_ _06274_ net472 VSS VSS VDD VDD _06317_ sky130_fd_sc_hd__o21ai_0
X_15430_ _05937_ _06314_ _06316_ _06317_ _06035_ VSS VSS VDD
+ VDD _06318_ sky130_fd_sc_hd__o2111a_1
X_15431_ _06209_ _06160_ net470 VSS VSS VDD VDD _06319_ sky130_fd_sc_hd__nand3b_1
X_15432_ net468 _06130_ _06319_ VSS VSS VDD VDD _06320_ sky130_fd_sc_hd__or3b_1
X_15433_ net470 _05937_ VSS VSS VDD VDD _06321_ sky130_fd_sc_hd__nand2_1
X_15434_ _05891_ _06321_ _06210_ net470 net468 VSS VSS VDD
+ VDD _06322_ sky130_fd_sc_hd__o221ai_1
X_15435_ _11969_ net470 _06076_ VSS VSS VDD VDD _06323_ sky130_fd_sc_hd__a21oi_1
X_15436_ _05945_ _06323_ _05956_ VSS VSS VDD VDD _06324_ sky130_fd_sc_hd__o21ai_1
X_15437_ _06015_ _06150_ _06110_ _06035_ VSS VSS VDD VDD _06325_
+ sky130_fd_sc_hd__a31oi_1
X_15438_ _06035_ _06320_ _06322_ _06324_ _06325_ VSS VSS VDD
+ VDD _06326_ sky130_fd_sc_hd__a32o_1
X_15439_ _06143_ _06313_ _06318_ _06326_ _05989_ VSS VSS VDD
+ VDD _06327_ sky130_fd_sc_hd__o32ai_4
X_15440_ _05900_ _06028_ _06152_ VSS VSS VDD VDD _06328_ sky130_fd_sc_hd__nand3_1
X_15441_ _11974_ _05900_ _06059_ _06328_ VSS VSS VDD VDD _06329_
+ sky130_fd_sc_hd__o211ai_2
X_15442_ net729 _05991_ VSS VSS VDD VDD _06330_ sky130_fd_sc_hd__nand2_1
X_15443_ _05884_ net513 _05937_ VSS VSS VDD VDD _06331_ sky130_fd_sc_hd__nand3_2
X_15444_ _05978_ _06310_ _06330_ _06331_ VSS VSS VDD VDD _06332_
+ sky130_fd_sc_hd__nand4_1
X_15445_ _05900_ _06210_ _06300_ VSS VSS VDD VDD _06333_ sky130_fd_sc_hd__nor3_1
X_15446_ net470 _06041_ _06184_ VSS VSS VDD VDD _06334_ sky130_fd_sc_hd__nor3_1
X_15447_ _06333_ _06334_ _06059_ VSS VSS VDD VDD _06335_ sky130_fd_sc_hd__o21ai_1
X_15448_ _06083_ _05899_ _05937_ VSS VSS VDD VDD _06336_ sky130_fd_sc_hd__nor3_1
X_15449_ _11976_ _05937_ _06336_ VSS VSS VDD VDD _06337_ sky130_fd_sc_hd__a21oi_1
X_15450_ _05978_ _06337_ _05954_ VSS VSS VDD VDD _06338_ sky130_fd_sc_hd__a21oi_1
X_15451_ _05954_ _06329_ _06332_ _06335_ _06338_ VSS VSS VDD
+ VDD _06339_ sky130_fd_sc_hd__a32oi_4
X_15452_ _06035_ _05988_ _06339_ VSS VSS VDD VDD _06340_ sky130_fd_sc_hd__nor3_1
X_15453_ _06072_ _06307_ _06327_ _06340_ VSS VSS VDD VDD _00036_
+ sky130_fd_sc_hd__a211oi_1
X_15454_ _11964_ _05937_ _06166_ VSS VSS VDD VDD _06341_ sky130_fd_sc_hd__o21ai_0
X_15455_ _11965_ _05963_ VSS VSS VDD VDD _06342_ sky130_fd_sc_hd__nor2_1
X_15456_ _05900_ _06341_ _06342_ VSS VSS VDD VDD _06343_ sky130_fd_sc_hd__a21oi_1
X_15457_ _05958_ _06343_ VSS VSS VDD VDD _06344_ sky130_fd_sc_hd__nand2_1
X_15458_ _06015_ _06028_ VSS VSS VDD VDD _06345_ sky130_fd_sc_hd__nand2_1
X_15459_ _05900_ _06345_ VSS VSS VDD VDD _06346_ sky130_fd_sc_hd__nand2_1
X_15460_ net469 _06282_ _06346_ _05917_ VSS VSS VDD VDD _06347_
+ sky130_fd_sc_hd__a31oi_1
X_15461_ net469 _05991_ _06111_ net472 VSS VSS VDD VDD _06348_
+ sky130_fd_sc_hd__a211oi_1
X_15462_ net472 _06115_ _06348_ VSS VSS VDD VDD _06349_ sky130_fd_sc_hd__a21oi_1
X_15463_ net513 _06063_ _06066_ _11972_ _05958_ VSS VSS VDD
+ VDD _06350_ sky130_fd_sc_hd__a221oi_1
X_15464_ net472 _06056_ net469 VSS VSS VDD VDD _06351_ sky130_fd_sc_hd__a21oi_1
X_15465_ _06350_ _06351_ _05917_ VSS VSS VDD VDD _06352_ sky130_fd_sc_hd__o21ai_0
X_15466_ _05891_ _06349_ _06352_ VSS VSS VDD VDD _06353_ sky130_fd_sc_hd__a21oi_1
X_15467_ _06344_ _06347_ _06353_ VSS VSS VDD VDD _06354_ sky130_fd_sc_hd__a21oi_1
X_15468_ _05945_ _05947_ _06085_ VSS VSS VDD VDD _06355_ sky130_fd_sc_hd__o21ai_0
X_15469_ _06188_ _06134_ _06114_ _06238_ _05991_ VSS VSS VDD
+ VDD _06356_ sky130_fd_sc_hd__a32oi_1
X_15470_ _06035_ _06356_ VSS VSS VDD VDD _06357_ sky130_fd_sc_hd__nor2_1
X_15471_ _06035_ _06355_ _06357_ VSS VSS VDD VDD _06358_ sky130_fd_sc_hd__a21oi_1
X_15472_ _05900_ _06085_ _06183_ VSS VSS VDD VDD _06359_ sky130_fd_sc_hd__nand3_2
X_15473_ net470 _06075_ _06151_ VSS VSS VDD VDD _06360_ sky130_fd_sc_hd__nand3_1
X_15474_ _06035_ _06359_ _06360_ VSS VSS VDD VDD _06361_ sky130_fd_sc_hd__nand3_1
X_15475_ _11978_ _05899_ _05945_ VSS VSS VDD VDD _06362_ sky130_fd_sc_hd__o21ai_0
X_15476_ _11969_ _06019_ VSS VSS VDD VDD _06363_ sky130_fd_sc_hd__nand2_1
X_15477_ _05917_ _06362_ _06363_ _05958_ VSS VSS VDD VDD _06364_
+ sky130_fd_sc_hd__a31oi_1
X_15478_ _05958_ _06358_ _06361_ _06364_ _06095_ VSS VSS VDD
+ VDD _06365_ sky130_fd_sc_hd__a221oi_2
X_15479_ _11974_ _05945_ _05900_ VSS VSS VDD VDD _06366_ sky130_fd_sc_hd__o21ai_0
X_15480_ net470 _05992_ _06151_ _06035_ VSS VSS VDD VDD _06367_
+ sky130_fd_sc_hd__a31oi_1
X_15481_ _06300_ _06366_ _06367_ VSS VSS VDD VDD _06368_ sky130_fd_sc_hd__o21ai_0
X_15482_ _06147_ _06321_ _06359_ _06035_ VSS VSS VDD VDD _06369_
+ sky130_fd_sc_hd__o211ai_1
X_15483_ _05954_ _06368_ _06369_ VSS VSS VDD VDD _06370_ sky130_fd_sc_hd__and3_1
X_15484_ _05991_ _06147_ VSS VSS VDD VDD _06371_ sky130_fd_sc_hd__nand2_1
X_15485_ _11969_ _06056_ _06078_ _05891_ _06371_ VSS VSS VDD
+ VDD _06372_ sky130_fd_sc_hd__o221ai_1
X_15486_ net513 _06063_ _06331_ VSS VSS VDD VDD _06373_ sky130_fd_sc_hd__o21ai_0
X_15487_ _06035_ _06373_ net468 VSS VSS VDD VDD _06374_ sky130_fd_sc_hd__o21ai_0
X_15488_ _06035_ _06372_ _06374_ VSS VSS VDD VDD _06375_ sky130_fd_sc_hd__a21oi_1
X_15489_ _11969_ _05945_ _06019_ _11974_ _06053_ VSS VSS VDD
+ VDD _06376_ sky130_fd_sc_hd__a221oi_1
X_15490_ _05978_ _06047_ VSS VSS VDD VDD _06377_ sky130_fd_sc_hd__nor2_1
X_15491_ _06175_ _06376_ _06377_ VSS VSS VDD VDD _06378_ sky130_fd_sc_hd__o21ai_1
X_15492_ _05900_ _06156_ VSS VSS VDD VDD _06379_ sky130_fd_sc_hd__nand2_1
X_15493_ net470 _06152_ _06300_ net468 VSS VSS VDD VDD _06380_
+ sky130_fd_sc_hd__a211oi_1
X_15494_ net468 _06262_ _06379_ _06380_ VSS VSS VDD VDD _06381_
+ sky130_fd_sc_hd__a31oi_1
X_15495_ _05900_ _05992_ _05994_ net469 VSS VSS VDD VDD _06382_
+ sky130_fd_sc_hd__a31oi_1
X_15496_ _06045_ _06382_ _06035_ VSS VSS VDD VDD _06383_ sky130_fd_sc_hd__a21oi_1
X_15497_ _06035_ _06381_ _06383_ VSS VSS VDD VDD _06384_ sky130_fd_sc_hd__a21oi_1
X_15498_ _05989_ _06370_ _06375_ _06378_ _06384_ VSS VSS VDD
+ VDD _06385_ sky130_fd_sc_hd__o32ai_1
X_15499_ _06059_ _06047_ _06354_ _06365_ _06385_ VSS VSS VDD
+ VDD _00037_ sky130_fd_sc_hd__a311oi_1
X_15500_ _06178_ _06300_ VSS VSS VDD VDD _06386_ sky130_fd_sc_hd__nor2_1
X_15501_ net470 _06386_ VSS VSS VDD VDD _06387_ sky130_fd_sc_hd__nor2_1
X_15502_ _11965_ _05900_ _05937_ VSS VSS VDD VDD _06388_ sky130_fd_sc_hd__o21ai_0
X_15503_ _05900_ _06062_ _06388_ VSS VSS VDD VDD _06389_ sky130_fd_sc_hd__a21oi_1
X_15504_ _06233_ _06389_ _05954_ VSS VSS VDD VDD _06390_ sky130_fd_sc_hd__o21ai_0
X_15505_ _05954_ _06286_ _06387_ _06390_ _05917_ VSS VSS VDD
+ VDD _06391_ sky130_fd_sc_hd__o311ai_0
X_15506_ _06084_ _06023_ net471 VSS VSS VDD VDD _06392_ sky130_fd_sc_hd__a21oi_1
X_15507_ _05900_ _05945_ _06238_ VSS VSS VDD VDD _06393_ sky130_fd_sc_hd__nor3_1
X_15508_ _05954_ _06092_ _06392_ _06393_ VSS VSS VDD VDD _06394_
+ sky130_fd_sc_hd__nor4_1
X_15509_ _05884_ _06090_ _05937_ VSS VSS VDD VDD _06395_ sky130_fd_sc_hd__a21oi_1
X_15510_ net468 _06057_ _06395_ VSS VSS VDD VDD _06396_ sky130_fd_sc_hd__nor3_1
X_15511_ _06394_ _06396_ _06035_ VSS VSS VDD VDD _06397_ sky130_fd_sc_hd__o21ai_0
X_15512_ _06391_ _06397_ _05988_ VSS VSS VDD VDD _06398_ sky130_fd_sc_hd__a21oi_1
X_15513_ _11966_ _05945_ _06167_ VSS VSS VDD VDD _06399_ sky130_fd_sc_hd__a21oi_1
X_15514_ _05900_ _06029_ _06150_ _06399_ _05954_ VSS VSS VDD
+ VDD _06400_ sky130_fd_sc_hd__a311oi_1
X_15515_ net470 _06041_ _06239_ VSS VSS VDD VDD _06401_ sky130_fd_sc_hd__nor3_1
X_15516_ net470 _06131_ _06309_ _06401_ net468 VSS VSS VDD
+ VDD _06402_ sky130_fd_sc_hd__a311oi_2
X_15517_ _11964_ _05945_ _06309_ VSS VSS VDD VDD _06403_ sky130_fd_sc_hd__o21ai_0
X_15518_ _11966_ _06066_ _06403_ net470 VSS VSS VDD VDD _06404_
+ sky130_fd_sc_hd__a22oi_1
X_15519_ net724 net470 _06150_ VSS VSS VDD VDD _06405_ sky130_fd_sc_hd__a21oi_1
X_15520_ _11981_ _11990_ _05945_ net468 VSS VSS VDD VDD _06406_
+ sky130_fd_sc_hd__o31ai_1
X_15521_ net468 _06404_ _06405_ _06406_ _06229_ VSS VSS VDD
+ VDD _06407_ sky130_fd_sc_hd__o221ai_1
X_15522_ _06037_ _06400_ _06402_ _06407_ _06059_ VSS VSS VDD
+ VDD _06408_ sky130_fd_sc_hd__o311ai_2
X_15523_ _11965_ _06111_ VSS VSS VDD VDD _06409_ sky130_fd_sc_hd__nand2_1
X_15524_ _11974_ net469 _05945_ VSS VSS VDD VDD _06410_ sky130_fd_sc_hd__o21ai_0
X_15525_ _05899_ _06024_ _06251_ VSS VSS VDD VDD _06411_ sky130_fd_sc_hd__nor3b_1
X_15526_ _05899_ _06409_ _06410_ _06411_ VSS VSS VDD VDD _06412_
+ sky130_fd_sc_hd__a31oi_2
X_15527_ net468 _06159_ _05988_ VSS VSS VDD VDD _06413_ sky130_fd_sc_hd__o21ai_0
X_15528_ _11972_ _05937_ _06184_ VSS VSS VDD VDD _06414_ sky130_fd_sc_hd__a21oi_1
X_15529_ net470 _06414_ _06330_ _05954_ VSS VSS VDD VDD _06415_
+ sky130_fd_sc_hd__o211ai_1
X_15530_ _06047_ _06195_ _06415_ _06059_ _05917_ VSS VSS VDD
+ VDD _06416_ sky130_fd_sc_hd__a311oi_1
X_15531_ _06412_ _06413_ _06416_ VSS VSS VDD VDD _06417_ sky130_fd_sc_hd__o21ai_1
X_15532_ net468 _06210_ net470 VSS VSS VDD VDD _06418_ sky130_fd_sc_hd__o21ai_0
X_15533_ _05891_ _05954_ _06418_ VSS VSS VDD VDD _06419_ sky130_fd_sc_hd__o21ai_0
X_15534_ net725 net513 net470 _05997_ VSS VSS VDD VDD _06420_
+ sky130_fd_sc_hd__a31oi_1
X_15535_ _05884_ _06023_ _06420_ _11978_ _06114_ VSS VSS VDD
+ VDD _06421_ sky130_fd_sc_hd__o221ai_1
X_15536_ _06090_ _06220_ VSS VSS VDD VDD _06422_ sky130_fd_sc_hd__nor2_1
X_15537_ _05884_ _06419_ _06421_ _05954_ _06422_ VSS VSS VDD
+ VDD _06423_ sky130_fd_sc_hd__a221oi_1
X_15538_ _11974_ _05900_ _05945_ _06144_ VSS VSS VDD VDD _06424_
+ sky130_fd_sc_hd__a211oi_1
X_15539_ _11982_ _05945_ VSS VSS VDD VDD _06425_ sky130_fd_sc_hd__nand2_1
X_15540_ net468 _06425_ VSS VSS VDD VDD _06426_ sky130_fd_sc_hd__nand2_1
X_15541_ _06342_ _06279_ net469 VSS VSS VDD VDD _06427_ sky130_fd_sc_hd__o21ai_2
X_15542_ _06424_ _06426_ _06427_ _06047_ VSS VSS VDD VDD _06428_
+ sky130_fd_sc_hd__o211ai_1
X_15543_ _06047_ _06423_ _06428_ _05917_ _05978_ VSS VSS VDD
+ VDD _06429_ sky130_fd_sc_hd__o2111ai_1
X_15544_ _06398_ _06408_ _06417_ _06429_ VSS VSS VDD VDD _00038_
+ sky130_fd_sc_hd__o211ai_1
X_15545_ _06147_ _06066_ VSS VSS VDD VDD _06430_ sky130_fd_sc_hd__nand2_1
X_15546_ _11964_ _05991_ _06019_ net513 _06035_ VSS VSS VDD
+ VDD _06431_ sky130_fd_sc_hd__a221oi_1
X_15547_ _06331_ _06430_ _06431_ VSS VSS VDD VDD _06432_ sky130_fd_sc_hd__nand3_1
X_15548_ _11978_ _05963_ _06078_ _11965_ _06171_ VSS VSS VDD
+ VDD _06433_ sky130_fd_sc_hd__o221ai_1
X_15549_ net469 _06432_ _06433_ VSS VSS VDD VDD _06434_ sky130_fd_sc_hd__nand3_1
X_15550_ _11974_ net470 _05937_ VSS VSS VDD VDD _06435_ sky130_fd_sc_hd__nor3_1
X_15551_ net470 _06129_ _06166_ _06435_ VSS VSS VDD VDD _06436_
+ sky130_fd_sc_hd__a31oi_1
X_15552_ _06035_ _06436_ VSS VSS VDD VDD _06437_ sky130_fd_sc_hd__nor2_1
X_15553_ _05900_ _06035_ _06029_ _06129_ VSS VSS VDD VDD _06438_
+ sky130_fd_sc_hd__nand4_1
X_15554_ _05917_ _06156_ _06167_ _06438_ VSS VSS VDD VDD _06439_
+ sky130_fd_sc_hd__o31ai_1
X_15555_ _06437_ _06439_ net468 VSS VSS VDD VDD _06440_ sky130_fd_sc_hd__o21ai_0
X_15556_ _06434_ _06440_ _06047_ VSS VSS VDD VDD _06441_ sky130_fd_sc_hd__a21oi_1
X_15557_ _06035_ _05978_ _06246_ VSS VSS VDD VDD _06442_ sky130_fd_sc_hd__nand3_1
X_15558_ _05900_ _06075_ VSS VSS VDD VDD _06443_ sky130_fd_sc_hd__nor2_1
X_15559_ _05890_ net469 _05945_ VSS VSS VDD VDD _06444_ sky130_fd_sc_hd__o21ai_0
X_15560_ net513 _06274_ _06444_ VSS VSS VDD VDD _06445_ sky130_fd_sc_hd__a21oi_1
X_15561_ _05937_ _06114_ _06445_ net472 VSS VSS VDD VDD _06446_
+ sky130_fd_sc_hd__a211oi_1
X_15562_ _06156_ _06019_ net472 VSS VSS VDD VDD _06447_ sky130_fd_sc_hd__o21ai_0
X_15563_ _06331_ _06447_ net469 VSS VSS VDD VDD _06448_ sky130_fd_sc_hd__a21oi_1
X_15564_ net513 _05991_ _05997_ VSS VSS VDD VDD _06449_ sky130_fd_sc_hd__a21oi_1
X_15565_ _05937_ _06270_ _06066_ VSS VSS VDD VDD _06450_ sky130_fd_sc_hd__a21oi_1
X_15566_ _05958_ _06449_ _06450_ net472 VSS VSS VDD VDD _06451_
+ sky130_fd_sc_hd__o22ai_1
X_15567_ _06448_ _06451_ _05917_ VSS VSS VDD VDD _06452_ sky130_fd_sc_hd__o21ai_0
X_15568_ _06442_ _06443_ _06446_ _06452_ _06047_ VSS VSS VDD
+ VDD _06453_ sky130_fd_sc_hd__o311a_1
X_15569_ _05900_ _06085_ _06086_ VSS VSS VDD VDD _06454_ sky130_fd_sc_hd__nand3_1
X_15570_ net470 _06028_ _06160_ VSS VSS VDD VDD _06455_ sky130_fd_sc_hd__nand3_1
X_15571_ _11976_ _05937_ _06047_ VSS VSS VDD VDD _06456_ sky130_fd_sc_hd__o21ai_0
X_15572_ _11966_ _05900_ _05937_ _06456_ VSS VSS VDD VDD _06457_
+ sky130_fd_sc_hd__a31oi_1
X_15573_ _05988_ _06454_ _06455_ _06457_ net469 VSS VSS VDD
+ VDD _06458_ sky130_fd_sc_hd__a311oi_1
X_15574_ _06270_ _05988_ _06000_ VSS VSS VDD VDD _06459_ sky130_fd_sc_hd__nor3_1
X_15575_ net470 _05997_ _06184_ VSS VSS VDD VDD _06460_ sky130_fd_sc_hd__nor3_1
X_15576_ _05988_ _05992_ VSS VSS VDD VDD _06461_ sky130_fd_sc_hd__nand2_1
X_15577_ net470 _06239_ _06460_ _06461_ VSS VSS VDD VDD _06462_
+ sky130_fd_sc_hd__a211oi_1
X_15578_ _05945_ _06047_ _06199_ VSS VSS VDD VDD _06463_ sky130_fd_sc_hd__nand3_1
X_15579_ _05921_ _06463_ VSS VSS VDD VDD _06464_ sky130_fd_sc_hd__nor2_1
X_15580_ net468 _06459_ _06462_ _06464_ VSS VSS VDD VDD _06465_
+ sky130_fd_sc_hd__nor4_1
X_15581_ _06458_ _06465_ _06060_ VSS VSS VDD VDD _06466_ sky130_fd_sc_hd__o21bai_1
X_15582_ net470 _06176_ VSS VSS VDD VDD _06467_ sky130_fd_sc_hd__nor2_1
X_15583_ net470 _06000_ _06151_ _06467_ _05988_ VSS VSS VDD
+ VDD _06468_ sky130_fd_sc_hd__a311oi_1
X_15584_ _06047_ _06026_ _06405_ VSS VSS VDD VDD _06469_ sky130_fd_sc_hd__nor3_1
X_15585_ _05900_ _06308_ _06129_ _06303_ VSS VSS VDD VDD _06470_
+ sky130_fd_sc_hd__a31oi_1
X_15586_ _11974_ net470 _05945_ _06076_ VSS VSS VDD VDD _06471_
+ sky130_fd_sc_hd__a211oi_1
X_15587_ _11990_ _05937_ _06047_ VSS VSS VDD VDD _06472_ sky130_fd_sc_hd__o21ai_0
X_15588_ _06047_ _06470_ _06471_ _06472_ net468 VSS VSS VDD
+ VDD _06473_ sky130_fd_sc_hd__o221ai_1
X_15589_ net468 _06468_ _06469_ _06006_ _06473_ VSS VSS VDD
+ VDD _06474_ sky130_fd_sc_hd__o311ai_1
X_15590_ _06059_ _06441_ _06453_ _06466_ _06474_ VSS VSS VDD
+ VDD _00039_ sky130_fd_sc_hd__o311ai_0
XTAP_TAPCELL_ROW_41_992 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_991 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15593_ sa01_sr\[7\] sa01_sr\[0\] VSS VSS VDD VDD _06477_
+ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_41_990 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15595_ sa21_sr\[1\] sa30_sub\[1\] VSS VSS VDD VDD _06479_
+ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_41_989 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15597_ sa11_sr\[7\] sa11_sr\[0\] sa11_sr\[1\] VSS VSS VDD
+ VDD _06481_ sky130_fd_sc_hd__xnor3_1
X_15598_ _06477_ _06479_ _06481_ VSS VSS VDD VDD _06482_ sky130_fd_sc_hd__xnor3_1
XTAP_TAPCELL_ROW_41_988 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_987 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15601_ text_in_r\[89\] _06482_ net490 VSS VSS VDD VDD _06485_
+ sky130_fd_sc_hd__mux2i_4
X_15602_ u0.w\[1\]\[25\] _06485_ VSS VSS VDD VDD _06486_ sky130_fd_sc_hd__xor2_4
X_15603_ net467 VSS VSS VDD VDD _06487_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_40_986 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_985 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15606_ sa11_sr\[0\] sa21_sr\[0\] VSS VSS VDD VDD _06489_
+ sky130_fd_sc_hd__xor2_2
X_15607_ sa01_sr\[7\] sa11_sr\[7\] sa30_sub\[0\] VSS VSS VDD
+ VDD _06490_ sky130_fd_sc_hd__xnor3_1
X_15608_ _06489_ _06490_ VSS VSS VDD VDD _06491_ sky130_fd_sc_hd__xnor2_1
X_15609_ text_in_r\[88\] _06491_ net490 VSS VSS VDD VDD _06492_
+ sky130_fd_sc_hd__mux2i_4
X_15610_ u0.w\[1\]\[24\] _06492_ VSS VSS VDD VDD _06493_ sky130_fd_sc_hd__xor2_4
X_15611_ net465 VSS VSS VDD VDD _06494_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_40_984 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15613_ sa01_sr\[1\] sa11_sr\[2\] sa21_sr\[2\] VSS VSS VDD
+ VDD _06495_ sky130_fd_sc_hd__xnor3_4
XTAP_TAPCELL_ROW_40_983 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15615_ sa11_sr\[1\] sa30_sub\[2\] VSS VSS VDD VDD _06497_
+ sky130_fd_sc_hd__xnor2_1
X_15616_ _06495_ _06497_ VSS VSS VDD VDD _06498_ sky130_fd_sc_hd__xor2_1
X_15617_ text_in_r\[90\] net492 VSS VSS VDD VDD _06499_ sky130_fd_sc_hd__nand2b_1
X_15618_ net492 _06498_ _06499_ u0.w\[1\]\[26\] VSS VSS VDD
+ VDD _06500_ sky130_fd_sc_hd__o211ai_1
X_15619_ net492 text_in_r\[90\] VSS VSS VDD VDD _06501_ sky130_fd_sc_hd__and2_0
X_15620_ net490 _06498_ _06501_ u0.w\[1\]\[26\] VSS VSS VDD
+ VDD _06502_ sky130_fd_sc_hd__a211o_1
X_15621_ _06500_ _06502_ VSS VSS VDD VDD _06503_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_40_982 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15623_ _06503_ VSS VSS VDD VDD _06505_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_40_981 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_980 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_979 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_978 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_977 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_976 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_975 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_974 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_973 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15633_ sa01_sr\[7\] sa01_sr\[3\] sa21_sr\[4\] VSS VSS VDD
+ VDD _06512_ sky130_fd_sc_hd__xnor3_1
XTAP_TAPCELL_ROW_40_972 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15635_ sa11_sr\[7\] sa30_sub\[4\] VSS VSS VDD VDD _06514_
+ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_40_971 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_970 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15638_ sa11_sr\[3\] sa11_sr\[4\] VSS VSS VDD VDD _06517_
+ sky130_fd_sc_hd__xnor2_1
X_15639_ _06512_ _06514_ _06517_ VSS VSS VDD VDD _06518_ sky130_fd_sc_hd__xnor3_2
X_15640_ text_in_r\[92\] _06518_ net490 VSS VSS VDD VDD _06519_
+ sky130_fd_sc_hd__mux2i_4
X_15641_ u0.w\[1\]\[28\] _06519_ VSS VSS VDD VDD _06520_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_40_969 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_968 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_967 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_966 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_965 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_964 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15648_ sa01_sr\[7\] sa01_sr\[2\] sa21_sr\[3\] VSS VSS VDD
+ VDD _06527_ sky130_fd_sc_hd__xnor3_1
X_15649_ sa11_sr\[7\] sa11_sr\[2\] VSS VSS VDD VDD _06528_
+ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_40_963 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15651_ sa11_sr\[3\] sa30_sub\[3\] VSS VSS VDD VDD _06530_
+ sky130_fd_sc_hd__xnor2_1
X_15652_ _06527_ _06528_ _06530_ VSS VSS VDD VDD _06531_ sky130_fd_sc_hd__xnor3_2
XTAP_TAPCELL_ROW_39_962 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15654_ net492 text_in_r\[91\] VSS VSS VDD VDD _06533_ sky130_fd_sc_hd__and2_0
X_15655_ net490 _06531_ _06533_ u0.w\[1\]\[27\] VSS VSS VDD
+ VDD _06534_ sky130_fd_sc_hd__a211oi_4
X_15656_ net492 u0.w\[1\]\[27\] VSS VSS VDD VDD _06535_ sky130_fd_sc_hd__nor2b_1
X_15657_ u0.w\[1\]\[27\] _06533_ _06535_ _06531_ VSS VSS VDD
+ VDD _06536_ sky130_fd_sc_hd__a22o_2
X_15658_ _06536_ _06534_ VSS VSS VDD VDD _06537_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_39_961 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_960 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15661_ _06505_ _06537_ VSS VSS VDD VDD _06540_ sky130_fd_sc_hd__nor2_8
X_15662_ _06536_ _06534_ VSS VSS VDD VDD _06541_ sky130_fd_sc_hd__nor2_8
X_15663_ net465 _06541_ VSS VSS VDD VDD _06542_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_39_959 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_958 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_957 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_956 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_955 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15669_ _12010_ net467 _06537_ VSS VSS VDD VDD _06548_ sky130_fd_sc_hd__mux2i_1
X_15670_ net532 _06548_ VSS VSS VDD VDD _06549_ sky130_fd_sc_hd__nor2_1
X_15671_ _11997_ _06540_ _06542_ _06549_ VSS VSS VDD VDD _06550_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_39_954 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_953 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15674_ _06503_ _06541_ VSS VSS VDD VDD _06553_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_39_952 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_951 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15677_ net504 _06505_ VSS VSS VDD VDD _06556_ sky130_fd_sc_hd__nand2_1
X_15678_ _06487_ _06537_ VSS VSS VDD VDD _06557_ sky130_fd_sc_hd__nor2_2
X_15679_ _12001_ _06553_ _06556_ _06557_ _06520_ VSS VSS VDD
+ VDD _06558_ sky130_fd_sc_hd__o221ai_1
XTAP_TAPCELL_ROW_39_950 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15681_ sa01_sr\[4\] sa11_sr\[5\] sa21_sr\[5\] VSS VSS VDD
+ VDD _06560_ sky130_fd_sc_hd__xnor3_4
X_15682_ sa11_sr\[4\] sa30_sub\[5\] VSS VSS VDD VDD _06561_
+ sky130_fd_sc_hd__xor2_1
X_15683_ _06560_ _06561_ VSS VSS VDD VDD _06562_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_39_949 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15685_ text_in_r\[93\] _06562_ net490 VSS VSS VDD VDD _06564_
+ sky130_fd_sc_hd__mux2i_4
X_15686_ u0.w\[1\]\[29\] _06564_ VSS VSS VDD VDD _06565_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_39_948 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_947 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15689_ _06520_ _06550_ _06558_ _06565_ VSS VSS VDD VDD _06568_
+ sky130_fd_sc_hd__o211ai_1
X_15690_ u0.w\[1\]\[28\] _06519_ VSS VSS VDD VDD _06569_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_39_946 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_945 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_944 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_943 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15695_ _06503_ _06541_ VSS VSS VDD VDD _06573_ sky130_fd_sc_hd__nor2_8
X_15696_ _06494_ _06540_ _06573_ VSS VSS VDD VDD _06574_ sky130_fd_sc_hd__a21oi_1
X_15697_ _06503_ _06537_ VSS VSS VDD VDD _06575_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_39_942 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_941 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_940 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15701_ _06503_ _06537_ VSS VSS VDD VDD _06579_ sky130_fd_sc_hd__nor2_4
X_15702_ net505 _06579_ VSS VSS VDD VDD _06580_ sky130_fd_sc_hd__nand2_1
X_15703_ net582 _06574_ _06575_ _11998_ _06580_ VSS VSS VDD
+ VDD _06581_ sky130_fd_sc_hd__o221ai_1
XTAP_TAPCELL_ROW_38_939 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15705_ _06487_ _06541_ VSS VSS VDD VDD _06583_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_38_938 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_937 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15708_ _06487_ net645 VSS VSS VDD VDD _06586_ sky130_fd_sc_hd__nand2_2
X_15709_ _12010_ _06541_ VSS VSS VDD VDD _06587_ sky130_fd_sc_hd__nand2_2
X_15710_ net532 _06586_ _06587_ VSS VSS VDD VDD _06588_ sky130_fd_sc_hd__nand3_1
X_15711_ _06556_ _06583_ _06588_ _06569_ VSS VSS VDD VDD _06589_
+ sky130_fd_sc_hd__o211ai_1
X_15712_ u0.w\[1\]\[29\] _06564_ VSS VSS VDD VDD _06590_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_38_936 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_935 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_934 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15716_ _06569_ _06581_ _06589_ _06590_ VSS VSS VDD VDD _06594_
+ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_38_933 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15718_ sa11_sr\[5\] sa21_sr\[6\] sa30_sub\[6\] VSS VSS VDD
+ VDD _06596_ sky130_fd_sc_hd__xnor3_1
XTAP_TAPCELL_ROW_38_932 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_931 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15721_ sa01_sr\[5\] sa11_sr\[6\] VSS VSS VDD VDD _06599_
+ sky130_fd_sc_hd__xnor2_1
X_15722_ _06596_ _06599_ VSS VSS VDD VDD _06600_ sky130_fd_sc_hd__xnor2_1
X_15723_ net492 _06600_ VSS VSS VDD VDD _06601_ sky130_fd_sc_hd__nor2_1
X_15724_ net492 text_in_r\[94\] _06601_ VSS VSS VDD VDD _06602_
+ sky130_fd_sc_hd__a21oi_4
X_15725_ u0.w\[1\]\[30\] _06602_ VSS VSS VDD VDD _06603_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_38_930 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15727_ sa11_sr\[7\] sa01_sr\[6\] sa21_sr\[7\] VSS VSS VDD
+ VDD _06605_ sky130_fd_sc_hd__xnor3_4
XTAP_TAPCELL_ROW_38_929 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15729_ sa11_sr\[6\] net690 VSS VSS VDD VDD _06607_ sky130_fd_sc_hd__xnor2_1
X_15730_ _06605_ _06607_ VSS VSS VDD VDD _06608_ sky130_fd_sc_hd__xnor2_1
X_15731_ net492 _06608_ VSS VSS VDD VDD _06609_ sky130_fd_sc_hd__nor2_1
X_15732_ net492 text_in_r\[95\] _06609_ VSS VSS VDD VDD _06610_
+ sky130_fd_sc_hd__a21oi_4
X_15733_ u0.w\[1\]\[31\] _06610_ VSS VSS VDD VDD _06611_ sky130_fd_sc_hd__xor2_4
X_15734_ _06603_ _06611_ VSS VSS VDD VDD _06612_ sky130_fd_sc_hd__nand2_8
X_15735_ _06568_ _06594_ _06612_ VSS VSS VDD VDD _06613_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_38_928 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15737_ _06565_ _06520_ VSS VSS VDD VDD _06615_ sky130_fd_sc_hd__nand2_4
X_15738_ _11998_ _06537_ VSS VSS VDD VDD _06616_ sky130_fd_sc_hd__nand2b_2
X_15739_ _06487_ net506 net669 VSS VSS VDD VDD _06617_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_38_927 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15741_ net532 _06616_ _06617_ _06579_ _12006_ VSS VSS VDD
+ VDD _06619_ sky130_fd_sc_hd__a32oi_1
X_15742_ _11998_ _06541_ VSS VSS VDD VDD _06620_ sky130_fd_sc_hd__nand2_1
X_15743_ net467 _06494_ _06537_ VSS VSS VDD VDD _06621_ sky130_fd_sc_hd__o21ai_0
X_15744_ _06620_ _06621_ _06505_ VSS VSS VDD VDD _06622_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_38_926 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_925 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15747_ _12004_ _06503_ _06541_ VSS VSS VDD VDD _06625_ sky130_fd_sc_hd__nor3_1
X_15748_ _06565_ net619 VSS VSS VDD VDD _06626_ sky130_fd_sc_hd__nand2_4
X_15749_ _06622_ _06625_ _06626_ VSS VSS VDD VDD _06627_ sky130_fd_sc_hd__o21bai_1
X_15750_ _06615_ _06619_ _06627_ VSS VSS VDD VDD _06628_ sky130_fd_sc_hd__o21ai_1
X_15751_ u0.w\[1\]\[30\] _06602_ VSS VSS VDD VDD _06629_ sky130_fd_sc_hd__xor2_4
X_15752_ u0.w\[1\]\[31\] _06610_ VSS VSS VDD VDD _06630_ sky130_fd_sc_hd__xnor2_4
X_15753_ _06629_ _06630_ VSS VSS VDD VDD _06631_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_38_924 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_923 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15756_ _12017_ net669 VSS VSS VDD VDD _06634_ sky130_fd_sc_hd__nand2_1
X_15757_ _11997_ _06505_ VSS VSS VDD VDD _06635_ sky130_fd_sc_hd__and2_2
X_15758_ net645 _06635_ VSS VSS VDD VDD _06636_ sky130_fd_sc_hd__nand2_1
X_15759_ _06505_ net645 VSS VSS VDD VDD _06637_ sky130_fd_sc_hd__xnor2_4
X_15760_ _06493_ _06637_ VSS VSS VDD VDD _06638_ sky130_fd_sc_hd__nor2_1
X_15761_ net466 _06537_ VSS VSS VDD VDD _06639_ sky130_fd_sc_hd__nand2_8
X_15762_ _11996_ _06534_ _06536_ VSS VSS VDD VDD _06640_ sky130_fd_sc_hd__or3_2
X_15763_ _06639_ _06640_ _06505_ VSS VSS VDD VDD _06641_ sky130_fd_sc_hd__a21oi_1
X_15764_ _06505_ _06537_ VSS VSS VDD VDD _06642_ sky130_fd_sc_hd__nand2_4
X_15765_ _11998_ _12001_ VSS VSS VDD VDD _06643_ sky130_fd_sc_hd__nor2_4
X_15766_ _06642_ _06643_ _06520_ VSS VSS VDD VDD _06644_ sky130_fd_sc_hd__o21ai_0
X_15767_ _06638_ _06641_ _06644_ VSS VSS VDD VDD _06645_ sky130_fd_sc_hd__nor3_1
X_15768_ _06569_ _06634_ _06636_ _06645_ _06565_ VSS VSS VDD
+ VDD _06646_ sky130_fd_sc_hd__a311oi_1
X_15769_ _06494_ _06541_ VSS VSS VDD VDD _06647_ sky130_fd_sc_hd__nand2_1
X_15770_ _12004_ _06541_ VSS VSS VDD VDD _06648_ sky130_fd_sc_hd__nand2_1
X_15771_ _11997_ _06537_ VSS VSS VDD VDD _06649_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_38_922 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15773_ _06648_ _06649_ net670 VSS VSS VDD VDD _06651_ sky130_fd_sc_hd__a21oi_1
X_15774_ net532 _06639_ _06647_ _06651_ _06615_ VSS VSS VDD
+ VDD _06652_ sky130_fd_sc_hd__a311o_1
X_15775_ _06487_ _06494_ net645 VSS VSS VDD VDD _06653_ sky130_fd_sc_hd__a21oi_4
X_15776_ _12001_ _06537_ VSS VSS VDD VDD _06654_ sky130_fd_sc_hd__nand2_2
X_15777_ _06505_ _06647_ _06654_ VSS VSS VDD VDD _06655_ sky130_fd_sc_hd__nand3_1
X_15778_ _06565_ _06569_ VSS VSS VDD VDD _06656_ sky130_fd_sc_hd__nor2_8
X_15779_ _06505_ _06653_ _06655_ _06656_ VSS VSS VDD VDD _06657_
+ sky130_fd_sc_hd__o211ai_1
X_15780_ _11997_ _06537_ VSS VSS VDD VDD _06658_ sky130_fd_sc_hd__nor2_2
X_15781_ _12006_ net669 VSS VSS VDD VDD _06659_ sky130_fd_sc_hd__nor2_2
X_15782_ _06658_ _06659_ net532 VSS VSS VDD VDD _06660_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_38_921 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_920 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15785_ _06565_ _06520_ VSS VSS VDD VDD _06663_ sky130_fd_sc_hd__nor2_2
X_15786_ _12001_ _06642_ _06660_ _06663_ VSS VSS VDD VDD _06664_
+ sky130_fd_sc_hd__o211ai_1
X_15787_ _11998_ _06541_ VSS VSS VDD VDD _06665_ sky130_fd_sc_hd__nor2_4
X_15788_ _12001_ _06537_ VSS VSS VDD VDD _06666_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_38_919 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15790_ _06665_ _06666_ net670 VSS VSS VDD VDD _06668_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_38_918 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15792_ _11996_ _06573_ _06626_ VSS VSS VDD VDD _06670_ sky130_fd_sc_hd__a21oi_1
X_15793_ _06603_ _06630_ VSS VSS VDD VDD _06671_ sky130_fd_sc_hd__nand2_4
X_15794_ _06668_ _06670_ _06671_ VSS VSS VDD VDD _06672_ sky130_fd_sc_hd__a21oi_1
X_15795_ _06652_ _06657_ _06664_ _06672_ VSS VSS VDD VDD _06673_
+ sky130_fd_sc_hd__nand4_2
X_15796_ _06628_ _06631_ _06646_ _06673_ VSS VSS VDD VDD _06674_
+ sky130_fd_sc_hd__o31ai_1
XTAP_TAPCELL_ROW_38_917 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15798_ _06565_ net645 VSS VSS VDD VDD _06676_ sky130_fd_sc_hd__nand2_1
X_15799_ _06590_ _06541_ VSS VSS VDD VDD _06677_ sky130_fd_sc_hd__nand2_1
X_15800_ _06676_ _06677_ VSS VSS VDD VDD _06678_ sky130_fd_sc_hd__nand2_1
X_15801_ _12004_ _06590_ net645 VSS VSS VDD VDD _06679_ sky130_fd_sc_hd__nor3_1
X_15802_ _11997_ _06678_ _06679_ VSS VSS VDD VDD _06680_ sky130_fd_sc_hd__a21oi_1
X_15803_ _12004_ _06590_ VSS VSS VDD VDD _06681_ sky130_fd_sc_hd__nand2_1
X_15804_ net466 net465 VSS VSS VDD VDD _06682_ sky130_fd_sc_hd__nor2_2
X_15805_ _06565_ _06682_ VSS VSS VDD VDD _06683_ sky130_fd_sc_hd__nand2_1
X_15806_ _06505_ _06541_ VSS VSS VDD VDD _06684_ sky130_fd_sc_hd__nand2_1
X_15807_ _11997_ _06590_ net645 net532 VSS VSS VDD VDD _06685_
+ sky130_fd_sc_hd__o211ai_1
X_15808_ _06684_ _06685_ _11996_ VSS VSS VDD VDD _06686_ sky130_fd_sc_hd__a21oi_1
X_15809_ _06573_ _06681_ _06683_ _06686_ VSS VSS VDD VDD _06687_
+ sky130_fd_sc_hd__a31oi_1
X_15810_ _06505_ _06680_ _06687_ VSS VSS VDD VDD _06688_ sky130_fd_sc_hd__o21ai_0
X_15811_ _06505_ _06565_ VSS VSS VDD VDD _06689_ sky130_fd_sc_hd__nand2_1
X_15812_ net465 _06689_ VSS VSS VDD VDD _06690_ sky130_fd_sc_hd__nor2_1
X_15813_ _11997_ net532 _06590_ _06690_ VSS VSS VDD VDD _06691_
+ sky130_fd_sc_hd__a31oi_1
X_15814_ _06494_ _06590_ VSS VSS VDD VDD _06692_ sky130_fd_sc_hd__nor2_1
X_15815_ _06505_ _06692_ _06487_ VSS VSS VDD VDD _06693_ sky130_fd_sc_hd__o21ai_0
X_15816_ _11997_ _06503_ VSS VSS VDD VDD _06694_ sky130_fd_sc_hd__nor2_1
X_15817_ net467 net507 VSS VSS VDD VDD _06695_ sky130_fd_sc_hd__nand2_1
X_15818_ _06494_ _06503_ VSS VSS VDD VDD _06696_ sky130_fd_sc_hd__nand2_4
X_15819_ _06695_ _06696_ _06590_ VSS VSS VDD VDD _06697_ sky130_fd_sc_hd__a21oi_1
X_15820_ _06590_ _06694_ _06697_ net645 VSS VSS VDD VDD _06698_
+ sky130_fd_sc_hd__a211oi_1
X_15821_ net645 _06691_ _06693_ _06698_ net464 VSS VSS VDD
+ VDD _06699_ sky130_fd_sc_hd__a311oi_2
X_15822_ _06629_ _06611_ VSS VSS VDD VDD _06700_ sky130_fd_sc_hd__nand2_2
X_15823_ net464 _06688_ _06699_ _06700_ VSS VSS VDD VDD _06701_
+ sky130_fd_sc_hd__a211oi_2
X_15824_ _06613_ _06674_ _06701_ VSS VSS VDD VDD _00040_ sky130_fd_sc_hd__nor3_1
X_15825_ _06603_ _06630_ VSS VSS VDD VDD _06702_ sky130_fd_sc_hd__nor2_4
X_15826_ _06505_ _06542_ _06666_ VSS VSS VDD VDD _06703_ sky130_fd_sc_hd__nor3_1
X_15827_ net467 _06541_ VSS VSS VDD VDD _06704_ sky130_fd_sc_hd__nor2_1
X_15828_ net670 _06704_ _06557_ VSS VSS VDD VDD _06705_ sky130_fd_sc_hd__nor3_1
X_15829_ _12020_ net645 net464 VSS VSS VDD VDD _06706_ sky130_fd_sc_hd__o21ai_4
X_15830_ _06520_ _06703_ _06705_ _06706_ _06590_ VSS VSS VDD
+ VDD _06707_ sky130_fd_sc_hd__o311ai_2
X_15831_ _06503_ _06682_ VSS VSS VDD VDD _06708_ sky130_fd_sc_hd__nand2_1
X_15832_ _12004_ _06505_ net669 VSS VSS VDD VDD _06709_ sky130_fd_sc_hd__a21oi_1
X_15833_ net465 net670 VSS VSS VDD VDD _06710_ sky130_fd_sc_hd__nand2_1
X_15834_ _11996_ _06505_ VSS VSS VDD VDD _06711_ sky130_fd_sc_hd__nand2_1
X_15835_ _06710_ _06711_ net669 VSS VSS VDD VDD _06712_ sky130_fd_sc_hd__a21oi_1
X_15836_ _06487_ _06541_ VSS VSS VDD VDD _06713_ sky130_fd_sc_hd__nand2_8
X_15837_ _06494_ _06505_ VSS VSS VDD VDD _06714_ sky130_fd_sc_hd__nor2_2
X_15838_ net465 net670 VSS VSS VDD VDD _06715_ sky130_fd_sc_hd__nor2_1
X_15839_ _06713_ _06714_ _06715_ VSS VSS VDD VDD _06716_ sky130_fd_sc_hd__nor3_1
X_15840_ _06626_ _06712_ _06716_ VSS VSS VDD VDD _06717_ sky130_fd_sc_hd__nor3_1
X_15841_ _06520_ _06708_ _06709_ _06717_ VSS VSS VDD VDD _06718_
+ sky130_fd_sc_hd__a31oi_2
X_15842_ _06494_ _06541_ VSS VSS VDD VDD _06719_ sky130_fd_sc_hd__nor2_4
X_15843_ _11997_ _06541_ VSS VSS VDD VDD _06720_ sky130_fd_sc_hd__nand2_2
X_15844_ _11996_ _06537_ VSS VSS VDD VDD _06721_ sky130_fd_sc_hd__nand2_4
X_15845_ net670 _06720_ _06721_ VSS VSS VDD VDD _06722_ sky130_fd_sc_hd__nand3_1
X_15846_ net532 _06666_ _06719_ _06722_ _06569_ VSS VSS VDD
+ VDD _06723_ sky130_fd_sc_hd__o311ai_1
X_15847_ net465 _06540_ VSS VSS VDD VDD _06724_ sky130_fd_sc_hd__nand2_1
X_15848_ _06505_ _06541_ VSS VSS VDD VDD _06725_ sky130_fd_sc_hd__nor2_4
X_15849_ net467 _06537_ VSS VSS VDD VDD _06726_ sky130_fd_sc_hd__nor2_1
X_15850_ _06725_ _06726_ _06494_ VSS VSS VDD VDD _06727_ sky130_fd_sc_hd__o21ai_1
X_15851_ _11997_ _06642_ _06724_ _06727_ net464 VSS VSS VDD
+ VDD _06728_ sky130_fd_sc_hd__o2111ai_4
X_15852_ _06723_ _06728_ _06565_ _06671_ VSS VSS VDD VDD _06729_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_38_916 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15854_ _11997_ _06534_ _06536_ VSS VSS VDD VDD _06731_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_37_915 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15856_ _06503_ _06653_ VSS VSS VDD VDD _06733_ sky130_fd_sc_hd__nor2_1
X_15857_ net532 _06654_ _06731_ _06733_ _06569_ VSS VSS VDD
+ VDD _06734_ sky130_fd_sc_hd__a311oi_1
X_15858_ _06487_ _06553_ VSS VSS VDD VDD _06735_ sky130_fd_sc_hd__nor2_2
X_15859_ _06494_ _06537_ VSS VSS VDD VDD _06736_ sky130_fd_sc_hd__nand2_4
X_15860_ net582 _06736_ VSS VSS VDD VDD _06737_ sky130_fd_sc_hd__nor2_2
X_15861_ _06505_ _06587_ _06735_ _06737_ _06520_ VSS VSS VDD
+ VDD _06738_ sky130_fd_sc_hd__a2111oi_1
X_15862_ _06590_ _06671_ _06734_ _06738_ VSS VSS VDD VDD _06739_
+ sky130_fd_sc_hd__nor4_1
X_15863_ _06702_ _06707_ _06718_ _06729_ _06739_ VSS VSS VDD
+ VDD _06740_ sky130_fd_sc_hd__a311o_1
XTAP_TAPCELL_ROW_37_914 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_913 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_912 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15867_ _11996_ net669 _06665_ VSS VSS VDD VDD _06744_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_37_911 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15869_ _06658_ _06719_ _06505_ VSS VSS VDD VDD _06746_ sky130_fd_sc_hd__o21ai_1
X_15870_ _06505_ _06744_ _06746_ VSS VSS VDD VDD _06747_ sky130_fd_sc_hd__o21ai_0
X_15871_ _11996_ net669 _06713_ VSS VSS VDD VDD _06748_ sky130_fd_sc_hd__o21ai_0
X_15872_ _12001_ _06534_ _06536_ VSS VSS VDD VDD _06749_ sky130_fd_sc_hd__or3_2
X_15873_ net532 _06736_ _06749_ VSS VSS VDD VDD _06750_ sky130_fd_sc_hd__nand3_1
X_15874_ _06505_ _06748_ _06750_ VSS VSS VDD VDD _06751_ sky130_fd_sc_hd__a21boi_0
X_15875_ _06626_ _06747_ _06751_ _06615_ VSS VSS VDD VDD _06752_
+ sky130_fd_sc_hd__o22ai_1
X_15876_ _06658_ _06737_ net532 VSS VSS VDD VDD _06753_ sky130_fd_sc_hd__o21ai_0
X_15877_ net465 _06573_ VSS VSS VDD VDD _06754_ sky130_fd_sc_hd__nand2_1
X_15878_ net466 net465 _06537_ VSS VSS VDD VDD _06755_ sky130_fd_sc_hd__nor3_4
X_15879_ _06665_ _06755_ _06505_ VSS VSS VDD VDD _06756_ sky130_fd_sc_hd__o21ai_0
X_15880_ _12010_ _06537_ VSS VSS VDD VDD _06757_ sky130_fd_sc_hd__nand2_4
X_15881_ _06590_ net619 VSS VSS VDD VDD _06758_ sky130_fd_sc_hd__nand2_2
X_15882_ net532 _06731_ _06757_ _06758_ VSS VSS VDD VDD _06759_
+ sky130_fd_sc_hd__a31oi_1
X_15883_ _06656_ _06753_ _06754_ _06756_ _06759_ VSS VSS VDD
+ VDD _06760_ sky130_fd_sc_hd__a32o_1
X_15884_ _06612_ _06752_ _06760_ VSS VSS VDD VDD _06761_ sky130_fd_sc_hd__nor3_1
X_15885_ net505 _06541_ VSS VSS VDD VDD _06762_ sky130_fd_sc_hd__nand2_2
X_15886_ _06505_ _06762_ net583 VSS VSS VDD VDD _06763_ sky130_fd_sc_hd__a21oi_1
X_15887_ net583 _06719_ _06763_ _06540_ _06615_ VSS VSS VDD
+ VDD _06764_ sky130_fd_sc_hd__a2111oi_0
X_15888_ _12010_ net670 _06635_ VSS VSS VDD VDD _06765_ sky130_fd_sc_hd__a21oi_1
X_15889_ _12001_ _06503_ VSS VSS VDD VDD _06766_ sky130_fd_sc_hd__nor2_1
X_15890_ net467 _06494_ _06505_ VSS VSS VDD VDD _06767_ sky130_fd_sc_hd__nor3_1
X_15891_ net669 _06766_ _06767_ net464 VSS VSS VDD VDD _06768_
+ sky130_fd_sc_hd__o31ai_2
X_15892_ net645 _06765_ _06768_ VSS VSS VDD VDD _06769_ sky130_fd_sc_hd__o21bai_2
X_15893_ _12001_ _06642_ _06637_ net467 VSS VSS VDD VDD _06770_
+ sky130_fd_sc_hd__o22ai_1
X_15894_ _06569_ _06770_ _06565_ VSS VSS VDD VDD _06771_ sky130_fd_sc_hd__a21oi_1
X_15895_ _06654_ _06720_ _06505_ VSS VSS VDD VDD _06772_ sky130_fd_sc_hd__a21oi_1
X_15896_ _06505_ _06736_ _06762_ _06772_ VSS VSS VDD VDD _06773_
+ sky130_fd_sc_hd__a31oi_1
X_15897_ _06769_ _06771_ _06773_ _06626_ VSS VSS VDD VDD _06774_
+ sky130_fd_sc_hd__o2bb2ai_1
X_15898_ _06631_ _06764_ _06774_ VSS VSS VDD VDD _06775_ sky130_fd_sc_hd__nor3_1
X_15899_ _06740_ _06761_ _06775_ VSS VSS VDD VDD _00041_ sky130_fd_sc_hd__nor3_1
X_15900_ _06494_ _06537_ VSS VSS VDD VDD _06776_ sky130_fd_sc_hd__nor2_4
X_15901_ _06487_ _06505_ VSS VSS VDD VDD _06777_ sky130_fd_sc_hd__nand2_1
X_15902_ _06542_ _06776_ _06777_ _06553_ _12010_ VSS VSS VDD
+ VDD _06778_ sky130_fd_sc_hd__o32ai_1
X_15903_ _06639_ _06620_ VSS VSS VDD VDD _06779_ sky130_fd_sc_hd__nand2_1
X_15904_ _11997_ _06541_ VSS VSS VDD VDD _06780_ sky130_fd_sc_hd__nor2_2
X_15905_ _06505_ _06776_ _06780_ VSS VSS VDD VDD _06781_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_37_910 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15907_ _06505_ _06779_ _06781_ net464 VSS VSS VDD VDD _06783_
+ sky130_fd_sc_hd__a211oi_1
X_15908_ net464 _06778_ _06783_ VSS VSS VDD VDD _06784_ sky130_fd_sc_hd__a21oi_1
X_15909_ _12010_ _06541_ VSS VSS VDD VDD _06785_ sky130_fd_sc_hd__nor2_2
X_15910_ _06776_ _06785_ VSS VSS VDD VDD _06786_ sky130_fd_sc_hd__nor2_1
X_15911_ _12001_ _06725_ _06786_ _06505_ _06557_ VSS VSS VDD
+ VDD _06787_ sky130_fd_sc_hd__a221oi_1
X_15912_ net467 _06505_ VSS VSS VDD VDD _06788_ sky130_fd_sc_hd__nor2_1
X_15913_ _06766_ _06767_ net669 VSS VSS VDD VDD _06789_ sky130_fd_sc_hd__o21ai_0
X_15914_ net669 _06635_ _06788_ _06789_ net464 VSS VSS VDD
+ VDD _06790_ sky130_fd_sc_hd__o311ai_0
X_15915_ net464 _06787_ _06790_ _06590_ VSS VSS VDD VDD _06791_
+ sky130_fd_sc_hd__o211ai_1
X_15916_ _06590_ _06784_ _06791_ VSS VSS VDD VDD _06792_ sky130_fd_sc_hd__o21ai_1
X_15917_ _12006_ _06537_ VSS VSS VDD VDD _06793_ sky130_fd_sc_hd__nand2_4
X_15918_ _06505_ _06731_ _06793_ VSS VSS VDD VDD _06794_ sky130_fd_sc_hd__nand3_1
X_15919_ _06658_ _06719_ net670 VSS VSS VDD VDD _06795_ sky130_fd_sc_hd__o21ai_1
X_15920_ net464 _06794_ _06795_ VSS VSS VDD VDD _06796_ sky130_fd_sc_hd__nand3_1
X_15921_ net466 _06503_ VSS VSS VDD VDD _06797_ sky130_fd_sc_hd__nor2_1
X_15922_ _12006_ _06505_ VSS VSS VDD VDD _06798_ sky130_fd_sc_hd__nor2_1
X_15923_ _06797_ _06798_ net669 VSS VSS VDD VDD _06799_ sky130_fd_sc_hd__o21ai_0
X_15924_ _12010_ _06505_ VSS VSS VDD VDD _06800_ sky130_fd_sc_hd__nand2_1
X_15925_ _06494_ _06503_ _06541_ VSS VSS VDD VDD _06801_ sky130_fd_sc_hd__a21oi_2
X_15926_ _06800_ _06801_ VSS VSS VDD VDD _06802_ sky130_fd_sc_hd__nand2_1
X_15927_ net619 _06799_ _06802_ VSS VSS VDD VDD _06803_ sky130_fd_sc_hd__nand3_1
X_15928_ _06565_ _06796_ _06803_ VSS VSS VDD VDD _06804_ sky130_fd_sc_hd__nand3_1
X_15929_ _12010_ net645 VSS VSS VDD VDD _06805_ sky130_fd_sc_hd__nand2b_1
X_15930_ _06505_ _06776_ _06659_ VSS VSS VDD VDD _06806_ sky130_fd_sc_hd__nor3_1
X_15931_ _06505_ _06749_ _06805_ _06806_ VSS VSS VDD VDD _06807_
+ sky130_fd_sc_hd__a31oi_1
X_15932_ net670 _06793_ _06713_ net619 _06766_ VSS VSS VDD
+ VDD _06808_ sky130_fd_sc_hd__a311o_1
X_15933_ net464 _06807_ _06808_ _06590_ VSS VSS VDD VDD _06809_
+ sky130_fd_sc_hd__o211ai_1
X_15934_ _06804_ _06809_ _06612_ VSS VSS VDD VDD _06810_ sky130_fd_sc_hd__a21oi_2
X_15935_ _06590_ _06575_ _06677_ VSS VSS VDD VDD _06811_ sky130_fd_sc_hd__o21ai_1
X_15936_ _06541_ _06643_ _06542_ _06505_ _06590_ VSS VSS VDD
+ VDD _06812_ sky130_fd_sc_hd__a2111oi_0
X_15937_ _06494_ _06505_ _06541_ VSS VSS VDD VDD _06813_ sky130_fd_sc_hd__nand3_1
X_15938_ _12024_ net645 VSS VSS VDD VDD _06814_ sky130_fd_sc_hd__nand2_1
X_15939_ _06813_ _06814_ _06565_ VSS VSS VDD VDD _06815_ sky130_fd_sc_hd__a21oi_1
X_15940_ _12004_ _06537_ VSS VSS VDD VDD _06816_ sky130_fd_sc_hd__nand2_1
X_15941_ _06689_ _06755_ _06816_ VSS VSS VDD VDD _06817_ sky130_fd_sc_hd__nor3b_1
X_15942_ net466 _06811_ _06812_ _06815_ _06817_ VSS VSS VDD
+ VDD _06818_ sky130_fd_sc_hd__a2111oi_1
X_15943_ _06603_ net464 _06818_ VSS VSS VDD VDD _06819_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_37_909 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_15945_ net645 _06694_ _06767_ VSS VSS VDD VDD _06821_ sky130_fd_sc_hd__nor3_1
X_15946_ _12017_ net645 _06821_ _06590_ VSS VSS VDD VDD _06822_
+ sky130_fd_sc_hd__a211oi_1
X_15947_ _06487_ _06503_ VSS VSS VDD VDD _06823_ sky130_fd_sc_hd__nand2_1
X_15948_ _12020_ net669 VSS VSS VDD VDD _06824_ sky130_fd_sc_hd__nor2_1
X_15949_ net669 _06823_ _06695_ _06824_ _06565_ VSS VSS VDD
+ VDD _06825_ sky130_fd_sc_hd__a311oi_1
X_15950_ _06629_ net619 _06822_ _06825_ VSS VSS VDD VDD _06826_
+ sky130_fd_sc_hd__nor4_1
X_15951_ _06487_ _06505_ _06776_ _06713_ _06714_ VSS VSS VDD
+ VDD _06827_ sky130_fd_sc_hd__o32ai_1
X_15952_ _06639_ _06777_ _11997_ VSS VSS VDD VDD _06828_ sky130_fd_sc_hd__a21oi_1
X_15953_ _06629_ net464 VSS VSS VDD VDD _06829_ sky130_fd_sc_hd__nor2_1
X_15954_ net670 _06639_ _06648_ VSS VSS VDD VDD _06830_ sky130_fd_sc_hd__nand3_1
X_15955_ _06505_ _06731_ _06721_ VSS VSS VDD VDD _06831_ sky130_fd_sc_hd__nand3_1
X_15956_ _06590_ _06830_ _06831_ VSS VSS VDD VDD _06832_ sky130_fd_sc_hd__nand3_1
X_15957_ _06590_ _06827_ _06828_ _06829_ _06832_ VSS VSS VDD
+ VDD _06833_ sky130_fd_sc_hd__o311a_1
X_15958_ net670 _06731_ _06721_ _06579_ _12001_ VSS VSS VDD
+ VDD _06834_ sky130_fd_sc_hd__a32oi_1
X_15959_ _06487_ net465 VSS VSS VDD VDD _06835_ sky130_fd_sc_hd__nand2_1
X_15960_ _12015_ _06541_ VSS VSS VDD VDD _06836_ sky130_fd_sc_hd__nand2_1
X_15961_ _06503_ net669 _06835_ _06836_ _06590_ VSS VSS VDD
+ VDD _06837_ sky130_fd_sc_hd__o311ai_0
X_15962_ _06590_ _06834_ _06837_ VSS VSS VDD VDD _06838_ sky130_fd_sc_hd__o21ai_0
X_15963_ _06629_ net464 _06838_ _06611_ VSS VSS VDD VDD _06839_
+ sky130_fd_sc_hd__a31oi_1
X_15964_ _06819_ _06826_ _06833_ _06839_ VSS VSS VDD VDD _06840_
+ sky130_fd_sc_hd__nor4b_2
X_15965_ _06702_ _06792_ _06810_ _06840_ VSS VSS VDD VDD _00042_
+ sky130_fd_sc_hd__a211oi_4
X_15966_ net465 _06537_ VSS VSS VDD VDD _06841_ sky130_fd_sc_hd__nand2_1
X_15967_ _11997_ _06540_ _06841_ _06797_ _06801_ net466 VSS
+ VSS VDD VDD _06842_ sky130_fd_sc_hd__a222oi_1
X_15968_ net465 _06725_ VSS VSS VDD VDD _06843_ sky130_fd_sc_hd__nand2_1
X_15969_ _06583_ _06658_ _06505_ VSS VSS VDD VDD _06844_ sky130_fd_sc_hd__o21ai_0
X_15970_ _06843_ _06844_ _06520_ VSS VSS VDD VDD _06845_ sky130_fd_sc_hd__a21oi_1
X_15971_ _06520_ _06842_ _06845_ VSS VSS VDD VDD _06846_ sky130_fd_sc_hd__a21oi_1
X_15972_ _12004_ _06541_ VSS VSS VDD VDD _06847_ sky130_fd_sc_hd__nor2_1
X_15973_ _06847_ _06505_ _06640_ VSS VSS VDD VDD _06848_ sky130_fd_sc_hd__nor3b_1
X_15974_ _06505_ _06736_ _06731_ _06848_ _06626_ VSS VSS VDD
+ VDD _06849_ sky130_fd_sc_hd__a311oi_1
X_15975_ _11997_ net645 VSS VSS VDD VDD _06850_ sky130_fd_sc_hd__nand2b_1
X_15976_ _06639_ _06749_ net532 VSS VSS VDD VDD _06851_ sky130_fd_sc_hd__a21oi_1
X_15977_ net532 _06587_ _06850_ _06851_ _06615_ VSS VSS VDD
+ VDD _06852_ sky130_fd_sc_hd__a311oi_1
X_15978_ _06590_ _06846_ _06849_ _06852_ _06631_ VSS VSS VDD
+ VDD _06853_ sky130_fd_sc_hd__a2111oi_0
X_15979_ _06505_ _06617_ _06850_ VSS VSS VDD VDD _06854_ sky130_fd_sc_hd__nand3_1
X_15980_ _06520_ _06541_ VSS VSS VDD VDD _06855_ sky130_fd_sc_hd__nand2_2
X_15981_ _06682_ _06855_ _12004_ VSS VSS VDD VDD _06856_ sky130_fd_sc_hd__a21oi_1
X_15982_ _06520_ _06537_ VSS VSS VDD VDD _06857_ sky130_fd_sc_hd__nand2_2
X_15983_ _06682_ _06857_ VSS VSS VDD VDD _06858_ sky130_fd_sc_hd__nor2_1
X_15984_ _06856_ _06858_ net670 VSS VSS VDD VDD _06859_ sky130_fd_sc_hd__o21ai_0
X_15985_ _06854_ _06859_ _06615_ VSS VSS VDD VDD _06860_ sky130_fd_sc_hd__a21oi_1
X_15986_ _06505_ _06780_ _06726_ VSS VSS VDD VDD _06861_ sky130_fd_sc_hd__nor3_2
X_15987_ _06505_ _06587_ _06793_ _06758_ _06861_ VSS VSS VDD
+ VDD _06862_ sky130_fd_sc_hd__a311oi_2
X_15988_ net465 _06537_ VSS VSS VDD VDD _06863_ sky130_fd_sc_hd__nor2_1
X_15989_ _06863_ _06847_ _06505_ VSS VSS VDD VDD _06864_ sky130_fd_sc_hd__o21ai_0
X_15990_ _11997_ _06575_ _06617_ _06864_ VSS VSS VDD VDD _06865_
+ sky130_fd_sc_hd__o211a_1
X_15991_ _06835_ _06696_ _06540_ VSS VSS VDD VDD _06866_ sky130_fd_sc_hd__a21o_1
X_15992_ _06656_ _06866_ _06671_ VSS VSS VDD VDD _06867_ sky130_fd_sc_hd__a21oi_1
X_15993_ _06626_ _06865_ _06867_ VSS VSS VDD VDD _06868_ sky130_fd_sc_hd__o21ai_0
X_15994_ _12006_ _06541_ VSS VSS VDD VDD _06869_ sky130_fd_sc_hd__nand2_4
X_15995_ _06649_ _06869_ _06505_ VSS VSS VDD VDD _06870_ sky130_fd_sc_hd__a21oi_4
X_15996_ _06762_ _06757_ net532 VSS VSS VDD VDD _06871_ sky130_fd_sc_hd__a21oi_1
X_15997_ _06626_ _06870_ _06871_ _06758_ _06802_ VSS VSS VDD
+ VDD _06872_ sky130_fd_sc_hd__o32ai_1
X_15998_ net532 _06639_ net465 VSS VSS VDD VDD _06873_ sky130_fd_sc_hd__a21oi_1
X_15999_ _11996_ _06553_ _06642_ net467 VSS VSS VDD VDD _06874_
+ sky130_fd_sc_hd__o22ai_1
X_16000_ _06615_ _06873_ _06874_ VSS VSS VDD VDD _06875_ sky130_fd_sc_hd__nor3_1
X_16001_ _12006_ _06503_ VSS VSS VDD VDD _06876_ sky130_fd_sc_hd__nor2_1
X_16002_ net670 _06643_ _06876_ net645 VSS VSS VDD VDD _06877_
+ sky130_fd_sc_hd__a211oi_1
X_16003_ _06708_ _06709_ _06877_ net619 _06565_ VSS VSS VDD
+ VDD _06878_ sky130_fd_sc_hd__a2111oi_0
X_16004_ _06872_ _06875_ _06878_ VSS VSS VDD VDD _06879_ sky130_fd_sc_hd__nor3_1
X_16005_ _06860_ _06862_ _06868_ _06879_ _06612_ VSS VSS VDD
+ VDD _06880_ sky130_fd_sc_hd__o32ai_2
X_16006_ _06494_ _06725_ _06637_ _12006_ VSS VSS VDD VDD _06881_
+ sky130_fd_sc_hd__a22oi_1
X_16007_ _06505_ net464 VSS VSS VDD VDD _06882_ sky130_fd_sc_hd__nor2_1
X_16008_ _06620_ _06850_ VSS VSS VDD VDD _06883_ sky130_fd_sc_hd__nand2_1
X_16009_ _06882_ _06883_ _06590_ VSS VSS VDD VDD _06884_ sky130_fd_sc_hd__a21oi_1
X_16010_ net619 _06881_ _06884_ VSS VSS VDD VDD _06885_ sky130_fd_sc_hd__o21ai_0
X_16011_ net670 _06658_ _06847_ VSS VSS VDD VDD _06886_ sky130_fd_sc_hd__or3_1
X_16012_ _06505_ _06779_ _06886_ VSS VSS VDD VDD _06887_ sky130_fd_sc_hd__o21ai_0
X_16013_ net669 _06643_ _06780_ VSS VSS VDD VDD _06888_ sky130_fd_sc_hd__a21oi_1
X_16014_ _06736_ _06587_ net670 VSS VSS VDD VDD _06889_ sky130_fd_sc_hd__a21oi_1
X_16015_ net532 _06888_ _06889_ VSS VSS VDD VDD _06890_ sky130_fd_sc_hd__a21oi_1
X_16016_ _06663_ _06887_ _06890_ _06656_ VSS VSS VDD VDD _06891_
+ sky130_fd_sc_hd__a22oi_1
X_16017_ _06885_ _06891_ _06700_ VSS VSS VDD VDD _06892_ sky130_fd_sc_hd__a21oi_1
X_16018_ _06853_ _06880_ _06892_ VSS VSS VDD VDD _00043_ sky130_fd_sc_hd__nor3_1
X_16019_ _06505_ _06654_ _06720_ _06798_ VSS VSS VDD VDD _06893_
+ sky130_fd_sc_hd__a31oi_2
X_16020_ net464 _06893_ VSS VSS VDD VDD _06894_ sky130_fd_sc_hd__nor2_1
X_16021_ _06649_ _06869_ VSS VSS VDD VDD _06895_ sky130_fd_sc_hd__nand2_1
X_16022_ net466 _06494_ _06537_ VSS VSS VDD VDD _06896_ sky130_fd_sc_hd__nor3_4
X_16023_ _06505_ _06896_ _06785_ VSS VSS VDD VDD _06897_ sky130_fd_sc_hd__nor3_1
X_16024_ _06505_ _06895_ _06897_ net619 VSS VSS VDD VDD _06898_
+ sky130_fd_sc_hd__a211oi_1
X_16025_ _11996_ _06505_ _06777_ VSS VSS VDD VDD _06899_ sky130_fd_sc_hd__o21ai_0
X_16026_ net669 _06899_ _06768_ VSS VSS VDD VDD _06900_ sky130_fd_sc_hd__a21oi_1
X_16027_ _12001_ _06541_ VSS VSS VDD VDD _06901_ sky130_fd_sc_hd__nor2_2
X_16028_ _06505_ _06896_ _06901_ VSS VSS VDD VDD _06902_ sky130_fd_sc_hd__nor3_1
X_16029_ net670 _06557_ _06785_ net619 VSS VSS VDD VDD _06903_
+ sky130_fd_sc_hd__o31ai_1
X_16030_ _06902_ _06903_ _06590_ VSS VSS VDD VDD _06904_ sky130_fd_sc_hd__o21ai_0
X_16031_ _06590_ _06894_ _06898_ _06900_ _06904_ VSS VSS VDD
+ VDD _06905_ sky130_fd_sc_hd__o32ai_1
X_16032_ _11998_ _06575_ _06617_ VSS VSS VDD VDD _06906_ sky130_fd_sc_hd__o21ai_0
X_16033_ _06647_ _06721_ _06503_ VSS VSS VDD VDD _06907_ sky130_fd_sc_hd__a21oi_1
X_16034_ _06906_ _06907_ _06520_ VSS VSS VDD VDD _06908_ sky130_fd_sc_hd__o21a_1
X_16035_ _06639_ _06762_ _06505_ VSS VSS VDD VDD _06909_ sky130_fd_sc_hd__a21oi_1
X_16036_ _12006_ _06579_ _06737_ _06909_ _06520_ VSS VSS VDD
+ VDD _06910_ sky130_fd_sc_hd__a2111oi_2
X_16037_ _06487_ _06719_ VSS VSS VDD VDD _06911_ sky130_fd_sc_hd__nand2_1
X_16038_ net467 _06540_ _06869_ _06505_ _06626_ VSS VSS VDD
+ VDD _06912_ sky130_fd_sc_hd__a221oi_1
X_16039_ _12008_ _06635_ net669 VSS VSS VDD VDD _06913_ sky130_fd_sc_hd__mux2i_1
X_16040_ _06590_ _06569_ VSS VSS VDD VDD _06914_ sky130_fd_sc_hd__nor2_2
X_16041_ _06911_ _06912_ _06913_ _06914_ VSS VSS VDD VDD _06915_
+ sky130_fd_sc_hd__a22oi_1
X_16042_ _06565_ _06908_ _06910_ _06915_ _06611_ VSS VSS VDD
+ VDD _06916_ sky130_fd_sc_hd__o311ai_2
X_16043_ _06611_ _06905_ _06916_ VSS VSS VDD VDD _06917_ sky130_fd_sc_hd__o21ai_0
X_16044_ net532 _06749_ _06721_ _06705_ _06565_ VSS VSS VDD
+ VDD _06918_ sky130_fd_sc_hd__a311oi_2
X_16045_ _06665_ _06755_ VSS VSS VDD VDD _06919_ sky130_fd_sc_hd__nor2_1
X_16046_ _06689_ _06919_ net619 VSS VSS VDD VDD _06920_ sky130_fd_sc_hd__o21ai_1
X_16047_ _06918_ _06920_ VSS VSS VDD VDD _06921_ sky130_fd_sc_hd__nor2_1
X_16048_ _06505_ _06901_ _06755_ VSS VSS VDD VDD _06922_ sky130_fd_sc_hd__nor3_1
X_16049_ _06505_ _06762_ _06649_ _06922_ VSS VSS VDD VDD _06923_
+ sky130_fd_sc_hd__a31oi_1
X_16050_ _06494_ _06575_ _06785_ net532 VSS VSS VDD VDD _06924_
+ sky130_fd_sc_hd__o22ai_1
X_16051_ _06656_ _06924_ _06612_ VSS VSS VDD VDD _06925_ sky130_fd_sc_hd__a21oi_1
X_16052_ _06615_ _06923_ _06925_ VSS VSS VDD VDD _06926_ sky130_fd_sc_hd__o21ai_0
X_16053_ _06505_ _06869_ _06665_ VSS VSS VDD VDD _06927_ sky130_fd_sc_hd__a21oi_1
X_16054_ net464 _06927_ VSS VSS VDD VDD _06928_ sky130_fd_sc_hd__nor2_1
X_16055_ net464 _06696_ VSS VSS VDD VDD _06929_ sky130_fd_sc_hd__nand2_1
X_16056_ _06505_ _06721_ _06713_ _06929_ VSS VSS VDD VDD _06930_
+ sky130_fd_sc_hd__a31oi_1
X_16057_ net464 _06776_ _06882_ VSS VSS VDD VDD _06931_ sky130_fd_sc_hd__a21oi_1
X_16058_ _06487_ _06931_ _06590_ VSS VSS VDD VDD _06932_ sky130_fd_sc_hd__o21ai_0
X_16059_ net464 _06788_ VSS VSS VDD VDD _06933_ sky130_fd_sc_hd__nand2_1
X_16060_ _11996_ _06505_ net619 VSS VSS VDD VDD _06934_ sky130_fd_sc_hd__nand3_1
X_16061_ _06503_ net619 VSS VSS VDD VDD _06935_ sky130_fd_sc_hd__nor2_1
X_16062_ _06494_ _06935_ _06487_ VSS VSS VDD VDD _06936_ sky130_fd_sc_hd__o21ai_0
X_16063_ net669 _06933_ _06934_ _06801_ _06936_ VSS VSS VDD
+ VDD _06937_ sky130_fd_sc_hd__a32oi_1
X_16064_ _06590_ _06928_ _06930_ _06932_ _06937_ VSS VSS VDD
+ VDD _06938_ sky130_fd_sc_hd__o32ai_1
X_16065_ _06921_ _06926_ _06938_ _06671_ VSS VSS VDD VDD _06939_
+ sky130_fd_sc_hd__o22ai_1
X_16066_ _06629_ _06917_ _06939_ VSS VSS VDD VDD _00044_ sky130_fd_sc_hd__a21oi_2
X_16067_ _06629_ _06630_ VSS VSS VDD VDD _06940_ sky130_fd_sc_hd__nor2_1
X_16068_ net532 _06639_ _06731_ VSS VSS VDD VDD _06941_ sky130_fd_sc_hd__nand3_1
X_16069_ net532 _06896_ _06659_ _06941_ _06565_ VSS VSS VDD
+ VDD _06942_ sky130_fd_sc_hd__o311ai_1
X_16070_ _06505_ _06648_ _06805_ VSS VSS VDD VDD _06943_ sky130_fd_sc_hd__nand3_1
X_16071_ _06505_ net669 _06682_ _06943_ _06590_ VSS VSS VDD
+ VDD _06944_ sky130_fd_sc_hd__o311ai_1
X_16072_ net619 _06942_ _06944_ VSS VSS VDD VDD _06945_ sky130_fd_sc_hd__nand3_2
X_16073_ _06590_ _06901_ _06776_ VSS VSS VDD VDD _06946_ sky130_fd_sc_hd__a21oi_1
X_16074_ _06565_ _06713_ _06676_ VSS VSS VDD VDD _06947_ sky130_fd_sc_hd__o21ai_0
X_16075_ _06565_ net669 net510 VSS VSS VDD VDD _06948_ sky130_fd_sc_hd__o21ai_0
X_16076_ net507 _06947_ _06948_ net532 VSS VSS VDD VDD _06949_
+ sky130_fd_sc_hd__o211ai_1
X_16077_ _06586_ _06692_ net619 VSS VSS VDD VDD _06950_ sky130_fd_sc_hd__a21oi_1
X_16078_ net532 _06946_ _06949_ _06950_ VSS VSS VDD VDD _06951_
+ sky130_fd_sc_hd__o211ai_1
X_16079_ _06940_ _06945_ _06951_ VSS VSS VDD VDD _06952_ sky130_fd_sc_hd__nand3_1
X_16080_ _12001_ net669 _06573_ _12006_ _06590_ VSS VSS VDD
+ VDD _06953_ sky130_fd_sc_hd__a221o_1
X_16081_ net670 _06654_ _06896_ VSS VSS VDD VDD _06954_ sky130_fd_sc_hd__a21oi_1
X_16082_ _06622_ _06953_ _06954_ _06565_ VSS VSS VDD VDD _06955_
+ sky130_fd_sc_hd__o22ai_1
X_16083_ _06505_ _06895_ _06813_ _06656_ VSS VSS VDD VDD _06956_
+ sky130_fd_sc_hd__o211ai_2
X_16084_ _06505_ _06548_ VSS VSS VDD VDD _06957_ sky130_fd_sc_hd__nand2_1
X_16085_ _06914_ _06668_ _06957_ VSS VSS VDD VDD _06958_ sky130_fd_sc_hd__nand3_1
X_16086_ _06520_ _06955_ _06956_ _06958_ VSS VSS VDD VDD _06959_
+ sky130_fd_sc_hd__o211a_1
X_16087_ _06640_ _06757_ net532 VSS VSS VDD VDD _06960_ sky130_fd_sc_hd__a21oi_1
X_16088_ _11997_ _06553_ _06520_ VSS VSS VDD VDD _06961_ sky130_fd_sc_hd__o21ai_0
X_16089_ _11998_ net645 _06720_ VSS VSS VDD VDD _06962_ sky130_fd_sc_hd__a21boi_1
X_16090_ _06487_ _06575_ _06962_ net532 _06569_ VSS VSS VDD
+ VDD _06963_ sky130_fd_sc_hd__o221ai_4
X_16091_ _06960_ _06961_ _06963_ _06590_ _06629_ VSS VSS VDD
+ VDD _06964_ sky130_fd_sc_hd__o2111ai_1
X_16092_ net464 _06553_ _06857_ VSS VSS VDD VDD _06965_ sky130_fd_sc_hd__o21ai_0
X_16093_ net619 _06583_ _06965_ _06487_ VSS VSS VDD VDD _06966_
+ sky130_fd_sc_hd__a22oi_2
X_16094_ _12004_ _06579_ _06725_ net507 VSS VSS VDD VDD _06967_
+ sky130_fd_sc_hd__a22oi_2
X_16095_ net619 _06541_ VSS VSS VDD VDD _06968_ sky130_fd_sc_hd__nand2_1
X_16096_ net467 _06642_ _06968_ _06603_ _06590_ VSS VSS VDD
+ VDD _06969_ sky130_fd_sc_hd__a311oi_2
X_16097_ net509 _06966_ _06967_ net464 _06969_ VSS VSS VDD
+ VDD _06970_ sky130_fd_sc_hd__o221ai_4
X_16098_ _06629_ _06959_ _06964_ _06970_ _06630_ VSS VSS VDD
+ VDD _06971_ sky130_fd_sc_hd__o2111ai_2
X_16099_ _06725_ _06682_ VSS VSS VDD VDD _06972_ sky130_fd_sc_hd__nand2_1
X_16100_ _06648_ _06656_ _06972_ _06700_ VSS VSS VDD VDD _06973_
+ sky130_fd_sc_hd__a31oi_1
X_16101_ _06540_ _06643_ _06615_ VSS VSS VDD VDD _06974_ sky130_fd_sc_hd__a21oi_1
X_16102_ _06586_ _06714_ _06715_ _06974_ VSS VSS VDD VDD _06975_
+ sky130_fd_sc_hd__o31ai_1
X_16103_ net532 _06649_ _06731_ VSS VSS VDD VDD _06976_ sky130_fd_sc_hd__nand3_1
X_16104_ _06590_ _06943_ _06976_ VSS VSS VDD VDD _06977_ sky130_fd_sc_hd__nand3_1
X_16105_ _12001_ _06573_ VSS VSS VDD VDD _06978_ sky130_fd_sc_hd__nand2_1
X_16106_ _12010_ net532 net669 VSS VSS VDD VDD _06979_ sky130_fd_sc_hd__o21ai_0
X_16107_ _06565_ _06978_ _06979_ _06520_ VSS VSS VDD VDD _06980_
+ sky130_fd_sc_hd__a31oi_1
X_16108_ _06977_ _06980_ VSS VSS VDD VDD _06981_ sky130_fd_sc_hd__nand2_1
X_16109_ _06973_ _06975_ _06981_ VSS VSS VDD VDD _06982_ sky130_fd_sc_hd__nand3_2
X_16110_ _06952_ _06971_ _06982_ VSS VSS VDD VDD _00045_ sky130_fd_sc_hd__and3_1
X_16111_ _12006_ net645 _06816_ VSS VSS VDD VDD _06983_ sky130_fd_sc_hd__o21ai_1
X_16112_ _06505_ _06983_ _06735_ net464 VSS VSS VDD VDD _06984_
+ sky130_fd_sc_hd__a211oi_4
X_16113_ net464 _06789_ _06984_ VSS VSS VDD VDD _06985_ sky130_fd_sc_hd__a21oi_1
X_16114_ _12006_ _06505_ net669 _06788_ VSS VSS VDD VDD _06986_
+ sky130_fd_sc_hd__a211oi_1
X_16115_ _12014_ net669 _06986_ VSS VSS VDD VDD _06987_ sky130_fd_sc_hd__a21oi_1
X_16116_ _11997_ _06553_ net619 VSS VSS VDD VDD _06988_ sky130_fd_sc_hd__o21ai_0
X_16117_ net619 _06987_ _06988_ _06889_ _06565_ VSS VSS VDD
+ VDD _06989_ sky130_fd_sc_hd__o221ai_1
X_16118_ _06565_ _06985_ _06989_ VSS VSS VDD VDD _06990_ sky130_fd_sc_hd__o21ai_0
X_16119_ _06520_ _06580_ VSS VSS VDD VDD _06991_ sky130_fd_sc_hd__nand2_1
X_16120_ net584 _06505_ VSS VSS VDD VDD _06992_ sky130_fd_sc_hd__nand2_1
X_16121_ _06553_ _06736_ _06992_ VSS VSS VDD VDD _06993_ sky130_fd_sc_hd__nand3_1
X_16122_ _06870_ _06991_ _06993_ _06520_ VSS VSS VDD VDD _06994_
+ sky130_fd_sc_hd__o22ai_4
X_16123_ _06616_ _06617_ net532 VSS VSS VDD VDD _06995_ sky130_fd_sc_hd__a21oi_1
X_16124_ net619 _06861_ _06995_ VSS VSS VDD VDD _06996_ sky130_fd_sc_hd__nor3_1
X_16125_ _11997_ _06505_ net619 net645 VSS VSS VDD VDD _06997_
+ sky130_fd_sc_hd__o211ai_1
X_16126_ net532 _06835_ VSS VSS VDD VDD _06998_ sky130_fd_sc_hd__nor2_1
X_16127_ _12015_ _06968_ _06997_ _06998_ _06565_ VSS VSS VDD
+ VDD _06999_ sky130_fd_sc_hd__o221ai_1
X_16128_ net645 _06643_ VSS VSS VDD VDD _07000_ sky130_fd_sc_hd__nand2_1
X_16129_ net532 _06617_ _07000_ VSS VSS VDD VDD _07001_ sky130_fd_sc_hd__nand3_1
X_16130_ _06776_ _06780_ _06505_ VSS VSS VDD VDD _07002_ sky130_fd_sc_hd__o21ai_1
X_16131_ net465 _06505_ _06487_ VSS VSS VDD VDD _07003_ sky130_fd_sc_hd__o21ai_0
X_16132_ net669 _07003_ _06758_ _06625_ VSS VSS VDD VDD _07004_
+ sky130_fd_sc_hd__a211oi_1
X_16133_ _06656_ _07001_ _07002_ _07004_ _06631_ VSS VSS VDD
+ VDD _07005_ sky130_fd_sc_hd__a311oi_1
X_16134_ _06996_ _06999_ _07005_ VSS VSS VDD VDD _07006_ sky130_fd_sc_hd__o21ai_1
X_16135_ net466 _06714_ _06542_ VSS VSS VDD VDD _07007_ sky130_fd_sc_hd__a21oi_1
X_16136_ net465 net532 _07007_ _12010_ VSS VSS VDD VDD _07008_
+ sky130_fd_sc_hd__o22ai_1
X_16137_ _06487_ _06520_ VSS VSS VDD VDD _07009_ sky130_fd_sc_hd__nand2_1
X_16138_ _06487_ _06968_ _07009_ VSS VSS VDD VDD _07010_ sky130_fd_sc_hd__o21ai_0
X_16139_ net464 _06785_ _06788_ VSS VSS VDD VDD _07011_ sky130_fd_sc_hd__o21ai_0
X_16140_ _06696_ _06855_ _07011_ _06565_ _06940_ VSS VSS VDD
+ VDD _07012_ sky130_fd_sc_hd__o2111ai_1
X_16141_ net619 _07008_ _07010_ net508 _07012_ VSS VSS VDD
+ VDD _07013_ sky130_fd_sc_hd__a221o_1
X_16142_ _06612_ _06565_ _06994_ _07006_ _07013_ VSS VSS VDD
+ VDD _07014_ sky130_fd_sc_hd__o311ai_1
X_16143_ _06659_ _06755_ _06505_ VSS VSS VDD VDD _07015_ sky130_fd_sc_hd__o21ai_0
X_16144_ net532 _06620_ _06757_ VSS VSS VDD VDD _07016_ sky130_fd_sc_hd__nand3_1
X_16145_ _06656_ _07015_ _07016_ VSS VSS VDD VDD _07017_ sky130_fd_sc_hd__nand3_1
X_16146_ _12006_ net669 _06719_ VSS VSS VDD VDD _07018_ sky130_fd_sc_hd__a21oi_1
X_16147_ net645 _06643_ VSS VSS VDD VDD _07019_ sky130_fd_sc_hd__nor2_1
X_16148_ net532 _06780_ _07019_ VSS VSS VDD VDD _07020_ sky130_fd_sc_hd__nor3_1
X_16149_ net532 _07018_ _07020_ VSS VSS VDD VDD _07021_ sky130_fd_sc_hd__a21oi_1
X_16150_ _11996_ net669 _06869_ VSS VSS VDD VDD _07022_ sky130_fd_sc_hd__o21ai_0
X_16151_ _11998_ _06579_ _07022_ net532 _06590_ VSS VSS VDD
+ VDD _07023_ sky130_fd_sc_hd__a221o_1
X_16152_ _06565_ _07021_ _07023_ _06569_ VSS VSS VDD VDD _07024_
+ sky130_fd_sc_hd__o211ai_1
X_16153_ _06487_ _06505_ _06653_ VSS VSS VDD VDD _07025_ sky130_fd_sc_hd__o21ai_1
X_16154_ _12013_ _12022_ net669 _06914_ _07025_ VSS VSS VDD
+ VDD _07026_ sky130_fd_sc_hd__o311ai_1
X_16155_ _07017_ _07024_ _07026_ _06671_ VSS VSS VDD VDD _07027_
+ sky130_fd_sc_hd__a31oi_1
X_16156_ _06702_ _06990_ _07014_ _07027_ VSS VSS VDD VDD _00046_
+ sky130_fd_sc_hd__a211o_1
X_16157_ _12010_ _06553_ _06637_ _11997_ _06754_ VSS VSS VDD
+ VDD _07028_ sky130_fd_sc_hd__o221ai_2
X_16158_ _06793_ _06713_ net532 VSS VSS VDD VDD _07029_ sky130_fd_sc_hd__a21oi_1
X_16159_ net532 _06786_ _07029_ net619 VSS VSS VDD VDD _07030_
+ sky130_fd_sc_hd__a211oi_1
X_16160_ net619 _07028_ _07030_ VSS VSS VDD VDD _07031_ sky130_fd_sc_hd__a21o_1
X_16161_ _06841_ _06813_ net466 VSS VSS VDD VDD _07032_ sky130_fd_sc_hd__a21oi_1
X_16162_ _11996_ _06540_ _06573_ net465 _07032_ VSS VSS VDD
+ VDD _07033_ sky130_fd_sc_hd__a221oi_2
X_16163_ _12006_ _06684_ net464 VSS VSS VDD VDD _07034_ sky130_fd_sc_hd__o21ai_0
X_16164_ net670 _06713_ _06757_ _07034_ VSS VSS VDD VDD _07035_
+ sky130_fd_sc_hd__a31oi_1
X_16165_ net619 _07033_ _07035_ _06590_ _06612_ VSS VSS VDD
+ VDD _07036_ sky130_fd_sc_hd__a2111oi_0
X_16166_ _06940_ _06590_ _07031_ _07036_ VSS VSS VDD VDD _07037_
+ sky130_fd_sc_hd__a31oi_1
X_16167_ _11998_ _06573_ VSS VSS VDD VDD _07038_ sky130_fd_sc_hd__nand2_1
X_16168_ _12008_ net645 _07038_ VSS VSS VDD VDD _07039_ sky130_fd_sc_hd__o21ai_0
X_16169_ _06914_ _07039_ _06631_ VSS VSS VDD VDD _07040_ sky130_fd_sc_hd__a21oi_1
X_16170_ _06505_ _06704_ _06658_ _06663_ _06746_ VSS VSS VDD
+ VDD _07041_ sky130_fd_sc_hd__o311ai_2
X_16171_ _12006_ net670 _06694_ VSS VSS VDD VDD _07042_ sky130_fd_sc_hd__a21oi_1
X_16172_ _12022_ net645 VSS VSS VDD VDD _07043_ sky130_fd_sc_hd__nor2_1
X_16173_ net645 _07042_ _07043_ VSS VSS VDD VDD _07044_ sky130_fd_sc_hd__a21oi_1
X_16174_ _12001_ _06505_ _06992_ VSS VSS VDD VDD _07045_ sky130_fd_sc_hd__o21ai_0
X_16175_ _06704_ _06696_ _07045_ net669 _06626_ VSS VSS VDD
+ VDD _07046_ sky130_fd_sc_hd__a221oi_1
X_16176_ _06656_ _07044_ _07046_ VSS VSS VDD VDD _07047_ sky130_fd_sc_hd__a21oi_1
X_16177_ _07040_ _07041_ _07047_ VSS VSS VDD VDD _07048_ sky130_fd_sc_hd__nand3_1
X_16178_ _11997_ _12004_ _06505_ VSS VSS VDD VDD _07049_ sky130_fd_sc_hd__mux2i_1
X_16179_ _06855_ _07049_ _06565_ VSS VSS VDD VDD _07050_ sky130_fd_sc_hd__o21ai_0
X_16180_ net467 net507 net532 VSS VSS VDD VDD _07051_ sky130_fd_sc_hd__nor3_1
X_16181_ _11996_ net532 _07051_ VSS VSS VDD VDD _07052_ sky130_fd_sc_hd__a21oi_1
X_16182_ net464 _06583_ VSS VSS VDD VDD _07053_ sky130_fd_sc_hd__nor2_1
X_16183_ _06553_ _06643_ _07018_ net532 _07053_ VSS VSS VDD
+ VDD _07054_ sky130_fd_sc_hd__o221ai_1
X_16184_ _06857_ _07052_ _07054_ VSS VSS VDD VDD _07055_ sky130_fd_sc_hd__o21ai_0
X_16185_ net464 _06901_ VSS VSS VDD VDD _07056_ sky130_fd_sc_hd__nor2_1
X_16186_ _06505_ _06616_ _06713_ VSS VSS VDD VDD _07057_ sky130_fd_sc_hd__nand3_1
X_16187_ _11996_ _06505_ _07057_ VSS VSS VDD VDD _07058_ sky130_fd_sc_hd__o21ai_0
X_16188_ _07025_ _07056_ _07058_ _06520_ VSS VSS VDD VDD _07059_
+ sky130_fd_sc_hd__a22oi_1
X_16189_ _06671_ VSS VSS VDD VDD _07060_ sky130_fd_sc_hd__inv_1
X_16190_ _07050_ _07055_ _07059_ _06565_ _07060_ VSS VSS VDD
+ VDD _07061_ sky130_fd_sc_hd__o221ai_1
X_16191_ net465 _06575_ _06684_ VSS VSS VDD VDD _07062_ sky130_fd_sc_hd__o21ai_0
X_16192_ _06736_ _06724_ net464 VSS VSS VDD VDD _07063_ sky130_fd_sc_hd__a21oi_1
X_16193_ _06573_ _06863_ net467 VSS VSS VDD VDD _07064_ sky130_fd_sc_hd__o21ai_0
X_16194_ _06911_ _07064_ _06569_ VSS VSS VDD VDD _07065_ sky130_fd_sc_hd__a21oi_1
X_16195_ _06487_ _07062_ _07063_ _07065_ VSS VSS VDD VDD _07066_
+ sky130_fd_sc_hd__a211oi_1
X_16196_ _06642_ _06855_ net465 VSS VSS VDD VDD _07067_ sky130_fd_sc_hd__a21oi_1
X_16197_ net465 net619 _06540_ _07067_ VSS VSS VDD VDD _07068_
+ sky130_fd_sc_hd__a31oi_1
X_16198_ _11997_ _06725_ _06935_ _06565_ VSS VSS VDD VDD _07069_
+ sky130_fd_sc_hd__a211oi_1
X_16199_ net466 _07068_ _07069_ VSS VSS VDD VDD _07070_ sky130_fd_sc_hd__o21ai_0
X_16200_ _06590_ _07066_ _07070_ _06702_ VSS VSS VDD VDD _07071_
+ sky130_fd_sc_hd__o211ai_1
X_16201_ _07037_ _07048_ _07061_ _07071_ VSS VSS VDD VDD _00047_
+ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_37_908 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_907 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16204_ sa02_sr\[7\] sa02_sr\[0\] VSS VSS VDD VDD _07074_
+ sky130_fd_sc_hd__xnor2_1
X_16205_ sa20_sub\[1\] sa31_sub\[1\] VSS VSS VDD VDD _07075_
+ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_37_906 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_905 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16208_ sa12_sr\[7\] sa12_sr\[0\] sa12_sr\[1\] VSS VSS VDD
+ VDD _07078_ sky130_fd_sc_hd__xor3_1
X_16209_ _07074_ _07075_ _07078_ VSS VSS VDD VDD _07079_ sky130_fd_sc_hd__xnor3_1
X_16210_ text_in_r\[57\] _07079_ _05879_ VSS VSS VDD VDD _07080_
+ sky130_fd_sc_hd__mux2i_4
X_16211_ u0.w\[2\]\[25\] _07080_ VSS VSS VDD VDD _07081_ sky130_fd_sc_hd__xor2_4
X_16212_ net647 VSS VSS VDD VDD _07082_ sky130_fd_sc_hd__inv_16
XTAP_TAPCELL_ROW_37_904 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_903 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16215_ sa02_sr\[7\] sa12_sr\[7\] VSS VSS VDD VDD _07084_
+ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_37_902 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16217_ sa12_sr\[0\] sa20_sub\[0\] sa31_sub\[0\] VSS VSS
+ VDD VDD _07086_ sky130_fd_sc_hd__xnor3_1
X_16218_ _07084_ _07086_ VSS VSS VDD VDD _07087_ sky130_fd_sc_hd__xnor2_1
X_16219_ text_in_r\[56\] _07087_ _05879_ VSS VSS VDD VDD _07088_
+ sky130_fd_sc_hd__mux2i_4
X_16220_ u0.w\[2\]\[24\] _07088_ VSS VSS VDD VDD _07089_ sky130_fd_sc_hd__xor2_4
X_16221_ _07089_ VSS VSS VDD VDD _07090_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_37_901 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_900 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_899 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_898 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16226_ sa02_sr\[1\] sa12_sr\[2\] sa20_sub\[2\] VSS VSS VDD
+ VDD _07094_ sky130_fd_sc_hd__xnor3_2
XTAP_TAPCELL_ROW_37_897 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16228_ sa12_sr\[1\] sa31_sub\[2\] VSS VSS VDD VDD _07096_
+ sky130_fd_sc_hd__xnor2_1
X_16229_ _07094_ _07096_ VSS VSS VDD VDD _07097_ sky130_fd_sc_hd__xor2_1
X_16230_ text_in_r\[58\] _07097_ _05879_ VSS VSS VDD VDD _07098_
+ sky130_fd_sc_hd__mux2i_1
X_16231_ u0.w\[2\]\[26\] _07098_ VSS VSS VDD VDD _07099_ sky130_fd_sc_hd__xnor2_1
X_16232_ net462 VSS VSS VDD VDD _07100_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_37_896 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_895 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_894 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_893 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_892 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_891 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_890 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_889 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_888 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_887 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16243_ sa12_sr\[7\] sa20_sub\[7\] VSS VSS VDD VDD _07108_
+ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_36_886 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16245_ sa02_sr\[6\] sa31_sub\[7\] VSS VSS VDD VDD _07110_
+ sky130_fd_sc_hd__xnor2_1
X_16246_ _07108_ _07110_ VSS VSS VDD VDD _07111_ sky130_fd_sc_hd__xnor2_1
X_16247_ sa12_sr\[6\] _07111_ VSS VSS VDD VDD _07112_ sky130_fd_sc_hd__xnor2_1
X_16248_ net493 text_in_r\[63\] VSS VSS VDD VDD _07113_ sky130_fd_sc_hd__nand2_1
X_16249_ net493 _07112_ _07113_ VSS VSS VDD VDD _07114_ sky130_fd_sc_hd__o21a_2
X_16250_ u0.w\[2\]\[31\] _07114_ VSS VSS VDD VDD _07115_ sky130_fd_sc_hd__xor2_4
X_16251_ sa02_sr\[5\] sa12_sr\[6\] sa20_sub\[6\] VSS VSS VDD
+ VDD _07116_ sky130_fd_sc_hd__xnor3_4
XTAP_TAPCELL_ROW_36_885 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16253_ sa12_sr\[5\] sa31_sub\[6\] VSS VSS VDD VDD _07118_
+ sky130_fd_sc_hd__xnor2_1
X_16254_ _07116_ _07118_ VSS VSS VDD VDD _07119_ sky130_fd_sc_hd__xnor2_1
X_16255_ net493 _07119_ VSS VSS VDD VDD _07120_ sky130_fd_sc_hd__nor2_1
X_16256_ net493 text_in_r\[62\] _07120_ VSS VSS VDD VDD _07121_
+ sky130_fd_sc_hd__a21oi_4
X_16257_ u0.w\[2\]\[30\] _07121_ VSS VSS VDD VDD _07122_ sky130_fd_sc_hd__xor2_4
X_16258_ _07115_ _07122_ VSS VSS VDD VDD _07123_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_36_884 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_883 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16261_ sa12_sr\[4\] sa20_sub\[5\] sa31_sub\[5\] VSS VSS
+ VDD VDD _07126_ sky130_fd_sc_hd__xnor3_1
XTAP_TAPCELL_ROW_36_882 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16263_ sa02_sr\[4\] sa12_sr\[5\] VSS VSS VDD VDD _07128_
+ sky130_fd_sc_hd__xor2_1
X_16264_ _07126_ _07128_ VSS VSS VDD VDD _07129_ sky130_fd_sc_hd__xnor2_1
X_16265_ text_in_r\[61\] _07129_ net547 VSS VSS VDD VDD _07130_
+ sky130_fd_sc_hd__mux2i_4
X_16266_ u0.w\[2\]\[29\] _07130_ VSS VSS VDD VDD _07131_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_36_881 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_880 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_879 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16270_ sa02_sr\[7\] sa02_sr\[3\] sa20_sub\[4\] VSS VSS VDD
+ VDD _07135_ sky130_fd_sc_hd__xnor3_1
X_16271_ sa12_sr\[3\] sa31_sub\[4\] VSS VSS VDD VDD _07136_
+ sky130_fd_sc_hd__xnor2_1
X_16272_ sa12_sr\[7\] sa12_sr\[4\] VSS VSS VDD VDD _07137_
+ sky130_fd_sc_hd__xnor2_1
X_16273_ _07135_ _07136_ _07137_ VSS VSS VDD VDD _07138_ sky130_fd_sc_hd__xnor3_1
X_16274_ text_in_r\[60\] _07138_ _05879_ VSS VSS VDD VDD _07139_
+ sky130_fd_sc_hd__mux2i_4
X_16275_ u0.w\[2\]\[28\] _07139_ VSS VSS VDD VDD _07140_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_36_878 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_877 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_876 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_875 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16280_ sa02_sr\[7\] sa02_sr\[2\] sa20_sub\[3\] VSS VSS VDD
+ VDD _07145_ sky130_fd_sc_hd__xnor3_1
X_16281_ net493 u0.w\[2\]\[27\] VSS VSS VDD VDD _07146_ sky130_fd_sc_hd__nor2b_1
X_16282_ _07145_ _07146_ VSS VSS VDD VDD _07147_ sky130_fd_sc_hd__nand2_1
X_16283_ sa02_sr\[7\] sa02_sr\[2\] sa20_sub\[3\] VSS VSS VDD
+ VDD _07148_ sky130_fd_sc_hd__xor3_1
X_16284_ u0.w\[2\]\[27\] net493 VSS VSS VDD VDD _07149_ sky130_fd_sc_hd__nor2_1
X_16285_ _07148_ _07149_ VSS VSS VDD VDD _07150_ sky130_fd_sc_hd__nand2_1
X_16286_ sa12_sr\[7\] sa12_sr\[2\] VSS VSS VDD VDD _07151_
+ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_36_874 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16288_ sa12_sr\[3\] sa31_sub\[3\] VSS VSS VDD VDD _07153_
+ sky130_fd_sc_hd__xnor2_1
X_16289_ _07151_ _07153_ VSS VSS VDD VDD _07154_ sky130_fd_sc_hd__xnor2_1
X_16290_ _07147_ _07150_ _07154_ VSS VSS VDD VDD _07155_ sky130_fd_sc_hd__a21oi_2
X_16291_ _07145_ _07149_ VSS VSS VDD VDD _07156_ sky130_fd_sc_hd__nand2_1
X_16292_ _07148_ _07146_ VSS VSS VDD VDD _07157_ sky130_fd_sc_hd__nand2_1
X_16293_ _07156_ _07157_ _07154_ VSS VSS VDD VDD _07158_ sky130_fd_sc_hd__a21boi_2
X_16294_ u0.w\[2\]\[27\] net493 VSS VSS VDD VDD _07159_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_36_873 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16296_ u0.w\[2\]\[27\] net493 text_in_r\[59\] VSS VSS VDD
+ VDD _07161_ sky130_fd_sc_hd__nand3_1
X_16297_ text_in_r\[59\] _07159_ _07161_ VSS VSS VDD VDD _07162_
+ sky130_fd_sc_hd__o21ai_2
X_16298_ _07155_ _07158_ _07162_ VSS VSS VDD VDD _07163_ sky130_fd_sc_hd__nor3_4
XTAP_TAPCELL_ROW_36_872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16301_ _07082_ _07090_ VSS VSS VDD VDD _07166_ sky130_fd_sc_hd__nor2_1
X_16302_ _07089_ _07100_ VSS VSS VDD VDD _07167_ sky130_fd_sc_hd__nor2_4
X_16303_ _07166_ _07167_ VSS VSS VDD VDD _07168_ sky130_fd_sc_hd__nor2_1
X_16304_ net459 _07168_ VSS VSS VDD VDD _07169_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_36_870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16308_ _07082_ _07090_ net457 VSS VSS VDD VDD _07173_ sky130_fd_sc_hd__a21oi_2
X_16309_ _07155_ _07158_ _07162_ VSS VSS VDD VDD _07174_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_35_867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16313_ _12028_ _07174_ VSS VSS VDD VDD _07178_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_35_864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16317_ _12036_ _07174_ VSS VSS VDD VDD _07182_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_35_861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16321_ _12029_ _07174_ VSS VSS VDD VDD _07186_ sky130_fd_sc_hd__nand2_4
X_16322_ _07182_ net461 _07186_ VSS VSS VDD VDD _07187_ sky130_fd_sc_hd__nand3b_1
X_16323_ net462 _07173_ _07178_ _07140_ _07187_ VSS VSS VDD
+ VDD _07188_ sky130_fd_sc_hd__o311ai_4
X_16324_ _07140_ _07169_ _07188_ VSS VSS VDD VDD _07189_ sky130_fd_sc_hd__o21ai_0
X_16325_ u0.w\[2\]\[28\] _07139_ VSS VSS VDD VDD _07190_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_35_858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16328_ _07082_ net463 VSS VSS VDD VDD _07193_ sky130_fd_sc_hd__nor2_1
X_16329_ _12029_ net463 VSS VSS VDD VDD _07194_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_35_856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16331_ net650 _07174_ VSS VSS VDD VDD _07196_ sky130_fd_sc_hd__nand2_4
X_16332_ _07193_ _07186_ _07194_ _07196_ VSS VSS VDD VDD _07197_
+ sky130_fd_sc_hd__a2bb2oi_1
XTAP_TAPCELL_ROW_35_855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16334_ _07100_ _07174_ VSS VSS VDD VDD _07199_ sky130_fd_sc_hd__nor2_4
X_16335_ _07100_ _07174_ VSS VSS VDD VDD _07200_ sky130_fd_sc_hd__nand2_4
X_16336_ _12036_ _07200_ VSS VSS VDD VDD _07201_ sky130_fd_sc_hd__nor2_1
X_16337_ _07100_ _07174_ VSS VSS VDD VDD _07202_ sky130_fd_sc_hd__xnor2_4
X_16338_ _12028_ _07202_ VSS VSS VDD VDD _07203_ sky130_fd_sc_hd__nor2_1
X_16339_ _12029_ _07199_ _07201_ _07203_ _07190_ VSS VSS VDD
+ VDD _07204_ sky130_fd_sc_hd__a2111oi_0
X_16340_ _07190_ _07197_ _07204_ _07131_ VSS VSS VDD VDD _07205_
+ sky130_fd_sc_hd__a211oi_1
X_16341_ _07131_ _07189_ _07205_ VSS VSS VDD VDD _07206_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_35_854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16345_ _12033_ _07174_ VSS VSS VDD VDD _07210_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_35_851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16347_ _12030_ net457 VSS VSS VDD VDD _07212_ sky130_fd_sc_hd__nor2_4
X_16348_ _07210_ _07212_ net463 VSS VSS VDD VDD _07213_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_35_850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16350_ net463 net459 VSS VSS VDD VDD _07215_ sky130_fd_sc_hd__nor2_4
X_16351_ _12028_ _07215_ VSS VSS VDD VDD _07216_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_35_849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16353_ _07090_ net459 VSS VSS VDD VDD _07218_ sky130_fd_sc_hd__nand2_4
X_16354_ _12029_ net459 VSS VSS VDD VDD _07219_ sky130_fd_sc_hd__nor2_4
X_16355_ net461 _07182_ _07219_ VSS VSS VDD VDD _07220_ sky130_fd_sc_hd__nor3_1
X_16356_ net463 _07196_ _07218_ _07220_ _07190_ VSS VSS VDD
+ VDD _07221_ sky130_fd_sc_hd__a311oi_1
X_16357_ _07190_ _07213_ _07216_ _07221_ _07122_ VSS VSS VDD
+ VDD _07222_ sky130_fd_sc_hd__a311oi_1
X_16358_ _07089_ _07174_ VSS VSS VDD VDD _07223_ sky130_fd_sc_hd__nand2_1
X_16359_ net548 _07223_ VSS VSS VDD VDD _07224_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_35_848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16361_ _12030_ _07174_ VSS VSS VDD VDD _07226_ sky130_fd_sc_hd__nor2_1
X_16362_ _07100_ _07224_ _07226_ VSS VSS VDD VDD _07227_ sky130_fd_sc_hd__nor3_1
X_16363_ _07122_ _07190_ VSS VSS VDD VDD _07228_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_35_847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16365_ _07082_ _07089_ net458 VSS VSS VDD VDD _07230_ sky130_fd_sc_hd__nand3_4
X_16366_ _12030_ net459 _07230_ VSS VSS VDD VDD _07231_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_35_846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16369_ net463 _07174_ VSS VSS VDD VDD _07234_ sky130_fd_sc_hd__nor2_4
X_16370_ _12038_ _07234_ VSS VSS VDD VDD _07235_ sky130_fd_sc_hd__nand2_1
X_16371_ _07100_ _07231_ _07235_ _07122_ _07140_ VSS VSS VDD
+ VDD _07236_ sky130_fd_sc_hd__o2111ai_1
X_16372_ u0.w\[2\]\[29\] _07130_ VSS VSS VDD VDD _07237_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_34_844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16374_ _07115_ _07237_ VSS VSS VDD VDD _07239_ sky130_fd_sc_hd__nor2_1
X_16375_ _07201_ _07227_ _07228_ _07236_ _07239_ VSS VSS VDD
+ VDD _07240_ sky130_fd_sc_hd__o311ai_1
XTAP_TAPCELL_ROW_34_843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16379_ _12049_ net459 _07215_ _12029_ _07228_ VSS VSS VDD
+ VDD _07244_ sky130_fd_sc_hd__a221oi_1
X_16380_ net649 _07090_ _07100_ VSS VSS VDD VDD _07245_ sky130_fd_sc_hd__nor3_1
X_16381_ _12033_ net463 _07174_ VSS VSS VDD VDD _07246_ sky130_fd_sc_hd__o21ai_0
X_16382_ _07245_ _07246_ _07140_ VSS VSS VDD VDD _07247_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_34_840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16384_ _12030_ _07174_ VSS VSS VDD VDD _07249_ sky130_fd_sc_hd__nand2_1
X_16385_ _07218_ _07249_ net463 VSS VSS VDD VDD _07250_ sky130_fd_sc_hd__a21oi_1
X_16386_ net463 _07163_ VSS VSS VDD VDD _07251_ sky130_fd_sc_hd__nand2_4
X_16387_ _12028_ _07251_ _07122_ VSS VSS VDD VDD _07252_ sky130_fd_sc_hd__o21ai_0
X_16388_ _07247_ _07250_ _07252_ VSS VSS VDD VDD _07253_ sky130_fd_sc_hd__nor3_1
X_16389_ _07115_ net460 _07244_ _07253_ VSS VSS VDD VDD _07254_
+ sky130_fd_sc_hd__nor4_1
XTAP_TAPCELL_ROW_34_839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16391_ _07082_ _07090_ _07174_ VSS VSS VDD VDD _07256_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_34_838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16394_ net674 _07234_ VSS VSS VDD VDD _07259_ sky130_fd_sc_hd__nand2_1
X_16395_ _12033_ net459 _07256_ _07100_ _07259_ VSS VSS VDD
+ VDD _07260_ sky130_fd_sc_hd__o221ai_2
X_16396_ _12029_ _07174_ VSS VSS VDD VDD _07261_ sky130_fd_sc_hd__nor2_2
X_16397_ _12038_ net459 VSS VSS VDD VDD _07262_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_34_836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16399_ _07261_ _07262_ net461 VSS VSS VDD VDD _07264_ sky130_fd_sc_hd__o21ai_0
X_16400_ _12033_ _07200_ _07264_ _07190_ VSS VSS VDD VDD _07265_
+ sky130_fd_sc_hd__o211ai_1
X_16401_ u0.w\[2\]\[30\] _07121_ VSS VSS VDD VDD _07266_ sky130_fd_sc_hd__xnor2_4
X_16402_ _07190_ _07260_ _07265_ _07266_ VSS VSS VDD VDD _07267_
+ sky130_fd_sc_hd__o211ai_2
X_16403_ _07222_ _07240_ _07254_ _07267_ VSS VSS VDD VDD _07268_
+ sky130_fd_sc_hd__a2bb2oi_1
X_16404_ u0.w\[2\]\[31\] _07114_ VSS VSS VDD VDD _07269_ sky130_fd_sc_hd__xnor2_4
X_16405_ _07269_ _07122_ VSS VSS VDD VDD _07270_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_34_835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16407_ _12042_ net459 VSS VSS VDD VDD _07272_ sky130_fd_sc_hd__nand2_2
X_16408_ _07082_ _07174_ VSS VSS VDD VDD _07273_ sky130_fd_sc_hd__nand2_1
X_16409_ _07090_ net463 VSS VSS VDD VDD _07274_ sky130_fd_sc_hd__nor2_1
X_16410_ net463 _07272_ _07273_ _07274_ _07196_ VSS VSS VDD
+ VDD _07275_ sky130_fd_sc_hd__a32oi_1
X_16411_ _07131_ _07275_ VSS VSS VDD VDD _07276_ sky130_fd_sc_hd__nor2_1
X_16412_ _07196_ _07272_ net463 VSS VSS VDD VDD _07277_ sky130_fd_sc_hd__a21oi_1
X_16413_ _07089_ net459 VSS VSS VDD VDD _07278_ sky130_fd_sc_hd__nor2_4
X_16414_ _12029_ _07199_ _07277_ _07278_ _07237_ VSS VSS VDD
+ VDD _07279_ sky130_fd_sc_hd__a2111oi_0
X_16415_ _07276_ _07279_ _07190_ VSS VSS VDD VDD _07280_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_34_834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16417_ _07090_ _07199_ _07215_ VSS VSS VDD VDD _07281_ sky130_fd_sc_hd__a21oi_1
X_16418_ net461 _07174_ VSS VSS VDD VDD _07282_ sky130_fd_sc_hd__nand2_1
X_16419_ net548 _07281_ _07282_ _12030_ _07259_ VSS VSS VDD
+ VDD _07283_ sky130_fd_sc_hd__o221ai_4
X_16420_ _07082_ _07174_ VSS VSS VDD VDD _07284_ sky130_fd_sc_hd__nor2_2
X_16421_ _07090_ net463 _07284_ _07251_ _12033_ VSS VSS VDD
+ VDD _07285_ sky130_fd_sc_hd__o32a_1
X_16422_ _07131_ _07285_ _07190_ VSS VSS VDD VDD _07286_ sky130_fd_sc_hd__a21oi_1
X_16423_ _07131_ _07283_ _07286_ VSS VSS VDD VDD _07287_ sky130_fd_sc_hd__o21ai_0
X_16424_ _07270_ _07280_ _07287_ VSS VSS VDD VDD _07288_ sky130_fd_sc_hd__nand3_1
X_16425_ _07123_ _07206_ _07268_ _07288_ VSS VSS VDD VDD _00048_
+ sky130_fd_sc_hd__o211ai_2
X_16426_ _12029_ net458 VSS VSS VDD VDD _07289_ sky130_fd_sc_hd__nand2b_2
X_16427_ _07289_ _07223_ VSS VSS VDD VDD _07290_ sky130_fd_sc_hd__nand2_1
X_16428_ _12028_ net458 _07212_ _07100_ VSS VSS VDD VDD _07291_
+ sky130_fd_sc_hd__a211o_1
X_16429_ net461 _07290_ _07291_ VSS VSS VDD VDD _07292_ sky130_fd_sc_hd__o21ai_0
X_16430_ net651 _07089_ _07174_ VSS VSS VDD VDD _07293_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_34_833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16432_ _07212_ _07293_ _07100_ VSS VSS VDD VDD _07295_ sky130_fd_sc_hd__o21ai_1
X_16433_ _12042_ _07174_ VSS VSS VDD VDD _07296_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_34_832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16435_ net461 _07289_ _07296_ net460 VSS VSS VDD VDD _07298_
+ sky130_fd_sc_hd__a31oi_1
X_16436_ net460 _07292_ _07295_ _07298_ _07140_ VSS VSS VDD
+ VDD _07299_ sky130_fd_sc_hd__a221oi_1
X_16437_ net461 _07223_ VSS VSS VDD VDD _07300_ sky130_fd_sc_hd__nor2_1
X_16438_ _07082_ _07090_ _07174_ VSS VSS VDD VDD _07301_ sky130_fd_sc_hd__nand3_2
X_16439_ _07289_ _07301_ _07100_ VSS VSS VDD VDD _07302_ sky130_fd_sc_hd__a21oi_1
X_16440_ _07300_ _07302_ _07237_ VSS VSS VDD VDD _07303_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_34_831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16442_ _12028_ net458 VSS VSS VDD VDD _07305_ sky130_fd_sc_hd__nor2_1
X_16443_ net548 _07174_ _07100_ VSS VSS VDD VDD _07306_ sky130_fd_sc_hd__o21ai_2
X_16444_ _07090_ net463 _07174_ VSS VSS VDD VDD _07307_ sky130_fd_sc_hd__nand3_4
X_16445_ _12033_ _07251_ _07305_ _07306_ _07307_ VSS VSS VDD
+ VDD _07308_ sky130_fd_sc_hd__o221ai_1
X_16446_ net460 _07308_ VSS VSS VDD VDD _07309_ sky130_fd_sc_hd__nand2_1
X_16447_ _07303_ _07309_ _07190_ VSS VSS VDD VDD _07310_ sky130_fd_sc_hd__a21oi_1
X_16448_ _07122_ _07299_ _07310_ VSS VSS VDD VDD _07311_ sky130_fd_sc_hd__nor3_1
X_16449_ _12036_ _07100_ VSS VSS VDD VDD _07312_ sky130_fd_sc_hd__nand2_1
X_16450_ _07082_ _07167_ VSS VSS VDD VDD _07313_ sky130_fd_sc_hd__nand2_1
X_16451_ _07174_ _07312_ _07313_ _07190_ VSS VSS VDD VDD _07314_
+ sky130_fd_sc_hd__a31oi_1
X_16452_ _12052_ _07131_ _07174_ _07314_ VSS VSS VDD VDD _07315_
+ sky130_fd_sc_hd__o31a_1
X_16453_ _07278_ _07210_ net463 VSS VSS VDD VDD _07316_ sky130_fd_sc_hd__o21ai_0
X_16454_ net649 net459 VSS VSS VDD VDD _07317_ sky130_fd_sc_hd__nor2_4
X_16455_ _07284_ _07317_ _07100_ VSS VSS VDD VDD _07318_ sky130_fd_sc_hd__o21ai_2
X_16456_ _07190_ _07237_ VSS VSS VDD VDD _07319_ sky130_fd_sc_hd__nand2_4
X_16457_ _07316_ _07318_ _07319_ VSS VSS VDD VDD _07320_ sky130_fd_sc_hd__a21oi_1
X_16458_ net650 _07174_ VSS VSS VDD VDD _07321_ sky130_fd_sc_hd__nor2_1
X_16459_ _07090_ _07100_ VSS VSS VDD VDD _07322_ sky130_fd_sc_hd__nor2_1
X_16460_ net674 net462 VSS VSS VDD VDD _07323_ sky130_fd_sc_hd__nor2_2
X_16461_ _07322_ _07323_ VSS VSS VDD VDD _07324_ sky130_fd_sc_hd__nor2_1
X_16462_ _07321_ _07324_ VSS VSS VDD VDD _07325_ sky130_fd_sc_hd__nand2_1
X_16463_ _07100_ net459 VSS VSS VDD VDD _07326_ sky130_fd_sc_hd__nor2_1
X_16464_ net674 _07326_ VSS VSS VDD VDD _07327_ sky130_fd_sc_hd__nand2_1
X_16465_ _07190_ _07131_ VSS VSS VDD VDD _07328_ sky130_fd_sc_hd__nand2_4
X_16466_ _07216_ _07325_ _07327_ _07328_ VSS VSS VDD VDD _07329_
+ sky130_fd_sc_hd__a31oi_1
X_16467_ _07266_ _07315_ _07320_ _07329_ _07115_ VSS VSS VDD
+ VDD _07330_ sky130_fd_sc_hd__o41ai_1
X_16468_ _12033_ _07200_ _07202_ net548 VSS VSS VDD VDD _07331_
+ sky130_fd_sc_hd__o22ai_1
X_16469_ _07131_ net459 VSS VSS VDD VDD _07332_ sky130_fd_sc_hd__nor2_1
X_16470_ _12033_ net463 _07332_ VSS VSS VDD VDD _07333_ sky130_fd_sc_hd__o21ai_0
X_16471_ _12029_ _12042_ net463 VSS VSS VDD VDD _07334_ sky130_fd_sc_hd__mux2i_1
X_16472_ _07174_ _07334_ _07140_ VSS VSS VDD VDD _07335_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_34_830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16474_ _07245_ _07333_ _07335_ _07237_ VSS VSS VDD VDD _07337_
+ sky130_fd_sc_hd__a2bb2oi_1
X_16475_ _07190_ _07331_ _07337_ _07266_ VSS VSS VDD VDD _07338_
+ sky130_fd_sc_hd__a211oi_1
X_16476_ _07190_ _07174_ VSS VSS VDD VDD _07339_ sky130_fd_sc_hd__nand2_2
X_16477_ _12033_ _07100_ _07339_ VSS VSS VDD VDD _07340_ sky130_fd_sc_hd__nor3_1
X_16478_ _12029_ _07190_ _07251_ VSS VSS VDD VDD _07341_ sky130_fd_sc_hd__a21oi_1
X_16479_ net463 _07140_ _07234_ net674 VSS VSS VDD VDD _07342_
+ sky130_fd_sc_hd__a22oi_1
X_16480_ _07090_ _07174_ VSS VSS VDD VDD _07343_ sky130_fd_sc_hd__nor2_2
X_16481_ _07278_ _07343_ _07100_ _07190_ VSS VSS VDD VDD _07344_
+ sky130_fd_sc_hd__o211ai_1
X_16482_ _07140_ _07174_ _07166_ _07237_ _07266_ VSS VSS VDD
+ VDD _07345_ sky130_fd_sc_hd__a311oi_1
X_16483_ net548 _07342_ _07344_ _07345_ VSS VSS VDD VDD _07346_
+ sky130_fd_sc_hd__o211ai_1
X_16484_ _07340_ _07341_ _07346_ VSS VSS VDD VDD _07347_ sky130_fd_sc_hd__nor3_1
X_16485_ _07115_ _07338_ _07347_ VSS VSS VDD VDD _07348_ sky130_fd_sc_hd__nor3_1
X_16486_ _07090_ net458 VSS VSS VDD VDD _07349_ sky130_fd_sc_hd__nor2_4
X_16487_ _07140_ net460 VSS VSS VDD VDD _07350_ sky130_fd_sc_hd__nor2_1
X_16488_ _07261_ _07305_ net461 VSS VSS VDD VDD _07351_ sky130_fd_sc_hd__o21ai_0
X_16489_ net463 _07210_ _07349_ _07350_ _07351_ VSS VSS VDD
+ VDD _07352_ sky130_fd_sc_hd__o311ai_1
X_16490_ net461 _07256_ VSS VSS VDD VDD _07353_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_34_829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16492_ net461 _07289_ VSS VSS VDD VDD _07355_ sky130_fd_sc_hd__nand2_1
X_16493_ _12033_ _07174_ _07355_ VSS VSS VDD VDD _07356_ sky130_fd_sc_hd__a21oi_1
X_16494_ net548 _07199_ _07272_ _07100_ VSS VSS VDD VDD _07357_
+ sky130_fd_sc_hd__a22oi_1
X_16495_ _07190_ _07301_ _07357_ VSS VSS VDD VDD _07358_ sky130_fd_sc_hd__nand3_1
X_16496_ _07190_ _07353_ _07356_ _07358_ net460 VSS VSS VDD
+ VDD _07359_ sky130_fd_sc_hd__o311ai_2
X_16497_ _12029_ _07215_ VSS VSS VDD VDD _07360_ sky130_fd_sc_hd__nand2_1
X_16498_ _07090_ _07202_ _07218_ _07082_ _07360_ VSS VSS VDD
+ VDD _07361_ sky130_fd_sc_hd__o221ai_1
X_16499_ _07190_ net460 VSS VSS VDD VDD _07362_ sky130_fd_sc_hd__nor2_2
X_16500_ _07361_ _07362_ _07122_ VSS VSS VDD VDD _07363_ sky130_fd_sc_hd__a21oi_1
X_16501_ _07352_ _07359_ _07363_ VSS VSS VDD VDD _07364_ sky130_fd_sc_hd__nand3_1
X_16502_ _07311_ _07330_ _07348_ _07364_ VSS VSS VDD VDD _00049_
+ sky130_fd_sc_hd__a2bb2oi_1
X_16503_ _12033_ _07100_ VSS VSS VDD VDD _07365_ sky130_fd_sc_hd__and2_0
X_16504_ _12029_ net462 _07237_ _07365_ VSS VSS VDD VDD _07366_
+ sky130_fd_sc_hd__a211oi_1
X_16505_ _12047_ _07237_ _07366_ VSS VSS VDD VDD _07367_ sky130_fd_sc_hd__a21oi_1
X_16506_ net648 _07090_ _07237_ VSS VSS VDD VDD _07368_ sky130_fd_sc_hd__o21ai_0
X_16507_ _12028_ _07131_ _07368_ _07100_ net458 VSS VSS VDD
+ VDD _07369_ sky130_fd_sc_hd__a221oi_1
X_16508_ net458 _07367_ _07369_ VSS VSS VDD VDD _07370_ sky130_fd_sc_hd__a21oi_1
X_16509_ _07269_ _07122_ VSS VSS VDD VDD _07371_ sky130_fd_sc_hd__nand2_1
X_16510_ _07190_ _07371_ VSS VSS VDD VDD _07372_ sky130_fd_sc_hd__nor2_1
X_16511_ _07269_ _07122_ _07190_ VSS VSS VDD VDD _07373_ sky130_fd_sc_hd__nand3_1
X_16512_ _12030_ _12033_ VSS VSS VDD VDD _07374_ sky130_fd_sc_hd__nor2_2
X_16513_ _07174_ _07374_ VSS VSS VDD VDD _07375_ sky130_fd_sc_hd__nor2_1
X_16514_ _07100_ _07173_ _07375_ VSS VSS VDD VDD _07376_ sky130_fd_sc_hd__nor3_1
X_16515_ _12036_ net457 VSS VSS VDD VDD _07377_ sky130_fd_sc_hd__nor2_1
X_16516_ net462 _07256_ _07377_ VSS VSS VDD VDD _07378_ sky130_fd_sc_hd__nor3_1
X_16517_ _07082_ net457 VSS VSS VDD VDD _07379_ sky130_fd_sc_hd__nand2_2
X_16518_ _12056_ net457 _07379_ _07323_ _07237_ VSS VSS VDD
+ VDD _07380_ sky130_fd_sc_hd__o221ai_1
X_16519_ _07237_ _07376_ _07378_ _07380_ VSS VSS VDD VDD _07381_
+ sky130_fd_sc_hd__o31ai_1
X_16520_ _07370_ _07372_ _07373_ _07381_ VSS VSS VDD VDD _07382_
+ sky130_fd_sc_hd__o2bb2ai_1
X_16521_ _07082_ _07100_ VSS VSS VDD VDD _07383_ sky130_fd_sc_hd__nand2_1
X_16522_ _07278_ _07343_ _07383_ _07251_ _12042_ VSS VSS VDD
+ VDD _07384_ sky130_fd_sc_hd__o32ai_1
X_16523_ net461 _07219_ _07210_ VSS VSS VDD VDD _07385_ sky130_fd_sc_hd__nor3_1
X_16524_ net461 _07196_ _07230_ _07385_ _07131_ VSS VSS VDD
+ VDD _07386_ sky130_fd_sc_hd__a311oi_1
X_16525_ _07131_ _07384_ _07386_ VSS VSS VDD VDD _07387_ sky130_fd_sc_hd__a21oi_1
X_16526_ _07100_ _07219_ _07343_ VSS VSS VDD VDD _07388_ sky130_fd_sc_hd__nor3_1
X_16527_ net463 _07317_ _07226_ VSS VSS VDD VDD _07389_ sky130_fd_sc_hd__nor3_1
X_16528_ _07388_ _07389_ VSS VSS VDD VDD _07390_ sky130_fd_sc_hd__nor2_1
X_16529_ _12042_ net458 VSS VSS VDD VDD _07391_ sky130_fd_sc_hd__nor2_1
X_16530_ _07343_ _07391_ VSS VSS VDD VDD _07392_ sky130_fd_sc_hd__nor2_1
X_16531_ _12033_ _07326_ _07392_ _07100_ _07284_ VSS VSS VDD
+ VDD _07393_ sky130_fd_sc_hd__a221oi_1
X_16532_ _07269_ _07266_ VSS VSS VDD VDD _07394_ sky130_fd_sc_hd__nor2_2
X_16533_ _07328_ _07390_ _07393_ _07319_ _07394_ VSS VSS VDD
+ VDD _07395_ sky130_fd_sc_hd__o221ai_1
X_16534_ _07140_ _07387_ _07395_ VSS VSS VDD VDD _07396_ sky130_fd_sc_hd__a21oi_1
X_16535_ _07115_ _07266_ VSS VSS VDD VDD _07397_ sky130_fd_sc_hd__nand2_2
X_16536_ _12038_ _07174_ VSS VSS VDD VDD _07398_ sky130_fd_sc_hd__nand2_1
X_16537_ _12033_ net461 _07362_ VSS VSS VDD VDD _07399_ sky130_fd_sc_hd__o21ai_0
X_16538_ net461 _07379_ _07398_ _07399_ VSS VSS VDD VDD _07400_
+ sky130_fd_sc_hd__a31oi_1
X_16539_ net461 _07261_ VSS VSS VDD VDD _07401_ sky130_fd_sc_hd__nor2_1
X_16540_ _07140_ _07131_ VSS VSS VDD VDD _07402_ sky130_fd_sc_hd__nand2_2
X_16541_ net461 _07290_ _07401_ _07398_ _07402_ VSS VSS VDD
+ VDD _07403_ sky130_fd_sc_hd__a221oi_1
X_16542_ _12038_ _07174_ _07223_ net461 VSS VSS VDD VDD _07404_
+ sky130_fd_sc_hd__o211ai_1
X_16543_ _12042_ _07174_ VSS VSS VDD VDD _07405_ sky130_fd_sc_hd__nand2b_1
X_16544_ _07100_ _07379_ _07405_ VSS VSS VDD VDD _07406_ sky130_fd_sc_hd__nand3_1
X_16545_ _07100_ _07343_ _07262_ VSS VSS VDD VDD _07407_ sky130_fd_sc_hd__nor3_1
X_16546_ net463 _07210_ _07391_ VSS VSS VDD VDD _07408_ sky130_fd_sc_hd__nor3_1
X_16547_ _07131_ _07407_ _07408_ VSS VSS VDD VDD _07409_ sky130_fd_sc_hd__nor3_1
X_16548_ net460 _07404_ _07406_ _07409_ _07140_ VSS VSS VDD
+ VDD _07410_ sky130_fd_sc_hd__a311oi_1
X_16549_ _07397_ _07400_ _07403_ _07410_ VSS VSS VDD VDD _07411_
+ sky130_fd_sc_hd__nor4_1
X_16550_ _12049_ _07174_ _07237_ VSS VSS VDD VDD _07412_ sky130_fd_sc_hd__a21oi_1
X_16551_ _07174_ _07194_ _07245_ _07412_ VSS VSS VDD VDD _07413_
+ sky130_fd_sc_hd__o31ai_1
X_16552_ _07082_ net462 VSS VSS VDD VDD _07414_ sky130_fd_sc_hd__nand2_1
X_16553_ _07082_ _07090_ net457 _07414_ VSS VSS VDD VDD _07415_
+ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_34_828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16555_ _12052_ net458 _07415_ _07237_ VSS VSS VDD VDD _07417_
+ sky130_fd_sc_hd__o211ai_1
X_16556_ _12036_ net458 VSS VSS VDD VDD _07418_ sky130_fd_sc_hd__nand2_1
X_16557_ _12028_ _07174_ VSS VSS VDD VDD _07419_ sky130_fd_sc_hd__nand2_1
X_16558_ net461 _07196_ _07418_ _07419_ _07401_ VSS VSS VDD
+ VDD _07420_ sky130_fd_sc_hd__a32oi_2
X_16559_ _07317_ _07193_ _12029_ VSS VSS VDD VDD _07421_ sky130_fd_sc_hd__o21ai_0
X_16560_ _07090_ net462 VSS VSS VDD VDD _07422_ sky130_fd_sc_hd__nand2_2
X_16561_ _07082_ net463 _07218_ _07422_ _07284_ VSS VSS VDD
+ VDD _07423_ sky130_fd_sc_hd__a32oi_1
X_16562_ _07421_ _07423_ _07237_ VSS VSS VDD VDD _07424_ sky130_fd_sc_hd__a21oi_1
X_16563_ _07237_ _07420_ _07424_ _07140_ VSS VSS VDD VDD _07425_
+ sky130_fd_sc_hd__a211oi_1
X_16564_ _07269_ _07266_ VSS VSS VDD VDD _07426_ sky130_fd_sc_hd__nand2_2
X_16565_ _07140_ _07413_ _07417_ _07425_ _07426_ VSS VSS VDD
+ VDD _07427_ sky130_fd_sc_hd__a311oi_1
X_16566_ _07382_ _07396_ _07411_ _07427_ VSS VSS VDD VDD _00050_
+ sky130_fd_sc_hd__nor4_1
X_16567_ _12030_ net457 VSS VSS VDD VDD _07428_ sky130_fd_sc_hd__nand2_1
X_16568_ _12029_ net460 VSS VSS VDD VDD _07429_ sky130_fd_sc_hd__nand2_1
X_16569_ net651 net460 _07174_ _07429_ VSS VSS VDD VDD _07430_
+ sky130_fd_sc_hd__o211ai_1
X_16570_ _12029_ net459 VSS VSS VDD VDD _07431_ sky130_fd_sc_hd__nand2_1
X_16571_ _12036_ _07174_ net460 VSS VSS VDD VDD _07432_ sky130_fd_sc_hd__a21oi_1
X_16572_ _07431_ _07432_ net461 VSS VSS VDD VDD _07433_ sky130_fd_sc_hd__a21oi_1
X_16573_ net462 _07428_ _07430_ _07433_ VSS VSS VDD VDD _07434_
+ sky130_fd_sc_hd__a31oi_1
X_16574_ _12042_ _07174_ VSS VSS VDD VDD _07435_ sky130_fd_sc_hd__nor2_1
X_16575_ net457 _07374_ _07219_ VSS VSS VDD VDD _07436_ sky130_fd_sc_hd__a21oi_1
X_16576_ net462 _07436_ VSS VSS VDD VDD _07437_ sky130_fd_sc_hd__nand2_1
X_16577_ net462 _07435_ _07349_ _07437_ _07237_ VSS VSS VDD
+ VDD _07438_ sky130_fd_sc_hd__o311ai_2
X_16578_ _12038_ _07202_ VSS VSS VDD VDD _07439_ sky130_fd_sc_hd__nand2_1
X_16579_ _07131_ _07307_ _07439_ _07190_ VSS VSS VDD VDD _07440_
+ sky130_fd_sc_hd__a31oi_1
X_16580_ _07190_ _07434_ _07438_ _07440_ _07123_ VSS VSS VDD
+ VDD _07441_ sky130_fd_sc_hd__a221oi_1
X_16581_ _07234_ _07332_ net674 VSS VSS VDD VDD _07442_ sky130_fd_sc_hd__o21ai_0
X_16582_ _07307_ _07442_ net649 VSS VSS VDD VDD _07443_ sky130_fd_sc_hd__a21oi_1
X_16583_ _12036_ _07199_ _07194_ _07174_ VSS VSS VDD VDD _07444_
+ sky130_fd_sc_hd__a22oi_1
X_16584_ _07237_ _07444_ VSS VSS VDD VDD _07445_ sky130_fd_sc_hd__nor2_1
X_16585_ _07167_ _07332_ _07443_ _07445_ _07190_ VSS VSS VDD
+ VDD _07446_ sky130_fd_sc_hd__a2111oi_1
X_16586_ _07100_ _07219_ _07321_ VSS VSS VDD VDD _07447_ sky130_fd_sc_hd__nor3_1
X_16587_ _07100_ _07272_ _07398_ _07447_ _07319_ VSS VSS VDD
+ VDD _07448_ sky130_fd_sc_hd__a311oi_2
X_16588_ _07089_ net457 VSS VSS VDD VDD _07449_ sky130_fd_sc_hd__nand2_2
X_16589_ _07082_ _07449_ VSS VSS VDD VDD _07450_ sky130_fd_sc_hd__nor2_1
X_16590_ _12036_ _07215_ _07328_ _07388_ _07450_ VSS VSS VDD
+ VDD _07451_ sky130_fd_sc_hd__a2111oi_0
X_16591_ _07426_ _07446_ _07448_ _07451_ VSS VSS VDD VDD _07452_
+ sky130_fd_sc_hd__nor4_1
X_16592_ _07100_ _07374_ VSS VSS VDD VDD _07453_ sky130_fd_sc_hd__nor2_1
X_16593_ _12038_ _07100_ _07453_ VSS VSS VDD VDD _07454_ sky130_fd_sc_hd__a21oi_1
X_16594_ _12042_ _07100_ _07167_ _07339_ VSS VSS VDD VDD _07455_
+ sky130_fd_sc_hd__a211oi_1
X_16595_ _07174_ _07454_ _07455_ _07314_ _07237_ VSS VSS VDD
+ VDD _07456_ sky130_fd_sc_hd__o221ai_1
X_16596_ _07082_ net457 VSS VSS VDD VDD _07457_ sky130_fd_sc_hd__nor2_4
X_16597_ _07100_ _07457_ _07090_ VSS VSS VDD VDD _07458_ sky130_fd_sc_hd__o21ai_0
X_16598_ _07082_ _07215_ _07402_ VSS VSS VDD VDD _07459_ sky130_fd_sc_hd__a21oi_1
X_16599_ _12028_ _07251_ _07458_ _07459_ VSS VSS VDD VDD _07460_
+ sky130_fd_sc_hd__o211ai_1
X_16600_ _12038_ net457 VSS VSS VDD VDD _07461_ sky130_fd_sc_hd__nand2_1
X_16601_ net462 _07186_ _07461_ VSS VSS VDD VDD _07462_ sky130_fd_sc_hd__nand3_1
X_16602_ _07100_ _07449_ _07296_ VSS VSS VDD VDD _07463_ sky130_fd_sc_hd__nand3_1
X_16603_ _07462_ _07463_ _07328_ VSS VSS VDD VDD _07464_ sky130_fd_sc_hd__a21o_1
X_16604_ _07456_ _07460_ _07464_ _07397_ VSS VSS VDD VDD _07465_
+ sky130_fd_sc_hd__a31oi_1
X_16605_ _07100_ _07178_ _07377_ VSS VSS VDD VDD _07466_ sky130_fd_sc_hd__nor3_1
X_16606_ net461 _07278_ _07261_ net460 VSS VSS VDD VDD _07467_
+ sky130_fd_sc_hd__o31ai_1
X_16607_ _07457_ _07261_ VSS VSS VDD VDD _07468_ sky130_fd_sc_hd__nor2_1
X_16608_ net461 _07468_ _07327_ VSS VSS VDD VDD _07469_ sky130_fd_sc_hd__o21ai_0
X_16609_ _07466_ _07467_ _07469_ net460 VSS VSS VDD VDD _07470_
+ sky130_fd_sc_hd__o22ai_2
X_16610_ _07100_ net458 VSS VSS VDD VDD _07471_ sky130_fd_sc_hd__nand2_1
X_16611_ _07196_ _07383_ VSS VSS VDD VDD _07472_ sky130_fd_sc_hd__nand2_1
X_16612_ net648 _07090_ VSS VSS VDD VDD _07473_ sky130_fd_sc_hd__nor2_1
X_16613_ _07167_ _07473_ _07174_ VSS VSS VDD VDD _07474_ sky130_fd_sc_hd__o21ai_0
X_16614_ _07082_ _07471_ _07472_ _12029_ _07474_ VSS VSS VDD
+ VDD _07475_ sky130_fd_sc_hd__o221ai_1
X_16615_ _12033_ net459 VSS VSS VDD VDD _07476_ sky130_fd_sc_hd__and2_1
X_16616_ _07219_ net461 _07272_ VSS VSS VDD VDD _07477_ sky130_fd_sc_hd__nand3b_1
X_16617_ net461 _07317_ _07476_ _07477_ net460 VSS VSS VDD
+ VDD _07478_ sky130_fd_sc_hd__o311ai_2
X_16618_ _07131_ _07475_ _07478_ _07372_ VSS VSS VDD VDD _07479_
+ sky130_fd_sc_hd__o211ai_1
X_16619_ _07373_ _07470_ _07479_ VSS VSS VDD VDD _07480_ sky130_fd_sc_hd__o21ai_0
X_16620_ _07441_ _07452_ _07465_ _07480_ VSS VSS VDD VDD _00051_
+ sky130_fd_sc_hd__nor4_1
X_16621_ _12038_ net457 net462 VSS VSS VDD VDD _07481_ sky130_fd_sc_hd__a21oi_1
X_16622_ _12028_ _07174_ _07306_ VSS VSS VDD VDD _07482_ sky130_fd_sc_hd__a21oi_1
X_16623_ _07167_ _07482_ _07140_ VSS VSS VDD VDD _07483_ sky130_fd_sc_hd__o21ai_0
X_16624_ _07140_ _07212_ _07481_ _07483_ VSS VSS VDD VDD _07484_
+ sky130_fd_sc_hd__o31ai_1
X_16625_ _07100_ _07140_ _07090_ VSS VSS VDD VDD _07485_ sky130_fd_sc_hd__a21oi_1
X_16626_ net548 _07485_ _07422_ _07174_ VSS VSS VDD VDD _07486_
+ sky130_fd_sc_hd__o211ai_1
X_16627_ _12028_ _07100_ _07190_ VSS VSS VDD VDD _07487_ sky130_fd_sc_hd__nand3_1
X_16628_ net548 _07100_ _07190_ net458 _07487_ VSS VSS VDD
+ VDD _07488_ sky130_fd_sc_hd__o311ai_0
X_16629_ _07140_ net458 VSS VSS VDD VDD _07489_ sky130_fd_sc_hd__nand2_1
X_16630_ _07100_ _07140_ _07489_ _07090_ VSS VSS VDD VDD _07490_
+ sky130_fd_sc_hd__o22ai_1
X_16631_ _07486_ _07488_ _07490_ net548 _07131_ VSS VSS VDD
+ VDD _07491_ sky130_fd_sc_hd__a221oi_1
X_16632_ _07131_ _07484_ _07491_ VSS VSS VDD VDD _07492_ sky130_fd_sc_hd__a21oi_1
X_16633_ _12033_ net457 VSS VSS VDD VDD _07493_ sky130_fd_sc_hd__nor2_1
X_16634_ _07100_ _07493_ _07293_ VSS VSS VDD VDD _07494_ sky130_fd_sc_hd__nor3_1
X_16635_ _07100_ _07186_ _07449_ _07494_ VSS VSS VDD VDD _07495_
+ sky130_fd_sc_hd__a31oi_1
X_16636_ _12042_ _07200_ _07349_ _07100_ _07237_ VSS VSS VDD
+ VDD _07496_ sky130_fd_sc_hd__o221ai_1
X_16637_ _07237_ _07495_ _07496_ _07140_ VSS VSS VDD VDD _07497_
+ sky130_fd_sc_hd__o211ai_1
X_16638_ _07100_ _07476_ _07305_ _07318_ _07237_ VSS VSS VDD
+ VDD _07498_ sky130_fd_sc_hd__o311ai_2
X_16639_ net460 _07295_ _07140_ VSS VSS VDD VDD _07499_ sky130_fd_sc_hd__a21oi_1
X_16640_ _07498_ _07499_ _07397_ VSS VSS VDD VDD _07500_ sky130_fd_sc_hd__a21oi_1
X_16641_ _07100_ _07493_ VSS VSS VDD VDD _07501_ sky130_fd_sc_hd__nor2_1
X_16642_ _07296_ _07379_ net462 VSS VSS VDD VDD _07502_ sky130_fd_sc_hd__a21oi_1
X_16643_ _07230_ _07501_ _07502_ VSS VSS VDD VDD _07503_ sky130_fd_sc_hd__a21oi_1
X_16644_ _12028_ _07100_ _07383_ VSS VSS VDD VDD _07504_ sky130_fd_sc_hd__o21ai_0
X_16645_ net458 _07504_ _07247_ VSS VSS VDD VDD _07505_ sky130_fd_sc_hd__a21oi_1
X_16646_ _07190_ _07503_ _07505_ net460 _07371_ VSS VSS VDD
+ VDD _07506_ sky130_fd_sc_hd__a2111oi_0
X_16647_ _12033_ _07174_ VSS VSS VDD VDD _07507_ sky130_fd_sc_hd__nand2_1
X_16648_ _07431_ _07507_ net461 VSS VSS VDD VDD _07508_ sky130_fd_sc_hd__a21oi_1
X_16649_ _12038_ net461 _07508_ VSS VSS VDD VDD _07509_ sky130_fd_sc_hd__a21oi_1
X_16650_ _07186_ _07461_ net462 VSS VSS VDD VDD _07510_ sky130_fd_sc_hd__a21oi_1
X_16651_ net461 _07230_ _07405_ _07510_ _07190_ VSS VSS VDD
+ VDD _07511_ sky130_fd_sc_hd__a311oi_1
X_16652_ _07190_ _07509_ _07511_ _07237_ _07371_ VSS VSS VDD
+ VDD _07512_ sky130_fd_sc_hd__a2111oi_0
X_16653_ _07497_ _07500_ _07506_ _07512_ VSS VSS VDD VDD _07513_
+ sky130_fd_sc_hd__a211oi_1
X_16654_ _07218_ _07249_ _07100_ VSS VSS VDD VDD _07514_ sky130_fd_sc_hd__a21oi_2
X_16655_ _12028_ _07200_ VSS VSS VDD VDD _07515_ sky130_fd_sc_hd__nor2_1
X_16656_ _07131_ _07450_ _07514_ _07515_ VSS VSS VDD VDD _07516_
+ sky130_fd_sc_hd__nor4_1
X_16657_ _12029_ _07100_ net458 VSS VSS VDD VDD _07517_ sky130_fd_sc_hd__nand3_1
X_16658_ _12040_ _07174_ VSS VSS VDD VDD _07518_ sky130_fd_sc_hd__nand2_1
X_16659_ _07517_ _07518_ _07237_ VSS VSS VDD VDD _07519_ sky130_fd_sc_hd__a21oi_1
X_16660_ _07516_ _07519_ _07140_ VSS VSS VDD VDD _07520_ sky130_fd_sc_hd__o21ai_0
X_16661_ net548 _07199_ _07224_ _07328_ _07481_ VSS VSS VDD
+ VDD _07521_ sky130_fd_sc_hd__a2111oi_0
X_16662_ _07457_ _07343_ net461 VSS VSS VDD VDD _07522_ sky130_fd_sc_hd__o21ai_0
X_16663_ _07235_ _07301_ _07522_ net460 VSS VSS VDD VDD _07523_
+ sky130_fd_sc_hd__a31oi_2
X_16664_ _07140_ _07521_ _07523_ VSS VSS VDD VDD _07524_ sky130_fd_sc_hd__or3_1
X_16665_ _07394_ _07520_ _07524_ VSS VSS VDD VDD _07525_ sky130_fd_sc_hd__nand3_1
X_16666_ _07426_ _07492_ _07513_ _07525_ VSS VSS VDD VDD _00052_
+ sky130_fd_sc_hd__o211ai_1
X_16667_ _12042_ _07471_ _07365_ net458 VSS VSS VDD VDD _07526_
+ sky130_fd_sc_hd__o22ai_1
X_16668_ _07100_ _07405_ _07418_ VSS VSS VDD VDD _07527_ sky130_fd_sc_hd__nand3_1
X_16669_ net461 _07186_ _07289_ net460 VSS VSS VDD VDD _07528_
+ sky130_fd_sc_hd__a31oi_1
X_16670_ net460 _07526_ _07527_ _07528_ _07140_ VSS VSS VDD
+ VDD _07529_ sky130_fd_sc_hd__a221oi_1
X_16671_ _07317_ _07324_ _07374_ _07199_ _07237_ VSS VSS VDD
+ VDD _07530_ sky130_fd_sc_hd__a221o_1
X_16672_ _07100_ _07301_ _07418_ _07237_ VSS VSS VDD VDD _07531_
+ sky130_fd_sc_hd__o211ai_1
X_16673_ _07530_ _07531_ _07190_ VSS VSS VDD VDD _07532_ sky130_fd_sc_hd__a21oi_1
X_16674_ _07529_ _07532_ _07394_ VSS VSS VDD VDD _07533_ sky130_fd_sc_hd__o21ai_0
X_16675_ _07249_ _07431_ net461 VSS VSS VDD VDD _07534_ sky130_fd_sc_hd__a21oi_1
X_16676_ _07082_ _07282_ _07350_ VSS VSS VDD VDD _07535_ sky130_fd_sc_hd__o21ai_0
X_16677_ _12029_ _07100_ _07174_ VSS VSS VDD VDD _07536_ sky130_fd_sc_hd__or3_1
X_16678_ _07296_ VSS VSS VDD VDD _07537_ sky130_fd_sc_hd__inv_1
X_16679_ _07178_ _07537_ _07100_ VSS VSS VDD VDD _07538_ sky130_fd_sc_hd__o21ai_0
X_16680_ _07536_ _07362_ _07538_ _07371_ VSS VSS VDD VDD _07539_
+ sky130_fd_sc_hd__a31oi_1
X_16681_ _07082_ _07215_ _07301_ _07140_ VSS VSS VDD VDD _07540_
+ sky130_fd_sc_hd__o211ai_1
X_16682_ _07082_ _07199_ _07457_ VSS VSS VDD VDD _07541_ sky130_fd_sc_hd__a21oi_1
X_16683_ _12036_ _07234_ VSS VSS VDD VDD _07542_ sky130_fd_sc_hd__nand2_1
X_16684_ net674 _07541_ _07542_ _07327_ _07190_ VSS VSS VDD
+ VDD _07543_ sky130_fd_sc_hd__o2111ai_1
X_16685_ net460 _07540_ _07543_ VSS VSS VDD VDD _07544_ sky130_fd_sc_hd__nand3_1
X_16686_ _07534_ _07535_ _07539_ _07544_ VSS VSS VDD VDD _07545_
+ sky130_fd_sc_hd__o211ai_1
X_16687_ net674 _07471_ _07462_ VSS VSS VDD VDD _07546_ sky130_fd_sc_hd__o21ai_1
X_16688_ _07100_ _07196_ _07272_ VSS VSS VDD VDD _07547_ sky130_fd_sc_hd__nand3_1
X_16689_ _07213_ _07547_ _07237_ VSS VSS VDD VDD _07548_ sky130_fd_sc_hd__a21oi_1
X_16690_ _07237_ _07546_ _07548_ VSS VSS VDD VDD _07549_ sky130_fd_sc_hd__a21oi_1
X_16691_ _12038_ _07215_ _07476_ VSS VSS VDD VDD _07550_ sky130_fd_sc_hd__a21oi_1
X_16692_ _07100_ _07224_ _07226_ _07550_ net460 VSS VSS VDD
+ VDD _07551_ sky130_fd_sc_hd__o311a_1
X_16693_ net461 _07507_ VSS VSS VDD VDD _07552_ sky130_fd_sc_hd__nand2_1
X_16694_ _07230_ _07552_ net460 VSS VSS VDD VDD _07553_ sky130_fd_sc_hd__a21oi_1
X_16695_ _07551_ _07553_ _07190_ VSS VSS VDD VDD _07554_ sky130_fd_sc_hd__o21ai_0
X_16696_ _07190_ _07549_ _07554_ _07269_ _07266_ VSS VSS VDD
+ VDD _07555_ sky130_fd_sc_hd__o2111ai_1
X_16697_ net461 _07262_ VSS VSS VDD VDD _07556_ sky130_fd_sc_hd__nor2_1
X_16698_ net461 _07468_ _07556_ _07230_ _07140_ VSS VSS VDD
+ VDD _07557_ sky130_fd_sc_hd__a221oi_1
X_16699_ _07090_ _07282_ _07224_ _07190_ VSS VSS VDD VDD _07558_
+ sky130_fd_sc_hd__a211oi_1
X_16700_ _07557_ _07558_ net460 VSS VSS VDD VDD _07559_ sky130_fd_sc_hd__o21ai_0
X_16701_ _07260_ _07307_ _07362_ VSS VSS VDD VDD _07560_ sky130_fd_sc_hd__nand3_1
X_16702_ net461 _07173_ _07319_ VSS VSS VDD VDD _07561_ sky130_fd_sc_hd__a21oi_1
X_16703_ _07527_ _07561_ _07397_ VSS VSS VDD VDD _07562_ sky130_fd_sc_hd__a21oi_1
X_16704_ _07559_ _07560_ _07562_ VSS VSS VDD VDD _07563_ sky130_fd_sc_hd__nand3_1
X_16705_ _07533_ _07545_ _07555_ _07563_ VSS VSS VDD VDD _00053_
+ sky130_fd_sc_hd__nand4_1
X_16706_ net462 _07435_ _07349_ _07536_ VSS VSS VDD VDD _07564_
+ sky130_fd_sc_hd__o31ai_1
X_16707_ _12038_ _07100_ net457 VSS VSS VDD VDD _07565_ sky130_fd_sc_hd__a21oi_1
X_16708_ _12046_ net457 _07414_ _07565_ _07190_ VSS VSS VDD
+ VDD _07566_ sky130_fd_sc_hd__a221oi_1
X_16709_ _07190_ _07564_ _07566_ VSS VSS VDD VDD _07567_ sky130_fd_sc_hd__a21oi_1
X_16710_ _07237_ _07567_ VSS VSS VDD VDD _07568_ sky130_fd_sc_hd__nor2_1
X_16711_ _12033_ _07140_ VSS VSS VDD VDD _07569_ sky130_fd_sc_hd__nand2_1
X_16712_ _12038_ _07190_ VSS VSS VDD VDD _07570_ sky130_fd_sc_hd__nand2_1
X_16713_ _07234_ _07569_ _07570_ VSS VSS VDD VDD _07571_ sky130_fd_sc_hd__nand3_1
X_16714_ _07312_ _07339_ _07571_ VSS VSS VDD VDD _07572_ sky130_fd_sc_hd__o21ai_0
X_16715_ net548 _07190_ VSS VSS VDD VDD _07573_ sky130_fd_sc_hd__nand2_1
X_16716_ _07140_ _07473_ VSS VSS VDD VDD _07574_ sky130_fd_sc_hd__nand2_1
X_16717_ _07573_ _07574_ _07251_ VSS VSS VDD VDD _07575_ sky130_fd_sc_hd__a21oi_1
X_16718_ _07131_ _07572_ _07575_ VSS VSS VDD VDD _07576_ sky130_fd_sc_hd__nor3_1
X_16719_ _07568_ _07576_ _07394_ VSS VSS VDD VDD _07577_ sky130_fd_sc_hd__o21ai_0
X_16720_ net463 _07166_ _07278_ VSS VSS VDD VDD _07578_ sky130_fd_sc_hd__a21oi_1
X_16721_ _12042_ _07578_ VSS VSS VDD VDD _07579_ sky130_fd_sc_hd__nor2_1
X_16722_ _07323_ _07450_ _07579_ VSS VSS VDD VDD _07580_ sky130_fd_sc_hd__nor3_1
X_16723_ _07140_ _07391_ net462 VSS VSS VDD VDD _07581_ sky130_fd_sc_hd__o21ai_0
X_16724_ _07422_ _07489_ _07581_ net548 _07574_ VSS VSS VDD
+ VDD _07582_ sky130_fd_sc_hd__o221ai_1
X_16725_ _07190_ _07449_ _07573_ VSS VSS VDD VDD _07583_ sky130_fd_sc_hd__o21ai_0
X_16726_ _12029_ _07140_ net458 VSS VSS VDD VDD _07584_ sky130_fd_sc_hd__a21oi_1
X_16727_ _12038_ _07190_ _07174_ VSS VSS VDD VDD _07585_ sky130_fd_sc_hd__nor3_1
X_16728_ _07100_ _07584_ _07585_ _07339_ net674 VSS VSS VDD
+ VDD _07586_ sky130_fd_sc_hd__o32ai_1
X_16729_ _07100_ _07583_ _07586_ _07131_ VSS VSS VDD VDD _07587_
+ sky130_fd_sc_hd__a211oi_1
X_16730_ _07131_ _07582_ _07587_ _07397_ VSS VSS VDD VDD _07588_
+ sky130_fd_sc_hd__a211oi_1
X_16731_ _07328_ _07580_ _07588_ VSS VSS VDD VDD _07589_ sky130_fd_sc_hd__o21ai_0
X_16732_ _07262_ _07293_ VSS VSS VDD VDD _07590_ sky130_fd_sc_hd__nor2_1
X_16733_ net462 _07590_ VSS VSS VDD VDD _07591_ sky130_fd_sc_hd__nor2_1
X_16734_ net462 _07428_ _07296_ _07591_ net460 VSS VSS VDD
+ VDD _07592_ sky130_fd_sc_hd__a311oi_1
X_16735_ _07082_ _07100_ _07256_ VSS VSS VDD VDD _07593_ sky130_fd_sc_hd__o21ai_0
X_16736_ _12045_ _12054_ net457 _07593_ net460 VSS VSS VDD
+ VDD _07594_ sky130_fd_sc_hd__o311ai_0
X_16737_ _07140_ _07594_ VSS VSS VDD VDD _07595_ sky130_fd_sc_hd__nand2_1
X_16738_ _12038_ net457 _07349_ VSS VSS VDD VDD _07596_ sky130_fd_sc_hd__a21oi_1
X_16739_ net462 _07219_ _07375_ VSS VSS VDD VDD _07597_ sky130_fd_sc_hd__nor3_1
X_16740_ net462 _07596_ _07597_ VSS VSS VDD VDD _07598_ sky130_fd_sc_hd__a21oi_1
X_16741_ _12028_ net457 _07461_ VSS VSS VDD VDD _07599_ sky130_fd_sc_hd__o21ai_0
X_16742_ _12030_ _07234_ _07599_ net462 _07328_ VSS VSS VDD
+ VDD _07600_ sky130_fd_sc_hd__a221oi_1
X_16743_ _07426_ _07600_ VSS VSS VDD VDD _07601_ sky130_fd_sc_hd__nor2_1
X_16744_ _07592_ _07595_ _07598_ _07319_ _07601_ VSS VSS VDD
+ VDD _07602_ sky130_fd_sc_hd__o221ai_2
X_16745_ _07100_ _07231_ _07447_ VSS VSS VDD VDD _07603_ sky130_fd_sc_hd__a21o_1
X_16746_ net460 _07603_ VSS VSS VDD VDD _07604_ sky130_fd_sc_hd__nand2_1
X_16747_ _07174_ _07374_ _07100_ VSS VSS VDD VDD _07605_ sky130_fd_sc_hd__a21oi_1
X_16748_ _07100_ _07186_ _07218_ _07230_ _07605_ VSS VSS VDD
+ VDD _07606_ sky130_fd_sc_hd__a32oi_1
X_16749_ _07237_ _07606_ VSS VSS VDD VDD _07607_ sky130_fd_sc_hd__nand2_1
X_16750_ _12047_ _07174_ VSS VSS VDD VDD _07608_ sky130_fd_sc_hd__nor2_1
X_16751_ _12029_ _07100_ _07174_ VSS VSS VDD VDD _07609_ sky130_fd_sc_hd__o21ai_0
X_16752_ _07100_ _07473_ _07609_ VSS VSS VDD VDD _07610_ sky130_fd_sc_hd__a21oi_1
X_16753_ _07608_ _07610_ _07131_ VSS VSS VDD VDD _07611_ sky130_fd_sc_hd__o21ai_0
X_16754_ _07082_ _07422_ _07174_ VSS VSS VDD VDD _07612_ sky130_fd_sc_hd__a21oi_1
X_16755_ _07201_ _07612_ _07237_ VSS VSS VDD VDD _07613_ sky130_fd_sc_hd__o21ai_0
X_16756_ _07611_ _07613_ _07373_ VSS VSS VDD VDD _07614_ sky130_fd_sc_hd__a21oi_1
X_16757_ _07372_ _07604_ _07607_ _07614_ VSS VSS VDD VDD _07615_
+ sky130_fd_sc_hd__a31oi_1
X_16758_ _07577_ _07589_ _07602_ _07615_ VSS VSS VDD VDD _00054_
+ sky130_fd_sc_hd__nand4_1
X_16759_ _07174_ _07167_ _07234_ VSS VSS VDD VDD _07616_ sky130_fd_sc_hd__a21oi_1
X_16760_ net674 _07199_ _07278_ VSS VSS VDD VDD _07617_ sky130_fd_sc_hd__a21oi_1
X_16761_ _07200_ _07218_ _07082_ VSS VSS VDD VDD _07618_ sky130_fd_sc_hd__a21oi_1
X_16762_ _07224_ _07618_ _07140_ VSS VSS VDD VDD _07619_ sky130_fd_sc_hd__o21ai_0
X_16763_ net548 _07616_ _07617_ _07140_ _07619_ VSS VSS VDD
+ VDD _07620_ sky130_fd_sc_hd__o221ai_1
X_16764_ _07090_ _07140_ _07251_ VSS VSS VDD VDD _07621_ sky130_fd_sc_hd__nor3_1
X_16765_ _07200_ _07489_ net674 VSS VSS VDD VDD _07622_ sky130_fd_sc_hd__a21oi_1
X_16766_ _07621_ _07622_ _07082_ VSS VSS VDD VDD _07623_ sky130_fd_sc_hd__o21ai_0
X_16767_ _07100_ _07140_ _07326_ _12029_ _07131_ VSS VSS VDD
+ VDD _07624_ sky130_fd_sc_hd__a221oi_1
X_16768_ _07131_ _07620_ _07623_ _07624_ _07269_ VSS VSS VDD
+ VDD _07625_ sky130_fd_sc_hd__a221oi_1
X_16769_ _12038_ net463 net458 _07194_ VSS VSS VDD VDD _07626_
+ sky130_fd_sc_hd__a211o_1
X_16770_ _12054_ _07174_ _07626_ VSS VSS VDD VDD _07627_ sky130_fd_sc_hd__o21ai_0
X_16771_ _12040_ _07174_ VSS VSS VDD VDD _07628_ sky130_fd_sc_hd__nor2_1
X_16772_ _12030_ _07100_ _07174_ _07628_ _07237_ VSS VSS VDD
+ VDD _07629_ sky130_fd_sc_hd__a311oi_1
X_16773_ _07237_ _07627_ _07629_ _07190_ VSS VSS VDD VDD _07630_
+ sky130_fd_sc_hd__a211oi_1
X_16774_ _07317_ _07355_ _07350_ VSS VSS VDD VDD _07631_ sky130_fd_sc_hd__o21ai_0
X_16775_ _07100_ _07290_ _07631_ VSS VSS VDD VDD _07632_ sky130_fd_sc_hd__a21oi_1
X_16776_ _12033_ _07100_ _07193_ VSS VSS VDD VDD _07633_ sky130_fd_sc_hd__o21bai_1
X_16777_ _07317_ _07422_ _07633_ net458 _07328_ VSS VSS VDD
+ VDD _07634_ sky130_fd_sc_hd__a221oi_1
X_16778_ _07115_ _07630_ _07632_ _07634_ VSS VSS VDD VDD _07635_
+ sky130_fd_sc_hd__nor4_1
X_16779_ net461 _07182_ _07173_ _07355_ _07305_ VSS VSS VDD
+ VDD _07636_ sky130_fd_sc_hd__o32a_1
X_16780_ _12028_ _07100_ _07212_ _07306_ _07237_ VSS VSS VDD
+ VDD _07637_ sky130_fd_sc_hd__o221ai_1
X_16781_ _07237_ _07636_ _07637_ VSS VSS VDD VDD _07638_ sky130_fd_sc_hd__o21ai_0
X_16782_ net462 _07375_ _07457_ VSS VSS VDD VDD _07639_ sky130_fd_sc_hd__a21oi_1
X_16783_ net462 _07596_ _07639_ VSS VSS VDD VDD _07640_ sky130_fd_sc_hd__o21ai_0
X_16784_ net460 _07493_ VSS VSS VDD VDD _07641_ sky130_fd_sc_hd__nor2_1
X_16785_ net460 _07640_ _07641_ _07593_ _07140_ VSS VSS VDD
+ VDD _07642_ sky130_fd_sc_hd__a221oi_1
X_16786_ _07140_ _07638_ _07642_ _07426_ VSS VSS VDD VDD _07643_
+ sky130_fd_sc_hd__a211o_1
X_16787_ _12042_ _07251_ VSS VSS VDD VDD _07644_ sky130_fd_sc_hd__nor2_1
X_16788_ _12029_ _07202_ VSS VSS VDD VDD _07645_ sky130_fd_sc_hd__nor2_1
X_16789_ _07300_ _07319_ _07644_ _07645_ VSS VSS VDD VDD _07646_
+ sky130_fd_sc_hd__nor4_1
X_16790_ _07090_ _07234_ _07349_ VSS VSS VDD VDD _07647_ sky130_fd_sc_hd__a21oi_1
X_16791_ net548 _07647_ VSS VSS VDD VDD _07648_ sky130_fd_sc_hd__nor2_1
X_16792_ _12028_ _07199_ _07300_ _07328_ _07648_ VSS VSS VDD
+ VDD _07649_ sky130_fd_sc_hd__a2111oi_0
X_16793_ _12038_ _07471_ VSS VSS VDD VDD _07650_ sky130_fd_sc_hd__nor2_1
X_16794_ net461 _07296_ _07379_ _07402_ _07650_ VSS VSS VDD
+ VDD _07651_ sky130_fd_sc_hd__a311oi_4
X_16795_ _07284_ _07262_ _07100_ VSS VSS VDD VDD _07652_ sky130_fd_sc_hd__o21ai_0
X_16796_ _07100_ _07392_ _07652_ _07362_ VSS VSS VDD VDD _07653_
+ sky130_fd_sc_hd__o211a_1
X_16797_ _07646_ _07649_ _07651_ _07653_ _07270_ VSS VSS VDD
+ VDD _07654_ sky130_fd_sc_hd__o41ai_1
X_16798_ _07266_ _07625_ _07635_ _07643_ _07654_ VSS VSS VDD
+ VDD _00055_ sky130_fd_sc_hd__o311ai_1
XTAP_TAPCELL_ROW_34_827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16801_ sa03_sr\[7\] sa03_sr\[0\] VSS VSS VDD VDD _07657_
+ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_34_825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16804_ sa21_sub\[1\] sa32_sub\[1\] VSS VSS VDD VDD _07660_
+ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_34_823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16808_ sa10_sub\[7\] sa10_sub\[0\] sa10_sub\[1\] VSS VSS
+ VDD VDD _07664_ sky130_fd_sc_hd__xnor3_1
X_16809_ _07657_ _07660_ _07664_ VSS VSS VDD VDD _07665_ sky130_fd_sc_hd__xnor3_1
X_16810_ text_in_r\[25\] _07665_ net490 VSS VSS VDD VDD _07666_
+ sky130_fd_sc_hd__mux2i_4
X_16811_ u0.tmp_w\[25\] _07666_ VSS VSS VDD VDD _07667_ sky130_fd_sc_hd__xor2_4
X_16812_ net568 VSS VSS VDD VDD _07668_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_33_820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16815_ sa03_sr\[7\] sa10_sub\[7\] VSS VSS VDD VDD _07670_
+ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_33_818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16817_ sa10_sub\[0\] sa21_sub\[0\] sa32_sub\[0\] VSS VSS
+ VDD VDD _07672_ sky130_fd_sc_hd__xnor3_1
X_16818_ _07670_ _07672_ VSS VSS VDD VDD _07673_ sky130_fd_sc_hd__xor2_1
X_16819_ text_in_r\[24\] _07673_ net490 VSS VSS VDD VDD _07674_
+ sky130_fd_sc_hd__mux2i_4
X_16820_ _07674_ u0.tmp_w\[24\] VSS VSS VDD VDD _07675_ sky130_fd_sc_hd__xor2_4
X_16821_ net576 VSS VSS VDD VDD _07676_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_33_817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16824_ sa03_sr\[1\] sa10_sub\[2\] sa21_sub\[2\] VSS VSS
+ VDD VDD _07678_ sky130_fd_sc_hd__xnor3_1
XTAP_TAPCELL_ROW_33_815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16826_ sa10_sub\[1\] sa32_sub\[2\] VSS VSS VDD VDD _07680_
+ sky130_fd_sc_hd__xor2_1
X_16827_ _07678_ _07680_ VSS VSS VDD VDD _07681_ sky130_fd_sc_hd__xnor2_1
X_16828_ text_in_r\[26\] _07681_ net512 VSS VSS VDD VDD _07682_
+ sky130_fd_sc_hd__mux2i_4
X_16829_ u0.tmp_w\[26\] _07682_ VSS VSS VDD VDD _07683_ sky130_fd_sc_hd__xnor2_4
X_16830_ net453 VSS VSS VDD VDD _07684_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_33_814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16841_ sa10_sub\[7\] sa21_sub\[7\] VSS VSS VDD VDD _07692_
+ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_33_804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16843_ sa03_sr\[6\] sa32_sub\[7\] VSS VSS VDD VDD _07694_
+ sky130_fd_sc_hd__xnor2_1
X_16844_ _07692_ _07694_ VSS VSS VDD VDD _07695_ sky130_fd_sc_hd__xnor2_1
X_16845_ sa10_sub\[6\] _07695_ VSS VSS VDD VDD _07696_ sky130_fd_sc_hd__xnor2_1
X_16846_ text_in_r\[31\] _07696_ net512 VSS VSS VDD VDD _07697_
+ sky130_fd_sc_hd__mux2i_4
X_16847_ u0.tmp_w\[31\] _07697_ VSS VSS VDD VDD _07698_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_33_803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16849_ sa10_sub\[5\] sa21_sub\[5\] VSS VSS VDD VDD _07700_
+ sky130_fd_sc_hd__xnor2_2
X_16850_ sa10_sub\[4\] sa03_sr\[4\] VSS VSS VDD VDD _07701_
+ sky130_fd_sc_hd__xor2_1
X_16851_ sa32_sub\[5\] _07700_ _07701_ VSS VSS VDD VDD _07702_
+ sky130_fd_sc_hd__xnor3_1
X_16852_ text_in_r\[29\] _07702_ net512 VSS VSS VDD VDD _07703_
+ sky130_fd_sc_hd__mux2i_4
X_16853_ u0.tmp_w\[29\] _07703_ VSS VSS VDD VDD _07704_ sky130_fd_sc_hd__xnor2_4
X_16854_ sa03_sr\[5\] sa10_sub\[6\] sa21_sub\[6\] VSS VSS
+ VDD VDD _07705_ sky130_fd_sc_hd__xnor3_1
X_16855_ sa10_sub\[5\] sa32_sub\[6\] VSS VSS VDD VDD _07706_
+ sky130_fd_sc_hd__xor2_1
X_16856_ _07705_ _07706_ VSS VSS VDD VDD _07707_ sky130_fd_sc_hd__xnor2_1
X_16857_ text_in_r\[30\] _07707_ net512 VSS VSS VDD VDD _07708_
+ sky130_fd_sc_hd__mux2i_4
X_16858_ u0.tmp_w\[30\] _07708_ VSS VSS VDD VDD _07709_ sky130_fd_sc_hd__xor2_4
X_16859_ _07704_ _07709_ VSS VSS VDD VDD _07710_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_33_802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16861_ sa03_sr\[7\] sa03_sr\[3\] sa21_sub\[4\] VSS VSS VDD
+ VDD _07712_ sky130_fd_sc_hd__xnor3_1
X_16862_ sa10_sub\[7\] sa10_sub\[3\] VSS VSS VDD VDD _07713_
+ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_33_801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16864_ sa10_sub\[4\] sa32_sub\[4\] VSS VSS VDD VDD _07715_
+ sky130_fd_sc_hd__xnor2_1
X_16865_ _07712_ _07713_ _07715_ VSS VSS VDD VDD _07716_ sky130_fd_sc_hd__xnor3_1
X_16866_ text_in_r\[28\] _07716_ net512 VSS VSS VDD VDD _07717_
+ sky130_fd_sc_hd__mux2i_4
X_16867_ u0.tmp_w\[28\] _07717_ VSS VSS VDD VDD _07718_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_33_800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16872_ sa03_sr\[7\] sa03_sr\[2\] sa21_sub\[3\] VSS VSS VDD
+ VDD _07723_ sky130_fd_sc_hd__xnor3_1
XTAP_TAPCELL_ROW_32_796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16874_ sa10_sub\[2\] sa32_sub\[3\] VSS VSS VDD VDD _07725_
+ sky130_fd_sc_hd__xnor2_1
X_16875_ _07713_ _07723_ _07725_ VSS VSS VDD VDD _07726_ sky130_fd_sc_hd__xnor3_2
X_16876_ text_in_r\[27\] _07726_ net490 VSS VSS VDD VDD _07727_
+ sky130_fd_sc_hd__mux2i_4
X_16877_ u0.tmp_w\[27\] _07727_ VSS VSS VDD VDD _07728_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_32_795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16881_ _07676_ net454 VSS VSS VDD VDD _07732_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_32_792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16883_ net575 net503 VSS VSS VDD VDD _07734_ sky130_fd_sc_hd__nand2_1
X_16884_ _07732_ _07734_ VSS VSS VDD VDD _07735_ sky130_fd_sc_hd__nand2_1
X_16885_ net449 _07735_ VSS VSS VDD VDD _07736_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_32_791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16889_ u0.tmp_w\[27\] _07727_ VSS VSS VDD VDD _07740_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_32_788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16892_ _12060_ _07740_ VSS VSS VDD VDD _07743_ sky130_fd_sc_hd__nand2_1
X_16893_ _07675_ _07740_ VSS VSS VDD VDD _07744_ sky130_fd_sc_hd__nor2_1
X_16894_ _07668_ _07744_ VSS VSS VDD VDD _07745_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_32_786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16898_ _12061_ net448 VSS VSS VDD VDD _07749_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_32_783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16900_ _12068_ _07740_ _07749_ _07684_ VSS VSS VDD VDD _07751_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_32_782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16903_ _07684_ _07743_ _07745_ _07751_ net452 VSS VSS VDD
+ VDD _07754_ sky130_fd_sc_hd__a311oi_1
X_16904_ net452 _07736_ _07754_ VSS VSS VDD VDD _07755_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_32_780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16907_ u0.tmp_w\[30\] _07708_ VSS VSS VDD VDD _07758_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_32_778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16910_ _07676_ net450 VSS VSS VDD VDD _07761_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_32_776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16913_ _12061_ net454 _07740_ VSS VSS VDD VDD _07764_ sky130_fd_sc_hd__nand3_2
X_16914_ _07761_ _07764_ VSS VSS VDD VDD _07765_ sky130_fd_sc_hd__nand2_1
X_16915_ net456 net449 VSS VSS VDD VDD _07766_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_31_774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16917_ _12074_ _07740_ VSS VSS VDD VDD _07768_ sky130_fd_sc_hd__nand2_1
X_16918_ _07766_ _07768_ net454 VSS VSS VDD VDD _07769_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_31_773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16920_ _07765_ _07769_ net452 VSS VSS VDD VDD _07771_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_31_772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16922_ net453 net447 VSS VSS VDD VDD _07773_ sky130_fd_sc_hd__nand2_8
X_16923_ net579 _07684_ VSS VSS VDD VDD _07774_ sky130_fd_sc_hd__nand2_1
X_16924_ _07668_ net450 VSS VSS VDD VDD _07775_ sky130_fd_sc_hd__nor2_2
X_16925_ u0.tmp_w\[28\] _07717_ VSS VSS VDD VDD _07776_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_31_771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16928_ _12065_ _07773_ _07774_ _07775_ _07776_ VSS VSS VDD
+ VDD _07779_ sky130_fd_sc_hd__o221ai_4
X_16929_ _07704_ _07758_ _07771_ _07779_ VSS VSS VDD VDD _07780_
+ sky130_fd_sc_hd__nand4_1
X_16930_ _07684_ net449 VSS VSS VDD VDD _07781_ sky130_fd_sc_hd__nand2_8
X_16931_ net454 net449 VSS VSS VDD VDD _07782_ sky130_fd_sc_hd__nor2_8
X_16932_ _07684_ net448 VSS VSS VDD VDD _07783_ sky130_fd_sc_hd__nor2_4
X_16933_ _07782_ _07783_ VSS VSS VDD VDD _07784_ sky130_fd_sc_hd__nor2_2
X_16934_ _12068_ _07781_ _07784_ _12060_ _07764_ VSS VSS VDD
+ VDD _07785_ sky130_fd_sc_hd__o221a_1
X_16935_ _12061_ _07683_ VSS VSS VDD VDD _07786_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_31_769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16937_ _07668_ net453 VSS VSS VDD VDD _07788_ sky130_fd_sc_hd__nor2_2
X_16938_ _12061_ _07728_ VSS VSS VDD VDD _07789_ sky130_fd_sc_hd__nand2_2
X_16939_ _07766_ _07786_ _07788_ _07789_ VSS VSS VDD VDD _07790_
+ sky130_fd_sc_hd__o2bb2ai_1
X_16940_ u0.tmp_w\[29\] _07703_ VSS VSS VDD VDD _07791_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_31_768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16943_ _07791_ _07709_ VSS VSS VDD VDD _07794_ sky130_fd_sc_hd__nand2_4
X_16944_ net452 _07790_ _07794_ VSS VSS VDD VDD _07795_ sky130_fd_sc_hd__a21oi_1
X_16945_ net452 _07785_ _07795_ VSS VSS VDD VDD _07796_ sky130_fd_sc_hd__o21ai_0
X_16946_ _07710_ _07755_ _07780_ _07796_ VSS VSS VDD VDD _07797_
+ sky130_fd_sc_hd__o211ai_1
X_16947_ _07758_ _07698_ VSS VSS VDD VDD _07798_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_31_766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16950_ net449 _07732_ _07781_ VSS VSS VDD VDD _07801_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_31_764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16952_ net454 net449 VSS VSS VDD VDD _07803_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_31_763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16954_ _12062_ _07803_ _07776_ VSS VSS VDD VDD _07805_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_31_762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16956_ _07676_ net454 net449 VSS VSS VDD VDD _07807_ sky130_fd_sc_hd__nor3_4
X_16957_ _07668_ _07801_ _07805_ _07807_ VSS VSS VDD VDD _07808_
+ sky130_fd_sc_hd__a211oi_1
X_16958_ _07668_ net449 VSS VSS VDD VDD _07809_ sky130_fd_sc_hd__nand2_1
X_16959_ _07668_ _07740_ VSS VSS VDD VDD _07810_ sky130_fd_sc_hd__nor2_1
X_16960_ _07774_ _07810_ net452 VSS VSS VDD VDD _07811_ sky130_fd_sc_hd__o21ai_1
X_16961_ net454 _07768_ _07809_ _07811_ VSS VSS VDD VDD _07812_
+ sky130_fd_sc_hd__a31oi_1
X_16962_ _07704_ _07798_ _07808_ _07812_ VSS VSS VDD VDD _07813_
+ sky130_fd_sc_hd__nor4_1
X_16963_ _12061_ _07684_ VSS VSS VDD VDD _07814_ sky130_fd_sc_hd__nand2_1
X_16964_ net450 _07814_ VSS VSS VDD VDD _07815_ sky130_fd_sc_hd__nand2_1
X_16965_ _12081_ net450 _07815_ VSS VSS VDD VDD _07816_ sky130_fd_sc_hd__o21ai_1
X_16966_ _12065_ net453 VSS VSS VDD VDD _07817_ sky130_fd_sc_hd__nor2_2
X_16967_ net571 _07676_ _07684_ VSS VSS VDD VDD _07818_ sky130_fd_sc_hd__nor3_1
X_16968_ _07817_ _07818_ VSS VSS VDD VDD _07819_ sky130_fd_sc_hd__nor2_1
X_16969_ net450 _07819_ net452 VSS VSS VDD VDD _07820_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_31_761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16971_ _12060_ _07684_ VSS VSS VDD VDD _07822_ sky130_fd_sc_hd__nor2_1
X_16972_ _07676_ net447 VSS VSS VDD VDD _07823_ sky130_fd_sc_hd__nand2_4
X_16973_ _12062_ net450 VSS VSS VDD VDD _07824_ sky130_fd_sc_hd__nand2_1
X_16974_ _07823_ _07824_ VSS VSS VDD VDD _07825_ sky130_fd_sc_hd__nand2_1
X_16975_ net448 _07822_ _07825_ _07684_ VSS VSS VDD VDD _07826_
+ sky130_fd_sc_hd__a22oi_2
X_16976_ net452 _07816_ _07820_ _07826_ _07794_ VSS VSS VDD
+ VDD _07827_ sky130_fd_sc_hd__a221oi_4
X_16977_ _07704_ _07758_ VSS VSS VDD VDD _07828_ sky130_fd_sc_hd__nand2_1
X_16978_ _12065_ net450 VSS VSS VDD VDD _07829_ sky130_fd_sc_hd__nor2_2
X_16979_ _12062_ _07740_ net454 VSS VSS VDD VDD _07830_ sky130_fd_sc_hd__o21ai_2
X_16980_ _07829_ _07830_ VSS VSS VDD VDD _07831_ sky130_fd_sc_hd__nor2_1
X_16981_ _12060_ net449 net454 VSS VSS VDD VDD _07832_ sky130_fd_sc_hd__a21oi_1
X_16982_ _07684_ net451 VSS VSS VDD VDD _07833_ sky130_fd_sc_hd__nor2_1
X_16983_ _07823_ _07766_ _07833_ VSS VSS VDD VDD _07834_ sky130_fd_sc_hd__nand3_1
X_16984_ _07684_ _07776_ VSS VSS VDD VDD _07835_ sky130_fd_sc_hd__nand2_1
X_16985_ _12068_ net449 VSS VSS VDD VDD _07836_ sky130_fd_sc_hd__nor2_1
X_16986_ _07835_ _07836_ _07749_ VSS VSS VDD VDD _07837_ sky130_fd_sc_hd__or3_1
X_16987_ _07776_ _07831_ _07832_ _07834_ _07837_ VSS VSS VDD
+ VDD _07838_ sky130_fd_sc_hd__o311ai_1
X_16988_ net449 _07817_ VSS VSS VDD VDD _07839_ sky130_fd_sc_hd__nand2_1
X_16989_ _07704_ _07776_ VSS VSS VDD VDD _07840_ sky130_fd_sc_hd__nor2_8
X_16990_ _12061_ net450 VSS VSS VDD VDD _07841_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_31_760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16992_ _12070_ net448 VSS VSS VDD VDD _07843_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_31_759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_16994_ _07841_ _07843_ net455 VSS VSS VDD VDD _07845_ sky130_fd_sc_hd__o21ai_0
X_16995_ _07758_ _07839_ _07840_ _07845_ _07698_ VSS VSS VDD
+ VDD _07846_ sky130_fd_sc_hd__a41oi_1
X_16996_ net456 net577 VSS VSS VDD VDD _07847_ sky130_fd_sc_hd__nor2_4
X_16997_ net449 _07847_ VSS VSS VDD VDD _07848_ sky130_fd_sc_hd__nor2_1
X_16998_ _12065_ net447 VSS VSS VDD VDD _07849_ sky130_fd_sc_hd__nor2_4
X_16999_ _07791_ _07758_ _07776_ VSS VSS VDD VDD _07850_ sky130_fd_sc_hd__nand3_1
X_17000_ _07849_ _07850_ _07807_ VSS VSS VDD VDD _07851_ sky130_fd_sc_hd__nor3_1
X_17001_ _07684_ _07848_ _07851_ VSS VSS VDD VDD _07852_ sky130_fd_sc_hd__o21ai_0
X_17002_ _07828_ _07838_ _07846_ _07852_ VSS VSS VDD VDD _07853_
+ sky130_fd_sc_hd__o211ai_1
X_17003_ _12068_ _07781_ net452 VSS VSS VDD VDD _07854_ sky130_fd_sc_hd__o21ai_1
X_17004_ _12062_ _07740_ VSS VSS VDD VDD _07855_ sky130_fd_sc_hd__nand2_2
X_17005_ net456 _07676_ VSS VSS VDD VDD _07856_ sky130_fd_sc_hd__nor2_2
X_17006_ _07684_ _07855_ _07803_ _07856_ VSS VSS VDD VDD _07857_
+ sky130_fd_sc_hd__o22ai_2
X_17007_ _07854_ _07857_ VSS VSS VDD VDD _07858_ sky130_fd_sc_hd__nor2_1
X_17008_ _12062_ net447 VSS VSS VDD VDD _07859_ sky130_fd_sc_hd__nor2_1
X_17009_ net456 _07676_ _07728_ VSS VSS VDD VDD _07860_ sky130_fd_sc_hd__nor3_4
X_17010_ _07684_ _07859_ _07860_ VSS VSS VDD VDD _07861_ sky130_fd_sc_hd__nor3_1
X_17011_ _12070_ _07782_ _07861_ net451 VSS VSS VDD VDD _07862_
+ sky130_fd_sc_hd__a211oi_1
X_17012_ _07858_ _07862_ _07710_ VSS VSS VDD VDD _07863_ sky130_fd_sc_hd__nor3_1
X_17013_ _07827_ _07853_ _07863_ VSS VSS VDD VDD _07864_ sky130_fd_sc_hd__nor3_1
X_17014_ _07698_ _07797_ _07813_ _07864_ VSS VSS VDD VDD _00056_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_31_758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17016_ _12074_ _07683_ VSS VSS VDD VDD _07866_ sky130_fd_sc_hd__nand2_1
X_17017_ _07814_ _07866_ VSS VSS VDD VDD _07867_ sky130_fd_sc_hd__nand2_1
X_17018_ net448 _07867_ VSS VSS VDD VDD _07868_ sky130_fd_sc_hd__nand2_1
X_17019_ _07820_ _07868_ VSS VSS VDD VDD _07869_ sky130_fd_sc_hd__nand2_2
X_17020_ u0.tmp_w\[31\] _07697_ VSS VSS VDD VDD _07870_ sky130_fd_sc_hd__xnor2_4
X_17021_ _07709_ _07870_ VSS VSS VDD VDD _07871_ sky130_fd_sc_hd__nand2_4
X_17022_ _07704_ _07871_ VSS VSS VDD VDD _07872_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_31_757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17025_ net456 _07784_ _07839_ VSS VSS VDD VDD _07874_ sky130_fd_sc_hd__o21ai_0
X_17026_ net451 _07874_ VSS VSS VDD VDD _07875_ sky130_fd_sc_hd__nand2_1
X_17027_ _12061_ _07740_ VSS VSS VDD VDD _07876_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_31_755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17029_ _12065_ net450 VSS VSS VDD VDD _07878_ sky130_fd_sc_hd__nand2_2
X_17030_ net454 _07876_ _07878_ VSS VSS VDD VDD _07879_ sky130_fd_sc_hd__nand3_1
X_17031_ net454 _07848_ _07879_ VSS VSS VDD VDD _07880_ sky130_fd_sc_hd__o21ai_0
X_17032_ _07758_ _07870_ VSS VSS VDD VDD _07881_ sky130_fd_sc_hd__nand2_4
X_17033_ _07676_ _07773_ _07781_ _12061_ VSS VSS VDD VDD _07882_
+ sky130_fd_sc_hd__o22ai_1
X_17034_ _07668_ _07740_ VSS VSS VDD VDD _07883_ sky130_fd_sc_hd__nand2_1
X_17035_ _07803_ _07883_ net503 VSS VSS VDD VDD _07884_ sky130_fd_sc_hd__a21oi_1
X_17036_ _07704_ _07882_ _07884_ VSS VSS VDD VDD _07885_ sky130_fd_sc_hd__nor3_1
X_17037_ _07704_ _07880_ _07881_ net451 _07885_ VSS VSS VDD
+ VDD _07886_ sky130_fd_sc_hd__a2111oi_2
X_17038_ net503 net455 VSS VSS VDD VDD _07887_ sky130_fd_sc_hd__nand2_2
X_17039_ net456 net450 VSS VSS VDD VDD _07888_ sky130_fd_sc_hd__nor2_4
X_17040_ _07676_ _07684_ VSS VSS VDD VDD _07889_ sky130_fd_sc_hd__nand2_4
X_17041_ _12060_ _07684_ VSS VSS VDD VDD _07890_ sky130_fd_sc_hd__nand2_1
X_17042_ _07887_ _07890_ net448 VSS VSS VDD VDD _07891_ sky130_fd_sc_hd__a21oi_1
X_17043_ _07887_ _07888_ _07889_ _07891_ _07776_ VSS VSS VDD
+ VDD _07892_ sky130_fd_sc_hd__a311o_1
X_17044_ _07675_ _07684_ VSS VSS VDD VDD _07893_ sky130_fd_sc_hd__nor2_1
X_17045_ _12068_ _07684_ _07893_ _07668_ _07740_ VSS VSS VDD
+ VDD _07894_ sky130_fd_sc_hd__a221oi_4
XTAP_TAPCELL_ROW_31_754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17047_ _07776_ _07894_ _07791_ VSS VSS VDD VDD _07896_ sky130_fd_sc_hd__a21oi_1
X_17048_ _12084_ _07728_ _07776_ VSS VSS VDD VDD _07897_ sky130_fd_sc_hd__o21ai_0
X_17049_ _07709_ _07698_ VSS VSS VDD VDD _07898_ sky130_fd_sc_hd__nand2_4
X_17050_ _07894_ _07897_ _07898_ VSS VSS VDD VDD _07899_ sky130_fd_sc_hd__o21bai_1
X_17051_ net456 net447 VSS VSS VDD VDD _07900_ sky130_fd_sc_hd__nor2_2
X_17052_ _07900_ _07775_ _07684_ VSS VSS VDD VDD _07901_ sky130_fd_sc_hd__o21ai_2
X_17053_ _07829_ _07744_ net454 VSS VSS VDD VDD _07902_ sky130_fd_sc_hd__o21ai_1
X_17054_ _07901_ _07902_ _07840_ VSS VSS VDD VDD _07903_ sky130_fd_sc_hd__a21boi_0
X_17055_ _07892_ _07896_ _07899_ _07903_ VSS VSS VDD VDD _07904_
+ sky130_fd_sc_hd__a211oi_2
X_17056_ _07869_ _07872_ _07875_ _07886_ _07904_ VSS VSS VDD
+ VDD _07905_ sky130_fd_sc_hd__a311oi_4
X_17057_ _07709_ _07870_ VSS VSS VDD VDD _07906_ sky130_fd_sc_hd__nor2_1
X_17058_ _07876_ _07745_ _07684_ VSS VSS VDD VDD _07907_ sky130_fd_sc_hd__a21oi_1
X_17059_ net454 net448 VSS VSS VDD VDD _07908_ sky130_fd_sc_hd__nor2_4
X_17060_ net503 _07908_ VSS VSS VDD VDD _07909_ sky130_fd_sc_hd__nand2_2
X_17061_ _07791_ _07909_ VSS VSS VDD VDD _07910_ sky130_fd_sc_hd__nand2_1
X_17062_ _12060_ _07740_ VSS VSS VDD VDD _07911_ sky130_fd_sc_hd__nor2_1
X_17063_ net454 _07888_ _07911_ _07902_ _07704_ VSS VSS VDD
+ VDD _07912_ sky130_fd_sc_hd__o311ai_1
X_17064_ _07907_ _07910_ _07912_ VSS VSS VDD VDD _07913_ sky130_fd_sc_hd__o21ai_0
X_17065_ _07776_ _07906_ _07913_ VSS VSS VDD VDD _07914_ sky130_fd_sc_hd__nand3_1
X_17066_ _12060_ _07740_ _07830_ VSS VSS VDD VDD _07915_ sky130_fd_sc_hd__a21oi_1
X_17067_ _12061_ _07740_ VSS VSS VDD VDD _07916_ sky130_fd_sc_hd__nand2_2
X_17068_ _07761_ _07916_ _07683_ VSS VSS VDD VDD _07917_ sky130_fd_sc_hd__a21oi_2
X_17069_ _07791_ _07776_ VSS VSS VDD VDD _07918_ sky130_fd_sc_hd__nor2_4
X_17070_ _07915_ _07917_ _07918_ _07906_ VSS VSS VDD VDD _07919_
+ sky130_fd_sc_hd__o211ai_1
X_17071_ _07704_ _07718_ VSS VSS VDD VDD _07920_ sky130_fd_sc_hd__nand2_4
X_17072_ _07740_ _07847_ _07883_ VSS VSS VDD VDD _07921_ sky130_fd_sc_hd__o21ai_0
X_17073_ _12074_ _07782_ _07921_ net454 VSS VSS VDD VDD _07922_
+ sky130_fd_sc_hd__a22oi_1
X_17074_ net451 net449 VSS VSS VDD VDD _07923_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_31_753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17076_ _12061_ net451 net449 VSS VSS VDD VDD _07925_ sky130_fd_sc_hd__a21oi_1
X_17077_ net451 _07849_ _07925_ VSS VSS VDD VDD _07926_ sky130_fd_sc_hd__a21oi_1
X_17078_ net451 net448 VSS VSS VDD VDD _07927_ sky130_fd_sc_hd__nand2_1
X_17079_ net451 _07766_ _07927_ net454 VSS VSS VDD VDD _07928_
+ sky130_fd_sc_hd__o22ai_1
X_17080_ _07684_ _07926_ _07928_ net503 VSS VSS VDD VDD _07929_
+ sky130_fd_sc_hd__a2bb2oi_1
X_17081_ _07807_ _07833_ _07668_ VSS VSS VDD VDD _07930_ sky130_fd_sc_hd__o21ai_1
X_17082_ _07791_ _07871_ VSS VSS VDD VDD _07931_ sky130_fd_sc_hd__nor2_2
X_17083_ _07923_ _07889_ _07929_ _07930_ _07931_ VSS VSS VDD
+ VDD _07932_ sky130_fd_sc_hd__o2111ai_4
X_17084_ _12060_ _07728_ _07684_ VSS VSS VDD VDD _07933_ sky130_fd_sc_hd__a21oi_1
X_17085_ _07916_ _07933_ VSS VSS VDD VDD _07934_ sky130_fd_sc_hd__nand2_1
X_17086_ _12065_ _07740_ VSS VSS VDD VDD _07935_ sky130_fd_sc_hd__and2_1
X_17087_ _07744_ _07935_ _07684_ VSS VSS VDD VDD _07936_ sky130_fd_sc_hd__o21ai_0
X_17088_ _07934_ _07936_ _07881_ VSS VSS VDD VDD _07937_ sky130_fd_sc_hd__a21oi_1
X_17089_ _12074_ net450 VSS VSS VDD VDD _07938_ sky130_fd_sc_hd__and2_2
X_17090_ net569 net578 net448 VSS VSS VDD VDD _07939_ sky130_fd_sc_hd__o21ai_1
X_17091_ _07684_ _07824_ _07939_ VSS VSS VDD VDD _07940_ sky130_fd_sc_hd__nand3_1
X_17092_ _07684_ _07841_ _07938_ _07940_ _07906_ VSS VSS VDD
+ VDD _07941_ sky130_fd_sc_hd__o311a_1
X_17093_ _07937_ _07941_ _07840_ VSS VSS VDD VDD _07942_ sky130_fd_sc_hd__o21ai_0
X_17094_ _07881_ _07920_ _07922_ _07932_ _07942_ VSS VSS VDD
+ VDD _07943_ sky130_fd_sc_hd__o311a_1
X_17095_ _07905_ _07914_ _07919_ _07943_ VSS VSS VDD VDD _00057_
+ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_31_752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17097_ _07668_ net455 VSS VSS VDD VDD _07945_ sky130_fd_sc_hd__nand2_1
X_17098_ _12084_ net448 VSS VSS VDD VDD _07946_ sky130_fd_sc_hd__nor2_1
X_17099_ _07791_ _07776_ VSS VSS VDD VDD _07947_ sky130_fd_sc_hd__nand2_4
X_17100_ net448 _07734_ _07945_ _07946_ _07947_ VSS VSS VDD
+ VDD _07948_ sky130_fd_sc_hd__a311o_1
X_17101_ _07791_ net452 VSS VSS VDD VDD _07949_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_30_751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17103_ net450 _07818_ _07786_ VSS VSS VDD VDD _07951_ sky130_fd_sc_hd__nor3_1
X_17104_ _12081_ net450 _07951_ VSS VSS VDD VDD _07952_ sky130_fd_sc_hd__a21oi_1
X_17105_ _07949_ _07952_ _07881_ VSS VSS VDD VDD _07953_ sky130_fd_sc_hd__a21oi_1
X_17106_ _07900_ _07788_ _12061_ VSS VSS VDD VDD _07954_ sky130_fd_sc_hd__o21ai_0
X_17107_ net572 _07684_ VSS VSS VDD VDD _07955_ sky130_fd_sc_hd__nor2_1
X_17108_ _07732_ _07775_ _07955_ _07823_ VSS VSS VDD VDD _07956_
+ sky130_fd_sc_hd__a22oi_1
X_17109_ _07704_ _07954_ _07956_ VSS VSS VDD VDD _07957_ sky130_fd_sc_hd__nand3_1
X_17110_ _12060_ net450 _07841_ VSS VSS VDD VDD _07958_ sky130_fd_sc_hd__a21oi_1
X_17111_ _07684_ _07836_ _07900_ _07791_ VSS VSS VDD VDD _07959_
+ sky130_fd_sc_hd__o31a_1
X_17112_ net453 _07958_ _07959_ VSS VSS VDD VDD _07960_ sky130_fd_sc_hd__o21ai_0
X_17113_ net452 _07957_ _07960_ VSS VSS VDD VDD _07961_ sky130_fd_sc_hd__nand3_1
X_17114_ _07948_ _07953_ _07961_ VSS VSS VDD VDD _07962_ sky130_fd_sc_hd__nand3_1
X_17115_ _07668_ net503 VSS VSS VDD VDD _07963_ sky130_fd_sc_hd__nand2_2
X_17116_ _12079_ net447 VSS VSS VDD VDD _07964_ sky130_fd_sc_hd__nand2_1
X_17117_ _07963_ _07781_ _07964_ VSS VSS VDD VDD _07965_ sky130_fd_sc_hd__o21ai_0
X_17118_ _07888_ _07889_ VSS VSS VDD VDD _07966_ sky130_fd_sc_hd__nand2_1
X_17119_ _12088_ net447 _07966_ net452 VSS VSS VDD VDD _07967_
+ sky130_fd_sc_hd__o211ai_1
X_17120_ net452 _07965_ _07967_ VSS VSS VDD VDD _07968_ sky130_fd_sc_hd__o21ai_0
X_17121_ _12062_ _12065_ VSS VSS VDD VDD _07969_ sky130_fd_sc_hd__nor2_2
X_17122_ net453 _07969_ VSS VSS VDD VDD _07970_ sky130_fd_sc_hd__nand2_1
X_17123_ _07684_ _07847_ VSS VSS VDD VDD _07971_ sky130_fd_sc_hd__nand2_1
X_17124_ net447 _07970_ _07971_ _07894_ _07776_ VSS VSS VDD
+ VDD _07972_ sky130_fd_sc_hd__a311oi_2
X_17125_ _12065_ _07782_ _07958_ net453 net452 VSS VSS VDD
+ VDD _07973_ sky130_fd_sc_hd__a221oi_1
X_17126_ _07791_ _07871_ _07972_ _07973_ VSS VSS VDD VDD _07974_
+ sky130_fd_sc_hd__nor4_1
X_17127_ _07872_ _07968_ _07974_ VSS VSS VDD VDD _07975_ sky130_fd_sc_hd__a21oi_1
X_17128_ net579 net450 VSS VSS VDD VDD _07976_ sky130_fd_sc_hd__nand2_2
X_17129_ _12070_ net449 VSS VSS VDD VDD _07977_ sky130_fd_sc_hd__nand2_2
X_17130_ _07876_ _07977_ net454 VSS VSS VDD VDD _07978_ sky130_fd_sc_hd__a21oi_1
X_17131_ net454 _07876_ _07976_ _07978_ VSS VSS VDD VDD _07979_
+ sky130_fd_sc_hd__a31oi_1
X_17132_ _12074_ net448 _07684_ VSS VSS VDD VDD _07980_ sky130_fd_sc_hd__o21ai_1
X_17133_ _07888_ _07980_ VSS VSS VDD VDD _07981_ sky130_fd_sc_hd__nor2_1
X_17134_ _12070_ _07740_ VSS VSS VDD VDD _07982_ sky130_fd_sc_hd__nand2_1
X_17135_ _07761_ _07982_ _07684_ VSS VSS VDD VDD _07983_ sky130_fd_sc_hd__a21oi_1
X_17136_ _07981_ _07983_ net451 VSS VSS VDD VDD _07984_ sky130_fd_sc_hd__o21ai_0
X_17137_ net451 _07979_ _07984_ VSS VSS VDD VDD _07985_ sky130_fd_sc_hd__o21ai_0
X_17138_ net454 _07823_ _07977_ VSS VSS VDD VDD _07986_ sky130_fd_sc_hd__nand3_1
X_17139_ net454 _07935_ _07938_ _07986_ net451 VSS VSS VDD
+ VDD _07987_ sky130_fd_sc_hd__o311ai_0
X_17140_ net454 _07883_ _07977_ _07817_ VSS VSS VDD VDD _07988_
+ sky130_fd_sc_hd__a31oi_1
X_17141_ _07776_ _07988_ _07704_ VSS VSS VDD VDD _07989_ sky130_fd_sc_hd__a21oi_1
X_17142_ _07987_ _07989_ _07798_ VSS VSS VDD VDD _07990_ sky130_fd_sc_hd__a21oi_1
X_17143_ _07791_ _07985_ _07990_ VSS VSS VDD VDD _07991_ sky130_fd_sc_hd__o21ai_1
X_17144_ net450 _07819_ _07776_ VSS VSS VDD VDD _07992_ sky130_fd_sc_hd__o21ai_1
X_17145_ _07815_ _07955_ VSS VSS VDD VDD _07993_ sky130_fd_sc_hd__nor2_1
X_17146_ _12065_ _07684_ VSS VSS VDD VDD _07994_ sky130_fd_sc_hd__nor2_1
X_17147_ _12074_ net453 VSS VSS VDD VDD _07995_ sky130_fd_sc_hd__nor2_1
X_17148_ _07994_ _07995_ net450 VSS VSS VDD VDD _07996_ sky130_fd_sc_hd__o21ai_0
X_17149_ net452 _07966_ _07996_ _07704_ VSS VSS VDD VDD _07997_
+ sky130_fd_sc_hd__a31oi_1
X_17150_ _07992_ _07993_ _07997_ VSS VSS VDD VDD _07998_ sky130_fd_sc_hd__o21ai_0
X_17151_ _07823_ _07789_ _07684_ VSS VSS VDD VDD _07999_ sky130_fd_sc_hd__a21oi_1
X_17152_ _07766_ _07855_ net454 VSS VSS VDD VDD _08000_ sky130_fd_sc_hd__a21oi_1
X_17153_ _07999_ _08000_ net452 VSS VSS VDD VDD _08001_ sky130_fd_sc_hd__o21ai_1
X_17154_ net578 net447 VSS VSS VDD VDD _08002_ sky130_fd_sc_hd__nand2_2
X_17155_ net570 _07683_ VSS VSS VDD VDD _08003_ sky130_fd_sc_hd__nor2_1
X_17156_ _08002_ _07761_ _08003_ VSS VSS VDD VDD _08004_ sky130_fd_sc_hd__nand3_1
X_17157_ _12074_ _07773_ _08004_ _07776_ VSS VSS VDD VDD _08005_
+ sky130_fd_sc_hd__o211ai_1
X_17158_ _07704_ _08001_ _08005_ _07898_ VSS VSS VDD VDD _08006_
+ sky130_fd_sc_hd__a31oi_1
X_17159_ _07998_ _08006_ VSS VSS VDD VDD _08007_ sky130_fd_sc_hd__nand2_1
X_17160_ _07962_ _07975_ _07991_ _08007_ VSS VSS VDD VDD _00058_
+ sky130_fd_sc_hd__nand4_1
X_17161_ _07684_ _07728_ VSS VSS VDD VDD _08008_ sky130_fd_sc_hd__nor2_2
X_17162_ _12068_ _08008_ _07786_ net449 VSS VSS VDD VDD _08009_
+ sky130_fd_sc_hd__a22oi_1
X_17163_ _07740_ _07732_ VSS VSS VDD VDD _08010_ sky130_fd_sc_hd__nor2_1
X_17164_ _07807_ _08010_ _07668_ VSS VSS VDD VDD _08011_ sky130_fd_sc_hd__o21ai_0
X_17165_ _07949_ _08009_ _08011_ _07881_ VSS VSS VDD VDD _08012_
+ sky130_fd_sc_hd__a31oi_1
X_17166_ _07963_ _07732_ _08008_ VSS VSS VDD VDD _08013_ sky130_fd_sc_hd__a21oi_1
X_17167_ _07684_ _07768_ _07977_ VSS VSS VDD VDD _08014_ sky130_fd_sc_hd__nand3_1
X_17168_ _07684_ _07749_ _07888_ _08014_ net451 VSS VSS VDD
+ VDD _08015_ sky130_fd_sc_hd__o311ai_0
X_17169_ net452 _08013_ _08015_ VSS VSS VDD VDD _08016_ sky130_fd_sc_hd__o21ai_1
X_17170_ net568 _07675_ _07740_ VSS VSS VDD VDD _08017_ sky130_fd_sc_hd__nand3_2
X_17171_ _07918_ _08017_ VSS VSS VDD VDD _08018_ sky130_fd_sc_hd__nand2_1
X_17172_ _12068_ _07908_ _07999_ _08018_ VSS VSS VDD VDD _08019_
+ sky130_fd_sc_hd__a211oi_1
X_17173_ _07791_ _08016_ _08019_ VSS VSS VDD VDD _08020_ sky130_fd_sc_hd__a21oi_1
X_17174_ _12061_ _07684_ VSS VSS VDD VDD _08021_ sky130_fd_sc_hd__nor2_2
X_17175_ net450 _07866_ VSS VSS VDD VDD _08022_ sky130_fd_sc_hd__nor2_1
X_17176_ _07683_ _07829_ _07810_ VSS VSS VDD VDD _08023_ sky130_fd_sc_hd__nor3_1
X_17177_ net450 _08021_ _08022_ _08023_ VSS VSS VDD VDD _08024_
+ sky130_fd_sc_hd__a211oi_1
X_17178_ _07841_ _07810_ _07684_ VSS VSS VDD VDD _08025_ sky130_fd_sc_hd__o21ai_0
X_17179_ _07675_ _07783_ VSS VSS VDD VDD _08026_ sky130_fd_sc_hd__nand2_2
X_17180_ _07840_ _08025_ _08026_ _07871_ VSS VSS VDD VDD _08027_
+ sky130_fd_sc_hd__a31oi_1
X_17181_ _07791_ _07718_ _08024_ _08027_ VSS VSS VDD VDD _08028_
+ sky130_fd_sc_hd__o31ai_2
X_17182_ _07810_ _07732_ _08003_ _07976_ VSS VSS VDD VDD _08029_
+ sky130_fd_sc_hd__a22oi_1
X_17183_ _07764_ _08029_ _07947_ VSS VSS VDD VDD _08030_ sky130_fd_sc_hd__a21oi_1
X_17184_ _12068_ net449 VSS VSS VDD VDD _08031_ sky130_fd_sc_hd__nand2_1
X_17185_ _07743_ _08031_ _07684_ VSS VSS VDD VDD _08032_ sky130_fd_sc_hd__a21oi_1
X_17186_ _07684_ _07876_ _07761_ _07920_ _08032_ VSS VSS VDD
+ VDD _08033_ sky130_fd_sc_hd__a311oi_4
X_17187_ _12070_ _07784_ _08010_ VSS VSS VDD VDD _08034_ sky130_fd_sc_hd__a21oi_1
X_17188_ _07684_ _07749_ VSS VSS VDD VDD _08035_ sky130_fd_sc_hd__nor2_1
X_17189_ net448 _07969_ VSS VSS VDD VDD _08036_ sky130_fd_sc_hd__nand2_1
X_17190_ _07768_ _07761_ net454 VSS VSS VDD VDD _08037_ sky130_fd_sc_hd__a21oi_1
X_17191_ _08035_ _08036_ _08037_ _07947_ VSS VSS VDD VDD _08038_
+ sky130_fd_sc_hd__a211oi_1
X_17192_ _07704_ _07766_ _07855_ VSS VSS VDD VDD _08039_ sky130_fd_sc_hd__o21ai_0
X_17193_ _12068_ _07704_ _07781_ VSS VSS VDD VDD _08040_ sky130_fd_sc_hd__nor3_1
X_17194_ net455 _07704_ _07728_ VSS VSS VDD VDD _08041_ sky130_fd_sc_hd__nand3_1
X_17195_ _07684_ _07791_ _07740_ VSS VSS VDD VDD _08042_ sky130_fd_sc_hd__nand3_1
X_17196_ _08041_ _08042_ _12061_ VSS VSS VDD VDD _08043_ sky130_fd_sc_hd__a21oi_1
X_17197_ net455 _08039_ _08040_ _07776_ _08043_ VSS VSS VDD
+ VDD _08044_ sky130_fd_sc_hd__a2111oi_0
X_17198_ _07949_ _08034_ _08038_ _08044_ VSS VSS VDD VDD _08045_
+ sky130_fd_sc_hd__a211oi_1
X_17199_ _08028_ _08030_ _08033_ _08045_ _07898_ VSS VSS VDD
+ VDD _08046_ sky130_fd_sc_hd__o32ai_2
X_17200_ _07791_ _07823_ VSS VSS VDD VDD _08047_ sky130_fd_sc_hd__nor2_1
X_17201_ _07791_ _07728_ VSS VSS VDD VDD _08048_ sky130_fd_sc_hd__nand2_1
X_17202_ _12070_ _07728_ VSS VSS VDD VDD _08049_ sky130_fd_sc_hd__nor2_1
X_17203_ _07749_ _08049_ VSS VSS VDD VDD _08050_ sky130_fd_sc_hd__nor2_1
X_17204_ _07676_ _08048_ _08050_ _07791_ net455 VSS VSS VDD
+ VDD _08051_ sky130_fd_sc_hd__o221ai_1
X_17205_ _07980_ _08047_ _08051_ VSS VSS VDD VDD _08052_ sky130_fd_sc_hd__o21ai_0
X_17206_ _12060_ _07773_ _07781_ net456 VSS VSS VDD VDD _08053_
+ sky130_fd_sc_hd__o22ai_1
X_17207_ net455 _07766_ net503 VSS VSS VDD VDD _08054_ sky130_fd_sc_hd__a21oi_1
X_17208_ _07791_ _08053_ _08054_ VSS VSS VDD VDD _08055_ sky130_fd_sc_hd__nor3_1
X_17209_ _12070_ net453 VSS VSS VDD VDD _08056_ sky130_fd_sc_hd__nor2_1
X_17210_ net455 _07969_ _08056_ _07728_ VSS VSS VDD VDD _08057_
+ sky130_fd_sc_hd__a211oi_2
X_17211_ _07704_ _07894_ _08057_ VSS VSS VDD VDD _08058_ sky130_fd_sc_hd__nor3_1
X_17212_ net451 _08055_ _08058_ VSS VSS VDD VDD _08059_ sky130_fd_sc_hd__nor3_1
X_17213_ net451 _08052_ _08059_ _07798_ VSS VSS VDD VDD _08060_
+ sky130_fd_sc_hd__a211oi_2
X_17214_ _08012_ _08020_ _08046_ _08060_ VSS VSS VDD VDD _00059_
+ sky130_fd_sc_hd__a211oi_1
X_17215_ net455 _07776_ VSS VSS VDD VDD _08061_ sky130_fd_sc_hd__nand2_1
X_17216_ _07776_ _07890_ _08061_ net456 VSS VSS VDD VDD _08062_
+ sky130_fd_sc_hd__o22ai_1
X_17217_ _07675_ _07835_ net456 VSS VSS VDD VDD _08063_ sky130_fd_sc_hd__a21oi_1
X_17218_ net449 _07732_ VSS VSS VDD VDD _08064_ sky130_fd_sc_hd__nand2_1
X_17219_ net449 _08062_ _08063_ _08064_ VSS VSS VDD VDD _08065_
+ sky130_fd_sc_hd__o22ai_2
X_17220_ net454 net451 VSS VSS VDD VDD _08066_ sky130_fd_sc_hd__nand2_1
X_17221_ net451 _08002_ _08066_ VSS VSS VDD VDD _08067_ sky130_fd_sc_hd__o21ai_0
X_17222_ net456 _08067_ _07704_ VSS VSS VDD VDD _08068_ sky130_fd_sc_hd__a21oi_1
X_17223_ _07832_ _07883_ _07893_ net451 VSS VSS VDD VDD _08069_
+ sky130_fd_sc_hd__a211oi_1
X_17224_ net451 _07830_ _07982_ _08069_ _07791_ VSS VSS VDD
+ VDD _08070_ sky130_fd_sc_hd__a311oi_1
X_17225_ _08065_ _08068_ _08070_ _07881_ VSS VSS VDD VDD _08071_
+ sky130_fd_sc_hd__a211oi_1
X_17226_ _07822_ _08003_ net448 VSS VSS VDD VDD _08072_ sky130_fd_sc_hd__o21ai_0
X_17227_ _07849_ _07860_ net453 VSS VSS VDD VDD _08073_ sky130_fd_sc_hd__o21ai_0
X_17228_ net453 _07888_ _07938_ _08073_ VSS VSS VDD VDD _08074_
+ sky130_fd_sc_hd__o31ai_2
X_17229_ _07820_ _08072_ _08074_ net452 _07704_ VSS VSS VDD
+ VDD _08075_ sky130_fd_sc_hd__a221oi_1
X_17230_ net450 _07818_ _08056_ VSS VSS VDD VDD _08076_ sky130_fd_sc_hd__nor3_1
X_17231_ _07814_ _07866_ net448 VSS VSS VDD VDD _08077_ sky130_fd_sc_hd__a21oi_1
X_17232_ _08076_ _08077_ _07949_ VSS VSS VDD VDD _08078_ sky130_fd_sc_hd__o21a_1
X_17233_ _12070_ _07684_ _07918_ VSS VSS VDD VDD _08079_ sky130_fd_sc_hd__o21ai_0
X_17234_ _07684_ _07878_ _07916_ _08079_ VSS VSS VDD VDD _08080_
+ sky130_fd_sc_hd__a31oi_1
X_17235_ _07871_ _08075_ _08078_ _08080_ VSS VSS VDD VDD _08081_
+ sky130_fd_sc_hd__nor4_1
X_17236_ _07684_ _07704_ _08002_ _07789_ VSS VSS VDD VDD _08082_
+ sky130_fd_sc_hd__and4_1
X_17237_ net448 _07847_ _07849_ _07684_ _07791_ VSS VSS VDD
+ VDD _08083_ sky130_fd_sc_hd__a2111oi_0
X_17238_ _07980_ _08026_ _07704_ VSS VSS VDD VDD _08084_ sky130_fd_sc_hd__a21oi_1
X_17239_ _08082_ _08083_ _08084_ _07776_ VSS VSS VDD VDD _08085_
+ sky130_fd_sc_hd__o31ai_1
X_17240_ _07684_ _07935_ _07911_ _07840_ _07901_ VSS VSS VDD
+ VDD _08086_ sky130_fd_sc_hd__o311ai_0
X_17241_ _07918_ _07940_ _07798_ VSS VSS VDD VDD _08087_ sky130_fd_sc_hd__a21oi_1
X_17242_ _08085_ _08086_ _08087_ VSS VSS VDD VDD _08088_ sky130_fd_sc_hd__and3_1
X_17243_ _12072_ net450 VSS VSS VDD VDD _08089_ sky130_fd_sc_hd__nand2_1
X_17244_ net450 _07814_ _08089_ VSS VSS VDD VDD _08090_ sky130_fd_sc_hd__o21ai_0
X_17245_ _12060_ _07781_ _08017_ _07791_ VSS VSS VDD VDD _08091_
+ sky130_fd_sc_hd__o211ai_2
X_17246_ _07683_ _07825_ _08091_ VSS VSS VDD VDD _08092_ sky130_fd_sc_hd__a21oi_1
X_17247_ _07704_ _08090_ _08092_ net452 VSS VSS VDD VDD _08093_
+ sky130_fd_sc_hd__a211oi_2
X_17248_ _07791_ net448 VSS VSS VDD VDD _08094_ sky130_fd_sc_hd__nor2_1
X_17249_ _08094_ _08049_ _07684_ VSS VSS VDD VDD _08095_ sky130_fd_sc_hd__o21ai_0
X_17250_ _07856_ _07788_ _07728_ VSS VSS VDD VDD _08096_ sky130_fd_sc_hd__o21ai_0
X_17251_ _07791_ net448 VSS VSS VDD VDD _08097_ sky130_fd_sc_hd__nand2_1
X_17252_ _07732_ _08097_ VSS VSS VDD VDD _08098_ sky130_fd_sc_hd__nor2_1
X_17253_ net456 _07704_ _08008_ _08098_ VSS VSS VDD VDD _08099_
+ sky130_fd_sc_hd__a31oi_1
X_17254_ net451 _08095_ _08096_ _08099_ VSS VSS VDD VDD _08100_
+ sky130_fd_sc_hd__nand4_1
X_17255_ _07898_ _08093_ _08100_ VSS VSS VDD VDD _08101_ sky130_fd_sc_hd__nor3b_1
X_17256_ _08071_ _08081_ _08088_ _08101_ VSS VSS VDD VDD _00060_
+ sky130_fd_sc_hd__nor4_1
X_17257_ net451 net449 VSS VSS VDD VDD _08102_ sky130_fd_sc_hd__nor2_2
X_17258_ net451 _07773_ _08102_ VSS VSS VDD VDD _08103_ sky130_fd_sc_hd__a21oi_1
X_17259_ net456 _08103_ VSS VSS VDD VDD _08104_ sky130_fd_sc_hd__nor2_1
X_17260_ net456 _07923_ _08104_ net503 VSS VSS VDD VDD _08105_
+ sky130_fd_sc_hd__a211oi_1
X_17261_ _07783_ _08102_ VSS VSS VDD VDD _08106_ sky130_fd_sc_hd__nor2_1
X_17262_ _07668_ _08106_ VSS VSS VDD VDD _08107_ sky130_fd_sc_hd__nor2_1
X_17263_ _12068_ _07782_ VSS VSS VDD VDD _08108_ sky130_fd_sc_hd__nand2_1
X_17264_ _08026_ _08108_ _07776_ VSS VSS VDD VDD _08109_ sky130_fd_sc_hd__a21oi_1
X_17265_ _07831_ _07769_ VSS VSS VDD VDD _08110_ sky130_fd_sc_hd__nor2_1
X_17266_ _12070_ _07908_ _07857_ _07935_ _07776_ VSS VSS VDD
+ VDD _08111_ sky130_fd_sc_hd__a2111oi_0
X_17267_ _07776_ _08110_ _08111_ _07828_ VSS VSS VDD VDD _08112_
+ sky130_fd_sc_hd__a211o_1
X_17268_ _07710_ _08105_ _08107_ _08109_ _08112_ VSS VSS VDD
+ VDD _08113_ sky130_fd_sc_hd__o41a_1
X_17269_ net453 _07878_ _07860_ VSS VSS VDD VDD _08114_ sky130_fd_sc_hd__a21oi_1
X_17270_ _07709_ _08114_ VSS VSS VDD VDD _08115_ sky130_fd_sc_hd__nor2_1
X_17271_ _07824_ _07916_ net453 VSS VSS VDD VDD _08116_ sky130_fd_sc_hd__a21oi_1
X_17272_ net456 _07783_ _08116_ _07758_ VSS VSS VDD VDD _08117_
+ sky130_fd_sc_hd__a211oi_1
X_17273_ _08115_ _08117_ VSS VSS VDD VDD _08118_ sky130_fd_sc_hd__nor2_1
X_17274_ _07728_ _07889_ _08050_ _07684_ VSS VSS VDD VDD _08119_
+ sky130_fd_sc_hd__o22ai_1
X_17275_ net447 _08021_ VSS VSS VDD VDD _08120_ sky130_fd_sc_hd__nand2_1
X_17276_ _12060_ net450 VSS VSS VDD VDD _08121_ sky130_fd_sc_hd__nor2_1
X_17277_ _07938_ _08121_ _07684_ VSS VSS VDD VDD _08122_ sky130_fd_sc_hd__o21ai_0
X_17278_ _07709_ _08120_ _08122_ _07947_ VSS VSS VDD VDD _08123_
+ sky130_fd_sc_hd__a31o_1
X_17279_ _07758_ _08119_ _08123_ VSS VSS VDD VDD _08124_ sky130_fd_sc_hd__a21oi_1
X_17280_ _07840_ _08118_ _08124_ _07698_ VSS VSS VDD VDD _08125_
+ sky130_fd_sc_hd__a211oi_1
X_17281_ _07887_ _07900_ _07889_ _07969_ _08008_ VSS VSS VDD
+ VDD _08126_ sky130_fd_sc_hd__a32oi_2
X_17282_ net455 _07876_ _07789_ VSS VSS VDD VDD _08127_ sky130_fd_sc_hd__nand3_1
X_17283_ _07836_ _07938_ _07684_ VSS VSS VDD VDD _08128_ sky130_fd_sc_hd__o21ai_1
X_17284_ net450 _07995_ _07704_ VSS VSS VDD VDD _08129_ sky130_fd_sc_hd__o21ai_1
X_17285_ _12065_ _07908_ _08129_ VSS VSS VDD VDD _08130_ sky130_fd_sc_hd__a21oi_1
X_17286_ _07791_ _08127_ _08128_ _08130_ _07776_ VSS VSS VDD
+ VDD _08131_ sky130_fd_sc_hd__a311oi_1
X_17287_ _12068_ net447 _07847_ _07783_ _07947_ VSS VSS VDD
+ VDD _08132_ sky130_fd_sc_hd__a221oi_1
X_17288_ _07949_ _08126_ _08131_ _07898_ _08132_ VSS VSS VDD
+ VDD _08133_ sky130_fd_sc_hd__a2111oi_2
X_17289_ net503 _07704_ _07809_ net451 VSS VSS VDD VDD _08134_
+ sky130_fd_sc_hd__a31oi_1
X_17290_ _07791_ _07888_ _08094_ net503 VSS VSS VDD VDD _08135_
+ sky130_fd_sc_hd__a211oi_1
X_17291_ net503 _08048_ _08135_ VSS VSS VDD VDD _08136_ sky130_fd_sc_hd__a21oi_1
X_17292_ _12065_ _08048_ _08002_ _07684_ VSS VSS VDD VDD _08137_
+ sky130_fd_sc_hd__o211ai_1
X_17293_ _07684_ _08136_ _08137_ VSS VSS VDD VDD _08138_ sky130_fd_sc_hd__o21ai_0
X_17294_ net455 _07876_ _07766_ VSS VSS VDD VDD _08139_ sky130_fd_sc_hd__nand3_1
X_17295_ net455 _07843_ _07860_ _08139_ VSS VSS VDD VDD _08140_
+ sky130_fd_sc_hd__o31ai_1
X_17296_ _07684_ net448 _07847_ _08128_ VSS VSS VDD VDD _08141_
+ sky130_fd_sc_hd__o31ai_1
X_17297_ _07918_ _08140_ _08141_ _07840_ _07798_ VSS VSS VDD
+ VDD _08142_ sky130_fd_sc_hd__a221o_1
X_17298_ _08134_ _08138_ _08142_ VSS VSS VDD VDD _08143_ sky130_fd_sc_hd__a21oi_1
X_17299_ _08113_ _08125_ _08133_ _08143_ VSS VSS VDD VDD _00061_
+ sky130_fd_sc_hd__a211oi_2
X_17300_ net569 net455 _07939_ VSS VSS VDD VDD _08144_ sky130_fd_sc_hd__a21oi_1
X_17301_ _12077_ _12086_ net448 VSS VSS VDD VDD _08145_ sky130_fd_sc_hd__nor3_1
X_17302_ net452 _08144_ _08145_ VSS VSS VDD VDD _08146_ sky130_fd_sc_hd__nor3_1
X_17303_ _12070_ net450 _07933_ VSS VSS VDD VDD _08147_ sky130_fd_sc_hd__o21ai_0
X_17304_ _12062_ net452 _07782_ _07881_ _07791_ VSS VSS VDD
+ VDD _08148_ sky130_fd_sc_hd__a311oi_1
X_17305_ _07776_ _08147_ _08148_ VSS VSS VDD VDD _08149_ sky130_fd_sc_hd__o21ai_0
X_17306_ _07789_ _08036_ net455 VSS VSS VDD VDD _08150_ sky130_fd_sc_hd__a21oi_1
X_17307_ net455 _07976_ _07982_ _08150_ _07776_ VSS VSS VDD
+ VDD _08151_ sky130_fd_sc_hd__a311oi_1
X_17308_ _12074_ _07728_ VSS VSS VDD VDD _08152_ sky130_fd_sc_hd__nand2_1
X_17309_ net455 _07855_ _08152_ net452 VSS VSS VDD VDD _08153_
+ sky130_fd_sc_hd__a31o_1
X_17310_ _07684_ _07939_ _07977_ _08153_ VSS VSS VDD VDD _08154_
+ sky130_fd_sc_hd__a31oi_1
X_17311_ _07704_ _07881_ _08151_ _08154_ VSS VSS VDD VDD _08155_
+ sky130_fd_sc_hd__or4_1
X_17312_ _07728_ _07969_ _07860_ _07684_ VSS VSS VDD VDD _08156_
+ sky130_fd_sc_hd__a211oi_1
X_17313_ _07684_ _07823_ _07789_ _08156_ net451 VSS VSS VDD
+ VDD _08157_ sky130_fd_sc_hd__a311oi_1
X_17314_ _07668_ _07732_ net449 VSS VSS VDD VDD _08158_ sky130_fd_sc_hd__a21oi_1
X_17315_ _07854_ _08158_ VSS VSS VDD VDD _08159_ sky130_fd_sc_hd__nor2_1
X_17316_ _08157_ _08159_ _07872_ VSS VSS VDD VDD _08160_ sky130_fd_sc_hd__o21ai_1
X_17317_ _08146_ _08149_ _08155_ _08160_ VSS VSS VDD VDD _08161_
+ sky130_fd_sc_hd__o211ai_1
X_17318_ _07667_ net503 _07683_ _07744_ VSS VSS VDD VDD _08162_
+ sky130_fd_sc_hd__a31oi_1
X_17319_ _12074_ _08162_ _08017_ _07889_ VSS VSS VDD VDD _08163_
+ sky130_fd_sc_hd__o211ai_1
X_17320_ _12074_ _07803_ net451 VSS VSS VDD VDD _08164_ sky130_fd_sc_hd__o21ai_0
X_17321_ _07676_ _07684_ net456 VSS VSS VDD VDD _08165_ sky130_fd_sc_hd__a21oi_1
X_17322_ _07893_ _08102_ _08164_ _08165_ _07791_ VSS VSS VDD
+ VDD _08166_ sky130_fd_sc_hd__a221o_1
X_17323_ net451 _08163_ _08166_ VSS VSS VDD VDD _08167_ sky130_fd_sc_hd__a21oi_1
X_17324_ _07668_ net451 VSS VSS VDD VDD _08168_ sky130_fd_sc_hd__nand2_1
X_17325_ _07676_ _07776_ VSS VSS VDD VDD _08169_ sky130_fd_sc_hd__nand2_1
X_17326_ _08168_ _08169_ net455 VSS VSS VDD VDD _08170_ sky130_fd_sc_hd__a21oi_1
X_17327_ _12070_ _08061_ VSS VSS VDD VDD _08171_ sky130_fd_sc_hd__nor2_1
X_17328_ _07668_ net455 net503 VSS VSS VDD VDD _08172_ sky130_fd_sc_hd__o21ai_0
X_17329_ _12061_ _07833_ _08172_ net451 VSS VSS VDD VDD _08173_
+ sky130_fd_sc_hd__a22oi_1
X_17330_ _08097_ _08170_ _08171_ _08048_ _08173_ VSS VSS VDD
+ VDD _08174_ sky130_fd_sc_hd__o32ai_2
X_17331_ _07798_ _08167_ _08174_ VSS VSS VDD VDD _08175_ sky130_fd_sc_hd__nor3_1
X_17332_ _12068_ _07728_ _08049_ VSS VSS VDD VDD _08176_ sky130_fd_sc_hd__a21oi_1
X_17333_ _07668_ _07773_ _08176_ net455 net451 VSS VSS VDD
+ VDD _08177_ sky130_fd_sc_hd__o221ai_1
X_17334_ _07992_ _08177_ _07704_ VSS VSS VDD VDD _08178_ sky130_fd_sc_hd__a21oi_1
X_17335_ _12070_ _07684_ net452 net447 _07955_ VSS VSS VDD
+ VDD _08179_ sky130_fd_sc_hd__a2111oi_0
X_17336_ _07740_ _08021_ _08037_ _07776_ VSS VSS VDD VDD _08180_
+ sky130_fd_sc_hd__a211oi_1
X_17337_ _12078_ _08102_ _08179_ _08180_ _07791_ VSS VSS VDD
+ VDD _08181_ sky130_fd_sc_hd__a2111oi_0
X_17338_ _07859_ _07860_ _07684_ VSS VSS VDD VDD _08182_ sky130_fd_sc_hd__o21ai_0
X_17339_ _07684_ _07749_ _07888_ _08182_ _07776_ VSS VSS VDD
+ VDD _08183_ sky130_fd_sc_hd__o311ai_1
X_17340_ _07684_ _07856_ _08021_ VSS VSS VDD VDD _08184_ sky130_fd_sc_hd__a21oi_1
X_17341_ net447 _08184_ _07964_ net451 VSS VSS VDD VDD _08185_
+ sky130_fd_sc_hd__o211ai_1
X_17342_ _07931_ _08183_ _08185_ VSS VSS VDD VDD _08186_ sky130_fd_sc_hd__nand3_1
X_17343_ _07898_ _08178_ _08181_ _08186_ VSS VSS VDD VDD _08187_
+ sky130_fd_sc_hd__o31ai_1
X_17344_ _08161_ _08175_ _08187_ VSS VSS VDD VDD _00062_ sky130_fd_sc_hd__nor3_1
X_17345_ _12068_ _07740_ net454 VSS VSS VDD VDD _08188_ sky130_fd_sc_hd__a21oi_1
X_17346_ _07745_ _08188_ VSS VSS VDD VDD _08189_ sky130_fd_sc_hd__nand2_1
X_17347_ _07668_ _07774_ _07740_ VSS VSS VDD VDD _08190_ sky130_fd_sc_hd__a21oi_1
X_17348_ _07920_ _08057_ _08190_ VSS VSS VDD VDD _08191_ sky130_fd_sc_hd__nor3_1
X_17349_ _07934_ _07949_ _08189_ _08191_ VSS VSS VDD VDD _08192_
+ sky130_fd_sc_hd__a31oi_1
X_17350_ net453 _07859_ _07888_ VSS VSS VDD VDD _08193_ sky130_fd_sc_hd__nor3_1
X_17351_ _07822_ _07947_ _08193_ VSS VSS VDD VDD _08194_ sky130_fd_sc_hd__or3_1
X_17352_ _07849_ _08144_ _07840_ VSS VSS VDD VDD _08195_ sky130_fd_sc_hd__o21ai_0
X_17353_ _08192_ _08194_ _08195_ _07709_ VSS VSS VDD VDD _08196_
+ sky130_fd_sc_hd__a31oi_1
X_17354_ _12086_ _07728_ VSS VSS VDD VDD _08197_ sky130_fd_sc_hd__nor2_1
X_17355_ _12070_ _07683_ _07740_ _07786_ VSS VSS VDD VDD _08198_
+ sky130_fd_sc_hd__a211oi_1
X_17356_ _07876_ _07809_ _07684_ VSS VSS VDD VDD _08199_ sky130_fd_sc_hd__a21oi_1
X_17357_ _07917_ _08199_ _07840_ VSS VSS VDD VDD _08200_ sky130_fd_sc_hd__o21ai_0
X_17358_ _07947_ _08197_ _08198_ _08200_ VSS VSS VDD VDD _08201_
+ sky130_fd_sc_hd__o31ai_1
X_17359_ _07994_ _07788_ net447 VSS VSS VDD VDD _08202_ sky130_fd_sc_hd__o21ai_0
X_17360_ _07732_ _07900_ _07920_ VSS VSS VDD VDD _08203_ sky130_fd_sc_hd__a21oi_1
X_17361_ _12062_ _07684_ net450 VSS VSS VDD VDD _08204_ sky130_fd_sc_hd__nand3_1
X_17362_ _12072_ net450 _08204_ VSS VSS VDD VDD _08205_ sky130_fd_sc_hd__o21ai_0
X_17363_ _08202_ _08203_ _08205_ _07949_ _07758_ VSS VSS VDD
+ VDD _08206_ sky130_fd_sc_hd__a221o_1
X_17364_ _08201_ _08206_ _07870_ VSS VSS VDD VDD _08207_ sky130_fd_sc_hd__o21ai_0
X_17365_ net449 _07889_ _07976_ VSS VSS VDD VDD _08208_ sky130_fd_sc_hd__o21ai_0
X_17366_ _12060_ _08008_ VSS VSS VDD VDD _08209_ sky130_fd_sc_hd__nand2_1
X_17367_ _07758_ net452 _07909_ _08209_ VSS VSS VDD VDD _08210_
+ sky130_fd_sc_hd__nand4_1
X_17368_ _07668_ _08208_ _08210_ VSS VSS VDD VDD _08211_ sky130_fd_sc_hd__a21oi_1
X_17369_ _07684_ _07888_ _07938_ VSS VSS VDD VDD _08212_ sky130_fd_sc_hd__nor3_1
X_17370_ _07684_ _08049_ _08212_ _07709_ net451 VSS VSS VDD
+ VDD _08213_ sky130_fd_sc_hd__a2111oi_2
X_17371_ _07740_ _07963_ VSS VSS VDD VDD _08214_ sky130_fd_sc_hd__nor2_1
X_17372_ _07823_ _07781_ _07668_ VSS VSS VDD VDD _08215_ sky130_fd_sc_hd__a21oi_1
X_17373_ _08214_ _08215_ _07776_ VSS VSS VDD VDD _08216_ sky130_fd_sc_hd__o21ai_0
X_17374_ _07676_ _07773_ _07761_ VSS VSS VDD VDD _08217_ sky130_fd_sc_hd__o21ai_0
X_17375_ net452 _08217_ VSS VSS VDD VDD _08218_ sky130_fd_sc_hd__nand2_1
X_17376_ _07782_ _08010_ _07668_ VSS VSS VDD VDD _08219_ sky130_fd_sc_hd__o21ai_0
X_17377_ _08216_ _08218_ _08219_ _07758_ VSS VSS VDD VDD _08220_
+ sky130_fd_sc_hd__a31oi_1
X_17378_ _07791_ _08211_ _08213_ _08220_ VSS VSS VDD VDD _08221_
+ sky130_fd_sc_hd__nor4_1
X_17379_ _07908_ _08102_ _07676_ VSS VSS VDD VDD _08222_ sky130_fd_sc_hd__o21ai_0
X_17380_ _07887_ _07927_ _08222_ VSS VSS VDD VDD _08223_ sky130_fd_sc_hd__o21ai_0
X_17381_ _12061_ _07783_ VSS VSS VDD VDD _08224_ sky130_fd_sc_hd__nand2_1
X_17382_ _07835_ _08224_ VSS VSS VDD VDD _08225_ sky130_fd_sc_hd__nand2_1
X_17383_ _07668_ _08223_ _08225_ VSS VSS VDD VDD _08226_ sky130_fd_sc_hd__a21oi_2
X_17384_ _12074_ _07773_ _07784_ _12061_ _07909_ VSS VSS VDD
+ VDD _08227_ sky130_fd_sc_hd__o221ai_1
X_17385_ net449 _07732_ VSS VSS VDD VDD _08228_ sky130_fd_sc_hd__nor2_1
X_17386_ _08152_ _08056_ VSS VSS VDD VDD _08229_ sky130_fd_sc_hd__nor2_1
X_17387_ _07883_ _07977_ net454 VSS VSS VDD VDD _08230_ sky130_fd_sc_hd__a21oi_1
X_17388_ _07850_ _08228_ _08229_ _08230_ _07698_ VSS VSS VDD
+ VDD _08231_ sky130_fd_sc_hd__o41ai_1
X_17389_ _07758_ _07840_ _08227_ _08231_ VSS VSS VDD VDD _08232_
+ sky130_fd_sc_hd__a31oi_1
X_17390_ _07794_ _08226_ _08232_ VSS VSS VDD VDD _08233_ sky130_fd_sc_hd__o21ai_2
X_17391_ _08196_ _08207_ _08221_ _08233_ VSS VSS VDD VDD _00063_
+ sky130_fd_sc_hd__o22ai_1
X_17392_ sa10_sr\[7\] sa00_sr\[1\] sa20_sr\[7\] VSS VSS VDD
+ VDD _08234_ sky130_fd_sc_hd__xnor3_1
X_17393_ _05875_ _05885_ _08234_ VSS VSS VDD VDD _08235_ sky130_fd_sc_hd__xnor3_1
X_17394_ text_in_r\[113\] _08235_ net660 VSS VSS VDD VDD _08236_
+ sky130_fd_sc_hd__mux2i_4
X_17395_ u0.w\[0\]\[17\] _08236_ VSS VSS VDD VDD _08237_ sky130_fd_sc_hd__xor2_4
X_17396_ net446 VSS VSS VDD VDD _08238_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_30_750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17399_ sa00_sr\[0\] sa30_sr\[0\] VSS VSS VDD VDD _08240_
+ sky130_fd_sc_hd__xor2_1
X_17400_ sa20_sr\[0\] _05970_ _08240_ VSS VSS VDD VDD _08241_
+ sky130_fd_sc_hd__xnor3_1
X_17401_ text_in_r\[112\] _08241_ net660 VSS VSS VDD VDD _08242_
+ sky130_fd_sc_hd__mux2i_4
X_17402_ u0.w\[0\]\[16\] _08242_ VSS VSS VDD VDD _08243_ sky130_fd_sc_hd__xor2_4
X_17403_ net697 VSS VSS VDD VDD _08244_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_30_748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17406_ sa20_sr\[1\] sa20_sr\[2\] sa00_sr\[2\] VSS VSS VDD
+ VDD _08246_ sky130_fd_sc_hd__xnor3_1
X_17407_ _05895_ _08246_ VSS VSS VDD VDD _08247_ sky130_fd_sc_hd__xnor2_2
X_17408_ text_in_r\[114\] _08247_ net490 VSS VSS VDD VDD _08248_
+ sky130_fd_sc_hd__mux2i_4
X_17409_ u0.w\[0\]\[18\] _08248_ VSS VSS VDD VDD _08249_ sky130_fd_sc_hd__xnor2_4
X_17410_ net442 VSS VSS VDD VDD _08250_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_30_746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17421_ net492 text_in_r\[115\] VSS VSS VDD VDD _08258_ sky130_fd_sc_hd__nand2_1
X_17422_ u0.w\[0\]\[19\] net492 _08258_ VSS VSS VDD VDD _08259_
+ sky130_fd_sc_hd__nand3_1
X_17423_ u0.w\[0\]\[19\] _08258_ _08259_ VSS VSS VDD VDD _08260_
+ sky130_fd_sc_hd__o21a_2
X_17424_ u0.w\[0\]\[19\] _08258_ VSS VSS VDD VDD _08261_ sky130_fd_sc_hd__and2_0
X_17425_ u0.w\[0\]\[19\] net492 VSS VSS VDD VDD _08262_ sky130_fd_sc_hd__nor2_1
X_17426_ sa20_sr\[2\] sa20_sr\[3\] sa00_sr\[3\] VSS VSS VDD
+ VDD _08263_ sky130_fd_sc_hd__xnor3_1
X_17427_ _05929_ _05970_ _08263_ VSS VSS VDD VDD _08264_ sky130_fd_sc_hd__xnor3_4
X_17428_ _08261_ _08262_ _08264_ VSS VSS VDD VDD _08265_ sky130_fd_sc_hd__mux2i_4
X_17429_ _08260_ _08265_ VSS VSS VDD VDD _08266_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_30_736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17431_ net444 _08266_ VSS VSS VDD VDD _08268_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_30_735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17433_ _08244_ net444 VSS VSS VDD VDD _08270_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_30_734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17436_ net445 _08266_ VSS VSS VDD VDD _08273_ sky130_fd_sc_hd__nand2_1
X_17437_ _08270_ _08273_ VSS VSS VDD VDD _08274_ sky130_fd_sc_hd__nand2_1
X_17438_ _12097_ _08268_ _08274_ VSS VSS VDD VDD _08275_ sky130_fd_sc_hd__o21ai_0
X_17439_ sa20_sr\[4\] sa00_sr\[5\] VSS VSS VDD VDD _08276_
+ sky130_fd_sc_hd__xor2_1
X_17440_ _05911_ _08276_ VSS VSS VDD VDD _08277_ sky130_fd_sc_hd__xnor2_2
X_17441_ text_in_r\[117\] _08277_ net490 VSS VSS VDD VDD _08278_
+ sky130_fd_sc_hd__mux2i_4
X_17442_ u0.w\[0\]\[21\] _08278_ VSS VSS VDD VDD _08279_ sky130_fd_sc_hd__xor2_4
X_17443_ sa20_sr\[3\] sa30_sr\[4\] sa20_sr\[7\] VSS VSS VDD
+ VDD _08280_ sky130_fd_sc_hd__xnor3_1
X_17444_ sa20_sr\[4\] sa00_sr\[4\] VSS VSS VDD VDD _08281_
+ sky130_fd_sc_hd__xnor2_1
X_17445_ _05925_ _08280_ _08281_ VSS VSS VDD VDD _08282_ sky130_fd_sc_hd__xnor3_1
X_17446_ text_in_r\[116\] _08282_ net547 VSS VSS VDD VDD _08283_
+ sky130_fd_sc_hd__mux2i_4
X_17447_ u0.w\[0\]\[20\] _08283_ VSS VSS VDD VDD _08284_ sky130_fd_sc_hd__xnor2_4
X_17448_ _08279_ _08284_ VSS VSS VDD VDD _08285_ sky130_fd_sc_hd__nor2_8
X_17449_ u0.w\[0\]\[21\] _08278_ VSS VSS VDD VDD _08286_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_30_732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17452_ net445 net700 _08250_ VSS VSS VDD VDD _08289_ sky130_fd_sc_hd__nor3_2
X_17453_ _08265_ _08260_ VSS VSS VDD VDD _08290_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_30_730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17456_ u0.w\[0\]\[20\] _08283_ VSS VSS VDD VDD _08293_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_30_728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17458_ _08289_ net701 _08270_ net441 VSS VSS VDD VDD _08295_
+ sky130_fd_sc_hd__o31ai_4
XTAP_TAPCELL_ROW_29_727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17461_ net446 net443 VSS VSS VDD VDD _08298_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_29_725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17464_ _12094_ _08250_ VSS VSS VDD VDD _08301_ sky130_fd_sc_hd__nor2_1
X_17465_ _08266_ _08298_ _08301_ VSS VSS VDD VDD _08302_ sky130_fd_sc_hd__nor3_1
X_17466_ _08286_ _08295_ _08302_ VSS VSS VDD VDD _08303_ sky130_fd_sc_hd__nor3_1
X_17467_ _08275_ _08285_ _08303_ VSS VSS VDD VDD _08304_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_29_723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17470_ _12106_ _08266_ VSS VSS VDD VDD _08307_ sky130_fd_sc_hd__nand2_2
X_17471_ _08238_ _08290_ VSS VSS VDD VDD _08308_ sky130_fd_sc_hd__nand2_2
X_17472_ net445 _08290_ VSS VSS VDD VDD _08309_ sky130_fd_sc_hd__nand2_4
X_17473_ net444 _08307_ _08308_ _08270_ _08309_ VSS VSS VDD
+ VDD _08310_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_29_721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17475_ net445 _08266_ VSS VSS VDD VDD _08312_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_29_720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17477_ _12106_ _08290_ VSS VSS VDD VDD _08314_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_29_719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17479_ _08244_ _08290_ VSS VSS VDD VDD _08316_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_29_718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17483_ _12093_ net444 _08266_ VSS VSS VDD VDD _08320_ sky130_fd_sc_hd__nand3_1
X_17484_ net444 _08312_ _08314_ _08316_ _08320_ VSS VSS VDD
+ VDD _08321_ sky130_fd_sc_hd__o311ai_0
X_17485_ _08286_ _08321_ VSS VSS VDD VDD _08322_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_29_715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17488_ _08286_ _08310_ _08322_ _08284_ VSS VSS VDD VDD _08325_
+ sky130_fd_sc_hd__o211ai_1
X_17489_ sa20_sr\[6\] sa20_sr\[7\] VSS VSS VDD VDD _08326_
+ sky130_fd_sc_hd__xnor2_1
X_17490_ _05974_ _08326_ VSS VSS VDD VDD _08327_ sky130_fd_sc_hd__xnor2_2
X_17491_ sa00_sr\[7\] _08327_ VSS VSS VDD VDD _08328_ sky130_fd_sc_hd__xnor2_1
X_17492_ text_in_r\[119\] _08328_ net512 VSS VSS VDD VDD _08329_
+ sky130_fd_sc_hd__mux2i_4
X_17493_ u0.w\[0\]\[23\] _08329_ VSS VSS VDD VDD _08330_ sky130_fd_sc_hd__xnor2_4
X_17494_ sa20_sr\[5\] sa00_sr\[6\] VSS VSS VDD VDD _08331_
+ sky130_fd_sc_hd__xnor2_1
X_17495_ _05982_ _08331_ VSS VSS VDD VDD _08332_ sky130_fd_sc_hd__xnor2_1
X_17496_ net492 _08332_ VSS VSS VDD VDD _08333_ sky130_fd_sc_hd__nor2_1
X_17497_ net492 text_in_r\[118\] _08333_ VSS VSS VDD VDD _08334_
+ sky130_fd_sc_hd__a21oi_4
X_17498_ u0.w\[0\]\[22\] _08334_ VSS VSS VDD VDD _08335_ sky130_fd_sc_hd__xnor2_4
X_17499_ _08330_ _08335_ VSS VSS VDD VDD _08336_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_29_713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17501_ _08304_ _08325_ _08336_ VSS VSS VDD VDD _08338_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_29_712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17504_ _08250_ _08266_ VSS VSS VDD VDD _08341_ sky130_fd_sc_hd__nor2_4
X_17505_ net446 _08244_ _08250_ VSS VSS VDD VDD _08342_ sky130_fd_sc_hd__nor3_2
X_17506_ _12102_ net443 _08266_ VSS VSS VDD VDD _08343_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_29_710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17508_ _08342_ _08343_ net441 VSS VSS VDD VDD _08345_ sky130_fd_sc_hd__o21ai_1
X_17509_ _12094_ _08341_ _08345_ VSS VSS VDD VDD _08346_ sky130_fd_sc_hd__a21oi_1
X_17510_ net446 _08244_ _08266_ VSS VSS VDD VDD _08347_ sky130_fd_sc_hd__nor3_2
X_17511_ _12094_ _08290_ net444 VSS VSS VDD VDD _08348_ sky130_fd_sc_hd__o21ai_0
X_17512_ _08347_ _08348_ VSS VSS VDD VDD _08349_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_29_709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17515_ _08250_ _08290_ VSS VSS VDD VDD _08352_ sky130_fd_sc_hd__nand2_8
X_17516_ _12100_ _08352_ VSS VSS VDD VDD _08353_ sky130_fd_sc_hd__nor2_1
X_17517_ net441 _08349_ _08353_ VSS VSS VDD VDD _08354_ sky130_fd_sc_hd__nor3_1
X_17518_ _12097_ net443 VSS VSS VDD VDD _08355_ sky130_fd_sc_hd__nor2_1
X_17519_ _08266_ _08342_ _08355_ net441 VSS VSS VDD VDD _08356_
+ sky130_fd_sc_hd__o31ai_2
X_17520_ _12092_ _08268_ VSS VSS VDD VDD _08357_ sky130_fd_sc_hd__nor2_1
X_17521_ _08244_ _08266_ VSS VSS VDD VDD _08358_ sky130_fd_sc_hd__nand2_4
X_17522_ _12094_ _08290_ VSS VSS VDD VDD _08359_ sky130_fd_sc_hd__nand2_1
X_17523_ _08358_ _08359_ net443 VSS VSS VDD VDD _08360_ sky130_fd_sc_hd__a21oi_1
X_17524_ _12093_ VSS VSS VDD VDD _08361_ sky130_fd_sc_hd__clkinv_4
X_17525_ _12113_ _08266_ net441 VSS VSS VDD VDD _08362_ sky130_fd_sc_hd__a21oi_1
X_17526_ _08361_ _08352_ _08362_ VSS VSS VDD VDD _08363_ sky130_fd_sc_hd__o21ai_0
X_17527_ _08356_ _08357_ _08360_ _08363_ _08279_ VSS VSS VDD
+ VDD _08364_ sky130_fd_sc_hd__o311ai_2
X_17528_ u0.w\[0\]\[22\] _08334_ VSS VSS VDD VDD _08365_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_29_707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17530_ _08365_ _08330_ VSS VSS VDD VDD _08367_ sky130_fd_sc_hd__and2_2
X_17531_ _08279_ _08346_ _08354_ _08364_ _08367_ VSS VSS VDD
+ VDD _08368_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_29_706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17534_ _08238_ _08244_ VSS VSS VDD VDD _08371_ sky130_fd_sc_hd__nand2_4
X_17535_ _12100_ _08286_ VSS VSS VDD VDD _08372_ sky130_fd_sc_hd__nor2_1
X_17536_ _08286_ _08371_ _08372_ VSS VSS VDD VDD _08373_ sky130_fd_sc_hd__a21oi_1
X_17537_ _08286_ net701 VSS VSS VDD VDD _08374_ sky130_fd_sc_hd__xnor2_1
X_17538_ _12100_ net701 VSS VSS VDD VDD _08375_ sky130_fd_sc_hd__nor2_1
X_17539_ _12093_ _08374_ _08375_ _08286_ VSS VSS VDD VDD _08376_
+ sky130_fd_sc_hd__a22oi_1
X_17540_ _08250_ _08266_ VSS VSS VDD VDD _08377_ sky130_fd_sc_hd__nand2_2
X_17541_ _12093_ _08279_ _08341_ VSS VSS VDD VDD _08378_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_28_704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17543_ _08377_ _08378_ _12092_ VSS VSS VDD VDD _08380_ sky130_fd_sc_hd__a21o_1
X_17544_ _08352_ _08373_ _08376_ _08250_ _08380_ VSS VSS VDD
+ VDD _08381_ sky130_fd_sc_hd__o221ai_1
XTAP_TAPCELL_ROW_28_703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17547_ net516 _08286_ _08250_ VSS VSS VDD VDD _08384_ sky130_fd_sc_hd__a21oi_1
X_17548_ _08244_ _08250_ VSS VSS VDD VDD _08385_ sky130_fd_sc_hd__nand2_1
X_17549_ _12093_ net444 _08279_ VSS VSS VDD VDD _08386_ sky130_fd_sc_hd__nand3_1
X_17550_ net445 _08384_ _08385_ _08279_ _08386_ VSS VSS VDD
+ VDD _08387_ sky130_fd_sc_hd__o221ai_1
X_17551_ _08244_ net442 VSS VSS VDD VDD _08388_ sky130_fd_sc_hd__nand2_4
X_17552_ net445 net700 VSS VSS VDD VDD _08389_ sky130_fd_sc_hd__nand2_1
X_17553_ _08388_ _08389_ _08279_ VSS VSS VDD VDD _08390_ sky130_fd_sc_hd__a21oi_1
X_17554_ _12093_ net444 _08286_ _08266_ VSS VSS VDD VDD _08391_
+ sky130_fd_sc_hd__o31ai_1
X_17555_ _08266_ _08387_ _08390_ _08391_ VSS VSS VDD VDD _08392_
+ sky130_fd_sc_hd__o22ai_1
X_17556_ _08335_ _08330_ VSS VSS VDD VDD _08393_ sky130_fd_sc_hd__nor2_2
X_17557_ net441 _08392_ _08393_ VSS VSS VDD VDD _08394_ sky130_fd_sc_hd__o21ai_0
X_17558_ net441 _08381_ _08394_ VSS VSS VDD VDD _08395_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_28_701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17561_ _12093_ _08266_ VSS VSS VDD VDD _08398_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_28_699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17563_ net444 _08309_ _08358_ VSS VSS VDD VDD _08400_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_28_698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17565_ net444 _08375_ _08398_ _08400_ net441 VSS VSS VDD
+ VDD _08402_ sky130_fd_sc_hd__o311ai_2
X_17566_ _12097_ _08290_ VSS VSS VDD VDD _08403_ sky130_fd_sc_hd__nor2_4
X_17567_ _12094_ _08266_ VSS VSS VDD VDD _08404_ sky130_fd_sc_hd__nor2_2
X_17568_ _08403_ _08404_ net444 VSS VSS VDD VDD _08405_ sky130_fd_sc_hd__o21ai_1
X_17569_ net444 _08266_ VSS VSS VDD VDD _08406_ sky130_fd_sc_hd__nor2_2
X_17570_ _12092_ _08406_ VSS VSS VDD VDD _08407_ sky130_fd_sc_hd__nand2_1
X_17571_ _08284_ _08405_ _08407_ VSS VSS VDD VDD _08408_ sky130_fd_sc_hd__nand3_1
X_17572_ _08286_ _08402_ _08408_ VSS VSS VDD VDD _08409_ sky130_fd_sc_hd__nand3_1
X_17573_ net700 _08266_ VSS VSS VDD VDD _08410_ sky130_fd_sc_hd__nand2_1
X_17574_ _08284_ _08410_ VSS VSS VDD VDD _08411_ sky130_fd_sc_hd__nor2_2
X_17575_ _12097_ _08266_ VSS VSS VDD VDD _08412_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_28_697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17578_ _12093_ _08266_ VSS VSS VDD VDD _08415_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17580_ _12102_ _08290_ VSS VSS VDD VDD _08417_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17582_ _08415_ _08417_ _08250_ VSS VSS VDD VDD _08419_ sky130_fd_sc_hd__a21oi_1
X_17583_ net441 _08419_ _08295_ VSS VSS VDD VDD _08420_ sky130_fd_sc_hd__o21ai_0
X_17584_ net443 _08411_ _08412_ _08279_ _08420_ VSS VSS VDD
+ VDD _08421_ sky130_fd_sc_hd__o311ai_2
X_17585_ _08335_ _08330_ VSS VSS VDD VDD _08422_ sky130_fd_sc_hd__nand2_4
X_17586_ _08409_ _08421_ _08422_ VSS VSS VDD VDD _08423_ sky130_fd_sc_hd__a21oi_1
X_17587_ _08338_ _08368_ _08395_ _08423_ VSS VSS VDD VDD _00064_
+ sky130_fd_sc_hd__nor4_1
X_17588_ _08244_ _08290_ VSS VSS VDD VDD _08424_ sky130_fd_sc_hd__nor2_1
X_17589_ net443 _08424_ _08238_ VSS VSS VDD VDD _08425_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_28_693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17591_ _08244_ _08266_ VSS VSS VDD VDD _08426_ sky130_fd_sc_hd__nor2_4
X_17592_ net446 _08426_ VSS VSS VDD VDD _08427_ sky130_fd_sc_hd__nand2_1
X_17593_ _08268_ _08285_ _08425_ _08427_ VSS VSS VDD VDD _08428_
+ sky130_fd_sc_hd__nand4_1
X_17594_ _12097_ _08290_ VSS VSS VDD VDD _08429_ sky130_fd_sc_hd__nand2_2
X_17595_ _08415_ _08429_ _08250_ VSS VSS VDD VDD _08430_ sky130_fd_sc_hd__a21oi_1
X_17596_ net699 _08266_ VSS VSS VDD VDD _08431_ sky130_fd_sc_hd__nor2_1
X_17597_ net443 _08431_ _08424_ VSS VSS VDD VDD _08432_ sky130_fd_sc_hd__nor3_1
X_17598_ _08279_ _08293_ VSS VSS VDD VDD _08433_ sky130_fd_sc_hd__nor2_4
X_17599_ _08430_ _08432_ _08433_ VSS VSS VDD VDD _08434_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_28_692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17601_ _12093_ _12106_ net443 VSS VSS VDD VDD _08436_ sky130_fd_sc_hd__mux2i_1
X_17602_ net701 _08436_ VSS VSS VDD VDD _08437_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_28_691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17604_ _08250_ _08290_ VSS VSS VDD VDD _08439_ sky130_fd_sc_hd__xnor2_2
X_17605_ _12097_ _08352_ _08439_ net446 VSS VSS VDD VDD _08440_
+ sky130_fd_sc_hd__o22ai_1
X_17606_ _08284_ _08440_ _08286_ VSS VSS VDD VDD _08441_ sky130_fd_sc_hd__a21oi_1
X_17607_ _08356_ _08437_ _08441_ VSS VSS VDD VDD _08442_ sky130_fd_sc_hd__o21ai_0
X_17608_ _08238_ _08266_ VSS VSS VDD VDD _08443_ sky130_fd_sc_hd__nand2_1
X_17609_ _08244_ _08250_ VSS VSS VDD VDD _08444_ sky130_fd_sc_hd__xnor2_1
X_17610_ _12092_ net700 net443 VSS VSS VDD VDD _08445_ sky130_fd_sc_hd__mux2i_1
X_17611_ _08443_ _08444_ _08445_ _08266_ VSS VSS VDD VDD _08446_
+ sky130_fd_sc_hd__o22ai_1
X_17612_ _08286_ _08446_ VSS VSS VDD VDD _08447_ sky130_fd_sc_hd__nand2_1
X_17613_ _12097_ _08266_ VSS VSS VDD VDD _08448_ sky130_fd_sc_hd__and2_0
X_17614_ _08426_ _08448_ net444 VSS VSS VDD VDD _08449_ sky130_fd_sc_hd__o21ai_1
X_17615_ _08238_ _08266_ VSS VSS VDD VDD _08450_ sky130_fd_sc_hd__nor2_1
X_17616_ net446 _08290_ VSS VSS VDD VDD _08451_ sky130_fd_sc_hd__nor2_2
X_17617_ _08450_ _08451_ _08250_ VSS VSS VDD VDD _08452_ sky130_fd_sc_hd__o21ai_0
X_17618_ _08279_ _08449_ _08452_ _08293_ VSS VSS VDD VDD _08453_
+ sky130_fd_sc_hd__a31oi_1
X_17619_ _12100_ _08250_ VSS VSS VDD VDD _08454_ sky130_fd_sc_hd__nand2_1
X_17620_ _08289_ _08266_ _08454_ VSS VSS VDD VDD _08455_ sky130_fd_sc_hd__nor3b_1
X_17621_ _12116_ _08286_ _08290_ VSS VSS VDD VDD _08456_ sky130_fd_sc_hd__nor3_1
X_17622_ _08455_ _08456_ VSS VSS VDD VDD _08457_ sky130_fd_sc_hd__or2_0
X_17623_ _08447_ _08453_ _08457_ net441 _08330_ VSS VSS VDD
+ VDD _08458_ sky130_fd_sc_hd__a221oi_1
X_17624_ _08330_ _08428_ _08434_ _08442_ _08458_ VSS VSS VDD
+ VDD _08459_ sky130_fd_sc_hd__a41oi_1
X_17625_ _08238_ _08244_ _08290_ VSS VSS VDD VDD _08460_ sky130_fd_sc_hd__a21oi_1
X_17626_ _08361_ _08266_ VSS VSS VDD VDD _08461_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_28_690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17628_ _08461_ _08429_ _08250_ VSS VSS VDD VDD _08463_ sky130_fd_sc_hd__a21oi_1
X_17629_ _08250_ _08460_ _08463_ VSS VSS VDD VDD _08464_ sky130_fd_sc_hd__a21o_1
X_17630_ _08238_ _08358_ VSS VSS VDD VDD _08465_ sky130_fd_sc_hd__nor2_1
X_17631_ _08361_ _08352_ _08439_ _08244_ VSS VSS VDD VDD _08466_
+ sky130_fd_sc_hd__o22ai_1
X_17632_ _08286_ _08465_ _08466_ VSS VSS VDD VDD _08467_ sky130_fd_sc_hd__nor3_1
X_17633_ _08286_ _08464_ _08467_ VSS VSS VDD VDD _08468_ sky130_fd_sc_hd__a21oi_1
X_17634_ _08371_ _08266_ VSS VSS VDD VDD _08469_ sky130_fd_sc_hd__nor2_1
X_17635_ _08238_ _08268_ VSS VSS VDD VDD _08470_ sky130_fd_sc_hd__nor2_1
X_17636_ _08250_ _08307_ _08469_ _08470_ _08279_ VSS VSS VDD
+ VDD _08471_ sky130_fd_sc_hd__a2111oi_0
X_17637_ _12093_ _08290_ VSS VSS VDD VDD _08472_ sky130_fd_sc_hd__nor2_4
X_17638_ _12092_ _08266_ VSS VSS VDD VDD _08473_ sky130_fd_sc_hd__nor2_2
X_17639_ _08426_ _08403_ _08250_ VSS VSS VDD VDD _08474_ sky130_fd_sc_hd__o21ai_0
X_17640_ _08250_ _08472_ _08473_ _08474_ _08279_ VSS VSS VDD
+ VDD _08475_ sky130_fd_sc_hd__o311a_1
X_17641_ _08471_ _08475_ _08284_ VSS VSS VDD VDD _08476_ sky130_fd_sc_hd__o21ai_0
X_17642_ _08335_ _08330_ VSS VSS VDD VDD _08477_ sky130_fd_sc_hd__and2_2
X_17643_ _08284_ _08468_ _08476_ _08477_ VSS VSS VDD VDD _08478_
+ sky130_fd_sc_hd__o211ai_1
X_17644_ _08249_ _08426_ _08472_ VSS VSS VDD VDD _08479_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_28_689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17646_ _12092_ _08266_ _08404_ _08250_ VSS VSS VDD VDD _08481_
+ sky130_fd_sc_hd__a211oi_1
X_17647_ _08479_ _08481_ _08433_ VSS VSS VDD VDD _08482_ sky130_fd_sc_hd__o21ai_0
X_17648_ _08451_ _08473_ _08250_ VSS VSS VDD VDD _08483_ sky130_fd_sc_hd__o21ai_0
X_17649_ _08449_ _08483_ VSS VSS VDD VDD _08484_ sky130_fd_sc_hd__nand2_1
X_17650_ _08285_ _08484_ _08336_ VSS VSS VDD VDD _08485_ sky130_fd_sc_hd__a21oi_1
X_17651_ net446 net699 _08290_ VSS VSS VDD VDD _08486_ sky130_fd_sc_hd__nor3_1
X_17652_ _08404_ _08486_ VSS VSS VDD VDD _08487_ sky130_fd_sc_hd__nor2_1
X_17653_ _08286_ _08293_ VSS VSS VDD VDD _08488_ sky130_fd_sc_hd__nor2_4
X_17654_ _12106_ _08290_ VSS VSS VDD VDD _08489_ sky130_fd_sc_hd__nand2_4
X_17655_ net443 _08461_ _08489_ VSS VSS VDD VDD _08490_ sky130_fd_sc_hd__nand3_1
X_17656_ net443 _08487_ _08488_ _08490_ VSS VSS VDD VDD _08491_
+ sky130_fd_sc_hd__o211ai_1
X_17657_ _08472_ _08469_ _08249_ VSS VSS VDD VDD _08492_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_28_688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17659_ _08286_ _08284_ VSS VSS VDD VDD _08494_ sky130_fd_sc_hd__nor2_2
X_17660_ net516 _08406_ VSS VSS VDD VDD _08495_ sky130_fd_sc_hd__nand2_1
X_17661_ _08492_ _08494_ _08495_ VSS VSS VDD VDD _08496_ sky130_fd_sc_hd__nand3_1
X_17662_ _08482_ _08485_ _08491_ _08496_ VSS VSS VDD VDD _08497_
+ sky130_fd_sc_hd__nand4_1
X_17663_ _08335_ _08459_ _08478_ _08497_ VSS VSS VDD VDD _00065_
+ sky130_fd_sc_hd__o211a_1
X_17664_ _12100_ _08266_ VSS VSS VDD VDD _08498_ sky130_fd_sc_hd__nand2_1
X_17665_ _12092_ _08260_ _08265_ VSS VSS VDD VDD _08499_ sky130_fd_sc_hd__and3_2
X_17666_ net442 _08472_ _08499_ VSS VSS VDD VDD _08500_ sky130_fd_sc_hd__nor3_1
X_17667_ net442 _08309_ _08498_ _08500_ _08286_ VSS VSS VDD
+ VDD _08501_ sky130_fd_sc_hd__a311oi_1
X_17668_ _08238_ _08249_ VSS VSS VDD VDD _08502_ sky130_fd_sc_hd__nor2_1
X_17669_ _08312_ _08502_ _12093_ VSS VSS VDD VDD _08503_ sky130_fd_sc_hd__o21ai_0
X_17670_ net446 _08250_ VSS VSS VDD VDD _08504_ sky130_fd_sc_hd__nor2_1
X_17671_ net446 _08388_ _08266_ _08358_ _08504_ VSS VSS VDD
+ VDD _08505_ sky130_fd_sc_hd__a32oi_1
X_17672_ _08503_ _08505_ _08279_ VSS VSS VDD VDD _08506_ sky130_fd_sc_hd__a21oi_1
X_17673_ _08293_ _08501_ _08506_ VSS VSS VDD VDD _08507_ sky130_fd_sc_hd__or3_1
X_17674_ _08238_ net443 VSS VSS VDD VDD _08508_ sky130_fd_sc_hd__nand2_1
X_17675_ _08266_ _08389_ _08508_ VSS VSS VDD VDD _08509_ sky130_fd_sc_hd__nand3_1
X_17676_ _12116_ _08266_ _08509_ _08279_ VSS VSS VDD VDD _08510_
+ sky130_fd_sc_hd__o211ai_1
X_17677_ _12093_ net443 _08266_ VSS VSS VDD VDD _08511_ sky130_fd_sc_hd__o21ai_0
X_17678_ _12113_ net701 _08279_ VSS VSS VDD VDD _08512_ sky130_fd_sc_hd__a21oi_1
X_17679_ _08342_ _08511_ _08512_ VSS VSS VDD VDD _08513_ sky130_fd_sc_hd__o21ai_0
X_17680_ net441 _08510_ _08513_ VSS VSS VDD VDD _08514_ sky130_fd_sc_hd__nand3_1
X_17681_ _08507_ _08514_ _08422_ VSS VSS VDD VDD _08515_ sky130_fd_sc_hd__a21oi_1
X_17682_ _08250_ _08398_ _08424_ VSS VSS VDD VDD _08516_ sky130_fd_sc_hd__nor3_1
X_17683_ _12094_ _08266_ VSS VSS VDD VDD _08517_ sky130_fd_sc_hd__nand2_1
X_17684_ _08309_ _08517_ net442 VSS VSS VDD VDD _08518_ sky130_fd_sc_hd__a21oi_1
X_17685_ _08516_ _08518_ _08284_ VSS VSS VDD VDD _08519_ sky130_fd_sc_hd__o21ai_1
X_17686_ _08238_ _08432_ VSS VSS VDD VDD _08520_ sky130_fd_sc_hd__nand2_1
X_17687_ _12106_ _08268_ _08520_ _08293_ VSS VSS VDD VDD _08521_
+ sky130_fd_sc_hd__o211ai_1
X_17688_ _08342_ _08355_ _08266_ VSS VSS VDD VDD _08522_ sky130_fd_sc_hd__o21ai_1
X_17689_ _08361_ net443 _08290_ _08508_ VSS VSS VDD VDD _08523_
+ sky130_fd_sc_hd__o211ai_1
X_17690_ _12106_ _08250_ _08266_ VSS VSS VDD VDD _08524_ sky130_fd_sc_hd__a21oi_1
X_17691_ _12097_ net443 VSS VSS VDD VDD _08525_ sky130_fd_sc_hd__nand2_1
X_17692_ _08385_ _08451_ _08524_ _08525_ net441 VSS VSS VDD
+ VDD _08526_ sky130_fd_sc_hd__a221oi_1
X_17693_ net441 _08522_ _08523_ _08526_ _08286_ VSS VSS VDD
+ VDD _08527_ sky130_fd_sc_hd__a311oi_2
X_17694_ _08335_ _08330_ VSS VSS VDD VDD _08528_ sky130_fd_sc_hd__or2_4
X_17695_ _08286_ _08519_ _08521_ _08527_ _08528_ VSS VSS VDD
+ VDD _08529_ sky130_fd_sc_hd__a311oi_2
X_17696_ _12094_ _12097_ VSS VSS VDD VDD _08530_ sky130_fd_sc_hd__nor2_2
X_17697_ _08266_ _08530_ _08469_ VSS VSS VDD VDD _08531_ sky130_fd_sc_hd__a21oi_1
X_17698_ _12100_ net701 _08486_ net442 VSS VSS VDD VDD _08532_
+ sky130_fd_sc_hd__a211oi_1
X_17699_ net442 _08531_ _08532_ VSS VSS VDD VDD _08533_ sky130_fd_sc_hd__a21oi_1
X_17700_ _08249_ _08290_ VSS VSS VDD VDD _08534_ sky130_fd_sc_hd__nor2_4
X_17701_ _12097_ _08534_ VSS VSS VDD VDD _08535_ sky130_fd_sc_hd__nand2_1
X_17702_ _08250_ _08472_ _08499_ _08535_ _08285_ VSS VSS VDD
+ VDD _08536_ sky130_fd_sc_hd__o311ai_0
X_17703_ _12111_ _08266_ VSS VSS VDD VDD _08537_ sky130_fd_sc_hd__nand2_1
X_17704_ net446 _08244_ net443 _08266_ _08537_ VSS VSS VDD
+ VDD _08538_ sky130_fd_sc_hd__o41ai_1
X_17705_ net700 net444 VSS VSS VDD VDD _08539_ sky130_fd_sc_hd__nor2_1
X_17706_ _12120_ _08266_ _08539_ _08443_ _08284_ VSS VSS VDD
+ VDD _08540_ sky130_fd_sc_hd__o221ai_1
X_17707_ _08284_ _08538_ _08540_ _08279_ VSS VSS VDD VDD _08541_
+ sky130_fd_sc_hd__o211ai_2
X_17708_ _08367_ _08536_ _08541_ VSS VSS VDD VDD _08542_ sky130_fd_sc_hd__nand3_1
X_17709_ _08433_ _08533_ _08542_ VSS VSS VDD VDD _08543_ sky130_fd_sc_hd__a21oi_1
X_17710_ _12102_ _08266_ VSS VSS VDD VDD _08544_ sky130_fd_sc_hd__nor2_2
X_17711_ _08250_ _08424_ _08544_ VSS VSS VDD VDD _08545_ sky130_fd_sc_hd__nor3_1
X_17712_ _12106_ _08266_ VSS VSS VDD VDD _08546_ sky130_fd_sc_hd__nor2_1
X_17713_ net443 _08403_ _08546_ VSS VSS VDD VDD _08547_ sky130_fd_sc_hd__nor3_1
X_17714_ _08545_ _08547_ _08488_ VSS VSS VDD VDD _08548_ sky130_fd_sc_hd__o21ai_0
X_17715_ _12102_ _08250_ VSS VSS VDD VDD _08549_ sky130_fd_sc_hd__nor2_1
X_17716_ _08298_ _08549_ _08266_ VSS VSS VDD VDD _08550_ sky130_fd_sc_hd__o21ai_0
X_17717_ _08388_ _08524_ VSS VSS VDD VDD _08551_ sky130_fd_sc_hd__nand2_1
X_17718_ _08433_ _08550_ _08551_ VSS VSS VDD VDD _08552_ sky130_fd_sc_hd__nand3_1
X_17719_ _08250_ _08417_ _08461_ VSS VSS VDD VDD _08553_ sky130_fd_sc_hd__nand3_1
X_17720_ _08426_ _08472_ net443 VSS VSS VDD VDD _08554_ sky130_fd_sc_hd__o21ai_0
X_17721_ _12102_ _08290_ _08451_ VSS VSS VDD VDD _08555_ sky130_fd_sc_hd__a21oi_1
X_17722_ _08279_ _08293_ VSS VSS VDD VDD _08556_ sky130_fd_sc_hd__nand2_2
X_17723_ net443 _08555_ _08556_ _08355_ VSS VSS VDD VDD _08557_
+ sky130_fd_sc_hd__a211oi_1
X_17724_ _08285_ _08553_ _08554_ _08557_ VSS VSS VDD VDD _08558_
+ sky130_fd_sc_hd__a31oi_1
X_17725_ _08548_ _08552_ _08558_ _08336_ VSS VSS VDD VDD _08559_
+ sky130_fd_sc_hd__a31oi_1
X_17726_ _08515_ _08529_ _08543_ _08559_ VSS VSS VDD VDD _00066_
+ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_28_687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17728_ _12100_ _08266_ VSS VSS VDD VDD _08561_ sky130_fd_sc_hd__nor2_2
X_17729_ _12092_ net701 VSS VSS VDD VDD _08562_ sky130_fd_sc_hd__nor2_1
X_17730_ _08250_ _08561_ _08562_ VSS VSS VDD VDD _08563_ sky130_fd_sc_hd__nor3_1
X_17731_ _08250_ _08316_ _08461_ _08563_ VSS VSS VDD VDD _08564_
+ sky130_fd_sc_hd__a31oi_1
X_17732_ _12093_ _08290_ VSS VSS VDD VDD _08565_ sky130_fd_sc_hd__nand2_1
X_17733_ _12106_ net701 _08565_ net443 VSS VSS VDD VDD _08566_
+ sky130_fd_sc_hd__o211ai_1
X_17734_ net443 _08450_ _08403_ _08566_ net441 VSS VSS VDD
+ VDD _08567_ sky130_fd_sc_hd__o311ai_2
X_17735_ net441 _08564_ _08567_ VSS VSS VDD VDD _08568_ sky130_fd_sc_hd__o21ai_0
X_17736_ _08286_ _08367_ VSS VSS VDD VDD _08569_ sky130_fd_sc_hd__nand2_1
X_17737_ _08279_ _08367_ VSS VSS VDD VDD _08570_ sky130_fd_sc_hd__nand2_1
X_17738_ _08250_ net441 VSS VSS VDD VDD _08571_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_28_686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17740_ net516 net441 net444 net445 VSS VSS VDD VDD _08573_
+ sky130_fd_sc_hd__a211oi_1
X_17741_ net445 net441 _08388_ _08573_ VSS VSS VDD VDD _08574_
+ sky130_fd_sc_hd__a31oi_1
X_17742_ _08250_ net441 VSS VSS VDD VDD _08575_ sky130_fd_sc_hd__nand2_1
X_17743_ net445 net444 _08284_ VSS VSS VDD VDD _08576_ sky130_fd_sc_hd__nor3_1
X_17744_ _12093_ _08575_ _08576_ net701 _08571_ VSS VSS VDD
+ VDD _08577_ sky130_fd_sc_hd__a2111oi_0
X_17745_ net701 _08574_ _08577_ VSS VSS VDD VDD _08578_ sky130_fd_sc_hd__a21oi_1
X_17746_ _08244_ _08571_ _08578_ VSS VSS VDD VDD _08579_ sky130_fd_sc_hd__a21oi_1
X_17747_ _08568_ _08569_ _08570_ _08579_ VSS VSS VDD VDD _08580_
+ sky130_fd_sc_hd__o22a_1
X_17748_ net443 _08530_ _08343_ VSS VSS VDD VDD _08581_ sky130_fd_sc_hd__a21oi_1
X_17749_ net443 _08309_ net516 VSS VSS VDD VDD _08582_ sky130_fd_sc_hd__a21oi_1
X_17750_ _12092_ _08268_ _08352_ net446 _08286_ VSS VSS VDD
+ VDD _08583_ sky130_fd_sc_hd__o221ai_1
X_17751_ _08286_ _08455_ _08581_ _08582_ _08583_ VSS VSS VDD
+ VDD _08584_ sky130_fd_sc_hd__o32a_1
X_17752_ _12102_ _08290_ VSS VSS VDD VDD _08585_ sky130_fd_sc_hd__nor2_2
X_17753_ _08398_ _08585_ net443 VSS VSS VDD VDD _08586_ sky130_fd_sc_hd__o21ai_1
X_17754_ _08250_ _08410_ _08489_ VSS VSS VDD VDD _08587_ sky130_fd_sc_hd__nand3_1
X_17755_ _08286_ _08586_ _08587_ VSS VSS VDD VDD _08588_ sky130_fd_sc_hd__nand3_1
X_17756_ _08279_ _08551_ net441 VSS VSS VDD VDD _08589_ sky130_fd_sc_hd__a21oi_1
X_17757_ _08588_ _08589_ _08336_ VSS VSS VDD VDD _08590_ sky130_fd_sc_hd__a21oi_1
X_17758_ _08284_ _08584_ _08590_ VSS VSS VDD VDD _08591_ sky130_fd_sc_hd__o21ai_1
X_17759_ _08284_ _08539_ VSS VSS VDD VDD _08592_ sky130_fd_sc_hd__nor2_1
X_17760_ _08273_ _08565_ _08250_ VSS VSS VDD VDD _08593_ sky130_fd_sc_hd__a21o_1
X_17761_ _08314_ _08544_ _08250_ VSS VSS VDD VDD _08594_ sky130_fd_sc_hd__o21ai_0
X_17762_ _08593_ _08594_ net441 VSS VSS VDD VDD _08595_ sky130_fd_sc_hd__a21oi_1
X_17763_ _08268_ _08389_ _08592_ _08595_ _08286_ VSS VSS VDD
+ VDD _08596_ sky130_fd_sc_hd__a311oi_1
X_17764_ net516 _08250_ _08266_ VSS VSS VDD VDD _08597_ sky130_fd_sc_hd__nor3_2
X_17765_ _08266_ _08270_ _08597_ VSS VSS VDD VDD _08598_ sky130_fd_sc_hd__a21oi_1
X_17766_ _08250_ _08290_ VSS VSS VDD VDD _08599_ sky130_fd_sc_hd__nor2_1
X_17767_ _12100_ _08599_ VSS VSS VDD VDD _08600_ sky130_fd_sc_hd__nand2_1
X_17768_ net445 _08598_ _08600_ _08285_ VSS VSS VDD VDD _08601_
+ sky130_fd_sc_hd__o211ai_1
X_17769_ _08361_ _08406_ _08601_ VSS VSS VDD VDD _08602_ sky130_fd_sc_hd__a21oi_2
X_17770_ _08286_ _08284_ VSS VSS VDD VDD _08603_ sky130_fd_sc_hd__nand2_2
X_17771_ _08238_ _08410_ _08454_ _08266_ VSS VSS VDD VDD _08604_
+ sky130_fd_sc_hd__o22ai_1
X_17772_ _08603_ _08516_ _08604_ VSS VSS VDD VDD _08605_ sky130_fd_sc_hd__nor3_1
X_17773_ _08596_ _08602_ _08605_ _08477_ VSS VSS VDD VDD _08606_
+ sky130_fd_sc_hd__o31ai_1
X_17774_ net443 _08284_ VSS VSS VDD VDD _08607_ sky130_fd_sc_hd__nand2_1
X_17775_ _12094_ _08266_ _08398_ VSS VSS VDD VDD _08608_ sky130_fd_sc_hd__a21oi_1
X_17776_ _12102_ _08439_ _08597_ VSS VSS VDD VDD _08609_ sky130_fd_sc_hd__a21oi_2
X_17777_ _08607_ _08608_ _08609_ _08284_ _08286_ VSS VSS VDD
+ VDD _08610_ sky130_fd_sc_hd__o221ai_1
X_17778_ _08266_ _08530_ VSS VSS VDD VDD _08611_ sky130_fd_sc_hd__nand2_1
X_17779_ _12093_ _08266_ _08611_ net443 VSS VSS VDD VDD _08612_
+ sky130_fd_sc_hd__o211ai_1
X_17780_ net443 _08314_ _08426_ _08494_ _08612_ VSS VSS VDD
+ VDD _08613_ sky130_fd_sc_hd__o311ai_0
X_17781_ net442 _08309_ _08517_ VSS VSS VDD VDD _08614_ sky130_fd_sc_hd__nand3_1
X_17782_ net442 _08472_ _08561_ _08614_ VSS VSS VDD VDD _08615_
+ sky130_fd_sc_hd__o31ai_1
X_17783_ _08488_ _08615_ _08528_ VSS VSS VDD VDD _08616_ sky130_fd_sc_hd__a21oi_1
X_17784_ _08610_ _08613_ _08616_ VSS VSS VDD VDD _08617_ sky130_fd_sc_hd__nand3_1
X_17785_ _08580_ _08591_ _08606_ _08617_ VSS VSS VDD VDD _00067_
+ sky130_fd_sc_hd__nand4_1
X_17786_ _08250_ _08443_ VSS VSS VDD VDD _08618_ sky130_fd_sc_hd__nand2_1
X_17787_ _08499_ _08618_ _08388_ _08285_ VSS VSS VDD VDD _08619_
+ sky130_fd_sc_hd__o211ai_1
X_17788_ _12102_ _08266_ net444 VSS VSS VDD VDD _08620_ sky130_fd_sc_hd__a21oi_2
X_17789_ _08404_ _08620_ _08433_ VSS VSS VDD VDD _08621_ sky130_fd_sc_hd__o21ai_0
X_17790_ _08477_ _08619_ _08621_ VSS VSS VDD VDD _08622_ sky130_fd_sc_hd__nand3_1
X_17791_ _08284_ _08508_ VSS VSS VDD VDD _08623_ sky130_fd_sc_hd__nor2_1
X_17792_ _12092_ _08250_ _08284_ _08623_ VSS VSS VDD VDD _08624_
+ sky130_fd_sc_hd__a31oi_2
X_17793_ net700 _08250_ VSS VSS VDD VDD _08625_ sky130_fd_sc_hd__nor2_1
X_17794_ net516 _08575_ net445 VSS VSS VDD VDD _08626_ sky130_fd_sc_hd__a21oi_1
X_17795_ _08625_ _08626_ net701 VSS VSS VDD VDD _08627_ sky130_fd_sc_hd__o21ai_0
X_17796_ _08411_ _08571_ net445 VSS VSS VDD VDD _08628_ sky130_fd_sc_hd__o21ai_0
X_17797_ net701 _08624_ _08627_ _08628_ VSS VSS VDD VDD _08629_
+ sky130_fd_sc_hd__o211ai_1
X_17798_ _08250_ _08403_ _08499_ _08452_ _08284_ VSS VSS VDD
+ VDD _08630_ sky130_fd_sc_hd__o311ai_0
X_17799_ _08250_ _08426_ _08352_ _12106_ VSS VSS VDD VDD _08631_
+ sky130_fd_sc_hd__o22ai_1
X_17800_ _08293_ _08631_ _08336_ VSS VSS VDD VDD _08632_ sky130_fd_sc_hd__a21oi_1
X_17801_ _08630_ _08632_ _08286_ VSS VSS VDD VDD _08633_ sky130_fd_sc_hd__a21oi_1
X_17802_ _08622_ _08629_ _08633_ VSS VSS VDD VDD _08634_ sky130_fd_sc_hd__o21ai_1
X_17803_ _12093_ net443 _08525_ VSS VSS VDD VDD _08635_ sky130_fd_sc_hd__o21ai_0
X_17804_ net701 _08635_ _08295_ VSS VSS VDD VDD _08636_ sky130_fd_sc_hd__a21oi_1
X_17805_ _08249_ _08293_ _08487_ VSS VSS VDD VDD _08637_ sky130_fd_sc_hd__nor3_1
X_17806_ _08336_ _08636_ _08637_ _08286_ _08622_ VSS VSS VDD
+ VDD _08638_ sky130_fd_sc_hd__o311ai_2
X_17807_ _12092_ _08250_ _08301_ VSS VSS VDD VDD _08639_ sky130_fd_sc_hd__a21oi_1
X_17808_ _08266_ _08556_ _08639_ VSS VSS VDD VDD _08640_ sky130_fd_sc_hd__nor3_1
X_17809_ net446 _08488_ _08620_ _08640_ VSS VSS VDD VDD _08641_
+ sky130_fd_sc_hd__a31oi_1
X_17810_ _12093_ _08250_ _08266_ VSS VSS VDD VDD _08642_ sky130_fd_sc_hd__nand3_1
X_17811_ _12104_ net701 _08284_ VSS VSS VDD VDD _08643_ sky130_fd_sc_hd__a21oi_1
X_17812_ _08642_ _08643_ _08279_ VSS VSS VDD VDD _08644_ sky130_fd_sc_hd__a21oi_1
X_17813_ _08293_ _08347_ _08470_ _08620_ _08644_ VSS VSS VDD
+ VDD _08645_ sky130_fd_sc_hd__o41ai_1
X_17814_ _08293_ net701 _08238_ _08279_ VSS VSS VDD VDD _08646_
+ sky130_fd_sc_hd__o211ai_1
X_17815_ _08293_ net701 _08639_ _08646_ VSS VSS VDD VDD _08647_
+ sky130_fd_sc_hd__a31oi_1
X_17816_ _08488_ _08620_ VSS VSS VDD VDD _08648_ sky130_fd_sc_hd__nand2_1
X_17817_ net516 _08648_ VSS VSS VDD VDD _08649_ sky130_fd_sc_hd__nand2_1
X_17818_ _12102_ _08250_ net701 VSS VSS VDD VDD _08650_ sky130_fd_sc_hd__a21oi_1
X_17819_ _08488_ _08650_ VSS VSS VDD VDD _08651_ sky130_fd_sc_hd__nand2_1
X_17820_ net444 _08473_ _08556_ _08651_ _08244_ VSS VSS VDD
+ VDD _08652_ sky130_fd_sc_hd__o311ai_0
X_17821_ _08647_ _08649_ _08652_ VSS VSS VDD VDD _08653_ sky130_fd_sc_hd__o21ai_0
X_17822_ _08641_ _08645_ _08653_ _08330_ VSS VSS VDD VDD _08654_
+ sky130_fd_sc_hd__a31oi_2
X_17823_ _08443_ _08489_ VSS VSS VDD VDD _08655_ sky130_fd_sc_hd__nand2_1
X_17824_ net445 _08244_ _08290_ VSS VSS VDD VDD _08656_ sky130_fd_sc_hd__nor3_4
X_17825_ _08250_ _08412_ _08656_ VSS VSS VDD VDD _08657_ sky130_fd_sc_hd__nor3_1
X_17826_ _08250_ _08655_ _08657_ net441 VSS VSS VDD VDD _08658_
+ sky130_fd_sc_hd__a211oi_1
X_17827_ _12092_ _08250_ _08298_ VSS VSS VDD VDD _08659_ sky130_fd_sc_hd__o21bai_1
X_17828_ _08266_ _08659_ _08356_ VSS VSS VDD VDD _08660_ sky130_fd_sc_hd__a21oi_1
X_17829_ _08286_ _08658_ _08660_ VSS VSS VDD VDD _08661_ sky130_fd_sc_hd__nor3_1
X_17830_ _08250_ _08415_ _08429_ _08549_ VSS VSS VDD VDD _08662_
+ sky130_fd_sc_hd__a31oi_1
X_17831_ _08266_ _08436_ VSS VSS VDD VDD _08663_ sky130_fd_sc_hd__nor2_1
X_17832_ net441 _08662_ _08663_ _08345_ VSS VSS VDD VDD _08664_
+ sky130_fd_sc_hd__o22ai_1
X_17833_ _08279_ _08664_ _08330_ VSS VSS VDD VDD _08665_ sky130_fd_sc_hd__o21ai_0
X_17834_ _08661_ _08665_ _08365_ VSS VSS VDD VDD _08666_ sky130_fd_sc_hd__o21ai_1
X_17835_ _08634_ _08638_ _08654_ _08666_ VSS VSS VDD VDD _00068_
+ sky130_fd_sc_hd__o2bb2ai_4
X_17836_ _12100_ net701 _08489_ VSS VSS VDD VDD _08667_ sky130_fd_sc_hd__o21ai_0
X_17837_ _08250_ _08667_ VSS VSS VDD VDD _08668_ sky130_fd_sc_hd__nand2_1
X_17838_ net444 _08461_ _08565_ VSS VSS VDD VDD _08669_ sky130_fd_sc_hd__nand3_1
X_17839_ _08668_ _08669_ net441 VSS VSS VDD VDD _08670_ sky130_fd_sc_hd__a21oi_1
X_17840_ _08250_ _08371_ _08266_ _08498_ _08293_ VSS VSS VDD
+ VDD _08671_ sky130_fd_sc_hd__o311ai_4
X_17841_ _08279_ _08671_ VSS VSS VDD VDD _08672_ sky130_fd_sc_hd__nand2_1
X_17842_ _12097_ _08250_ _08266_ VSS VSS VDD VDD _08673_ sky130_fd_sc_hd__a21oi_1
X_17843_ _12106_ _08377_ VSS VSS VDD VDD _08674_ sky130_fd_sc_hd__nor2_1
X_17844_ _08308_ _08444_ _08611_ _08250_ net441 VSS VSS VDD
+ VDD _08675_ sky130_fd_sc_hd__o221ai_1
X_17845_ net441 _08673_ _08674_ _08675_ _08286_ VSS VSS VDD
+ VDD _08676_ sky130_fd_sc_hd__o311ai_1
X_17846_ _08670_ _08672_ _08393_ _08676_ VSS VSS VDD VDD _08677_
+ sky130_fd_sc_hd__o211ai_1
X_17847_ _12097_ _08250_ _08625_ VSS VSS VDD VDD _08678_ sky130_fd_sc_hd__a21oi_1
X_17848_ _08266_ _08678_ _08295_ VSS VSS VDD VDD _08679_ sky130_fd_sc_hd__o21bai_1
X_17849_ _08336_ _08286_ VSS VSS VDD VDD _08680_ sky130_fd_sc_hd__nor2_1
X_17850_ _08371_ _08341_ net441 VSS VSS VDD VDD _08681_ sky130_fd_sc_hd__a21oi_1
X_17851_ _08668_ _08681_ VSS VSS VDD VDD _08682_ sky130_fd_sc_hd__nand2_1
X_17852_ _08359_ _08415_ net443 VSS VSS VDD VDD _08683_ sky130_fd_sc_hd__a21oi_1
X_17853_ net445 _08341_ _08683_ net441 VSS VSS VDD VDD _08684_
+ sky130_fd_sc_hd__a211oi_1
X_17854_ _12092_ net701 _08489_ VSS VSS VDD VDD _08685_ sky130_fd_sc_hd__o21ai_0
X_17855_ _08361_ _08599_ _08685_ _08250_ _08284_ VSS VSS VDD
+ VDD _08686_ sky130_fd_sc_hd__a221oi_2
X_17856_ _08570_ _08684_ _08686_ VSS VSS VDD VDD _08687_ sky130_fd_sc_hd__nor3_1
X_17857_ _08679_ _08680_ _08682_ _08687_ VSS VSS VDD VDD _08688_
+ sky130_fd_sc_hd__a31oi_1
X_17858_ _08284_ _08290_ VSS VSS VDD VDD _08689_ sky130_fd_sc_hd__nor2_1
X_17859_ _08284_ _08312_ _08689_ VSS VSS VDD VDD _08690_ sky130_fd_sc_hd__a21oi_1
X_17860_ _08266_ _08285_ net445 VSS VSS VDD VDD _08691_ sky130_fd_sc_hd__o21ai_0
X_17861_ _08244_ _08377_ _08690_ _08691_ VSS VSS VDD VDD _08692_
+ sky130_fd_sc_hd__nand4_1
X_17862_ _08433_ _08454_ net701 VSS VSS VDD VDD _08693_ sky130_fd_sc_hd__a21oi_1
X_17863_ _08341_ _08693_ net445 VSS VSS VDD VDD _08694_ sky130_fd_sc_hd__o21ai_0
X_17864_ net516 _08341_ _08534_ _12100_ VSS VSS VDD VDD _08695_
+ sky130_fd_sc_hd__a22o_1
X_17865_ _08284_ _08695_ _08569_ VSS VSS VDD VDD _08696_ sky130_fd_sc_hd__a21oi_1
X_17866_ _12102_ _08406_ _08448_ _08293_ _08349_ VSS VSS VDD
+ VDD _08697_ sky130_fd_sc_hd__a2111oi_1
X_17867_ _08250_ _08309_ _08307_ VSS VSS VDD VDD _08698_ sky130_fd_sc_hd__nand3_1
X_17868_ _08405_ _08698_ _08284_ VSS VSS VDD VDD _08699_ sky130_fd_sc_hd__a21oi_1
X_17869_ _08279_ _08422_ _08697_ _08699_ VSS VSS VDD VDD _08700_
+ sky130_fd_sc_hd__nor4_1
X_17870_ _08692_ _08694_ _08696_ _08700_ VSS VSS VDD VDD _08701_
+ sky130_fd_sc_hd__a31oi_1
X_17871_ _08244_ _08534_ _08284_ VSS VSS VDD VDD _08702_ sky130_fd_sc_hd__a21oi_1
X_17872_ net443 _08656_ _08429_ VSS VSS VDD VDD _08703_ sky130_fd_sc_hd__o21ai_0
X_17873_ _08586_ _08702_ _08703_ _08284_ VSS VSS VDD VDD _08704_
+ sky130_fd_sc_hd__a22o_1
X_17874_ net444 _08544_ _08656_ VSS VSS VDD VDD _08705_ sky130_fd_sc_hd__nor3_1
X_17875_ net444 _08309_ _08461_ _08705_ VSS VSS VDD VDD _08706_
+ sky130_fd_sc_hd__a31oi_1
X_17876_ net516 _08341_ VSS VSS VDD VDD _08707_ sky130_fd_sc_hd__nor2_1
X_17877_ _08284_ _08347_ _08707_ VSS VSS VDD VDD _08708_ sky130_fd_sc_hd__nor3_1
X_17878_ _08284_ _08706_ _08708_ _08279_ _08336_ VSS VSS VDD
+ VDD _08709_ sky130_fd_sc_hd__a2111oi_0
X_17879_ _08279_ _08477_ _08704_ _08709_ VSS VSS VDD VDD _08710_
+ sky130_fd_sc_hd__a31oi_1
X_17880_ _08677_ _08688_ _08701_ _08710_ VSS VSS VDD VDD _00069_
+ sky130_fd_sc_hd__nand4_1
X_17881_ net701 _08530_ _08656_ _08250_ VSS VSS VDD VDD _08711_
+ sky130_fd_sc_hd__a211oi_1
X_17882_ _08250_ _08358_ _08565_ _08711_ VSS VSS VDD VDD _08712_
+ sky130_fd_sc_hd__a31oi_1
X_17883_ _08404_ _08656_ _08250_ VSS VSS VDD VDD _08713_ sky130_fd_sc_hd__o21ai_0
X_17884_ _08593_ _08713_ _08279_ VSS VSS VDD VDD _08714_ sky130_fd_sc_hd__a21oi_1
X_17885_ _08279_ _08712_ _08714_ VSS VSS VDD VDD _08715_ sky130_fd_sc_hd__a21oi_1
X_17886_ _08238_ _08388_ net701 VSS VSS VDD VDD _08716_ sky130_fd_sc_hd__a21oi_1
X_17887_ _12111_ net701 _08286_ VSS VSS VDD VDD _08717_ sky130_fd_sc_hd__o21ai_0
X_17888_ _12093_ _08250_ _08290_ VSS VSS VDD VDD _08718_ sky130_fd_sc_hd__o21ai_0
X_17889_ _08238_ net516 _08250_ _08718_ VSS VSS VDD VDD _08719_
+ sky130_fd_sc_hd__a31oi_1
X_17890_ _08286_ _08353_ _08716_ _08717_ _08719_ VSS VSS VDD
+ VDD _08720_ sky130_fd_sc_hd__o32ai_1
X_17891_ net441 _08720_ _08367_ VSS VSS VDD VDD _08721_ sky130_fd_sc_hd__o21ai_0
X_17892_ net441 _08715_ _08721_ VSS VSS VDD VDD _08722_ sky130_fd_sc_hd__a21oi_1
X_17893_ net446 net516 net443 _08431_ VSS VSS VDD VDD _08723_
+ sky130_fd_sc_hd__a31oi_1
X_17894_ _08238_ _08410_ _08723_ _12106_ _08385_ VSS VSS VDD
+ VDD _08724_ sky130_fd_sc_hd__o221ai_1
X_17895_ net516 net441 VSS VSS VDD VDD _08725_ sky130_fd_sc_hd__nand2_1
X_17896_ net441 _08546_ net444 VSS VSS VDD VDD _08726_ sky130_fd_sc_hd__o21ai_0
X_17897_ _08725_ _08726_ net445 VSS VSS VDD VDD _08727_ sky130_fd_sc_hd__a21oi_1
X_17898_ _08625_ _08689_ _08724_ _08284_ _08727_ VSS VSS VDD
+ VDD _08728_ sky130_fd_sc_hd__a221oi_1
X_17899_ _08336_ _08279_ _08728_ VSS VSS VDD VDD _08729_ sky130_fd_sc_hd__nor3_1
X_17900_ net443 _08314_ _08426_ _08268_ _12093_ VSS VSS VDD
+ VDD _08730_ sky130_fd_sc_hd__o32ai_1
X_17901_ _12102_ _08250_ _08266_ VSS VSS VDD VDD _08731_ sky130_fd_sc_hd__a21oi_1
X_17902_ _12110_ _08266_ _08508_ _08731_ _08284_ VSS VSS VDD
+ VDD _08732_ sky130_fd_sc_hd__a221oi_1
X_17903_ _08284_ _08730_ _08732_ _08528_ _08279_ VSS VSS VDD
+ VDD _08733_ sky130_fd_sc_hd__a2111oi_1
X_17904_ _12102_ _08284_ _08266_ VSS VSS VDD VDD _08734_ sky130_fd_sc_hd__o21ai_0
X_17905_ _12093_ net441 net701 VSS VSS VDD VDD _08735_ sky130_fd_sc_hd__nand3_1
X_17906_ net446 _08284_ _08411_ net444 VSS VSS VDD VDD _08736_
+ sky130_fd_sc_hd__a211oi_1
X_17907_ net444 _08734_ _08735_ _08736_ VSS VSS VDD VDD _08737_
+ sky130_fd_sc_hd__a31oi_1
X_17908_ net441 _08316_ _08680_ VSS VSS VDD VDD _08738_ sky130_fd_sc_hd__o21ai_1
X_17909_ _08486_ _08544_ _08250_ VSS VSS VDD VDD _08739_ sky130_fd_sc_hd__o21ai_0
X_17910_ net442 _08517_ _08489_ VSS VSS VDD VDD _08740_ sky130_fd_sc_hd__nand3_1
X_17911_ _08494_ _08739_ _08740_ VSS VSS VDD VDD _08741_ sky130_fd_sc_hd__nand3_1
X_17912_ _08266_ _08530_ net443 VSS VSS VDD VDD _08742_ sky130_fd_sc_hd__a21oi_1
X_17913_ _08250_ _08431_ _08585_ VSS VSS VDD VDD _08743_ sky130_fd_sc_hd__nor3_1
X_17914_ _08361_ _08352_ _08742_ _08743_ _08488_ VSS VSS VDD
+ VDD _08744_ sky130_fd_sc_hd__o221ai_1
X_17915_ _08238_ _08250_ _08460_ VSS VSS VDD VDD _08745_ sky130_fd_sc_hd__o21ai_1
X_17916_ _12109_ _12118_ _08266_ _08285_ _08745_ VSS VSS VDD
+ VDD _08746_ sky130_fd_sc_hd__o311ai_2
X_17917_ _08250_ _08603_ _08499_ _08585_ VSS VSS VDD VDD _08747_
+ sky130_fd_sc_hd__nor4_1
X_17918_ _12094_ _08534_ _08433_ _08747_ _08422_ VSS VSS VDD
+ VDD _08748_ sky130_fd_sc_hd__a311oi_1
X_17919_ _08741_ _08744_ _08746_ _08748_ VSS VSS VDD VDD _08749_
+ sky130_fd_sc_hd__nand4_1
X_17920_ net441 _08522_ VSS VSS VDD VDD _08750_ sky130_fd_sc_hd__nand2_1
X_17921_ _12100_ net701 _08585_ VSS VSS VDD VDD _08751_ sky130_fd_sc_hd__a21oi_1
X_17922_ _08238_ _08268_ _08751_ net443 _08284_ VSS VSS VDD
+ VDD _08752_ sky130_fd_sc_hd__o221ai_1
X_17923_ _08279_ _08393_ _08750_ _08752_ VSS VSS VDD VDD _08753_
+ sky130_fd_sc_hd__nand4_1
X_17924_ _08737_ _08738_ _08749_ _08753_ VSS VSS VDD VDD _08754_
+ sky130_fd_sc_hd__o211ai_1
X_17925_ _08722_ _08729_ _08733_ _08754_ VSS VSS VDD VDD _00070_
+ sky130_fd_sc_hd__nor4_1
X_17926_ _12106_ _08268_ _08439_ _12093_ _08495_ VSS VSS VDD
+ VDD _08755_ sky130_fd_sc_hd__o221ai_1
X_17927_ _08365_ _08293_ _08755_ VSS VSS VDD VDD _08756_ sky130_fd_sc_hd__nor3_1
X_17928_ net444 _08358_ _08489_ VSS VSS VDD VDD _08757_ sky130_fd_sc_hd__and3_1
X_17929_ _08250_ _08555_ _08757_ _08365_ _08284_ VSS VSS VDD
+ VDD _08758_ sky130_fd_sc_hd__a2111oi_0
X_17930_ _08406_ _08689_ _08244_ VSS VSS VDD VDD _08759_ sky130_fd_sc_hd__o21ai_0
X_17931_ net444 _08284_ VSS VSS VDD VDD _08760_ sky130_fd_sc_hd__nor2_1
X_17932_ _12093_ _08341_ _08571_ _08656_ _08760_ VSS VSS VDD
+ VDD _08761_ sky130_fd_sc_hd__a221oi_1
X_17933_ net445 _08759_ _08761_ VSS VSS VDD VDD _08762_ sky130_fd_sc_hd__o21ai_0
X_17934_ _08335_ _08762_ VSS VSS VDD VDD _08763_ sky130_fd_sc_hd__nor2_1
X_17935_ _08756_ _08758_ _08763_ VSS VSS VDD VDD _08764_ sky130_fd_sc_hd__nor3_1
X_17936_ net442 _08431_ _08585_ VSS VSS VDD VDD _08765_ sky130_fd_sc_hd__nor3_1
X_17937_ _08268_ _08530_ _08309_ VSS VSS VDD VDD _08766_ sky130_fd_sc_hd__o21ai_0
X_17938_ _08765_ _08766_ _08286_ VSS VSS VDD VDD _08767_ sky130_fd_sc_hd__o21ai_0
X_17939_ _08286_ _08412_ VSS VSS VDD VDD _08768_ sky130_fd_sc_hd__nor2_1
X_17940_ _08745_ _08768_ VSS VSS VDD VDD _08769_ sky130_fd_sc_hd__nand2_1
X_17941_ _08767_ _08769_ _08293_ VSS VSS VDD VDD _08770_ sky130_fd_sc_hd__a21oi_1
X_17942_ _12092_ _08250_ _08404_ _08618_ _08279_ VSS VSS VDD
+ VDD _08771_ sky130_fd_sc_hd__o221ai_1
X_17943_ _08371_ _08266_ _08498_ VSS VSS VDD VDD _08772_ sky130_fd_sc_hd__o21ai_1
X_17944_ _08250_ _08279_ _08472_ _08473_ VSS VSS VDD VDD _08773_
+ sky130_fd_sc_hd__nor4_1
X_17945_ _08250_ _08286_ _08772_ _08773_ VSS VSS VDD VDD _08774_
+ sky130_fd_sc_hd__a31oi_1
X_17946_ _08293_ _08771_ _08774_ VSS VSS VDD VDD _08775_ sky130_fd_sc_hd__and3_1
X_17947_ _12093_ _08249_ net701 VSS VSS VDD VDD _08776_ sky130_fd_sc_hd__o21ai_0
X_17948_ _12102_ _08249_ _08776_ VSS VSS VDD VDD _08777_ sky130_fd_sc_hd__a21oi_1
X_17949_ _12118_ net701 VSS VSS VDD VDD _08778_ sky130_fd_sc_hd__nor2_1
X_17950_ _08308_ _08461_ _08250_ VSS VSS VDD VDD _08779_ sky130_fd_sc_hd__a21oi_1
X_17951_ _08479_ _08779_ _08488_ VSS VSS VDD VDD _08780_ sky130_fd_sc_hd__o21ai_1
X_17952_ _12094_ _08250_ net701 VSS VSS VDD VDD _08781_ sky130_fd_sc_hd__nand3_1
X_17953_ _12104_ _08290_ _08781_ VSS VSS VDD VDD _08782_ sky130_fd_sc_hd__o21ai_1
X_17954_ _12097_ _08250_ VSS VSS VDD VDD _08783_ sky130_fd_sc_hd__nor2_1
X_17955_ _08502_ _08783_ _08266_ VSS VSS VDD VDD _08784_ sky130_fd_sc_hd__o21ai_0
X_17956_ _08388_ _08312_ _08603_ VSS VSS VDD VDD _08785_ sky130_fd_sc_hd__a21oi_1
X_17957_ _08285_ _08782_ _08784_ _08785_ _08335_ VSS VSS VDD
+ VDD _08786_ sky130_fd_sc_hd__a221oi_2
X_17958_ _08556_ _08777_ _08778_ _08780_ _08786_ VSS VSS VDD
+ VDD _08787_ sky130_fd_sc_hd__o311ai_4
X_17959_ _08365_ _08770_ _08775_ _08787_ _08330_ VSS VSS VDD
+ VDD _08788_ sky130_fd_sc_hd__o311ai_4
X_17960_ _08534_ _08597_ _08238_ VSS VSS VDD VDD _08789_ sky130_fd_sc_hd__o21ai_0
X_17961_ _08352_ _08358_ _08238_ VSS VSS VDD VDD _08790_ sky130_fd_sc_hd__a21oi_1
X_17962_ _08347_ _08790_ _08293_ VSS VSS VDD VDD _08791_ sky130_fd_sc_hd__o21ai_0
X_17963_ _08244_ _08268_ _08316_ VSS VSS VDD VDD _08792_ sky130_fd_sc_hd__o21ai_0
X_17964_ _08284_ _08792_ VSS VSS VDD VDD _08793_ sky130_fd_sc_hd__nand2_1
X_17965_ _08789_ _08791_ _08793_ _08528_ VSS VSS VDD VDD _08794_
+ sky130_fd_sc_hd__a31oi_1
X_17966_ _08244_ _08534_ _08426_ VSS VSS VDD VDD _08795_ sky130_fd_sc_hd__a21oi_1
X_17967_ _12092_ _08599_ VSS VSS VDD VDD _08796_ sky130_fd_sc_hd__nand2_1
X_17968_ net446 _08795_ _08796_ _08284_ _08495_ VSS VSS VDD
+ VDD _08797_ sky130_fd_sc_hd__o2111ai_1
X_17969_ _12102_ _08377_ _08655_ _08250_ net441 VSS VSS VDD
+ VDD _08798_ sky130_fd_sc_hd__o221ai_1
X_17970_ _08797_ _08798_ _08336_ VSS VSS VDD VDD _08799_ sky130_fd_sc_hd__a21oi_1
X_17971_ _08794_ _08799_ _08286_ VSS VSS VDD VDD _08800_ sky130_fd_sc_hd__o21ai_1
X_17972_ _08330_ _08286_ _08764_ _08788_ _08800_ VSS VSS VDD
+ VDD _00071_ sky130_fd_sc_hd__o311ai_4
X_17973_ sa11_sr\[7\] sa21_sr\[7\] VSS VSS VDD VDD _08801_
+ sky130_fd_sc_hd__xnor2_2
X_17974_ sa21_sr\[1\] sa30_sub\[1\] sa01_sr\[1\] VSS VSS VDD
+ VDD _08802_ sky130_fd_sc_hd__xor3_1
X_17975_ _06489_ _08801_ _08802_ VSS VSS VDD VDD _08803_ sky130_fd_sc_hd__xnor3_1
X_17976_ text_in_r\[81\] _08803_ net490 VSS VSS VDD VDD _08804_
+ sky130_fd_sc_hd__mux2i_4
X_17977_ u0.w\[1\]\[17\] _08804_ VSS VSS VDD VDD _08805_ sky130_fd_sc_hd__xor2_4
X_17978_ net440 VSS VSS VDD VDD _08806_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_28_685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17981_ sa01_sr\[0\] sa30_sub\[0\] VSS VSS VDD VDD _08808_
+ sky130_fd_sc_hd__xor2_1
X_17982_ sa21_sr\[0\] _08801_ _08808_ VSS VSS VDD VDD _08809_
+ sky130_fd_sc_hd__xnor3_1
X_17983_ text_in_r\[80\] _08809_ net490 VSS VSS VDD VDD _08810_
+ sky130_fd_sc_hd__mux2i_4
X_17984_ u0.w\[1\]\[16\] _08810_ VSS VSS VDD VDD _08811_ sky130_fd_sc_hd__xor2_4
X_17985_ net543 VSS VSS VDD VDD _08812_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_28_683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_17988_ sa21_sr\[1\] sa21_sr\[2\] sa01_sr\[2\] VSS VSS VDD
+ VDD _08814_ sky130_fd_sc_hd__xnor3_1
X_17989_ _06497_ _08814_ VSS VSS VDD VDD _08815_ sky130_fd_sc_hd__xor2_1
X_17990_ text_in_r\[82\] _08815_ net490 VSS VSS VDD VDD _08816_
+ sky130_fd_sc_hd__mux2i_4
X_17991_ _08816_ u0.w\[1\]\[18\] VSS VSS VDD VDD _08817_ sky130_fd_sc_hd__xnor2_4
X_17992_ net439 VSS VSS VDD VDD _08818_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_28_681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18000_ sa21_sr\[4\] sa30_sub\[5\] sa01_sr\[5\] VSS VSS VDD
+ VDD _08823_ sky130_fd_sc_hd__xnor3_4
X_18001_ sa11_sr\[4\] sa21_sr\[5\] VSS VSS VDD VDD _08824_
+ sky130_fd_sc_hd__xor2_1
X_18002_ _08823_ _08824_ VSS VSS VDD VDD _08825_ sky130_fd_sc_hd__xnor2_1
X_18003_ text_in_r\[85\] _08825_ net512 VSS VSS VDD VDD _08826_
+ sky130_fd_sc_hd__mux2i_4
X_18004_ u0.w\[1\]\[21\] _08826_ VSS VSS VDD VDD _08827_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_27_674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18006_ net492 u0.w\[1\]\[19\] VSS VSS VDD VDD _08829_ sky130_fd_sc_hd__nor2b_1
X_18007_ u0.w\[1\]\[19\] net492 VSS VSS VDD VDD _08830_ sky130_fd_sc_hd__nor2_1
X_18008_ sa21_sr\[2\] sa30_sub\[3\] sa21_sr\[7\] VSS VSS VDD
+ VDD _08831_ sky130_fd_sc_hd__xnor3_1
X_18009_ sa21_sr\[3\] sa01_sr\[3\] VSS VSS VDD VDD _08832_
+ sky130_fd_sc_hd__xnor2_1
X_18010_ _06528_ _08831_ _08832_ VSS VSS VDD VDD _08833_ sky130_fd_sc_hd__xnor3_1
X_18011_ _08829_ _08830_ _08833_ VSS VSS VDD VDD _08834_ sky130_fd_sc_hd__mux2_2
X_18012_ u0.w\[1\]\[19\] net492 VSS VSS VDD VDD _08835_ sky130_fd_sc_hd__nand2_1
X_18013_ u0.w\[1\]\[19\] net492 text_in_r\[83\] VSS VSS VDD
+ VDD _08836_ sky130_fd_sc_hd__nand3b_1
X_18014_ text_in_r\[83\] _08835_ _08836_ VSS VSS VDD VDD _08837_
+ sky130_fd_sc_hd__o21ai_4
X_18015_ _08834_ _08837_ VSS VSS VDD VDD _08838_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_27_673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18017_ net549 _08812_ _08838_ VSS VSS VDD VDD _08840_ sky130_fd_sc_hd__nor3_4
XTAP_TAPCELL_ROW_27_672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18019_ _08837_ _08834_ VSS VSS VDD VDD _08842_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_27_671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18021_ _12126_ net749 net438 VSS VSS VDD VDD _08844_ sky130_fd_sc_hd__o21ai_0
X_18022_ sa21_sr\[3\] sa30_sub\[4\] VSS VSS VDD VDD _08845_
+ sky130_fd_sc_hd__xnor2_1
X_18023_ sa11_sr\[3\] sa21_sr\[4\] sa01_sr\[4\] VSS VSS VDD
+ VDD _08846_ sky130_fd_sc_hd__xnor3_1
X_18024_ _08801_ _08845_ _08846_ VSS VSS VDD VDD _08847_ sky130_fd_sc_hd__xnor3_1
X_18025_ text_in_r\[84\] _08847_ net490 VSS VSS VDD VDD _08848_
+ sky130_fd_sc_hd__mux2i_4
X_18026_ u0.w\[1\]\[20\] _08848_ VSS VSS VDD VDD _08849_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_27_670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18028_ _08840_ _08844_ net618 VSS VSS VDD VDD _08851_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_27_669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18030_ _08818_ _08842_ VSS VSS VDD VDD _08853_ sky130_fd_sc_hd__nand2_4
X_18031_ _12132_ _08853_ VSS VSS VDD VDD _08854_ sky130_fd_sc_hd__nor2_1
X_18032_ _12126_ _08838_ VSS VSS VDD VDD _08855_ sky130_fd_sc_hd__nor2_2
X_18033_ net549 _08812_ _08842_ VSS VSS VDD VDD _08856_ sky130_fd_sc_hd__nor3_4
XTAP_TAPCELL_ROW_27_668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18035_ net438 _08842_ VSS VSS VDD VDD _08858_ sky130_fd_sc_hd__nor2_4
X_18036_ _12134_ _08858_ VSS VSS VDD VDD _08859_ sky130_fd_sc_hd__nand2_1
X_18037_ u0.w\[1\]\[20\] _08848_ VSS VSS VDD VDD _08860_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_27_667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18039_ _08818_ _08855_ _08856_ _08859_ net617 VSS VSS VDD
+ VDD _08862_ sky130_fd_sc_hd__o311ai_0
X_18040_ _08851_ _08854_ _08862_ VSS VSS VDD VDD _08863_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_27_666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18045_ _12124_ _08838_ VSS VSS VDD VDD _08868_ sky130_fd_sc_hd__nand2_1
X_18046_ net438 _08868_ VSS VSS VDD VDD _08869_ sky130_fd_sc_hd__nand2_1
X_18047_ _08840_ _08869_ VSS VSS VDD VDD _08870_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_27_662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18050_ _12126_ _12129_ VSS VSS VDD VDD _08873_ sky130_fd_sc_hd__nor2_1
X_18051_ _08812_ _08842_ VSS VSS VDD VDD _08874_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_27_660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18053_ net749 _08873_ _08874_ net438 VSS VSS VDD VDD _08876_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_27_659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18055_ _08870_ _08876_ net617 VSS VSS VDD VDD _08878_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_27_658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18061_ _12125_ _08818_ VSS VSS VDD VDD _08884_ sky130_fd_sc_hd__nand2_2
X_18062_ _12145_ net749 VSS VSS VDD VDD _08885_ sky130_fd_sc_hd__nor2_1
X_18063_ net749 _08884_ _08885_ VSS VSS VDD VDD _08886_ sky130_fd_sc_hd__a21oi_1
X_18064_ net618 _08886_ _08827_ VSS VSS VDD VDD _08887_ sky130_fd_sc_hd__a21oi_1
X_18065_ sa21_sr\[6\] net691 VSS VSS VDD VDD _08888_ sky130_fd_sc_hd__xnor2_2
X_18066_ sa01_sr\[7\] sa11_sr\[6\] sa21_sr\[7\] VSS VSS VDD
+ VDD _08889_ sky130_fd_sc_hd__xnor3_1
X_18067_ _08888_ _08889_ VSS VSS VDD VDD _08890_ sky130_fd_sc_hd__xor2_2
X_18068_ text_in_r\[87\] _08890_ net512 VSS VSS VDD VDD _08891_
+ sky130_fd_sc_hd__mux2i_4
X_18069_ u0.w\[1\]\[23\] _08891_ VSS VSS VDD VDD _08892_ sky130_fd_sc_hd__xnor2_4
X_18070_ sa21_sr\[5\] sa01_sr\[6\] VSS VSS VDD VDD _08893_
+ sky130_fd_sc_hd__xor2_1
X_18071_ _06596_ _08893_ VSS VSS VDD VDD _08894_ sky130_fd_sc_hd__xnor2_1
X_18072_ text_in_r\[86\] _08894_ net490 VSS VSS VDD VDD _08895_
+ sky130_fd_sc_hd__mux2i_4
X_18073_ u0.w\[1\]\[22\] _08895_ VSS VSS VDD VDD _08896_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_26_653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18075_ _08892_ _08896_ VSS VSS VDD VDD _08898_ sky130_fd_sc_hd__nand2_1
X_18076_ _08827_ _08863_ _08878_ _08887_ _08898_ VSS VSS VDD
+ VDD _08899_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_26_652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18078_ _08805_ _08842_ VSS VSS VDD VDD _08901_ sky130_fd_sc_hd__nand2_2
X_18079_ _08812_ _08838_ VSS VSS VDD VDD _08902_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_26_651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18081_ _12132_ _08842_ VSS VSS VDD VDD _08904_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_26_650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18083_ _12125_ _08838_ VSS VSS VDD VDD _08906_ sky130_fd_sc_hd__nor2_2
X_18084_ net438 _08904_ _08906_ VSS VSS VDD VDD _08907_ sky130_fd_sc_hd__nor3_1
X_18085_ net438 _08901_ _08902_ _08907_ VSS VSS VDD VDD _08908_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_26_649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18087_ net549 net540 _08838_ VSS VSS VDD VDD _08910_ sky130_fd_sc_hd__o21ai_2
X_18088_ _12129_ _08838_ VSS VSS VDD VDD _08911_ sky130_fd_sc_hd__nor2_2
X_18089_ net540 _08858_ _08910_ net438 _08911_ VSS VSS VDD
+ VDD _08912_ sky130_fd_sc_hd__a221o_1
X_18090_ _08827_ _08912_ VSS VSS VDD VDD _08913_ sky130_fd_sc_hd__nor2_1
X_18091_ _08827_ _08908_ _08913_ VSS VSS VDD VDD _08914_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_26_648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18093_ u0.w\[1\]\[23\] _08891_ VSS VSS VDD VDD _08916_ sky130_fd_sc_hd__xor2_4
X_18094_ _08916_ _08896_ VSS VSS VDD VDD _08917_ sky130_fd_sc_hd__nor2_4
X_18095_ net617 _08917_ VSS VSS VDD VDD _08918_ sky130_fd_sc_hd__nand2_1
X_18096_ net545 _08818_ VSS VSS VDD VDD _08919_ sky130_fd_sc_hd__nor2_4
X_18097_ net440 net541 _08919_ VSS VSS VDD VDD _08920_ sky130_fd_sc_hd__a21oi_1
X_18098_ net749 _08920_ VSS VSS VDD VDD _08921_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_26_647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18100_ _08806_ _08812_ VSS VSS VDD VDD _08923_ sky130_fd_sc_hd__nand2_2
X_18101_ net749 _08923_ VSS VSS VDD VDD _08924_ sky130_fd_sc_hd__nand2_1
X_18102_ _12124_ _08838_ VSS VSS VDD VDD _08925_ sky130_fd_sc_hd__nand2b_1
X_18103_ _12125_ _08842_ VSS VSS VDD VDD _08926_ sky130_fd_sc_hd__and2_2
X_18104_ _08818_ _08904_ _08926_ VSS VSS VDD VDD _08927_ sky130_fd_sc_hd__nor3_1
X_18105_ _08818_ _08924_ _08925_ net618 _08927_ VSS VSS VDD
+ VDD _08928_ sky130_fd_sc_hd__a311oi_1
X_18106_ net618 _08921_ _08928_ VSS VSS VDD VDD _08929_ sky130_fd_sc_hd__a21oi_1
X_18107_ u0.w\[1\]\[21\] _08826_ VSS VSS VDD VDD _08930_ sky130_fd_sc_hd__xor2_4
X_18108_ _08892_ _08930_ VSS VSS VDD VDD _08931_ sky130_fd_sc_hd__nor2_2
X_18109_ _08896_ _08931_ VSS VSS VDD VDD _08932_ sky130_fd_sc_hd__nand2_1
X_18110_ _08812_ net438 VSS VSS VDD VDD _08933_ sky130_fd_sc_hd__nor2_1
X_18111_ net440 _08838_ VSS VSS VDD VDD _08934_ sky130_fd_sc_hd__nand2_4
X_18112_ net439 _08838_ VSS VSS VDD VDD _08935_ sky130_fd_sc_hd__nand2_8
X_18113_ u0.w\[1\]\[22\] _08895_ VSS VSS VDD VDD _08936_ sky130_fd_sc_hd__xnor2_4
X_18114_ _12129_ net618 _08935_ _08931_ _08936_ VSS VSS VDD
+ VDD _08937_ sky130_fd_sc_hd__o311ai_1
X_18115_ net617 _08933_ _08934_ _08937_ VSS VSS VDD VDD _08938_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_26_646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18117_ _12138_ _08842_ VSS VSS VDD VDD _08940_ sky130_fd_sc_hd__nor2_1
X_18118_ _08806_ _08842_ VSS VSS VDD VDD _08941_ sky130_fd_sc_hd__nand2_4
X_18119_ _08940_ _08818_ _08941_ VSS VSS VDD VDD _08942_ sky130_fd_sc_hd__nand3b_1
X_18120_ _08818_ _08842_ VSS VSS VDD VDD _08943_ sky130_fd_sc_hd__nor2_4
X_18121_ _12125_ _08943_ VSS VSS VDD VDD _08944_ sky130_fd_sc_hd__nand2_1
X_18122_ _08812_ _08842_ VSS VSS VDD VDD _08945_ sky130_fd_sc_hd__nand2_4
X_18123_ net618 _08942_ _08944_ _08945_ VSS VSS VDD VDD _08946_
+ sky130_fd_sc_hd__nand4_1
X_18124_ _12125_ _08838_ VSS VSS VDD VDD _08947_ sky130_fd_sc_hd__nand2_4
X_18125_ _12134_ _08842_ VSS VSS VDD VDD _08948_ sky130_fd_sc_hd__nand2_2
X_18126_ net438 _08947_ _08948_ VSS VSS VDD VDD _08949_ sky130_fd_sc_hd__and3_1
X_18127_ _12129_ _08853_ VSS VSS VDD VDD _08950_ sky130_fd_sc_hd__nor2_1
X_18128_ _08930_ _08917_ VSS VSS VDD VDD _08951_ sky130_fd_sc_hd__nand2_2
X_18129_ net617 _08912_ _08949_ _08950_ _08951_ VSS VSS VDD
+ VDD _08952_ sky130_fd_sc_hd__a2111oi_0
X_18130_ _12129_ _08842_ VSS VSS VDD VDD _08953_ sky130_fd_sc_hd__nor2_2
X_18131_ _08855_ _08953_ net640 VSS VSS VDD VDD _08954_ sky130_fd_sc_hd__o21ai_0
X_18132_ net640 _08838_ VSS VSS VDD VDD _08955_ sky130_fd_sc_hd__nor2_8
X_18133_ _12124_ _08955_ VSS VSS VDD VDD _08956_ sky130_fd_sc_hd__nand2_1
X_18134_ _08930_ net617 VSS VSS VDD VDD _08957_ sky130_fd_sc_hd__nor2_4
X_18135_ _08917_ _08954_ _08956_ _08957_ VSS VSS VDD VDD _08958_
+ sky130_fd_sc_hd__and4_1
X_18136_ _08938_ _08946_ _08952_ _08958_ VSS VSS VDD VDD _08959_
+ sky130_fd_sc_hd__a211oi_1
X_18137_ _08914_ _08918_ _08929_ _08932_ _08959_ VSS VSS VDD
+ VDD _08960_ sky130_fd_sc_hd__o221ai_2
XTAP_TAPCELL_ROW_26_645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18139_ _12138_ _08838_ VSS VSS VDD VDD _08962_ sky130_fd_sc_hd__nand2_2
X_18140_ net438 _08941_ _08962_ _08901_ _08933_ VSS VSS VDD
+ VDD _08963_ sky130_fd_sc_hd__a32oi_1
X_18141_ net440 _08818_ VSS VSS VDD VDD _08964_ sky130_fd_sc_hd__nand2_1
X_18142_ _12125_ net439 VSS VSS VDD VDD _08965_ sky130_fd_sc_hd__nor2_1
X_18143_ _08926_ _08964_ _08965_ _08901_ _08936_ VSS VSS VDD
+ VDD _08966_ sky130_fd_sc_hd__a221o_1
X_18144_ _08896_ _08963_ _08966_ VSS VSS VDD VDD _08967_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_26_644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18146_ _08916_ _08930_ VSS VSS VDD VDD _08969_ sky130_fd_sc_hd__nand2_2
X_18147_ _08818_ _08838_ VSS VSS VDD VDD _08970_ sky130_fd_sc_hd__nor2_1
X_18148_ _08970_ _08858_ _12124_ VSS VSS VDD VDD _08971_ sky130_fd_sc_hd__o21ai_0
X_18149_ _12125_ _08935_ VSS VSS VDD VDD _08972_ sky130_fd_sc_hd__nor2_1
X_18150_ _12132_ _08955_ _08972_ VSS VSS VDD VDD _08973_ sky130_fd_sc_hd__a21oi_1
X_18151_ _08812_ net438 _08838_ VSS VSS VDD VDD _08974_ sky130_fd_sc_hd__nand3_1
X_18152_ _08853_ _08974_ net551 VSS VSS VDD VDD _08975_ sky130_fd_sc_hd__a21oi_1
X_18153_ net438 _08842_ VSS VSS VDD VDD _08976_ sky130_fd_sc_hd__nand2_1
X_18154_ _12126_ _08976_ VSS VSS VDD VDD _08977_ sky130_fd_sc_hd__nor2_1
X_18155_ net499 _08858_ _08975_ _08977_ _08896_ VSS VSS VDD
+ VDD _08978_ sky130_fd_sc_hd__a2111oi_2
XTAP_TAPCELL_ROW_26_643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18157_ _08896_ _08971_ _08973_ _08978_ net618 VSS VSS VDD
+ VDD _08980_ sky130_fd_sc_hd__a311oi_1
X_18158_ net618 _08967_ _08969_ _08980_ VSS VSS VDD VDD _08981_
+ sky130_fd_sc_hd__a211oi_1
X_18159_ _08899_ _08960_ _08981_ VSS VSS VDD VDD _00072_ sky130_fd_sc_hd__or3_1
X_18160_ _12125_ _08838_ VSS VSS VDD VDD _08982_ sky130_fd_sc_hd__nand2b_4
X_18161_ _08806_ _08812_ _08842_ VSS VSS VDD VDD _08983_ sky130_fd_sc_hd__nand3_4
X_18162_ _08982_ _08983_ _08818_ VSS VSS VDD VDD _08984_ sky130_fd_sc_hd__a21oi_1
X_18163_ net499 _08955_ VSS VSS VDD VDD _08985_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_26_642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18165_ _08984_ _08985_ _08860_ VSS VSS VDD VDD _08987_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_26_641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18169_ _12126_ net749 VSS VSS VDD VDD _08991_ sky130_fd_sc_hd__nand2_1
X_18170_ _08818_ _08991_ _08910_ VSS VSS VDD VDD _08992_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_26_638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18172_ _12138_ _08842_ VSS VSS VDD VDD _08994_ sky130_fd_sc_hd__nand2_2
X_18173_ net640 _08982_ _08994_ VSS VSS VDD VDD _08995_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_26_637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18176_ net618 _08992_ _08995_ _08827_ _08896_ VSS VSS VDD
+ VDD _08998_ sky130_fd_sc_hd__a311oi_1
XTAP_TAPCELL_ROW_26_635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18178_ _08806_ _08838_ VSS VSS VDD VDD _09000_ sky130_fd_sc_hd__nand2_4
X_18179_ _08812_ _08818_ VSS VSS VDD VDD _09001_ sky130_fd_sc_hd__nor2_1
X_18180_ net499 net439 VSS VSS VDD VDD _09002_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_26_634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18182_ _12124_ _08818_ _09001_ VSS VSS VDD VDD _09004_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_25_633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18185_ _09000_ _09001_ _09002_ _09004_ _08838_ VSS VSS VDD
+ VDD _09007_ sky130_fd_sc_hd__o32ai_1
X_18186_ _12132_ _08818_ _08838_ VSS VSS VDD VDD _09008_ sky130_fd_sc_hd__a21oi_1
X_18187_ _08818_ _08923_ _09008_ VSS VSS VDD VDD _09009_ sky130_fd_sc_hd__o21ai_0
X_18188_ _12148_ _08827_ net749 _09009_ net617 VSS VSS VDD
+ VDD _09010_ sky130_fd_sc_hd__o311a_1
X_18189_ _08957_ _09007_ _09010_ VSS VSS VDD VDD _09011_ sky130_fd_sc_hd__a21oi_2
X_18190_ _08987_ _08998_ _08936_ _09011_ VSS VSS VDD VDD _09012_
+ sky130_fd_sc_hd__o2bb2ai_1
X_18191_ _12126_ _08834_ _08837_ VSS VSS VDD VDD _09013_ sky130_fd_sc_hd__or3_1
X_18192_ _08945_ _08947_ net640 VSS VSS VDD VDD _09014_ sky130_fd_sc_hd__a21oi_1
X_18193_ net642 _08868_ _09013_ _09014_ VSS VSS VDD VDD _09015_
+ sky130_fd_sc_hd__a31oi_1
X_18194_ net540 _08838_ VSS VSS VDD VDD _09016_ sky130_fd_sc_hd__nor2_4
X_18195_ _08953_ _09016_ net640 VSS VSS VDD VDD _09017_ sky130_fd_sc_hd__o21ai_0
X_18196_ _12124_ _08838_ _09000_ _08818_ VSS VSS VDD VDD _09018_
+ sky130_fd_sc_hd__o211ai_1
X_18197_ _08827_ _08860_ VSS VSS VDD VDD _09019_ sky130_fd_sc_hd__nand2_1
X_18198_ _09017_ _09018_ _09019_ VSS VSS VDD VDD _09020_ sky130_fd_sc_hd__a21oi_1
X_18199_ _08957_ _09015_ _09020_ VSS VSS VDD VDD _09021_ sky130_fd_sc_hd__a21oi_1
X_18200_ _08818_ _08934_ _08941_ VSS VSS VDD VDD _09022_ sky130_fd_sc_hd__nand3_1
X_18201_ _08818_ _08953_ _09016_ VSS VSS VDD VDD _09023_ sky130_fd_sc_hd__or3_1
X_18202_ _08827_ _08860_ VSS VSS VDD VDD _09024_ sky130_fd_sc_hd__nor2_2
X_18203_ _08896_ _09022_ _09023_ _09024_ _08892_ VSS VSS VDD
+ VDD _09025_ sky130_fd_sc_hd__a41oi_2
X_18204_ _08896_ _09021_ _09025_ VSS VSS VDD VDD _09026_ sky130_fd_sc_hd__o21ai_0
X_18205_ _08818_ _08962_ VSS VSS VDD VDD _09027_ sky130_fd_sc_hd__nand2_1
X_18206_ _08806_ _08935_ _08983_ _09027_ VSS VSS VDD VDD _09028_
+ sky130_fd_sc_hd__o211ai_1
X_18207_ _12124_ _08842_ VSS VSS VDD VDD _09029_ sky130_fd_sc_hd__nand2_4
X_18208_ _08812_ _08838_ VSS VSS VDD VDD _09030_ sky130_fd_sc_hd__nor2_2
X_18209_ net640 _09030_ _08953_ VSS VSS VDD VDD _09031_ sky130_fd_sc_hd__nor3_1
X_18210_ net640 _08947_ _09029_ _09031_ _08827_ VSS VSS VDD
+ VDD _09032_ sky130_fd_sc_hd__a311oi_1
X_18211_ _08827_ _09028_ _09032_ _08860_ VSS VSS VDD VDD _09033_
+ sky130_fd_sc_hd__a211oi_1
X_18212_ _08930_ _08860_ VSS VSS VDD VDD _09034_ sky130_fd_sc_hd__nand2_4
X_18213_ _08818_ _08842_ VSS VSS VDD VDD _09035_ sky130_fd_sc_hd__xnor2_2
X_18214_ _08812_ _09035_ VSS VSS VDD VDD _09036_ sky130_fd_sc_hd__nor2_1
X_18215_ _08838_ _08884_ _08902_ _08806_ VSS VSS VDD VDD _09037_
+ sky130_fd_sc_hd__o22ai_2
X_18216_ _08806_ _08812_ _08842_ VSS VSS VDD VDD _09038_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_25_631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18218_ _12129_ net749 VSS VSS VDD VDD _09040_ sky130_fd_sc_hd__nand2_1
X_18219_ _08982_ _09040_ _08818_ VSS VSS VDD VDD _09041_ sky130_fd_sc_hd__a21oi_1
X_18220_ _08818_ _09038_ _09041_ VSS VSS VDD VDD _09042_ sky130_fd_sc_hd__a21oi_1
X_18221_ _09034_ _09036_ _09037_ _09042_ _09019_ VSS VSS VDD
+ VDD _09043_ sky130_fd_sc_hd__o32ai_1
X_18222_ _08896_ _09033_ _09043_ VSS VSS VDD VDD _09044_ sky130_fd_sc_hd__nor3_1
X_18223_ _08806_ _08838_ VSS VSS VDD VDD _09045_ sky130_fd_sc_hd__nor2_4
X_18224_ _12129_ net644 _09024_ VSS VSS VDD VDD _09046_ sky130_fd_sc_hd__o21ai_1
X_18225_ _08806_ _08858_ _09045_ _09046_ VSS VSS VDD VDD _09047_
+ sky130_fd_sc_hd__a22oi_1
X_18226_ _08930_ net618 VSS VSS VDD VDD _09048_ sky130_fd_sc_hd__nand2_2
X_18227_ _08943_ _09019_ _09048_ _08950_ VSS VSS VDD VDD _09049_
+ sky130_fd_sc_hd__o22ai_1
X_18228_ net438 _08827_ net749 VSS VSS VDD VDD _09050_ sky130_fd_sc_hd__nor3_1
X_18229_ _08970_ _09050_ _08806_ VSS VSS VDD VDD _09051_ sky130_fd_sc_hd__o21ai_1
X_18230_ _08812_ _09047_ _09049_ _09051_ VSS VSS VDD VDD _09052_
+ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_25_630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18232_ _08818_ _08840_ _08940_ VSS VSS VDD VDD _09054_ sky130_fd_sc_hd__nor3_1
X_18233_ _12125_ _08842_ VSS VSS VDD VDD _09055_ sky130_fd_sc_hd__nor2_2
X_18234_ net438 _08911_ _09055_ VSS VSS VDD VDD _09056_ sky130_fd_sc_hd__nor3_2
X_18235_ _08827_ net618 VSS VSS VDD VDD _09057_ sky130_fd_sc_hd__nor2_2
X_18236_ _09054_ _09056_ _09057_ VSS VSS VDD VDD _09058_ sky130_fd_sc_hd__o21ai_0
X_18237_ net438 _08874_ _09016_ VSS VSS VDD VDD _09059_ sky130_fd_sc_hd__nor3_2
X_18238_ _08818_ _08911_ _09055_ VSS VSS VDD VDD _09060_ sky130_fd_sc_hd__nor3_1
X_18239_ _09059_ _09060_ _08957_ VSS VSS VDD VDD _09061_ sky130_fd_sc_hd__o21ai_0
X_18240_ _08896_ _09052_ _09058_ _09061_ _08916_ VSS VSS VDD
+ VDD _09062_ sky130_fd_sc_hd__a41o_1
X_18241_ _09012_ _09026_ _09044_ _09062_ VSS VSS VDD VDD _00073_
+ sky130_fd_sc_hd__o22ai_1
XTAP_TAPCELL_ROW_25_629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18244_ net440 _08811_ VSS VSS VDD VDD _09064_ sky130_fd_sc_hd__nand2_1
X_18245_ _08806_ net439 VSS VSS VDD VDD _09065_ sky130_fd_sc_hd__nand2_1
X_18246_ _09064_ _09065_ net749 VSS VSS VDD VDD _09066_ sky130_fd_sc_hd__a21oi_1
X_18247_ _12148_ net749 _09066_ VSS VSS VDD VDD _09067_ sky130_fd_sc_hd__a21oi_1
X_18248_ net440 _08812_ _08818_ VSS VSS VDD VDD _09068_ sky130_fd_sc_hd__nor3_1
X_18249_ _12145_ net749 VSS VSS VDD VDD _09069_ sky130_fd_sc_hd__nand2_1
X_18250_ net749 _08965_ _09068_ _09069_ _08827_ VSS VSS VDD
+ VDD _09070_ sky130_fd_sc_hd__o311ai_0
X_18251_ _08827_ _09067_ _09070_ VSS VSS VDD VDD _09071_ sky130_fd_sc_hd__o21ai_0
X_18252_ _08941_ _08964_ VSS VSS VDD VDD _09072_ sky130_fd_sc_hd__nand2_1
X_18253_ _08806_ net439 _08902_ _09072_ _12125_ VSS VSS VDD
+ VDD _09073_ sky130_fd_sc_hd__a32oi_1
X_18254_ _08934_ _08919_ _09073_ _08957_ _08917_ VSS VSS VDD
+ VDD _09074_ sky130_fd_sc_hd__o2111ai_1
X_18255_ _08982_ _09029_ VSS VSS VDD VDD _09075_ sky130_fd_sc_hd__nand2_1
X_18256_ _12132_ _08838_ VSS VSS VDD VDD _09076_ sky130_fd_sc_hd__nand2_4
X_18257_ net438 _08901_ _09076_ VSS VSS VDD VDD _09077_ sky130_fd_sc_hd__nand3_1
X_18258_ net438 _09075_ _09077_ VSS VSS VDD VDD _09078_ sky130_fd_sc_hd__o21ai_0
X_18259_ _08917_ _09024_ _09078_ VSS VSS VDD VDD _09079_ sky130_fd_sc_hd__nand3_1
X_18260_ _08918_ _09071_ _09074_ _09079_ VSS VSS VDD VDD _09080_
+ sky130_fd_sc_hd__o211ai_1
X_18261_ _12126_ _08838_ _09045_ VSS VSS VDD VDD _09081_ sky130_fd_sc_hd__a21oi_1
X_18262_ net542 _08842_ VSS VSS VDD VDD _09082_ sky130_fd_sc_hd__nor2_1
X_18263_ _09082_ _08926_ net438 VSS VSS VDD VDD _09083_ sky130_fd_sc_hd__o21ai_1
X_18264_ net638 _09081_ _09083_ VSS VSS VDD VDD _09084_ sky130_fd_sc_hd__o21ai_0
X_18265_ _12138_ _08935_ VSS VSS VDD VDD _09085_ sky130_fd_sc_hd__nor2_1
X_18266_ _08806_ _09059_ _09085_ _08849_ VSS VSS VDD VDD _09086_
+ sky130_fd_sc_hd__a211oi_1
X_18267_ net618 _09084_ _09086_ _08930_ VSS VSS VDD VDD _09087_
+ sky130_fd_sc_hd__a211oi_1
X_18268_ _09000_ _09002_ VSS VSS VDD VDD _09088_ sky130_fd_sc_hd__nor2_1
X_18269_ _12138_ _08818_ VSS VSS VDD VDD _09089_ sky130_fd_sc_hd__nand2_1
X_18270_ net749 _09089_ VSS VSS VDD VDD _09090_ sky130_fd_sc_hd__nand2_1
X_18271_ _12129_ net439 _09090_ VSS VSS VDD VDD _09091_ sky130_fd_sc_hd__a21oi_1
X_18272_ net749 _08884_ _09065_ VSS VSS VDD VDD _09092_ sky130_fd_sc_hd__nand3_1
X_18273_ _12129_ net439 net617 VSS VSS VDD VDD _09093_ sky130_fd_sc_hd__o21ai_0
X_18274_ net617 _08842_ VSS VSS VDD VDD _09094_ sky130_fd_sc_hd__nand2_1
X_18275_ _09068_ _09093_ _09094_ VSS VSS VDD VDD _09095_ sky130_fd_sc_hd__o21ai_0
X_18276_ _09092_ _09095_ VSS VSS VDD VDD _09096_ sky130_fd_sc_hd__nand2_1
X_18277_ net617 _09088_ _09091_ _09096_ _08930_ VSS VSS VDD
+ VDD _09097_ sky130_fd_sc_hd__o311a_1
X_18278_ _08892_ _08936_ _09087_ _09097_ VSS VSS VDD VDD _09098_
+ sky130_fd_sc_hd__or4_1
X_18279_ net640 _08945_ _08947_ VSS VSS VDD VDD _09099_ sky130_fd_sc_hd__nand3_1
X_18280_ _08818_ _08982_ _08948_ VSS VSS VDD VDD _09100_ sky130_fd_sc_hd__nand3_1
X_18281_ _12134_ _08842_ VSS VSS VDD VDD _09101_ sky130_fd_sc_hd__nor2_2
X_18282_ _08818_ _09030_ _09101_ VSS VSS VDD VDD _09102_ sky130_fd_sc_hd__or3_1
X_18283_ _12138_ _08834_ _08837_ VSS VSS VDD VDD _09103_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_25_627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18285_ _08818_ _09000_ _09103_ VSS VSS VDD VDD _09105_ sky130_fd_sc_hd__nand3_1
X_18286_ _09102_ _09105_ net617 VSS VSS VDD VDD _09106_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_25_626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18288_ net617 _09099_ _09100_ _09106_ _08930_ VSS VSS VDD
+ VDD _09108_ sky130_fd_sc_hd__a311o_1
X_18289_ net499 net617 VSS VSS VDD VDD _09109_ sky130_fd_sc_hd__nor2_1
X_18290_ _08806_ net617 net749 _09109_ VSS VSS VDD VDD _09110_
+ sky130_fd_sc_hd__a211oi_1
X_18291_ _12134_ _08838_ net438 VSS VSS VDD VDD _09111_ sky130_fd_sc_hd__o21ai_0
X_18292_ net617 _08838_ VSS VSS VDD VDD _09112_ sky130_fd_sc_hd__nor2_2
X_18293_ _12129_ _12138_ _09112_ VSS VSS VDD VDD _09113_ sky130_fd_sc_hd__mux2i_1
X_18294_ _09110_ _09111_ _09113_ net438 _08930_ VSS VSS VDD
+ VDD _09114_ sky130_fd_sc_hd__o221ai_1
X_18295_ _08916_ _08936_ _09108_ _09114_ VSS VSS VDD VDD _09115_
+ sky130_fd_sc_hd__nand4_1
X_18296_ _08916_ _08936_ VSS VSS VDD VDD _09116_ sky130_fd_sc_hd__nor2_4
X_18297_ _08838_ _08873_ VSS VSS VDD VDD _09117_ sky130_fd_sc_hd__nand2_2
X_18298_ _08983_ _09117_ _08818_ VSS VSS VDD VDD _09118_ sky130_fd_sc_hd__a21oi_1
X_18299_ _12132_ _08838_ VSS VSS VDD VDD _09119_ sky130_fd_sc_hd__nor2_1
X_18300_ net438 _09038_ _09119_ VSS VSS VDD VDD _09120_ sky130_fd_sc_hd__nor3_1
X_18301_ _12152_ _08838_ _09000_ _09002_ _08930_ VSS VSS VDD
+ VDD _09121_ sky130_fd_sc_hd__o221ai_1
X_18302_ _08930_ _09118_ _09120_ _08849_ _09121_ VSS VSS VDD
+ VDD _09122_ sky130_fd_sc_hd__o311ai_0
X_18303_ _12129_ _08818_ VSS VSS VDD VDD _09123_ sky130_fd_sc_hd__nand2_1
X_18304_ net749 _09123_ _09075_ _08818_ VSS VSS VDD VDD _09124_
+ sky130_fd_sc_hd__o22ai_1
X_18305_ net440 _08812_ VSS VSS VDD VDD _09125_ sky130_fd_sc_hd__nor2_1
X_18306_ _08818_ net749 _09125_ VSS VSS VDD VDD _09126_ sky130_fd_sc_hd__nand3_1
X_18307_ _12143_ _08838_ _08827_ VSS VSS VDD VDD _09127_ sky130_fd_sc_hd__a21oi_1
X_18308_ _08827_ _09124_ _09126_ _09127_ _08849_ VSS VSS VDD
+ VDD _09128_ sky130_fd_sc_hd__a221o_1
X_18309_ _09116_ _09122_ _09128_ VSS VSS VDD VDD _09129_ sky130_fd_sc_hd__nand3_1
X_18310_ _09080_ _09098_ _09115_ _09129_ VSS VSS VDD VDD _00074_
+ sky130_fd_sc_hd__nand4b_2
X_18311_ net438 _09055_ _09119_ VSS VSS VDD VDD _09130_ sky130_fd_sc_hd__nor3_1
X_18312_ net438 _09081_ _09130_ VSS VSS VDD VDD _09131_ sky130_fd_sc_hd__a21oi_1
X_18313_ _12126_ _08838_ _08906_ VSS VSS VDD VDD _09132_ sky130_fd_sc_hd__a21oi_1
X_18314_ _08818_ net617 _09132_ _08827_ VSS VSS VDD VDD _09133_
+ sky130_fd_sc_hd__o31ai_1
X_18315_ _08812_ net438 _08842_ VSS VSS VDD VDD _09134_ sky130_fd_sc_hd__nand3_1
X_18316_ _12134_ net617 _09035_ VSS VSS VDD VDD _09135_ sky130_fd_sc_hd__nand3_1
X_18317_ net618 _09134_ _09135_ VSS VSS VDD VDD _09136_ sky130_fd_sc_hd__o21ai_0
X_18318_ _09048_ _09131_ _09133_ _09136_ VSS VSS VDD VDD _09137_
+ sky130_fd_sc_hd__o22ai_1
X_18319_ _08945_ _08962_ net640 VSS VSS VDD VDD _09138_ sky130_fd_sc_hd__a21oi_2
X_18320_ _12126_ _12129_ _08842_ VSS VSS VDD VDD _09139_ sky130_fd_sc_hd__nor3_1
X_18321_ _08818_ _08906_ _09139_ VSS VSS VDD VDD _09140_ sky130_fd_sc_hd__nor3_1
X_18322_ _09034_ _09138_ _09140_ VSS VSS VDD VDD _09141_ sky130_fd_sc_hd__nor3_1
X_18323_ _08936_ _09137_ _09141_ VSS VSS VDD VDD _09142_ sky130_fd_sc_hd__nor3_1
X_18324_ _12132_ _08842_ _09101_ net439 VSS VSS VDD VDD _09143_
+ sky130_fd_sc_hd__a211oi_1
X_18325_ net439 _08983_ _09117_ _09143_ _08849_ VSS VSS VDD
+ VDD _09144_ sky130_fd_sc_hd__a311oi_1
X_18326_ net617 _08919_ _09090_ VSS VSS VDD VDD _09145_ sky130_fd_sc_hd__nor3_1
X_18327_ _09144_ _09145_ _08930_ VSS VSS VDD VDD _09146_ sky130_fd_sc_hd__o21ai_0
X_18328_ _08930_ _08849_ VSS VSS VDD VDD _09147_ sky130_fd_sc_hd__nor2_2
X_18329_ _08806_ _08955_ VSS VSS VDD VDD _09148_ sky130_fd_sc_hd__nand2_1
X_18330_ _08818_ _09045_ _08812_ VSS VSS VDD VDD _09149_ sky130_fd_sc_hd__o21ai_0
X_18331_ _12124_ _08935_ _09147_ _09148_ _09149_ VSS VSS VDD
+ VDD _09150_ sky130_fd_sc_hd__o2111ai_1
X_18332_ _12125_ _08842_ VSS VSS VDD VDD _09151_ sky130_fd_sc_hd__nand2_2
X_18333_ _12134_ _08838_ VSS VSS VDD VDD _09152_ sky130_fd_sc_hd__nand2_1
X_18334_ _09151_ _09152_ VSS VSS VDD VDD _09153_ sky130_fd_sc_hd__nand2_2
X_18335_ net439 _09153_ VSS VSS VDD VDD _09154_ sky130_fd_sc_hd__nand2_1
X_18336_ _08818_ _08902_ _09103_ VSS VSS VDD VDD _09155_ sky130_fd_sc_hd__nand3_1
X_18337_ _08957_ _09154_ _09155_ _08896_ VSS VSS VDD VDD _09156_
+ sky130_fd_sc_hd__a31oi_1
X_18338_ _09146_ _09150_ _09156_ VSS VSS VDD VDD _09157_ sky130_fd_sc_hd__and3_1
X_18339_ _12124_ net749 VSS VSS VDD VDD _09158_ sky130_fd_sc_hd__nor2_1
X_18340_ _08818_ _09158_ _09119_ VSS VSS VDD VDD _09159_ sky130_fd_sc_hd__nor3_1
X_18341_ _08818_ _08945_ _08982_ _09159_ VSS VSS VDD VDD _09160_
+ sky130_fd_sc_hd__a31oi_1
X_18342_ _08818_ _08940_ _08926_ VSS VSS VDD VDD _09161_ sky130_fd_sc_hd__or3_1
X_18343_ net640 _09045_ _08953_ _09161_ _08860_ VSS VSS VDD
+ VDD _09162_ sky130_fd_sc_hd__o311ai_0
X_18344_ _08860_ _09160_ _09162_ VSS VSS VDD VDD _09163_ sky130_fd_sc_hd__o21ai_1
X_18345_ _08849_ _08901_ _08919_ _09116_ VSS VSS VDD VDD _09164_
+ sky130_fd_sc_hd__o31ai_1
X_18346_ _08806_ _08849_ _08955_ _09164_ _08827_ VSS VSS VDD
+ VDD _09165_ sky130_fd_sc_hd__a311oi_1
X_18347_ net617 _08842_ VSS VSS VDD VDD _09166_ sky130_fd_sc_hd__nor2_2
X_18348_ _08818_ _08849_ VSS VSS VDD VDD _09167_ sky130_fd_sc_hd__nor2_1
X_18349_ _08818_ _09166_ _09167_ VSS VSS VDD VDD _09168_ sky130_fd_sc_hd__a21oi_1
X_18350_ net499 _09167_ net749 VSS VSS VDD VDD _09169_ sky130_fd_sc_hd__o21ai_0
X_18351_ _08964_ _09166_ _09168_ _12125_ _09169_ VSS VSS VDD
+ VDD _09170_ sky130_fd_sc_hd__o221ai_2
X_18352_ _09116_ _08827_ _09163_ _09165_ _09170_ VSS VSS VDD
+ VDD _09171_ sky130_fd_sc_hd__a32oi_1
X_18353_ _08934_ _09151_ _08818_ VSS VSS VDD VDD _09172_ sky130_fd_sc_hd__a21oi_2
X_18354_ _08818_ _08948_ _08962_ _09172_ VSS VSS VDD VDD _09173_
+ sky130_fd_sc_hd__a31oi_1
X_18355_ _08849_ _09002_ VSS VSS VDD VDD _09174_ sky130_fd_sc_hd__nor2_1
X_18356_ _08935_ _09064_ _09174_ _08827_ VSS VSS VDD VDD _09175_
+ sky130_fd_sc_hd__a31oi_1
X_18357_ net617 _09173_ _09175_ VSS VSS VDD VDD _09176_ sky130_fd_sc_hd__o21ai_0
X_18358_ _12132_ _08943_ VSS VSS VDD VDD _09177_ sky130_fd_sc_hd__nand2_1
X_18359_ _08818_ _08838_ VSS VSS VDD VDD _09178_ sky130_fd_sc_hd__nand2_1
X_18360_ _08812_ _09178_ _09134_ VSS VSS VDD VDD _09179_ sky130_fd_sc_hd__o21ai_0
X_18361_ _08806_ _09179_ VSS VSS VDD VDD _09180_ sky130_fd_sc_hd__nand2_1
X_18362_ _12125_ _08853_ _09147_ _09177_ _09180_ VSS VSS VDD
+ VDD _09181_ sky130_fd_sc_hd__o2111ai_2
X_18363_ _08812_ _08934_ VSS VSS VDD VDD _09182_ sky130_fd_sc_hd__nor2_2
X_18364_ _12132_ _08955_ _09182_ VSS VSS VDD VDD _09183_ sky130_fd_sc_hd__a21oi_1
X_18365_ _08957_ _09083_ _09183_ VSS VSS VDD VDD _09184_ sky130_fd_sc_hd__nand3_1
X_18366_ _08917_ _09176_ _09181_ _09184_ VSS VSS VDD VDD _09185_
+ sky130_fd_sc_hd__nand4_1
X_18367_ _08892_ _09142_ _09157_ _09171_ _09185_ VSS VSS VDD
+ VDD _00075_ sky130_fd_sc_hd__o311a_1
X_18368_ _12134_ net438 _08930_ _09056_ VSS VSS VDD VDD _09186_
+ sky130_fd_sc_hd__a211oi_1
X_18369_ _08934_ _09103_ VSS VSS VDD VDD _09187_ sky130_fd_sc_hd__and2_0
X_18370_ _08818_ _08856_ _08911_ VSS VSS VDD VDD _09188_ sky130_fd_sc_hd__nor3_1
X_18371_ _08818_ _09187_ _09188_ _08827_ VSS VSS VDD VDD _09189_
+ sky130_fd_sc_hd__a211oi_1
X_18372_ net617 _09186_ _09189_ VSS VSS VDD VDD _09190_ sky130_fd_sc_hd__nor3_1
X_18373_ net438 _09103_ VSS VSS VDD VDD _09191_ sky130_fd_sc_hd__nand2_1
X_18374_ _08856_ _09191_ _09153_ _08818_ VSS VSS VDD VDD _09192_
+ sky130_fd_sc_hd__a2bb2oi_1
X_18375_ _08827_ _09192_ net618 VSS VSS VDD VDD _09193_ sky130_fd_sc_hd__a21oi_1
X_18376_ _08936_ _09190_ _09193_ VSS VSS VDD VDD _09194_ sky130_fd_sc_hd__nor3_1
X_18377_ net550 net438 _08858_ _12124_ _09048_ VSS VSS VDD
+ VDD _09195_ sky130_fd_sc_hd__a221oi_1
X_18378_ _12134_ _08838_ net438 VSS VSS VDD VDD _09196_ sky130_fd_sc_hd__a21oi_1
X_18379_ _08855_ _09196_ VSS VSS VDD VDD _09197_ sky130_fd_sc_hd__nor2_1
X_18380_ net617 _09197_ VSS VSS VDD VDD _09198_ sky130_fd_sc_hd__nor2_1
X_18381_ _08818_ _09000_ _09029_ net618 _08919_ VSS VSS VDD
+ VDD _09199_ sky130_fd_sc_hd__a311oi_1
X_18382_ _08930_ _09198_ _09199_ VSS VSS VDD VDD _09200_ sky130_fd_sc_hd__nor3_1
X_18383_ _09057_ _09134_ VSS VSS VDD VDD _09201_ sky130_fd_sc_hd__nand2_1
X_18384_ _08806_ _09035_ _09182_ _09201_ VSS VSS VDD VDD _09202_
+ sky130_fd_sc_hd__a211oi_2
X_18385_ _08983_ _09195_ _09200_ _08896_ _09202_ VSS VSS VDD
+ VDD _09203_ sky130_fd_sc_hd__a2111oi_1
X_18386_ _09000_ _09040_ net438 VSS VSS VDD VDD _09204_ sky130_fd_sc_hd__a21oi_1
X_18387_ _08936_ _08870_ _09034_ _09204_ VSS VSS VDD VDD _09205_
+ sky130_fd_sc_hd__nor4_1
X_18388_ _08818_ _08991_ _08910_ _08957_ VSS VSS VDD VDD _09206_
+ sky130_fd_sc_hd__nand4_1
X_18389_ net749 _08923_ VSS VSS VDD VDD _09207_ sky130_fd_sc_hd__nor2_1
X_18390_ _09082_ _08906_ _08818_ VSS VSS VDD VDD _09208_ sky130_fd_sc_hd__o21ai_0
X_18391_ _08818_ _08911_ _09207_ _09147_ _09208_ VSS VSS VDD
+ VDD _09209_ sky130_fd_sc_hd__o311ai_1
X_18392_ _12129_ _08842_ _09029_ net640 VSS VSS VDD VDD _09210_
+ sky130_fd_sc_hd__o211ai_1
X_18393_ _08818_ _09030_ _08853_ _12138_ VSS VSS VDD VDD _09211_
+ sky130_fd_sc_hd__o22ai_1
X_18394_ _09022_ _09024_ _09210_ _09211_ _09057_ VSS VSS VDD
+ VDD _09212_ sky130_fd_sc_hd__a32oi_2
X_18395_ _09206_ _09209_ _09212_ _08896_ VSS VSS VDD VDD _09213_
+ sky130_fd_sc_hd__a31oi_1
X_18396_ _08827_ net618 VSS VSS VDD VDD _09214_ sky130_fd_sc_hd__nand2_1
X_18397_ net549 _08943_ _09214_ _09196_ _08840_ VSS VSS VDD
+ VDD _09215_ sky130_fd_sc_hd__a2111oi_0
X_18398_ _08874_ _09045_ net438 VSS VSS VDD VDD _09216_ sky130_fd_sc_hd__o21ai_0
X_18399_ _08859_ _08983_ _09216_ _09048_ VSS VSS VDD VDD _09217_
+ sky130_fd_sc_hd__a31oi_1
X_18400_ _08902_ _09029_ net438 VSS VSS VDD VDD _09218_ sky130_fd_sc_hd__a21oi_1
X_18401_ _08856_ _08977_ _09034_ _09218_ VSS VSS VDD VDD _09219_
+ sky130_fd_sc_hd__nor4_1
X_18402_ _12136_ _08838_ VSS VSS VDD VDD _09220_ sky130_fd_sc_hd__nor2_1
X_18403_ _08838_ _08884_ _09220_ VSS VSS VDD VDD _09221_ sky130_fd_sc_hd__a21oi_1
X_18404_ _09019_ _09221_ _08896_ VSS VSS VDD VDD _09222_ sky130_fd_sc_hd__o21ai_0
X_18405_ _09215_ _09217_ _09219_ _09222_ VSS VSS VDD VDD _09223_
+ sky130_fd_sc_hd__nor4_1
X_18406_ _08892_ _09213_ _09223_ VSS VSS VDD VDD _09224_ sky130_fd_sc_hd__or3_1
X_18407_ _08916_ _09194_ _09203_ _09205_ _09224_ VSS VSS VDD
+ VDD _00076_ sky130_fd_sc_hd__o41ai_1
X_18408_ _08812_ _08976_ _08840_ VSS VSS VDD VDD _09225_ sky130_fd_sc_hd__a21oi_1
X_18409_ _12134_ _08838_ _08818_ VSS VSS VDD VDD _09226_ sky130_fd_sc_hd__o21ai_0
X_18410_ _08818_ _09045_ _09055_ _09226_ _08856_ VSS VSS VDD
+ VDD _09227_ sky130_fd_sc_hd__o32ai_1
X_18411_ net618 _09227_ VSS VSS VDD VDD _09228_ sky130_fd_sc_hd__nand2_1
X_18412_ net618 _09225_ _09228_ _08936_ VSS VSS VDD VDD _09229_
+ sky130_fd_sc_hd__o211ai_1
X_18413_ _08941_ _09001_ _09002_ _09117_ _08818_ VSS VSS VDD
+ VDD _09230_ sky130_fd_sc_hd__o32ai_1
X_18414_ net749 _09123_ net617 VSS VSS VDD VDD _09231_ sky130_fd_sc_hd__a21oi_1
X_18415_ _12138_ _09178_ _09231_ VSS VSS VDD VDD _09232_ sky130_fd_sc_hd__o21ai_0
X_18416_ net618 _09230_ _09232_ _08896_ VSS VSS VDD VDD _09233_
+ sky130_fd_sc_hd__o211ai_1
X_18417_ _08931_ _09229_ _09233_ VSS VSS VDD VDD _09234_ sky130_fd_sc_hd__nand3_1
X_18418_ _08935_ _08923_ VSS VSS VDD VDD _09235_ sky130_fd_sc_hd__nor2_1
X_18419_ _08976_ _08923_ _09076_ VSS VSS VDD VDD _09236_ sky130_fd_sc_hd__o21a_1
X_18420_ _08896_ _09236_ net618 VSS VSS VDD VDD _09237_ sky130_fd_sc_hd__a21oi_1
X_18421_ _08896_ _08950_ _09036_ _09235_ _09237_ VSS VSS VDD
+ VDD _09238_ sky130_fd_sc_hd__o41ai_1
X_18422_ _08982_ _09151_ _08936_ VSS VSS VDD VDD _09239_ sky130_fd_sc_hd__a21oi_1
X_18423_ _08936_ _08924_ _09239_ _08818_ VSS VSS VDD VDD _09240_
+ sky130_fd_sc_hd__a211oi_1
X_18424_ _08818_ _09076_ _09103_ _09240_ net617 VSS VSS VDD
+ VDD _09241_ sky130_fd_sc_hd__a311o_1
X_18425_ _08916_ _08930_ _09238_ _09241_ VSS VSS VDD VDD _09242_
+ sky130_fd_sc_hd__nand4_1
X_18426_ _12129_ _08838_ _08955_ _12134_ _08851_ VSS VSS VDD
+ VDD _09243_ sky130_fd_sc_hd__a221o_1
X_18427_ _08818_ _08855_ _08953_ _08942_ _08860_ VSS VSS VDD
+ VDD _09244_ sky130_fd_sc_hd__o311ai_1
X_18428_ _08827_ _08917_ _09243_ _09244_ VSS VSS VDD VDD _09245_
+ sky130_fd_sc_hd__nand4_1
X_18429_ _08991_ _08947_ net642 VSS VSS VDD VDD _09246_ sky130_fd_sc_hd__a21oi_2
X_18430_ net440 _08970_ _09246_ VSS VSS VDD VDD _09247_ sky130_fd_sc_hd__a21oi_1
X_18431_ _08925_ _08994_ net438 VSS VSS VDD VDD _09248_ sky130_fd_sc_hd__a21oi_1
X_18432_ net618 _08972_ _09248_ VSS VSS VDD VDD _09249_ sky130_fd_sc_hd__nor3_1
X_18433_ net618 _09247_ _09249_ VSS VSS VDD VDD _09250_ sky130_fd_sc_hd__a21oi_1
X_18434_ net618 _08943_ VSS VSS VDD VDD _09251_ sky130_fd_sc_hd__nand2_1
X_18435_ _08806_ _09112_ _08812_ VSS VSS VDD VDD _09252_ sky130_fd_sc_hd__o21ai_0
X_18436_ _08806_ _09094_ _09251_ _09252_ VSS VSS VDD VDD _09253_
+ sky130_fd_sc_hd__a31oi_1
X_18437_ net499 _08970_ _08858_ _12132_ VSS VSS VDD VDD _09254_
+ sky130_fd_sc_hd__a22oi_1
X_18438_ _08806_ _08955_ _09166_ _09254_ net617 VSS VSS VDD
+ VDD _09255_ sky130_fd_sc_hd__o32ai_1
X_18439_ _08898_ _08930_ _09253_ _09255_ VSS VSS VDD VDD _09256_
+ sky130_fd_sc_hd__nor4_1
X_18440_ _12129_ _09112_ _09153_ net617 _08818_ VSS VSS VDD
+ VDD _09257_ sky130_fd_sc_hd__a221oi_1
X_18441_ _08849_ _09125_ VSS VSS VDD VDD _09258_ sky130_fd_sc_hd__nand2_1
X_18442_ net617 _09002_ VSS VSS VDD VDD _09259_ sky130_fd_sc_hd__nand2_1
X_18443_ _09258_ _09259_ net749 VSS VSS VDD VDD _09260_ sky130_fd_sc_hd__a21oi_1
X_18444_ _08951_ _09257_ _09260_ VSS VSS VDD VDD _09261_ sky130_fd_sc_hd__nor3_1
X_18445_ _09116_ _08930_ _09250_ _09256_ _09261_ VSS VSS VDD
+ VDD _09262_ sky130_fd_sc_hd__a311oi_1
X_18446_ _09234_ _09242_ _09245_ _09262_ VSS VSS VDD VDD _00077_
+ sky130_fd_sc_hd__nand4_1
X_18447_ _08855_ _08856_ VSS VSS VDD VDD _09263_ sky130_fd_sc_hd__nor2_1
X_18448_ net438 _09263_ VSS VSS VDD VDD _09264_ sky130_fd_sc_hd__nor2_1
X_18449_ _08806_ _08818_ _09038_ VSS VSS VDD VDD _09265_ sky130_fd_sc_hd__o21ai_1
X_18450_ _12141_ _12150_ _08838_ _09265_ _08936_ VSS VSS VDD
+ VDD _09266_ sky130_fd_sc_hd__o311ai_0
X_18451_ _08936_ _09172_ _09264_ _09266_ VSS VSS VDD VDD _09267_
+ sky130_fd_sc_hd__o31ai_1
X_18452_ _12124_ _08838_ _09152_ VSS VSS VDD VDD _09268_ sky130_fd_sc_hd__o21a_1
X_18453_ _12126_ _08858_ VSS VSS VDD VDD _09269_ sky130_fd_sc_hd__nand2_1
X_18454_ _08818_ _09268_ _09269_ VSS VSS VDD VDD _09270_ sky130_fd_sc_hd__o21ai_0
X_18455_ _12125_ _08818_ _08842_ VSS VSS VDD VDD _09271_ sky130_fd_sc_hd__o21ai_0
X_18456_ _08818_ _09125_ _09271_ VSS VSS VDD VDD _09272_ sky130_fd_sc_hd__a21oi_1
X_18457_ _12143_ _08842_ _08896_ VSS VSS VDD VDD _09273_ sky130_fd_sc_hd__o21ai_0
X_18458_ _08896_ _09270_ _09272_ _09273_ _08849_ VSS VSS VDD
+ VDD _09274_ sky130_fd_sc_hd__o221a_1
X_18459_ net617 _09267_ _09274_ _08930_ _08916_ VSS VSS VDD
+ VDD _09275_ sky130_fd_sc_hd__a2111oi_1
X_18460_ net617 _09153_ _09166_ VSS VSS VDD VDD _09276_ sky130_fd_sc_hd__a21oi_1
X_18461_ _08849_ net749 VSS VSS VDD VDD _09277_ sky130_fd_sc_hd__nor2_1
X_18462_ net440 _08849_ _09277_ net499 VSS VSS VDD VDD _09278_
+ sky130_fd_sc_hd__a22o_1
X_18463_ _08812_ _09112_ _09278_ _08818_ _08896_ VSS VSS VDD
+ VDD _09279_ sky130_fd_sc_hd__a221oi_1
X_18464_ _08818_ _09276_ _09279_ VSS VSS VDD VDD _09280_ sky130_fd_sc_hd__o21ai_0
X_18465_ net440 _08838_ _08818_ VSS VSS VDD VDD _09281_ sky130_fd_sc_hd__a21oi_1
X_18466_ _09143_ _09281_ _08849_ VSS VSS VDD VDD _09282_ sky130_fd_sc_hd__o21ai_0
X_18467_ _09095_ _09282_ _08896_ VSS VSS VDD VDD _09283_ sky130_fd_sc_hd__nand3b_1
X_18468_ _09280_ _09283_ _08969_ VSS VSS VDD VDD _09284_ sky130_fd_sc_hd__a21oi_1
X_18469_ net440 _08919_ _08838_ VSS VSS VDD VDD _09285_ sky130_fd_sc_hd__o21ai_0
X_18470_ _08854_ _09048_ VSS VSS VDD VDD _09286_ sky130_fd_sc_hd__nor2_1
X_18471_ net749 _08873_ _08856_ _08818_ VSS VSS VDD VDD _09287_
+ sky130_fd_sc_hd__a211oi_1
X_18472_ _08818_ _08902_ _09151_ _09034_ _09287_ VSS VSS VDD
+ VDD _09288_ sky130_fd_sc_hd__a311oi_1
X_18473_ _09285_ _09286_ _09288_ VSS VSS VDD VDD _09289_ sky130_fd_sc_hd__a21oi_1
X_18474_ _12126_ _08838_ VSS VSS VDD VDD _09290_ sky130_fd_sc_hd__nand2_1
X_18475_ net641 _08994_ _09290_ VSS VSS VDD VDD _09291_ sky130_fd_sc_hd__nand3_1
X_18476_ _08818_ _08910_ _08948_ VSS VSS VDD VDD _09292_ sky130_fd_sc_hd__nand3_1
X_18477_ _09291_ _09292_ VSS VSS VDD VDD _09293_ sky130_fd_sc_hd__nand2_1
X_18478_ net643 _08926_ _09139_ VSS VSS VDD VDD _09294_ sky130_fd_sc_hd__nor3_1
X_18479_ _08818_ _09016_ _09101_ VSS VSS VDD VDD _09295_ sky130_fd_sc_hd__nor3_1
X_18480_ _09294_ _09295_ net618 VSS VSS VDD VDD _09296_ sky130_fd_sc_hd__o21ai_0
X_18481_ net618 _09293_ _09296_ VSS VSS VDD VDD _09297_ sky130_fd_sc_hd__o21ai_2
X_18482_ _08898_ _09289_ _09297_ _08951_ VSS VSS VDD VDD _09298_
+ sky130_fd_sc_hd__o22ai_1
X_18483_ net440 _09001_ _09016_ VSS VSS VDD VDD _09299_ sky130_fd_sc_hd__a21oi_1
X_18484_ _12138_ _09299_ VSS VSS VDD VDD _09300_ sky130_fd_sc_hd__nor2_1
X_18485_ _09002_ _09182_ _09300_ _08849_ VSS VSS VDD VDD _09301_
+ sky130_fd_sc_hd__o31ai_1
X_18486_ _08849_ _09002_ _09103_ _08818_ VSS VSS VDD VDD _09302_
+ sky130_fd_sc_hd__o22ai_1
X_18487_ _08919_ _09277_ _09302_ _08806_ _08896_ VSS VSS VDD
+ VDD _09303_ sky130_fd_sc_hd__a221oi_1
X_18488_ _12142_ _08838_ VSS VSS VDD VDD _09304_ sky130_fd_sc_hd__nand2_1
X_18489_ _12134_ _08818_ VSS VSS VDD VDD _09305_ sky130_fd_sc_hd__nand2_1
X_18490_ net749 _09065_ _09305_ VSS VSS VDD VDD _09306_ sky130_fd_sc_hd__nand3_1
X_18491_ _09304_ _09306_ _08849_ VSS VSS VDD VDD _09307_ sky130_fd_sc_hd__a21oi_1
X_18492_ net617 _08972_ _09138_ _08896_ VSS VSS VDD VDD _09308_
+ sky130_fd_sc_hd__o31ai_1
X_18493_ _09307_ _09308_ _08931_ VSS VSS VDD VDD _09309_ sky130_fd_sc_hd__o21ai_0
X_18494_ _09301_ _09303_ _09309_ VSS VSS VDD VDD _09310_ sky130_fd_sc_hd__a21oi_1
X_18495_ _09275_ _09284_ _09298_ _09310_ VSS VSS VDD VDD _00078_
+ sky130_fd_sc_hd__nor4_2
X_18496_ _08812_ _08935_ _08945_ VSS VSS VDD VDD _09311_ sky130_fd_sc_hd__o21ai_0
X_18497_ _09178_ _09134_ net549 VSS VSS VDD VDD _09312_ sky130_fd_sc_hd__a21oi_1
X_18498_ net499 net749 net549 VSS VSS VDD VDD _09313_ sky130_fd_sc_hd__a21oi_1
X_18499_ net549 _08853_ _08902_ _09313_ net618 VSS VSS VDD
+ VDD _09314_ sky130_fd_sc_hd__a311oi_1
X_18500_ net618 _09311_ _09312_ _09314_ VSS VSS VDD VDD _09315_
+ sky130_fd_sc_hd__a211o_1
X_18501_ _08818_ _08923_ _08838_ VSS VSS VDD VDD _09316_ sky130_fd_sc_hd__a21oi_1
X_18502_ _08906_ _09038_ net438 VSS VSS VDD VDD _09317_ sky130_fd_sc_hd__o21ai_0
X_18503_ net617 _09316_ _09317_ VSS VSS VDD VDD _09318_ sky130_fd_sc_hd__o21ai_0
X_18504_ _08849_ _09125_ _08943_ _08969_ VSS VSS VDD VDD _09319_
+ sky130_fd_sc_hd__a31oi_1
X_18505_ _08931_ _09315_ _09318_ _09319_ VSS VSS VDD VDD _09320_
+ sky130_fd_sc_hd__a22o_1
X_18506_ _08916_ _08936_ _09320_ VSS VSS VDD VDD _09321_ sky130_fd_sc_hd__a21oi_1
X_18507_ _08812_ _08858_ _09030_ VSS VSS VDD VDD _09322_ sky130_fd_sc_hd__a21oi_1
X_18508_ net552 _09322_ VSS VSS VDD VDD _09323_ sky130_fd_sc_hd__nor2_1
X_18509_ _12124_ _08943_ _08955_ net499 _09323_ VSS VSS VDD
+ VDD _09324_ sky130_fd_sc_hd__a221oi_1
X_18510_ _12138_ _08935_ _09035_ _12125_ _08985_ VSS VSS VDD
+ VDD _09325_ sky130_fd_sc_hd__o221ai_1
X_18511_ _08930_ _09325_ net617 VSS VSS VDD VDD _09326_ sky130_fd_sc_hd__a21oi_1
X_18512_ _08818_ _08948_ _09000_ VSS VSS VDD VDD _09327_ sky130_fd_sc_hd__nand3_1
X_18513_ net438 _08902_ _08994_ VSS VSS VDD VDD _09328_ sky130_fd_sc_hd__nand3_1
X_18514_ _09057_ _09327_ _09328_ VSS VSS VDD VDD _09329_ sky130_fd_sc_hd__nand3_1
X_18515_ _12134_ _09178_ _09187_ _08818_ _09147_ VSS VSS VDD
+ VDD _09330_ sky130_fd_sc_hd__o221ai_1
X_18516_ _09329_ _09330_ VSS VSS VDD VDD _09331_ sky130_fd_sc_hd__nand2_1
X_18517_ _09214_ _09324_ _09326_ _09331_ VSS VSS VDD VDD _09332_
+ sky130_fd_sc_hd__o22ai_1
X_18518_ _12134_ net439 _08965_ VSS VSS VDD VDD _09333_ sky130_fd_sc_hd__a21oi_1
X_18519_ _12150_ _08838_ VSS VSS VDD VDD _09334_ sky130_fd_sc_hd__nand2_1
X_18520_ _08838_ _09333_ _09334_ VSS VSS VDD VDD _09335_ sky130_fd_sc_hd__o21ai_0
X_18521_ _12126_ _08818_ net749 VSS VSS VDD VDD _09336_ sky130_fd_sc_hd__nand3_1
X_18522_ _12136_ net749 _09336_ _08827_ VSS VSS VDD VDD _09337_
+ sky130_fd_sc_hd__o211ai_1
X_18523_ _08827_ _09335_ _09337_ net617 _09116_ VSS VSS VDD
+ VDD _09338_ sky130_fd_sc_hd__o2111a_1
X_18524_ _12124_ _08818_ VSS VSS VDD VDD _09339_ sky130_fd_sc_hd__nor2_1
X_18525_ _08818_ _09013_ _09000_ _09339_ VSS VSS VDD VDD _09340_
+ sky130_fd_sc_hd__a31oi_1
X_18526_ net617 _08911_ VSS VSS VDD VDD _09341_ sky130_fd_sc_hd__nor2_1
X_18527_ net618 _09340_ _09341_ _09265_ VSS VSS VDD VDD _09342_
+ sky130_fd_sc_hd__a2bb2oi_1
X_18528_ _08951_ _09342_ VSS VSS VDD VDD _09343_ sky130_fd_sc_hd__nor2_1
X_18529_ _09116_ _09112_ VSS VSS VDD VDD _09344_ sky130_fd_sc_hd__nand2_1
X_18530_ _08818_ _08827_ net499 VSS VSS VDD VDD _09345_ sky130_fd_sc_hd__a21oi_1
X_18531_ _08818_ _08827_ _08806_ VSS VSS VDD VDD _09346_ sky130_fd_sc_hd__o21ai_0
X_18532_ _08806_ _08827_ _09002_ _09345_ _09346_ VSS VSS VDD
+ VDD _09347_ sky130_fd_sc_hd__o32ai_1
X_18533_ _08818_ _08983_ _09076_ _08849_ VSS VSS VDD VDD _09348_
+ sky130_fd_sc_hd__a31o_1
X_18534_ net438 _08947_ _09029_ _09348_ VSS VSS VDD VDD _09349_
+ sky130_fd_sc_hd__a31oi_1
X_18535_ _08941_ _09117_ _08818_ net617 VSS VSS VDD VDD _09350_
+ sky130_fd_sc_hd__a211o_1
X_18536_ _09016_ _09101_ _08818_ _08849_ _08901_ VSS VSS VDD
+ VDD _09351_ sky130_fd_sc_hd__o2111ai_1
X_18537_ _08827_ _08917_ _09350_ _09351_ VSS VSS VDD VDD _09352_
+ sky130_fd_sc_hd__nand4_1
X_18538_ _12125_ _08930_ VSS VSS VDD VDD _09353_ sky130_fd_sc_hd__nand2_1
X_18539_ net440 _08930_ _09353_ _08818_ VSS VSS VDD VDD _09354_
+ sky130_fd_sc_hd__o211ai_1
X_18540_ _12129_ _08827_ VSS VSS VDD VDD _09355_ sky130_fd_sc_hd__nand2_1
X_18541_ _12125_ _08827_ _09355_ net439 VSS VSS VDD VDD _09356_
+ sky130_fd_sc_hd__o211ai_1
X_18542_ _09116_ _09166_ _09354_ _09356_ VSS VSS VDD VDD _09357_
+ sky130_fd_sc_hd__nand4_1
X_18543_ _09344_ _09347_ _09349_ _09352_ _09357_ VSS VSS VDD
+ VDD _09358_ sky130_fd_sc_hd__o221ai_2
X_18544_ _08896_ _09320_ _09338_ _09343_ _09358_ VSS VSS VDD
+ VDD _09359_ sky130_fd_sc_hd__a2111oi_1
X_18545_ _09321_ _09332_ _09359_ VSS VSS VDD VDD _00079_ sky130_fd_sc_hd__o21ai_0
X_18546_ sa12_sr\[0\] sa20_sub\[0\] sa02_sr\[1\] VSS VSS VDD
+ VDD _09360_ sky130_fd_sc_hd__xnor3_1
X_18547_ _07075_ _07108_ _09360_ VSS VSS VDD VDD _09361_ sky130_fd_sc_hd__xnor3_1
X_18548_ text_in_r\[49\] _09361_ _05879_ VSS VSS VDD VDD _09362_
+ sky130_fd_sc_hd__mux2i_4
X_18549_ u0.w\[2\]\[17\] _09362_ VSS VSS VDD VDD _09363_ sky130_fd_sc_hd__xor2_4
X_18550_ net437 VSS VSS VDD VDD _09364_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_25_625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18553_ sa02_sr\[0\] sa31_sub\[0\] VSS VSS VDD VDD _09366_
+ sky130_fd_sc_hd__xor2_1
X_18554_ sa20_sub\[0\] _07108_ _09366_ VSS VSS VDD VDD _09367_
+ sky130_fd_sc_hd__xor3_1
X_18555_ text_in_r\[48\] _09367_ _05879_ VSS VSS VDD VDD _09368_
+ sky130_fd_sc_hd__mux2i_4
X_18556_ u0.w\[2\]\[16\] _09368_ VSS VSS VDD VDD _09369_ sky130_fd_sc_hd__xor2_4
X_18557_ net596 VSS VSS VDD VDD _09370_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_25_623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18559_ sa20_sub\[1\] sa20_sub\[2\] sa02_sr\[2\] VSS VSS
+ VDD VDD _09371_ sky130_fd_sc_hd__xnor3_1
X_18560_ _07096_ _09371_ VSS VSS VDD VDD _09372_ sky130_fd_sc_hd__xor2_1
X_18561_ text_in_r\[50\] _09372_ _05879_ VSS VSS VDD VDD _09373_
+ sky130_fd_sc_hd__mux2i_4
X_18562_ _09373_ u0.w\[2\]\[18\] VSS VSS VDD VDD _09374_ sky130_fd_sc_hd__xnor2_4
X_18563_ net743 VSS VSS VDD VDD _09375_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_25_622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18572_ sa20_sub\[3\] sa20_sub\[4\] sa02_sr\[4\] VSS VSS
+ VDD VDD _09381_ sky130_fd_sc_hd__xnor3_1
X_18573_ _07108_ _07136_ _09381_ VSS VSS VDD VDD _09382_ sky130_fd_sc_hd__xnor3_1
X_18574_ net493 text_in_r\[52\] VSS VSS VDD VDD _09383_ sky130_fd_sc_hd__nand2_1
X_18575_ net493 _09382_ _09383_ VSS VSS VDD VDD _09384_ sky130_fd_sc_hd__o21a_4
X_18576_ u0.w\[2\]\[20\] _09384_ VSS VSS VDD VDD _09385_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_25_614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18579_ sa20_sub\[4\] sa02_sr\[5\] VSS VSS VDD VDD _09388_
+ sky130_fd_sc_hd__xor2_1
X_18580_ _07126_ _09388_ VSS VSS VDD VDD _09389_ sky130_fd_sc_hd__xnor2_1
X_18581_ text_in_r\[53\] _09389_ net547 VSS VSS VDD VDD _09390_
+ sky130_fd_sc_hd__mux2i_4
X_18582_ u0.w\[2\]\[21\] _09390_ VSS VSS VDD VDD _09391_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_25_612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18587_ net493 u0.w\[2\]\[19\] VSS VSS VDD VDD _09396_ sky130_fd_sc_hd__nor2b_1
X_18588_ u0.w\[2\]\[19\] net493 VSS VSS VDD VDD _09397_ sky130_fd_sc_hd__nor2_1
X_18589_ sa20_sub\[3\] sa20_sub\[7\] VSS VSS VDD VDD _09398_
+ sky130_fd_sc_hd__xor2_1
X_18590_ sa20_sub\[2\] sa31_sub\[3\] VSS VSS VDD VDD _09399_
+ sky130_fd_sc_hd__xor2_1
X_18591_ sa12_sr\[7\] sa12_sr\[2\] sa02_sr\[3\] VSS VSS VDD
+ VDD _09400_ sky130_fd_sc_hd__xnor3_1
X_18592_ _09398_ _09399_ _09400_ VSS VSS VDD VDD _09401_ sky130_fd_sc_hd__xnor3_1
X_18593_ _09396_ _09397_ _09401_ VSS VSS VDD VDD _09402_ sky130_fd_sc_hd__mux2_4
X_18594_ u0.w\[2\]\[19\] net493 VSS VSS VDD VDD _09403_ sky130_fd_sc_hd__nand2_1
X_18595_ u0.w\[2\]\[19\] net493 text_in_r\[51\] VSS VSS VDD
+ VDD _09404_ sky130_fd_sc_hd__nand3b_1
X_18596_ text_in_r\[51\] _09403_ _09404_ VSS VSS VDD VDD _09405_
+ sky130_fd_sc_hd__o21ai_4
X_18597_ _09405_ _09402_ VSS VSS VDD VDD _09406_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_24_608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18599_ _09375_ _09406_ VSS VSS VDD VDD _09408_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_24_607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18601_ _12157_ _09406_ VSS VSS VDD VDD _09410_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_24_606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18603_ _09402_ _09405_ VSS VSS VDD VDD _09412_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_24_605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18606_ _12166_ _09412_ VSS VSS VDD VDD _09415_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_24_603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18608_ _09410_ _09415_ net435 VSS VSS VDD VDD _09417_ sky130_fd_sc_hd__o21ai_0
X_18609_ _12161_ _09408_ _09417_ VSS VSS VDD VDD _09418_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_24_602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18611_ _12158_ _09412_ VSS VSS VDD VDD _09420_ sky130_fd_sc_hd__nor2_4
X_18612_ _12161_ _09406_ VSS VSS VDD VDD _09421_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_24_601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18615_ _09420_ _09421_ net435 VSS VSS VDD VDD _09424_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_24_599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18618_ net743 _09412_ VSS VSS VDD VDD _09427_ sky130_fd_sc_hd__nor2_4
X_18619_ _12156_ _09427_ VSS VSS VDD VDD _09428_ sky130_fd_sc_hd__nand2_1
X_18620_ _09391_ _09424_ _09428_ VSS VSS VDD VDD _09429_ sky130_fd_sc_hd__nand3_1
X_18621_ _09391_ _09418_ _09429_ VSS VSS VDD VDD _09430_ sky130_fd_sc_hd__o21ai_2
X_18622_ u0.w\[2\]\[20\] _09384_ VSS VSS VDD VDD _09431_ sky130_fd_sc_hd__xnor2_4
X_18623_ u0.w\[2\]\[21\] _09390_ VSS VSS VDD VDD _09432_ sky130_fd_sc_hd__xor2_4
X_18624_ _09431_ _09432_ VSS VSS VDD VDD _09433_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_24_597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18627_ net437 _09375_ VSS VSS VDD VDD _09436_ sky130_fd_sc_hd__nor2_1
X_18628_ _12157_ _09375_ net740 _09436_ VSS VSS VDD VDD _09437_
+ sky130_fd_sc_hd__a211o_1
X_18629_ net531 _09375_ VSS VSS VDD VDD _09438_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_24_595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18631_ _12164_ net436 VSS VSS VDD VDD _09440_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_24_594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18634_ _09438_ _09440_ net740 VSS VSS VDD VDD _09443_ sky130_fd_sc_hd__o21ai_0
X_18635_ _09433_ _09437_ _09443_ VSS VSS VDD VDD _09444_ sky130_fd_sc_hd__nand3_1
X_18636_ net603 _09369_ _09412_ VSS VSS VDD VDD _09445_ sky130_fd_sc_hd__o21ai_2
X_18637_ _09370_ _09412_ VSS VSS VDD VDD _09446_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_24_592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18639_ _12161_ _09406_ VSS VSS VDD VDD _09448_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_24_591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18642_ _09446_ _09448_ _09374_ VSS VSS VDD VDD _09451_ sky130_fd_sc_hd__a21o_1
X_18643_ _09431_ _09391_ VSS VSS VDD VDD _09452_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_24_589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18645_ _09375_ _09445_ _09451_ _09452_ VSS VSS VDD VDD _09454_
+ sky130_fd_sc_hd__o211ai_1
X_18646_ sa31_sub\[6\] sa02_sr\[6\] VSS VSS VDD VDD _09455_
+ sky130_fd_sc_hd__xor2_4
X_18647_ sa12_sr\[5\] sa20_sub\[5\] sa20_sub\[6\] VSS VSS
+ VDD VDD _09456_ sky130_fd_sc_hd__xnor3_1
X_18648_ _09455_ _09456_ VSS VSS VDD VDD _09457_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_24_588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18650_ text_in_r\[54\] _09457_ net547 VSS VSS VDD VDD _09459_
+ sky130_fd_sc_hd__mux2i_4
X_18651_ u0.w\[2\]\[22\] _09459_ VSS VSS VDD VDD _09460_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_24_587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18653_ net741 _09430_ _09444_ _09454_ _09460_ VSS VSS VDD
+ VDD _09462_ sky130_fd_sc_hd__o2111ai_1
XTAP_TAPCELL_ROW_23_586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18656_ net601 _09370_ _09406_ VSS VSS VDD VDD _09465_ sky130_fd_sc_hd__nor3_4
X_18657_ net435 _09406_ VSS VSS VDD VDD _09466_ sky130_fd_sc_hd__nor2_4
X_18658_ _12166_ _09466_ VSS VSS VDD VDD _09467_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_23_584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18661_ _09375_ _09465_ _09420_ _09467_ net741 VSS VSS VDD
+ VDD _09470_ sky130_fd_sc_hd__o311ai_1
XTAP_TAPCELL_ROW_23_582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18664_ _12164_ _09408_ VSS VSS VDD VDD _09473_ sky130_fd_sc_hd__nor2_2
X_18665_ net607 _09370_ _09412_ VSS VSS VDD VDD _09474_ sky130_fd_sc_hd__nor3_2
X_18666_ _12158_ _09406_ VSS VSS VDD VDD _09475_ sky130_fd_sc_hd__nor2_1
X_18667_ _09375_ _09474_ _09475_ VSS VSS VDD VDD _09476_ sky130_fd_sc_hd__nor3_1
X_18668_ net741 _09473_ _09476_ VSS VSS VDD VDD _09477_ sky130_fd_sc_hd__nor3_2
X_18669_ _09460_ _09432_ _09477_ VSS VSS VDD VDD _09478_ sky130_fd_sc_hd__nor3_1
X_18670_ net598 net436 VSS VSS VDD VDD _09479_ sky130_fd_sc_hd__nor2_4
X_18671_ _12156_ _09375_ VSS VSS VDD VDD _09480_ sky130_fd_sc_hd__nor2_1
X_18672_ _09479_ _09480_ net740 VSS VSS VDD VDD _09481_ sky130_fd_sc_hd__o21ai_2
X_18673_ _12158_ _12161_ VSS VSS VDD VDD _09482_ sky130_fd_sc_hd__nor2_2
X_18674_ net604 _09370_ _09375_ VSS VSS VDD VDD _09483_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_23_580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18676_ _09375_ _09482_ _09483_ net740 VSS VSS VDD VDD _09485_
+ sky130_fd_sc_hd__a211o_1
X_18677_ u0.w\[2\]\[22\] _09459_ VSS VSS VDD VDD _09486_ sky130_fd_sc_hd__xor2_4
X_18678_ _09486_ _09432_ VSS VSS VDD VDD _09487_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_23_579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18680_ _12177_ net740 _09427_ _12157_ net741 VSS VSS VDD
+ VDD _09489_ sky130_fd_sc_hd__a221oi_2
X_18681_ net741 _09481_ _09485_ _09487_ _09489_ VSS VSS VDD
+ VDD _09490_ sky130_fd_sc_hd__a311oi_4
X_18682_ sa20_sub\[6\] sa31_sub\[7\] VSS VSS VDD VDD _09491_
+ sky130_fd_sc_hd__xor2_2
X_18683_ sa12_sr\[6\] sa20_sub\[7\] VSS VSS VDD VDD _09492_
+ sky130_fd_sc_hd__xnor2_1
X_18684_ _09491_ _09492_ VSS VSS VDD VDD _09493_ sky130_fd_sc_hd__xnor2_1
X_18685_ sa02_sr\[7\] _09493_ VSS VSS VDD VDD _09494_ sky130_fd_sc_hd__xnor2_1
X_18686_ net493 _09494_ VSS VSS VDD VDD _09495_ sky130_fd_sc_hd__nor2_1
X_18687_ net493 text_in_r\[55\] _09495_ VSS VSS VDD VDD _09496_
+ sky130_fd_sc_hd__a21oi_4
X_18688_ u0.w\[2\]\[23\] _09496_ VSS VSS VDD VDD _09497_ sky130_fd_sc_hd__xor2_4
X_18689_ _09470_ _09478_ _09490_ _09497_ VSS VSS VDD VDD _09498_
+ sky130_fd_sc_hd__a211oi_1
X_18690_ _09486_ _09431_ VSS VSS VDD VDD _09499_ sky130_fd_sc_hd__nand2_1
X_18691_ net531 net434 net740 VSS VSS VDD VDD _09500_ sky130_fd_sc_hd__nor3_2
X_18692_ _09364_ _09499_ _09500_ VSS VSS VDD VDD _09501_ sky130_fd_sc_hd__nand3_1
X_18693_ _09375_ _09406_ VSS VSS VDD VDD _09502_ sky130_fd_sc_hd__xnor2_4
X_18694_ net531 _09502_ VSS VSS VDD VDD _09503_ sky130_fd_sc_hd__nor2_1
X_18695_ net596 _09406_ VSS VSS VDD VDD _09504_ sky130_fd_sc_hd__nand2_2
X_18696_ _09364_ _09504_ VSS VSS VDD VDD _09505_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_23_578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18698_ _12157_ _09412_ VSS VSS VDD VDD _09507_ sky130_fd_sc_hd__nor2_1
X_18699_ _12164_ net740 _09507_ VSS VSS VDD VDD _09508_ sky130_fd_sc_hd__a21oi_1
X_18700_ _09486_ _09385_ VSS VSS VDD VDD _09509_ sky130_fd_sc_hd__nand2_1
X_18701_ _12156_ _09466_ _09509_ VSS VSS VDD VDD _09510_ sky130_fd_sc_hd__a21oi_1
X_18702_ _09375_ _09508_ _09510_ VSS VSS VDD VDD _09511_ sky130_fd_sc_hd__o21ai_0
X_18703_ _09499_ _09503_ _09505_ _09465_ _09511_ VSS VSS VDD
+ VDD _09512_ sky130_fd_sc_hd__o41ai_1
X_18704_ net434 _09412_ VSS VSS VDD VDD _09513_ sky130_fd_sc_hd__nand2_2
X_18705_ _09364_ _09406_ VSS VSS VDD VDD _09514_ sky130_fd_sc_hd__nor2_2
X_18706_ net598 _09375_ VSS VSS VDD VDD _09515_ sky130_fd_sc_hd__nand2_1
X_18707_ _12161_ _09513_ _09514_ _09515_ VSS VSS VDD VDD _09516_
+ sky130_fd_sc_hd__o22ai_1
X_18708_ _09364_ _09412_ VSS VSS VDD VDD _09517_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_23_577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18710_ _12170_ _09412_ VSS VSS VDD VDD _09519_ sky130_fd_sc_hd__and2_2
X_18711_ _09517_ _09519_ _09375_ VSS VSS VDD VDD _09520_ sky130_fd_sc_hd__o21ai_0
X_18712_ _12157_ net434 _09412_ VSS VSS VDD VDD _09521_ sky130_fd_sc_hd__and3_2
X_18713_ net597 _09412_ VSS VSS VDD VDD _09522_ sky130_fd_sc_hd__nor2_4
X_18714_ _09385_ _09521_ _09522_ VSS VSS VDD VDD _09523_ sky130_fd_sc_hd__nor3_1
X_18715_ _09385_ _09516_ _09520_ _09523_ _09486_ VSS VSS VDD
+ VDD _09524_ sky130_fd_sc_hd__a221oi_1
X_18716_ u0.w\[2\]\[23\] _09496_ VSS VSS VDD VDD _09525_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_23_576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18718_ _09501_ _09512_ _09524_ _09432_ _09525_ VSS VSS VDD
+ VDD _09527_ sky130_fd_sc_hd__a2111oi_1
XTAP_TAPCELL_ROW_23_575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18722_ net437 _09412_ VSS VSS VDD VDD _09531_ sky130_fd_sc_hd__nor2_4
X_18723_ _09375_ _09519_ _09531_ _09515_ _09517_ VSS VSS VDD
+ VDD _09532_ sky130_fd_sc_hd__o32ai_2
XTAP_TAPCELL_ROW_23_572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18725_ net437 _09406_ VSS VSS VDD VDD _09534_ sky130_fd_sc_hd__nand2_2
X_18726_ _12157_ net434 VSS VSS VDD VDD _09535_ sky130_fd_sc_hd__nor2_2
X_18727_ _09364_ net435 VSS VSS VDD VDD _09536_ sky130_fd_sc_hd__nor2_1
X_18728_ _12157_ _09406_ VSS VSS VDD VDD _09537_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_23_571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18730_ _09534_ _09535_ _09536_ _09537_ VSS VSS VDD VDD _09539_
+ sky130_fd_sc_hd__o2bb2ai_1
XTAP_TAPCELL_ROW_23_570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18733_ _09460_ _09539_ _09431_ VSS VSS VDD VDD _09542_ sky130_fd_sc_hd__o21ai_0
X_18734_ _09460_ _09532_ _09542_ VSS VSS VDD VDD _09543_ sky130_fd_sc_hd__a21oi_1
X_18735_ _09460_ _09385_ VSS VSS VDD VDD _09544_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_23_568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18737_ net435 _09406_ VSS VSS VDD VDD _09546_ sky130_fd_sc_hd__nand2_1
X_18738_ net531 _09466_ VSS VSS VDD VDD _09547_ sky130_fd_sc_hd__nand2_1
X_18739_ _12158_ _09546_ _09547_ VSS VSS VDD VDD _09548_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_23_567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18742_ net740 _09438_ _09427_ VSS VSS VDD VDD _09550_ sky130_fd_sc_hd__a21oi_1
X_18743_ net437 _09550_ VSS VSS VDD VDD _09551_ sky130_fd_sc_hd__nor2_1
X_18744_ _12156_ _09502_ VSS VSS VDD VDD _09552_ sky130_fd_sc_hd__nor2_1
X_18745_ _09521_ _09473_ _09552_ VSS VSS VDD VDD _09553_ sky130_fd_sc_hd__nor3_1
X_18746_ _09544_ _09548_ _09551_ _09553_ _09509_ VSS VSS VDD
+ VDD _09554_ sky130_fd_sc_hd__o32ai_1
X_18747_ _09391_ _09525_ _09543_ _09554_ VSS VSS VDD VDD _09555_
+ sky130_fd_sc_hd__nor4_1
X_18748_ _09462_ _09498_ _09527_ _09555_ VSS VSS VDD VDD _00080_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_23_565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18750_ _09522_ _09421_ VSS VSS VDD VDD _09557_ sky130_fd_sc_hd__nor2_1
X_18751_ _12156_ _09412_ VSS VSS VDD VDD _09558_ sky130_fd_sc_hd__nor2_1
X_18752_ _09364_ _09412_ VSS VSS VDD VDD _09559_ sky130_fd_sc_hd__nand2_8
X_18753_ _09558_ _09375_ _09559_ VSS VSS VDD VDD _09560_ sky130_fd_sc_hd__nand3b_1
X_18754_ _09375_ _09557_ _09560_ VSS VSS VDD VDD _09561_ sky130_fd_sc_hd__o21ai_0
X_18755_ _09364_ _09522_ _09410_ VSS VSS VDD VDD _09562_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_23_564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18757_ net531 _09375_ net742 VSS VSS VDD VDD _09564_ sky130_fd_sc_hd__nand3_1
X_18758_ _09375_ _09562_ _09564_ VSS VSS VDD VDD _09565_ sky130_fd_sc_hd__o21ai_1
X_18759_ _09370_ _09412_ VSS VSS VDD VDD _09566_ sky130_fd_sc_hd__nor2_2
X_18760_ _12156_ _09412_ VSS VSS VDD VDD _09567_ sky130_fd_sc_hd__and2_0
X_18761_ _12158_ _09412_ net435 VSS VSS VDD VDD _09568_ sky130_fd_sc_hd__o21ai_2
X_18762_ net435 _09566_ _09410_ _09567_ _09568_ VSS VSS VDD
+ VDD _09569_ sky130_fd_sc_hd__o32ai_1
X_18763_ net437 net600 _09406_ VSS VSS VDD VDD _09570_ sky130_fd_sc_hd__nor3_1
X_18764_ _09420_ _09570_ _09375_ VSS VSS VDD VDD _09571_ sky130_fd_sc_hd__o21ai_0
X_18765_ _12157_ _09412_ VSS VSS VDD VDD _09572_ sky130_fd_sc_hd__nand2b_4
X_18766_ _12170_ _09406_ VSS VSS VDD VDD _09573_ sky130_fd_sc_hd__nand2_2
X_18767_ net435 _09572_ _09573_ _09391_ VSS VSS VDD VDD _09574_
+ sky130_fd_sc_hd__a31oi_1
X_18768_ _09391_ _09569_ _09571_ _09574_ _09385_ VSS VSS VDD
+ VDD _09575_ sky130_fd_sc_hd__a221oi_1
X_18769_ _09433_ _09561_ _09565_ _09452_ _09575_ VSS VSS VDD
+ VDD _09576_ sky130_fd_sc_hd__a221oi_1
X_18770_ _09486_ _09525_ _09576_ VSS VSS VDD VDD _09577_ sky130_fd_sc_hd__nor3_1
X_18771_ _09385_ _09432_ VSS VSS VDD VDD _09578_ sky130_fd_sc_hd__nor2_4
X_18772_ _12161_ _09412_ _09572_ VSS VSS VDD VDD _09579_ sky130_fd_sc_hd__o21ai_1
X_18773_ _09370_ _09406_ VSS VSS VDD VDD _09580_ sky130_fd_sc_hd__nor2_4
X_18774_ net434 _09580_ _09522_ VSS VSS VDD VDD _09581_ sky130_fd_sc_hd__or3_1
X_18775_ _09375_ _09579_ _09581_ VSS VSS VDD VDD _09582_ sky130_fd_sc_hd__o21ai_2
X_18776_ _09375_ _09406_ VSS VSS VDD VDD _09583_ sky130_fd_sc_hd__nor2_4
X_18777_ _09385_ _09391_ VSS VSS VDD VDD _09584_ sky130_fd_sc_hd__nand2_1
X_18778_ net599 _09412_ VSS VSS VDD VDD _09585_ sky130_fd_sc_hd__nand2_1
X_18779_ _09375_ _09585_ net437 VSS VSS VDD VDD _09586_ sky130_fd_sc_hd__a21oi_1
X_18780_ _09505_ _09583_ _09584_ _09586_ VSS VSS VDD VDD _09587_
+ sky130_fd_sc_hd__nor4_1
X_18781_ _09486_ _09525_ VSS VSS VDD VDD _09588_ sky130_fd_sc_hd__nand2_2
X_18782_ _12170_ _09406_ VSS VSS VDD VDD _09589_ sky130_fd_sc_hd__nor2_2
X_18783_ _09375_ _09589_ _09474_ VSS VSS VDD VDD _09590_ sky130_fd_sc_hd__nor3_1
X_18784_ _12161_ _09412_ VSS VSS VDD VDD _09591_ sky130_fd_sc_hd__nor2_2
X_18785_ net435 _09410_ _09591_ VSS VSS VDD VDD _09592_ sky130_fd_sc_hd__nor3_1
X_18786_ _09590_ _09592_ _09385_ VSS VSS VDD VDD _09593_ sky130_fd_sc_hd__o21ai_0
X_18787_ net437 _09502_ _09408_ _12161_ _09431_ VSS VSS VDD
+ VDD _09594_ sky130_fd_sc_hd__o221ai_1
X_18788_ _09593_ _09594_ _09391_ VSS VSS VDD VDD _09595_ sky130_fd_sc_hd__a21oi_1
X_18789_ _09578_ _09582_ _09587_ _09588_ _09595_ VSS VSS VDD
+ VDD _09596_ sky130_fd_sc_hd__a2111oi_2
X_18790_ net436 _09572_ _09448_ VSS VSS VDD VDD _09597_ sky130_fd_sc_hd__and3_1
X_18791_ _09375_ _09445_ _09597_ VSS VSS VDD VDD _09598_ sky130_fd_sc_hd__a21oi_1
X_18792_ _09370_ _09502_ _09446_ _09364_ VSS VSS VDD VDD _09599_
+ sky130_fd_sc_hd__o22ai_1
X_18793_ _12157_ _09427_ _09391_ _09599_ VSS VSS VDD VDD _09600_
+ sky130_fd_sc_hd__a211oi_1
X_18794_ _09391_ _09598_ _09600_ _09544_ VSS VSS VDD VDD _09601_
+ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_22_563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18796_ _09566_ _09421_ _09375_ VSS VSS VDD VDD _09603_ sky130_fd_sc_hd__o21ai_1
X_18797_ _12156_ net436 net742 _09521_ VSS VSS VDD VDD _09604_
+ sky130_fd_sc_hd__a31oi_1
X_18798_ _09432_ _09603_ _09604_ VSS VSS VDD VDD _09605_ sky130_fd_sc_hd__nand3_1
X_18799_ _09364_ _09370_ _09406_ VSS VSS VDD VDD _09606_ sky130_fd_sc_hd__nand3_4
X_18800_ _09374_ _09519_ _09583_ net602 VSS VSS VDD VDD _09607_
+ sky130_fd_sc_hd__a2bb2oi_1
X_18801_ _09460_ _09431_ VSS VSS VDD VDD _09608_ sky130_fd_sc_hd__nand2_1
X_18802_ _09391_ _09606_ _09607_ _09608_ VSS VSS VDD VDD _09609_
+ sky130_fd_sc_hd__a31oi_1
X_18803_ _09605_ _09609_ VSS VSS VDD VDD _09610_ sky130_fd_sc_hd__nand2_1
X_18804_ _09601_ _09610_ _09497_ VSS VSS VDD VDD _09611_ sky130_fd_sc_hd__a21oi_4
X_18805_ _09486_ _09497_ VSS VSS VDD VDD _09612_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_22_562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_18807_ net437 net598 VSS VSS VDD VDD _09614_ sky130_fd_sc_hd__nor2_1
X_18808_ net436 _09614_ VSS VSS VDD VDD _09615_ sky130_fd_sc_hd__nand2_1
X_18809_ _12164_ _09375_ VSS VSS VDD VDD _09616_ sky130_fd_sc_hd__nand2_1
X_18810_ _12180_ net742 _09391_ VSS VSS VDD VDD _09617_ sky130_fd_sc_hd__nor3_1
X_18811_ net742 _09615_ _09616_ _09617_ VSS VSS VDD VDD _09618_
+ sky130_fd_sc_hd__a31oi_1
X_18812_ _09431_ _09618_ VSS VSS VDD VDD _09619_ sky130_fd_sc_hd__nor2_1
X_18813_ _09370_ _09375_ VSS VSS VDD VDD _09620_ sky130_fd_sc_hd__nor2_2
X_18814_ _12156_ _09375_ _09620_ VSS VSS VDD VDD _09621_ sky130_fd_sc_hd__a21oi_1
X_18815_ _09479_ _09559_ _09620_ _09621_ _09412_ VSS VSS VDD
+ VDD _09622_ sky130_fd_sc_hd__o32ai_2
X_18816_ net436 _09514_ _09531_ VSS VSS VDD VDD _09623_ sky130_fd_sc_hd__nor3_1
X_18817_ net436 _09557_ _09623_ _09391_ VSS VSS VDD VDD _09624_
+ sky130_fd_sc_hd__a211oi_1
X_18818_ _09391_ _09622_ _09624_ net741 VSS VSS VDD VDD _09625_
+ sky130_fd_sc_hd__a211oi_1
X_18819_ _09612_ _09619_ _09625_ VSS VSS VDD VDD _09626_ sky130_fd_sc_hd__nor3_1
X_18820_ _09611_ _09596_ _09577_ _09626_ VSS VSS VDD VDD _00081_
+ sky130_fd_sc_hd__nor4_4
X_18821_ _09375_ _09580_ _09415_ VSS VSS VDD VDD _09627_ sky130_fd_sc_hd__nor3_1
X_18822_ _12170_ _09412_ VSS VSS VDD VDD _09628_ sky130_fd_sc_hd__nor2_2
X_18823_ net434 _09421_ _09628_ VSS VSS VDD VDD _09629_ sky130_fd_sc_hd__nor3_1
X_18824_ _09385_ _09391_ VSS VSS VDD VDD _09630_ sky130_fd_sc_hd__nor2_1
X_18825_ _09627_ _09629_ _09630_ VSS VSS VDD VDD _09631_ sky130_fd_sc_hd__o21ai_0
X_18826_ _12166_ net742 VSS VSS VDD VDD _09632_ sky130_fd_sc_hd__nand2_1
X_18827_ net434 _09559_ _09632_ VSS VSS VDD VDD _09633_ sky130_fd_sc_hd__nand3_1
X_18828_ _12161_ net434 _09452_ _09633_ VSS VSS VDD VDD _09634_
+ sky130_fd_sc_hd__o211ai_1
X_18829_ _09566_ _09410_ net434 VSS VSS VDD VDD _09635_ sky130_fd_sc_hd__o21ai_0
X_18830_ _09375_ _09572_ _09632_ VSS VSS VDD VDD _09636_ sky130_fd_sc_hd__nand3_1
X_18831_ _09364_ _09375_ VSS VSS VDD VDD _09637_ sky130_fd_sc_hd__nand2_1
X_18832_ _12166_ _09375_ _09637_ VSS VSS VDD VDD _09638_ sky130_fd_sc_hd__o21ai_0
X_18833_ _12170_ _09375_ net740 _09438_ VSS VSS VDD VDD _09639_
+ sky130_fd_sc_hd__a211oi_1
X_18834_ net740 _09638_ _09639_ VSS VSS VDD VDD _09640_ sky130_fd_sc_hd__a21oi_1
X_18835_ _09433_ _09635_ _09636_ _09640_ _09578_ VSS VSS VDD
+ VDD _09641_ sky130_fd_sc_hd__a32oi_1
X_18836_ _09460_ _09631_ _09634_ _09641_ _09525_ VSS VSS VDD
+ VDD _09642_ sky130_fd_sc_hd__a41o_1
X_18837_ _09375_ _09412_ VSS VSS VDD VDD _09643_ sky130_fd_sc_hd__nor2_2
X_18838_ _09446_ _09573_ VSS VSS VDD VDD _09644_ sky130_fd_sc_hd__nand2_1
X_18839_ _12161_ _09643_ _09644_ _09375_ _09514_ VSS VSS VDD
+ VDD _09645_ sky130_fd_sc_hd__a221oi_1
X_18840_ _09537_ _09446_ _09375_ VSS VSS VDD VDD _09646_ sky130_fd_sc_hd__a21oi_1
X_18841_ net435 _09531_ _09475_ VSS VSS VDD VDD _09647_ sky130_fd_sc_hd__nor3_1
X_18842_ _09646_ _09647_ _09391_ VSS VSS VDD VDD _09648_ sky130_fd_sc_hd__o21ai_1
X_18843_ _09391_ _09645_ _09648_ VSS VSS VDD VDD _09649_ sky130_fd_sc_hd__o21ai_1
X_18844_ _12161_ net434 _09385_ VSS VSS VDD VDD _09650_ sky130_fd_sc_hd__o21ai_0
X_18845_ net740 _09431_ _09483_ _09650_ VSS VSS VDD VDD _09651_
+ sky130_fd_sc_hd__o22ai_2
X_18846_ _12170_ _09513_ _09581_ net437 _09433_ VSS VSS VDD
+ VDD _09652_ sky130_fd_sc_hd__o221a_1
X_18847_ _09432_ _09437_ _09651_ _09652_ _09460_ VSS VSS VDD
+ VDD _09653_ sky130_fd_sc_hd__a311o_1
X_18848_ _09431_ _09649_ _09653_ VSS VSS VDD VDD _09654_ sky130_fd_sc_hd__a21oi_1
X_18849_ net742 _09535_ _09483_ VSS VSS VDD VDD _09655_ sky130_fd_sc_hd__nor3_1
X_18850_ _12177_ net742 _09486_ VSS VSS VDD VDD _09656_ sky130_fd_sc_hd__a21oi_1
X_18851_ _09433_ _09656_ VSS VSS VDD VDD _09657_ sky130_fd_sc_hd__nand2_1
X_18852_ _09655_ _09657_ _09525_ VSS VSS VDD VDD _09658_ sky130_fd_sc_hd__o21ai_2
X_18853_ net606 _09370_ VSS VSS VDD VDD _09659_ sky130_fd_sc_hd__nor2_2
X_18854_ _12184_ _09385_ _09406_ VSS VSS VDD VDD _09660_ sky130_fd_sc_hd__o21ai_0
X_18855_ _09375_ _09385_ _09659_ _09660_ VSS VSS VDD VDD _09661_
+ sky130_fd_sc_hd__a31oi_1
X_18856_ _12175_ _09385_ net742 VSS VSS VDD VDD _09662_ sky130_fd_sc_hd__a21oi_1
X_18857_ net437 _09385_ _09479_ _09662_ VSS VSS VDD VDD _09663_
+ sky130_fd_sc_hd__o31a_1
X_18858_ _09364_ _09370_ VSS VSS VDD VDD _09664_ sky130_fd_sc_hd__nor2_1
X_18859_ net742 _09436_ _09664_ VSS VSS VDD VDD _09665_ sky130_fd_sc_hd__or3_1
X_18860_ _12180_ net740 _09665_ VSS VSS VDD VDD _09666_ sky130_fd_sc_hd__o21ai_0
X_18861_ _09460_ _09661_ _09663_ _09666_ _09544_ VSS VSS VDD
+ VDD _09667_ sky130_fd_sc_hd__o32a_1
X_18862_ _12164_ _09412_ VSS VSS VDD VDD _09668_ sky130_fd_sc_hd__nand2_2
X_18863_ net436 _09668_ _09534_ VSS VSS VDD VDD _09669_ sky130_fd_sc_hd__nand3_1
X_18864_ _12156_ net742 net435 VSS VSS VDD VDD _09670_ sky130_fd_sc_hd__a21oi_2
X_18865_ _09572_ _09670_ _09608_ VSS VSS VDD VDD _09671_ sky130_fd_sc_hd__a21oi_1
X_18866_ _09669_ _09671_ VSS VSS VDD VDD _09672_ sky130_fd_sc_hd__nand2_1
X_18867_ _09412_ _09482_ VSS VSS VDD VDD _09673_ sky130_fd_sc_hd__nand2_1
X_18868_ _09606_ _09673_ _09375_ VSS VSS VDD VDD _09674_ sky130_fd_sc_hd__a21oi_1
X_18869_ _12164_ _09402_ _09405_ VSS VSS VDD VDD _09675_ sky130_fd_sc_hd__or3_2
X_18870_ _09375_ _09445_ _09675_ VSS VSS VDD VDD _09676_ sky130_fd_sc_hd__and3_1
X_18871_ _09674_ _09676_ _09499_ VSS VSS VDD VDD _09677_ sky130_fd_sc_hd__o21bai_2
X_18872_ _12157_ _09514_ _09436_ VSS VSS VDD VDD _09678_ sky130_fd_sc_hd__nor3_1
X_18873_ _09364_ _09375_ _09580_ _09559_ _09620_ VSS VSS VDD
+ VDD _09679_ sky130_fd_sc_hd__o32ai_1
X_18874_ _09608_ _09678_ _09679_ VSS VSS VDD VDD _09680_ sky130_fd_sc_hd__nor3_1
X_18875_ _12157_ _09412_ VSS VSS VDD VDD _09681_ sky130_fd_sc_hd__nand2_1
X_18876_ _12156_ _09412_ _09681_ VSS VSS VDD VDD _09682_ sky130_fd_sc_hd__o21ai_1
X_18877_ _12161_ _09466_ _09682_ net436 _09509_ VSS VSS VDD
+ VDD _09683_ sky130_fd_sc_hd__a221oi_1
X_18878_ _09432_ _09680_ _09683_ VSS VSS VDD VDD _09684_ sky130_fd_sc_hd__nor3_1
X_18879_ _09432_ _09667_ _09672_ _09677_ _09684_ VSS VSS VDD
+ VDD _09685_ sky130_fd_sc_hd__a32oi_4
X_18880_ _09642_ _09654_ _09658_ _09685_ VSS VSS VDD VDD _00082_
+ sky130_fd_sc_hd__o22ai_4
X_18881_ _12158_ _09412_ VSS VSS VDD VDD _09686_ sky130_fd_sc_hd__nand2_1
X_18882_ _12157_ _09391_ VSS VSS VDD VDD _09687_ sky130_fd_sc_hd__nand2_1
X_18883_ net437 _09391_ _09687_ net742 VSS VSS VDD VDD _09688_
+ sky130_fd_sc_hd__o211ai_1
X_18884_ _12164_ net742 _09391_ VSS VSS VDD VDD _09689_ sky130_fd_sc_hd__a21oi_1
X_18885_ _09681_ _09689_ net435 VSS VSS VDD VDD _09690_ sky130_fd_sc_hd__a21oi_1
X_18886_ net435 _09686_ _09688_ _09690_ net741 VSS VSS VDD
+ VDD _09691_ sky130_fd_sc_hd__a311oi_1
X_18887_ _09375_ _09507_ _09673_ VSS VSS VDD VDD _09692_ sky130_fd_sc_hd__nor3b_1
X_18888_ net435 _09566_ _09589_ VSS VSS VDD VDD _09693_ sky130_fd_sc_hd__nor3_1
X_18889_ _09370_ net745 VSS VSS VDD VDD _09694_ sky130_fd_sc_hd__nand2_1
X_18890_ net740 _09694_ VSS VSS VDD VDD _09695_ sky130_fd_sc_hd__nor2_1
X_18891_ _12166_ _09502_ _09432_ _09695_ VSS VSS VDD VDD _09696_
+ sky130_fd_sc_hd__a211o_1
X_18892_ _09391_ _09692_ _09693_ _09696_ net741 VSS VSS VDD
+ VDD _09697_ sky130_fd_sc_hd__o311a_1
X_18893_ _12156_ net742 _09675_ net434 VSS VSS VDD VDD _09698_
+ sky130_fd_sc_hd__o211ai_2
X_18894_ net434 _09522_ _09410_ _09578_ _09698_ VSS VSS VDD
+ VDD _09699_ sky130_fd_sc_hd__o311ai_0
X_18895_ _09517_ _09410_ _09375_ VSS VSS VDD VDD _09700_ sky130_fd_sc_hd__o21ai_0
X_18896_ net531 _09643_ VSS VSS VDD VDD _09701_ sky130_fd_sc_hd__nand2_1
X_18897_ _09630_ _09700_ _09701_ _09588_ VSS VSS VDD VDD _09702_
+ sky130_fd_sc_hd__a31oi_1
X_18898_ _09534_ _09438_ _09637_ _09566_ VSS VSS VDD VDD _09703_
+ sky130_fd_sc_hd__o22ai_1
X_18899_ _09521_ _09703_ _09452_ VSS VSS VDD VDD _09704_ sky130_fd_sc_hd__o21ai_0
X_18900_ _09375_ _09589_ _09537_ VSS VSS VDD VDD _09705_ sky130_fd_sc_hd__nor3b_1
X_18901_ net436 _09517_ _09421_ VSS VSS VDD VDD _09706_ sky130_fd_sc_hd__nor3_1
X_18902_ _09705_ _09706_ _09433_ VSS VSS VDD VDD _09707_ sky130_fd_sc_hd__o21ai_0
X_18903_ _09699_ _09702_ _09704_ _09707_ VSS VSS VDD VDD _09708_
+ sky130_fd_sc_hd__nand4_1
X_18904_ net531 _09391_ VSS VSS VDD VDD _09709_ sky130_fd_sc_hd__nand2_1
X_18905_ _09375_ _09537_ _09709_ VSS VSS VDD VDD _09710_ sky130_fd_sc_hd__a21oi_1
X_18906_ net437 _09431_ VSS VSS VDD VDD _09711_ sky130_fd_sc_hd__nor2_1
X_18907_ _09513_ _09711_ VSS VSS VDD VDD _09712_ sky130_fd_sc_hd__nand2_1
X_18908_ _09479_ _09710_ _09712_ VSS VSS VDD VDD _09713_ sky130_fd_sc_hd__nor3_1
X_18909_ _09406_ _09432_ VSS VSS VDD VDD _09714_ sky130_fd_sc_hd__nand2_1
X_18910_ _09668_ _09432_ _09714_ net531 VSS VSS VDD VDD _09715_
+ sky130_fd_sc_hd__o22ai_1
X_18911_ net435 net741 _09715_ VSS VSS VDD VDD _09716_ sky130_fd_sc_hd__nand3_1
X_18912_ _12157_ _09408_ _09584_ _09716_ _09525_ VSS VSS VDD
+ VDD _09717_ sky130_fd_sc_hd__o311ai_1
X_18913_ _09364_ net742 _09537_ net435 VSS VSS VDD VDD _09718_
+ sky130_fd_sc_hd__o211ai_2
X_18914_ net435 _09589_ _09415_ _09718_ VSS VSS VDD VDD _09719_
+ sky130_fd_sc_hd__o31ai_1
X_18915_ _09364_ _09585_ _09616_ _09412_ VSS VSS VDD VDD _09720_
+ sky130_fd_sc_hd__o22ai_1
X_18916_ _09432_ _09646_ _09720_ VSS VSS VDD VDD _09721_ sky130_fd_sc_hd__nor3_1
X_18917_ _09432_ _09719_ _09721_ net741 VSS VSS VDD VDD _09722_
+ sky130_fd_sc_hd__a211oi_1
X_18918_ _12166_ _09412_ VSS VSS VDD VDD _09723_ sky130_fd_sc_hd__nand2_4
X_18919_ _09375_ _09723_ _09675_ VSS VSS VDD VDD _09724_ sky130_fd_sc_hd__and3_1
X_18920_ _09674_ _09724_ _09452_ VSS VSS VDD VDD _09725_ sky130_fd_sc_hd__o21ai_1
X_18921_ net434 _09391_ _09537_ _09723_ VSS VSS VDD VDD _09726_
+ sky130_fd_sc_hd__nand4_1
X_18922_ net742 _09432_ _09620_ VSS VSS VDD VDD _09727_ sky130_fd_sc_hd__nand3_1
X_18923_ net598 _09406_ _09432_ VSS VSS VDD VDD _09728_ sky130_fd_sc_hd__nor3_1
X_18924_ _09628_ _09728_ _09375_ VSS VSS VDD VDD _09729_ sky130_fd_sc_hd__o21ai_0
X_18925_ _09726_ _09727_ _09729_ _09385_ VSS VSS VDD VDD _09730_
+ sky130_fd_sc_hd__a31o_1
X_18926_ net740 _09436_ _09664_ VSS VSS VDD VDD _09731_ sky130_fd_sc_hd__or3_1
X_18927_ net741 _09391_ _09481_ _09731_ VSS VSS VDD VDD _09732_
+ sky130_fd_sc_hd__nand4_1
X_18928_ _09497_ _09725_ _09730_ _09732_ VSS VSS VDD VDD _09733_
+ sky130_fd_sc_hd__nand4_2
X_18929_ _09713_ _09717_ _09722_ _09733_ _09460_ VSS VSS VDD
+ VDD _09734_ sky130_fd_sc_hd__o311ai_1
X_18930_ _09612_ _09691_ _09697_ _09708_ _09734_ VSS VSS VDD
+ VDD _00083_ sky130_fd_sc_hd__o311a_1
X_18931_ _09375_ _09585_ _09537_ VSS VSS VDD VDD _09735_ sky130_fd_sc_hd__nand3_1
X_18932_ _09375_ _09570_ _09591_ _09735_ net741 VSS VSS VDD
+ VDD _09736_ sky130_fd_sc_hd__o311ai_0
X_18933_ net741 _09571_ _09736_ _09391_ VSS VSS VDD VDD _09737_
+ sky130_fd_sc_hd__o211ai_1
X_18934_ net436 _09628_ _09701_ VSS VSS VDD VDD _09738_ sky130_fd_sc_hd__o21ai_0
X_18935_ _09452_ _09738_ _09486_ VSS VSS VDD VDD _09739_ sky130_fd_sc_hd__a21oi_1
X_18936_ _12161_ net740 _09558_ VSS VSS VDD VDD _09740_ sky130_fd_sc_hd__a21oi_1
X_18937_ _09375_ _09740_ VSS VSS VDD VDD _09741_ sky130_fd_sc_hd__nor2_1
X_18938_ _09623_ _09741_ _09630_ VSS VSS VDD VDD _09742_ sky130_fd_sc_hd__o21ai_0
X_18939_ _09737_ _09739_ _09742_ _09525_ VSS VSS VDD VDD _09743_
+ sky130_fd_sc_hd__a31oi_1
X_18940_ _09431_ _09391_ VSS VSS VDD VDD _09744_ sky130_fd_sc_hd__nand2_2
X_18941_ net740 _09659_ _09559_ VSS VSS VDD VDD _09745_ sky130_fd_sc_hd__o21ai_0
X_18942_ net746 _09745_ _09467_ VSS VSS VDD VDD _09746_ sky130_fd_sc_hd__a21boi_1
X_18943_ _12168_ net742 VSS VSS VDD VDD _09747_ sky130_fd_sc_hd__nand2_1
X_18944_ _12157_ _09375_ net740 VSS VSS VDD VDD _09748_ sky130_fd_sc_hd__nand3_1
X_18945_ _09580_ _09517_ net744 VSS VSS VDD VDD _09749_ sky130_fd_sc_hd__o21ai_0
X_18946_ _09431_ _09432_ VSS VSS VDD VDD _09750_ sky130_fd_sc_hd__nand2_4
X_18947_ _09467_ _09606_ _09749_ _09750_ VSS VSS VDD VDD _09751_
+ sky130_fd_sc_hd__a31oi_2
X_18948_ _09433_ _09747_ _09748_ _09751_ _09460_ VSS VSS VDD
+ VDD _09752_ sky130_fd_sc_hd__a311oi_4
X_18949_ _09364_ _09580_ VSS VSS VDD VDD _09753_ sky130_fd_sc_hd__nand2_1
X_18950_ _09446_ _09670_ VSS VSS VDD VDD _09754_ sky130_fd_sc_hd__nand2_1
X_18951_ _09568_ _09754_ VSS VSS VDD VDD _09755_ sky130_fd_sc_hd__nand2_1
X_18952_ _09753_ _09452_ _09755_ VSS VSS VDD VDD _09756_ sky130_fd_sc_hd__nand3_1
X_18953_ _09744_ _09746_ _09752_ _09756_ VSS VSS VDD VDD _09757_
+ sky130_fd_sc_hd__o211ai_4
X_18954_ _09375_ net741 _09370_ VSS VSS VDD VDD _09758_ sky130_fd_sc_hd__a21oi_1
X_18955_ _09536_ _09758_ net742 VSS VSS VDD VDD _09759_ sky130_fd_sc_hd__o21ai_0
X_18956_ net435 _09711_ VSS VSS VDD VDD _09760_ sky130_fd_sc_hd__nand2_1
X_18957_ _12156_ _09375_ _09431_ net742 VSS VSS VDD VDD _09761_
+ sky130_fd_sc_hd__a31oi_1
X_18958_ _09760_ _09761_ _09391_ VSS VSS VDD VDD _09762_ sky130_fd_sc_hd__a21oi_1
X_18959_ _09559_ _09670_ _09438_ _09584_ VSS VSS VDD VDD _09763_
+ sky130_fd_sc_hd__a211oi_1
X_18960_ net531 net740 _09385_ VSS VSS VDD VDD _09764_ sky130_fd_sc_hd__nand3_1
X_18961_ net434 _09431_ _09764_ VSS VSS VDD VDD _09765_ sky130_fd_sc_hd__a21boi_2
X_18962_ _09375_ _09723_ _09420_ VSS VSS VDD VDD _09766_ sky130_fd_sc_hd__a21oi_1
X_18963_ _09364_ _09391_ _09765_ _09766_ _09744_ VSS VSS VDD
+ VDD _09767_ sky130_fd_sc_hd__o32ai_2
X_18964_ _09759_ _09762_ _09763_ _09767_ VSS VSS VDD VDD _09768_
+ sky130_fd_sc_hd__a211oi_1
X_18965_ _09486_ _09768_ _09525_ VSS VSS VDD VDD _09769_ sky130_fd_sc_hd__o21ai_1
X_18966_ _12166_ _09375_ _09578_ VSS VSS VDD VDD _09770_ sky130_fd_sc_hd__o21ai_0
X_18967_ _09375_ _09579_ _09770_ VSS VSS VDD VDD _09771_ sky130_fd_sc_hd__a21oi_1
X_18968_ _09375_ _09465_ _09591_ _09750_ VSS VSS VDD VDD _09772_
+ sky130_fd_sc_hd__nor4_1
X_18969_ net434 _09514_ _09750_ _09628_ _09486_ VSS VSS VDD
+ VDD _09773_ sky130_fd_sc_hd__o41ai_1
X_18970_ _09375_ _09474_ _09567_ VSS VSS VDD VDD _09774_ sky130_fd_sc_hd__nor3_1
X_18971_ net436 _09514_ _09591_ VSS VSS VDD VDD _09775_ sky130_fd_sc_hd__nor3_1
X_18972_ _09774_ _09775_ _09452_ VSS VSS VDD VDD _09776_ sky130_fd_sc_hd__o21ai_0
X_18973_ _09537_ _09723_ net434 VSS VSS VDD VDD _09777_ sky130_fd_sc_hd__a21oi_1
X_18974_ _09375_ _09465_ _09628_ VSS VSS VDD VDD _09778_ sky130_fd_sc_hd__nor3_1
X_18975_ _09777_ _09778_ _09433_ VSS VSS VDD VDD _09779_ sky130_fd_sc_hd__o21ai_0
X_18976_ _09776_ _09779_ VSS VSS VDD VDD _09780_ sky130_fd_sc_hd__nand2_1
X_18977_ _09771_ _09772_ _09773_ _09780_ VSS VSS VDD VDD _09781_
+ sky130_fd_sc_hd__nor4_1
X_18978_ _09743_ _09757_ _09769_ _09781_ VSS VSS VDD VDD _00084_
+ sky130_fd_sc_hd__o2bb2ai_1
X_18979_ net436 _09412_ _09431_ VSS VSS VDD VDD _09782_ sky130_fd_sc_hd__nor3_1
X_18980_ _09412_ _09431_ _09616_ _09782_ VSS VSS VDD VDD _09783_
+ sky130_fd_sc_hd__a31oi_1
X_18981_ _12164_ _09466_ VSS VSS VDD VDD _09784_ sky130_fd_sc_hd__nand2_1
X_18982_ _09431_ _09546_ _09784_ _09711_ VSS VSS VDD VDD _09785_
+ sky130_fd_sc_hd__a31oi_1
X_18983_ _09385_ _09620_ _09406_ VSS VSS VDD VDD _09786_ sky130_fd_sc_hd__o21ai_0
X_18984_ net742 _09385_ _09440_ _09786_ _09364_ VSS VSS VDD
+ VDD _09787_ sky130_fd_sc_hd__o311ai_0
X_18985_ _09364_ _09783_ _09785_ _09370_ _09787_ VSS VSS VDD
+ VDD _09788_ sky130_fd_sc_hd__o221ai_1
X_18986_ _12158_ _09406_ VSS VSS VDD VDD _09789_ sky130_fd_sc_hd__nand2_1
X_18987_ _09789_ _09681_ net435 VSS VSS VDD VDD _09790_ sky130_fd_sc_hd__a21oi_1
X_18988_ net437 _09643_ _09790_ _09385_ VSS VSS VDD VDD _09791_
+ sky130_fd_sc_hd__a211oi_1
X_18989_ _12156_ _09406_ _09573_ VSS VSS VDD VDD _09792_ sky130_fd_sc_hd__o21ai_0
X_18990_ _12157_ _09513_ VSS VSS VDD VDD _09793_ sky130_fd_sc_hd__nor2_1
X_18991_ _09375_ _09792_ _09793_ _09431_ VSS VSS VDD VDD _09794_
+ sky130_fd_sc_hd__a211oi_1
X_18992_ _09391_ _09791_ _09794_ VSS VSS VDD VDD _09795_ sky130_fd_sc_hd__nor3_1
X_18993_ _09391_ _09788_ _09795_ _09497_ VSS VSS VDD VDD _09796_
+ sky130_fd_sc_hd__a211oi_1
X_18994_ net437 net740 _09479_ _09620_ VSS VSS VDD VDD _09797_
+ sky130_fd_sc_hd__nor4_1
X_18995_ _09375_ _09673_ _09433_ VSS VSS VDD VDD _09798_ sky130_fd_sc_hd__o21ai_1
X_18996_ net740 _09615_ _09452_ _09668_ VSS VSS VDD VDD _09799_
+ sky130_fd_sc_hd__o211ai_1
X_18997_ _09797_ _09798_ _09799_ VSS VSS VDD VDD _09800_ sky130_fd_sc_hd__o21ai_0
X_18998_ _12161_ _09427_ VSS VSS VDD VDD _09801_ sky130_fd_sc_hd__nand2_1
X_18999_ _12170_ net436 _09412_ VSS VSS VDD VDD _09802_ sky130_fd_sc_hd__o21ai_0
X_19000_ _09628_ net436 _09668_ VSS VSS VDD VDD _09803_ sky130_fd_sc_hd__nor3b_1
X_19001_ net436 _09537_ _09572_ _09803_ _09391_ VSS VSS VDD
+ VDD _09804_ sky130_fd_sc_hd__a311oi_1
X_19002_ _09391_ _09801_ _09802_ _09804_ net741 VSS VSS VDD
+ VDD _09805_ sky130_fd_sc_hd__a311oi_1
X_19003_ _09525_ _09800_ _09805_ VSS VSS VDD VDD _09806_ sky130_fd_sc_hd__nor3_1
X_19004_ net742 _09391_ VSS VSS VDD VDD _09807_ sky130_fd_sc_hd__nand2_1
X_19005_ _09391_ _09559_ _09807_ VSS VSS VDD VDD _09808_ sky130_fd_sc_hd__o21ai_0
X_19006_ _12161_ net435 _09714_ _09709_ _09531_ VSS VSS VDD
+ VDD _09809_ sky130_fd_sc_hd__o32ai_1
X_19007_ _09438_ _09808_ _09809_ _09431_ VSS VSS VDD VDD _09810_
+ sky130_fd_sc_hd__a211oi_1
X_19008_ _09375_ _09714_ VSS VSS VDD VDD _09811_ sky130_fd_sc_hd__nor2_1
X_19009_ _09466_ _09811_ net531 VSS VSS VDD VDD _09812_ sky130_fd_sc_hd__o21ai_0
X_19010_ net740 _09614_ VSS VSS VDD VDD _09813_ sky130_fd_sc_hd__nor2_1
X_19011_ net436 _09813_ _09803_ VSS VSS VDD VDD _09814_ sky130_fd_sc_hd__a21oi_1
X_19012_ net434 _09465_ _09415_ VSS VSS VDD VDD _09815_ sky130_fd_sc_hd__nor3_1
X_19013_ net434 _09534_ _09572_ _09815_ _09432_ VSS VSS VDD
+ VDD _09816_ sky130_fd_sc_hd__a311oi_1
X_19014_ _09432_ _09814_ _09816_ VSS VSS VDD VDD _09817_ sky130_fd_sc_hd__a21oi_1
X_19015_ _09810_ _09812_ _09817_ _09431_ _09525_ VSS VSS VDD
+ VDD _09818_ sky130_fd_sc_hd__a221oi_2
X_19016_ net435 _09448_ VSS VSS VDD VDD _09819_ sky130_fd_sc_hd__nand2_1
X_19017_ _09753_ _09819_ _09391_ VSS VSS VDD VDD _09820_ sky130_fd_sc_hd__a21oi_1
X_19018_ _12161_ _09412_ _09427_ _12166_ _09432_ VSS VSS VDD
+ VDD _09821_ sky130_fd_sc_hd__a221oi_1
X_19019_ _09375_ _09474_ _09475_ _09821_ VSS VSS VDD VDD _09822_
+ sky130_fd_sc_hd__o31a_1
X_19020_ net435 _09537_ _09723_ VSS VSS VDD VDD _09823_ sky130_fd_sc_hd__nand3_1
X_19021_ _09370_ _09375_ net740 VSS VSS VDD VDD _09824_ sky130_fd_sc_hd__nand3_1
X_19022_ _09452_ _09823_ _09824_ _09497_ VSS VSS VDD VDD _09825_
+ sky130_fd_sc_hd__a31oi_1
X_19023_ net435 _09517_ _09519_ _09424_ _09433_ VSS VSS VDD
+ VDD _09826_ sky130_fd_sc_hd__o311ai_0
X_19024_ net741 _09820_ _09822_ _09825_ _09826_ VSS VSS VDD
+ VDD _09827_ sky130_fd_sc_hd__o311ai_0
X_19025_ _09460_ _09827_ VSS VSS VDD VDD _09828_ sky130_fd_sc_hd__nand2_1
X_19026_ _09460_ _09796_ _09806_ _09818_ _09828_ VSS VSS VDD
+ VDD _00085_ sky130_fd_sc_hd__o32ai_4
X_19027_ _12156_ net740 _09723_ VSS VSS VDD VDD _09829_ sky130_fd_sc_hd__o21ai_0
X_19028_ _12158_ _09466_ _09829_ net436 VSS VSS VDD VDD _09830_
+ sky130_fd_sc_hd__a22oi_1
X_19029_ _09406_ _09482_ VSS VSS VDD VDD _09831_ sky130_fd_sc_hd__nor2_1
X_19030_ net434 _09504_ _09723_ VSS VSS VDD VDD _09832_ sky130_fd_sc_hd__nand3_1
X_19031_ net434 _09507_ _09831_ _09832_ _09432_ VSS VSS VDD
+ VDD _09833_ sky130_fd_sc_hd__o311ai_0
X_19032_ _09432_ _09830_ _09833_ VSS VSS VDD VDD _09834_ sky130_fd_sc_hd__o21ai_0
X_19033_ net602 _09374_ _09445_ VSS VSS VDD VDD _09835_ sky130_fd_sc_hd__a21o_1
X_19034_ _12173_ _12182_ net740 _09433_ _09835_ VSS VSS VDD
+ VDD _09836_ sky130_fd_sc_hd__o311ai_1
X_19035_ _09686_ _09573_ _09375_ VSS VSS VDD VDD _09837_ sky130_fd_sc_hd__a21oi_1
X_19036_ net435 _09415_ _09570_ VSS VSS VDD VDD _09838_ sky130_fd_sc_hd__nor3_1
X_19037_ _09837_ _09838_ _09452_ VSS VSS VDD VDD _09839_ sky130_fd_sc_hd__o21ai_1
X_19038_ _09836_ _09839_ VSS VSS VDD VDD _09840_ sky130_fd_sc_hd__nand2_1
X_19039_ _09431_ _09834_ _09840_ VSS VSS VDD VDD _09841_ sky130_fd_sc_hd__a21oi_2
X_19040_ _12175_ net742 VSS VSS VDD VDD _09842_ sky130_fd_sc_hd__nor2_1
X_19041_ _12157_ _09375_ VSS VSS VDD VDD _09843_ sky130_fd_sc_hd__nor2_1
X_19042_ _09375_ _09659_ _09843_ net740 VSS VSS VDD VDD _09844_
+ sky130_fd_sc_hd__a211oi_2
X_19043_ net435 _09465_ _09420_ _09433_ _09718_ VSS VSS VDD
+ VDD _09845_ sky130_fd_sc_hd__o311ai_4
X_19044_ net742 _09482_ _09375_ VSS VSS VDD VDD _09846_ sky130_fd_sc_hd__a21oi_1
X_19045_ _09375_ _09537_ _09446_ _09846_ _09753_ VSS VSS VDD
+ VDD _09847_ sky130_fd_sc_hd__a32oi_1
X_19046_ _09364_ _09694_ net742 VSS VSS VDD VDD _09848_ sky130_fd_sc_hd__a21oi_1
X_19047_ _09473_ _09750_ _09848_ VSS VSS VDD VDD _09849_ sky130_fd_sc_hd__nor3_1
X_19048_ _09452_ _09847_ _09849_ _09588_ VSS VSS VDD VDD _09850_
+ sky130_fd_sc_hd__a211oi_2
X_19049_ _09744_ _09842_ _09844_ _09845_ _09850_ VSS VSS VDD
+ VDD _09851_ sky130_fd_sc_hd__o311ai_4
X_19050_ _09693_ _09793_ VSS VSS VDD VDD _09852_ sky130_fd_sc_hd__nor2_1
X_19051_ _12166_ _09375_ net740 _09436_ VSS VSS VDD VDD _09853_
+ sky130_fd_sc_hd__a211o_1
X_19052_ _12174_ net740 _09509_ VSS VSS VDD VDD _09854_ sky130_fd_sc_hd__a21oi_1
X_19053_ _09853_ _09854_ _09432_ VSS VSS VDD VDD _09855_ sky130_fd_sc_hd__a21oi_1
X_19054_ _09499_ _09852_ _09855_ VSS VSS VDD VDD _09856_ sky130_fd_sc_hd__o21ai_0
X_19055_ net437 _09620_ _09522_ VSS VSS VDD VDD _09857_ sky130_fd_sc_hd__a21oi_1
X_19056_ net437 _09580_ _09479_ VSS VSS VDD VDD _09858_ sky130_fd_sc_hd__a21oi_1
X_19057_ _12170_ _09857_ _09858_ VSS VSS VDD VDD _09859_ sky130_fd_sc_hd__o21ai_0
X_19058_ net740 _09438_ _09659_ VSS VSS VDD VDD _09860_ sky130_fd_sc_hd__a21oi_1
X_19059_ _09385_ _09628_ _09436_ VSS VSS VDD VDD _09861_ sky130_fd_sc_hd__o21ai_0
X_19060_ _09431_ _09860_ _09861_ _09460_ VSS VSS VDD VDD _09862_
+ sky130_fd_sc_hd__o211ai_1
X_19061_ _09431_ _09859_ _09862_ VSS VSS VDD VDD _09863_ sky130_fd_sc_hd__a21oi_1
X_19062_ net602 _09583_ _09724_ _09385_ VSS VSS VDD VDD _09864_
+ sky130_fd_sc_hd__a211oi_1
X_19063_ _09364_ _09385_ _09764_ _09375_ VSS VSS VDD VDD _09865_
+ sky130_fd_sc_hd__o211ai_1
X_19064_ _12166_ _09431_ net740 VSS VSS VDD VDD _09866_ sky130_fd_sc_hd__o21ai_0
X_19065_ _09431_ _09537_ _09866_ net434 VSS VSS VDD VDD _09867_
+ sky130_fd_sc_hd__o211ai_1
X_19066_ _09460_ _09432_ VSS VSS VDD VDD _09868_ sky130_fd_sc_hd__nand2_1
X_19067_ _09431_ _09522_ _09865_ _09867_ _09868_ VSS VSS VDD
+ VDD _09869_ sky130_fd_sc_hd__a221o_1
X_19068_ _09487_ _09651_ _09864_ _09869_ _09497_ VSS VSS VDD
+ VDD _09870_ sky130_fd_sc_hd__o311a_1
X_19069_ _09856_ _09863_ _09870_ VSS VSS VDD VDD _09871_ sky130_fd_sc_hd__o21ai_1
X_19070_ _09486_ _09497_ _09841_ _09851_ _09871_ VSS VSS VDD
+ VDD _00086_ sky130_fd_sc_hd__o311ai_4
X_19071_ _12182_ net742 VSS VSS VDD VDD _09872_ sky130_fd_sc_hd__nor2_1
X_19072_ _12166_ net435 net740 _09535_ VSS VSS VDD VDD _09873_
+ sky130_fd_sc_hd__a211oi_1
X_19073_ _09391_ _09872_ _09873_ VSS VSS VDD VDD _09874_ sky130_fd_sc_hd__nor3_1
X_19074_ _12158_ _09375_ net740 VSS VSS VDD VDD _09875_ sky130_fd_sc_hd__a21oi_1
X_19075_ _12168_ net740 _09432_ _09875_ VSS VSS VDD VDD _09876_
+ sky130_fd_sc_hd__a211oi_2
X_19076_ _09566_ _09410_ _09375_ VSS VSS VDD VDD _09877_ sky130_fd_sc_hd__o21ai_0
X_19077_ _09375_ _09531_ _09410_ _09877_ _09432_ VSS VSS VDD
+ VDD _09878_ sky130_fd_sc_hd__o311ai_1
X_19078_ _12161_ _09375_ VSS VSS VDD VDD _09879_ sky130_fd_sc_hd__nor2_1
X_19079_ _09536_ _09879_ net740 VSS VSS VDD VDD _09880_ sky130_fd_sc_hd__o21ai_0
X_19080_ _09531_ _09694_ _09432_ VSS VSS VDD VDD _09881_ sky130_fd_sc_hd__a21oi_1
X_19081_ _09880_ _09881_ VSS VSS VDD VDD _09882_ sky130_fd_sc_hd__nand2_1
X_19082_ _09431_ _09878_ _09882_ VSS VSS VDD VDD _09883_ sky130_fd_sc_hd__nand3_1
X_19083_ net435 _09420_ _09559_ VSS VSS VDD VDD _09884_ sky130_fd_sc_hd__nor3b_1
X_19084_ _09480_ _09884_ _09452_ VSS VSS VDD VDD _09885_ sky130_fd_sc_hd__o21ai_1
X_19085_ _09668_ _09606_ net435 VSS VSS VDD VDD _09886_ sky130_fd_sc_hd__a21o_1
X_19086_ _09433_ _09604_ _09886_ VSS VSS VDD VDD _09887_ sky130_fd_sc_hd__nand3_1
X_19087_ _09591_ _09750_ VSS VSS VDD VDD _09888_ sky130_fd_sc_hd__nor2_1
X_19088_ _09888_ _09835_ _09486_ VSS VSS VDD VDD _09889_ sky130_fd_sc_hd__a21oi_1
X_19089_ _09504_ _09723_ net436 VSS VSS VDD VDD _09890_ sky130_fd_sc_hd__a21oi_1
X_19090_ _09513_ _09482_ _09534_ VSS VSS VDD VDD _09891_ sky130_fd_sc_hd__o21ai_0
X_19091_ _09890_ _09891_ _09578_ VSS VSS VDD VDD _09892_ sky130_fd_sc_hd__o21ai_2
X_19092_ _09885_ _09887_ _09889_ _09892_ _09497_ VSS VSS VDD
+ VDD _09893_ sky130_fd_sc_hd__a41oi_4
X_19093_ _09431_ _09874_ _09876_ _09883_ _09893_ VSS VSS VDD
+ VDD _09894_ sky130_fd_sc_hd__o311ai_4
X_19094_ _09375_ net741 net531 VSS VSS VDD VDD _09895_ sky130_fd_sc_hd__o21ai_0
X_19095_ net531 net741 _09895_ VSS VSS VDD VDD _09896_ sky130_fd_sc_hd__o21ai_0
X_19096_ net740 _09479_ _09364_ VSS VSS VDD VDD _09897_ sky130_fd_sc_hd__o21ai_0
X_19097_ net740 _09896_ _09897_ VSS VSS VDD VDD _09898_ sky130_fd_sc_hd__a21oi_1
X_19098_ _09375_ net741 _09643_ _12157_ _09898_ VSS VSS VDD
+ VDD _09899_ sky130_fd_sc_hd__a221oi_2
X_19099_ net531 _09583_ _09522_ VSS VSS VDD VDD _09900_ sky130_fd_sc_hd__a21oi_1
X_19100_ _09466_ _09695_ _09364_ VSS VSS VDD VDD _09901_ sky130_fd_sc_hd__o21ai_0
X_19101_ _09408_ _09446_ _09364_ VSS VSS VDD VDD _09902_ sky130_fd_sc_hd__a21oi_1
X_19102_ _09474_ _09902_ net741 VSS VSS VDD VDD _09903_ sky130_fd_sc_hd__o21ai_0
X_19103_ net741 _09900_ _09901_ _09391_ _09903_ VSS VSS VDD
+ VDD _09904_ sky130_fd_sc_hd__o2111ai_1
X_19104_ net434 net742 VSS VSS VDD VDD _09905_ sky130_fd_sc_hd__xnor2_1
X_19105_ _12157_ _09905_ _09583_ _12170_ _09500_ VSS VSS VDD
+ VDD _09906_ sky130_fd_sc_hd__a221oi_1
X_19106_ _12156_ net434 net740 VSS VSS VDD VDD _09907_ sky130_fd_sc_hd__nand3_1
X_19107_ _09564_ _09578_ _09907_ VSS VSS VDD VDD _09908_ sky130_fd_sc_hd__nand3_1
X_19108_ _09504_ _09824_ net437 VSS VSS VDD VDD _09909_ sky130_fd_sc_hd__a21oi_1
X_19109_ _09750_ _09906_ _09908_ _09909_ VSS VSS VDD VDD _09910_
+ sky130_fd_sc_hd__o22a_1
X_19110_ _09375_ _09559_ _09632_ VSS VSS VDD VDD _09911_ sky130_fd_sc_hd__nand3_1
X_19111_ _09375_ _09644_ _09911_ _09452_ VSS VSS VDD VDD _09912_
+ sky130_fd_sc_hd__o211ai_2
X_19112_ _12166_ net434 net742 VSS VSS VDD VDD _09913_ sky130_fd_sc_hd__nor3_1
X_19113_ net434 _09573_ _09559_ _09913_ VSS VSS VDD VDD _09914_
+ sky130_fd_sc_hd__a31oi_1
X_19114_ _09433_ _09914_ _09486_ VSS VSS VDD VDD _09915_ sky130_fd_sc_hd__a21oi_1
X_19115_ _09910_ _09912_ _09915_ _09525_ VSS VSS VDD VDD _09916_
+ sky130_fd_sc_hd__a31oi_4
X_19116_ _09391_ _09899_ _09904_ _09916_ VSS VSS VDD VDD _09917_
+ sky130_fd_sc_hd__o211ai_1
X_19117_ _09893_ _09916_ _09460_ VSS VSS VDD VDD _09918_ sky130_fd_sc_hd__o21ai_0
X_19118_ _09894_ _09917_ _09918_ VSS VSS VDD VDD _00087_ sky130_fd_sc_hd__nand3_1
X_19119_ sa10_sub\[0\] sa21_sub\[0\] sa03_sr\[1\] VSS VSS
+ VDD VDD _09919_ sky130_fd_sc_hd__xnor3_1
X_19120_ _07660_ _07692_ _09919_ VSS VSS VDD VDD _09920_ sky130_fd_sc_hd__xnor3_4
X_19121_ text_in_r\[17\] _09920_ net491 VSS VSS VDD VDD _09921_
+ sky130_fd_sc_hd__mux2i_4
X_19122_ u0.tmp_w\[17\] _09921_ VSS VSS VDD VDD _09922_ sky130_fd_sc_hd__xor2_4
X_19123_ net554 VSS VSS VDD VDD _09923_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_22_561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19126_ sa03_sr\[0\] sa32_sub\[0\] VSS VSS VDD VDD _09925_
+ sky130_fd_sc_hd__xor2_1
X_19127_ sa21_sub\[0\] _07692_ _09925_ VSS VSS VDD VDD _09926_
+ sky130_fd_sc_hd__xnor3_1
X_19128_ text_in_r\[16\] _09926_ net490 VSS VSS VDD VDD _09927_
+ sky130_fd_sc_hd__mux2i_4
X_19129_ _09927_ u0.tmp_w\[16\] VSS VSS VDD VDD _09928_ sky130_fd_sc_hd__xor2_4
X_19130_ _09928_ VSS VSS VDD VDD _09929_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_22_559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19133_ sa32_sub\[2\] sa03_sr\[2\] VSS VSS VDD VDD _09931_
+ sky130_fd_sc_hd__xor2_2
X_19134_ sa10_sub\[1\] sa21_sub\[1\] sa21_sub\[2\] VSS VSS
+ VDD VDD _09932_ sky130_fd_sc_hd__xnor3_2
X_19135_ _09931_ _09932_ VSS VSS VDD VDD _09933_ sky130_fd_sc_hd__xnor2_4
X_19136_ text_in_r\[18\] _09933_ net547 VSS VSS VDD VDD _09934_
+ sky130_fd_sc_hd__mux2i_4
X_19137_ u0.tmp_w\[18\] _09934_ VSS VSS VDD VDD _09935_ sky130_fd_sc_hd__xnor2_4
X_19138_ net430 VSS VSS VDD VDD _09936_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_22_557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19146_ sa32_sub\[6\] sa03_sr\[6\] VSS VSS VDD VDD _09941_
+ sky130_fd_sc_hd__xnor2_4
X_19147_ sa21_sub\[6\] _07700_ _09941_ VSS VSS VDD VDD _09942_
+ sky130_fd_sc_hd__xor3_1
X_19148_ text_in_r\[22\] _09942_ net512 VSS VSS VDD VDD _09943_
+ sky130_fd_sc_hd__mux2i_4
X_19149_ u0.tmp_w\[22\] _09943_ VSS VSS VDD VDD _09944_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_22_550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19151_ sa21_sub\[6\] sa32_sub\[7\] VSS VSS VDD VDD _09946_
+ sky130_fd_sc_hd__xnor2_1
X_19152_ sa03_sr\[7\] sa10_sub\[6\] sa21_sub\[7\] VSS VSS
+ VDD VDD _09947_ sky130_fd_sc_hd__xnor3_1
X_19153_ _09946_ _09947_ VSS VSS VDD VDD _09948_ sky130_fd_sc_hd__xor2_1
X_19154_ text_in_r\[23\] _09948_ net512 VSS VSS VDD VDD _09949_
+ sky130_fd_sc_hd__mux2i_4
X_19155_ u0.tmp_w\[23\] _09949_ VSS VSS VDD VDD _09950_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_22_549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19157_ _09944_ _09950_ VSS VSS VDD VDD _09952_ sky130_fd_sc_hd__nor2_1
X_19158_ sa21_sub\[4\] sa32_sub\[5\] sa03_sr\[5\] VSS VSS
+ VDD VDD _09953_ sky130_fd_sc_hd__xnor3_4
X_19159_ sa10_sub\[4\] sa21_sub\[5\] VSS VSS VDD VDD _09954_
+ sky130_fd_sc_hd__xor2_1
X_19160_ _09953_ _09954_ VSS VSS VDD VDD _09955_ sky130_fd_sc_hd__xnor2_2
X_19161_ text_in_r\[21\] _09955_ net512 VSS VSS VDD VDD _09956_
+ sky130_fd_sc_hd__mux2i_4
X_19162_ u0.tmp_w\[21\] _09956_ VSS VSS VDD VDD _09957_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_22_548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19166_ ld_r u0.tmp_w\[19\] VSS VSS VDD VDD _09961_ sky130_fd_sc_hd__nor2b_1
X_19167_ u0.tmp_w\[19\] ld_r VSS VSS VDD VDD _09962_ sky130_fd_sc_hd__nor2_1
X_19168_ sa10_sub\[7\] sa10_sub\[2\] VSS VSS VDD VDD _09963_
+ sky130_fd_sc_hd__xnor2_1
X_19169_ sa21_sub\[2\] sa32_sub\[3\] sa21_sub\[7\] VSS VSS
+ VDD VDD _09964_ sky130_fd_sc_hd__xnor3_1
X_19170_ sa21_sub\[3\] sa03_sr\[3\] VSS VSS VDD VDD _09965_
+ sky130_fd_sc_hd__xnor2_1
X_19171_ _09963_ _09964_ _09965_ VSS VSS VDD VDD _09966_ sky130_fd_sc_hd__xnor3_4
X_19172_ _09961_ _09962_ _09966_ VSS VSS VDD VDD _09967_ sky130_fd_sc_hd__mux2i_4
X_19173_ u0.tmp_w\[19\] net547 VSS VSS VDD VDD _09968_ sky130_fd_sc_hd__nor2_1
X_19174_ u0.tmp_w\[19\] net530 VSS VSS VDD VDD _09969_ sky130_fd_sc_hd__nand2_1
X_19175_ text_in_r\[19\] _09969_ VSS VSS VDD VDD _09970_ sky130_fd_sc_hd__nor2_1
X_19176_ text_in_r\[19\] _09968_ _09970_ VSS VSS VDD VDD _09971_
+ sky130_fd_sc_hd__a21oi_4
X_19177_ _09967_ _09971_ VSS VSS VDD VDD _09972_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_22_545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19180_ net555 _09972_ VSS VSS VDD VDD _09975_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_22_543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19182_ _09967_ _09971_ VSS VSS VDD VDD _09977_ sky130_fd_sc_hd__nand2_8
X_19183_ _12202_ _09977_ VSS VSS VDD VDD _09978_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_22_542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19186_ _09975_ _09978_ net430 VSS VSS VDD VDD _09981_ sky130_fd_sc_hd__a21oi_1
X_19187_ _12189_ VSS VSS VDD VDD _09982_ sky130_fd_sc_hd__clkinvlp_4
X_19188_ net432 _09977_ VSS VSS VDD VDD _09983_ sky130_fd_sc_hd__nand2_8
X_19189_ _09929_ _09972_ VSS VSS VDD VDD _09984_ sky130_fd_sc_hd__nand2_4
X_19190_ _09982_ _09983_ _09984_ VSS VSS VDD VDD _09985_ sky130_fd_sc_hd__o21ai_0
X_19191_ sa21_sub\[3\] sa32_sub\[4\] VSS VSS VDD VDD _09986_
+ sky130_fd_sc_hd__xnor2_1
X_19192_ sa10_sub\[3\] sa21_sub\[4\] sa03_sr\[4\] VSS VSS
+ VDD VDD _09987_ sky130_fd_sc_hd__xnor3_1
X_19193_ _07692_ _09986_ _09987_ VSS VSS VDD VDD _09988_ sky130_fd_sc_hd__xnor3_1
X_19194_ text_in_r\[20\] _09988_ net512 VSS VSS VDD VDD _09989_
+ sky130_fd_sc_hd__mux2i_4
X_19195_ u0.tmp_w\[20\] _09989_ VSS VSS VDD VDD _09990_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_22_540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19197_ _09981_ _09985_ _09990_ VSS VSS VDD VDD _09992_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_21_539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19199_ _09923_ _09972_ VSS VSS VDD VDD _09994_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_21_538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19202_ net521 _09936_ VSS VSS VDD VDD _09997_ sky130_fd_sc_hd__nand2_1
X_19203_ u0.tmp_w\[20\] _09989_ VSS VSS VDD VDD _09998_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_21_536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19207_ _12193_ _09983_ _09994_ _09997_ net428 VSS VSS VDD
+ VDD _10002_ sky130_fd_sc_hd__o221ai_1
XTAP_TAPCELL_ROW_21_533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19209_ _09936_ _09972_ VSS VSS VDD VDD _10004_ sky130_fd_sc_hd__nand2_4
X_19210_ net498 _09983_ _10004_ VSS VSS VDD VDD _10005_ sky130_fd_sc_hd__o21ai_0
X_19211_ _09935_ _09972_ VSS VSS VDD VDD _10006_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_21_532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19213_ net432 _09972_ VSS VSS VDD VDD _10008_ sky130_fd_sc_hd__nand2_1
X_19214_ _12190_ _10008_ VSS VSS VDD VDD _10009_ sky130_fd_sc_hd__nor2_1
X_19215_ _09923_ _10005_ _10006_ net498 _10009_ VSS VSS VDD
+ VDD _10010_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_21_531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19217_ _09923_ _09972_ VSS VSS VDD VDD _10012_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_21_530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19219_ _09923_ _09977_ VSS VSS VDD VDD _10014_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_21_529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19221_ _10014_ _09997_ _09990_ VSS VSS VDD VDD _10016_ sky130_fd_sc_hd__o21ai_0
X_19222_ net430 _09978_ _10012_ _10016_ VSS VSS VDD VDD _10017_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_21_528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19224_ net428 _10010_ _10017_ _09957_ VSS VSS VDD VDD _10019_
+ sky130_fd_sc_hd__a211oi_1
X_19225_ _09957_ _09992_ _10002_ _10019_ VSS VSS VDD VDD _10020_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_21_527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19228_ _09929_ _09977_ VSS VSS VDD VDD _10023_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_21_525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19231_ _12189_ _09977_ VSS VSS VDD VDD _10026_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_21_523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19233_ _12196_ _09972_ VSS VSS VDD VDD _10028_ sky130_fd_sc_hd__nor2_1
X_19234_ net432 _10026_ _10028_ VSS VSS VDD VDD _10029_ sky130_fd_sc_hd__nor3_1
X_19235_ net432 _09975_ _10023_ _10029_ VSS VSS VDD VDD _10030_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_21_522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19237_ _12193_ _09972_ VSS VSS VDD VDD _10032_ sky130_fd_sc_hd__nor2_1
X_19238_ _12190_ _09977_ VSS VSS VDD VDD _10033_ sky130_fd_sc_hd__nor2_4
X_19239_ _10032_ _10033_ net432 VSS VSS VDD VDD _10034_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_21_521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19241_ net430 _09977_ VSS VSS VDD VDD _10036_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_21_520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19243_ _12188_ _10036_ net428 VSS VSS VDD VDD _10038_ sky130_fd_sc_hd__a21oi_1
X_19244_ net428 _10030_ _10034_ _10038_ _09944_ VSS VSS VDD
+ VDD _10039_ sky130_fd_sc_hd__a221oi_1
X_19245_ u0.tmp_w\[22\] _09943_ VSS VSS VDD VDD _10040_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_21_519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19248_ _12198_ VSS VSS VDD VDD _10043_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_21_517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19250_ _09936_ net428 VSS VSS VDD VDD _10045_ sky130_fd_sc_hd__nand2_1
X_19251_ _10043_ _10045_ VSS VSS VDD VDD _10046_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_20_516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19253_ _12190_ net429 VSS VSS VDD VDD _10048_ sky130_fd_sc_hd__nand2_1
X_19254_ _09923_ net518 VSS VSS VDD VDD _10049_ sky130_fd_sc_hd__nand2_1
X_19255_ _09998_ _10049_ VSS VSS VDD VDD _10050_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_20_515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19258_ _10048_ _10050_ _09936_ VSS VSS VDD VDD _10053_ sky130_fd_sc_hd__a21oi_1
X_19259_ _10040_ _09972_ _10046_ _10053_ VSS VSS VDD VDD _10054_
+ sky130_fd_sc_hd__nor4_1
XTAP_TAPCELL_ROW_20_513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19262_ _09923_ net519 _09998_ VSS VSS VDD VDD _10057_ sky130_fd_sc_hd__a21oi_1
X_19263_ _12190_ _09998_ _10057_ VSS VSS VDD VDD _10058_ sky130_fd_sc_hd__a21oi_1
X_19264_ _09936_ net429 VSS VSS VDD VDD _10059_ sky130_fd_sc_hd__nand2_1
X_19265_ _09936_ _10058_ _10059_ _12196_ VSS VSS VDD VDD _10060_
+ sky130_fd_sc_hd__o22ai_1
X_19266_ _10040_ _09977_ _10060_ _09950_ _09957_ VSS VSS VDD
+ VDD _10061_ sky130_fd_sc_hd__o311ai_0
X_19267_ _10039_ _10054_ _10061_ VSS VSS VDD VDD _10062_ sky130_fd_sc_hd__nor3_1
X_19268_ net430 _09972_ VSS VSS VDD VDD _10063_ sky130_fd_sc_hd__xnor2_4
X_19269_ _12189_ _09983_ VSS VSS VDD VDD _10064_ sky130_fd_sc_hd__nor2_2
X_19270_ _12196_ _10036_ _10063_ _12188_ _10064_ VSS VSS VDD
+ VDD _10065_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_20_511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19273_ net433 _09936_ VSS VSS VDD VDD _10068_ sky130_fd_sc_hd__nand2_1
X_19274_ _12189_ net430 VSS VSS VDD VDD _10069_ sky130_fd_sc_hd__nor2_1
X_19275_ _12189_ _09972_ _10068_ _10069_ _09975_ VSS VSS VDD
+ VDD _10070_ sky130_fd_sc_hd__a32oi_1
X_19276_ _09990_ _10070_ VSS VSS VDD VDD _10071_ sky130_fd_sc_hd__nand2_1
X_19277_ _09990_ _10065_ _10071_ VSS VSS VDD VDD _10072_ sky130_fd_sc_hd__o21ai_0
X_19278_ u0.tmp_w\[21\] _09956_ VSS VSS VDD VDD _10073_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_20_509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19281_ _10040_ _09950_ VSS VSS VDD VDD _10076_ sky130_fd_sc_hd__nor2_2
X_19282_ _10073_ _10076_ VSS VSS VDD VDD _10077_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_20_507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19284_ net433 net498 VSS VSS VDD VDD _10079_ sky130_fd_sc_hd__nand2_1
X_19285_ _09929_ net431 VSS VSS VDD VDD _10080_ sky130_fd_sc_hd__nand2_4
X_19286_ _10079_ _10080_ VSS VSS VDD VDD _10081_ sky130_fd_sc_hd__nand2_1
X_19287_ _09977_ _10081_ VSS VSS VDD VDD _10082_ sky130_fd_sc_hd__xnor2_1
X_19288_ net521 _09977_ VSS VSS VDD VDD _10083_ sky130_fd_sc_hd__nor2_4
X_19289_ _12188_ _09977_ _10083_ _09923_ net430 VSS VSS VDD
+ VDD _10084_ sky130_fd_sc_hd__a221oi_1
X_19290_ _09982_ _09972_ VSS VSS VDD VDD _10085_ sky130_fd_sc_hd__nand2_2
X_19291_ _12196_ _09977_ VSS VSS VDD VDD _10086_ sky130_fd_sc_hd__nand2_4
X_19292_ net430 _10085_ _10086_ VSS VSS VDD VDD _10087_ sky130_fd_sc_hd__nand3_1
X_19293_ net428 _10087_ VSS VSS VDD VDD _10088_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_20_506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19295_ u0.tmp_w\[23\] _09949_ VSS VSS VDD VDD _10090_ sky130_fd_sc_hd__xor2_4
X_19296_ _09944_ _10090_ VSS VSS VDD VDD _10091_ sky130_fd_sc_hd__nand2_2
X_19297_ _10073_ _10091_ VSS VSS VDD VDD _10092_ sky130_fd_sc_hd__nor2_1
X_19298_ net428 _10082_ _10084_ _10088_ _10092_ VSS VSS VDD
+ VDD _10093_ sky130_fd_sc_hd__o221ai_1
X_19299_ net433 _09929_ _09936_ VSS VSS VDD VDD _10094_ sky130_fd_sc_hd__nor3_2
X_19300_ _12193_ net432 VSS VSS VDD VDD _10095_ sky130_fd_sc_hd__nor2_2
X_19301_ _09977_ _10094_ _10095_ net428 VSS VSS VDD VDD _10096_
+ sky130_fd_sc_hd__o31ai_4
X_19302_ _12188_ _09983_ VSS VSS VDD VDD _10097_ sky130_fd_sc_hd__nor2_2
X_19303_ _12190_ _09972_ VSS VSS VDD VDD _10098_ sky130_fd_sc_hd__nand2_1
X_19304_ _10023_ _10098_ net430 VSS VSS VDD VDD _10099_ sky130_fd_sc_hd__a21oi_1
X_19305_ _12189_ _09936_ VSS VSS VDD VDD _10100_ sky130_fd_sc_hd__nand2_1
X_19306_ _12209_ _09977_ VSS VSS VDD VDD _10101_ sky130_fd_sc_hd__nand2_1
X_19307_ _09977_ _10100_ _10101_ _09990_ VSS VSS VDD VDD _10102_
+ sky130_fd_sc_hd__o211ai_1
X_19308_ _09944_ _09950_ VSS VSS VDD VDD _10103_ sky130_fd_sc_hd__nand2_1
X_19309_ _09957_ _10103_ VSS VSS VDD VDD _10104_ sky130_fd_sc_hd__nor2_1
X_19310_ _10096_ _10097_ _10099_ _10102_ _10104_ VSS VSS VDD
+ VDD _10105_ sky130_fd_sc_hd__o311ai_1
X_19311_ net433 net518 VSS VSS VDD VDD _10106_ sky130_fd_sc_hd__nor2_4
X_19312_ _09972_ _10106_ VSS VSS VDD VDD _10107_ sky130_fd_sc_hd__nor2_2
X_19313_ _12198_ _09972_ VSS VSS VDD VDD _10108_ sky130_fd_sc_hd__nand2_4
X_19314_ _12189_ _09977_ VSS VSS VDD VDD _10109_ sky130_fd_sc_hd__nand2_4
X_19315_ _09944_ _10090_ VSS VSS VDD VDD _10110_ sky130_fd_sc_hd__nor2_1
X_19316_ _10073_ _10110_ VSS VSS VDD VDD _10111_ sky130_fd_sc_hd__nand2_1
X_19317_ net432 net429 _10108_ _10109_ _10111_ VSS VSS VDD
+ VDD _10112_ sky130_fd_sc_hd__a41oi_2
X_19318_ _12193_ _09977_ VSS VSS VDD VDD _10113_ sky130_fd_sc_hd__nor2_2
X_19319_ net520 _09977_ VSS VSS VDD VDD _10114_ sky130_fd_sc_hd__nand2_2
X_19320_ net429 _10114_ VSS VSS VDD VDD _10115_ sky130_fd_sc_hd__nor2_1
X_19321_ _10113_ _10115_ _09936_ VSS VSS VDD VDD _10116_ sky130_fd_sc_hd__o21ai_1
X_19322_ _09936_ net429 _10107_ _10112_ _10116_ VSS VSS VDD
+ VDD _10117_ sky130_fd_sc_hd__o311ai_4
X_19323_ _10072_ _10077_ _10093_ _10105_ _10117_ VSS VSS VDD
+ VDD _10118_ sky130_fd_sc_hd__o2111ai_1
X_19324_ _09952_ _10020_ _10062_ _10118_ VSS VSS VDD VDD _00088_
+ sky130_fd_sc_hd__a211o_1
X_19325_ _09923_ _10083_ VSS VSS VDD VDD _10119_ sky130_fd_sc_hd__nand2_2
X_19326_ _09982_ _09977_ VSS VSS VDD VDD _10120_ sky130_fd_sc_hd__nand2_4
X_19327_ _10119_ _10120_ _09936_ VSS VSS VDD VDD _10121_ sky130_fd_sc_hd__a21oi_1
X_19328_ _10073_ _09998_ VSS VSS VDD VDD _10122_ sky130_fd_sc_hd__nand2_4
X_19329_ net498 _10036_ _10121_ _10122_ VSS VSS VDD VDD _10123_
+ sky130_fd_sc_hd__a211oi_1
X_19330_ net433 _09972_ VSS VSS VDD VDD _10124_ sky130_fd_sc_hd__nor2_1
X_19331_ _12188_ _09977_ VSS VSS VDD VDD _10125_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_20_505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19333_ _12193_ _09977_ VSS VSS VDD VDD _10127_ sky130_fd_sc_hd__nand2_1
X_19334_ net520 _09972_ VSS VSS VDD VDD _10128_ sky130_fd_sc_hd__nand2_2
X_19335_ net431 _10127_ _10128_ VSS VSS VDD VDD _10129_ sky130_fd_sc_hd__nand3_1
X_19336_ _10073_ _09990_ VSS VSS VDD VDD _10130_ sky130_fd_sc_hd__nor2_2
X_19337_ net431 _10124_ _10125_ _10129_ _10130_ VSS VSS VDD
+ VDD _10131_ sky130_fd_sc_hd__o311a_1
X_19338_ _09977_ _10106_ _10033_ VSS VSS VDD VDD _10132_ sky130_fd_sc_hd__a21oi_2
X_19339_ _12202_ _09972_ VSS VSS VDD VDD _10133_ sky130_fd_sc_hd__nand2_4
X_19340_ _10120_ _10133_ _09936_ VSS VSS VDD VDD _10134_ sky130_fd_sc_hd__a21oi_1
X_19341_ _09936_ _10132_ _10134_ VSS VSS VDD VDD _10135_ sky130_fd_sc_hd__a21oi_1
X_19342_ _10073_ _09990_ VSS VSS VDD VDD _10136_ sky130_fd_sc_hd__nand2_8
X_19343_ _09957_ net429 VSS VSS VDD VDD _10137_ sky130_fd_sc_hd__nand2_4
X_19344_ _12188_ _09977_ VSS VSS VDD VDD _10138_ sky130_fd_sc_hd__nand2b_1
X_19345_ _10098_ _10138_ _09936_ VSS VSS VDD VDD _10139_ sky130_fd_sc_hd__a21oi_2
X_19346_ _09936_ _10120_ _10128_ _10139_ VSS VSS VDD VDD _10140_
+ sky130_fd_sc_hd__a31oi_1
X_19347_ _10135_ _10136_ _10137_ _10140_ VSS VSS VDD VDD _10141_
+ sky130_fd_sc_hd__o22ai_1
X_19348_ _09950_ _10123_ _10131_ _10141_ VSS VSS VDD VDD _10142_
+ sky130_fd_sc_hd__nor4_1
XTAP_TAPCELL_ROW_20_504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19350_ _12193_ _09972_ VSS VSS VDD VDD _10144_ sky130_fd_sc_hd__nand2_2
X_19351_ _10120_ _10144_ _09936_ VSS VSS VDD VDD _10145_ sky130_fd_sc_hd__a21oi_1
X_19352_ _09936_ _10107_ _10145_ VSS VSS VDD VDD _10146_ sky130_fd_sc_hd__a21oi_1
X_19353_ _09936_ _09978_ VSS VSS VDD VDD _10147_ sky130_fd_sc_hd__nand2_1
X_19354_ _09936_ _09972_ VSS VSS VDD VDD _10148_ sky130_fd_sc_hd__nor2_4
X_19355_ net433 _10148_ _09998_ VSS VSS VDD VDD _10149_ sky130_fd_sc_hd__a21oi_2
X_19356_ _10119_ _10147_ _10149_ VSS VSS VDD VDD _10150_ sky130_fd_sc_hd__nand3_1
X_19357_ net429 _10146_ _10150_ VSS VSS VDD VDD _10151_ sky130_fd_sc_hd__o21ai_0
X_19358_ _09923_ _09977_ VSS VSS VDD VDD _10152_ sky130_fd_sc_hd__nand2_4
X_19359_ _10008_ _10152_ net498 VSS VSS VDD VDD _10153_ sky130_fd_sc_hd__a21oi_1
X_19360_ net498 _10148_ _10036_ _09982_ _10153_ VSS VSS VDD
+ VDD _10154_ sky130_fd_sc_hd__a221oi_4
X_19361_ _12188_ _09972_ VSS VSS VDD VDD _10155_ sky130_fd_sc_hd__nand2_2
X_19362_ net431 _10109_ _10155_ VSS VSS VDD VDD _10156_ sky130_fd_sc_hd__and3_1
X_19363_ _09984_ _10127_ net431 VSS VSS VDD VDD _10157_ sky130_fd_sc_hd__a21oi_1
X_19364_ _10156_ _10157_ VSS VSS VDD VDD _10158_ sky130_fd_sc_hd__nor2_1
X_19365_ _10122_ _10154_ _10158_ _10136_ _09950_ VSS VSS VDD
+ VDD _10159_ sky130_fd_sc_hd__o221ai_1
X_19366_ _09957_ _10151_ _10159_ VSS VSS VDD VDD _10160_ sky130_fd_sc_hd__a21oi_1
X_19367_ _10109_ _10144_ _09936_ VSS VSS VDD VDD _10161_ sky130_fd_sc_hd__a21oi_1
X_19368_ _09936_ _09984_ _10114_ _10161_ VSS VSS VDD VDD _10162_
+ sky130_fd_sc_hd__a31oi_1
X_19369_ _09929_ _09972_ VSS VSS VDD VDD _10163_ sky130_fd_sc_hd__nor2_2
X_19370_ net432 _10163_ _09923_ VSS VSS VDD VDD _10164_ sky130_fd_sc_hd__o21ai_0
X_19371_ _09923_ _10128_ _10164_ _09983_ _10130_ VSS VSS VDD
+ VDD _10165_ sky130_fd_sc_hd__o2111ai_1
X_19372_ _10137_ _10162_ _10165_ VSS VSS VDD VDD _10166_ sky130_fd_sc_hd__o21ai_0
X_19373_ _09923_ _10063_ VSS VSS VDD VDD _10167_ sky130_fd_sc_hd__nand2_1
X_19374_ _12193_ _10004_ _10167_ VSS VSS VDD VDD _10168_ sky130_fd_sc_hd__o21ai_1
X_19375_ _12202_ net430 VSS VSS VDD VDD _10169_ sky130_fd_sc_hd__nand2_1
X_19376_ _10100_ _10169_ _09972_ VSS VSS VDD VDD _10170_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_20_503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19378_ _10096_ _10170_ _10073_ VSS VSS VDD VDD _10172_ sky130_fd_sc_hd__o21ai_0
X_19379_ _09990_ _10168_ _10172_ VSS VSS VDD VDD _10173_ sky130_fd_sc_hd__a21oi_1
X_19380_ _10040_ _10090_ VSS VSS VDD VDD _10174_ sky130_fd_sc_hd__nor2_4
X_19381_ _10166_ _10173_ _10174_ VSS VSS VDD VDD _10175_ sky130_fd_sc_hd__o21ai_1
X_19382_ _12196_ _09936_ VSS VSS VDD VDD _10176_ sky130_fd_sc_hd__and2_0
X_19383_ net433 net518 _09936_ VSS VSS VDD VDD _10177_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_20_502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19385_ _09977_ _10176_ _10177_ _09998_ VSS VSS VDD VDD _10179_
+ sky130_fd_sc_hd__o31ai_2
X_19386_ _12212_ _09957_ _09972_ VSS VSS VDD VDD _10180_ sky130_fd_sc_hd__nor3_1
X_19387_ _09929_ _09936_ VSS VSS VDD VDD _10181_ sky130_fd_sc_hd__nor2_2
X_19388_ net520 net432 VSS VSS VDD VDD _10182_ sky130_fd_sc_hd__nor2_1
X_19389_ _12188_ _09936_ _10181_ VSS VSS VDD VDD _10183_ sky130_fd_sc_hd__a21oi_1
X_19390_ _10181_ _10152_ _10182_ _10183_ _09977_ VSS VSS VDD
+ VDD _10184_ sky130_fd_sc_hd__o32ai_1
X_19391_ _09936_ _09975_ _10152_ VSS VSS VDD VDD _10185_ sky130_fd_sc_hd__nand3_2
X_19392_ _10129_ _10185_ _09957_ VSS VSS VDD VDD _10186_ sky130_fd_sc_hd__a21oi_1
X_19393_ _09957_ _10184_ _10186_ VSS VSS VDD VDD _10187_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_20_501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19395_ _10179_ _10180_ _10187_ _09998_ _10076_ VSS VSS VDD
+ VDD _10189_ sky130_fd_sc_hd__o221ai_2
X_19396_ _09944_ _10142_ _10160_ _10175_ _10189_ VSS VSS VDD
+ VDD _00089_ sky130_fd_sc_hd__o311ai_2
X_19397_ _09923_ net430 VSS VSS VDD VDD _10190_ sky130_fd_sc_hd__nand2_1
X_19398_ _10079_ _10190_ _09972_ VSS VSS VDD VDD _10191_ sky130_fd_sc_hd__a21oi_1
X_19399_ _12212_ _09972_ _10191_ VSS VSS VDD VDD _10192_ sky130_fd_sc_hd__a21oi_1
X_19400_ _10120_ _10155_ net432 VSS VSS VDD VDD _10193_ sky130_fd_sc_hd__a21oi_1
X_19401_ _09975_ _10086_ _09936_ VSS VSS VDD VDD _10194_ sky130_fd_sc_hd__a21oi_1
X_19402_ _10193_ _10194_ net429 VSS VSS VDD VDD _10195_ sky130_fd_sc_hd__o21ai_0
X_19403_ net429 _10192_ _10195_ VSS VSS VDD VDD _10196_ sky130_fd_sc_hd__o21ai_0
X_19404_ _09957_ _10110_ VSS VSS VDD VDD _10197_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_20_500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19406_ net433 _09936_ VSS VSS VDD VDD _10199_ sky130_fd_sc_hd__nor2_1
X_19407_ _10012_ _10068_ VSS VSS VDD VDD _10200_ sky130_fd_sc_hd__nand2_1
X_19408_ _09994_ _10080_ _10199_ _10023_ _10200_ _12189_ VSS
+ VSS VDD VDD _10201_ sky130_fd_sc_hd__a222oi_1
X_19409_ _12209_ _09972_ VSS VSS VDD VDD _10202_ sky130_fd_sc_hd__nand2_1
X_19410_ _09972_ _10094_ _10069_ _10202_ net428 VSS VSS VDD
+ VDD _10203_ sky130_fd_sc_hd__o311ai_0
X_19411_ net428 _10201_ _10203_ VSS VSS VDD VDD _10204_ sky130_fd_sc_hd__o21ai_0
X_19412_ _10111_ _10196_ _10197_ _10204_ VSS VSS VDD VDD _10205_
+ sky130_fd_sc_hd__o22ai_1
X_19413_ _10040_ _10090_ VSS VSS VDD VDD _10206_ sky130_fd_sc_hd__nand2_2
X_19414_ _09936_ _10127_ _10133_ VSS VSS VDD VDD _10207_ sky130_fd_sc_hd__nand3_1
X_19415_ net431 _10023_ _10108_ VSS VSS VDD VDD _10208_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_20_499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19417_ _12198_ _09977_ VSS VSS VDD VDD _10210_ sky130_fd_sc_hd__nand2_1
X_19418_ _12202_ _09977_ VSS VSS VDD VDD _10211_ sky130_fd_sc_hd__nor2_4
X_19419_ _10124_ _10211_ _09936_ VSS VSS VDD VDD _10212_ sky130_fd_sc_hd__o21a_1
X_19420_ net431 _09984_ _10210_ _10212_ _10073_ VSS VSS VDD
+ VDD _10213_ sky130_fd_sc_hd__a311oi_1
X_19421_ _10073_ _10207_ _10208_ _10213_ _09998_ VSS VSS VDD
+ VDD _10214_ sky130_fd_sc_hd__a311oi_1
X_19422_ _09936_ _10108_ _10120_ VSS VSS VDD VDD _10215_ sky130_fd_sc_hd__nand3_1
X_19423_ _12189_ _09972_ VSS VSS VDD VDD _10216_ sky130_fd_sc_hd__nor2_2
X_19424_ _09929_ _09977_ VSS VSS VDD VDD _10217_ sky130_fd_sc_hd__nor2_2
X_19425_ _10216_ _10217_ net431 VSS VSS VDD VDD _10218_ sky130_fd_sc_hd__o21ai_0
X_19426_ net431 _10108_ _10152_ _10095_ _09957_ VSS VSS VDD
+ VDD _10219_ sky130_fd_sc_hd__a311oi_1
X_19427_ _09957_ _10215_ _10218_ _10219_ net429 VSS VSS VDD
+ VDD _10220_ sky130_fd_sc_hd__a311oi_1
X_19428_ net431 _10120_ _10155_ _10006_ _12193_ VSS VSS VDD
+ VDD _10221_ sky130_fd_sc_hd__a32oi_1
X_19429_ _12207_ _09977_ _09957_ VSS VSS VDD VDD _10222_ sky130_fd_sc_hd__a21oi_1
X_19430_ net431 _09977_ _10049_ _10222_ VSS VSS VDD VDD _10223_
+ sky130_fd_sc_hd__o31ai_1
X_19431_ _10073_ _10221_ _10223_ _09998_ VSS VSS VDD VDD _10224_
+ sky130_fd_sc_hd__o211ai_1
X_19432_ _12190_ _12193_ VSS VSS VDD VDD _10225_ sky130_fd_sc_hd__nor2_4
X_19433_ _09929_ _10073_ VSS VSS VDD VDD _10226_ sky130_fd_sc_hd__xnor2_1
X_19434_ net431 _09957_ _09923_ VSS VSS VDD VDD _10227_ sky130_fd_sc_hd__a21oi_1
X_19435_ _09936_ _10226_ _10227_ VSS VSS VDD VDD _10228_ sky130_fd_sc_hd__a21oi_1
X_19436_ _09998_ _09972_ VSS VSS VDD VDD _10229_ sky130_fd_sc_hd__nor2_1
X_19437_ _09936_ _10073_ _10225_ _10228_ _10229_ VSS VSS VDD
+ VDD _10230_ sky130_fd_sc_hd__o311ai_0
X_19438_ net429 _09972_ VSS VSS VDD VDD _10231_ sky130_fd_sc_hd__nand2_1
X_19439_ _12216_ _10073_ _10231_ VSS VSS VDD VDD _10232_ sky130_fd_sc_hd__a21oi_1
X_19440_ _10073_ _10176_ _10177_ _10232_ VSS VSS VDD VDD _10233_
+ sky130_fd_sc_hd__o31ai_1
X_19441_ _10174_ _10224_ _10230_ _10233_ VSS VSS VDD VDD _10234_
+ sky130_fd_sc_hd__nand4_1
X_19442_ _10206_ _10214_ _10220_ _10234_ VSS VSS VDD VDD _10235_
+ sky130_fd_sc_hd__o31ai_2
X_19443_ _09972_ _10100_ _10190_ VSS VSS VDD VDD _10236_ sky130_fd_sc_hd__and3_1
X_19444_ _10094_ _10095_ _09977_ VSS VSS VDD VDD _10237_ sky130_fd_sc_hd__o21ai_0
X_19445_ net428 _10237_ VSS VSS VDD VDD _10238_ sky130_fd_sc_hd__nand2_1
X_19446_ _09936_ _09977_ VSS VSS VDD VDD _10239_ sky130_fd_sc_hd__nor2_4
X_19447_ _10023_ _10133_ net430 VSS VSS VDD VDD _10240_ sky130_fd_sc_hd__a21oi_1
X_19448_ _12193_ _10239_ _10240_ _09994_ VSS VSS VDD VDD _10241_
+ sky130_fd_sc_hd__a211oi_1
X_19449_ _10236_ _10238_ _10241_ net428 VSS VSS VDD VDD _10242_
+ sky130_fd_sc_hd__o22a_1
X_19450_ _12190_ _09977_ _10014_ VSS VSS VDD VDD _10243_ sky130_fd_sc_hd__a21oi_1
X_19451_ net430 _10085_ _10114_ VSS VSS VDD VDD _10244_ sky130_fd_sc_hd__nand3_1
X_19452_ net430 _10243_ _10244_ _09990_ VSS VSS VDD VDD _10245_
+ sky130_fd_sc_hd__o211ai_1
X_19453_ _09923_ _09936_ VSS VSS VDD VDD _10246_ sky130_fd_sc_hd__nand2_1
X_19454_ _10083_ _10163_ _10246_ _09983_ _12202_ VSS VSS VDD
+ VDD _10247_ sky130_fd_sc_hd__o32ai_1
X_19455_ net428 _10247_ VSS VSS VDD VDD _10248_ sky130_fd_sc_hd__nand2_1
X_19456_ _10092_ _10245_ _10248_ VSS VSS VDD VDD _10249_ sky130_fd_sc_hd__nand3_1
X_19457_ _10077_ _10242_ _10249_ VSS VSS VDD VDD _10250_ sky130_fd_sc_hd__o21ai_1
X_19458_ _10205_ _10235_ _10250_ VSS VSS VDD VDD _00090_ sky130_fd_sc_hd__or3_1
X_19459_ _09929_ _09936_ VSS VSS VDD VDD _10251_ sky130_fd_sc_hd__nand2_2
X_19460_ _10073_ _10128_ _10251_ _09983_ _09923_ VSS VSS VDD
+ VDD _10252_ sky130_fd_sc_hd__o2111ai_1
X_19461_ _10073_ _10083_ VSS VSS VDD VDD _10253_ sky130_fd_sc_hd__nand2_1
X_19462_ _10073_ _10086_ _10253_ VSS VSS VDD VDD _10254_ sky130_fd_sc_hd__o21ai_0
X_19463_ _09957_ _09972_ _10069_ _10254_ net432 VSS VSS VDD
+ VDD _10255_ sky130_fd_sc_hd__a32oi_1
X_19464_ net428 _10252_ _10255_ VSS VSS VDD VDD _10256_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_20_498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19466_ _12196_ _10036_ _10163_ net433 _10137_ VSS VSS VDD
+ VDD _10257_ sky130_fd_sc_hd__a221oi_1
X_19467_ _10085_ _10152_ _09936_ VSS VSS VDD VDD _10258_ sky130_fd_sc_hd__a21oi_2
X_19468_ _09978_ _10108_ net432 VSS VSS VDD VDD _10259_ sky130_fd_sc_hd__a21oi_1
X_19469_ _10258_ _10259_ VSS VSS VDD VDD _10260_ sky130_fd_sc_hd__nor2_1
X_19470_ _10136_ _10260_ VSS VSS VDD VDD _10261_ sky130_fd_sc_hd__nor2_1
X_19471_ _10244_ _10257_ _10261_ VSS VSS VDD VDD _10262_ sky130_fd_sc_hd__a21oi_1
X_19472_ _12198_ net431 _09977_ VSS VSS VDD VDD _10263_ sky130_fd_sc_hd__o21ai_0
X_19473_ net431 _10225_ _10263_ VSS VSS VDD VDD _10264_ sky130_fd_sc_hd__a21oi_1
X_19474_ _09957_ _10179_ _10264_ VSS VSS VDD VDD _10265_ sky130_fd_sc_hd__nor3_1
X_19475_ _09957_ _09998_ VSS VSS VDD VDD _10266_ sky130_fd_sc_hd__nand2_1
X_19476_ _09935_ _09975_ net498 VSS VSS VDD VDD _10267_ sky130_fd_sc_hd__a21oi_1
X_19477_ _09923_ _10036_ _10097_ _10266_ _10267_ VSS VSS VDD
+ VDD _10268_ sky130_fd_sc_hd__a2111oi_1
X_19478_ _09967_ _09971_ _10043_ VSS VSS VDD VDD _10269_ sky130_fd_sc_hd__a21oi_4
X_19479_ _12189_ _09972_ _10269_ VSS VSS VDD VDD _10270_ sky130_fd_sc_hd__a21oi_2
X_19480_ _09957_ _10270_ VSS VSS VDD VDD _10271_ sky130_fd_sc_hd__nand2_1
X_19481_ _10073_ _10217_ VSS VSS VDD VDD _10272_ sky130_fd_sc_hd__nand2_1
X_19482_ net518 _09972_ VSS VSS VDD VDD _10273_ sky130_fd_sc_hd__nor2_1
X_19483_ _09957_ _10273_ _10211_ net432 VSS VSS VDD VDD _10274_
+ sky130_fd_sc_hd__a211oi_1
X_19484_ net432 _10271_ _10272_ net428 _10274_ VSS VSS VDD
+ VDD _10275_ sky130_fd_sc_hd__a311oi_1
X_19485_ _10265_ _10268_ _10275_ VSS VSS VDD VDD _10276_ sky130_fd_sc_hd__nor3_1
X_19486_ _10206_ _10276_ VSS VSS VDD VDD _10277_ sky130_fd_sc_hd__nor2_1
X_19487_ net433 _10251_ VSS VSS VDD VDD _10278_ sky130_fd_sc_hd__nor2_1
X_19488_ net433 _09972_ _10080_ _10278_ _09990_ VSS VSS VDD
+ VDD _10279_ sky130_fd_sc_hd__a311oi_1
X_19489_ net498 _09936_ VSS VSS VDD VDD _10280_ sky130_fd_sc_hd__nor2_1
X_19490_ _09923_ _10036_ _10280_ net428 VSS VSS VDD VDD _10281_
+ sky130_fd_sc_hd__a211oi_1
X_19491_ _09936_ net428 VSS VSS VDD VDD _10282_ sky130_fd_sc_hd__xnor2_1
X_19492_ _09923_ _10045_ _10282_ _12189_ _09977_ VSS VSS VDD
+ VDD _10283_ sky130_fd_sc_hd__o221ai_1
X_19493_ _10279_ _10281_ _10104_ _10283_ VSS VSS VDD VDD _10284_
+ sky130_fd_sc_hd__o211ai_1
X_19494_ _12189_ _09972_ VSS VSS VDD VDD _10285_ sky130_fd_sc_hd__nand2_1
X_19495_ _12202_ _09972_ _10285_ _09935_ VSS VSS VDD VDD _10286_
+ sky130_fd_sc_hd__o211ai_1
X_19496_ net430 _10014_ _10032_ _10286_ VSS VSS VDD VDD _10287_
+ sky130_fd_sc_hd__o31a_1
X_19497_ _12196_ _09977_ _10138_ net430 VSS VSS VDD VDD _10288_
+ sky130_fd_sc_hd__o211ai_1
X_19498_ net430 _10083_ _10216_ _10288_ _09990_ VSS VSS VDD
+ VDD _10289_ sky130_fd_sc_hd__o311ai_1
X_19499_ _09990_ _10287_ _10289_ _10174_ _09957_ VSS VSS VDD
+ VDD _10290_ sky130_fd_sc_hd__o2111ai_1
X_19500_ _12198_ net428 VSS VSS VDD VDD _10291_ sky130_fd_sc_hd__nand2_1
X_19501_ net429 _09977_ VSS VSS VDD VDD _10292_ sky130_fd_sc_hd__nor2_2
X_19502_ _12190_ _09977_ VSS VSS VDD VDD _10293_ sky130_fd_sc_hd__nand2_1
X_19503_ _10085_ _10293_ net428 VSS VSS VDD VDD _10294_ sky130_fd_sc_hd__a21oi_1
X_19504_ _09929_ _10292_ _10294_ VSS VSS VDD VDD _10295_ sky130_fd_sc_hd__a21oi_1
X_19505_ _10291_ _10063_ _10295_ _09936_ _10092_ VSS VSS VDD
+ VDD _10296_ sky130_fd_sc_hd__o221ai_1
X_19506_ _12196_ _09977_ VSS VSS VDD VDD _10297_ sky130_fd_sc_hd__nor2_1
X_19507_ net430 _10216_ _10297_ VSS VSS VDD VDD _10298_ sky130_fd_sc_hd__nor3_1
X_19508_ net430 _10243_ _10298_ VSS VSS VDD VDD _10299_ sky130_fd_sc_hd__a21o_1
X_19509_ _09978_ _09984_ net432 VSS VSS VDD VDD _10300_ sky130_fd_sc_hd__a21oi_1
X_19510_ _09977_ _10225_ _10026_ _09936_ VSS VSS VDD VDD _10301_
+ sky130_fd_sc_hd__a211oi_1
X_19511_ _10300_ _10301_ net428 VSS VSS VDD VDD _10302_ sky130_fd_sc_hd__o21ai_0
X_19512_ net428 _10299_ _10302_ _10076_ _10073_ VSS VSS VDD
+ VDD _10303_ sky130_fd_sc_hd__o2111ai_1
X_19513_ _10284_ _10290_ _10296_ _10303_ VSS VSS VDD VDD _10304_
+ sky130_fd_sc_hd__nand4_1
X_19514_ _10110_ _10256_ _10262_ _10277_ _10304_ VSS VSS VDD
+ VDD _00091_ sky130_fd_sc_hd__a311oi_1
X_19515_ _12202_ _10004_ _10217_ _09936_ VSS VSS VDD VDD _10305_
+ sky130_fd_sc_hd__o22ai_1
X_19516_ _12193_ _09977_ VSS VSS VDD VDD _10306_ sky130_fd_sc_hd__and2_0
X_19517_ _09936_ _10306_ _10125_ _10185_ net429 VSS VSS VDD
+ VDD _10307_ sky130_fd_sc_hd__o311ai_2
X_19518_ net429 _10305_ _10307_ VSS VSS VDD VDD _10308_ sky130_fd_sc_hd__o21ai_0
X_19519_ _09977_ _10106_ _10113_ VSS VSS VDD VDD _10309_ sky130_fd_sc_hd__a21oi_1
X_19520_ net432 _10309_ VSS VSS VDD VDD _10310_ sky130_fd_sc_hd__nand2_1
X_19521_ _10273_ _10026_ _09936_ VSS VSS VDD VDD _10311_ sky130_fd_sc_hd__o21ai_0
X_19522_ _10059_ _10132_ _09957_ VSS VSS VDD VDD _10312_ sky130_fd_sc_hd__o21ai_0
X_19523_ _09998_ _10310_ _10311_ _10312_ VSS VSS VDD VDD _10313_
+ sky130_fd_sc_hd__a31oi_1
X_19524_ _10073_ _10308_ _10313_ VSS VSS VDD VDD _10314_ sky130_fd_sc_hd__a21oi_2
X_19525_ _12190_ _09936_ VSS VSS VDD VDD _10315_ sky130_fd_sc_hd__nor2_2
X_19526_ _12188_ _09936_ _10315_ VSS VSS VDD VDD _10316_ sky130_fd_sc_hd__a21oi_1
X_19527_ _10163_ _10182_ _12198_ VSS VSS VDD VDD _10317_ sky130_fd_sc_hd__o21ai_0
X_19528_ _10012_ _10181_ _10083_ VSS VSS VDD VDD _10318_ sky130_fd_sc_hd__a21oi_1
X_19529_ _10317_ _10318_ net428 VSS VSS VDD VDD _10319_ sky130_fd_sc_hd__a21oi_1
X_19530_ _09998_ _09972_ net431 VSS VSS VDD VDD _10320_ sky130_fd_sc_hd__o21ai_0
X_19531_ _10059_ _10269_ _10049_ VSS VSS VDD VDD _10321_ sky130_fd_sc_hd__o21ai_0
X_19532_ _09929_ _10320_ _10321_ VSS VSS VDD VDD _10322_ sky130_fd_sc_hd__a21oi_1
X_19533_ _10292_ _10316_ _10319_ _10322_ _09957_ VSS VSS VDD
+ VDD _10323_ sky130_fd_sc_hd__a2111oi_2
X_19534_ _12200_ _09977_ VSS VSS VDD VDD _10324_ sky130_fd_sc_hd__nor2_1
X_19535_ _09977_ _10100_ _10324_ VSS VSS VDD VDD _10325_ sky130_fd_sc_hd__a21oi_2
X_19536_ net433 _10128_ _10269_ net431 _10149_ VSS VSS VDD
+ VDD _10326_ sky130_fd_sc_hd__o221ai_1
X_19537_ net429 _10325_ _10326_ VSS VSS VDD VDD _10327_ sky130_fd_sc_hd__o21ai_0
X_19538_ net433 net429 VSS VSS VDD VDD _10328_ sky130_fd_sc_hd__nand2_1
X_19539_ _12188_ _10292_ _10328_ VSS VSS VDD VDD _10329_ sky130_fd_sc_hd__a21boi_0
X_19540_ _10292_ _10315_ _10329_ net431 VSS VSS VDD VDD _10330_
+ sky130_fd_sc_hd__o2bb2ai_1
X_19541_ _10073_ _10210_ _10330_ _10091_ VSS VSS VDD VDD _10331_
+ sky130_fd_sc_hd__a31oi_1
X_19542_ _10073_ _10327_ _10331_ VSS VSS VDD VDD _10332_ sky130_fd_sc_hd__o21ai_1
X_19543_ _09936_ _10152_ _10155_ VSS VSS VDD VDD _10333_ sky130_fd_sc_hd__nand3_1
X_19544_ _09936_ _10210_ _10033_ VSS VSS VDD VDD _10334_ sky130_fd_sc_hd__a21oi_1
X_19545_ _09998_ _10334_ VSS VSS VDD VDD _10335_ sky130_fd_sc_hd__nor2_1
X_19546_ _09998_ _10080_ _10333_ _10335_ _10073_ VSS VSS VDD
+ VDD _10336_ sky130_fd_sc_hd__a311oi_4
X_19547_ net433 _10163_ VSS VSS VDD VDD _10337_ sky130_fd_sc_hd__nand2_1
X_19548_ _09929_ _10239_ VSS VSS VDD VDD _10338_ sky130_fd_sc_hd__nand2_1
X_19549_ net554 _10063_ _10337_ _10338_ VSS VSS VDD VDD _10339_
+ sky130_fd_sc_hd__o211ai_2
X_19550_ net554 _09935_ _10006_ _12188_ _10136_ VSS VSS VDD
+ VDD _10340_ sky130_fd_sc_hd__a221oi_1
X_19551_ _10119_ _10340_ _09944_ VSS VSS VDD VDD _10341_ sky130_fd_sc_hd__a21oi_1
X_19552_ _10122_ _10339_ _10341_ VSS VSS VDD VDD _10342_ sky130_fd_sc_hd__o21ai_2
X_19553_ net554 _09929_ _09972_ VSS VSS VDD VDD _10343_ sky130_fd_sc_hd__nor3_4
X_19554_ net429 _10211_ _10343_ VSS VSS VDD VDD _10344_ sky130_fd_sc_hd__nor3_1
X_19555_ _12198_ net429 _10344_ _09936_ VSS VSS VDD VDD _10345_
+ sky130_fd_sc_hd__a211oi_1
X_19556_ net428 _10270_ VSS VSS VDD VDD _10346_ sky130_fd_sc_hd__nand2_1
X_19557_ _09990_ _10109_ _10144_ VSS VSS VDD VDD _10347_ sky130_fd_sc_hd__nand3_1
X_19558_ _10346_ _10347_ net432 VSS VSS VDD VDD _10348_ sky130_fd_sc_hd__a21oi_1
X_19559_ _10073_ _10345_ _10348_ VSS VSS VDD VDD _10349_ sky130_fd_sc_hd__nor3_1
X_19560_ _12188_ _09936_ _10246_ VSS VSS VDD VDD _10350_ sky130_fd_sc_hd__o21ai_0
X_19561_ _09977_ _10350_ _10096_ VSS VSS VDD VDD _10351_ sky130_fd_sc_hd__a21oi_2
X_19562_ _10152_ _10133_ VSS VSS VDD VDD _10352_ sky130_fd_sc_hd__nand2_1
X_19563_ _09936_ _10113_ _10343_ VSS VSS VDD VDD _10353_ sky130_fd_sc_hd__nor3_1
X_19564_ _09936_ _10352_ _10353_ _09998_ VSS VSS VDD VDD _10354_
+ sky130_fd_sc_hd__a211oi_1
X_19565_ _09957_ _10351_ _10354_ _09944_ VSS VSS VDD VDD _10355_
+ sky130_fd_sc_hd__o31ai_2
X_19566_ _10336_ _10342_ _10349_ _10355_ _09950_ VSS VSS VDD
+ VDD _10356_ sky130_fd_sc_hd__o221ai_4
X_19567_ _10206_ _10314_ _10323_ _10332_ _10356_ VSS VSS VDD
+ VDD _00092_ sky130_fd_sc_hd__o221ai_4
X_19568_ net554 _09977_ VSS VSS VDD VDD _10357_ sky130_fd_sc_hd__nor2_2
X_19569_ _09929_ _10357_ _10338_ VSS VSS VDD VDD _10358_ sky130_fd_sc_hd__o21ai_0
X_19570_ _10043_ _09972_ _10343_ _09935_ VSS VSS VDD VDD _10359_
+ sky130_fd_sc_hd__a211oi_1
X_19571_ _09935_ _09975_ _10120_ _10359_ net428 VSS VSS VDD
+ VDD _10360_ sky130_fd_sc_hd__a311oi_1
X_19572_ net428 _10358_ _10360_ VSS VSS VDD VDD _10361_ sky130_fd_sc_hd__a21oi_1
X_19573_ net433 _09929_ _09972_ VSS VSS VDD VDD _10362_ sky130_fd_sc_hd__o21ai_0
X_19574_ _10293_ _10362_ _09936_ VSS VSS VDD VDD _10363_ sky130_fd_sc_hd__a21oi_1
X_19575_ _12198_ _10036_ _10306_ _10363_ VSS VSS VDD VDD _10364_
+ sky130_fd_sc_hd__a211oi_1
X_19576_ _09936_ _09975_ _09978_ VSS VSS VDD VDD _10365_ sky130_fd_sc_hd__nand3_1
X_19577_ net428 _10034_ _10365_ _10197_ VSS VSS VDD VDD _10366_
+ sky130_fd_sc_hd__a31oi_1
X_19578_ net428 _10364_ _10366_ VSS VSS VDD VDD _10367_ sky130_fd_sc_hd__o21ai_0
X_19579_ _09944_ _09950_ _10073_ _10361_ _10367_ VSS VSS VDD
+ VDD _10368_ sky130_fd_sc_hd__o41ai_1
X_19580_ _09923_ _09929_ VSS VSS VDD VDD _10369_ sky130_fd_sc_hd__nand2_1
X_19581_ _10211_ _09935_ _10086_ VSS VSS VDD VDD _10370_ sky130_fd_sc_hd__nor3b_1
X_19582_ _10239_ _10369_ _10370_ VSS VSS VDD VDD _10371_ sky130_fd_sc_hd__a21oi_1
X_19583_ _10148_ _10106_ _10063_ net498 _09990_ VSS VSS VDD
+ VDD _10372_ sky130_fd_sc_hd__a221oi_1
X_19584_ _12193_ _10004_ _10372_ VSS VSS VDD VDD _10373_ sky130_fd_sc_hd__o21ai_0
X_19585_ net428 _10371_ _10373_ _10040_ _10073_ VSS VSS VDD
+ VDD _10374_ sky130_fd_sc_hd__o2111ai_1
X_19586_ _10138_ _10133_ net430 VSS VSS VDD VDD _10375_ sky130_fd_sc_hd__a21oi_1
X_19587_ _10064_ _10375_ _09944_ VSS VSS VDD VDD _10376_ sky130_fd_sc_hd__o21ai_0
X_19588_ _09929_ _10006_ _10270_ _09935_ _09944_ VSS VSS VDD
+ VDD _10377_ sky130_fd_sc_hd__a221oi_1
X_19589_ _10122_ _10377_ VSS VSS VDD VDD _10378_ sky130_fd_sc_hd__nor2_1
X_19590_ _09935_ _10144_ _10343_ VSS VSS VDD VDD _10379_ sky130_fd_sc_hd__a21oi_1
X_19591_ _09944_ _10136_ _10379_ VSS VSS VDD VDD _10380_ sky130_fd_sc_hd__nor3_1
X_19592_ _10098_ _10109_ net430 VSS VSS VDD VDD _10381_ sky130_fd_sc_hd__a21oi_1
X_19593_ net554 _10239_ _10136_ _10381_ _10040_ VSS VSS VDD
+ VDD _10382_ sky130_fd_sc_hd__a2111oi_1
X_19594_ _10376_ _10378_ _10380_ _10382_ VSS VSS VDD VDD _10383_
+ sky130_fd_sc_hd__a211oi_1
X_19595_ _10374_ _10383_ _09950_ VSS VSS VDD VDD _10384_ sky130_fd_sc_hd__mux2i_1
X_19596_ net429 _10148_ _10292_ net433 VSS VSS VDD VDD _10385_
+ sky130_fd_sc_hd__a211oi_1
X_19597_ net433 _10231_ _10385_ VSS VSS VDD VDD _10386_ sky130_fd_sc_hd__a21oi_1
X_19598_ net498 _10239_ _10006_ _12196_ VSS VSS VDD VDD _10387_
+ sky130_fd_sc_hd__a22oi_1
X_19599_ _09990_ _09972_ VSS VSS VDD VDD _10388_ sky130_fd_sc_hd__nor2_1
X_19600_ _10239_ _10388_ net559 VSS VSS VDD VDD _10389_ sky130_fd_sc_hd__o21ai_0
X_19601_ net428 _10387_ _10389_ VSS VSS VDD VDD _10390_ sky130_fd_sc_hd__o21ai_0
X_19602_ _09929_ _10386_ _10390_ VSS VSS VDD VDD _10391_ sky130_fd_sc_hd__a21oi_1
X_19603_ _10073_ _10103_ _10391_ VSS VSS VDD VDD _10392_ sky130_fd_sc_hd__nor3_1
X_19604_ _10073_ _09997_ _10080_ VSS VSS VDD VDD _10393_ sky130_fd_sc_hd__o21ai_0
X_19605_ net432 _09957_ _10225_ VSS VSS VDD VDD _10394_ sky130_fd_sc_hd__nand3_1
X_19606_ _12196_ _10073_ VSS VSS VDD VDD _10395_ sky130_fd_sc_hd__nand2_1
X_19607_ _10394_ _10395_ _09972_ VSS VSS VDD VDD _10396_ sky130_fd_sc_hd__a21oi_1
X_19608_ _10357_ _10393_ _10396_ VSS VSS VDD VDD _10397_ sky130_fd_sc_hd__a21oi_1
X_19609_ _09935_ _10285_ _10120_ _10370_ _09957_ VSS VSS VDD
+ VDD _10398_ sky130_fd_sc_hd__a311o_1
X_19610_ _12193_ _10036_ VSS VSS VDD VDD _10399_ sky130_fd_sc_hd__nand2_1
X_19611_ _12202_ net430 _09977_ VSS VSS VDD VDD _10400_ sky130_fd_sc_hd__o21ai_0
X_19612_ _09957_ _10399_ _10400_ net428 VSS VSS VDD VDD _10401_
+ sky130_fd_sc_hd__a31oi_1
X_19613_ net428 _10397_ _10398_ _10401_ _10091_ VSS VSS VDD
+ VDD _10402_ sky130_fd_sc_hd__a221oi_1
X_19614_ _10368_ _10384_ _10392_ _10402_ VSS VSS VDD VDD _00093_
+ sky130_fd_sc_hd__nor4_4
X_19615_ _09972_ _10225_ _10343_ _09936_ VSS VSS VDD VDD _10403_
+ sky130_fd_sc_hd__a211oi_1
X_19616_ _10085_ _10114_ net432 VSS VSS VDD VDD _10404_ sky130_fd_sc_hd__a21oi_1
X_19617_ net433 _10280_ _09977_ VSS VSS VDD VDD _10405_ sky130_fd_sc_hd__o21ai_0
X_19618_ _12196_ _10004_ _10405_ _09990_ VSS VSS VDD VDD _10406_
+ sky130_fd_sc_hd__o211ai_1
X_19619_ _09990_ _10403_ _10404_ _10406_ _10073_ VSS VSS VDD
+ VDD _10407_ sky130_fd_sc_hd__o311ai_1
X_19620_ net432 _10033_ _10343_ VSS VSS VDD VDD _10408_ sky130_fd_sc_hd__nor3_1
X_19621_ net431 _10049_ VSS VSS VDD VDD _10409_ sky130_fd_sc_hd__nor2_1
X_19622_ _12189_ _09936_ _09972_ VSS VSS VDD VDD _10410_ sky130_fd_sc_hd__o21ai_0
X_19623_ _12207_ _09972_ _10409_ _10410_ net429 VSS VSS VDD
+ VDD _10411_ sky130_fd_sc_hd__o221ai_1
X_19624_ net429 _10258_ _10408_ _10411_ _09957_ VSS VSS VDD
+ VDD _10412_ sky130_fd_sc_hd__o311ai_0
X_19625_ _09936_ _10217_ _10269_ VSS VSS VDD VDD _10413_ sky130_fd_sc_hd__nor3_1
X_19626_ _09972_ _10225_ VSS VSS VDD VDD _10414_ sky130_fd_sc_hd__nor2_1
X_19627_ net432 _10026_ _10414_ VSS VSS VDD VDD _10415_ sky130_fd_sc_hd__nor3_1
X_19628_ _10413_ _10415_ _10073_ VSS VSS VDD VDD _10416_ sky130_fd_sc_hd__o21ai_0
X_19629_ _10125_ _10269_ net432 VSS VSS VDD VDD _10417_ sky130_fd_sc_hd__o21ai_0
X_19630_ _12190_ _10006_ _10073_ VSS VSS VDD VDD _10418_ sky130_fd_sc_hd__a21oi_1
X_19631_ _10417_ _10418_ _09998_ VSS VSS VDD VDD _10419_ sky130_fd_sc_hd__a21oi_1
X_19632_ _10416_ _10419_ _09944_ VSS VSS VDD VDD _10420_ sky130_fd_sc_hd__a21oi_1
X_19633_ _09923_ _09936_ _10107_ VSS VSS VDD VDD _10421_ sky130_fd_sc_hd__o21ai_1
X_19634_ _12205_ _12214_ _09977_ VSS VSS VDD VDD _10422_ sky130_fd_sc_hd__or3_1
X_19635_ _12198_ _09936_ _09977_ VSS VSS VDD VDD _10423_ sky130_fd_sc_hd__a21oi_1
X_19636_ _10169_ _10423_ _10122_ VSS VSS VDD VDD _10424_ sky130_fd_sc_hd__a21oi_2
X_19637_ _09936_ _10106_ _10108_ _10133_ _10315_ VSS VSS VDD
+ VDD _10425_ sky130_fd_sc_hd__a32oi_4
X_19638_ _10130_ _10421_ _10422_ _10424_ _10425_ VSS VSS VDD
+ VDD _10426_ sky130_fd_sc_hd__a32oi_2
X_19639_ _09944_ _10407_ _10412_ _10420_ _10426_ VSS VSS VDD
+ VDD _10427_ sky130_fd_sc_hd__a32o_1
X_19640_ net433 _10181_ _10083_ VSS VSS VDD VDD _10428_ sky130_fd_sc_hd__a21oi_1
X_19641_ _12202_ _10428_ _10337_ _10251_ _09990_ VSS VSS VDD
+ VDD _10429_ sky130_fd_sc_hd__o2111a_1
X_19642_ _09929_ _10148_ _10050_ VSS VSS VDD VDD _10430_ sky130_fd_sc_hd__a21oi_1
X_19643_ net428 _10211_ _10199_ VSS VSS VDD VDD _10431_ sky130_fd_sc_hd__o21ai_0
X_19644_ _10429_ _10430_ _10431_ _10040_ VSS VSS VDD VDD _10432_
+ sky130_fd_sc_hd__o211ai_1
X_19645_ _12206_ _09977_ _10190_ _10423_ VSS VSS VDD VDD _10433_
+ sky130_fd_sc_hd__a22oi_1
X_19646_ net428 _10064_ _10300_ _09944_ VSS VSS VDD VDD _10434_
+ sky130_fd_sc_hd__o31a_1
X_19647_ _09990_ _10433_ _10434_ VSS VSS VDD VDD _10435_ sky130_fd_sc_hd__o21ai_0
X_19648_ _12198_ _09972_ VSS VSS VDD VDD _10436_ sky130_fd_sc_hd__nor2_1
X_19649_ _12196_ _09972_ _10436_ VSS VSS VDD VDD _10437_ sky130_fd_sc_hd__a21oi_1
X_19650_ net431 _10437_ _10149_ VSS VSS VDD VDD _10438_ sky130_fd_sc_hd__o21ai_0
X_19651_ net429 _10114_ _10328_ VSS VSS VDD VDD _10439_ sky130_fd_sc_hd__o21ai_0
X_19652_ net428 _09977_ net432 VSS VSS VDD VDD _10440_ sky130_fd_sc_hd__o21ai_0
X_19653_ net428 _10270_ _10440_ VSS VSS VDD VDD _10441_ sky130_fd_sc_hd__a21oi_1
X_19654_ net498 _10231_ _10073_ _10040_ VSS VSS VDD VDD _10442_
+ sky130_fd_sc_hd__o211ai_1
X_19655_ _09936_ _10439_ _10441_ _10442_ VSS VSS VDD VDD _10443_
+ sky130_fd_sc_hd__a211oi_1
X_19656_ _09944_ _10073_ _10238_ _10438_ _10443_ VSS VSS VDD
+ VDD _10444_ sky130_fd_sc_hd__a41o_1
X_19657_ _09957_ _10432_ _10435_ _10444_ _09950_ VSS VSS VDD
+ VDD _10445_ sky130_fd_sc_hd__a311o_1
X_19658_ _10090_ _10427_ _10445_ VSS VSS VDD VDD _00094_ sky130_fd_sc_hd__o21ai_1
X_19659_ _10217_ _10269_ _09936_ VSS VSS VDD VDD _10446_ sky130_fd_sc_hd__o21ai_0
X_19660_ _09983_ _10225_ _10446_ _09975_ VSS VSS VDD VDD _10447_
+ sky130_fd_sc_hd__o211ai_1
X_19661_ _09957_ _10113_ VSS VSS VDD VDD _10448_ sky130_fd_sc_hd__nor2_1
X_19662_ _09957_ _10447_ _10448_ _10421_ _09998_ VSS VSS VDD
+ VDD _10449_ sky130_fd_sc_hd__a221o_1
X_19663_ _09944_ _10449_ _09950_ VSS VSS VDD VDD _10450_ sky130_fd_sc_hd__o21ai_0
X_19664_ _12198_ net432 _09977_ _10069_ VSS VSS VDD VDD _10451_
+ sky130_fd_sc_hd__a211o_1
X_19665_ _12214_ _09972_ _10451_ VSS VSS VDD VDD _10452_ sky130_fd_sc_hd__o21ai_0
X_19666_ _12190_ _09936_ _09972_ VSS VSS VDD VDD _10453_ sky130_fd_sc_hd__nand3_1
X_19667_ _12200_ _09972_ _10453_ VSS VSS VDD VDD _10454_ sky130_fd_sc_hd__o21ai_0
X_19668_ _10073_ _10454_ net428 VSS VSS VDD VDD _10455_ sky130_fd_sc_hd__o21ai_0
X_19669_ _10073_ _10452_ _10455_ VSS VSS VDD VDD _10456_ sky130_fd_sc_hd__a21oi_1
X_19670_ _09936_ _10357_ _10216_ VSS VSS VDD VDD _10457_ sky130_fd_sc_hd__nor3_1
X_19671_ _09936_ _09984_ _10109_ _10136_ _10457_ VSS VSS VDD
+ VDD _10458_ sky130_fd_sc_hd__a311oi_2
X_19672_ _12193_ _09936_ _10068_ VSS VSS VDD VDD _10459_ sky130_fd_sc_hd__o21ai_0
X_19673_ _10357_ _10080_ _10459_ _09977_ _10137_ VSS VSS VDD
+ VDD _10460_ sky130_fd_sc_hd__a221oi_1
X_19674_ _10040_ _10456_ _10458_ _10460_ VSS VSS VDD VDD _10461_
+ sky130_fd_sc_hd__nor4_1
X_19675_ _09936_ _10152_ VSS VSS VDD VDD _10462_ sky130_fd_sc_hd__nand2_1
X_19676_ _12188_ _09936_ _10033_ _10462_ VSS VSS VDD VDD _10463_
+ sky130_fd_sc_hd__o22ai_1
X_19677_ _09936_ _10119_ _10086_ _10156_ VSS VSS VDD VDD _10464_
+ sky130_fd_sc_hd__a31oi_1
X_19678_ _10073_ _10464_ VSS VSS VDD VDD _10465_ sky130_fd_sc_hd__nor2_1
X_19679_ _10073_ _10463_ net429 _09944_ _10465_ VSS VSS VDD
+ VDD _10466_ sky130_fd_sc_hd__a2111oi_1
X_19680_ _12198_ net432 _09972_ VSS VSS VDD VDD _10467_ sky130_fd_sc_hd__nor3_1
X_19681_ _09936_ _10352_ VSS VSS VDD VDD _10468_ sky130_fd_sc_hd__nor2_1
X_19682_ net498 _10004_ VSS VSS VDD VDD _10469_ sky130_fd_sc_hd__nor2_1
X_19683_ _12202_ _10148_ _10063_ _12189_ _10469_ VSS VSS VDD
+ VDD _10470_ sky130_fd_sc_hd__a221oi_2
X_19684_ _10266_ _10467_ _10468_ _10136_ _10470_ VSS VSS VDD
+ VDD _10471_ sky130_fd_sc_hd__o32ai_4
X_19685_ net433 _09936_ _10108_ _10181_ _10133_ VSS VSS VDD
+ VDD _10472_ sky130_fd_sc_hd__a32oi_1
X_19686_ _10424_ _10472_ _09944_ VSS VSS VDD VDD _10473_ sky130_fd_sc_hd__a21oi_1
X_19687_ _09936_ _10273_ _10217_ VSS VSS VDD VDD _10474_ sky130_fd_sc_hd__a21oi_1
X_19688_ _12188_ _10148_ _10036_ net498 _10137_ VSS VSS VDD
+ VDD _10475_ sky130_fd_sc_hd__a221oi_1
X_19689_ net433 _10474_ _10475_ VSS VSS VDD VDD _10476_ sky130_fd_sc_hd__o21ai_0
X_19690_ _10473_ _10476_ VSS VSS VDD VDD _10477_ sky130_fd_sc_hd__nand2_1
X_19691_ _10471_ _10477_ _10090_ VSS VSS VDD VDD _10478_ sky130_fd_sc_hd__o21ai_1
X_19692_ _09929_ _10239_ _10006_ VSS VSS VDD VDD _10479_ sky130_fd_sc_hd__a21oi_1
X_19693_ _10004_ _10023_ _09923_ VSS VSS VDD VDD _10480_ sky130_fd_sc_hd__a21oi_1
X_19694_ _09923_ _10217_ _10480_ net429 VSS VSS VDD VDD _10481_
+ sky130_fd_sc_hd__a211oi_1
X_19695_ net498 _10148_ _10083_ net428 VSS VSS VDD VDD _10482_
+ sky130_fd_sc_hd__a211oi_1
X_19696_ net559 _10479_ _10481_ _10482_ VSS VSS VDD VDD _10483_
+ sky130_fd_sc_hd__o22ai_1
X_19697_ _10036_ _10388_ _09929_ VSS VSS VDD VDD _10484_ sky130_fd_sc_hd__o21ai_0
X_19698_ _09929_ net428 _09983_ _10484_ VSS VSS VDD VDD _10485_
+ sky130_fd_sc_hd__o31ai_1
X_19699_ _09936_ _10285_ _10045_ _10073_ _10090_ VSS VSS VDD
+ VDD _10486_ sky130_fd_sc_hd__o2111ai_1
X_19700_ _09923_ _10485_ _10486_ VSS VSS VDD VDD _10487_ sky130_fd_sc_hd__a21oi_1
X_19701_ _09957_ _10483_ _10487_ _10040_ VSS VSS VDD VDD _10488_
+ sky130_fd_sc_hd__a211oi_2
X_19702_ _10450_ _10461_ _10466_ _10478_ _10488_ VSS VSS VDD
+ VDD _00095_ sky130_fd_sc_hd__o32ai_2
X_19703_ sa00_sr\[1\] sa30_sr\[7\] VSS VSS VDD VDD _10489_
+ sky130_fd_sc_hd__xnor2_1
X_19704_ sa10_sr\[1\] sa30_sr\[0\] VSS VSS VDD VDD _10490_
+ sky130_fd_sc_hd__xnor2_1
X_19705_ sa30_sr\[1\] sa20_sr\[0\] sa20_sr\[7\] VSS VSS VDD
+ VDD _10491_ sky130_fd_sc_hd__xnor3_1
X_19706_ _10489_ _10490_ _10491_ VSS VSS VDD VDD _10492_ sky130_fd_sc_hd__xnor3_2
X_19707_ text_in_r\[105\] _10492_ net660 VSS VSS VDD VDD _10493_
+ sky130_fd_sc_hd__mux2i_4
X_19708_ u0.w\[0\]\[9\] _10493_ VSS VSS VDD VDD _10494_ sky130_fd_sc_hd__xor2_4
X_19709_ _10494_ VSS VSS VDD VDD _10495_ sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_20_497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19711_ sa10_sr\[0\] sa20_sr\[7\] sa30_sr\[7\] VSS VSS VDD
+ VDD _10496_ sky130_fd_sc_hd__xnor3_1
X_19712_ _08240_ _10496_ VSS VSS VDD VDD _10497_ sky130_fd_sc_hd__xnor2_1
X_19713_ text_in_r\[104\] _10497_ net660 VSS VSS VDD VDD _10498_
+ sky130_fd_sc_hd__mux2i_4
X_19714_ _10498_ u0.w\[0\]\[8\] VSS VSS VDD VDD _10499_ sky130_fd_sc_hd__xor2_4
X_19715_ net523 VSS VSS VDD VDD _10500_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_20_496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19717_ sa10_sr\[2\] sa30_sr\[2\] sa00_sr\[2\] VSS VSS VDD
+ VDD _10501_ sky130_fd_sc_hd__xnor3_1
X_19718_ _05875_ _10501_ VSS VSS VDD VDD _10502_ sky130_fd_sc_hd__xnor2_2
X_19719_ net492 text_in_r\[106\] u0.w\[0\]\[10\] VSS VSS VDD
+ VDD _10503_ sky130_fd_sc_hd__a21oi_1
X_19720_ net661 _10502_ _10503_ VSS VSS VDD VDD _10504_ sky130_fd_sc_hd__a21bo_1
X_19721_ u0.w\[0\]\[10\] net492 text_in_r\[106\] VSS VSS VDD
+ VDD _10505_ sky130_fd_sc_hd__and3_1
X_19722_ u0.w\[0\]\[10\] net547 _10502_ _10505_ VSS VSS VDD
+ VDD _10506_ sky130_fd_sc_hd__a31oi_2
X_19723_ _10504_ _10506_ VSS VSS VDD VDD _10507_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_20_495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19725_ _10507_ VSS VSS VDD VDD _10509_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_20_494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19734_ sa30_sr\[4\] sa10_sr\[5\] sa00_sr\[5\] VSS VSS VDD
+ VDD _10515_ sky130_fd_sc_hd__xnor3_1
X_19735_ sa20_sr\[4\] sa30_sr\[5\] VSS VSS VDD VDD _10516_
+ sky130_fd_sc_hd__xor2_1
X_19736_ _10515_ _10516_ VSS VSS VDD VDD _10517_ sky130_fd_sc_hd__xnor2_1
X_19737_ text_in_r\[109\] _10517_ net547 VSS VSS VDD VDD _10518_
+ sky130_fd_sc_hd__mux2i_4
X_19738_ u0.w\[0\]\[13\] _10518_ VSS VSS VDD VDD _10519_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_19_486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19742_ sa30_sr\[5\] sa10_sr\[6\] sa00_sr\[6\] VSS VSS VDD
+ VDD _10523_ sky130_fd_sc_hd__xnor3_2
X_19743_ sa20_sr\[5\] sa30_sr\[6\] VSS VSS VDD VDD _10524_
+ sky130_fd_sc_hd__xnor2_1
X_19744_ _10523_ _10524_ VSS VSS VDD VDD _10525_ sky130_fd_sc_hd__xnor2_1
X_19745_ net492 _10525_ VSS VSS VDD VDD _10526_ sky130_fd_sc_hd__nor2_1
X_19746_ net492 text_in_r\[110\] _10526_ VSS VSS VDD VDD _10527_
+ sky130_fd_sc_hd__a21oi_4
X_19747_ u0.w\[0\]\[14\] _10527_ VSS VSS VDD VDD _10528_ sky130_fd_sc_hd__xor2_4
X_19748_ sa00_sr\[7\] sa30_sr\[6\] VSS VSS VDD VDD _10529_
+ sky130_fd_sc_hd__xor2_2
X_19749_ sa20_sr\[6\] sa30_sr\[7\] VSS VSS VDD VDD _10530_
+ sky130_fd_sc_hd__xor2_1
X_19750_ _10529_ _10530_ VSS VSS VDD VDD _10531_ sky130_fd_sc_hd__xnor2_1
X_19751_ sa10_sr\[7\] _10531_ VSS VSS VDD VDD _10532_ sky130_fd_sc_hd__xnor2_2
X_19752_ text_in_r\[111\] _10532_ net547 VSS VSS VDD VDD _10533_
+ sky130_fd_sc_hd__mux2i_4
X_19753_ u0.w\[0\]\[15\] _10533_ VSS VSS VDD VDD _10534_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_19_483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19755_ _10528_ _10534_ VSS VSS VDD VDD _10536_ sky130_fd_sc_hd__nand2_4
X_19756_ sa00_sr\[4\] sa30_sr\[7\] VSS VSS VDD VDD _10537_
+ sky130_fd_sc_hd__xnor2_1
X_19757_ sa30_sr\[3\] sa10_sr\[4\] VSS VSS VDD VDD _10538_
+ sky130_fd_sc_hd__xnor2_1
X_19758_ _08280_ _10537_ _10538_ VSS VSS VDD VDD _10539_ sky130_fd_sc_hd__xnor3_2
X_19759_ text_in_r\[108\] _10539_ net661 VSS VSS VDD VDD _10540_
+ sky130_fd_sc_hd__mux2i_4
X_19760_ u0.w\[0\]\[12\] _10540_ VSS VSS VDD VDD _10541_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_19_482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19764_ sa00_sr\[3\] sa30_sr\[7\] VSS VSS VDD VDD _10545_
+ sky130_fd_sc_hd__xnor2_1
X_19765_ sa30_sr\[2\] sa10_sr\[3\] VSS VSS VDD VDD _10546_
+ sky130_fd_sc_hd__xnor2_1
X_19766_ sa20_sr\[2\] sa30_sr\[3\] sa20_sr\[7\] VSS VSS VDD
+ VDD _10547_ sky130_fd_sc_hd__xnor3_1
X_19767_ _10545_ _10546_ _10547_ VSS VSS VDD VDD _10548_ sky130_fd_sc_hd__xnor3_1
X_19768_ text_in_r\[107\] _10548_ net661 VSS VSS VDD VDD _10549_
+ sky130_fd_sc_hd__mux2i_4
X_19769_ _10549_ u0.w\[0\]\[11\] VSS VSS VDD VDD _10550_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_19_479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19771_ net688 net426 VSS VSS VDD VDD _10552_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_19_478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19773_ _10509_ net427 VSS VSS VDD VDD _10554_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_19_477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19775_ u0.w\[0\]\[11\] _10549_ VSS VSS VDD VDD _10556_ sky130_fd_sc_hd__xor2_4
X_19776_ net587 net425 VSS VSS VDD VDD _10557_ sky130_fd_sc_hd__nand2_4
X_19777_ _10554_ _10557_ VSS VSS VDD VDD _10558_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_19_476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19781_ _10507_ net427 VSS VSS VDD VDD _10562_ sky130_fd_sc_hd__nand2_4
X_19782_ _12221_ _10562_ VSS VSS VDD VDD _10563_ sky130_fd_sc_hd__nor2_2
X_19783_ _12230_ _10552_ _10558_ _12220_ _10563_ VSS VSS VDD
+ VDD _10564_ sky130_fd_sc_hd__a221oi_1
X_19784_ _10495_ _10507_ VSS VSS VDD VDD _10565_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_19_473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19786_ _12221_ net425 VSS VSS VDD VDD _10567_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_19_472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19788_ _10495_ net426 VSS VSS VDD VDD _10569_ sky130_fd_sc_hd__nor2_2
X_19789_ _12221_ _10509_ VSS VSS VDD VDD _10570_ sky130_fd_sc_hd__nand2b_2
X_19790_ _10565_ _10567_ _10569_ _10570_ _10541_ VSS VSS VDD
+ VDD _10571_ sky130_fd_sc_hd__o221ai_2
X_19791_ _10541_ _10564_ _10571_ VSS VSS VDD VDD _10572_ sky130_fd_sc_hd__o21ai_0
X_19792_ _10519_ _10536_ _10572_ VSS VSS VDD VDD _10573_ sky130_fd_sc_hd__nor3b_1
X_19793_ u0.w\[0\]\[13\] _10518_ VSS VSS VDD VDD _10574_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_19_471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19798_ _12220_ net424 VSS VSS VDD VDD _10579_ sky130_fd_sc_hd__nor2_1
X_19799_ _12234_ net426 VSS VSS VDD VDD _10580_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_18_467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19802_ _12221_ net424 _10509_ VSS VSS VDD VDD _10583_ sky130_fd_sc_hd__a21oi_4
X_19803_ _12230_ net424 _10583_ VSS VSS VDD VDD _10584_ sky130_fd_sc_hd__o21ai_1
X_19804_ u0.w\[0\]\[12\] _10540_ VSS VSS VDD VDD _10585_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_18_465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19808_ net587 _10579_ _10580_ _10584_ _10585_ VSS VSS VDD
+ VDD _10589_ sky130_fd_sc_hd__o311ai_4
XTAP_TAPCELL_ROW_18_462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19810_ net681 _10499_ VSS VSS VDD VDD _10590_ sky130_fd_sc_hd__nand2_1
X_19811_ _10500_ net687 VSS VSS VDD VDD _10591_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_18_461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19813_ _10541_ _10550_ VSS VSS VDD VDD _10593_ sky130_fd_sc_hd__nand2_1
X_19814_ _10590_ _10591_ _10593_ VSS VSS VDD VDD _10594_ sky130_fd_sc_hd__a21o_1
X_19815_ _10585_ _10550_ VSS VSS VDD VDD _10595_ sky130_fd_sc_hd__nor2_2
X_19816_ _10590_ _10591_ _10595_ VSS VSS VDD VDD _10596_ sky130_fd_sc_hd__nand3_1
X_19817_ _10589_ _10594_ _10596_ VSS VSS VDD VDD _10597_ sky130_fd_sc_hd__nand3_1
X_19818_ _10574_ _10536_ _10597_ VSS VSS VDD VDD _10598_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_18_460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19822_ _10509_ net424 VSS VSS VDD VDD _10602_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_18_457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19825_ _12225_ _10509_ net427 VSS VSS VDD VDD _10605_ sky130_fd_sc_hd__nor3_1
X_19826_ _12222_ net587 net427 _10605_ net423 VSS VSS VDD
+ VDD _10606_ sky130_fd_sc_hd__a311oi_2
X_19827_ _12230_ _10602_ _10606_ VSS VSS VDD VDD _10607_ sky130_fd_sc_hd__o21ai_1
X_19828_ _12225_ _10556_ VSS VSS VDD VDD _10608_ sky130_fd_sc_hd__nor2_4
X_19829_ _12222_ _10556_ _10608_ VSS VSS VDD VDD _10609_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_18_455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19831_ _12232_ _10509_ _10550_ VSS VSS VDD VDD _10611_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_18_454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19834_ _10509_ _10609_ _10611_ _10585_ VSS VSS VDD VDD _10614_
+ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_18_452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19837_ _12243_ _10550_ _10552_ _12221_ net423 VSS VSS VDD
+ VDD _10617_ sky130_fd_sc_hd__a221oi_1
X_19838_ _10504_ _10506_ _12227_ VSS VSS VDD VDD _10618_ sky130_fd_sc_hd__a21oi_4
X_19839_ _12225_ _10507_ _10618_ VSS VSS VDD VDD _10619_ sky130_fd_sc_hd__a21oi_1
X_19840_ net425 _10619_ _10541_ VSS VSS VDD VDD _10620_ sky130_fd_sc_hd__a21o_1
X_19841_ _12222_ _10556_ VSS VSS VDD VDD _10621_ sky130_fd_sc_hd__nand2_1
X_19842_ _10500_ _10550_ VSS VSS VDD VDD _10622_ sky130_fd_sc_hd__nand2_4
X_19843_ _10621_ _10622_ net515 VSS VSS VDD VDD _10623_ sky130_fd_sc_hd__a21oi_1
X_19844_ _12220_ _10562_ VSS VSS VDD VDD _10624_ sky130_fd_sc_hd__nor2_2
X_19845_ _10620_ _10623_ _10624_ VSS VSS VDD VDD _10625_ sky130_fd_sc_hd__nor3_1
X_19846_ u0.w\[0\]\[14\] _10527_ VSS VSS VDD VDD _10626_ sky130_fd_sc_hd__xnor2_4
X_19847_ _10626_ _10534_ VSS VSS VDD VDD _10627_ sky130_fd_sc_hd__nor2_1
X_19848_ _10519_ _10617_ _10625_ _10627_ VSS VSS VDD VDD _10628_
+ sky130_fd_sc_hd__o31ai_1
X_19849_ _10519_ _10607_ _10614_ _10628_ VSS VSS VDD VDD _10629_
+ sky130_fd_sc_hd__a31oi_2
X_19850_ _10499_ _10507_ VSS VSS VDD VDD _10630_ sky130_fd_sc_hd__nor2_2
X_19851_ _12234_ _10509_ VSS VSS VDD VDD _10631_ sky130_fd_sc_hd__nor2_1
X_19852_ _10630_ _10631_ _10550_ VSS VSS VDD VDD _10632_ sky130_fd_sc_hd__o21ai_2
X_19853_ _10509_ net426 VSS VSS VDD VDD _10633_ sky130_fd_sc_hd__nor2_1
X_19854_ _12221_ net426 VSS VSS VDD VDD _10634_ sky130_fd_sc_hd__and2_1
X_19855_ _12232_ _10633_ _10634_ net423 VSS VSS VDD VDD _10635_
+ sky130_fd_sc_hd__a211oi_1
X_19856_ net423 _10632_ _10635_ VSS VSS VDD VDD _10636_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_18_450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19858_ _12227_ _10556_ VSS VSS VDD VDD _10638_ sky130_fd_sc_hd__nand2_4
X_19859_ _10593_ _10638_ net515 VSS VSS VDD VDD _10639_ sky130_fd_sc_hd__a21oi_1
X_19860_ net620 _10636_ _10639_ VSS VSS VDD VDD _10640_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_18_449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19862_ _12220_ _10552_ VSS VSS VDD VDD _10642_ sky130_fd_sc_hd__nand2_1
X_19863_ _12227_ net424 VSS VSS VDD VDD _10643_ sky130_fd_sc_hd__nor2_2
X_19864_ _12222_ net426 VSS VSS VDD VDD _10644_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_18_448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19866_ _10643_ _10644_ net587 VSS VSS VDD VDD _10646_ sky130_fd_sc_hd__o21ai_0
X_19867_ net526 net424 VSS VSS VDD VDD _10647_ sky130_fd_sc_hd__nor2_2
X_19868_ _10495_ net427 _10507_ VSS VSS VDD VDD _10648_ sky130_fd_sc_hd__o21ai_1
X_19869_ _12221_ net426 _10509_ VSS VSS VDD VDD _10649_ sky130_fd_sc_hd__o21ai_0
X_19870_ _12230_ net424 VSS VSS VDD VDD _10650_ sky130_fd_sc_hd__nor2_1
X_19871_ _10647_ _10648_ _10649_ _10650_ VSS VSS VDD VDD _10651_
+ sky130_fd_sc_hd__o22ai_1
X_19872_ _10541_ _10651_ VSS VSS VDD VDD _10652_ sky130_fd_sc_hd__nor2_1
X_19873_ _10541_ _10642_ _10646_ _10652_ _10574_ VSS VSS VDD
+ VDD _10653_ sky130_fd_sc_hd__a311oi_2
X_19874_ net587 _10585_ VSS VSS VDD VDD _10654_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_18_447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19876_ _12225_ net426 VSS VSS VDD VDD _10656_ sky130_fd_sc_hd__nor2_1
X_19877_ _10647_ _10656_ VSS VSS VDD VDD _10657_ sky130_fd_sc_hd__nor2_1
X_19878_ _10654_ _10657_ VSS VSS VDD VDD _10658_ sky130_fd_sc_hd__nand2_1
X_19879_ _12222_ _10509_ VSS VSS VDD VDD _10659_ sky130_fd_sc_hd__nor2_1
X_19880_ _10495_ _10509_ VSS VSS VDD VDD _10660_ sky130_fd_sc_hd__nand2_2
X_19881_ _10659_ _10660_ net425 VSS VSS VDD VDD _10661_ sky130_fd_sc_hd__nand3b_1
X_19882_ net514 net427 VSS VSS VDD VDD _10662_ sky130_fd_sc_hd__nor2_4
X_19883_ _12236_ net426 VSS VSS VDD VDD _10663_ sky130_fd_sc_hd__nand2_1
X_19884_ _10509_ _10585_ VSS VSS VDD VDD _10664_ sky130_fd_sc_hd__nor2_4
X_19885_ _10662_ _10663_ _10664_ VSS VSS VDD VDD _10665_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_18_446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19887_ _10574_ _10534_ VSS VSS VDD VDD _10667_ sky130_fd_sc_hd__nand2_1
X_19888_ net423 _10632_ _10661_ _10665_ _10667_ VSS VSS VDD
+ VDD _10668_ sky130_fd_sc_hd__a311oi_1
XTAP_TAPCELL_ROW_17_445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19890_ _10658_ _10668_ _10528_ VSS VSS VDD VDD _10670_ sky130_fd_sc_hd__a21oi_1
X_19891_ net525 net426 VSS VSS VDD VDD _10671_ sky130_fd_sc_hd__nor2_2
X_19892_ net587 _10608_ _10671_ _10562_ _12227_ VSS VSS VDD
+ VDD _10672_ sky130_fd_sc_hd__o32ai_1
X_19893_ _10541_ _10672_ VSS VSS VDD VDD _10673_ sky130_fd_sc_hd__nor2_1
X_19894_ _10634_ _10671_ _10507_ VSS VSS VDD VDD _10674_ sky130_fd_sc_hd__o21ai_1
X_19895_ _12225_ net587 VSS VSS VDD VDD _10675_ sky130_fd_sc_hd__nor2_1
X_19896_ net425 _10675_ VSS VSS VDD VDD _10676_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_17_444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19898_ _10507_ net425 VSS VSS VDD VDD _10678_ sky130_fd_sc_hd__nor2_4
X_19899_ _12236_ _10678_ VSS VSS VDD VDD _10679_ sky130_fd_sc_hd__nand2_2
X_19900_ _10674_ _10676_ _10679_ net423 VSS VSS VDD VDD _10680_
+ sky130_fd_sc_hd__a31oi_1
X_19901_ _10673_ _10680_ net620 _10534_ VSS VSS VDD VDD _10681_
+ sky130_fd_sc_hd__o211ai_1
X_19902_ _10534_ _10640_ _10653_ _10670_ _10681_ VSS VSS VDD
+ VDD _10682_ sky130_fd_sc_hd__o311a_1
X_19903_ _10573_ _10598_ _10629_ _10682_ VSS VSS VDD VDD _00096_
+ sky130_fd_sc_hd__nor4_4
X_19904_ u0.w\[0\]\[15\] _10533_ VSS VSS VDD VDD _10683_ sky130_fd_sc_hd__xnor2_4
X_19905_ _10528_ _10683_ VSS VSS VDD VDD _10684_ sky130_fd_sc_hd__nand2_2
X_19906_ net682 _10509_ VSS VSS VDD VDD _10685_ sky130_fd_sc_hd__nor2_1
X_19907_ net427 _10618_ _10685_ VSS VSS VDD VDD _10686_ sky130_fd_sc_hd__nor3_1
X_19908_ _12250_ net425 _10541_ VSS VSS VDD VDD _10687_ sky130_fd_sc_hd__o21ai_0
X_19909_ _12221_ _10509_ VSS VSS VDD VDD _10688_ sky130_fd_sc_hd__nand2_1
X_19910_ _12236_ _10507_ VSS VSS VDD VDD _10689_ sky130_fd_sc_hd__nand2_1
X_19911_ _10688_ _10689_ net425 VSS VSS VDD VDD _10690_ sky130_fd_sc_hd__a21oi_1
X_19912_ _10686_ _10687_ _10690_ _10620_ VSS VSS VDD VDD _10691_
+ sky130_fd_sc_hd__o22ai_1
XTAP_TAPCELL_ROW_17_443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19914_ _10608_ _10662_ _10509_ VSS VSS VDD VDD _10693_ sky130_fd_sc_hd__o21ai_0
X_19915_ net620 _10585_ VSS VSS VDD VDD _10694_ sky130_fd_sc_hd__nand2_4
X_19916_ net684 _10671_ _10694_ VSS VSS VDD VDD _10695_ sky130_fd_sc_hd__a21oi_1
X_19917_ _12221_ _10550_ VSS VSS VDD VDD _10696_ sky130_fd_sc_hd__nand2_2
X_19918_ net515 _10696_ _10638_ _10630_ net693 VSS VSS VDD
+ VDD _10697_ sky130_fd_sc_hd__a32oi_1
X_19919_ _10500_ _10554_ _10697_ VSS VSS VDD VDD _10698_ sky130_fd_sc_hd__o21ai_0
X_19920_ _10574_ net423 VSS VSS VDD VDD _10699_ sky130_fd_sc_hd__nor2_4
X_19921_ _10574_ _10691_ _10693_ _10695_ _10698_ _10699_ VSS
+ VSS VDD VDD _10700_ sky130_fd_sc_hd__a222oi_1
X_19922_ _10500_ _10556_ VSS VSS VDD VDD _10701_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_17_442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19924_ _10696_ _10701_ net515 VSS VSS VDD VDD _10703_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_17_441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19926_ _12220_ net694 _10644_ _10509_ VSS VSS VDD VDD _10705_
+ sky130_fd_sc_hd__a211oi_1
X_19927_ _10703_ _10705_ _10699_ VSS VSS VDD VDD _10706_ sky130_fd_sc_hd__o21ai_0
X_19928_ _10519_ net423 VSS VSS VDD VDD _10707_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_17_440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19930_ _12234_ _10550_ VSS VSS VDD VDD _10709_ sky130_fd_sc_hd__nand2_1
X_19931_ _12222_ _10602_ _10709_ net587 VSS VSS VDD VDD _10710_
+ sky130_fd_sc_hd__o22a_1
X_19932_ _12221_ _10550_ VSS VSS VDD VDD _10711_ sky130_fd_sc_hd__nand2b_2
X_19933_ _12236_ _10556_ VSS VSS VDD VDD _10712_ sky130_fd_sc_hd__nand2_1
X_19934_ net515 _10711_ _10712_ VSS VSS VDD VDD _10713_ sky130_fd_sc_hd__nand3_1
X_19935_ _10707_ _10710_ _10713_ VSS VSS VDD VDD _10714_ sky130_fd_sc_hd__nand3_1
X_19936_ net620 _10541_ VSS VSS VDD VDD _10715_ sky130_fd_sc_hd__nor2_1
X_19937_ _12234_ _10556_ VSS VSS VDD VDD _10716_ sky130_fd_sc_hd__and2_2
X_19938_ _12221_ net424 VSS VSS VDD VDD _10717_ sky130_fd_sc_hd__nor2_2
X_19939_ _10716_ _10717_ net515 VSS VSS VDD VDD _10718_ sky130_fd_sc_hd__o21ai_0
X_19940_ net526 _10552_ VSS VSS VDD VDD _10719_ sky130_fd_sc_hd__nand2_2
X_19941_ _10626_ _10534_ VSS VSS VDD VDD _10720_ sky130_fd_sc_hd__nand2_4
X_19942_ _10715_ _10718_ _10719_ _10720_ VSS VSS VDD VDD _10721_
+ sky130_fd_sc_hd__a31oi_1
X_19943_ net685 net424 VSS VSS VDD VDD _10722_ sky130_fd_sc_hd__nor2_2
X_19944_ _12220_ net426 VSS VSS VDD VDD _10723_ sky130_fd_sc_hd__nor2_2
X_19945_ _10574_ _10541_ VSS VSS VDD VDD _10724_ sky130_fd_sc_hd__nor2_2
X_19946_ _10643_ _10671_ net515 VSS VSS VDD VDD _10725_ sky130_fd_sc_hd__o21ai_0
X_19947_ net515 _10722_ _10723_ _10724_ _10725_ VSS VSS VDD
+ VDD _10726_ sky130_fd_sc_hd__o311ai_1
X_19948_ _10706_ _10714_ _10721_ _10726_ VSS VSS VDD VDD _10727_
+ sky130_fd_sc_hd__nand4_1
X_19949_ _10684_ _10700_ _10727_ VSS VSS VDD VDD _10728_ sky130_fd_sc_hd__o21ai_1
X_19950_ _12234_ _10554_ VSS VSS VDD VDD _10729_ sky130_fd_sc_hd__nor2_1
X_19951_ _10638_ _10711_ _10509_ VSS VSS VDD VDD _10730_ sky130_fd_sc_hd__a21oi_1
X_19952_ _10729_ _10730_ net620 VSS VSS VDD VDD _10731_ sky130_fd_sc_hd__o21ai_1
X_19953_ _10678_ _10633_ VSS VSS VDD VDD _10732_ sky130_fd_sc_hd__nor2_2
X_19954_ _12221_ _10552_ _10647_ net514 VSS VSS VDD VDD _10733_
+ sky130_fd_sc_hd__a22oi_1
X_19955_ _10500_ _10732_ _10733_ _10574_ VSS VSS VDD VDD _10734_
+ sky130_fd_sc_hd__o211ai_1
X_19956_ _10585_ _10731_ _10734_ VSS VSS VDD VDD _10735_ sky130_fd_sc_hd__nand3_1
X_19957_ _10580_ _10722_ net587 VSS VSS VDD VDD _10736_ sky130_fd_sc_hd__o21ai_0
X_19958_ net620 _10679_ _10736_ VSS VSS VDD VDD _10737_ sky130_fd_sc_hd__and3_1
X_19959_ _10500_ net426 VSS VSS VDD VDD _10738_ sky130_fd_sc_hd__nor2_1
X_19960_ _10717_ _10723_ net587 VSS VSS VDD VDD _10739_ sky130_fd_sc_hd__o21ai_0
X_19961_ net515 _10643_ _10738_ _10739_ _10574_ VSS VSS VDD
+ VDD _10740_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_17_439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19963_ _10737_ _10740_ _10541_ VSS VSS VDD VDD _10742_ sky130_fd_sc_hd__o21ai_0
X_19964_ _10626_ _10683_ VSS VSS VDD VDD _10743_ sky130_fd_sc_hd__nand2_4
X_19965_ _10735_ _10742_ _10743_ VSS VSS VDD VDD _10744_ sky130_fd_sc_hd__a21oi_2
X_19966_ _12234_ net693 VSS VSS VDD VDD _10745_ sky130_fd_sc_hd__nor2_1
X_19967_ _10509_ _10671_ _10745_ VSS VSS VDD VDD _10746_ sky130_fd_sc_hd__nor3_1
X_19968_ net515 _10608_ _10723_ VSS VSS VDD VDD _10747_ sky130_fd_sc_hd__nor3_1
X_19969_ _10746_ _10747_ _10699_ VSS VSS VDD VDD _10748_ sky130_fd_sc_hd__o21ai_0
X_19970_ _10495_ net424 VSS VSS VDD VDD _10749_ sky130_fd_sc_hd__nor2_2
X_19971_ _10662_ _10749_ _10509_ VSS VSS VDD VDD _10750_ sky130_fd_sc_hd__o21ai_1
X_19972_ _10725_ _10750_ VSS VSS VDD VDD _10751_ sky130_fd_sc_hd__nand2_1
X_19973_ _10707_ _10751_ VSS VSS VDD VDD _10752_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_17_438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19975_ _12230_ _12234_ net587 VSS VSS VDD VDD _10754_ sky130_fd_sc_hd__mux2i_1
X_19976_ net424 _10754_ VSS VSS VDD VDD _10755_ sky130_fd_sc_hd__nand2_1
X_19977_ _12246_ net620 net424 _10755_ net423 VSS VSS VDD
+ VDD _10756_ sky130_fd_sc_hd__o311ai_4
X_19978_ _10748_ _10752_ _10756_ _10536_ VSS VSS VDD VDD _10757_
+ sky130_fd_sc_hd__a31oi_2
X_19979_ _10757_ _10744_ _10728_ VSS VSS VDD VDD _00097_ sky130_fd_sc_hd__nor3_4
X_19980_ _12222_ _12227_ _10556_ VSS VSS VDD VDD _10758_ sky130_fd_sc_hd__nor3_2
X_19981_ _12230_ _10552_ _10558_ _12234_ _10758_ net515 VSS
+ VSS VDD VDD _10759_ sky130_fd_sc_hd__a222oi_1
X_19982_ _10574_ _10759_ VSS VSS VDD VDD _10760_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_17_437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19984_ _10495_ net686 VSS VSS VDD VDD _10762_ sky130_fd_sc_hd__nand2_4
X_19985_ _12225_ _10509_ net693 VSS VSS VDD VDD _10763_ sky130_fd_sc_hd__a21oi_1
X_19986_ _12252_ net693 _10762_ _10763_ _10519_ VSS VSS VDD
+ VDD _10764_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_17_436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_19988_ _12241_ net426 _10552_ _12225_ VSS VSS VDD VDD _10766_
+ sky130_fd_sc_hd__a22oi_2
X_19989_ _12220_ net424 VSS VSS VDD VDD _10767_ sky130_fd_sc_hd__and2_1
X_19990_ _12227_ _10678_ VSS VSS VDD VDD _10768_ sky130_fd_sc_hd__nand2_1
X_19991_ _10509_ _10717_ _10767_ _10768_ net620 VSS VSS VDD
+ VDD _10769_ sky130_fd_sc_hd__o311ai_2
X_19992_ net620 _10766_ _10769_ _10528_ net423 VSS VSS VDD
+ VDD _10770_ sky130_fd_sc_hd__o2111ai_4
X_19993_ _10626_ net423 _10760_ _10764_ _10770_ VSS VSS VDD
+ VDD _10771_ sky130_fd_sc_hd__o41ai_1
X_19994_ _10565_ _10662_ _12221_ VSS VSS VDD VDD _10772_ sky130_fd_sc_hd__o21ai_0
X_19995_ _10622_ _10685_ _10749_ _10591_ VSS VSS VDD VDD _10773_
+ sky130_fd_sc_hd__a22oi_1
X_19996_ _10519_ _10541_ VSS VSS VDD VDD _10774_ sky130_fd_sc_hd__nand2_2
X_19997_ _10772_ _10773_ _10774_ VSS VSS VDD VDD _10775_ sky130_fd_sc_hd__a21oi_1
X_19998_ _10590_ _10762_ _10519_ net693 VSS VSS VDD VDD _10776_
+ sky130_fd_sc_hd__a211oi_1
X_19999_ _12246_ _10574_ net693 _10776_ VSS VSS VDD VDD _10777_
+ sky130_fd_sc_hd__a31oi_1
X_20000_ _12243_ net693 VSS VSS VDD VDD _10778_ sky130_fd_sc_hd__nand2_1
X_20001_ _12225_ net587 VSS VSS VDD VDD _10779_ sky130_fd_sc_hd__nand2_1
X_20002_ net694 _10570_ _10779_ VSS VSS VDD VDD _10780_ sky130_fd_sc_hd__nand3_1
X_20003_ _10519_ _10778_ _10780_ VSS VSS VDD VDD _10781_ sky130_fd_sc_hd__nand3_1
X_20004_ _10777_ _10781_ _10541_ VSS VSS VDD VDD _10782_ sky130_fd_sc_hd__a21oi_1
X_20005_ _12230_ net426 VSS VSS VDD VDD _10783_ sky130_fd_sc_hd__and2_0
X_20006_ _10634_ _10723_ _10509_ VSS VSS VDD VDD _10784_ sky130_fd_sc_hd__o21ai_0
X_20007_ _10509_ _10569_ _10783_ _10784_ _10707_ VSS VSS VDD
+ VDD _10785_ sky130_fd_sc_hd__o311a_1
X_20008_ _10528_ _10775_ _10782_ _10785_ VSS VSS VDD VDD _10786_
+ sky130_fd_sc_hd__nor4_1
X_20009_ _12225_ net424 VSS VSS VDD VDD _10787_ sky130_fd_sc_hd__nand2_1
X_20010_ _10787_ _10709_ net515 VSS VSS VDD VDD _10788_ sky130_fd_sc_hd__a21oi_1
X_20011_ _12236_ _10562_ VSS VSS VDD VDD _10789_ sky130_fd_sc_hd__nor2_1
X_20012_ _10694_ _10788_ _10789_ VSS VSS VDD VDD _10790_ sky130_fd_sc_hd__nor3_1
X_20013_ _10536_ _10790_ VSS VSS VDD VDD _10791_ sky130_fd_sc_hd__nor2_1
X_20014_ _12222_ net424 VSS VSS VDD VDD _10792_ sky130_fd_sc_hd__nor2_1
X_20015_ _12221_ net424 VSS VSS VDD VDD _10793_ sky130_fd_sc_hd__and2_0
X_20016_ _10793_ _10647_ net515 VSS VSS VDD VDD _10794_ sky130_fd_sc_hd__o21ai_1
X_20017_ net515 _10792_ _10662_ _10794_ VSS VSS VDD VDD _10795_
+ sky130_fd_sc_hd__o31ai_1
X_20018_ _10699_ _10795_ VSS VSS VDD VDD _10796_ sky130_fd_sc_hd__nand2_1
X_20019_ _12225_ net426 VSS VSS VDD VDD _10797_ sky130_fd_sc_hd__nand2b_2
X_20020_ _12227_ net693 _10749_ _10509_ VSS VSS VDD VDD _10798_
+ sky130_fd_sc_hd__a211oi_1
X_20021_ _10509_ _10797_ _10712_ _10798_ VSS VSS VDD VDD _10799_
+ sky130_fd_sc_hd__a31oi_1
X_20022_ net425 _10619_ _10585_ VSS VSS VDD VDD _10800_ sky130_fd_sc_hd__o21ai_2
X_20023_ net425 _10762_ _10688_ _10800_ _10519_ VSS VSS VDD
+ VDD _10801_ sky130_fd_sc_hd__a311oi_2
X_20024_ _10707_ _10799_ _10801_ VSS VSS VDD VDD _10802_ sky130_fd_sc_hd__a21oi_1
X_20025_ _10791_ _10796_ _10802_ VSS VSS VDD VDD _10803_ sky130_fd_sc_hd__nand3_1
X_20026_ _12232_ net424 _10717_ VSS VSS VDD VDD _10804_ sky130_fd_sc_hd__a21oi_1
X_20027_ net515 _10804_ _10674_ VSS VSS VDD VDD _10805_ sky130_fd_sc_hd__o21ai_0
X_20028_ _10495_ net426 VSS VSS VDD VDD _10806_ sky130_fd_sc_hd__nand2_2
X_20029_ _12232_ net424 VSS VSS VDD VDD _10807_ sky130_fd_sc_hd__nand2_1
X_20030_ net515 _10806_ _10807_ net620 _10618_ VSS VSS VDD
+ VDD _10808_ sky130_fd_sc_hd__a311oi_1
X_20031_ net620 _10805_ _10808_ _10541_ VSS VSS VDD VDD _10809_
+ sky130_fd_sc_hd__a211oi_1
X_20032_ _12232_ net426 VSS VSS VDD VDD _10810_ sky130_fd_sc_hd__nand2_2
X_20033_ _10701_ _10810_ _10509_ VSS VSS VDD VDD _10811_ sky130_fd_sc_hd__a21oi_1
X_20034_ _12236_ net694 _10509_ VSS VSS VDD VDD _10812_ sky130_fd_sc_hd__o21ai_2
X_20035_ _10722_ _10812_ _10699_ VSS VSS VDD VDD _10813_ sky130_fd_sc_hd__o21ai_0
X_20036_ _10622_ _10807_ _10509_ VSS VSS VDD VDD _10814_ sky130_fd_sc_hd__a21oi_1
X_20037_ _10643_ _10812_ _10707_ VSS VSS VDD VDD _10815_ sky130_fd_sc_hd__o21ai_0
X_20038_ _10811_ _10813_ _10814_ _10815_ VSS VSS VDD VDD _10816_
+ sky130_fd_sc_hd__o22ai_1
X_20039_ _10809_ _10816_ _10720_ VSS VSS VDD VDD _10817_ sky130_fd_sc_hd__o21bai_2
X_20040_ _10534_ _10771_ _10786_ _10803_ _10817_ VSS VSS VDD
+ VDD _00098_ sky130_fd_sc_hd__o311a_2
X_20041_ _12221_ net620 _10509_ VSS VSS VDD VDD _10818_ sky130_fd_sc_hd__a21oi_1
X_20042_ net514 net620 _10818_ VSS VSS VDD VDD _10819_ sky130_fd_sc_hd__o21ai_0
X_20043_ _12230_ net515 net620 _10595_ _10819_ VSS VSS VDD
+ VDD _10820_ sky130_fd_sc_hd__o311ai_0
X_20044_ _10574_ _10585_ VSS VSS VDD VDD _10821_ sky130_fd_sc_hd__nand2_2
X_20045_ _10507_ _10701_ VSS VSS VDD VDD _10822_ sky130_fd_sc_hd__nor2_1
X_20046_ _10821_ _10822_ VSS VSS VDD VDD _10823_ sky130_fd_sc_hd__nor2_1
X_20047_ _12222_ _12227_ VSS VSS VDD VDD _10824_ sky130_fd_sc_hd__nor2_1
X_20048_ net424 _10824_ VSS VSS VDD VDD _10825_ sky130_fd_sc_hd__nor2_1
X_20049_ _10793_ _10825_ net515 VSS VSS VDD VDD _10826_ sky130_fd_sc_hd__o21ai_0
X_20050_ _10679_ _10823_ _10826_ VSS VSS VDD VDD _10827_ sky130_fd_sc_hd__nand3_1
X_20051_ _10585_ net425 VSS VSS VDD VDD _10828_ sky130_fd_sc_hd__nor2_1
X_20052_ _12221_ net620 _10509_ VSS VSS VDD VDD _10829_ sky130_fd_sc_hd__o21ai_0
X_20053_ _12222_ _10509_ _10829_ VSS VSS VDD VDD _10830_ sky130_fd_sc_hd__o21ai_0
X_20054_ net525 _10509_ VSS VSS VDD VDD _10831_ sky130_fd_sc_hd__nor2_1
X_20055_ _12232_ _10732_ _10831_ net425 _10694_ VSS VSS VDD
+ VDD _10832_ sky130_fd_sc_hd__a221oi_1
X_20056_ _10828_ _10830_ _10832_ VSS VSS VDD VDD _10833_ sky130_fd_sc_hd__a21oi_1
X_20057_ _10528_ _10820_ _10827_ _10833_ VSS VSS VDD VDD _10834_
+ sky130_fd_sc_hd__nand4_1
X_20058_ _10583_ _10810_ VSS VSS VDD VDD _10835_ sky130_fd_sc_hd__nand2_1
X_20059_ _12236_ net426 VSS VSS VDD VDD _10836_ sky130_fd_sc_hd__nor2_1
X_20060_ _10647_ _10836_ _10509_ VSS VSS VDD VDD _10837_ sky130_fd_sc_hd__o21ai_0
X_20061_ _10835_ _10837_ VSS VSS VDD VDD _10838_ sky130_fd_sc_hd__nand2_1
X_20062_ _10699_ _10838_ VSS VSS VDD VDD _10839_ sky130_fd_sc_hd__nand2_1
X_20063_ _12236_ _10509_ VSS VSS VDD VDD _10840_ sky130_fd_sc_hd__nand2_1
X_20064_ _10574_ _10591_ _10595_ _10840_ _10528_ VSS VSS VDD
+ VDD _10841_ sky130_fd_sc_hd__a41oi_2
XTAP_TAPCELL_ROW_17_435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20066_ _12232_ _10509_ VSS VSS VDD VDD _10843_ sky130_fd_sc_hd__nand2_1
X_20067_ _10509_ _10824_ _10843_ VSS VSS VDD VDD _10844_ sky130_fd_sc_hd__o21ai_0
X_20068_ net427 _10844_ _10821_ VSS VSS VDD VDD _10845_ sky130_fd_sc_hd__a21oi_1
X_20069_ net514 _10602_ VSS VSS VDD VDD _10846_ sky130_fd_sc_hd__nor2_1
X_20070_ _10500_ _10648_ _10694_ _10846_ _10624_ VSS VSS VDD
+ VDD _10847_ sky130_fd_sc_hd__a2111oi_0
X_20071_ _10755_ _10845_ _10847_ VSS VSS VDD VDD _10848_ sky130_fd_sc_hd__a21oi_1
X_20072_ _10839_ _10841_ _10848_ _10683_ VSS VSS VDD VDD _10849_
+ sky130_fd_sc_hd__a31oi_1
X_20073_ _10500_ _10541_ VSS VSS VDD VDD _10850_ sky130_fd_sc_hd__nor2_1
X_20074_ _10495_ _10541_ _10831_ _10660_ _10850_ VSS VSS VDD
+ VDD _10851_ sky130_fd_sc_hd__o32ai_1
X_20075_ _12221_ _10509_ _10541_ VSS VSS VDD VDD _10852_ sky130_fd_sc_hd__nor3_1
X_20076_ _12221_ _10507_ _10585_ VSS VSS VDD VDD _10853_ sky130_fd_sc_hd__nor3_1
X_20077_ _10585_ _10565_ _10852_ _10853_ net425 VSS VSS VDD
+ VDD _10854_ sky130_fd_sc_hd__a2111oi_0
X_20078_ _10500_ _10664_ _10851_ net425 _10854_ VSS VSS VDD
+ VDD _10855_ sky130_fd_sc_hd__a221oi_1
X_20079_ _12225_ _10678_ VSS VSS VDD VDD _10856_ sky130_fd_sc_hd__nand2_1
X_20080_ net514 _10500_ VSS VSS VDD VDD _10857_ sky130_fd_sc_hd__nor2_1
X_20081_ _10831_ _10857_ net425 VSS VSS VDD VDD _10858_ sky130_fd_sc_hd__o21ai_0
X_20082_ _10856_ _10858_ _10528_ _10541_ VSS VSS VDD VDD _10859_
+ sky130_fd_sc_hd__a211oi_1
X_20083_ _12221_ net424 VSS VSS VDD VDD _10860_ sky130_fd_sc_hd__nand2b_1
X_20084_ _10860_ _10806_ _10509_ VSS VSS VDD VDD _10861_ sky130_fd_sc_hd__a21oi_1
X_20085_ _10663_ _10807_ net515 VSS VSS VDD VDD _10862_ sky130_fd_sc_hd__a21oi_1
X_20086_ _10528_ net423 _10861_ _10862_ VSS VSS VDD VDD _10863_
+ sky130_fd_sc_hd__nor4_2
X_20087_ _10528_ _10855_ _10859_ _10863_ VSS VSS VDD VDD _10864_
+ sky130_fd_sc_hd__a211oi_1
X_20088_ _10574_ _10743_ VSS VSS VDD VDD _10865_ sky130_fd_sc_hd__nor2_1
X_20089_ _10509_ _10567_ _10797_ VSS VSS VDD VDD _10866_ sky130_fd_sc_hd__nand3_1
X_20090_ _10509_ _10580_ _10650_ _10866_ _10585_ VSS VSS VDD
+ VDD _10867_ sky130_fd_sc_hd__o311ai_2
X_20091_ _12230_ _10552_ VSS VSS VDD VDD _10868_ sky130_fd_sc_hd__nand2_1
X_20092_ net514 net528 net427 VSS VSS VDD VDD _10869_ sky130_fd_sc_hd__nand3_4
X_20093_ _10541_ _10868_ _10794_ _10869_ VSS VSS VDD VDD _10870_
+ sky130_fd_sc_hd__nand4_1
X_20094_ _10865_ _10867_ _10870_ VSS VSS VDD VDD _10871_ sky130_fd_sc_hd__nand3_1
X_20095_ _12236_ net424 _10583_ VSS VSS VDD VDD _10872_ sky130_fd_sc_hd__o21a_1
X_20096_ net515 _10569_ _10643_ VSS VSS VDD VDD _10873_ sky130_fd_sc_hd__nor3_1
X_20097_ _10872_ _10873_ _10585_ VSS VSS VDD VDD _10874_ sky130_fd_sc_hd__o21ai_0
X_20098_ _12220_ net426 VSS VSS VDD VDD _10875_ sky130_fd_sc_hd__nand2_1
X_20099_ _12230_ net424 VSS VSS VDD VDD _10876_ sky130_fd_sc_hd__nand2_1
X_20100_ net515 _10585_ _10634_ _10738_ VSS VSS VDD VDD _10877_
+ sky130_fd_sc_hd__nor4_1
X_20101_ _10875_ _10664_ _10876_ _10877_ VSS VSS VDD VDD _10878_
+ sky130_fd_sc_hd__a31oi_1
X_20102_ net620 _10627_ _10874_ _10878_ VSS VSS VDD VDD _10879_
+ sky130_fd_sc_hd__nand4_1
X_20103_ net620 _10534_ _10864_ _10871_ _10879_ VSS VSS VDD
+ VDD _10880_ sky130_fd_sc_hd__o311ai_2
X_20104_ _10834_ _10849_ _10880_ VSS VSS VDD VDD _00099_ sky130_fd_sc_hd__a21oi_2
X_20105_ _12227_ net587 VSS VSS VDD VDD _10881_ sky130_fd_sc_hd__nand2_1
X_20106_ _10570_ _10881_ net694 VSS VSS VDD VDD _10882_ sky130_fd_sc_hd__a21oi_1
X_20107_ net423 _10632_ VSS VSS VDD VDD _10883_ sky130_fd_sc_hd__nand2_1
X_20108_ net423 _10710_ _10882_ _10883_ _10626_ VSS VSS VDD
+ VDD _10884_ sky130_fd_sc_hd__o221ai_2
X_20109_ _10656_ _10722_ net515 VSS VSS VDD VDD _10885_ sky130_fd_sc_hd__o21ai_1
X_20110_ _12221_ _10509_ net694 _10716_ VSS VSS VDD VDD _10886_
+ sky130_fd_sc_hd__a31oi_1
X_20111_ _10541_ _10886_ _10528_ VSS VSS VDD VDD _10887_ sky130_fd_sc_hd__o21ai_0
X_20112_ _10541_ _10611_ _10885_ _10887_ VSS VSS VDD VDD _10888_
+ sky130_fd_sc_hd__a31oi_1
X_20113_ _10574_ _10683_ _10888_ VSS VSS VDD VDD _10889_ sky130_fd_sc_hd__nor3_1
X_20114_ _10509_ _10567_ _10810_ VSS VSS VDD VDD _10890_ sky130_fd_sc_hd__nand3_1
X_20115_ _10528_ net423 _10890_ VSS VSS VDD VDD _10891_ sky130_fd_sc_hd__nand3_1
X_20116_ net515 _10797_ _10712_ _10891_ VSS VSS VDD VDD _10892_
+ sky130_fd_sc_hd__a31oi_1
X_20117_ _10509_ _10644_ _10810_ VSS VSS VDD VDD _10893_ sky130_fd_sc_hd__o21ai_0
X_20118_ net515 _10722_ _10767_ net423 _10591_ VSS VSS VDD
+ VDD _10894_ sky130_fd_sc_hd__o311ai_0
X_20119_ net423 _10893_ _10894_ VSS VSS VDD VDD _10895_ sky130_fd_sc_hd__o21ai_0
X_20120_ _10509_ _10696_ _10638_ VSS VSS VDD VDD _10896_ sky130_fd_sc_hd__nand3_1
X_20121_ _12232_ _10509_ _10528_ _10541_ _10896_ VSS VSS VDD
+ VDD _10897_ sky130_fd_sc_hd__o2111ai_1
X_20122_ _10528_ _10895_ _10897_ VSS VSS VDD VDD _10898_ sky130_fd_sc_hd__o21ai_0
X_20123_ _10574_ _10534_ _10892_ _10898_ VSS VSS VDD VDD _10899_
+ sky130_fd_sc_hd__nor4_1
X_20124_ _10499_ _10550_ VSS VSS VDD VDD _10900_ sky130_fd_sc_hd__nand2_1
X_20125_ _10541_ _10900_ _10664_ VSS VSS VDD VDD _10901_ sky130_fd_sc_hd__o21bai_1
X_20126_ _12220_ _10654_ _10685_ net423 net425 VSS VSS VDD
+ VDD _10902_ sky130_fd_sc_hd__a221o_1
X_20127_ _10509_ _10585_ _10500_ VSS VSS VDD VDD _10903_ sky130_fd_sc_hd__a21oi_1
X_20128_ net514 _10903_ _10591_ net693 VSS VSS VDD VDD _10904_
+ sky130_fd_sc_hd__o211ai_1
X_20129_ net514 _10901_ _10902_ _10904_ _10743_ VSS VSS VDD
+ VDD _10905_ sky130_fd_sc_hd__a221oi_2
X_20130_ _10500_ _10557_ _10812_ net423 VSS VSS VDD VDD _10906_
+ sky130_fd_sc_hd__o211ai_1
X_20131_ _10643_ _10767_ _10664_ VSS VSS VDD VDD _10907_ sky130_fd_sc_hd__o21ai_0
X_20132_ net423 _10750_ _10906_ _10907_ VSS VSS VDD VDD _10908_
+ sky130_fd_sc_hd__o211ai_1
X_20133_ _10720_ _10908_ _10574_ VSS VSS VDD VDD _10909_ sky130_fd_sc_hd__o21ai_0
X_20134_ net514 _10701_ _10611_ VSS VSS VDD VDD _10910_ sky130_fd_sc_hd__o21ai_0
X_20135_ net514 _10556_ VSS VSS VDD VDD _10911_ sky130_fd_sc_hd__nand2_1
X_20136_ _10911_ _10900_ _10509_ VSS VSS VDD VDD _10912_ sky130_fd_sc_hd__a21oi_1
X_20137_ _10910_ _10912_ _10541_ VSS VSS VDD VDD _10913_ sky130_fd_sc_hd__o21ai_0
X_20138_ _10621_ _10622_ _10509_ VSS VSS VDD VDD _10914_ sky130_fd_sc_hd__a21oi_1
X_20139_ _12220_ _10602_ _10869_ VSS VSS VDD VDD _10915_ sky130_fd_sc_hd__o21ai_0
X_20140_ _10914_ _10915_ _10585_ VSS VSS VDD VDD _10916_ sky130_fd_sc_hd__o21ai_0
X_20141_ _10913_ _10916_ _10536_ VSS VSS VDD VDD _10917_ sky130_fd_sc_hd__a21oi_1
X_20142_ net515 _10797_ _10638_ VSS VSS VDD VDD _10918_ sky130_fd_sc_hd__nand3_1
X_20143_ _10509_ _10712_ _10806_ VSS VSS VDD VDD _10919_ sky130_fd_sc_hd__nand3_1
X_20144_ _10918_ _10919_ net423 VSS VSS VDD VDD _10920_ sky130_fd_sc_hd__a21oi_1
X_20145_ _12220_ _10509_ _10660_ VSS VSS VDD VDD _10921_ sky130_fd_sc_hd__o21ai_0
X_20146_ net694 _10921_ _10620_ VSS VSS VDD VDD _10922_ sky130_fd_sc_hd__a21oi_2
X_20147_ _10684_ _10920_ _10922_ VSS VSS VDD VDD _10923_ sky130_fd_sc_hd__nor3_1
X_20148_ _10905_ _10909_ _10917_ _10923_ VSS VSS VDD VDD _10924_
+ sky130_fd_sc_hd__nor4_1
X_20149_ _10884_ _10889_ _10899_ _10924_ VSS VSS VDD VDD _00100_
+ sky130_fd_sc_hd__a211oi_1
X_20150_ net587 _10711_ VSS VSS VDD VDD _10925_ sky130_fd_sc_hd__nand2_1
X_20151_ _12225_ net426 VSS VSS VDD VDD _10926_ sky130_fd_sc_hd__nand2_1
X_20152_ _10509_ _10926_ VSS VSS VDD VDD _10927_ sky130_fd_sc_hd__nand2_2
X_20153_ _12232_ net426 VSS VSS VDD VDD _10928_ sky130_fd_sc_hd__nor2_1
X_20154_ _10569_ _10925_ _10927_ _10928_ net620 VSS VSS VDD
+ VDD _10929_ sky130_fd_sc_hd__o221ai_2
X_20155_ _12234_ _10557_ _10783_ _10812_ _10574_ VSS VSS VDD
+ VDD _10930_ sky130_fd_sc_hd__o221ai_1
X_20156_ net527 net620 _10662_ VSS VSS VDD VDD _10931_ sky130_fd_sc_hd__nand3_1
X_20157_ _10574_ net424 _10509_ VSS VSS VDD VDD _10932_ sky130_fd_sc_hd__a21oi_1
X_20158_ _10507_ net620 net426 VSS VSS VDD VDD _10933_ sky130_fd_sc_hd__nor3_1
X_20159_ _10574_ net424 _10932_ _10933_ VSS VSS VDD VDD _10934_
+ sky130_fd_sc_hd__o22ai_1
X_20160_ _12227_ _10552_ _10562_ _12234_ VSS VSS VDD VDD _10935_
+ sky130_fd_sc_hd__o2bb2ai_1
X_20161_ _10500_ _10934_ _10935_ _10574_ VSS VSS VDD VDD _10936_
+ sky130_fd_sc_hd__a22oi_1
X_20162_ _10931_ _10936_ _10541_ VSS VSS VDD VDD _10937_ sky130_fd_sc_hd__a21oi_1
X_20163_ _10541_ _10929_ _10930_ _10937_ _10683_ VSS VSS VDD
+ VDD _10938_ sky130_fd_sc_hd__a311oi_2
X_20164_ _12227_ net427 VSS VSS VDD VDD _10939_ sky130_fd_sc_hd__nand2_1
X_20165_ net427 _10843_ _10939_ _10606_ VSS VSS VDD VDD _10940_
+ sky130_fd_sc_hd__o211ai_1
X_20166_ _10840_ _10881_ net424 VSS VSS VDD VDD _10941_ sky130_fd_sc_hd__a21oi_1
X_20167_ _10541_ _10941_ VSS VSS VDD VDD _10942_ sky130_fd_sc_hd__nor2_1
X_20168_ _10661_ _10942_ _10574_ VSS VSS VDD VDD _10943_ sky130_fd_sc_hd__a21oi_1
X_20169_ _10574_ _10541_ VSS VSS VDD VDD _10944_ sky130_fd_sc_hd__nand2_1
X_20170_ _10638_ _10927_ _10944_ VSS VSS VDD VDD _10945_ sky130_fd_sc_hd__a21oi_1
X_20171_ _10500_ _10678_ _10583_ _10810_ _10821_ VSS VSS VDD
+ VDD _10946_ sky130_fd_sc_hd__a221oi_2
X_20172_ _10940_ _10943_ _10945_ _10946_ _10534_ VSS VSS VDD
+ VDD _10947_ sky130_fd_sc_hd__a2111oi_2
X_20173_ _12227_ _10552_ VSS VSS VDD VDD _10948_ sky130_fd_sc_hd__nand2_1
X_20174_ _12236_ net515 net694 VSS VSS VDD VDD _10949_ sky130_fd_sc_hd__o21ai_0
X_20175_ _10783_ _10812_ _10574_ VSS VSS VDD VDD _10950_ sky130_fd_sc_hd__o21ai_0
X_20176_ _10583_ _10711_ _10950_ VSS VSS VDD VDD _10951_ sky130_fd_sc_hd__a21oi_1
X_20177_ net620 _10948_ _10949_ _10951_ VSS VSS VDD VDD _10952_
+ sky130_fd_sc_hd__a31oi_1
X_20178_ _12225_ _10552_ VSS VSS VDD VDD _10953_ sky130_fd_sc_hd__nand2_1
X_20179_ _10716_ _10758_ net515 VSS VSS VDD VDD _10954_ sky130_fd_sc_hd__o21ai_0
X_20180_ net620 _10953_ _10954_ VSS VSS VDD VDD _10955_ sky130_fd_sc_hd__nand3_1
X_20181_ _12234_ _10633_ _10783_ net620 VSS VSS VDD VDD _10956_
+ sky130_fd_sc_hd__a211o_1
X_20182_ net423 _10955_ _10956_ _10536_ VSS VSS VDD VDD _10957_
+ sky130_fd_sc_hd__a31oi_1
X_20183_ net423 _10952_ _10957_ VSS VSS VDD VDD _10958_ sky130_fd_sc_hd__o21ai_0
X_20184_ _10696_ _10621_ net515 VSS VSS VDD VDD _10959_ sky130_fd_sc_hd__a21oi_1
X_20185_ _10495_ _10557_ VSS VSS VDD VDD _10960_ sky130_fd_sc_hd__nor2_1
X_20186_ _10959_ _10960_ _10541_ VSS VSS VDD VDD _10961_ sky130_fd_sc_hd__o21ai_0
X_20187_ _12220_ net694 VSS VSS VDD VDD _10962_ sky130_fd_sc_hd__nand2b_1
X_20188_ _10962_ _10712_ net515 VSS VSS VDD VDD _10963_ sky130_fd_sc_hd__a21oi_1
X_20189_ _10563_ _10963_ net423 VSS VSS VDD VDD _10964_ sky130_fd_sc_hd__o21ai_0
X_20190_ _10541_ _10754_ VSS VSS VDD VDD _10965_ sky130_fd_sc_hd__nand2_1
X_20191_ net514 _10541_ _10965_ VSS VSS VDD VDD _10966_ sky130_fd_sc_hd__o21ai_0
X_20192_ _10500_ _10595_ _10850_ VSS VSS VDD VDD _10967_ sky130_fd_sc_hd__a21oi_1
X_20193_ _10585_ net425 _10565_ VSS VSS VDD VDD _10968_ sky130_fd_sc_hd__nand3_1
X_20194_ net514 _10967_ _10968_ _10719_ net620 VSS VSS VDD
+ VDD _10969_ sky130_fd_sc_hd__o2111ai_2
X_20195_ net427 _10966_ _10969_ VSS VSS VDD VDD _10970_ sky130_fd_sc_hd__a21oi_1
X_20196_ _10574_ _10961_ _10964_ _10684_ _10970_ VSS VSS VDD
+ VDD _10971_ sky130_fd_sc_hd__a311o_1
X_20197_ _10528_ _10938_ _10947_ _10958_ _10971_ VSS VSS VDD
+ VDD _00101_ sky130_fd_sc_hd__o311ai_2
X_20198_ _12232_ net424 VSS VSS VDD VDD _10972_ sky130_fd_sc_hd__nor2_1
X_20199_ _12230_ net424 _10972_ VSS VSS VDD VDD _10973_ sky130_fd_sc_hd__a21oi_1
X_20200_ _10495_ _10562_ _10973_ net515 _10541_ VSS VSS VDD
+ VDD _10974_ sky130_fd_sc_hd__o221ai_1
X_20201_ _12240_ net427 VSS VSS VDD VDD _10975_ sky130_fd_sc_hd__nand2_1
X_20202_ net425 _10762_ _10843_ VSS VSS VDD VDD _10976_ sky130_fd_sc_hd__nand3_1
X_20203_ _10975_ _10976_ _10694_ VSS VSS VDD VDD _10977_ sky130_fd_sc_hd__a21oi_1
X_20204_ _10563_ _10774_ _10822_ _10679_ VSS VSS VDD VDD _10978_
+ sky130_fd_sc_hd__nor4b_1
X_20205_ _10574_ _10800_ _10974_ _10977_ _10978_ VSS VSS VDD
+ VDD _10979_ sky130_fd_sc_hd__a311oi_1
X_20206_ _10534_ _10979_ VSS VSS VDD VDD _10980_ sky130_fd_sc_hd__nand2_1
X_20207_ _10644_ _10927_ _10724_ VSS VSS VDD VDD _10981_ sky130_fd_sc_hd__o21ai_0
X_20208_ _12221_ _10509_ VSS VSS VDD VDD _10982_ sky130_fd_sc_hd__nor2_1
X_20209_ _12225_ _10509_ net426 _10982_ VSS VSS VDD VDD _10983_
+ sky130_fd_sc_hd__a211oi_1
X_20210_ _12241_ net424 _10699_ VSS VSS VDD VDD _10984_ sky130_fd_sc_hd__o21ai_0
X_20211_ _10861_ _10981_ _10983_ _10984_ VSS VSS VDD VDD _10985_
+ sky130_fd_sc_hd__o22a_1
X_20212_ net424 _10824_ _10509_ VSS VSS VDD VDD _10986_ sky130_fd_sc_hd__a21oi_1
X_20213_ _10509_ _10567_ _10622_ _10926_ _10986_ VSS VSS VDD
+ VDD _10987_ sky130_fd_sc_hd__a32oi_1
X_20214_ _10715_ _10987_ VSS VSS VDD VDD _10988_ sky130_fd_sc_hd__nand2_1
X_20215_ _12230_ net694 VSS VSS VDD VDD _10989_ sky130_fd_sc_hd__nor2_1
X_20216_ _10749_ _10989_ _10509_ VSS VSS VDD VDD _10990_ sky130_fd_sc_hd__o21ai_0
X_20217_ _12225_ _10562_ _10707_ _10990_ VSS VSS VDD VDD _10991_
+ sky130_fd_sc_hd__o211ai_1
X_20218_ _10683_ _10985_ _10988_ _10991_ VSS VSS VDD VDD _10992_
+ sky130_fd_sc_hd__nand4_2
X_20219_ _12232_ _10507_ VSS VSS VDD VDD _10993_ sky130_fd_sc_hd__nand2_1
X_20220_ net425 _10993_ VSS VSS VDD VDD _10994_ sky130_fd_sc_hd__nor2_1
X_20221_ _10509_ _10567_ _10554_ _10500_ VSS VSS VDD VDD _10995_
+ sky130_fd_sc_hd__o22ai_1
X_20222_ _10541_ _10994_ _10995_ VSS VSS VDD VDD _10996_ sky130_fd_sc_hd__nor3_1
X_20223_ _10585_ net427 _10831_ _10675_ VSS VSS VDD VDD _10997_
+ sky130_fd_sc_hd__nor4_1
X_20224_ _12250_ _10828_ _10996_ _10997_ net620 VSS VSS VDD
+ VDD _10998_ sky130_fd_sc_hd__a2111oi_1
X_20225_ _10509_ _10900_ net514 VSS VSS VDD VDD _10999_ sky130_fd_sc_hd__a21oi_1
X_20226_ net693 _10591_ _10724_ _10953_ VSS VSS VDD VDD _11000_
+ sky130_fd_sc_hd__o211ai_2
X_20227_ _10630_ _10774_ VSS VSS VDD VDD _11001_ sky130_fd_sc_hd__nor2_1
X_20228_ _12236_ _10557_ _10869_ _11001_ VSS VSS VDD VDD _11002_
+ sky130_fd_sc_hd__o211ai_1
X_20229_ _10999_ _11000_ _11002_ VSS VSS VDD VDD _11003_ sky130_fd_sc_hd__o21ai_1
X_20230_ _12236_ _12232_ _10509_ VSS VSS VDD VDD _11004_ sky130_fd_sc_hd__mux2i_1
X_20231_ net427 _11004_ _10585_ VSS VSS VDD VDD _11005_ sky130_fd_sc_hd__o21ai_0
X_20232_ _12234_ _10509_ net425 _10659_ VSS VSS VDD VDD _11006_
+ sky130_fd_sc_hd__a211oi_1
X_20233_ _12239_ _12248_ net427 _10694_ VSS VSS VDD VDD _11007_
+ sky130_fd_sc_hd__or4_1
X_20234_ net620 _11005_ _11006_ _11007_ VSS VSS VDD VDD _11008_
+ sky130_fd_sc_hd__o31ai_1
X_20235_ _10649_ _10825_ VSS VSS VDD VDD _11009_ sky130_fd_sc_hd__or2_0
X_20236_ _10671_ _10972_ net515 VSS VSS VDD VDD _11010_ sky130_fd_sc_hd__o21ai_0
X_20237_ _11009_ _11010_ _10944_ VSS VSS VDD VDD _11011_ sky130_fd_sc_hd__a21oi_1
X_20238_ _10565_ _10857_ net427 VSS VSS VDD VDD _11012_ sky130_fd_sc_hd__o21ai_1
X_20239_ _10694_ _11012_ VSS VSS VDD VDD _11013_ sky130_fd_sc_hd__nor2_1
X_20240_ _12220_ _10509_ net427 VSS VSS VDD VDD _11014_ sky130_fd_sc_hd__nor3_1
X_20241_ _12222_ _10678_ _10774_ _11014_ _10994_ VSS VSS VDD
+ VDD _11015_ sky130_fd_sc_hd__a2111oi_0
X_20242_ _11008_ _11011_ _11013_ _11015_ VSS VSS VDD VDD _11016_
+ sky130_fd_sc_hd__nor4_1
X_20243_ _10720_ _10998_ _11003_ _11016_ _10743_ VSS VSS VDD
+ VDD _11017_ sky130_fd_sc_hd__o32ai_1
X_20244_ _10528_ _10980_ _10992_ _11017_ VSS VSS VDD VDD _00102_
+ sky130_fd_sc_hd__a31oi_2
X_20245_ _12227_ _10562_ _10779_ net694 VSS VSS VDD VDD _11018_
+ sky130_fd_sc_hd__o22a_1
X_20246_ _10662_ _10925_ _10574_ VSS VSS VDD VDD _11019_ sky130_fd_sc_hd__o21ai_0
X_20247_ _10509_ _10696_ _10701_ _11019_ VSS VSS VDD VDD _11020_
+ sky130_fd_sc_hd__a31oi_1
X_20248_ _10519_ _10750_ _11018_ _11020_ net423 VSS VSS VDD
+ VDD _11021_ sky130_fd_sc_hd__a311oi_1
X_20249_ _12248_ net425 VSS VSS VDD VDD _11022_ sky130_fd_sc_hd__nor2_1
X_20250_ net425 _10570_ _10993_ _11022_ net620 VSS VSS VDD
+ VDD _11023_ sky130_fd_sc_hd__a311oi_4
X_20251_ _12222_ _10552_ _10745_ VSS VSS VDD VDD _11024_ sky130_fd_sc_hd__a21oi_1
X_20252_ _10574_ _11024_ VSS VSS VDD VDD _11025_ sky130_fd_sc_hd__nor2_1
X_20253_ _10541_ _11023_ _11025_ VSS VSS VDD VDD _11026_ sky130_fd_sc_hd__nor3_1
X_20254_ net525 _10541_ VSS VSS VDD VDD _11027_ sky130_fd_sc_hd__nor2_1
X_20255_ _10541_ net427 _10762_ _10554_ net683 VSS VSS VDD
+ VDD _11028_ sky130_fd_sc_hd__o32ai_1
X_20256_ _12234_ net587 _10541_ net427 VSS VSS VDD VDD _11029_
+ sky130_fd_sc_hd__nor4_1
X_20257_ _10749_ _11027_ _11028_ _10574_ _11029_ VSS VSS VDD
+ VDD _11030_ sky130_fd_sc_hd__a2111oi_0
X_20258_ _10500_ _10562_ _10701_ VSS VSS VDD VDD _11031_ sky130_fd_sc_hd__o21ai_0
X_20259_ _10541_ _11031_ VSS VSS VDD VDD _11032_ sky130_fd_sc_hd__nand2_1
X_20260_ _12234_ net424 net587 VSS VSS VDD VDD _11033_ sky130_fd_sc_hd__a21oi_1
X_20261_ net515 _10567_ _10926_ _11033_ VSS VSS VDD VDD _11034_
+ sky130_fd_sc_hd__a31oi_1
X_20262_ net423 _10583_ _10709_ net620 VSS VSS VDD VDD _11035_
+ sky130_fd_sc_hd__a31oi_1
X_20263_ net423 _11034_ _11035_ VSS VSS VDD VDD _11036_ sky130_fd_sc_hd__o21a_1
X_20264_ _11030_ _11032_ _10536_ _11036_ VSS VSS VDD VDD _11037_
+ sky130_fd_sc_hd__a211oi_1
X_20265_ _12236_ _10562_ _10732_ _12221_ _10719_ VSS VSS VDD
+ VDD _11038_ sky130_fd_sc_hd__o221ai_2
X_20266_ net425 _11004_ VSS VSS VDD VDD _11039_ sky130_fd_sc_hd__nand2_1
X_20267_ net427 _10591_ _10660_ VSS VSS VDD VDD _11040_ sky130_fd_sc_hd__nand3_1
X_20268_ _11039_ _11040_ _10541_ VSS VSS VDD VDD _11041_ sky130_fd_sc_hd__a21oi_1
X_20269_ _10541_ _11038_ _11041_ _10720_ net620 VSS VSS VDD
+ VDD _11042_ sky130_fd_sc_hd__a2111oi_1
X_20270_ net427 _10762_ _10843_ VSS VSS VDD VDD _11043_ sky130_fd_sc_hd__nand3_1
X_20271_ _12236_ _10557_ _11043_ _10585_ VSS VSS VDD VDD _11044_
+ sky130_fd_sc_hd__o211ai_1
X_20272_ _10624_ _10605_ _10822_ _10729_ _10541_ VSS VSS VDD
+ VDD _11045_ sky130_fd_sc_hd__o41ai_2
X_20273_ _11044_ _11045_ _10574_ _10720_ VSS VSS VDD VDD _11046_
+ sky130_fd_sc_hd__a211oi_1
X_20274_ _11037_ _11042_ _11046_ VSS VSS VDD VDD _11047_ sky130_fd_sc_hd__nor3_2
X_20275_ _12227_ net427 _11012_ VSS VSS VDD VDD _11048_ sky130_fd_sc_hd__o21ai_1
X_20276_ _10509_ _10662_ _10758_ VSS VSS VDD VDD _11049_ sky130_fd_sc_hd__nor3_1
X_20277_ net515 _10716_ _10972_ VSS VSS VDD VDD _11050_ sky130_fd_sc_hd__nor3_1
X_20278_ _10574_ _11049_ _11050_ VSS VSS VDD VDD _11051_ sky130_fd_sc_hd__nor3_1
X_20279_ _10574_ _11048_ _11051_ VSS VSS VDD VDD _11052_ sky130_fd_sc_hd__a21oi_1
X_20280_ net515 _10580_ _10650_ _10925_ _10723_ VSS VSS VDD
+ VDD _11053_ sky130_fd_sc_hd__o32ai_1
X_20281_ _12220_ _10509_ VSS VSS VDD VDD _11054_ sky130_fd_sc_hd__nor2_1
X_20282_ net515 _10644_ _10722_ VSS VSS VDD VDD _11055_ sky130_fd_sc_hd__nor3_1
X_20283_ _10821_ _11054_ _11055_ VSS VSS VDD VDD _11056_ sky130_fd_sc_hd__nor3_1
X_20284_ _10724_ _11053_ _11056_ _10743_ VSS VSS VDD VDD _11057_
+ sky130_fd_sc_hd__a211oi_1
X_20285_ net423 _11052_ _11057_ VSS VSS VDD VDD _11058_ sky130_fd_sc_hd__o21ai_1
X_20286_ _10684_ _11021_ _11026_ _11047_ _11058_ VSS VSS VDD
+ VDD _00103_ sky130_fd_sc_hd__o311ai_2
X_20287_ sa01_sr\[1\] sa30_sub\[7\] VSS VSS VDD VDD _11059_
+ sky130_fd_sc_hd__xnor2_1
X_20288_ sa11_sr\[1\] sa30_sub\[0\] VSS VSS VDD VDD _11060_
+ sky130_fd_sc_hd__xnor2_1
X_20289_ sa30_sub\[1\] sa21_sr\[0\] sa21_sr\[7\] VSS VSS VDD
+ VDD _11061_ sky130_fd_sc_hd__xnor3_1
X_20290_ _11059_ _11060_ _11061_ VSS VSS VDD VDD _11062_ sky130_fd_sc_hd__xnor3_1
X_20291_ text_in_r\[73\] _11062_ net490 VSS VSS VDD VDD _11063_
+ sky130_fd_sc_hd__mux2i_4
X_20292_ u0.w\[1\]\[9\] _11063_ VSS VSS VDD VDD _11064_ sky130_fd_sc_hd__xor2_4
X_20293_ net628 VSS VSS VDD VDD _11065_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_17_434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20296_ sa11_sr\[0\] sa21_sr\[7\] net689 VSS VSS VDD VDD
+ _11067_ sky130_fd_sc_hd__xnor3_1
X_20297_ _08808_ _11067_ VSS VSS VDD VDD _11068_ sky130_fd_sc_hd__xnor2_1
X_20298_ text_in_r\[72\] _11068_ net490 VSS VSS VDD VDD _11069_
+ sky130_fd_sc_hd__mux2i_4
X_20299_ u0.w\[1\]\[8\] _11069_ VSS VSS VDD VDD _11070_ sky130_fd_sc_hd__xor2_4
X_20300_ net622 VSS VSS VDD VDD _11071_ sky130_fd_sc_hd__clkinv_8
XTAP_TAPCELL_ROW_17_432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20302_ sa11_sr\[2\] sa30_sub\[2\] sa01_sr\[2\] VSS VSS VDD
+ VDD _11072_ sky130_fd_sc_hd__xnor3_1
X_20303_ _06479_ _11072_ VSS VSS VDD VDD _11073_ sky130_fd_sc_hd__xor2_1
X_20304_ text_in_r\[74\] _11073_ net490 VSS VSS VDD VDD _11074_
+ sky130_fd_sc_hd__mux2i_4
X_20305_ _11074_ u0.w\[1\]\[10\] VSS VSS VDD VDD _11075_ sky130_fd_sc_hd__xnor2_4
X_20306_ net420 VSS VSS VDD VDD _11076_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_17_431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20315_ sa21_sr\[5\] sa30_sub\[6\] VSS VSS VDD VDD _11082_
+ sky130_fd_sc_hd__xnor2_1
X_20316_ sa30_sub\[5\] sa11_sr\[6\] sa01_sr\[6\] VSS VSS VDD
+ VDD _11083_ sky130_fd_sc_hd__xnor3_4
X_20317_ _11082_ _11083_ VSS VSS VDD VDD _11084_ sky130_fd_sc_hd__xnor2_1
X_20318_ net492 _11084_ VSS VSS VDD VDD _11085_ sky130_fd_sc_hd__nor2_4
X_20319_ net492 text_in_r\[78\] _11085_ VSS VSS VDD VDD _11086_
+ sky130_fd_sc_hd__a21oi_4
X_20320_ u0.w\[1\]\[14\] _11086_ VSS VSS VDD VDD _11087_ sky130_fd_sc_hd__xor2_4
X_20321_ sa01_sr\[7\] sa30_sub\[6\] VSS VSS VDD VDD _11088_
+ sky130_fd_sc_hd__xnor2_4
X_20322_ _08888_ _11088_ VSS VSS VDD VDD _11089_ sky130_fd_sc_hd__xnor2_2
X_20323_ sa11_sr\[7\] _11089_ VSS VSS VDD VDD _11090_ sky130_fd_sc_hd__xnor2_4
X_20324_ text_in_r\[79\] _11090_ net512 VSS VSS VDD VDD _11091_
+ sky130_fd_sc_hd__mux2i_4
X_20325_ u0.w\[1\]\[15\] _11091_ VSS VSS VDD VDD _11092_ sky130_fd_sc_hd__xnor2_4
X_20326_ _11087_ _11092_ VSS VSS VDD VDD _11093_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_17_423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20329_ sa01_sr\[3\] sa30_sub\[7\] VSS VSS VDD VDD _11096_
+ sky130_fd_sc_hd__xnor2_1
X_20330_ sa30_sub\[2\] sa11_sr\[3\] VSS VSS VDD VDD _11097_
+ sky130_fd_sc_hd__xnor2_1
X_20331_ _08831_ _11096_ _11097_ VSS VSS VDD VDD _11098_ sky130_fd_sc_hd__xnor3_4
X_20332_ text_in_r\[75\] net492 VSS VSS VDD VDD _11099_ sky130_fd_sc_hd__nand2b_1
X_20333_ net492 _11098_ _11099_ u0.w\[1\]\[11\] VSS VSS VDD
+ VDD _11100_ sky130_fd_sc_hd__o211a_1
X_20334_ net492 text_in_r\[75\] VSS VSS VDD VDD _11101_ sky130_fd_sc_hd__and2_1
X_20335_ net512 _11098_ _11101_ u0.w\[1\]\[11\] VSS VSS VDD
+ VDD _11102_ sky130_fd_sc_hd__a211oi_4
X_20336_ _11102_ _11100_ VSS VSS VDD VDD _11103_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_16_421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20338_ _11065_ _11103_ VSS VSS VDD VDD _11105_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_16_420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20340_ net492 _11098_ _11099_ u0.w\[1\]\[11\] VSS VSS VDD
+ VDD _11107_ sky130_fd_sc_hd__o211ai_4
X_20341_ net512 _11098_ _11101_ u0.w\[1\]\[11\] VSS VSS VDD
+ VDD _11108_ sky130_fd_sc_hd__a211o_2
X_20342_ _11107_ _11108_ VSS VSS VDD VDD _11109_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_16_419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20345_ _12272_ _11109_ VSS VSS VDD VDD _11112_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_16_417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20347_ _12261_ _11109_ VSS VSS VDD VDD _11114_ sky130_fd_sc_hd__nand2_2
X_20348_ net621 _11103_ VSS VSS VDD VDD _11115_ sky130_fd_sc_hd__nand2_4
X_20349_ _11076_ _11114_ _11115_ VSS VSS VDD VDD _11116_ sky130_fd_sc_hd__nand3_1
X_20350_ sa01_sr\[4\] sa30_sub\[7\] VSS VSS VDD VDD _11117_
+ sky130_fd_sc_hd__xor2_1
X_20351_ sa30_sub\[3\] sa11_sr\[4\] VSS VSS VDD VDD _11118_
+ sky130_fd_sc_hd__xnor2_1
X_20352_ sa21_sr\[3\] sa30_sub\[4\] sa21_sr\[7\] VSS VSS VDD
+ VDD _11119_ sky130_fd_sc_hd__xor3_1
X_20353_ _11117_ _11118_ _11119_ VSS VSS VDD VDD _11120_ sky130_fd_sc_hd__xnor3_4
X_20354_ text_in_r\[76\] _11120_ net490 VSS VSS VDD VDD _11121_
+ sky130_fd_sc_hd__mux2i_4
X_20355_ u0.w\[1\]\[12\] _11121_ VSS VSS VDD VDD _11122_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_16_416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20357_ _11076_ _11105_ _11112_ _11116_ _11122_ VSS VSS VDD
+ VDD _11124_ sky130_fd_sc_hd__o311ai_0
X_20358_ _11121_ u0.w\[1\]\[12\] VSS VSS VDD VDD _11125_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_16_415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20360_ _12270_ _11076_ VSS VSS VDD VDD _11127_ sky130_fd_sc_hd__nor2_1
X_20361_ net621 net422 VSS VSS VDD VDD _11128_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_16_414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20363_ _11127_ _11128_ _11103_ VSS VSS VDD VDD _11130_ sky130_fd_sc_hd__o21ai_0
X_20364_ _11125_ _11130_ VSS VSS VDD VDD _11131_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_16_413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20368_ _11065_ _11076_ VSS VSS VDD VDD _11135_ sky130_fd_sc_hd__nand2_1
X_20369_ _12258_ _11076_ _11109_ _11135_ VSS VSS VDD VDD _11136_
+ sky130_fd_sc_hd__o211ai_2
X_20370_ sa30_sub\[4\] sa11_sr\[5\] VSS VSS VDD VDD _11137_
+ sky130_fd_sc_hd__xor2_2
X_20371_ _08823_ _11137_ VSS VSS VDD VDD _11138_ sky130_fd_sc_hd__xnor2_4
X_20372_ text_in_r\[77\] _11138_ net512 VSS VSS VDD VDD _11139_
+ sky130_fd_sc_hd__mux2i_4
X_20373_ u0.w\[1\]\[13\] _11139_ VSS VSS VDD VDD _11140_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_16_410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20377_ _11131_ _11136_ _11140_ VSS VSS VDD VDD _11144_ sky130_fd_sc_hd__a21oi_1
X_20378_ _11124_ _11144_ VSS VSS VDD VDD _11145_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_16_407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20380_ _12272_ _11100_ _11102_ VSS VSS VDD VDD _11147_ sky130_fd_sc_hd__or3_1
X_20381_ _12257_ _11107_ _11108_ VSS VSS VDD VDD _11148_ sky130_fd_sc_hd__nand3_4
X_20382_ _11071_ _11109_ VSS VSS VDD VDD _11149_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_16_406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20385_ _11148_ _11149_ _11076_ VSS VSS VDD VDD _11152_ sky130_fd_sc_hd__a21oi_1
X_20386_ _11076_ _11114_ _11147_ _11152_ VSS VSS VDD VDD _11153_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_16_404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20389_ net420 _11103_ VSS VSS VDD VDD _11156_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_16_402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20392_ _11071_ _11103_ VSS VSS VDD VDD _11159_ sky130_fd_sc_hd__nor2_2
X_20393_ _12261_ net658 _11159_ VSS VSS VDD VDD _11160_ sky130_fd_sc_hd__a21oi_1
X_20394_ _12263_ _11156_ _11160_ net664 _11125_ VSS VSS VDD
+ VDD _11161_ sky130_fd_sc_hd__o221ai_1
X_20395_ net665 _11153_ _11161_ VSS VSS VDD VDD _11162_ sky130_fd_sc_hd__o21ai_0
X_20396_ _11140_ _11162_ VSS VSS VDD VDD _11163_ sky130_fd_sc_hd__nand2_1
X_20397_ _11087_ _11092_ VSS VSS VDD VDD _11164_ sky130_fd_sc_hd__nand2_4
X_20398_ _12261_ VSS VSS VDD VDD _11165_ sky130_fd_sc_hd__inv_1
X_20399_ _12263_ _11165_ net420 VSS VSS VDD VDD _11166_ sky130_fd_sc_hd__mux2i_2
X_20400_ _11103_ _11166_ _11125_ VSS VSS VDD VDD _11167_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_16_400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20402_ _12256_ _11156_ VSS VSS VDD VDD _11169_ sky130_fd_sc_hd__nor2_1
X_20403_ _11071_ _11103_ VSS VSS VDD VDD _11170_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_16_399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20405_ _12258_ _11109_ VSS VSS VDD VDD _11172_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20407_ _11170_ _11172_ net420 VSS VSS VDD VDD _11174_ sky130_fd_sc_hd__a21oi_1
X_20408_ _11167_ _11169_ _11174_ VSS VSS VDD VDD _11175_ sky130_fd_sc_hd__nor3_1
X_20409_ net422 _11103_ VSS VSS VDD VDD _11176_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_15_397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20413_ _12279_ net658 _11176_ _12257_ net665 VSS VSS VDD
+ VDD _11180_ sky130_fd_sc_hd__a221oi_1
X_20414_ _11140_ _11175_ _11180_ VSS VSS VDD VDD _11181_ sky130_fd_sc_hd__nor3_1
X_20415_ _12266_ _11103_ VSS VSS VDD VDD _11182_ sky130_fd_sc_hd__nor2_2
X_20416_ _11076_ _11182_ VSS VSS VDD VDD _11183_ sky130_fd_sc_hd__nand2_1
X_20417_ _12258_ _11109_ VSS VSS VDD VDD _11184_ sky130_fd_sc_hd__nor2_1
X_20418_ _11076_ _11184_ VSS VSS VDD VDD _11185_ sky130_fd_sc_hd__nor2_1
X_20419_ _11114_ _11185_ VSS VSS VDD VDD _11186_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20421_ net420 _11109_ VSS VSS VDD VDD _11188_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_15_393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20423_ _12258_ _11103_ VSS VSS VDD VDD _11190_ sky130_fd_sc_hd__nor2_4
X_20424_ _12261_ _11103_ _11190_ VSS VSS VDD VDD _11191_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_15_392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20426_ _12268_ _11188_ _11191_ net422 _11122_ VSS VSS VDD
+ VDD _11193_ sky130_fd_sc_hd__a221oi_1
X_20427_ u0.w\[1\]\[13\] _11139_ VSS VSS VDD VDD _11194_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_15_391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20430_ _11122_ _11183_ _11186_ _11193_ _11194_ VSS VSS VDD
+ VDD _11197_ sky130_fd_sc_hd__a311oi_1
X_20431_ _11164_ _11181_ _11197_ VSS VSS VDD VDD _11198_ sky130_fd_sc_hd__nor3_1
X_20432_ _11071_ net421 VSS VSS VDD VDD _11199_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_15_389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20434_ net511 net501 VSS VSS VDD VDD _11201_ sky130_fd_sc_hd__nand2_1
X_20435_ _11199_ _11201_ _11194_ VSS VSS VDD VDD _11202_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_15_388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20437_ _12257_ net422 _11140_ VSS VSS VDD VDD _11204_ sky130_fd_sc_hd__nor3_1
X_20438_ net501 _11140_ _11076_ VSS VSS VDD VDD _11205_ sky130_fd_sc_hd__a21oi_1
X_20439_ _12257_ net422 _11194_ VSS VSS VDD VDD _11206_ sky130_fd_sc_hd__nand3_1
X_20440_ _11071_ _11076_ _11140_ VSS VSS VDD VDD _11207_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_15_387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20442_ net511 _11205_ _11206_ _11207_ _11109_ VSS VSS VDD
+ VDD _11209_ sky130_fd_sc_hd__o2111ai_1
X_20443_ _11109_ _11202_ _11204_ _11209_ _11122_ VSS VSS VDD
+ VDD _11210_ sky130_fd_sc_hd__o311a_1
X_20444_ _11076_ _11103_ VSS VSS VDD VDD _11211_ sky130_fd_sc_hd__nand2_1
X_20445_ net420 _11109_ VSS VSS VDD VDD _11212_ sky130_fd_sc_hd__nand2_4
X_20446_ _11211_ _11212_ VSS VSS VDD VDD _11213_ sky130_fd_sc_hd__nand2_1
X_20447_ _11140_ _11122_ VSS VSS VDD VDD _11214_ sky130_fd_sc_hd__nor2_8
X_20448_ _12257_ _11076_ VSS VSS VDD VDD _11215_ sky130_fd_sc_hd__nor2_1
X_20449_ net658 _11215_ VSS VSS VDD VDD _11216_ sky130_fd_sc_hd__nand2_1
X_20450_ _11214_ _11216_ VSS VSS VDD VDD _11217_ sky130_fd_sc_hd__nand2_1
X_20451_ _12266_ _11176_ _11213_ _12256_ _11217_ VSS VSS VDD
+ VDD _11218_ sky130_fd_sc_hd__a221oi_1
X_20452_ _11140_ _11125_ VSS VSS VDD VDD _11219_ sky130_fd_sc_hd__nand2_8
X_20453_ _12257_ VSS VSS VDD VDD _11220_ sky130_fd_sc_hd__inv_1
X_20454_ _11220_ _11109_ VSS VSS VDD VDD _11221_ sky130_fd_sc_hd__nand2_4
X_20455_ _12266_ _11103_ VSS VSS VDD VDD _11222_ sky130_fd_sc_hd__nand2_4
X_20456_ _11221_ _11222_ _11076_ VSS VSS VDD VDD _11223_ sky130_fd_sc_hd__a21oi_1
X_20457_ _12256_ net658 VSS VSS VDD VDD _11224_ sky130_fd_sc_hd__nand2_1
X_20458_ _12270_ _11109_ VSS VSS VDD VDD _11225_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_15_386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20460_ _11224_ _11225_ _11075_ VSS VSS VDD VDD _11227_ sky130_fd_sc_hd__a21oi_1
X_20461_ u0.w\[1\]\[14\] _11086_ VSS VSS VDD VDD _11228_ sky130_fd_sc_hd__xnor2_4
X_20462_ _11228_ _11092_ VSS VSS VDD VDD _11229_ sky130_fd_sc_hd__nor2_8
X_20463_ _11219_ _11223_ _11227_ _11229_ VSS VSS VDD VDD _11230_
+ sky130_fd_sc_hd__o31ai_1
X_20464_ net621 _11109_ VSS VSS VDD VDD _11231_ sky130_fd_sc_hd__nor2_1
X_20465_ _12266_ _11109_ _11221_ _11076_ VSS VSS VDD VDD _11232_
+ sky130_fd_sc_hd__o211ai_1
X_20466_ _11076_ _11231_ _11105_ _11232_ _11125_ VSS VSS VDD
+ VDD _11233_ sky130_fd_sc_hd__o311ai_0
X_20467_ _12263_ _11109_ VSS VSS VDD VDD _11234_ sky130_fd_sc_hd__nor2_1
X_20468_ _11234_ _11190_ net664 VSS VSS VDD VDD _11235_ sky130_fd_sc_hd__o21ai_1
X_20469_ _12256_ _11176_ net665 VSS VSS VDD VDD _11236_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_15_385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20471_ _11235_ _11236_ _11194_ VSS VSS VDD VDD _11238_ sky130_fd_sc_hd__a21oi_1
X_20472_ _12268_ _11109_ VSS VSS VDD VDD _11239_ sky130_fd_sc_hd__nand2_1
X_20473_ _11148_ _11239_ net665 VSS VSS VDD VDD _11240_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_15_384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20475_ _11122_ _11109_ VSS VSS VDD VDD _11241_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_15_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20477_ _12263_ net422 net658 VSS VSS VDD VDD _11243_ sky130_fd_sc_hd__nor3_1
X_20478_ net501 _11241_ _11243_ VSS VSS VDD VDD _11244_ sky130_fd_sc_hd__a21oi_1
X_20479_ _11076_ _11240_ _11244_ VSS VSS VDD VDD _11245_ sky130_fd_sc_hd__o21ai_0
X_20480_ _11241_ _11127_ _11140_ VSS VSS VDD VDD _11246_ sky130_fd_sc_hd__a21oi_1
X_20481_ _11233_ _11238_ _11245_ _11246_ VSS VSS VDD VDD _11247_
+ sky130_fd_sc_hd__a22oi_1
X_20482_ _11228_ _11092_ VSS VSS VDD VDD _11248_ sky130_fd_sc_hd__nand2_4
X_20483_ _11210_ _11218_ _11230_ _11247_ _11248_ VSS VSS VDD
+ VDD _11249_ sky130_fd_sc_hd__o32ai_1
X_20484_ _11093_ _11145_ _11163_ _11198_ _11249_ VSS VSS VDD
+ VDD _00104_ sky130_fd_sc_hd__a311oi_1
X_20485_ _12261_ _11109_ VSS VSS VDD VDD _11250_ sky130_fd_sc_hd__nor2_1
X_20486_ net627 _11103_ VSS VSS VDD VDD _11251_ sky130_fd_sc_hd__nor2_1
X_20487_ _11250_ _11251_ _11076_ VSS VSS VDD VDD _11252_ sky130_fd_sc_hd__o21ai_0
X_20488_ net501 net658 VSS VSS VDD VDD _11253_ sky130_fd_sc_hd__nor2_1
X_20489_ net511 _11253_ _11219_ VSS VSS VDD VDD _11254_ sky130_fd_sc_hd__a21oi_1
X_20490_ _11252_ _11254_ _11164_ VSS VSS VDD VDD _11255_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_15_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20492_ _12263_ net420 VSS VSS VDD VDD _11257_ sky130_fd_sc_hd__nor2_1
X_20493_ net629 _11076_ VSS VSS VDD VDD _11258_ sky130_fd_sc_hd__nor2_1
X_20494_ net658 _11257_ _11258_ VSS VSS VDD VDD _11259_ sky130_fd_sc_hd__nor3_1
X_20495_ _12286_ _11109_ _11122_ VSS VSS VDD VDD _11260_ sky130_fd_sc_hd__o21ai_0
X_20496_ _12257_ _11076_ VSS VSS VDD VDD _11261_ sky130_fd_sc_hd__nand2_1
X_20497_ _12272_ net421 VSS VSS VDD VDD _11262_ sky130_fd_sc_hd__nand2_1
X_20498_ _11261_ _11262_ _11109_ VSS VSS VDD VDD _11263_ sky130_fd_sc_hd__a21oi_1
X_20499_ _11259_ _11260_ _11263_ _11167_ VSS VSS VDD VDD _11264_
+ sky130_fd_sc_hd__o22ai_1
X_20500_ _12257_ _11109_ VSS VSS VDD VDD _11265_ sky130_fd_sc_hd__nor2_4
X_20501_ _12263_ _11103_ VSS VSS VDD VDD _11266_ sky130_fd_sc_hd__nor2_1
X_20502_ _11076_ _11265_ _11266_ VSS VSS VDD VDD _11267_ sky130_fd_sc_hd__nor3_1
X_20503_ _11140_ _11122_ VSS VSS VDD VDD _11268_ sky130_fd_sc_hd__nand2_4
X_20504_ _11076_ _11149_ _11115_ _11267_ _11268_ VSS VSS VDD
+ VDD _11269_ sky130_fd_sc_hd__a311oi_1
X_20505_ _11194_ _11264_ _11269_ VSS VSS VDD VDD _11270_ sky130_fd_sc_hd__a21oi_1
X_20506_ _11255_ _11270_ VSS VSS VDD VDD _11271_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20508_ _11076_ _11103_ VSS VSS VDD VDD _11273_ sky130_fd_sc_hd__nor2_2
X_20509_ _11188_ _11273_ VSS VSS VDD VDD _11274_ sky130_fd_sc_hd__nor2_4
X_20510_ net511 _11231_ _11176_ _12257_ VSS VSS VDD VDD _11275_
+ sky130_fd_sc_hd__a22oi_1
X_20511_ _11071_ _11274_ _11275_ VSS VSS VDD VDD _11276_ sky130_fd_sc_hd__o21ai_1
X_20512_ _12256_ _11109_ VSS VSS VDD VDD _11277_ sky130_fd_sc_hd__nand2_2
X_20513_ net664 _11148_ _11277_ VSS VSS VDD VDD _11278_ sky130_fd_sc_hd__nand3_1
X_20514_ _11194_ _11122_ VSS VSS VDD VDD _11279_ sky130_fd_sc_hd__nand2_4
X_20515_ _12263_ _11103_ VSS VSS VDD VDD _11280_ sky130_fd_sc_hd__nand2_1
X_20516_ _11280_ _11149_ net664 VSS VSS VDD VDD _11281_ sky130_fd_sc_hd__a21oi_1
X_20517_ _11279_ _11281_ VSS VSS VDD VDD _11282_ sky130_fd_sc_hd__nor2_1
X_20518_ _11214_ _11276_ _11278_ _11282_ VSS VSS VDD VDD _11283_
+ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_15_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20520_ _11194_ _11122_ VSS VSS VDD VDD _11285_ sky130_fd_sc_hd__nor2_4
X_20521_ _12263_ _11109_ VSS VSS VDD VDD _11286_ sky130_fd_sc_hd__and2_0
X_20522_ _11265_ _11286_ net421 VSS VSS VDD VDD _11287_ sky130_fd_sc_hd__o21ai_0
X_20523_ _12270_ _11211_ _11285_ _11287_ VSS VSS VDD VDD _11288_
+ sky130_fd_sc_hd__o211ai_1
X_20524_ _11194_ _11125_ VSS VSS VDD VDD _11289_ sky130_fd_sc_hd__nor2_4
X_20525_ _12270_ net658 VSS VSS VDD VDD _11290_ sky130_fd_sc_hd__nor2_1
X_20526_ net626 _11109_ VSS VSS VDD VDD _11291_ sky130_fd_sc_hd__nor2_4
X_20527_ _11290_ _11291_ net664 VSS VSS VDD VDD _11292_ sky130_fd_sc_hd__o21ai_0
X_20528_ _12272_ _11188_ VSS VSS VDD VDD _11293_ sky130_fd_sc_hd__nand2_1
X_20529_ _11289_ _11292_ _11293_ _11248_ VSS VSS VDD VDD _11294_
+ sky130_fd_sc_hd__a31oi_1
X_20530_ _11283_ _11288_ _11294_ VSS VSS VDD VDD _11295_ sky130_fd_sc_hd__nand3_1
X_20531_ _12270_ _11109_ VSS VSS VDD VDD _11296_ sky130_fd_sc_hd__and2_0
X_20532_ _11296_ _11265_ net421 VSS VSS VDD VDD _11297_ sky130_fd_sc_hd__o21ai_0
X_20533_ net501 _11176_ VSS VSS VDD VDD _11298_ sky130_fd_sc_hd__nand2_1
X_20534_ _11140_ _11125_ VSS VSS VDD VDD _11299_ sky130_fd_sc_hd__nor2_4
X_20535_ _12270_ _11103_ VSS VSS VDD VDD _11300_ sky130_fd_sc_hd__nand2_2
X_20536_ _12258_ net658 _11300_ VSS VSS VDD VDD _11301_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_15_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20538_ _12272_ _11109_ VSS VSS VDD VDD _11303_ sky130_fd_sc_hd__and2_1
X_20539_ _11076_ _11265_ _11303_ VSS VSS VDD VDD _11304_ sky130_fd_sc_hd__nor3_1
X_20540_ _11076_ _11301_ _11304_ VSS VSS VDD VDD _11305_ sky130_fd_sc_hd__a21oi_1
X_20541_ _11214_ _11297_ _11298_ _11299_ _11305_ VSS VSS VDD
+ VDD _11306_ sky130_fd_sc_hd__a32o_1
X_20542_ _11076_ _11148_ _11149_ VSS VSS VDD VDD _11307_ sky130_fd_sc_hd__and3_1
X_20543_ _12256_ net658 _11190_ VSS VSS VDD VDD _11308_ sky130_fd_sc_hd__a21oi_1
X_20544_ _11076_ _11308_ _11289_ VSS VSS VDD VDD _11309_ sky130_fd_sc_hd__o21ai_0
X_20545_ _11234_ _11253_ VSS VSS VDD VDD _11310_ sky130_fd_sc_hd__nor2_1
X_20546_ _11076_ _11310_ VSS VSS VDD VDD _11311_ sky130_fd_sc_hd__nor2_1
X_20547_ _12256_ net658 VSS VSS VDD VDD _11312_ sky130_fd_sc_hd__nor2_1
X_20548_ net664 _11312_ _11291_ _11285_ VSS VSS VDD VDD _11313_
+ sky130_fd_sc_hd__o31ai_1
X_20549_ _11307_ _11309_ _11311_ _11313_ VSS VSS VDD VDD _11314_
+ sky130_fd_sc_hd__o22ai_1
X_20550_ _11306_ _11314_ _11093_ VSS VSS VDD VDD _11315_ sky130_fd_sc_hd__o21ai_0
X_20551_ _11065_ _11109_ VSS VSS VDD VDD _11316_ sky130_fd_sc_hd__nand2_2
X_20552_ net628 _11103_ VSS VSS VDD VDD _11317_ sky130_fd_sc_hd__nand2_1
X_20553_ _11316_ _11317_ net664 VSS VSS VDD VDD _11318_ sky130_fd_sc_hd__a21oi_1
X_20554_ _11279_ _11311_ _11318_ VSS VSS VDD VDD _11319_ sky130_fd_sc_hd__nor3_1
X_20555_ _12261_ _11103_ VSS VSS VDD VDD _11320_ sky130_fd_sc_hd__nand2_2
X_20556_ _11320_ _11277_ net664 VSS VSS VDD VDD _11321_ sky130_fd_sc_hd__a21oi_1
X_20557_ net624 _11109_ VSS VSS VDD VDD _11322_ sky130_fd_sc_hd__nand2_1
X_20558_ _11322_ _11300_ _11076_ VSS VSS VDD VDD _11323_ sky130_fd_sc_hd__a21oi_1
X_20559_ _12266_ _12270_ net422 VSS VSS VDD VDD _11324_ sky130_fd_sc_hd__mux2i_2
X_20560_ _12282_ _11140_ _11109_ VSS VSS VDD VDD _11325_ sky130_fd_sc_hd__nor3_1
X_20561_ _11109_ _11324_ _11325_ VSS VSS VDD VDD _11326_ sky130_fd_sc_hd__a21oi_2
X_20562_ _11268_ _11321_ _11323_ _11326_ _11122_ VSS VSS VDD
+ VDD _11327_ sky130_fd_sc_hd__o32ai_1
X_20563_ _11319_ _11327_ _11229_ VSS VSS VDD VDD _11328_ sky130_fd_sc_hd__o21ai_0
X_20564_ _11271_ _11295_ _11315_ _11328_ VSS VSS VDD VDD _00105_
+ sky130_fd_sc_hd__nand4_1
X_20565_ _11065_ net658 _11222_ VSS VSS VDD VDD _11329_ sky130_fd_sc_hd__o21ai_0
X_20566_ _12256_ _11103_ _11148_ VSS VSS VDD VDD _11330_ sky130_fd_sc_hd__o21ai_1
X_20567_ _11076_ _11330_ VSS VSS VDD VDD _11331_ sky130_fd_sc_hd__nand2_1
X_20568_ _11076_ _11329_ _11331_ VSS VSS VDD VDD _11332_ sky130_fd_sc_hd__o21ai_0
X_20569_ _11065_ _11109_ VSS VSS VDD VDD _11333_ sky130_fd_sc_hd__nor2_4
X_20570_ _11065_ net420 _11316_ VSS VSS VDD VDD _11334_ sky130_fd_sc_hd__o21ai_0
X_20571_ _11170_ _11258_ _11333_ _11199_ _11334_ _12257_ VSS
+ VSS VDD VDD _11335_ sky130_fd_sc_hd__a222oi_1
X_20572_ _11279_ _11332_ _11335_ _11268_ VSS VSS VDD VDD _11336_
+ sky130_fd_sc_hd__o22ai_1
X_20573_ net631 _11140_ VSS VSS VDD VDD _11337_ sky130_fd_sc_hd__nor2_1
X_20574_ _12257_ _11140_ _11337_ VSS VSS VDD VDD _11338_ sky130_fd_sc_hd__a21oi_1
X_20575_ _11065_ net622 _11140_ VSS VSS VDD VDD _11339_ sky130_fd_sc_hd__nor3_1
X_20576_ _11165_ net420 _11140_ _11339_ VSS VSS VDD VDD _11340_
+ sky130_fd_sc_hd__a31oi_1
X_20577_ net420 _11338_ _11340_ VSS VSS VDD VDD _11341_ sky130_fd_sc_hd__o21ai_0
X_20578_ _12279_ _11194_ VSS VSS VDD VDD _11342_ sky130_fd_sc_hd__nor2_1
X_20579_ _12282_ _11194_ net658 _11342_ VSS VSS VDD VDD _11343_
+ sky130_fd_sc_hd__a211oi_1
X_20580_ net658 _11341_ _11343_ _11122_ VSS VSS VDD VDD _11344_
+ sky130_fd_sc_hd__a211oi_1
X_20581_ _11248_ _11336_ _11344_ VSS VSS VDD VDD _11345_ sky130_fd_sc_hd__nor3_1
X_20582_ _12263_ _11188_ _11330_ net420 _11219_ VSS VSS VDD
+ VDD _11346_ sky130_fd_sc_hd__a221oi_1
X_20583_ _12277_ net658 VSS VSS VDD VDD _11347_ sky130_fd_sc_hd__nand2_1
X_20584_ _12261_ _11176_ VSS VSS VDD VDD _11348_ sky130_fd_sc_hd__nand2_1
X_20585_ _11194_ _11125_ VSS VSS VDD VDD _11349_ sky130_fd_sc_hd__nand2_4
X_20586_ _11347_ _11348_ _11349_ VSS VSS VDD VDD _11350_ sky130_fd_sc_hd__a21oi_1
X_20587_ _12258_ _12263_ VSS VSS VDD VDD _11351_ sky130_fd_sc_hd__nor2_2
X_20588_ _12270_ _11274_ _11351_ _11156_ _11183_ VSS VSS VDD
+ VDD _11352_ sky130_fd_sc_hd__o221ai_2
X_20589_ _11065_ net420 VSS VSS VDD VDD _11353_ sky130_fd_sc_hd__nand2_1
X_20590_ _12261_ _11076_ _11109_ VSS VSS VDD VDD _11354_ sky130_fd_sc_hd__a21oi_1
X_20591_ _12288_ _11109_ _11353_ _11354_ VSS VSS VDD VDD _11355_
+ sky130_fd_sc_hd__a22oi_1
X_20592_ _11140_ _11355_ _11122_ VSS VSS VDD VDD _11356_ sky130_fd_sc_hd__o21ai_0
X_20593_ _11140_ _11352_ _11356_ VSS VSS VDD VDD _11357_ sky130_fd_sc_hd__a21oi_1
X_20594_ _12272_ _11103_ VSS VSS VDD VDD _11358_ sky130_fd_sc_hd__nor2_2
X_20595_ net420 _11234_ _11358_ VSS VSS VDD VDD _11359_ sky130_fd_sc_hd__or3_1
X_20596_ _12268_ net658 _11115_ net420 VSS VSS VDD VDD _11360_
+ sky130_fd_sc_hd__o211ai_1
X_20597_ _11359_ _11360_ _11279_ VSS VSS VDD VDD _11361_ sky130_fd_sc_hd__a21oi_1
X_20598_ net421 _11291_ _11358_ VSS VSS VDD VDD _11362_ sky130_fd_sc_hd__or3_1
X_20599_ _12268_ _11109_ VSS VSS VDD VDD _11363_ sky130_fd_sc_hd__nor2_2
X_20600_ _11076_ _11159_ _11363_ VSS VSS VDD VDD _11364_ sky130_fd_sc_hd__or3_1
X_20601_ _11362_ _11364_ _11268_ VSS VSS VDD VDD _11365_ sky130_fd_sc_hd__a21oi_1
X_20602_ net421 _11148_ _11149_ VSS VSS VDD VDD _11366_ sky130_fd_sc_hd__and3_1
X_20603_ _11265_ net420 _11239_ VSS VSS VDD VDD _11367_ sky130_fd_sc_hd__nor3b_1
X_20604_ _11065_ _11103_ VSS VSS VDD VDD _11368_ sky130_fd_sc_hd__nand2_2
X_20605_ net420 _11239_ _11368_ _11257_ _11349_ VSS VSS VDD
+ VDD _11369_ sky130_fd_sc_hd__a311o_1
X_20606_ _11219_ _11366_ _11367_ _11369_ VSS VSS VDD VDD _11370_
+ sky130_fd_sc_hd__o31ai_1
X_20607_ _11361_ _11365_ _11370_ _11093_ VSS VSS VDD VDD _11371_
+ sky130_fd_sc_hd__o31ai_1
X_20608_ _11164_ _11346_ _11350_ _11357_ _11371_ VSS VSS VDD
+ VDD _11372_ sky130_fd_sc_hd__o41ai_1
X_20609_ net658 _11166_ _11122_ VSS VSS VDD VDD _11373_ sky130_fd_sc_hd__a21oi_2
X_20610_ _11109_ _11261_ _11353_ VSS VSS VDD VDD _11374_ sky130_fd_sc_hd__nand3_1
X_20611_ _11250_ _11303_ _11076_ VSS VSS VDD VDD _11375_ sky130_fd_sc_hd__o21ai_0
X_20612_ _11076_ _11266_ _11291_ _11375_ _11194_ VSS VSS VDD
+ VDD _11376_ sky130_fd_sc_hd__o311ai_1
X_20613_ _12272_ _11156_ VSS VSS VDD VDD _11377_ sky130_fd_sc_hd__nor2_1
X_20614_ _11114_ _11300_ net421 VSS VSS VDD VDD _11378_ sky130_fd_sc_hd__a21oi_1
X_20615_ _11194_ _11377_ _11378_ net665 VSS VSS VDD VDD _11379_
+ sky130_fd_sc_hd__o31ai_1
X_20616_ _11194_ _11373_ _11374_ _11376_ _11379_ VSS VSS VDD
+ VDD _11380_ sky130_fd_sc_hd__a32oi_1
X_20617_ net421 _11221_ _11115_ VSS VSS VDD VDD _11381_ sky130_fd_sc_hd__nand3_1
X_20618_ net421 _11184_ _11251_ _11381_ _11140_ VSS VSS VDD
+ VDD _11382_ sky130_fd_sc_hd__o311ai_0
X_20619_ _11122_ _11377_ _11378_ VSS VSS VDD VDD _11383_ sky130_fd_sc_hd__nor3_1
X_20620_ _11382_ _11383_ _11229_ VSS VSS VDD VDD _11384_ sky130_fd_sc_hd__o21ai_0
X_20621_ _11380_ _11384_ VSS VSS VDD VDD _11385_ sky130_fd_sc_hd__nor2_1
X_20622_ _11345_ _11372_ _11385_ VSS VSS VDD VDD _00106_ sky130_fd_sc_hd__or3_1
X_20623_ _11071_ _11109_ VSS VSS VDD VDD _11386_ sky130_fd_sc_hd__nor2_1
X_20624_ _11065_ _11386_ VSS VSS VDD VDD _11387_ sky130_fd_sc_hd__nand2_2
X_20625_ _11109_ _11215_ VSS VSS VDD VDD _11388_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20627_ _11231_ _11182_ _11076_ VSS VSS VDD VDD _11390_ sky130_fd_sc_hd__o21ai_0
X_20628_ _11289_ _11387_ _11388_ _11390_ VSS VSS VDD VDD _11391_
+ sky130_fd_sc_hd__nand4_1
X_20629_ _11221_ _11320_ _11075_ VSS VSS VDD VDD _11392_ sky130_fd_sc_hd__a21oi_1
X_20630_ _11222_ _11225_ _11076_ VSS VSS VDD VDD _11393_ sky130_fd_sc_hd__a21oi_1
X_20631_ _11220_ _11103_ VSS VSS VDD VDD _11394_ sky130_fd_sc_hd__nor2_2
X_20632_ _12268_ net658 _11147_ _11076_ VSS VSS VDD VDD _11395_
+ sky130_fd_sc_hd__o211ai_1
X_20633_ _11076_ _11394_ _11333_ _11395_ _11194_ VSS VSS VDD
+ VDD _11396_ sky130_fd_sc_hd__o311a_1
X_20634_ _11194_ _11392_ _11393_ _11396_ net665 VSS VSS VDD
+ VDD _11397_ sky130_fd_sc_hd__o32ai_1
X_20635_ net511 _11071_ _11199_ VSS VSS VDD VDD _11398_ sky130_fd_sc_hd__o21ai_0
X_20636_ _12261_ _11188_ _11398_ _11109_ _11349_ VSS VSS VDD
+ VDD _11399_ sky130_fd_sc_hd__a221oi_1
X_20637_ _11391_ _11397_ _11399_ _11087_ VSS VSS VDD VDD _11400_
+ sky130_fd_sc_hd__a211oi_1
X_20638_ net664 _11105_ _11234_ VSS VSS VDD VDD _11401_ sky130_fd_sc_hd__or3_1
X_20639_ _11076_ _11394_ _11112_ _11401_ VSS VSS VDD VDD _11402_
+ sky130_fd_sc_hd__o31ai_1
X_20640_ _12256_ _11109_ VSS VSS VDD VDD _11403_ sky130_fd_sc_hd__nor2_1
X_20641_ _11076_ _11182_ _11403_ VSS VSS VDD VDD _11404_ sky130_fd_sc_hd__nor3_1
X_20642_ net421 _11265_ _11253_ VSS VSS VDD VDD _11405_ sky130_fd_sc_hd__nor3_1
X_20643_ _11404_ _11405_ _11087_ _11289_ VSS VSS VDD VDD _11406_
+ sky130_fd_sc_hd__o211ai_1
X_20644_ _11228_ _11219_ _11402_ _11406_ _11092_ VSS VSS VDD
+ VDD _11407_ sky130_fd_sc_hd__o311ai_1
X_20645_ net621 _11125_ _11075_ net511 VSS VSS VDD VDD _11408_
+ sky130_fd_sc_hd__a211oi_1
X_20646_ net511 net665 _11199_ _11408_ VSS VSS VDD VDD _11409_
+ sky130_fd_sc_hd__a31oi_1
X_20647_ _11065_ _11076_ _11125_ VSS VSS VDD VDD _11410_ sky130_fd_sc_hd__nand3_1
X_20648_ _11076_ _11125_ _11410_ VSS VSS VDD VDD _11411_ sky130_fd_sc_hd__o21ai_0
X_20649_ _11076_ _11125_ _11220_ VSS VSS VDD VDD _11412_ sky130_fd_sc_hd__a21oi_1
X_20650_ _11411_ _11412_ net658 VSS VSS VDD VDD _11413_ sky130_fd_sc_hd__o21ai_0
X_20651_ net658 _11409_ _11413_ VSS VSS VDD VDD _11414_ sky130_fd_sc_hd__o21ai_0
X_20652_ net665 _11199_ VSS VSS VDD VDD _11415_ sky130_fd_sc_hd__nor2_1
X_20653_ _11140_ _11164_ _11414_ _11415_ VSS VSS VDD VDD _11416_
+ sky130_fd_sc_hd__nor4_1
X_20654_ net501 _11194_ _11109_ VSS VSS VDD VDD _11417_ sky130_fd_sc_hd__nor3_1
X_20655_ _12257_ _11103_ VSS VSS VDD VDD _11418_ sky130_fd_sc_hd__nor2_1
X_20656_ _11418_ _11363_ VSS VSS VDD VDD _11419_ sky130_fd_sc_hd__nor2_2
X_20657_ _11194_ _11159_ _11076_ VSS VSS VDD VDD _11420_ sky130_fd_sc_hd__a21oi_1
X_20658_ _11194_ _11419_ _11420_ VSS VSS VDD VDD _11421_ sky130_fd_sc_hd__o21ai_1
X_20659_ net421 _11358_ _11417_ _11421_ _11122_ VSS VSS VDD
+ VDD _11422_ sky130_fd_sc_hd__o311ai_4
X_20660_ _11076_ _11105_ _11071_ VSS VSS VDD VDD _11423_ sky130_fd_sc_hd__o21ai_0
X_20661_ _11065_ _11176_ _11219_ VSS VSS VDD VDD _11424_ sky130_fd_sc_hd__a21oi_1
X_20662_ _11169_ _11423_ _11424_ VSS VSS VDD VDD _11425_ sky130_fd_sc_hd__nand3b_1
X_20663_ _12268_ _11103_ VSS VSS VDD VDD _11426_ sky130_fd_sc_hd__nand2_2
X_20664_ net422 _11182_ _11426_ VSS VSS VDD VDD _11427_ sky130_fd_sc_hd__nor3b_1
X_20665_ _11103_ _11351_ VSS VSS VDD VDD _11428_ sky130_fd_sc_hd__nand2_1
X_20666_ _11225_ _11428_ _11076_ VSS VSS VDD VDD _11429_ sky130_fd_sc_hd__a21oi_1
X_20667_ _11427_ _11429_ _11214_ VSS VSS VDD VDD _11430_ sky130_fd_sc_hd__o21ai_1
X_20668_ _11071_ _11273_ _11274_ _12268_ VSS VSS VDD VDD _11431_
+ sky130_fd_sc_hd__a22oi_1
X_20669_ _12257_ _11076_ _11194_ _11184_ VSS VSS VDD VDD _11432_
+ sky130_fd_sc_hd__nor4_2
X_20670_ _11076_ _11194_ _11148_ VSS VSS VDD VDD _11433_ sky130_fd_sc_hd__nand3_1
X_20671_ _12266_ _11109_ _11433_ VSS VSS VDD VDD _11434_ sky130_fd_sc_hd__a21oi_1
X_20672_ _12258_ _11103_ VSS VSS VDD VDD _11435_ sky130_fd_sc_hd__nand2_1
X_20673_ net627 _11194_ _11109_ VSS VSS VDD VDD _11436_ sky130_fd_sc_hd__nand3_1
X_20674_ _11435_ _11436_ _11076_ VSS VSS VDD VDD _11437_ sky130_fd_sc_hd__a21oi_1
X_20675_ _11125_ _11432_ _11434_ _11437_ VSS VSS VDD VDD _11438_
+ sky130_fd_sc_hd__nor4_1
X_20676_ net421 _11159_ _11112_ VSS VSS VDD VDD _11439_ sky130_fd_sc_hd__nor3_1
X_20677_ net421 _11221_ _11428_ _11439_ _11349_ VSS VSS VDD
+ VDD _11440_ sky130_fd_sc_hd__a311oi_1
X_20678_ _11285_ _11431_ _11440_ _11438_ _11228_ VSS VSS VDD
+ VDD _11441_ sky130_fd_sc_hd__a2111oi_2
X_20679_ _11228_ _11422_ _11425_ _11430_ _11441_ VSS VSS VDD
+ VDD _11442_ sky130_fd_sc_hd__a41oi_4
X_20680_ _11400_ _11407_ _11416_ _11442_ _11092_ VSS VSS VDD
+ VDD _00107_ sky130_fd_sc_hd__o32ai_1
X_20681_ net422 _11125_ VSS VSS VDD VDD _11443_ sky130_fd_sc_hd__nor2_2
X_20682_ _12257_ net422 VSS VSS VDD VDD _11444_ sky130_fd_sc_hd__nor2_1
X_20683_ _12263_ net422 VSS VSS VDD VDD _11445_ sky130_fd_sc_hd__and2_0
X_20684_ _11444_ _11445_ _11109_ VSS VSS VDD VDD _11446_ sky130_fd_sc_hd__o21ai_1
X_20685_ _11301_ _11443_ _11446_ _11131_ _11194_ VSS VSS VDD
+ VDD _11447_ sky130_fd_sc_hd__a221oi_4
X_20686_ _11076_ _11316_ _11317_ VSS VSS VDD VDD _11448_ sky130_fd_sc_hd__nand3_1
X_20687_ _12263_ _11109_ _11277_ net664 VSS VSS VDD VDD _11449_
+ sky130_fd_sc_hd__o211ai_1
X_20688_ _11071_ _11212_ _11358_ net421 VSS VSS VDD VDD _11450_
+ sky130_fd_sc_hd__o22ai_1
X_20689_ _11122_ _11450_ _11194_ VSS VSS VDD VDD _11451_ sky130_fd_sc_hd__o21ai_0
X_20690_ _11122_ _11448_ _11449_ _11451_ VSS VSS VDD VDD _11452_
+ sky130_fd_sc_hd__a31oi_1
X_20691_ _11076_ _11426_ _11190_ VSS VSS VDD VDD _11453_ sky130_fd_sc_hd__a21oi_1
X_20692_ _11076_ _11277_ _11368_ VSS VSS VDD VDD _11454_ sky130_fd_sc_hd__and3_1
X_20693_ net665 _11199_ VSS VSS VDD VDD _11455_ sky130_fd_sc_hd__nand2_1
X_20694_ net665 _11453_ _11454_ _11455_ _11140_ VSS VSS VDD
+ VDD _11456_ sky130_fd_sc_hd__o221ai_1
X_20695_ net501 _11212_ _11115_ _11065_ VSS VSS VDD VDD _11457_
+ sky130_fd_sc_hd__o22ai_1
X_20696_ _11065_ _11274_ _11457_ _11349_ VSS VSS VDD VDD _11458_
+ sky130_fd_sc_hd__a211o_1
X_20697_ net511 _11149_ _11299_ VSS VSS VDD VDD _11459_ sky130_fd_sc_hd__o21ai_1
X_20698_ _11065_ _11076_ VSS VSS VDD VDD _11460_ sky130_fd_sc_hd__nor2_1
X_20699_ _12256_ _11188_ _11459_ _11460_ VSS VSS VDD VDD _11461_
+ sky130_fd_sc_hd__a211o_1
X_20700_ _11092_ _11456_ _11458_ _11461_ VSS VSS VDD VDD _11462_
+ sky130_fd_sc_hd__nand4_1
X_20701_ _11092_ _11447_ _11452_ _11462_ _11228_ VSS VSS VDD
+ VDD _11463_ sky130_fd_sc_hd__o311ai_0
X_20702_ _12256_ net421 VSS VSS VDD VDD _11464_ sky130_fd_sc_hd__nand2b_1
X_20703_ _11135_ _11464_ _11109_ VSS VSS VDD VDD _11465_ sky130_fd_sc_hd__a21oi_1
X_20704_ _11076_ _11250_ _11286_ VSS VSS VDD VDD _11466_ sky130_fd_sc_hd__nor3_1
X_20705_ net421 _11291_ _11303_ VSS VSS VDD VDD _11467_ sky130_fd_sc_hd__nor3_1
X_20706_ _11466_ _11467_ _11122_ VSS VSS VDD VDD _11468_ sky130_fd_sc_hd__o21ai_0
X_20707_ _11167_ _11465_ _11468_ VSS VSS VDD VDD _11469_ sky130_fd_sc_hd__o21ai_0
X_20708_ _11418_ _11363_ _11125_ VSS VSS VDD VDD _11470_ sky130_fd_sc_hd__o21ai_0
X_20709_ _11265_ _11266_ _11122_ VSS VSS VDD VDD _11471_ sky130_fd_sc_hd__o21ai_0
X_20710_ _12268_ _11122_ VSS VSS VDD VDD _11472_ sky130_fd_sc_hd__nand2_1
X_20711_ _11250_ _11303_ _11125_ VSS VSS VDD VDD _11473_ sky130_fd_sc_hd__o21ai_0
X_20712_ _11472_ _11473_ _11076_ VSS VSS VDD VDD _11474_ sky130_fd_sc_hd__a21oi_1
X_20713_ _11076_ _11470_ _11471_ _11474_ _11194_ VSS VSS VDD
+ VDD _11475_ sky130_fd_sc_hd__a311oi_1
X_20714_ _11194_ _11469_ _11475_ _11164_ VSS VSS VDD VDD _11476_
+ sky130_fd_sc_hd__a211o_1
X_20715_ _12258_ _11212_ _11387_ VSS VSS VDD VDD _11477_ sky130_fd_sc_hd__o21ai_0
X_20716_ _11170_ _11277_ net421 VSS VSS VDD VDD _11478_ sky130_fd_sc_hd__a21oi_1
X_20717_ _11109_ _11261_ _11225_ _11140_ VSS VSS VDD VDD _11479_
+ sky130_fd_sc_hd__o211ai_1
X_20718_ _11140_ _11477_ _11478_ _11479_ net665 VSS VSS VDD
+ VDD _11480_ sky130_fd_sc_hd__o311ai_1
X_20719_ _12268_ _11076_ VSS VSS VDD VDD _11481_ sky130_fd_sc_hd__nand2_1
X_20720_ _11165_ _11109_ VSS VSS VDD VDD _11482_ sky130_fd_sc_hd__nand2_2
X_20721_ _11482_ _11368_ _11076_ VSS VSS VDD VDD _11483_ sky130_fd_sc_hd__a21oi_1
X_20722_ _11105_ _11386_ net421 VSS VSS VDD VDD _11484_ sky130_fd_sc_hd__o21a_1
X_20723_ _11268_ _11483_ _11484_ _11459_ VSS VSS VDD VDD _11485_
+ sky130_fd_sc_hd__o22ai_1
X_20724_ _11109_ _11481_ _11485_ VSS VSS VDD VDD _11486_ sky130_fd_sc_hd__o21ai_0
X_20725_ _11229_ _11480_ _11486_ VSS VSS VDD VDD _11487_ sky130_fd_sc_hd__nand3_1
X_20726_ _11463_ _11476_ _11487_ VSS VSS VDD VDD _00108_ sky130_fd_sc_hd__nand3_1
X_20727_ _11140_ _11348_ VSS VSS VDD VDD _11488_ sky130_fd_sc_hd__nand2_1
X_20728_ _11429_ _11488_ net665 VSS VSS VDD VDD _11489_ sky130_fd_sc_hd__o21ai_0
X_20729_ _11358_ _11076_ _11222_ VSS VSS VDD VDD _11490_ sky130_fd_sc_hd__nand3b_1
X_20730_ _11076_ _11394_ _11265_ _11490_ VSS VSS VDD VDD _11491_
+ sky130_fd_sc_hd__o31ai_1
X_20731_ _12263_ _11176_ VSS VSS VDD VDD _11492_ sky130_fd_sc_hd__nand2_1
X_20732_ _12272_ net420 _11103_ VSS VSS VDD VDD _11493_ sky130_fd_sc_hd__o21ai_0
X_20733_ _11122_ _11492_ _11493_ _11194_ VSS VSS VDD VDD _11494_
+ sky130_fd_sc_hd__a31oi_1
X_20734_ _11194_ _11491_ _11494_ VSS VSS VDD VDD _11495_ sky130_fd_sc_hd__a21o_1
X_20735_ _11076_ _11225_ _11222_ _11214_ VSS VSS VDD VDD _11496_
+ sky130_fd_sc_hd__o211ai_1
X_20736_ _11229_ _11496_ VSS VSS VDD VDD _11497_ sky130_fd_sc_hd__nand2_1
X_20737_ _11489_ _11495_ _11497_ VSS VSS VDD VDD _11498_ sky130_fd_sc_hd__a21oi_1
X_20738_ _12270_ _11156_ _11274_ net501 _11492_ VSS VSS VDD
+ VDD _11499_ sky130_fd_sc_hd__o221ai_1
X_20739_ _12270_ _11212_ _11490_ VSS VSS VDD VDD _11500_ sky130_fd_sc_hd__o21ai_0
X_20740_ _12261_ _11109_ _11239_ VSS VSS VDD VDD _11501_ sky130_fd_sc_hd__o21ai_0
X_20741_ _11148_ _11316_ _11076_ VSS VSS VDD VDD _11502_ sky130_fd_sc_hd__a21oi_1
X_20742_ _11076_ _11501_ _11502_ VSS VSS VDD VDD _11503_ sky130_fd_sc_hd__a21oi_1
X_20743_ _11299_ _11500_ _11503_ _11268_ VSS VSS VDD VDD _11504_
+ sky130_fd_sc_hd__o2bb2ai_1
X_20744_ _11071_ _11212_ _11159_ _11065_ VSS VSS VDD VDD _11505_
+ sky130_fd_sc_hd__a22oi_1
X_20745_ _11219_ _11505_ _11093_ VSS VSS VDD VDD _11506_ sky130_fd_sc_hd__o21ai_0
X_20746_ _11214_ _11499_ _11504_ _11506_ VSS VSS VDD VDD _11507_
+ sky130_fd_sc_hd__a211oi_2
X_20747_ _11403_ _11303_ _11076_ VSS VSS VDD VDD _11508_ sky130_fd_sc_hd__o21ai_1
X_20748_ _11172_ _11148_ net420 VSS VSS VDD VDD _11509_ sky130_fd_sc_hd__a21oi_1
X_20749_ net511 _11273_ _11279_ _11509_ VSS VSS VDD VDD _11510_
+ sky130_fd_sc_hd__a211oi_2
X_20750_ _11214_ _11216_ _11508_ _11510_ VSS VSS VDD VDD _11511_
+ sky130_fd_sc_hd__a31oi_1
X_20751_ net501 net665 net658 VSS VSS VDD VDD _11512_ sky130_fd_sc_hd__nor3_1
X_20752_ _11241_ _11512_ _11065_ VSS VSS VDD VDD _11513_ sky130_fd_sc_hd__o21ai_0
X_20753_ net511 _11122_ VSS VSS VDD VDD _11514_ sky130_fd_sc_hd__nor2_1
X_20754_ _11176_ _11514_ net501 VSS VSS VDD VDD _11515_ sky130_fd_sc_hd__o21ai_0
X_20755_ _11122_ _11103_ VSS VSS VDD VDD _11516_ sky130_fd_sc_hd__nor2_1
X_20756_ _11125_ _11109_ VSS VSS VDD VDD _11517_ sky130_fd_sc_hd__nor2_1
X_20757_ net511 _11076_ _11516_ _11517_ _11324_ VSS VSS VDD
+ VDD _11518_ sky130_fd_sc_hd__a32oi_1
X_20758_ _11140_ _11513_ _11515_ _11518_ VSS VSS VDD VDD _11519_
+ sky130_fd_sc_hd__nand4_1
X_20759_ _11511_ _11519_ _11164_ VSS VSS VDD VDD _11520_ sky130_fd_sc_hd__a21oi_1
X_20760_ _11140_ _11280_ VSS VSS VDD VDD _11521_ sky130_fd_sc_hd__nand2_1
X_20761_ _12268_ _11176_ _11521_ VSS VSS VDD VDD _11522_ sky130_fd_sc_hd__a21oi_1
X_20762_ _11076_ _11286_ _11320_ VSS VSS VDD VDD _11523_ sky130_fd_sc_hd__o21ai_0
X_20763_ _11186_ _11522_ _11523_ _11194_ net665 VSS VSS VDD
+ VDD _11524_ sky130_fd_sc_hd__a221oi_1
X_20764_ _11112_ _11251_ _11076_ VSS VSS VDD VDD _11525_ sky130_fd_sc_hd__o21ai_0
X_20765_ _11235_ _11285_ _11525_ VSS VSS VDD VDD _11526_ sky130_fd_sc_hd__and3_1
X_20766_ net501 _11211_ _11419_ _11076_ _11214_ VSS VSS VDD
+ VDD _11527_ sky130_fd_sc_hd__o221a_1
X_20767_ _11248_ _11524_ _11526_ _11527_ VSS VSS VDD VDD _11528_
+ sky130_fd_sc_hd__nor4_1
X_20768_ _11498_ _11507_ _11520_ _11528_ VSS VSS VDD VDD _00109_
+ sky130_fd_sc_hd__nor4_1
X_20769_ net628 net625 net658 VSS VSS VDD VDD _11529_ sky130_fd_sc_hd__o21ai_0
X_20770_ _12275_ _12284_ net658 _11460_ _11529_ VSS VSS VDD
+ VDD _11530_ sky130_fd_sc_hd__o32ai_1
X_20771_ net421 _11322_ _11426_ VSS VSS VDD VDD _11531_ sky130_fd_sc_hd__nand3_1
X_20772_ _11109_ _11351_ _11221_ _11076_ VSS VSS VDD VDD _11532_
+ sky130_fd_sc_hd__o211ai_1
X_20773_ _11531_ _11532_ _11279_ VSS VSS VDD VDD _11533_ sky130_fd_sc_hd__a21oi_1
X_20774_ _11285_ _11530_ _11533_ VSS VSS VDD VDD _11534_ sky130_fd_sc_hd__a21oi_1
X_20775_ _11076_ _11268_ _12258_ VSS VSS VDD VDD _11535_ sky130_fd_sc_hd__a21oi_1
X_20776_ net658 _11481_ _11214_ _11076_ VSS VSS VDD VDD _11536_
+ sky130_fd_sc_hd__o211ai_1
X_20777_ _12258_ _11536_ _12270_ VSS VSS VDD VDD _11537_ sky130_fd_sc_hd__a21boi_0
X_20778_ _12256_ _11109_ _11363_ _11076_ VSS VSS VDD VDD _11538_
+ sky130_fd_sc_hd__a211oi_2
X_20779_ _11076_ _11268_ _11538_ VSS VSS VDD VDD _11539_ sky130_fd_sc_hd__nor3_1
X_20780_ _11481_ _11262_ _11103_ VSS VSS VDD VDD _11540_ sky130_fd_sc_hd__a21oi_1
X_20781_ _11268_ _11538_ _11540_ _11349_ VSS VSS VDD VDD _11541_
+ sky130_fd_sc_hd__o22ai_1
X_20782_ _11109_ _11539_ _11537_ _11535_ _11541_ VSS VSS VDD
+ VDD _11542_ sky130_fd_sc_hd__o41ai_2
X_20783_ _11534_ _11542_ _11248_ VSS VSS VDD VDD _11543_ sky130_fd_sc_hd__a21oi_2
X_20784_ _12272_ _11212_ _11115_ _11065_ VSS VSS VDD VDD _11544_
+ sky130_fd_sc_hd__o22ai_1
X_20785_ _12261_ net421 _11109_ _11199_ VSS VSS VDD VDD _11545_
+ sky130_fd_sc_hd__o211ai_1
X_20786_ _12286_ net658 _11140_ VSS VSS VDD VDD _11546_ sky130_fd_sc_hd__a21oi_1
X_20787_ _11545_ _11546_ VSS VSS VDD VDD _11547_ sky130_fd_sc_hd__nand2_1
X_20788_ _11194_ _11128_ _11544_ _11547_ VSS VSS VDD VDD _11548_
+ sky130_fd_sc_hd__o31ai_2
X_20789_ _11076_ _11115_ net511 VSS VSS VDD VDD _11549_ sky130_fd_sc_hd__a21oi_1
X_20790_ net622 _11156_ _11348_ VSS VSS VDD VDD _11550_ sky130_fd_sc_hd__o21ai_0
X_20791_ _11076_ _11115_ VSS VSS VDD VDD _11551_ sky130_fd_sc_hd__nand2_1
X_20792_ _11076_ _11419_ _11551_ _11214_ VSS VSS VDD VDD _11552_
+ sky130_fd_sc_hd__o211ai_1
X_20793_ _11219_ _11549_ _11550_ _11093_ _11552_ VSS VSS VDD
+ VDD _11553_ sky130_fd_sc_hd__o311ai_1
X_20794_ _11122_ _11548_ _11553_ VSS VSS VDD VDD _11554_ sky130_fd_sc_hd__a21oi_1
X_20795_ _11182_ _11333_ _11076_ VSS VSS VDD VDD _11555_ sky130_fd_sc_hd__o21ai_0
X_20796_ _12261_ _11156_ _11299_ _11555_ VSS VSS VDD VDD _11556_
+ sky130_fd_sc_hd__o211ai_1
X_20797_ net664 _11221_ _11285_ _11368_ VSS VSS VDD VDD _11557_
+ sky130_fd_sc_hd__nand4_1
X_20798_ net664 _11219_ _11191_ _11556_ _11557_ VSS VSS VDD
+ VDD _11558_ sky130_fd_sc_hd__o311a_1
X_20799_ _11165_ net420 _11109_ VSS VSS VDD VDD _11559_ sky130_fd_sc_hd__o21ai_1
X_20800_ _12277_ _11109_ _11215_ _11559_ _11289_ VSS VSS VDD
+ VDD _11560_ sky130_fd_sc_hd__o221ai_1
X_20801_ net421 _11418_ _11386_ VSS VSS VDD VDD _11561_ sky130_fd_sc_hd__nor3_1
X_20802_ net658 _11351_ VSS VSS VDD VDD _11562_ sky130_fd_sc_hd__nor2_1
X_20803_ _11076_ _11250_ _11562_ VSS VSS VDD VDD _11563_ sky130_fd_sc_hd__nor3_1
X_20804_ _11561_ _11563_ _11214_ VSS VSS VDD VDD _11564_ sky130_fd_sc_hd__o21ai_1
X_20805_ _11558_ _11560_ _11564_ _11164_ VSS VSS VDD VDD _11565_
+ sky130_fd_sc_hd__a31oi_1
X_20806_ _11065_ _11156_ VSS VSS VDD VDD _11566_ sky130_fd_sc_hd__nor2_1
X_20807_ net665 _11427_ _11566_ VSS VSS VDD VDD _11567_ sky130_fd_sc_hd__nor3_1
X_20808_ _11140_ _11373_ _11567_ VSS VSS VDD VDD _11568_ sky130_fd_sc_hd__nor3_1
X_20809_ _11216_ _11289_ VSS VSS VDD VDD _11569_ sky130_fd_sc_hd__nand2_1
X_20810_ _12268_ _11076_ net658 VSS VSS VDD VDD _11570_ sky130_fd_sc_hd__a21oi_1
X_20811_ _12276_ net658 _11353_ _11570_ VSS VSS VDD VDD _11571_
+ sky130_fd_sc_hd__a22oi_1
X_20812_ _11439_ _11569_ _11571_ _11219_ VSS VSS VDD VDD _11572_
+ sky130_fd_sc_hd__o22ai_1
X_20813_ _11568_ _11572_ _11229_ VSS VSS VDD VDD _11573_ sky130_fd_sc_hd__o21ai_0
X_20814_ _11543_ _11554_ _11565_ _11573_ VSS VSS VDD VDD _00110_
+ sky130_fd_sc_hd__nor4b_1
X_20815_ net421 _11316_ _11428_ VSS VSS VDD VDD _11574_ sky130_fd_sc_hd__nand3_1
X_20816_ net421 _11296_ _11363_ _11574_ _11122_ VSS VSS VDD
+ VDD _11575_ sky130_fd_sc_hd__o311ai_2
X_20817_ _11076_ _11222_ _11225_ VSS VSS VDD VDD _11576_ sky130_fd_sc_hd__nand3_1
X_20818_ net665 _11278_ _11576_ VSS VSS VDD VDD _11577_ sky130_fd_sc_hd__nand3_1
X_20819_ _11575_ _11577_ _11194_ VSS VSS VDD VDD _11578_ sky130_fd_sc_hd__a21oi_1
X_20820_ _11460_ _11529_ VSS VSS VDD VDD _11579_ sky130_fd_sc_hd__nor2_1
X_20821_ net421 _11190_ _11291_ _11464_ VSS VSS VDD VDD _11580_
+ sky130_fd_sc_hd__o31ai_1
X_20822_ net665 _11580_ VSS VSS VDD VDD _11581_ sky130_fd_sc_hd__nand2_1
X_20823_ net665 _11266_ _11579_ _11581_ _11194_ VSS VSS VDD
+ VDD _11582_ sky130_fd_sc_hd__o311a_1
X_20824_ _11578_ _11582_ _11248_ VSS VSS VDD VDD _11583_ sky130_fd_sc_hd__o21bai_1
X_20825_ _11076_ _11265_ _11251_ VSS VSS VDD VDD _11584_ sky130_fd_sc_hd__nor3_1
X_20826_ _12268_ net664 net658 _11444_ VSS VSS VDD VDD _11585_
+ sky130_fd_sc_hd__a211o_1
X_20827_ _12284_ _11109_ _11214_ _11585_ VSS VSS VDD VDD _11586_
+ sky130_fd_sc_hd__o211ai_1
X_20828_ _12258_ _11176_ VSS VSS VDD VDD _11587_ sky130_fd_sc_hd__nand2_1
X_20829_ _12270_ _11109_ _11587_ VSS VSS VDD VDD _11588_ sky130_fd_sc_hd__o21ai_0
X_20830_ net664 _11280_ _11482_ _11318_ VSS VSS VDD VDD _11589_
+ sky130_fd_sc_hd__a31oi_1
X_20831_ _11285_ _11588_ _11589_ _11289_ _11164_ VSS VSS VDD
+ VDD _11590_ sky130_fd_sc_hd__a221oi_1
X_20832_ _11279_ _11307_ _11584_ _11586_ _11590_ VSS VSS VDD
+ VDD _11591_ sky130_fd_sc_hd__o311ai_0
X_20833_ _11075_ _11224_ _11114_ VSS VSS VDD VDD _11592_ sky130_fd_sc_hd__nand3_1
X_20834_ _11076_ _11322_ _11300_ VSS VSS VDD VDD _11593_ sky130_fd_sc_hd__nand3_1
X_20835_ _11199_ _11135_ _11109_ VSS VSS VDD VDD _11594_ sky130_fd_sc_hd__a21oi_1
X_20836_ _11349_ _11540_ _11594_ VSS VSS VDD VDD _11595_ sky130_fd_sc_hd__nor3_1
X_20837_ _11289_ _11592_ _11593_ _11595_ VSS VSS VDD VDD _11596_
+ sky130_fd_sc_hd__a31o_1
X_20838_ _11076_ _11291_ _11303_ _11211_ _12268_ VSS VSS VDD
+ VDD _11597_ sky130_fd_sc_hd__o32ai_1
X_20839_ _12272_ _11156_ _11274_ _12257_ _11298_ VSS VSS VDD
+ VDD _11598_ sky130_fd_sc_hd__o221ai_1
X_20840_ _11285_ _11597_ _11598_ _11299_ VSS VSS VDD VDD _11599_
+ sky130_fd_sc_hd__a22o_1
X_20841_ _11596_ _11599_ _11093_ VSS VSS VDD VDD _11600_ sky130_fd_sc_hd__o21ai_0
X_20842_ _11125_ net658 VSS VSS VDD VDD _11601_ sky130_fd_sc_hd__nor2_1
X_20843_ net511 _11241_ _11601_ VSS VSS VDD VDD _11602_ sky130_fd_sc_hd__a21oi_1
X_20844_ net422 _11516_ _11188_ VSS VSS VDD VDD _11603_ sky130_fd_sc_hd__a21oi_1
X_20845_ _12270_ net422 VSS VSS VDD VDD _11604_ sky130_fd_sc_hd__nor2_1
X_20846_ net501 net664 _11517_ _11604_ _11516_ VSS VSS VDD
+ VDD _11605_ sky130_fd_sc_hd__a32oi_1
X_20847_ net501 _11602_ _11603_ net511 _11605_ VSS VSS VDD
+ VDD _11606_ sky130_fd_sc_hd__o221ai_1
X_20848_ _11140_ _11606_ VSS VSS VDD VDD _11607_ sky130_fd_sc_hd__nand2_1
X_20849_ _12261_ _11517_ _11394_ _11076_ VSS VSS VDD VDD _11608_
+ sky130_fd_sc_hd__a211oi_1
X_20850_ _11176_ _11241_ _12270_ VSS VSS VDD VDD _11609_ sky130_fd_sc_hd__o21ai_0
X_20851_ _11443_ _11608_ _11609_ _11194_ VSS VSS VDD VDD _11610_
+ sky130_fd_sc_hd__o211ai_1
X_20852_ _11229_ _11607_ _11610_ VSS VSS VDD VDD _11611_ sky130_fd_sc_hd__nand3_1
X_20853_ _11583_ _11591_ _11600_ _11611_ VSS VSS VDD VDD _00111_
+ sky130_fd_sc_hd__and4_1
X_20854_ sa02_sr\[1\] sa31_sub\[7\] VSS VSS VDD VDD _11612_
+ sky130_fd_sc_hd__xnor2_1
X_20855_ sa12_sr\[1\] sa31_sub\[0\] VSS VSS VDD VDD _11613_
+ sky130_fd_sc_hd__xnor2_1
X_20856_ sa31_sub\[1\] sa20_sub\[0\] sa20_sub\[7\] VSS VSS
+ VDD VDD _11614_ sky130_fd_sc_hd__xnor3_1
X_20857_ _11612_ _11613_ _11614_ VSS VSS VDD VDD _11615_ sky130_fd_sc_hd__xnor3_1
X_20858_ text_in_r\[41\] _11615_ _05879_ VSS VSS VDD VDD _11616_
+ sky130_fd_sc_hd__mux2i_4
X_20859_ _11616_ u0.w\[2\]\[9\] VSS VSS VDD VDD _11617_ sky130_fd_sc_hd__xor2_4
X_20860_ net419 VSS VSS VDD VDD _11618_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_15_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20862_ sa12_sr\[0\] sa20_sub\[7\] sa31_sub\[7\] VSS VSS
+ VDD VDD _11619_ sky130_fd_sc_hd__xnor3_1
X_20863_ _09366_ _11619_ VSS VSS VDD VDD _11620_ sky130_fd_sc_hd__xnor2_1
X_20864_ text_in_r\[40\] _11620_ _05879_ VSS VSS VDD VDD _11621_
+ sky130_fd_sc_hd__mux2i_4
X_20865_ u0.w\[2\]\[8\] _11621_ VSS VSS VDD VDD _11622_ sky130_fd_sc_hd__xor2_4
X_20866_ net418 VSS VSS VDD VDD _11623_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_15_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20868_ sa12_sr\[2\] sa31_sub\[2\] sa02_sr\[2\] VSS VSS VDD
+ VDD _11624_ sky130_fd_sc_hd__xnor3_1
X_20869_ _07075_ _11624_ VSS VSS VDD VDD _11625_ sky130_fd_sc_hd__xnor2_1
X_20870_ text_in_r\[42\] _11625_ _05879_ VSS VSS VDD VDD _11626_
+ sky130_fd_sc_hd__mux2i_4
X_20871_ u0.w\[2\]\[10\] _11626_ VSS VSS VDD VDD _11627_ sky130_fd_sc_hd__xnor2_4
X_20872_ net417 VSS VSS VDD VDD _11628_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_14_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20882_ sa31_sub\[4\] sa12_sr\[5\] sa02_sr\[5\] VSS VSS VDD
+ VDD _11635_ sky130_fd_sc_hd__xnor3_4
X_20883_ sa20_sub\[4\] sa31_sub\[5\] VSS VSS VDD VDD _11636_
+ sky130_fd_sc_hd__xor2_2
X_20884_ _11635_ _11636_ VSS VSS VDD VDD _11637_ sky130_fd_sc_hd__xnor2_4
X_20885_ text_in_r\[45\] _11637_ net660 VSS VSS VDD VDD _11638_
+ sky130_fd_sc_hd__mux2i_4
X_20886_ _11638_ u0.w\[2\]\[13\] VSS VSS VDD VDD _11639_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_14_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20891_ net493 u0.w\[2\]\[11\] VSS VSS VDD VDD _11644_ sky130_fd_sc_hd__nor2b_1
X_20892_ u0.w\[2\]\[11\] net493 VSS VSS VDD VDD _11645_ sky130_fd_sc_hd__nor2_1
X_20893_ sa02_sr\[3\] sa31_sub\[7\] VSS VSS VDD VDD _11646_
+ sky130_fd_sc_hd__xor2_1
X_20894_ sa31_sub\[2\] sa12_sr\[3\] VSS VSS VDD VDD _11647_
+ sky130_fd_sc_hd__xnor2_1
X_20895_ sa20_sub\[2\] sa31_sub\[3\] sa20_sub\[7\] VSS VSS
+ VDD VDD _11648_ sky130_fd_sc_hd__xor3_1
X_20896_ _11646_ _11647_ _11648_ VSS VSS VDD VDD _11649_ sky130_fd_sc_hd__xnor3_4
X_20897_ _11644_ _11645_ _11649_ VSS VSS VDD VDD _11650_ sky130_fd_sc_hd__mux2i_4
X_20898_ u0.w\[2\]\[11\] net660 VSS VSS VDD VDD _11651_ sky130_fd_sc_hd__nor2_1
X_20899_ u0.w\[2\]\[11\] net493 VSS VSS VDD VDD _11652_ sky130_fd_sc_hd__nand2_1
X_20900_ text_in_r\[43\] _11652_ VSS VSS VDD VDD _11653_ sky130_fd_sc_hd__nor2_1
X_20901_ text_in_r\[43\] _11651_ _11653_ VSS VSS VDD VDD _11654_
+ sky130_fd_sc_hd__a21oi_4
X_20902_ _11654_ _11650_ VSS VSS VDD VDD _11655_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_14_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20908_ _12297_ _11655_ VSS VSS VDD VDD _11661_ sky130_fd_sc_hd__nor2_1
X_20909_ _12294_ _11655_ _11661_ VSS VSS VDD VDD _11662_ sky130_fd_sc_hd__a21oi_2
X_20910_ _11627_ net713 VSS VSS VDD VDD _11663_ sky130_fd_sc_hd__nor2_8
X_20911_ _12304_ _11663_ VSS VSS VDD VDD _11664_ sky130_fd_sc_hd__nand2_2
X_20912_ sa12_sr\[4\] sa02_sr\[4\] VSS VSS VDD VDD _11665_
+ sky130_fd_sc_hd__xor2_1
X_20913_ sa31_sub\[3\] sa31_sub\[7\] VSS VSS VDD VDD _11666_
+ sky130_fd_sc_hd__xnor2_1
X_20914_ sa20_sub\[3\] sa31_sub\[4\] sa20_sub\[7\] VSS VSS
+ VDD VDD _11667_ sky130_fd_sc_hd__xor3_1
X_20915_ _11665_ _11666_ _11667_ VSS VSS VDD VDD _11668_ sky130_fd_sc_hd__xnor3_4
X_20916_ text_in_r\[44\] _11668_ net660 VSS VSS VDD VDD _11669_
+ sky130_fd_sc_hd__mux2i_4
X_20917_ u0.w\[2\]\[12\] _11669_ VSS VSS VDD VDD _11670_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_14_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20920_ _11628_ _11662_ _11664_ net758 VSS VSS VDD VDD _11673_
+ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_14_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20923_ _11628_ _11655_ VSS VSS VDD VDD _11676_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_14_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20926_ _12294_ _11655_ VSS VSS VDD VDD _11679_ sky130_fd_sc_hd__nor2_1
X_20927_ _12297_ _11655_ _11679_ _11628_ VSS VSS VDD VDD _11680_
+ sky130_fd_sc_hd__a211oi_2
X_20928_ net758 _11680_ VSS VSS VDD VDD _11681_ sky130_fd_sc_hd__nor2_1
X_20929_ _12302_ _11676_ _11681_ VSS VSS VDD VDD _11682_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_13_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20931_ _11650_ _11654_ VSS VSS VDD VDD _11684_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_13_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20933_ net417 _11684_ VSS VSS VDD VDD _11686_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_13_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20935_ _12294_ _11623_ _11684_ VSS VSS VDD VDD _11688_ sky130_fd_sc_hd__mux2i_4
XTAP_TAPCELL_ROW_13_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20937_ _12299_ net416 VSS VSS VDD VDD _11690_ sky130_fd_sc_hd__nor2_1
X_20938_ _12297_ net416 _11684_ VSS VSS VDD VDD _11691_ sky130_fd_sc_hd__a21o_1
X_20939_ _11690_ _11691_ _11670_ VSS VSS VDD VDD _11692_ sky130_fd_sc_hd__o21a_2
X_20940_ _12292_ _11686_ _11688_ net417 _11692_ VSS VSS VDD
+ VDD _11693_ sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_13_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20943_ net416 _11684_ VSS VSS VDD VDD _11696_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_13_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20947_ _12315_ _11684_ _11696_ _12293_ net758 VSS VSS VDD
+ VDD _11700_ sky130_fd_sc_hd__a221oi_1
X_20948_ net757 _11700_ VSS VSS VDD VDD _11701_ sky130_fd_sc_hd__nor2_1
X_20949_ net757 _11673_ _11682_ _11693_ _11701_ VSS VSS VDD
+ VDD _11702_ sky130_fd_sc_hd__a32oi_4
X_20950_ sa20_sub\[5\] sa31_sub\[5\] VSS VSS VDD VDD _11703_
+ sky130_fd_sc_hd__xor2_1
X_20951_ _11703_ _09455_ VSS VSS VDD VDD _11704_ sky130_fd_sc_hd__xnor2_2
X_20952_ sa12_sr\[6\] _11704_ VSS VSS VDD VDD _11705_ sky130_fd_sc_hd__xnor2_4
X_20953_ text_in_r\[46\] _11705_ net547 VSS VSS VDD VDD _11706_
+ sky130_fd_sc_hd__mux2_2
X_20954_ u0.w\[2\]\[14\] _11706_ VSS VSS VDD VDD _11707_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_13_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20956_ _07084_ _09491_ VSS VSS VDD VDD _11709_ sky130_fd_sc_hd__xnor2_2
X_20957_ sa31_sub\[6\] _11709_ VSS VSS VDD VDD _11710_ sky130_fd_sc_hd__xnor2_4
X_20958_ text_in_r\[47\] _11710_ net547 VSS VSS VDD VDD _11711_
+ sky130_fd_sc_hd__mux2i_4
X_20959_ u0.w\[2\]\[15\] _11711_ VSS VSS VDD VDD _11712_ sky130_fd_sc_hd__xnor2_4
X_20960_ _11707_ _11712_ VSS VSS VDD VDD _11713_ sky130_fd_sc_hd__nand2b_2
X_20961_ _11712_ _11707_ VSS VSS VDD VDD _11714_ sky130_fd_sc_hd__or2_1
X_20962_ u0.w\[2\]\[12\] _11669_ VSS VSS VDD VDD _11715_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_13_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20966_ u0.w\[2\]\[13\] _11638_ VSS VSS VDD VDD _11719_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_13_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20970_ _11623_ _11628_ VSS VSS VDD VDD _11723_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_13_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20974_ net418 _11639_ _11628_ VSS VSS VDD VDD _11726_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_13_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20980_ _12293_ net415 _11719_ _11684_ VSS VSS VDD VDD _11732_
+ sky130_fd_sc_hd__a31oi_1
X_20981_ _11719_ _11723_ _11726_ net419 _11732_ VSS VSS VDD
+ VDD _11733_ sky130_fd_sc_hd__o221ai_2
X_20982_ _12293_ net416 VSS VSS VDD VDD _11734_ sky130_fd_sc_hd__nor2_2
X_20983_ _11623_ _11627_ VSS VSS VDD VDD _11735_ sky130_fd_sc_hd__nand2_1
X_20984_ net419 net418 VSS VSS VDD VDD _11736_ sky130_fd_sc_hd__nand2_1
X_20985_ _11735_ _11736_ _11719_ VSS VSS VDD VDD _11737_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_12_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20988_ _11719_ _11734_ _11737_ net713 VSS VSS VDD VDD _11740_
+ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_12_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20991_ _11639_ net414 VSS VSS VDD VDD _11743_ sky130_fd_sc_hd__nor2_8
X_20992_ _12302_ _11628_ VSS VSS VDD VDD _11744_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_12_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_20994_ _11639_ _11670_ VSS VSS VDD VDD _11746_ sky130_fd_sc_hd__nand2_4
X_20995_ _12306_ _11696_ _11746_ VSS VSS VDD VDD _11747_ sky130_fd_sc_hd__a21oi_1
X_20996_ _12293_ _11628_ _11743_ _11744_ _11747_ VSS VSS VDD
+ VDD _11748_ sky130_fd_sc_hd__o32ai_1
X_20997_ _12302_ VSS VSS VDD VDD _11749_ sky130_fd_sc_hd__inv_1
X_20998_ _11719_ _11670_ VSS VSS VDD VDD _11750_ sky130_fd_sc_hd__nand2_1
X_20999_ _12302_ _11750_ VSS VSS VDD VDD _11751_ sky130_fd_sc_hd__nand2_1
X_21000_ _11749_ _11747_ _11751_ _12293_ _11686_ VSS VSS VDD
+ VDD _11752_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_12_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21002_ _12293_ _11639_ _11670_ _11684_ _11628_ VSS VSS VDD
+ VDD _11754_ sky130_fd_sc_hd__a311oi_1
X_21003_ _11663_ _11754_ _12292_ VSS VSS VDD VDD _11755_ sky130_fd_sc_hd__o21ai_0
X_21004_ _11747_ _11743_ _11755_ VSS VSS VDD VDD _11756_ sky130_fd_sc_hd__o21ai_0
X_21005_ net713 _11748_ _11752_ _11756_ VSS VSS VDD VDD _11757_
+ sky130_fd_sc_hd__a211oi_2
X_21006_ net414 _11733_ _11740_ _11757_ VSS VSS VDD VDD _11758_
+ sky130_fd_sc_hd__a31oi_4
XTAP_TAPCELL_ROW_12_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21009_ _12299_ _11655_ VSS VSS VDD VDD _11761_ sky130_fd_sc_hd__nor2_2
X_21010_ _12294_ _11684_ VSS VSS VDD VDD _11762_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_12_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21013_ _11761_ _11762_ net415 VSS VSS VDD VDD _11765_ sky130_fd_sc_hd__o21ai_0
X_21014_ _12292_ _11696_ VSS VSS VDD VDD _11766_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_12_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21016_ net711 _11655_ VSS VSS VDD VDD _11768_ sky130_fd_sc_hd__nand2_1
X_21017_ _11623_ _11684_ VSS VSS VDD VDD _11769_ sky130_fd_sc_hd__nand2_2
X_21018_ _12302_ _11655_ VSS VSS VDD VDD _11770_ sky130_fd_sc_hd__nor2_2
X_21019_ _12293_ _11684_ VSS VSS VDD VDD _11771_ sky130_fd_sc_hd__nor2_4
X_21020_ net415 _11770_ _11771_ VSS VSS VDD VDD _11772_ sky130_fd_sc_hd__nor3_1
X_21021_ net415 _11768_ _11769_ _11772_ net414 VSS VSS VDD
+ VDD _11773_ sky130_fd_sc_hd__a311oi_1
X_21022_ net414 _11765_ _11766_ _11773_ _11719_ VSS VSS VDD
+ VDD _11774_ sky130_fd_sc_hd__a311o_1
X_21023_ _11622_ net416 VSS VSS VDD VDD _11775_ sky130_fd_sc_hd__nor2_1
X_21024_ _12306_ _11628_ VSS VSS VDD VDD _11776_ sky130_fd_sc_hd__nor2_1
X_21025_ _11775_ _11776_ _11684_ VSS VSS VDD VDD _11777_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_12_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21028_ _12304_ net416 VSS VSS VDD VDD _11780_ sky130_fd_sc_hd__nand2_1
X_21029_ _12293_ _11686_ _11780_ net713 VSS VSS VDD VDD _11781_
+ sky130_fd_sc_hd__a2bb2oi_1
X_21030_ _12299_ _11696_ _11781_ net414 net757 VSS VSS VDD
+ VDD _11782_ sky130_fd_sc_hd__a221oi_1
X_21031_ net414 _11777_ _11782_ VSS VSS VDD VDD _11783_ sky130_fd_sc_hd__o21ai_0
X_21032_ _11712_ _11707_ VSS VSS VDD VDD _11784_ sky130_fd_sc_hd__and2_2
X_21033_ _11618_ _11628_ VSS VSS VDD VDD _11785_ sky130_fd_sc_hd__nand2_1
X_21034_ _12294_ _11628_ net713 _11785_ VSS VSS VDD VDD _11786_
+ sky130_fd_sc_hd__o211ai_1
X_21035_ u0.w\[2\]\[15\] _11711_ VSS VSS VDD VDD _11787_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_12_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21037_ _11787_ _11707_ VSS VSS VDD VDD _11789_ sky130_fd_sc_hd__nand2_4
X_21038_ _11719_ _11670_ _11786_ _11777_ _11789_ VSS VSS VDD
+ VDD _11790_ sky130_fd_sc_hd__a41oi_1
XTAP_TAPCELL_ROW_12_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21040_ _12308_ _11684_ VSS VSS VDD VDD _11792_ sky130_fd_sc_hd__nand2b_1
X_21041_ net416 _11792_ _11768_ VSS VSS VDD VDD _11793_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_12_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21043_ _12297_ _11655_ VSS VSS VDD VDD _11795_ sky130_fd_sc_hd__nand2_1
X_21044_ net418 _11684_ VSS VSS VDD VDD _11796_ sky130_fd_sc_hd__nand2_2
X_21045_ _11628_ _11795_ _11796_ VSS VSS VDD VDD _11797_ sky130_fd_sc_hd__nand3_1
X_21046_ _11639_ _11670_ VSS VSS VDD VDD _11798_ sky130_fd_sc_hd__nor2_1
X_21047_ _11793_ _11797_ _11798_ VSS VSS VDD VDD _11799_ sky130_fd_sc_hd__nand3_1
X_21048_ _11650_ _11654_ _12293_ VSS VSS VDD VDD _11800_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_12_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21050_ _11622_ net713 _11800_ _11628_ VSS VSS VDD VDD _11802_
+ sky130_fd_sc_hd__a211oi_2
X_21051_ _11628_ _11792_ _11795_ _11802_ VSS VSS VDD VDD _11803_
+ sky130_fd_sc_hd__a31oi_1
X_21052_ _12297_ net418 _11655_ VSS VSS VDD VDD _11804_ sky130_fd_sc_hd__mux2i_1
X_21053_ _12299_ _11686_ _11804_ net416 _11670_ VSS VSS VDD
+ VDD _11805_ sky130_fd_sc_hd__o221ai_1
X_21054_ _11670_ _11803_ _11805_ _11639_ VSS VSS VDD VDD _11806_
+ sky130_fd_sc_hd__o211ai_1
X_21055_ _11790_ _11799_ _11806_ VSS VSS VDD VDD _11807_ sky130_fd_sc_hd__and3_1
X_21056_ _11774_ _11783_ _11784_ _11807_ VSS VSS VDD VDD _11808_
+ sky130_fd_sc_hd__a31oi_2
X_21057_ _11702_ _11713_ _11714_ _11758_ _11808_ VSS VSS VDD
+ VDD _00112_ sky130_fd_sc_hd__o221ai_4
X_21058_ _12293_ _11684_ VSS VSS VDD VDD _11809_ sky130_fd_sc_hd__nand2_2
X_21059_ _12292_ net713 VSS VSS VDD VDD _11810_ sky130_fd_sc_hd__nand2_1
X_21060_ net415 _11809_ _11810_ VSS VSS VDD VDD _11811_ sky130_fd_sc_hd__nand3_1
X_21061_ _11623_ _11696_ _11663_ _12299_ VSS VSS VDD VDD _11812_
+ sky130_fd_sc_hd__a22oi_1
X_21062_ _11618_ _11684_ VSS VSS VDD VDD _11813_ sky130_fd_sc_hd__nand2_4
X_21063_ _11628_ _11813_ VSS VSS VDD VDD _11814_ sky130_fd_sc_hd__nor2_1
X_21064_ net415 _11655_ VSS VSS VDD VDD _11815_ sky130_fd_sc_hd__nand2_4
X_21065_ _12306_ _11815_ VSS VSS VDD VDD _11816_ sky130_fd_sc_hd__nor2_1
X_21066_ _12308_ _11663_ _11814_ _11816_ _11719_ VSS VSS VDD
+ VDD _11817_ sky130_fd_sc_hd__a2111oi_0
X_21067_ _11719_ _11811_ _11812_ net758 _11817_ VSS VSS VDD
+ VDD _11818_ sky130_fd_sc_hd__a311o_1
X_21068_ _11628_ _11655_ VSS VSS VDD VDD _11819_ sky130_fd_sc_hd__xnor2_4
X_21069_ _11618_ _11769_ _11819_ _11623_ VSS VSS VDD VDD _11820_
+ sky130_fd_sc_hd__o22ai_1
X_21070_ _12293_ _11696_ _11820_ VSS VSS VDD VDD _11821_ sky130_fd_sc_hd__a21oi_1
X_21071_ _11628_ _11684_ VSS VSS VDD VDD _11822_ sky130_fd_sc_hd__nand2_2
X_21072_ _12299_ net713 _11800_ VSS VSS VDD VDD _11823_ sky130_fd_sc_hd__a21oi_1
X_21073_ _12306_ _11822_ _11823_ _11628_ _11639_ VSS VSS VDD
+ VDD _11824_ sky130_fd_sc_hd__o221ai_1
X_21074_ _11639_ _11821_ _11824_ net758 VSS VSS VDD VDD _11825_
+ sky130_fd_sc_hd__o211ai_1
X_21075_ _11670_ _11655_ VSS VSS VDD VDD _00421_ sky130_fd_sc_hd__nor2_2
X_21076_ _12293_ _12308_ net415 VSS VSS VDD VDD _00422_ sky130_fd_sc_hd__mux2i_1
X_21077_ _12297_ _11670_ VSS VSS VDD VDD _00423_ sky130_fd_sc_hd__nand2_1
X_21078_ _11618_ net414 _11628_ VSS VSS VDD VDD _00424_ sky130_fd_sc_hd__a21oi_1
X_21079_ _12299_ _11628_ VSS VSS VDD VDD _00425_ sky130_fd_sc_hd__and2_0
X_21080_ _00423_ _00424_ _11684_ _00425_ VSS VSS VDD VDD _00426_
+ sky130_fd_sc_hd__a211oi_1
X_21081_ _12322_ _00421_ _00422_ _11692_ _00426_ VSS VSS VDD
+ VDD _00427_ sky130_fd_sc_hd__a221oi_1
X_21082_ _11707_ net757 _00427_ VSS VSS VDD VDD _00428_ sky130_fd_sc_hd__nor3_1
X_21083_ _12299_ _11684_ VSS VSS VDD VDD _00429_ sky130_fd_sc_hd__nor2_4
X_21084_ _11623_ _11655_ VSS VSS VDD VDD _00430_ sky130_fd_sc_hd__nand2_2
X_21085_ _11628_ _00430_ _11796_ VSS VSS VDD VDD _00431_ sky130_fd_sc_hd__nand3_1
X_21086_ _11628_ _11800_ _00429_ _00431_ _11715_ VSS VSS VDD
+ VDD _00432_ sky130_fd_sc_hd__o311ai_0
X_21087_ _11622_ _11684_ VSS VSS VDD VDD _00433_ sky130_fd_sc_hd__nor2_2
X_21088_ _12297_ _11684_ VSS VSS VDD VDD _00434_ sky130_fd_sc_hd__nand2b_4
X_21089_ _11618_ _11655_ VSS VSS VDD VDD _00435_ sky130_fd_sc_hd__nand2_2
X_21090_ _00434_ _00435_ VSS VSS VDD VDD _00436_ sky130_fd_sc_hd__nand2_1
X_21091_ net712 _00433_ _00436_ _11628_ _11715_ VSS VSS VDD
+ VDD _00437_ sky130_fd_sc_hd__a221o_1
X_21092_ _00432_ _00437_ _11707_ _11719_ VSS VSS VDD VDD _00438_
+ sky130_fd_sc_hd__a211oi_1
X_21093_ _11707_ _11818_ _11825_ _00428_ _00438_ VSS VSS VDD
+ VDD _00439_ sky130_fd_sc_hd__a311o_1
XTAP_TAPCELL_ROW_12_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21095_ _12292_ _11684_ _11762_ VSS VSS VDD VDD _00441_ sky130_fd_sc_hd__a21oi_1
X_21096_ _11628_ _11809_ _00430_ VSS VSS VDD VDD _00442_ sky130_fd_sc_hd__nand3_1
X_21097_ _11628_ _00441_ _00442_ VSS VSS VDD VDD _00443_ sky130_fd_sc_hd__o21ai_0
X_21098_ _12308_ _11650_ _11654_ VSS VSS VDD VDD _00444_ sky130_fd_sc_hd__and3_2
X_21099_ _11650_ _11654_ _12306_ VSS VSS VDD VDD _00445_ sky130_fd_sc_hd__a21oi_4
X_21100_ _12294_ _11655_ _00445_ VSS VSS VDD VDD _00446_ sky130_fd_sc_hd__a21oi_1
X_21101_ _11628_ _00446_ VSS VSS VDD VDD _00447_ sky130_fd_sc_hd__nand2_1
X_21102_ _11628_ _11800_ _00444_ _00447_ _11719_ VSS VSS VDD
+ VDD _00448_ sky130_fd_sc_hd__o311ai_2
X_21103_ _11719_ _00443_ _00448_ VSS VSS VDD VDD _00449_ sky130_fd_sc_hd__o21ai_2
X_21104_ _00433_ _11761_ net416 VSS VSS VDD VDD _00450_ sky130_fd_sc_hd__o21ai_0
X_21105_ _12292_ _11684_ _11813_ _11628_ VSS VSS VDD VDD _00451_
+ sky130_fd_sc_hd__o211ai_1
X_21106_ net757 _00450_ _00451_ VSS VSS VDD VDD _00452_ sky130_fd_sc_hd__nand3_1
X_21107_ _12306_ VSS VSS VDD VDD _00453_ sky130_fd_sc_hd__inv_1
X_21108_ _00453_ _11684_ VSS VSS VDD VDD _00454_ sky130_fd_sc_hd__nor2_1
X_21109_ _11800_ _00454_ net415 VSS VSS VDD VDD _00455_ sky130_fd_sc_hd__o21ai_0
X_21110_ _11623_ _11676_ _00455_ _11719_ VSS VSS VDD VDD _00456_
+ sky130_fd_sc_hd__o211ai_2
X_21111_ net758 _00452_ _00456_ _11789_ VSS VSS VDD VDD _00457_
+ sky130_fd_sc_hd__a31oi_1
X_21112_ net758 _00449_ _00457_ VSS VSS VDD VDD _00458_ sky130_fd_sc_hd__o21ai_0
X_21113_ _11712_ _11707_ VSS VSS VDD VDD _00459_ sky130_fd_sc_hd__nor2_4
X_21114_ _12306_ net417 VSS VSS VDD VDD _00460_ sky130_fd_sc_hd__nand2_1
X_21115_ net713 _11744_ _00460_ VSS VSS VDD VDD _00461_ sky130_fd_sc_hd__nand3_1
X_21116_ _12318_ net757 net713 _00461_ net758 VSS VSS VDD
+ VDD _00462_ sky130_fd_sc_hd__o311ai_4
X_21117_ _12292_ _11684_ _00434_ _11628_ VSS VSS VDD VDD _00463_
+ sky130_fd_sc_hd__o211ai_1
X_21118_ _11628_ _00433_ _00445_ _00463_ VSS VSS VDD VDD _00464_
+ sky130_fd_sc_hd__o31ai_1
X_21119_ net419 _11684_ VSS VSS VDD VDD _00465_ sky130_fd_sc_hd__nor2_4
X_21120_ _11618_ _11655_ VSS VSS VDD VDD _00466_ sky130_fd_sc_hd__nor2_1
X_21121_ _00465_ _00466_ _11628_ VSS VSS VDD VDD _00467_ sky130_fd_sc_hd__o21ai_4
X_21122_ _11719_ net414 VSS VSS VDD VDD _00468_ sky130_fd_sc_hd__nand2_2
X_21123_ _00450_ _00467_ _00468_ VSS VSS VDD VDD _00469_ sky130_fd_sc_hd__a21oi_1
X_21124_ net757 _11715_ _00464_ _00469_ VSS VSS VDD VDD _00470_
+ sky130_fd_sc_hd__a31oi_1
X_21125_ _00459_ _00462_ _00470_ VSS VSS VDD VDD _00471_ sky130_fd_sc_hd__nand3_1
X_21126_ _11787_ _00439_ _00458_ _00471_ VSS VSS VDD VDD _00113_
+ sky130_fd_sc_hd__o211ai_1
X_21127_ _11770_ _00465_ _11627_ VSS VSS VDD VDD _00472_ sky130_fd_sc_hd__o21ai_0
X_21128_ _12292_ _11655_ _11800_ VSS VSS VDD VDD _00473_ sky130_fd_sc_hd__a21oi_1
X_21129_ _11628_ _00473_ VSS VSS VDD VDD _00474_ sky130_fd_sc_hd__nand2_1
X_21130_ _11618_ _11627_ VSS VSS VDD VDD _00475_ sky130_fd_sc_hd__nor2_1
X_21131_ _00465_ _00475_ _12293_ VSS VSS VDD VDD _00476_ sky130_fd_sc_hd__o21ai_0
X_21132_ net419 _11628_ VSS VSS VDD VDD _00477_ sky130_fd_sc_hd__nor2_1
X_21133_ _11735_ _00466_ _00477_ _11769_ VSS VSS VDD VDD _00478_
+ sky130_fd_sc_hd__a22oi_1
X_21134_ _00476_ _00478_ _11719_ VSS VSS VDD VDD _00479_ sky130_fd_sc_hd__a21oi_1
X_21135_ _11719_ _00472_ _00474_ _00479_ net758 VSS VSS VDD
+ VDD _00480_ sky130_fd_sc_hd__a311oi_1
X_21136_ _12297_ _11627_ net713 _11734_ VSS VSS VDD VDD _00481_
+ sky130_fd_sc_hd__a211oi_1
X_21137_ _12315_ net713 _00481_ _11719_ VSS VSS VDD VDD _00482_
+ sky130_fd_sc_hd__a211oi_1
X_21138_ _11618_ net417 VSS VSS VDD VDD _00483_ sky130_fd_sc_hd__nand2_1
X_21139_ _12318_ _11684_ _11719_ VSS VSS VDD VDD _00484_ sky130_fd_sc_hd__o21ai_0
X_21140_ _11684_ _11736_ _00483_ _00484_ VSS VSS VDD VDD _00485_
+ sky130_fd_sc_hd__a31oi_1
X_21141_ net414 _00482_ _00485_ VSS VSS VDD VDD _00486_ sky130_fd_sc_hd__nor3_1
X_21142_ _00480_ _00486_ _11784_ VSS VSS VDD VDD _00487_ sky130_fd_sc_hd__o21ai_2
X_21143_ _12294_ _12299_ VSS VSS VDD VDD _00488_ sky130_fd_sc_hd__nor2_1
X_21144_ _00488_ VSS VSS VDD VDD _00489_ sky130_fd_sc_hd__inv_1
X_21145_ net417 _11684_ _00489_ VSS VSS VDD VDD _00490_ sky130_fd_sc_hd__nand3_1
X_21146_ _12302_ _11676_ _11819_ _12306_ _00490_ VSS VSS VDD
+ VDD _00491_ sky130_fd_sc_hd__o221ai_1
X_21147_ net758 _00491_ VSS VSS VDD VDD _00492_ sky130_fd_sc_hd__nor2_1
X_21148_ _12299_ _11663_ _00473_ net417 net414 VSS VSS VDD
+ VDD _00493_ sky130_fd_sc_hd__a221oi_1
X_21149_ _11719_ _00492_ _00493_ VSS VSS VDD VDD _00494_ sky130_fd_sc_hd__nor3_1
X_21150_ _12297_ _11628_ VSS VSS VDD VDD _00495_ sky130_fd_sc_hd__nand2_1
X_21151_ _00421_ _00483_ _00495_ VSS VSS VDD VDD _00496_ sky130_fd_sc_hd__nand3_1
X_21152_ net414 _11684_ VSS VSS VDD VDD _00497_ sky130_fd_sc_hd__nor2_1
X_21153_ _11670_ _11684_ VSS VSS VDD VDD _00498_ sky130_fd_sc_hd__nand2_1
X_21154_ _12313_ _00498_ VSS VSS VDD VDD _00499_ sky130_fd_sc_hd__nor2_1
X_21155_ _00495_ _00497_ _00499_ VSS VSS VDD VDD _00500_ sky130_fd_sc_hd__a21oi_1
X_21156_ _12324_ net414 net713 VSS VSS VDD VDD _00501_ sky130_fd_sc_hd__nand3_1
X_21157_ _00496_ _00500_ _00501_ net757 VSS VSS VDD VDD _00502_
+ sky130_fd_sc_hd__a31oi_2
X_21158_ _11787_ _11707_ VSS VSS VDD VDD _00503_ sky130_fd_sc_hd__nor2_4
X_21159_ _00494_ _00502_ _00503_ VSS VSS VDD VDD _00504_ sky130_fd_sc_hd__o21ai_4
X_21160_ _12306_ _11684_ VSS VSS VDD VDD _00505_ sky130_fd_sc_hd__nand2_1
X_21161_ _11795_ _00505_ _11627_ VSS VSS VDD VDD _00506_ sky130_fd_sc_hd__a21oi_1
X_21162_ _12308_ _11686_ VSS VSS VDD VDD _00507_ sky130_fd_sc_hd__nor2_2
X_21163_ _11623_ _11655_ VSS VSS VDD VDD _00508_ sky130_fd_sc_hd__nor2_1
X_21164_ _00508_ _11771_ VSS VSS VDD VDD _00509_ sky130_fd_sc_hd__nor2_1
X_21165_ _11679_ _00465_ _11628_ VSS VSS VDD VDD _00510_ sky130_fd_sc_hd__o21ai_0
X_21166_ _11628_ _00509_ _00510_ _11715_ VSS VSS VDD VDD _00511_
+ sky130_fd_sc_hd__o211ai_1
X_21167_ _11715_ _00506_ _00507_ _00511_ net757 VSS VSS VDD
+ VDD _00512_ sky130_fd_sc_hd__o311ai_2
X_21168_ _11627_ _00436_ VSS VSS VDD VDD _00513_ sky130_fd_sc_hd__nand2_1
X_21169_ _11627_ _11771_ _11761_ _11743_ _00513_ VSS VSS VDD
+ VDD _00514_ sky130_fd_sc_hd__o311ai_2
X_21170_ net419 net713 VSS VSS VDD VDD _00515_ sky130_fd_sc_hd__nor2_4
X_21171_ _11661_ _00444_ _11628_ VSS VSS VDD VDD _00516_ sky130_fd_sc_hd__o21ai_0
X_21172_ _11628_ _00515_ _00429_ _00516_ _11798_ VSS VSS VDD
+ VDD _00517_ sky130_fd_sc_hd__o311ai_1
X_21173_ _00459_ _00512_ _00514_ _00517_ VSS VSS VDD VDD _00518_
+ sky130_fd_sc_hd__nand4_2
X_21174_ _12304_ _11684_ _11796_ VSS VSS VDD VDD _00519_ sky130_fd_sc_hd__o21ai_0
X_21175_ _12308_ _11684_ VSS VSS VDD VDD _00520_ sky130_fd_sc_hd__nor2_1
X_21176_ net416 _11761_ _00520_ VSS VSS VDD VDD _00521_ sky130_fd_sc_hd__or3_1
X_21177_ _11628_ _00519_ _00521_ VSS VSS VDD VDD _00522_ sky130_fd_sc_hd__o21ai_0
X_21178_ _12304_ net713 VSS VSS VDD VDD _00523_ sky130_fd_sc_hd__nand2_4
X_21179_ net416 _11813_ _00523_ _11715_ _11690_ VSS VSS VDD
+ VDD _00524_ sky130_fd_sc_hd__a311oi_1
X_21180_ _11715_ _00522_ _00524_ VSS VSS VDD VDD _00525_ sky130_fd_sc_hd__a21oi_1
X_21181_ _12293_ VSS VSS VDD VDD _00526_ sky130_fd_sc_hd__inv_1
X_21182_ _00526_ _11684_ VSS VSS VDD VDD _00527_ sky130_fd_sc_hd__nand2_2
X_21183_ _00527_ _00523_ net416 VSS VSS VDD VDD _00528_ sky130_fd_sc_hd__a21oi_1
X_21184_ _11802_ _00528_ net758 VSS VSS VDD VDD _00529_ sky130_fd_sc_hd__o21ai_0
X_21185_ _12304_ _11628_ _11785_ VSS VSS VDD VDD _00530_ sky130_fd_sc_hd__o21ai_0
X_21186_ net418 _11628_ VSS VSS VDD VDD _00531_ sky130_fd_sc_hd__nor2_4
X_21187_ _12308_ _11628_ VSS VSS VDD VDD _00532_ sky130_fd_sc_hd__and2_0
X_21188_ _11684_ _00531_ _00532_ _11715_ VSS VSS VDD VDD _00533_
+ sky130_fd_sc_hd__o31ai_2
X_21189_ _11684_ _00530_ _00533_ VSS VSS VDD VDD _00534_ sky130_fd_sc_hd__a21oi_1
X_21190_ _11719_ _00534_ VSS VSS VDD VDD _00535_ sky130_fd_sc_hd__nor2_1
X_21191_ _11719_ _00525_ _00529_ _00535_ _11789_ VSS VSS VDD
+ VDD _00536_ sky130_fd_sc_hd__a221o_1
X_21192_ _00487_ _00504_ _00518_ _00536_ VSS VSS VDD VDD _00114_
+ sky130_fd_sc_hd__nand4_1
X_21193_ _12292_ _11686_ _11676_ net419 VSS VSS VDD VDD _00537_
+ sky130_fd_sc_hd__o22ai_1
X_21194_ net415 _11768_ net418 VSS VSS VDD VDD _00538_ sky130_fd_sc_hd__a21oi_1
X_21195_ _00537_ _00538_ net758 VSS VSS VDD VDD _00539_ sky130_fd_sc_hd__o21a_1
X_21196_ _12308_ _11655_ VSS VSS VDD VDD _00540_ sky130_fd_sc_hd__nand2_2
X_21197_ _12293_ _11655_ VSS VSS VDD VDD _00541_ sky130_fd_sc_hd__nand2_4
X_21198_ _12304_ _11684_ VSS VSS VDD VDD _00542_ sky130_fd_sc_hd__nand2_1
X_21199_ net415 _00541_ _00542_ VSS VSS VDD VDD _00543_ sky130_fd_sc_hd__and3_1
X_21200_ _11628_ _11796_ _00540_ _00543_ net758 VSS VSS VDD
+ VDD _00544_ sky130_fd_sc_hd__a311oi_1
X_21201_ _12304_ _11655_ VSS VSS VDD VDD _00545_ sky130_fd_sc_hd__nor2_1
X_21202_ _12302_ net713 _00545_ VSS VSS VDD VDD _00546_ sky130_fd_sc_hd__a21oi_1
X_21203_ _11655_ _00489_ VSS VSS VDD VDD _00547_ sky130_fd_sc_hd__nor2_2
X_21204_ _00454_ _00547_ net415 VSS VSS VDD VDD _00548_ sky130_fd_sc_hd__o21ai_0
X_21205_ net415 _00546_ _00548_ _11670_ VSS VSS VDD VDD _00549_
+ sky130_fd_sc_hd__o211ai_1
X_21206_ _11719_ _00533_ _00549_ VSS VSS VDD VDD _00550_ sky130_fd_sc_hd__nand3_1
X_21207_ _11719_ _00539_ _00544_ _00550_ _11707_ VSS VSS VDD
+ VDD _00551_ sky130_fd_sc_hd__o311ai_1
X_21208_ _12308_ _11684_ VSS VSS VDD VDD _00552_ sky130_fd_sc_hd__nand2_1
X_21209_ _00430_ _00552_ net415 VSS VSS VDD VDD _00553_ sky130_fd_sc_hd__a21oi_2
X_21210_ _11623_ net415 VSS VSS VDD VDD _00554_ sky130_fd_sc_hd__nor2_1
X_21211_ _00554_ _00541_ _00490_ _11743_ VSS VSS VDD VDD _00555_
+ sky130_fd_sc_hd__o211ai_1
X_21212_ _12294_ net415 _11719_ _11734_ VSS VSS VDD VDD _00556_
+ sky130_fd_sc_hd__a22oi_1
X_21213_ net414 net713 VSS VSS VDD VDD _00557_ sky130_fd_sc_hd__nand2_1
X_21214_ net419 _11639_ VSS VSS VDD VDD _00558_ sky130_fd_sc_hd__nor2_1
X_21215_ _12293_ _11639_ _00558_ _11628_ VSS VSS VDD VDD _00559_
+ sky130_fd_sc_hd__a211oi_1
X_21216_ _11749_ _11628_ _11719_ _00557_ _00559_ VSS VSS VDD
+ VDD _00560_ sky130_fd_sc_hd__a311oi_2
X_21217_ net418 _11815_ VSS VSS VDD VDD _00561_ sky130_fd_sc_hd__nor2_1
X_21218_ _12304_ _11819_ _00561_ _11746_ VSS VSS VDD VDD _00562_
+ sky130_fd_sc_hd__a211oi_1
X_21219_ _00421_ _00556_ _00560_ _00562_ _11707_ VSS VSS VDD
+ VDD _00563_ sky130_fd_sc_hd__a2111oi_1
X_21220_ _00553_ _00555_ _00563_ VSS VSS VDD VDD _00564_ sky130_fd_sc_hd__o21ai_2
X_21221_ _12299_ _11684_ VSS VSS VDD VDD _00565_ sky130_fd_sc_hd__nand2_1
X_21222_ _11792_ _00541_ _11628_ VSS VSS VDD VDD _00566_ sky130_fd_sc_hd__a21oi_1
X_21223_ _11628_ _00435_ _00565_ _00566_ _11715_ VSS VSS VDD
+ VDD _00567_ sky130_fd_sc_hd__a311oi_1
X_21224_ _12302_ _11684_ VSS VSS VDD VDD _00568_ sky130_fd_sc_hd__nor2_1
X_21225_ _12292_ _11655_ VSS VSS VDD VDD _00569_ sky130_fd_sc_hd__nor2_1
X_21226_ _11628_ _00568_ _00569_ VSS VSS VDD VDD _00570_ sky130_fd_sc_hd__nor3_1
X_21227_ _11628_ _00527_ _00430_ _00570_ net758 VSS VSS VDD
+ VDD _00571_ sky130_fd_sc_hd__a311oi_1
X_21228_ _11707_ _00567_ _00571_ VSS VSS VDD VDD _00572_ sky130_fd_sc_hd__nor3_1
X_21229_ _12302_ _11684_ _11769_ VSS VSS VDD VDD _00573_ sky130_fd_sc_hd__o21ai_0
X_21230_ _12293_ _11628_ _11684_ _11796_ net712 VSS VSS VDD
+ VDD _00574_ sky130_fd_sc_hd__o32ai_1
X_21231_ _11707_ _11715_ VSS VSS VDD VDD _00575_ sky130_fd_sc_hd__nand2_1
X_21232_ _11628_ _00573_ _00574_ _00575_ VSS VSS VDD VDD _00576_
+ sky130_fd_sc_hd__a211oi_1
X_21233_ _12302_ _11684_ _00454_ VSS VSS VDD VDD _00577_ sky130_fd_sc_hd__a21oi_1
X_21234_ _12297_ _11684_ _11771_ net415 VSS VSS VDD VDD _00578_
+ sky130_fd_sc_hd__a211oi_1
X_21235_ _11707_ _11670_ VSS VSS VDD VDD _00579_ sky130_fd_sc_hd__nand2_1
X_21236_ net415 _00577_ _00578_ _00579_ VSS VSS VDD VDD _00580_
+ sky130_fd_sc_hd__a211oi_1
X_21237_ _00572_ _00576_ _00580_ net757 _11712_ VSS VSS VDD
+ VDD _00581_ sky130_fd_sc_hd__o311a_1
X_21238_ _11771_ _00515_ net415 VSS VSS VDD VDD _00582_ sky130_fd_sc_hd__o21ai_0
X_21239_ _00523_ _00552_ net415 VSS VSS VDD VDD _00583_ sky130_fd_sc_hd__a21o_1
X_21240_ _12297_ _11663_ VSS VSS VDD VDD _00584_ sky130_fd_sc_hd__nand2_1
X_21241_ net419 _11623_ VSS VSS VDD VDD _00585_ sky130_fd_sc_hd__nor2_1
X_21242_ _00531_ _00585_ net713 VSS VSS VDD VDD _00586_ sky130_fd_sc_hd__o21ai_0
X_21243_ _00584_ _00586_ net414 VSS VSS VDD VDD _00587_ sky130_fd_sc_hd__a21oi_1
X_21244_ net414 _00582_ _00583_ _00587_ VSS VSS VDD VDD _00588_
+ sky130_fd_sc_hd__a31oi_1
X_21245_ _11719_ _11784_ VSS VSS VDD VDD _00589_ sky130_fd_sc_hd__nand2_1
X_21246_ _11628_ _11670_ VSS VSS VDD VDD _00590_ sky130_fd_sc_hd__nand2_1
X_21247_ net415 net414 VSS VSS VDD VDD _00591_ sky130_fd_sc_hd__nand2_1
X_21248_ net419 _00590_ _00591_ VSS VSS VDD VDD _00592_ sky130_fd_sc_hd__o21ai_0
X_21249_ _11623_ net414 _11628_ _11618_ VSS VSS VDD VDD _00593_
+ sky130_fd_sc_hd__o211ai_1
X_21250_ _11618_ net414 _00531_ _00593_ net713 VSS VSS VDD
+ VDD _00594_ sky130_fd_sc_hd__o311ai_0
X_21251_ net713 _00592_ _00594_ VSS VSS VDD VDD _00595_ sky130_fd_sc_hd__o21ai_0
X_21252_ _12293_ _11684_ _00590_ _00531_ net414 VSS VSS VDD
+ VDD _00596_ sky130_fd_sc_hd__a32oi_1
X_21253_ _11719_ _00503_ _00595_ _00596_ VSS VSS VDD VDD _00597_
+ sky130_fd_sc_hd__nand4_1
X_21254_ _00588_ _00589_ _00597_ VSS VSS VDD VDD _00598_ sky130_fd_sc_hd__o21ai_1
X_21255_ _11787_ _00551_ _00564_ _00581_ _00598_ VSS VSS VDD
+ VDD _00115_ sky130_fd_sc_hd__a311oi_2
X_21256_ _12299_ _11655_ _11661_ _11628_ VSS VSS VDD VDD _00599_
+ sky130_fd_sc_hd__a211oi_2
X_21257_ _11628_ _11813_ _00540_ _00599_ VSS VSS VDD VDD _00600_
+ sky130_fd_sc_hd__a31oi_1
X_21258_ _11670_ _00600_ VSS VSS VDD VDD _00601_ sky130_fd_sc_hd__nor2_1
X_21259_ _12292_ _11628_ _11785_ VSS VSS VDD VDD _00602_ sky130_fd_sc_hd__o21ai_0
X_21260_ _11684_ _00602_ _11692_ VSS VSS VDD VDD _00603_ sky130_fd_sc_hd__a21boi_0
X_21261_ _12292_ _11663_ VSS VSS VDD VDD _00604_ sky130_fd_sc_hd__nand2_1
X_21262_ _11618_ _00433_ VSS VSS VDD VDD _00605_ sky130_fd_sc_hd__nand2_1
X_21263_ net712 net416 _00575_ VSS VSS VDD VDD _00606_ sky130_fd_sc_hd__a21oi_1
X_21264_ _00604_ _00605_ _00606_ _11639_ _11787_ VSS VSS VDD
+ VDD _00607_ sky130_fd_sc_hd__a311oi_2
X_21265_ net419 net418 _11684_ VSS VSS VDD VDD _00608_ sky130_fd_sc_hd__nand3_2
X_21266_ _11618_ _11819_ _00579_ VSS VSS VDD VDD _00609_ sky130_fd_sc_hd__a21oi_1
X_21267_ _00561_ _00608_ _00609_ VSS VSS VDD VDD _00610_ sky130_fd_sc_hd__nand3b_2
X_21268_ _11707_ _00601_ _00603_ _00607_ _00610_ VSS VSS VDD
+ VDD _00611_ sky130_fd_sc_hd__o311a_1
X_21269_ _12299_ net416 _11734_ VSS VSS VDD VDD _00612_ sky130_fd_sc_hd__a21oi_1
X_21270_ _11684_ _00612_ _11777_ net758 VSS VSS VDD VDD _00613_
+ sky130_fd_sc_hd__o211ai_1
X_21271_ _11628_ _11715_ _00446_ VSS VSS VDD VDD _00614_ sky130_fd_sc_hd__nand3_1
X_21272_ _12297_ _11684_ VSS VSS VDD VDD _00615_ sky130_fd_sc_hd__nor2_1
X_21273_ _00515_ _00615_ net416 VSS VSS VDD VDD _00616_ sky130_fd_sc_hd__o21ai_0
X_21274_ _12306_ _11650_ _11654_ VSS VSS VDD VDD _00617_ sky130_fd_sc_hd__nand3_1
X_21275_ _12293_ _11628_ _11684_ VSS VSS VDD VDD _00618_ sky130_fd_sc_hd__nand3_1
X_21276_ _00617_ _00618_ _11715_ VSS VSS VDD VDD _00619_ sky130_fd_sc_hd__a21oi_1
X_21277_ _11715_ _11664_ _00616_ _00619_ _11707_ VSS VSS VDD
+ VDD _00620_ sky130_fd_sc_hd__a311oi_1
X_21278_ _11707_ _00613_ _00614_ _00620_ VSS VSS VDD VDD _00621_
+ sky130_fd_sc_hd__a31oi_1
X_21279_ _11787_ net757 _00621_ VSS VSS VDD VDD _00622_ sky130_fd_sc_hd__and3_1
X_21280_ _11768_ _11796_ VSS VSS VDD VDD _00623_ sky130_fd_sc_hd__nand2_1
X_21281_ net416 _00623_ VSS VSS VDD VDD _00624_ sky130_fd_sc_hd__nand2_1
X_21282_ _12292_ _11676_ _11688_ _11628_ _00608_ VSS VSS VDD
+ VDD _00625_ sky130_fd_sc_hd__o221ai_1
X_21283_ _11715_ _00625_ VSS VSS VDD VDD _00626_ sky130_fd_sc_hd__nor2_1
X_21284_ net414 _11664_ _00605_ _00624_ _00626_ VSS VSS VDD
+ VDD _00627_ sky130_fd_sc_hd__a41o_1
X_21285_ _12292_ _11684_ _00565_ VSS VSS VDD VDD _00628_ sky130_fd_sc_hd__o21ai_0
X_21286_ _11628_ _00628_ _00467_ VSS VSS VDD VDD _00629_ sky130_fd_sc_hd__o21a_1
X_21287_ _11623_ _11815_ _00520_ net416 _11670_ VSS VSS VDD
+ VDD _00630_ sky130_fd_sc_hd__o221ai_1
X_21288_ _11670_ _00629_ _00630_ _11707_ VSS VSS VDD VDD _00631_
+ sky130_fd_sc_hd__o211ai_1
X_21289_ _11707_ _00627_ _00631_ _11719_ _11787_ VSS VSS VDD
+ VDD _00632_ sky130_fd_sc_hd__o2111a_1
X_21290_ _11707_ _11762_ VSS VSS VDD VDD _00633_ sky130_fd_sc_hd__nand2_1
X_21291_ _12304_ _11707_ _00633_ net416 VSS VSS VDD VDD _00634_
+ sky130_fd_sc_hd__o211ai_1
X_21292_ net416 _11707_ _11800_ _00429_ VSS VSS VDD VDD _00635_
+ sky130_fd_sc_hd__nor4_1
X_21293_ _12304_ _11707_ _11684_ _00635_ VSS VSS VDD VDD _00636_
+ sky130_fd_sc_hd__a31oi_1
X_21294_ net416 _00434_ _00540_ VSS VSS VDD VDD _00637_ sky130_fd_sc_hd__nand3_1
X_21295_ _11628_ _00541_ _00542_ VSS VSS VDD VDD _00638_ sky130_fd_sc_hd__nand3_1
X_21296_ _00637_ _00638_ _11707_ _11715_ VSS VSS VDD VDD _00639_
+ sky130_fd_sc_hd__a211oi_1
X_21297_ _11628_ _11813_ _11810_ _00579_ _00531_ VSS VSS VDD
+ VDD _00640_ sky130_fd_sc_hd__a311oi_4
X_21298_ _11715_ _00634_ _00636_ _00639_ _00640_ VSS VSS VDD
+ VDD _00641_ sky130_fd_sc_hd__a311oi_1
X_21299_ _11787_ _11719_ _00641_ VSS VSS VDD VDD _00642_ sky130_fd_sc_hd__nor3_1
X_21300_ _00611_ _00622_ _00632_ _00642_ VSS VSS VDD VDD _00116_
+ sky130_fd_sc_hd__nor4_1
X_21301_ _11770_ _00444_ _11628_ VSS VSS VDD VDD _00643_ sky130_fd_sc_hd__o21a_1
X_21302_ net416 _00527_ _00541_ _00643_ VSS VSS VDD VDD _00644_
+ sky130_fd_sc_hd__a31oi_1
X_21303_ _11684_ _00425_ _11822_ _12308_ net757 VSS VSS VDD
+ VDD _00645_ sky130_fd_sc_hd__o221ai_1
X_21304_ _11639_ _00644_ _00645_ _11715_ VSS VSS VDD VDD _00646_
+ sky130_fd_sc_hd__o211ai_1
X_21305_ _12297_ _11696_ VSS VSS VDD VDD _00647_ sky130_fd_sc_hd__nand2_1
X_21306_ _12302_ _11684_ _00454_ net415 _11639_ VSS VSS VDD
+ VDD _00648_ sky130_fd_sc_hd__a221oi_1
X_21307_ net757 _00548_ _00647_ _00648_ net414 VSS VSS VDD
+ VDD _00649_ sky130_fd_sc_hd__a311o_1
X_21308_ _00459_ _00646_ _00649_ VSS VSS VDD VDD _00650_ sky130_fd_sc_hd__and3_1
X_21309_ _12304_ _11696_ VSS VSS VDD VDD _00651_ sky130_fd_sc_hd__nand2_1
X_21310_ _00565_ _00651_ VSS VSS VDD VDD _00652_ sky130_fd_sc_hd__nand2_1
X_21311_ _12299_ net416 _00532_ VSS VSS VDD VDD _00653_ sky130_fd_sc_hd__a21oi_1
X_21312_ _11655_ _00653_ _11786_ _11670_ VSS VSS VDD VDD _00654_
+ sky130_fd_sc_hd__o211ai_1
X_21313_ net758 _11680_ _00652_ _00654_ net757 VSS VSS VDD
+ VDD _00655_ sky130_fd_sc_hd__o311a_1
X_21314_ net418 _11822_ VSS VSS VDD VDD _00656_ sky130_fd_sc_hd__nor2_1
X_21315_ _00543_ _00656_ _11670_ VSS VSS VDD VDD _00657_ sky130_fd_sc_hd__o21ai_0
X_21316_ _12297_ _11684_ net415 VSS VSS VDD VDD _00658_ sky130_fd_sc_hd__a21oi_1
X_21317_ _12299_ net713 _00658_ VSS VSS VDD VDD _00659_ sky130_fd_sc_hd__a21oi_1
X_21318_ net414 _00659_ VSS VSS VDD VDD _00660_ sky130_fd_sc_hd__nand2_1
X_21319_ _11719_ _00657_ _00660_ VSS VSS VDD VDD _00661_ sky130_fd_sc_hd__and3_1
X_21320_ _00655_ _00661_ _11784_ VSS VSS VDD VDD _00662_ sky130_fd_sc_hd__o21a_1
X_21321_ net418 _11819_ VSS VSS VDD VDD _00663_ sky130_fd_sc_hd__nor2_1
X_21322_ _12299_ _11696_ VSS VSS VDD VDD _00664_ sky130_fd_sc_hd__nand2_1
X_21323_ _12306_ _11686_ _00664_ VSS VSS VDD VDD _00665_ sky130_fd_sc_hd__o21ai_0
X_21324_ _00663_ _00665_ net758 VSS VSS VDD VDD _00666_ sky130_fd_sc_hd__o21ai_0
X_21325_ _11816_ _00643_ _11715_ VSS VSS VDD VDD _00667_ sky130_fd_sc_hd__o21ai_0
X_21326_ net415 _11809_ _00435_ VSS VSS VDD VDD _00668_ sky130_fd_sc_hd__nand3_1
X_21327_ _11628_ _00434_ _00523_ VSS VSS VDD VDD _00669_ sky130_fd_sc_hd__nand3_1
X_21328_ net418 _00435_ _00561_ net414 VSS VSS VDD VDD _00670_
+ sky130_fd_sc_hd__a211oi_1
X_21329_ net414 _00668_ _00669_ _00670_ _11719_ VSS VSS VDD
+ VDD _00671_ sky130_fd_sc_hd__a311oi_1
X_21330_ _11719_ _00666_ _00667_ _00671_ _11789_ VSS VSS VDD
+ VDD _00672_ sky130_fd_sc_hd__a311oi_1
X_21331_ _11744_ _00421_ _00460_ VSS VSS VDD VDD _00673_ sky130_fd_sc_hd__nand3_1
X_21332_ net419 _11628_ _00497_ VSS VSS VDD VDD _00674_ sky130_fd_sc_hd__nand3_1
X_21333_ net418 _00557_ _00498_ VSS VSS VDD VDD _00675_ sky130_fd_sc_hd__o21ai_0
X_21334_ net419 net414 _11676_ VSS VSS VDD VDD _00676_ sky130_fd_sc_hd__o21ai_0
X_21335_ _11618_ _00675_ _00676_ net418 _11719_ VSS VSS VDD
+ VDD _00677_ sky130_fd_sc_hd__a221oi_1
X_21336_ _12294_ net713 VSS VSS VDD VDD _00678_ sky130_fd_sc_hd__nand2_1
X_21337_ _11809_ _00678_ net415 VSS VSS VDD VDD _00679_ sky130_fd_sc_hd__a21oi_1
X_21338_ _11618_ _11815_ VSS VSS VDD VDD _00680_ sky130_fd_sc_hd__nor2_1
X_21339_ _00444_ _00569_ _11628_ VSS VSS VDD VDD _00681_ sky130_fd_sc_hd__o21ai_0
X_21340_ _12293_ _11686_ _11743_ _00681_ VSS VSS VDD VDD _00682_
+ sky130_fd_sc_hd__o211ai_2
X_21341_ _00468_ _00679_ _00680_ _00682_ _00503_ VSS VSS VDD
+ VDD _00683_ sky130_fd_sc_hd__o311ai_4
X_21342_ _00673_ _00674_ _00677_ _00683_ VSS VSS VDD VDD _00684_
+ sky130_fd_sc_hd__a31oi_2
X_21343_ _00650_ _00662_ _00672_ _00684_ VSS VSS VDD VDD _00117_
+ sky130_fd_sc_hd__or4_1
X_21344_ net417 _00508_ VSS VSS VDD VDD _00685_ sky130_fd_sc_hd__nor2_1
X_21345_ net418 _11686_ _00685_ net419 _00647_ VSS VSS VDD
+ VDD _00686_ sky130_fd_sc_hd__o221ai_1
X_21346_ net757 _00686_ VSS VSS VDD VDD _00687_ sky130_fd_sc_hd__nand2_1
X_21347_ _00543_ _00685_ _11719_ VSS VSS VDD VDD _00688_ sky130_fd_sc_hd__o21ai_0
X_21348_ _12297_ net415 VSS VSS VDD VDD _00689_ sky130_fd_sc_hd__nor2_1
X_21349_ _12322_ _11684_ VSS VSS VDD VDD _00690_ sky130_fd_sc_hd__nand2_1
X_21350_ _11684_ _00531_ _00689_ _00690_ _11719_ VSS VSS VDD
+ VDD _00691_ sky130_fd_sc_hd__o311ai_0
X_21351_ _12308_ _11815_ _00608_ _11639_ _11723_ VSS VSS VDD
+ VDD _00692_ sky130_fd_sc_hd__o2111ai_1
X_21352_ _00691_ _00692_ net758 VSS VSS VDD VDD _00693_ sky130_fd_sc_hd__a21oi_1
X_21353_ net758 _00687_ _00688_ _00693_ _11789_ VSS VSS VDD
+ VDD _00694_ sky130_fd_sc_hd__a311oi_2
X_21354_ _00568_ _00466_ _11628_ VSS VSS VDD VDD _00695_ sky130_fd_sc_hd__o21ai_0
X_21355_ _12297_ _11686_ _00695_ VSS VSS VDD VDD _00696_ sky130_fd_sc_hd__o21ai_0
X_21356_ _12293_ _11628_ _11655_ _00495_ VSS VSS VDD VDD _00697_
+ sky130_fd_sc_hd__o211ai_1
X_21357_ _12313_ net713 _00697_ _11639_ VSS VSS VDD VDD _00698_
+ sky130_fd_sc_hd__o211ai_1
X_21358_ _11639_ _00696_ _00698_ net414 VSS VSS VDD VDD _00699_
+ sky130_fd_sc_hd__o211ai_1
X_21359_ _11628_ _00509_ VSS VSS VDD VDD _00700_ sky130_fd_sc_hd__nand2_1
X_21360_ _11684_ _00488_ _00434_ net417 VSS VSS VDD VDD _00701_
+ sky130_fd_sc_hd__o211ai_1
X_21361_ _11628_ _11771_ _00515_ VSS VSS VDD VDD _00702_ sky130_fd_sc_hd__nor3_1
X_21362_ _11628_ _11662_ _00702_ _11746_ VSS VSS VDD VDD _00703_
+ sky130_fd_sc_hd__a211oi_1
X_21363_ _11743_ _00700_ _00701_ _00703_ VSS VSS VDD VDD _00704_
+ sky130_fd_sc_hd__a31oi_1
X_21364_ _00503_ _00699_ _00704_ VSS VSS VDD VDD _00705_ sky130_fd_sc_hd__and3_1
X_21365_ _12304_ _11628_ _11684_ _00477_ VSS VSS VDD VDD _00706_
+ sky130_fd_sc_hd__a211oi_1
X_21366_ _12312_ _11684_ _00706_ VSS VSS VDD VDD _00707_ sky130_fd_sc_hd__a21oi_1
X_21367_ _12293_ _11686_ net414 VSS VSS VDD VDD _00708_ sky130_fd_sc_hd__o21ai_0
X_21368_ net414 _00707_ _00708_ _00553_ _11639_ VSS VSS VDD
+ VDD _00709_ sky130_fd_sc_hd__o221ai_1
X_21369_ _12299_ _00590_ VSS VSS VDD VDD _00710_ sky130_fd_sc_hd__nor2_1
X_21370_ net419 net414 VSS VSS VDD VDD _00711_ sky130_fd_sc_hd__nand2_1
X_21371_ _00423_ _00711_ _11628_ VSS VSS VDD VDD _00712_ sky130_fd_sc_hd__a21oi_1
X_21372_ _00710_ _00712_ _11684_ VSS VSS VDD VDD _00713_ sky130_fd_sc_hd__o21ai_0
X_21373_ net415 _11670_ _00546_ _00713_ _11719_ VSS VSS VDD
+ VDD _00714_ sky130_fd_sc_hd__o311ai_0
X_21374_ _00459_ _00709_ _00714_ VSS VSS VDD VDD _00715_ sky130_fd_sc_hd__and3_1
X_21375_ net713 _00488_ VSS VSS VDD VDD _00716_ sky130_fd_sc_hd__nor2_1
X_21376_ _11623_ _11684_ _00542_ net417 VSS VSS VDD VDD _00717_
+ sky130_fd_sc_hd__o211ai_1
X_21377_ net417 _11771_ _00716_ _00717_ VSS VSS VDD VDD _00718_
+ sky130_fd_sc_hd__o31ai_1
X_21378_ _12292_ _11684_ _00542_ VSS VSS VDD VDD _00719_ sky130_fd_sc_hd__o21ai_0
X_21379_ _12294_ _11663_ _00719_ net417 _11719_ VSS VSS VDD
+ VDD _00720_ sky130_fd_sc_hd__a221oi_1
X_21380_ _11719_ _00718_ _00720_ VSS VSS VDD VDD _00721_ sky130_fd_sc_hd__a21oi_1
X_21381_ _12304_ net713 _00445_ _11627_ VSS VSS VDD VDD _00722_
+ sky130_fd_sc_hd__a211oi_1
X_21382_ _12294_ _11684_ _00444_ _11628_ VSS VSS VDD VDD _00723_
+ sky130_fd_sc_hd__a211oi_1
X_21383_ net419 net417 VSS VSS VDD VDD _00724_ sky130_fd_sc_hd__nand2_1
X_21384_ _11618_ _11623_ VSS VSS VDD VDD _00725_ sky130_fd_sc_hd__nand2_1
X_21385_ _12311_ _12320_ _11684_ VSS VSS VDD VDD _00726_ sky130_fd_sc_hd__nor3_1
X_21386_ _11684_ _00724_ _00725_ _00726_ _11746_ VSS VSS VDD
+ VDD _00727_ sky130_fd_sc_hd__a311o_1
X_21387_ _11750_ _00722_ _00723_ _00727_ _11784_ VSS VSS VDD
+ VDD _00728_ sky130_fd_sc_hd__o311ai_1
X_21388_ net414 _00721_ _00728_ VSS VSS VDD VDD _00729_ sky130_fd_sc_hd__a21oi_1
X_21389_ _00694_ _00705_ _00715_ _00729_ VSS VSS VDD VDD _00118_
+ sky130_fd_sc_hd__nor4_2
X_21390_ _12304_ _11822_ VSS VSS VDD VDD _00730_ sky130_fd_sc_hd__nor2_1
X_21391_ net416 _11813_ _00540_ _00730_ _11746_ VSS VSS VDD
+ VDD _00731_ sky130_fd_sc_hd__a311oi_1
X_21392_ _11815_ _11822_ VSS VSS VDD VDD _00732_ sky130_fd_sc_hd__nand2_1
X_21393_ _11622_ _11696_ _00732_ _00526_ _00507_ VSS VSS VDD
+ VDD _00733_ sky130_fd_sc_hd__a221o_1
X_21394_ _11769_ _00540_ VSS VSS VDD VDD _00734_ sky130_fd_sc_hd__nand2_1
X_21395_ _11628_ _11813_ _00523_ VSS VSS VDD VDD _00735_ sky130_fd_sc_hd__nand3_1
X_21396_ _11628_ _00734_ _00735_ _11743_ VSS VSS VDD VDD _00736_
+ sky130_fd_sc_hd__o211ai_1
X_21397_ _00468_ _00733_ _00736_ VSS VSS VDD VDD _00737_ sky130_fd_sc_hd__o21ai_0
X_21398_ _00433_ _00445_ _11628_ VSS VSS VDD VDD _00738_ sky130_fd_sc_hd__o21ai_0
X_21399_ _00569_ _00615_ net416 VSS VSS VDD VDD _00739_ sky130_fd_sc_hd__o21ai_0
X_21400_ _00738_ _00739_ _11719_ net758 VSS VSS VDD VDD _00740_
+ sky130_fd_sc_hd__a211oi_1
X_21401_ _00731_ _00737_ _00740_ VSS VSS VDD VDD _00741_ sky130_fd_sc_hd__nor3_1
X_21402_ _12294_ _11696_ _00445_ VSS VSS VDD VDD _00742_ sky130_fd_sc_hd__a21oi_1
X_21403_ _12297_ _11684_ _00565_ net416 VSS VSS VDD VDD _00743_
+ sky130_fd_sc_hd__o211ai_1
X_21404_ _11715_ _00467_ _00743_ VSS VSS VDD VDD _00744_ sky130_fd_sc_hd__nand3_1
X_21405_ _11715_ _00742_ _00744_ VSS VSS VDD VDD _00745_ sky130_fd_sc_hd__o21ai_0
X_21406_ _11734_ _11684_ _11780_ VSS VSS VDD VDD _00746_ sky130_fd_sc_hd__nor3b_1
X_21407_ _12320_ net713 _11743_ VSS VSS VDD VDD _00747_ sky130_fd_sc_hd__o21ai_1
X_21408_ _11628_ _11800_ _00465_ _00442_ _11798_ VSS VSS VDD
+ VDD _00748_ sky130_fd_sc_hd__o311ai_1
X_21409_ _00746_ _00747_ _00748_ VSS VSS VDD VDD _00749_ sky130_fd_sc_hd__o21ai_2
X_21410_ net757 _00745_ _00749_ VSS VSS VDD VDD _00750_ sky130_fd_sc_hd__a21oi_1
X_21411_ net415 _00497_ _11663_ VSS VSS VDD VDD _00751_ sky130_fd_sc_hd__a21oi_1
X_21412_ _11618_ _00498_ _00557_ VSS VSS VDD VDD _00752_ sky130_fd_sc_hd__o21ai_0
X_21413_ _12306_ net415 net414 _11684_ VSS VSS VDD VDD _00753_
+ sky130_fd_sc_hd__nor4_1
X_21414_ net418 net415 _00421_ _00753_ _11719_ VSS VSS VDD
+ VDD _00754_ sky130_fd_sc_hd__a311o_1
X_21415_ _11623_ _00752_ _00754_ VSS VSS VDD VDD _00755_ sky130_fd_sc_hd__a21oi_1
X_21416_ net419 _00751_ _00755_ VSS VSS VDD VDD _00756_ sky130_fd_sc_hd__o21ai_1
X_21417_ _12297_ _00421_ _00541_ VSS VSS VDD VDD _00757_ sky130_fd_sc_hd__a21boi_0
X_21418_ _11676_ _00498_ _00453_ VSS VSS VDD VDD _00758_ sky130_fd_sc_hd__a21o_1
X_21419_ _11628_ _00757_ _00758_ _00590_ VSS VSS VDD VDD _00759_
+ sky130_fd_sc_hd__o211ai_2
X_21420_ _11719_ _00759_ _11714_ VSS VSS VDD VDD _00760_ sky130_fd_sc_hd__a21oi_1
X_21421_ _11628_ _00577_ _11746_ VSS VSS VDD VDD _00761_ sky130_fd_sc_hd__a21oi_1
X_21422_ _12304_ net713 _00617_ _11628_ VSS VSS VDD VDD _00762_
+ sky130_fd_sc_hd__o211ai_2
X_21423_ _11628_ _00465_ _00547_ _00762_ VSS VSS VDD VDD _00763_
+ sky130_fd_sc_hd__o31ai_1
X_21424_ _11684_ _00724_ _00725_ _00429_ _11639_ VSS VSS VDD
+ VDD _00764_ sky130_fd_sc_hd__a311oi_1
X_21425_ net757 _00763_ _00764_ VSS VSS VDD VDD _00765_ sky130_fd_sc_hd__a21oi_1
X_21426_ _12292_ _11628_ _11743_ VSS VSS VDD VDD _00766_ sky130_fd_sc_hd__o21ai_0
X_21427_ net415 _11762_ _00515_ VSS VSS VDD VDD _00767_ sky130_fd_sc_hd__nor3_1
X_21428_ _00766_ _00767_ _11784_ VSS VSS VDD VDD _00768_ sky130_fd_sc_hd__o21ai_0
X_21429_ _11811_ _00761_ _00765_ net414 _00768_ VSS VSS VDD
+ VDD _00769_ sky130_fd_sc_hd__a221oi_1
X_21430_ _00756_ _00760_ _00769_ VSS VSS VDD VDD _00770_ sky130_fd_sc_hd__a21oi_1
X_21431_ _11789_ _00741_ _00750_ _11713_ _00770_ VSS VSS VDD
+ VDD _00119_ sky130_fd_sc_hd__o221ai_1
X_21432_ sa03_sr\[1\] sa32_sub\[7\] VSS VSS VDD VDD _00771_
+ sky130_fd_sc_hd__xnor2_1
X_21433_ sa10_sub\[1\] sa32_sub\[0\] VSS VSS VDD VDD _00772_
+ sky130_fd_sc_hd__xnor2_1
X_21434_ sa32_sub\[1\] sa21_sub\[0\] sa21_sub\[7\] VSS VSS
+ VDD VDD _00773_ sky130_fd_sc_hd__xnor3_1
X_21435_ _00771_ _00772_ _00773_ VSS VSS VDD VDD _00774_ sky130_fd_sc_hd__xnor3_1
X_21436_ text_in_r\[9\] _00774_ net490 VSS VSS VDD VDD _00775_
+ sky130_fd_sc_hd__mux2i_4
X_21437_ u0.tmp_w\[9\] _00775_ VSS VSS VDD VDD _00776_ sky130_fd_sc_hd__xor2_4
X_21438_ net632 VSS VSS VDD VDD _00777_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_12_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21441_ sa10_sub\[0\] sa21_sub\[7\] sa32_sub\[7\] VSS VSS
+ VDD VDD _00779_ sky130_fd_sc_hd__xnor3_1
X_21442_ _09925_ _00779_ VSS VSS VDD VDD _00780_ sky130_fd_sc_hd__xor2_1
X_21443_ net655 text_in_r\[8\] VSS VSS VDD VDD _00781_ sky130_fd_sc_hd__nand2_1
X_21444_ net656 _00780_ _00781_ VSS VSS VDD VDD _00782_ sky130_fd_sc_hd__o21a_4
X_21445_ u0.tmp_w\[8\] _00782_ VSS VSS VDD VDD _00783_ sky130_fd_sc_hd__xor2_4
X_21446_ _00783_ VSS VSS VDD VDD _00784_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_12_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21448_ sa10_sub\[2\] sa32_sub\[2\] sa03_sr\[2\] VSS VSS
+ VDD VDD _00785_ sky130_fd_sc_hd__xnor3_2
X_21449_ sa21_sub\[1\] sa32_sub\[1\] VSS VSS VDD VDD _00786_
+ sky130_fd_sc_hd__xor2_1
X_21450_ u0.tmp_w\[10\] net654 VSS VSS VDD VDD _00787_ sky130_fd_sc_hd__nor2_1
X_21451_ _00786_ _00787_ VSS VSS VDD VDD _00788_ sky130_fd_sc_hd__nand2_1
X_21452_ net654 u0.tmp_w\[10\] VSS VSS VDD VDD _00789_ sky130_fd_sc_hd__nor2b_1
X_21453_ _00786_ _00785_ _00789_ VSS VSS VDD VDD _00790_ sky130_fd_sc_hd__or3b_1
X_21454_ _00786_ _00785_ _00789_ VSS VSS VDD VDD _00791_ sky130_fd_sc_hd__nand3_1
X_21455_ _07660_ _00785_ _00787_ VSS VSS VDD VDD _00792_ sky130_fd_sc_hd__nand3_1
X_21456_ _00785_ _00788_ _00790_ _00791_ _00792_ VSS VSS VDD
+ VDD _00793_ sky130_fd_sc_hd__o2111ai_4
X_21457_ u0.tmp_w\[10\] net492 VSS VSS VDD VDD _00794_ sky130_fd_sc_hd__nand2b_1
X_21458_ u0.tmp_w\[10\] net492 text_in_r\[10\] VSS VSS VDD
+ VDD _00795_ sky130_fd_sc_hd__nand3_1
X_21459_ text_in_r\[10\] _00794_ _00795_ VSS VSS VDD VDD _00796_
+ sky130_fd_sc_hd__o21ai_2
X_21460_ _00793_ _00796_ VSS VSS VDD VDD _00797_ sky130_fd_sc_hd__nor2_8
X_21461_ _00797_ VSS VSS VDD VDD _00798_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_12_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21469_ sa21_sub\[5\] sa32_sub\[5\] sa10_sub\[6\] VSS VSS
+ VDD VDD _00803_ sky130_fd_sc_hd__xnor3_2
X_21470_ _09941_ _00803_ VSS VSS VDD VDD _00804_ sky130_fd_sc_hd__xor2_4
X_21471_ text_in_r\[14\] _00804_ net512 VSS VSS VDD VDD _00805_
+ sky130_fd_sc_hd__mux2i_4
X_21472_ u0.tmp_w\[14\] _00805_ VSS VSS VDD VDD _00806_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_11_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21475_ sa32_sub\[6\] _07670_ _09946_ VSS VSS VDD VDD _00809_
+ sky130_fd_sc_hd__xor3_4
X_21476_ text_in_r\[15\] _00809_ net512 VSS VSS VDD VDD _00810_
+ sky130_fd_sc_hd__mux2i_4
X_21477_ u0.tmp_w\[15\] _00810_ VSS VSS VDD VDD _00811_ sky130_fd_sc_hd__xnor2_4
X_21478_ _00806_ _00811_ VSS VSS VDD VDD _00812_ sky130_fd_sc_hd__nand2_2
X_21479_ sa32_sub\[4\] sa10_sub\[5\] VSS VSS VDD VDD _00813_
+ sky130_fd_sc_hd__xor2_2
X_21480_ _09953_ _00813_ VSS VSS VDD VDD _00814_ sky130_fd_sc_hd__xnor2_4
X_21481_ text_in_r\[13\] _00814_ net512 VSS VSS VDD VDD _00815_
+ sky130_fd_sc_hd__mux2i_4
X_21482_ u0.tmp_w\[13\] _00815_ VSS VSS VDD VDD _00816_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_11_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21484_ sa32_sub\[3\] sa32_sub\[7\] VSS VSS VDD VDD _00818_
+ sky130_fd_sc_hd__xnor2_1
X_21485_ sa21_sub\[3\] sa32_sub\[4\] sa21_sub\[7\] VSS VSS
+ VDD VDD _00819_ sky130_fd_sc_hd__xor3_1
X_21486_ _07701_ _00818_ _00819_ VSS VSS VDD VDD _00820_ sky130_fd_sc_hd__xnor3_4
X_21487_ text_in_r\[12\] _00820_ net512 VSS VSS VDD VDD _00821_
+ sky130_fd_sc_hd__mux2i_4
X_21488_ u0.tmp_w\[12\] _00821_ VSS VSS VDD VDD _00822_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_11_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21491_ sa03_sr\[3\] sa32_sub\[7\] VSS VSS VDD VDD _00825_
+ sky130_fd_sc_hd__xnor2_1
X_21492_ sa32_sub\[2\] sa10_sub\[3\] VSS VSS VDD VDD _00826_
+ sky130_fd_sc_hd__xnor2_1
X_21493_ _09964_ _00825_ _00826_ VSS VSS VDD VDD _00827_ sky130_fd_sc_hd__xnor3_4
X_21494_ text_in_r\[11\] net492 VSS VSS VDD VDD _00828_ sky130_fd_sc_hd__nand2b_1
X_21495_ net492 _00827_ _00828_ VSS VSS VDD VDD _00829_ sky130_fd_sc_hd__o21a_2
X_21496_ u0.tmp_w\[11\] _00829_ VSS VSS VDD VDD _00830_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_11_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21498_ _00797_ net412 VSS VSS VDD VDD _00832_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_11_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21500_ _12330_ VSS VSS VDD VDD _00834_ sky130_fd_sc_hd__clkinv_2
XTAP_TAPCELL_ROW_11_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21502_ _00834_ _12328_ _00798_ VSS VSS VDD VDD _00836_ sky130_fd_sc_hd__mux2i_4
XTAP_TAPCELL_ROW_11_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21504_ _12335_ _00832_ _00836_ net412 VSS VSS VDD VDD _00838_
+ sky130_fd_sc_hd__o22ai_1
XTAP_TAPCELL_ROW_11_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21506_ _12338_ _00797_ VSS VSS VDD VDD _00840_ sky130_fd_sc_hd__nor2_1
X_21507_ _00783_ _00798_ VSS VSS VDD VDD _00841_ sky130_fd_sc_hd__nor2_2
X_21508_ _00840_ _00841_ net412 VSS VSS VDD VDD _00842_ sky130_fd_sc_hd__o21ai_0
X_21509_ _00829_ u0.tmp_w\[11\] VSS VSS VDD VDD _00843_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_11_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21511_ _00777_ _00797_ VSS VSS VDD VDD _00845_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_11_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21513_ _12329_ _00798_ VSS VSS VDD VDD _00847_ sky130_fd_sc_hd__nand2_1
X_21514_ net409 _00845_ _00847_ net413 VSS VSS VDD VDD _00848_
+ sky130_fd_sc_hd__a31oi_4
X_21515_ _00822_ _00838_ _00842_ _00848_ VSS VSS VDD VDD _00849_
+ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_11_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21519_ _12329_ VSS VSS VDD VDD _00853_ sky130_fd_sc_hd__clkinv_4
X_21520_ _00853_ _00822_ VSS VSS VDD VDD _00854_ sky130_fd_sc_hd__nand2_1
X_21521_ u0.tmp_w\[12\] _00821_ VSS VSS VDD VDD _00855_ sky130_fd_sc_hd__xor2_4
X_21522_ _12342_ _00855_ VSS VSS VDD VDD _00856_ sky130_fd_sc_hd__nand2_1
X_21523_ _00855_ net412 VSS VSS VDD VDD _00857_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_11_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21525_ net412 _00854_ _00856_ _00857_ _12340_ VSS VSS VDD
+ VDD _00859_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_11_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21528_ _00784_ net410 VSS VSS VDD VDD _00862_ sky130_fd_sc_hd__nor2_4
X_21529_ _00855_ _00862_ VSS VSS VDD VDD _00863_ sky130_fd_sc_hd__nand2_1
X_21530_ _12335_ net412 VSS VSS VDD VDD _00864_ sky130_fd_sc_hd__nor2_2
X_21531_ net553 _00864_ VSS VSS VDD VDD _00865_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_10_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21533_ net553 _00859_ _00863_ _00865_ _00816_ VSS VSS VDD
+ VDD _00867_ sky130_fd_sc_hd__a221oi_1
X_21534_ _00816_ _00849_ _00867_ VSS VSS VDD VDD _00868_ sky130_fd_sc_hd__a21oi_1
X_21535_ _00812_ _00868_ VSS VSS VDD VDD _00869_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_10_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21537_ _00784_ net412 VSS VSS VDD VDD _00871_ sky130_fd_sc_hd__nand2_8
X_21538_ _12330_ net410 VSS VSS VDD VDD _00872_ sky130_fd_sc_hd__nand2_1
X_21539_ _00871_ _00872_ net666 VSS VSS VDD VDD _00873_ sky130_fd_sc_hd__a21oi_1
X_21540_ _12328_ _00832_ VSS VSS VDD VDD _00874_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_10_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21542_ _12335_ _00798_ VSS VSS VDD VDD _00876_ sky130_fd_sc_hd__nand2b_2
X_21543_ _12333_ _00797_ VSS VSS VDD VDD _00877_ sky130_fd_sc_hd__nand2_1
X_21544_ net409 _00876_ _00877_ net413 VSS VSS VDD VDD _00878_
+ sky130_fd_sc_hd__a31oi_4
X_21545_ _00873_ _00874_ _00878_ VSS VSS VDD VDD _00879_ sky130_fd_sc_hd__nor3b_1
X_21546_ _00797_ net411 VSS VSS VDD VDD _00880_ sky130_fd_sc_hd__nor2_4
X_21547_ _12351_ net667 _00880_ _12329_ _00855_ VSS VSS VDD
+ VDD _00881_ sky130_fd_sc_hd__a221oi_2
XTAP_TAPCELL_ROW_10_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21550_ _12340_ net412 VSS VSS VDD VDD _00884_ sky130_fd_sc_hd__nand2_4
X_21551_ net666 _00884_ VSS VSS VDD VDD _00885_ sky130_fd_sc_hd__nor2_1
X_21552_ net492 text_in_r\[11\] VSS VSS VDD VDD _00886_ sky130_fd_sc_hd__and2_0
X_21553_ net512 _00827_ _00886_ u0.tmp_w\[11\] VSS VSS VDD
+ VDD _00887_ sky130_fd_sc_hd__a211oi_1
X_21554_ net492 _00827_ _00828_ u0.tmp_w\[11\] VSS VSS VDD
+ VDD _00888_ sky130_fd_sc_hd__o211ai_2
X_21555_ _00887_ _12333_ _00888_ VSS VSS VDD VDD _00889_ sky130_fd_sc_hd__nand3b_4
X_21556_ _12330_ net411 _00889_ VSS VSS VDD VDD _00890_ sky130_fd_sc_hd__o21ai_0
X_21557_ _00798_ _00890_ VSS VSS VDD VDD _00891_ sky130_fd_sc_hd__nor2_1
X_21558_ _00798_ net672 VSS VSS VDD VDD _00892_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_10_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21560_ _12333_ net409 VSS VSS VDD VDD _00894_ sky130_fd_sc_hd__nand2_2
X_21561_ _00834_ _00830_ VSS VSS VDD VDD _00895_ sky130_fd_sc_hd__nand2_1
X_21562_ _00797_ _00894_ _00895_ _00855_ VSS VSS VDD VDD _00896_
+ sky130_fd_sc_hd__a31oi_4
X_21563_ _12338_ _00892_ _00896_ VSS VSS VDD VDD _00897_ sky130_fd_sc_hd__o21ai_0
X_21564_ net413 _00885_ _00891_ _00897_ _00816_ VSS VSS VDD
+ VDD _00898_ sky130_fd_sc_hd__o311ai_2
X_21565_ u0.tmp_w\[15\] _00810_ VSS VSS VDD VDD _00899_ sky130_fd_sc_hd__xor2_4
X_21566_ _00806_ _00899_ VSS VSS VDD VDD _00900_ sky130_fd_sc_hd__nor2_4
X_21567_ _00816_ _00879_ _00881_ _00898_ _00900_ VSS VSS VDD
+ VDD _00901_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_10_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21569_ u0.tmp_w\[13\] _00815_ VSS VSS VDD VDD _00903_ sky130_fd_sc_hd__xor2_4
X_21570_ _00784_ _00903_ net666 VSS VSS VDD VDD _00904_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_10_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21572_ _00783_ _00797_ VSS VSS VDD VDD _00905_ sky130_fd_sc_hd__nor2_2
X_21573_ _00853_ _00798_ _00816_ VSS VSS VDD VDD _00906_ sky130_fd_sc_hd__nor3_1
X_21574_ _00777_ _00904_ _00905_ _00816_ _00906_ VSS VSS VDD
+ VDD _00907_ sky130_fd_sc_hd__a221oi_1
X_21575_ _12329_ net666 _00816_ VSS VSS VDD VDD _00908_ sky130_fd_sc_hd__nor3_1
X_21576_ net667 _00908_ VSS VSS VDD VDD _00909_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21578_ _00784_ _00797_ VSS VSS VDD VDD _00911_ sky130_fd_sc_hd__nand2_4
X_21579_ net500 _00783_ VSS VSS VDD VDD _00912_ sky130_fd_sc_hd__nand2_1
X_21580_ _00911_ _00912_ VSS VSS VDD VDD _00913_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21582_ _00816_ net667 _00913_ _00855_ VSS VSS VDD VDD _00915_
+ sky130_fd_sc_hd__a31oi_2
X_21583_ net667 _00907_ _00909_ _00915_ VSS VSS VDD VDD _00916_
+ sky130_fd_sc_hd__o211ai_1
X_21584_ _00798_ net412 VSS VSS VDD VDD _00917_ sky130_fd_sc_hd__nor2_4
X_21585_ _00797_ net672 VSS VSS VDD VDD _00918_ sky130_fd_sc_hd__nor2_2
X_21586_ _00917_ _00918_ VSS VSS VDD VDD _00919_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_10_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21589_ _00853_ net672 VSS VSS VDD VDD _00922_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_10_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21591_ _00903_ _00855_ VSS VSS VDD VDD _00924_ sky130_fd_sc_hd__nand2_4
X_21592_ net553 _00922_ _00924_ VSS VSS VDD VDD _00925_ sky130_fd_sc_hd__a21oi_1
X_21593_ _12338_ _00892_ _00919_ _12328_ _00925_ VSS VSS VDD
+ VDD _00926_ sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_10_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21596_ _12338_ net410 VSS VSS VDD VDD _00929_ sky130_fd_sc_hd__nor2_1
X_21597_ _00853_ _00830_ VSS VSS VDD VDD _00930_ sky130_fd_sc_hd__nor2_1
X_21598_ _00798_ _00929_ _00930_ VSS VSS VDD VDD _00931_ sky130_fd_sc_hd__nor3_1
X_21599_ _12328_ net410 VSS VSS VDD VDD _00932_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_10_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21601_ _12342_ _00830_ VSS VSS VDD VDD _00934_ sky130_fd_sc_hd__nor2_1
X_21602_ net553 _00932_ _00934_ VSS VSS VDD VDD _00935_ sky130_fd_sc_hd__nor3_1
X_21603_ _00903_ net413 VSS VSS VDD VDD _00936_ sky130_fd_sc_hd__nor2_4
X_21604_ _00931_ _00935_ _00936_ VSS VSS VDD VDD _00937_ sky130_fd_sc_hd__o21ai_0
X_21605_ u0.tmp_w\[14\] _00805_ VSS VSS VDD VDD _00938_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_10_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21607_ _00938_ _00899_ VSS VSS VDD VDD _00940_ sky130_fd_sc_hd__nand2_4
X_21608_ _00916_ _00926_ _00937_ _00940_ VSS VSS VDD VDD _00941_
+ sky130_fd_sc_hd__a31oi_1
X_21609_ _00777_ net410 VSS VSS VDD VDD _00942_ sky130_fd_sc_hd__nand2_4
X_21610_ _00816_ _00855_ VSS VSS VDD VDD _00943_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_10_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21612_ _12344_ net411 VSS VSS VDD VDD _00945_ sky130_fd_sc_hd__nand2_2
X_21613_ net553 _00942_ _00943_ _00945_ VSS VSS VDD VDD _00946_
+ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_10_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21615_ _00816_ net413 VSS VSS VDD VDD _00948_ sky130_fd_sc_hd__nor2_1
X_21616_ _12330_ _00798_ VSS VSS VDD VDD _00949_ sky130_fd_sc_hd__nor2_1
X_21617_ _00777_ _00798_ VSS VSS VDD VDD _00950_ sky130_fd_sc_hd__nand2_1
X_21618_ _00950_ VSS VSS VDD VDD _00951_ sky130_fd_sc_hd__inv_1
X_21619_ net412 _00949_ _00951_ VSS VSS VDD VDD _00952_ sky130_fd_sc_hd__or3_1
X_21620_ _12342_ _00798_ VSS VSS VDD VDD _00953_ sky130_fd_sc_hd__nor2_1
X_21621_ _00905_ _00953_ net667 VSS VSS VDD VDD _00954_ sky130_fd_sc_hd__o21ai_2
X_21622_ _00948_ _00952_ _00954_ VSS VSS VDD VDD _00955_ sky130_fd_sc_hd__nand3_1
X_21623_ _00784_ _00892_ VSS VSS VDD VDD _00956_ sky130_fd_sc_hd__nor2_2
X_21624_ _12335_ _00832_ _00889_ net553 VSS VSS VDD VDD _00957_
+ sky130_fd_sc_hd__o22ai_1
X_21625_ _00956_ _00957_ _00936_ VSS VSS VDD VDD _00958_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_10_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21627_ _12333_ net410 VSS VSS VDD VDD _00960_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_10_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21629_ _00783_ net409 VSS VSS VDD VDD _00962_ sky130_fd_sc_hd__nor2_1
X_21630_ _00903_ net413 VSS VSS VDD VDD _00963_ sky130_fd_sc_hd__nand2_2
X_21631_ _12329_ net411 VSS VSS VDD VDD _00964_ sky130_fd_sc_hd__nand2_4
X_21632_ _00784_ net410 VSS VSS VDD VDD _00965_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_10_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21634_ _00964_ _00965_ _00798_ VSS VSS VDD VDD _00967_ sky130_fd_sc_hd__a21oi_1
X_21635_ _12344_ _00798_ VSS VSS VDD VDD _00968_ sky130_fd_sc_hd__nand2_1
X_21636_ _00903_ _00855_ VSS VSS VDD VDD _00969_ sky130_fd_sc_hd__nor2_2
X_21637_ net410 _00968_ _00969_ VSS VSS VDD VDD _00970_ sky130_fd_sc_hd__o21ai_0
X_21638_ net553 _00962_ _00963_ _00967_ _00970_ VSS VSS VDD
+ VDD _00971_ sky130_fd_sc_hd__o32ai_1
X_21639_ net553 _00960_ _00971_ VSS VSS VDD VDD _00972_ sky130_fd_sc_hd__o21ai_2
X_21640_ _00806_ _00899_ VSS VSS VDD VDD _00973_ sky130_fd_sc_hd__nand2_1
X_21641_ _00946_ _00955_ _00958_ _00972_ _00973_ VSS VSS VDD
+ VDD _00974_ sky130_fd_sc_hd__a41oi_1
X_21642_ _00869_ _00901_ _00941_ _00974_ VSS VSS VDD VDD _00120_
+ sky130_fd_sc_hd__nor4_1
X_21643_ _00783_ net411 VSS VSS VDD VDD _00975_ sky130_fd_sc_hd__nor2_4
X_21644_ _12342_ net410 VSS VSS VDD VDD _00976_ sky130_fd_sc_hd__nor2_1
X_21645_ _00975_ _00976_ net553 VSS VSS VDD VDD _00977_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_10_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21647_ _12328_ net410 VSS VSS VDD VDD _00979_ sky130_fd_sc_hd__nand2_4
X_21648_ _00798_ _00979_ _00889_ VSS VSS VDD VDD _00980_ sky130_fd_sc_hd__nand3_1
X_21649_ _00816_ _00822_ VSS VSS VDD VDD _00981_ sky130_fd_sc_hd__nand2_4
X_21650_ _00977_ _00980_ _00981_ VSS VSS VDD VDD _00982_ sky130_fd_sc_hd__a21oi_1
X_21651_ _12335_ _00830_ VSS VSS VDD VDD _00983_ sky130_fd_sc_hd__nand2b_1
X_21652_ _00983_ _00965_ _00798_ VSS VSS VDD VDD _00984_ sky130_fd_sc_hd__a21oi_1
X_21653_ net635 _00830_ VSS VSS VDD VDD _00985_ sky130_fd_sc_hd__nand2_1
X_21654_ _00942_ _00985_ net553 VSS VSS VDD VDD _00986_ sky130_fd_sc_hd__a21oi_4
X_21655_ _00963_ _00984_ _00986_ VSS VSS VDD VDD _00987_ sky130_fd_sc_hd__nor3_1
X_21656_ _00840_ _00953_ net410 VSS VSS VDD VDD _00988_ sky130_fd_sc_hd__o21ai_1
X_21657_ _12354_ _00816_ net410 _00988_ VSS VSS VDD VDD _00989_
+ sky130_fd_sc_hd__o31ai_1
X_21658_ _00855_ _00989_ _00940_ VSS VSS VDD VDD _00990_ sky130_fd_sc_hd__a21o_1
X_21659_ _00806_ _00899_ _00903_ VSS VSS VDD VDD _00991_ sky130_fd_sc_hd__nand3_1
X_21660_ _00853_ net412 VSS VSS VDD VDD _00992_ sky130_fd_sc_hd__nand2_8
X_21661_ _12344_ net672 VSS VSS VDD VDD _00993_ sky130_fd_sc_hd__nand2_1
X_21662_ _00834_ net672 VSS VSS VDD VDD _00994_ sky130_fd_sc_hd__nand2_1
X_21663_ _12342_ net412 VSS VSS VDD VDD _00995_ sky130_fd_sc_hd__nand2_2
X_21664_ _00994_ _00995_ _00797_ VSS VSS VDD VDD _00996_ sky130_fd_sc_hd__a21oi_1
X_21665_ net666 _00992_ _00993_ _00996_ _00855_ VSS VSS VDD
+ VDD _00997_ sky130_fd_sc_hd__a311oi_2
X_21666_ _12342_ net671 VSS VSS VDD VDD _00998_ sky130_fd_sc_hd__nand2_2
X_21667_ _00992_ _00998_ _00798_ VSS VSS VDD VDD _00999_ sky130_fd_sc_hd__a21oi_1
X_21668_ _00822_ _00956_ _00999_ VSS VSS VDD VDD _01000_ sky130_fd_sc_hd__nor3_1
X_21669_ _00991_ _00997_ _01000_ VSS VSS VDD VDD _01001_ sky130_fd_sc_hd__or3_1
X_21670_ _00982_ _00987_ _00990_ _01001_ VSS VSS VDD VDD _01002_
+ sky130_fd_sc_hd__o31ai_1
X_21671_ _00784_ _00919_ VSS VSS VDD VDD _01003_ sky130_fd_sc_hd__nor2_1
X_21672_ _00853_ _00892_ _00871_ _00777_ VSS VSS VDD VDD _01004_
+ sky130_fd_sc_hd__o22ai_1
X_21673_ _01003_ _01004_ _00855_ VSS VSS VDD VDD _01005_ sky130_fd_sc_hd__o21ai_1
X_21674_ net666 _00979_ _00964_ VSS VSS VDD VDD _01006_ sky130_fd_sc_hd__nand3_1
X_21675_ _12335_ net411 VSS VSS VDD VDD _01007_ sky130_fd_sc_hd__nand2_1
X_21676_ _00965_ _01007_ net553 VSS VSS VDD VDD _01008_ sky130_fd_sc_hd__a21oi_2
X_21677_ _00855_ _01008_ VSS VSS VDD VDD _01009_ sky130_fd_sc_hd__nor2_1
X_21678_ _01006_ _01009_ _00816_ VSS VSS VDD VDD _01010_ sky130_fd_sc_hd__a21oi_1
X_21679_ _12344_ _00918_ VSS VSS VDD VDD _01011_ sky130_fd_sc_hd__nand2_1
X_21680_ net636 net410 VSS VSS VDD VDD _01012_ sky130_fd_sc_hd__nor2_1
X_21681_ _00934_ _01012_ net666 VSS VSS VDD VDD _01013_ sky130_fd_sc_hd__o21ai_1
X_21682_ _12329_ _00798_ net672 VSS VSS VDD VDD _01014_ sky130_fd_sc_hd__nor3_2
X_21683_ _00798_ _00830_ VSS VSS VDD VDD _01015_ sky130_fd_sc_hd__nand2_1
X_21684_ _12335_ _00797_ VSS VSS VDD VDD _01016_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21686_ _12342_ _01015_ _01016_ _00830_ VSS VSS VDD VDD _01018_
+ sky130_fd_sc_hd__o22ai_1
X_21687_ net413 _01014_ _01018_ VSS VSS VDD VDD _01019_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_9_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21689_ net413 _01011_ _01013_ _01019_ _00903_ VSS VSS VDD
+ VDD _01021_ sky130_fd_sc_hd__a311oi_4
X_21690_ _01005_ _01010_ _01021_ _00812_ VSS VSS VDD VDD _01022_
+ sky130_fd_sc_hd__a211oi_1
X_21691_ _12344_ _00797_ VSS VSS VDD VDD _01023_ sky130_fd_sc_hd__nand2_1
X_21692_ _00847_ _01023_ net409 VSS VSS VDD VDD _01024_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_9_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21694_ _12358_ net409 net413 VSS VSS VDD VDD _01026_ sky130_fd_sc_hd__o21ai_0
X_21695_ net409 _00845_ _00876_ _01026_ VSS VSS VDD VDD _01027_
+ sky130_fd_sc_hd__a31oi_1
X_21696_ _00878_ _01024_ _01027_ VSS VSS VDD VDD _01028_ sky130_fd_sc_hd__a21oi_1
X_21697_ net500 net412 VSS VSS VDD VDD _01029_ sky130_fd_sc_hd__nor2_4
X_21698_ _12333_ net410 VSS VSS VDD VDD _01030_ sky130_fd_sc_hd__nor2_1
X_21699_ _01029_ _01030_ _00798_ VSS VSS VDD VDD _01031_ sky130_fd_sc_hd__o21ai_1
X_21700_ _00777_ _00965_ _01031_ _00936_ VSS VSS VDD VDD _01032_
+ sky130_fd_sc_hd__o211ai_1
X_21701_ _12335_ net410 VSS VSS VDD VDD _01033_ sky130_fd_sc_hd__nand2_1
X_21702_ net553 _00964_ _01033_ VSS VSS VDD VDD _01034_ sky130_fd_sc_hd__nand3_1
X_21703_ _00862_ _00975_ _00798_ VSS VSS VDD VDD _01035_ sky130_fd_sc_hd__o21ai_0
X_21704_ _01034_ _01035_ _00981_ VSS VSS VDD VDD _01036_ sky130_fd_sc_hd__a21o_1
X_21705_ _00816_ _01028_ _01032_ _01036_ VSS VSS VDD VDD _01037_
+ sky130_fd_sc_hd__o211ai_2
X_21706_ _00938_ _00811_ VSS VSS VDD VDD _01038_ sky130_fd_sc_hd__nor2_2
X_21707_ _00816_ _01038_ VSS VSS VDD VDD _01039_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_9_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21709_ _00979_ _00985_ net553 VSS VSS VDD VDD _01041_ sky130_fd_sc_hd__a21oi_1
X_21710_ _12330_ _00830_ VSS VSS VDD VDD _01042_ sky130_fd_sc_hd__nor2_1
X_21711_ _12328_ net667 _01042_ VSS VSS VDD VDD _01043_ sky130_fd_sc_hd__a21oi_1
X_21712_ _00798_ _00964_ _00965_ VSS VSS VDD VDD _01044_ sky130_fd_sc_hd__nand3_1
X_21713_ _00798_ _01043_ _01044_ net413 VSS VSS VDD VDD _01045_
+ sky130_fd_sc_hd__o211ai_1
X_21714_ net413 _00984_ _01041_ _01045_ VSS VSS VDD VDD _01046_
+ sky130_fd_sc_hd__o31ai_1
X_21715_ _00900_ _01037_ _01039_ _01046_ VSS VSS VDD VDD _01047_
+ sky130_fd_sc_hd__o2bb2ai_1
X_21716_ _01002_ _01022_ _01047_ VSS VSS VDD VDD _00121_ sky130_fd_sc_hd__nor3_1
X_21717_ _00777_ net411 VSS VSS VDD VDD _01048_ sky130_fd_sc_hd__nand2_8
X_21718_ _12340_ net409 VSS VSS VDD VDD _01049_ sky130_fd_sc_hd__nand2_2
X_21719_ net666 _01048_ _01049_ VSS VSS VDD VDD _01050_ sky130_fd_sc_hd__nand3_1
X_21720_ _00876_ _01050_ VSS VSS VDD VDD _01051_ sky130_fd_sc_hd__nand2_1
X_21721_ _00992_ _01049_ net553 VSS VSS VDD VDD _01052_ sky130_fd_sc_hd__a21oi_1
X_21722_ _00967_ _01052_ _00816_ VSS VSS VDD VDD _01053_ sky130_fd_sc_hd__o21ai_0
X_21723_ _00816_ _01051_ _01053_ VSS VSS VDD VDD _01054_ sky130_fd_sc_hd__o21ai_0
X_21724_ _00871_ _01049_ _00798_ VSS VSS VDD VDD _01055_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_9_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_21726_ _12335_ net409 VSS VSS VDD VDD _01057_ sky130_fd_sc_hd__nor2_1
X_21727_ _12344_ net411 _00798_ VSS VSS VDD VDD _01058_ sky130_fd_sc_hd__o21ai_2
X_21728_ _01057_ _01058_ _00943_ VSS VSS VDD VDD _01059_ sky130_fd_sc_hd__o21ai_0
X_21729_ _01055_ _01059_ VSS VSS VDD VDD _01060_ sky130_fd_sc_hd__nor2_1
X_21730_ _00884_ _00965_ _00798_ VSS VSS VDD VDD _01061_ sky130_fd_sc_hd__a21oi_1
X_21731_ _01012_ _01058_ _00969_ VSS VSS VDD VDD _01062_ sky130_fd_sc_hd__o21ai_0
X_21732_ _01061_ _01062_ _01038_ VSS VSS VDD VDD _01063_ sky130_fd_sc_hd__o21ai_0
X_21733_ _01060_ _01063_ VSS VSS VDD VDD _01064_ sky130_fd_sc_hd__nor2_1
X_21734_ _00822_ _01054_ _01064_ VSS VSS VDD VDD _01065_ sky130_fd_sc_hd__o21ai_1
X_21735_ net553 _00979_ _00992_ _00918_ _12335_ VSS VSS VDD
+ VDD _01066_ sky130_fd_sc_hd__a32oi_1
X_21736_ _12330_ _12335_ net410 VSS VSS VDD VDD _01067_ sky130_fd_sc_hd__nor3_4
X_21737_ _12338_ _00880_ _01067_ net553 VSS VSS VDD VDD _01068_
+ sky130_fd_sc_hd__a22oi_1
X_21738_ _00917_ _00918_ _12342_ VSS VSS VDD VDD _01069_ sky130_fd_sc_hd__o21ai_0
X_21739_ net413 _01068_ _01069_ VSS VSS VDD VDD _01070_ sky130_fd_sc_hd__nand3_1
X_21740_ net413 _01066_ _01070_ _00816_ VSS VSS VDD VDD _01071_
+ sky130_fd_sc_hd__o211ai_1
X_21741_ _12333_ _00798_ net409 VSS VSS VDD VDD _01072_ sky130_fd_sc_hd__a21oi_1
X_21742_ _12360_ net409 _00845_ _01072_ _00855_ VSS VSS VDD
+ VDD _01073_ sky130_fd_sc_hd__a221oi_1
X_21743_ _12349_ net411 VSS VSS VDD VDD _01074_ sky130_fd_sc_hd__nand2_1
X_21744_ _12333_ _00880_ VSS VSS VDD VDD _01075_ sky130_fd_sc_hd__nand2_1
X_21745_ _01074_ _01075_ net413 VSS VSS VDD VDD _01076_ sky130_fd_sc_hd__a21oi_1
X_21746_ _01073_ _01076_ _00903_ VSS VSS VDD VDD _01077_ sky130_fd_sc_hd__o21ai_0
X_21747_ _00900_ _01071_ _01077_ VSS VSS VDD VDD _01078_ sky130_fd_sc_hd__nand3_1
X_21748_ _00798_ _00979_ _00992_ VSS VSS VDD VDD _01079_ sky130_fd_sc_hd__nand3_1
X_21749_ _00929_ _01029_ net553 VSS VSS VDD VDD _01080_ sky130_fd_sc_hd__o21ai_0
X_21750_ _00943_ _01079_ _01080_ _00812_ VSS VSS VDD VDD _01081_
+ sky130_fd_sc_hd__a31oi_2
X_21751_ _12329_ _00797_ VSS VSS VDD VDD _01082_ sky130_fd_sc_hd__nor2_1
X_21752_ _01082_ net409 _00877_ VSS VSS VDD VDD _01083_ sky130_fd_sc_hd__nor3b_1
X_21753_ _12351_ net409 _01083_ VSS VSS VDD VDD _01084_ sky130_fd_sc_hd__a21oi_1
X_21754_ _12354_ net667 VSS VSS VDD VDD _01085_ sky130_fd_sc_hd__nor2_1
X_21755_ net667 _00845_ _00912_ _01085_ VSS VSS VDD VDD _01086_
+ sky130_fd_sc_hd__a31oi_1
X_21756_ _00777_ net553 _00871_ VSS VSS VDD VDD _01087_ sky130_fd_sc_hd__nand3_1
X_21757_ net500 net667 _00911_ VSS VSS VDD VDD _01088_ sky130_fd_sc_hd__nand3_1
X_21758_ net500 _00798_ VSS VSS VDD VDD _01089_ sky130_fd_sc_hd__nand2_1
X_21759_ _00942_ _01089_ _00853_ VSS VSS VDD VDD _01090_ sky130_fd_sc_hd__a21o_1
X_21760_ _01087_ _01088_ _01090_ _00981_ VSS VSS VDD VDD _01091_
+ sky130_fd_sc_hd__a31oi_1
X_21761_ _00936_ _01084_ _01086_ _00948_ _01091_ VSS VSS VDD
+ VDD _01092_ sky130_fd_sc_hd__a221oi_1
X_21762_ _01081_ _01092_ VSS VSS VDD VDD _01093_ sky130_fd_sc_hd__nand2_1
X_21763_ _12344_ _00830_ _00889_ VSS VSS VDD VDD _01094_ sky130_fd_sc_hd__o21ai_0
X_21764_ _00798_ _00864_ _01012_ VSS VSS VDD VDD _01095_ sky130_fd_sc_hd__or3_1
X_21765_ net666 _01094_ _01095_ VSS VSS VDD VDD _01096_ sky130_fd_sc_hd__o21ai_0
X_21766_ _00876_ _00877_ VSS VSS VDD VDD _01097_ sky130_fd_sc_hd__nand2_1
X_21767_ net411 _01097_ VSS VSS VDD VDD _01098_ sky130_fd_sc_hd__nand2_1
X_21768_ net413 _01096_ _01098_ _00848_ VSS VSS VDD VDD _01099_
+ sky130_fd_sc_hd__a22o_1
X_21769_ _12344_ _00832_ _00995_ net553 _01075_ VSS VSS VDD
+ VDD _01100_ sky130_fd_sc_hd__o221ai_1
X_21770_ _12329_ net409 VSS VSS VDD VDD _01101_ sky130_fd_sc_hd__nand2_8
X_21771_ _00871_ _01101_ _00798_ VSS VSS VDD VDD _01102_ sky130_fd_sc_hd__a21oi_1
X_21772_ _00798_ _00895_ _00942_ _00981_ _01102_ VSS VSS VDD
+ VDD _01103_ sky130_fd_sc_hd__a311oi_1
X_21773_ _00936_ _01100_ _01103_ _00940_ VSS VSS VDD VDD _01104_
+ sky130_fd_sc_hd__a211oi_1
X_21774_ _00816_ _01099_ _01104_ VSS VSS VDD VDD _01105_ sky130_fd_sc_hd__o21ai_0
X_21775_ _01065_ _01078_ _01093_ _01105_ VSS VSS VDD VDD _00122_
+ sky130_fd_sc_hd__nand4_1
X_21776_ _12329_ _00798_ VSS VSS VDD VDD _01106_ sky130_fd_sc_hd__nor2_1
X_21777_ _00806_ _00822_ VSS VSS VDD VDD _01107_ sky130_fd_sc_hd__nand2_2
X_21778_ _00777_ _00862_ _01106_ net409 _01107_ VSS VSS VDD
+ VDD _01108_ sky130_fd_sc_hd__a221oi_1
X_21779_ _12338_ net411 VSS VSS VDD VDD _01109_ sky130_fd_sc_hd__nor2_1
X_21780_ _00962_ _01109_ _00798_ VSS VSS VDD VDD _01110_ sky130_fd_sc_hd__o21ai_0
X_21781_ _01108_ _01110_ VSS VSS VDD VDD _01111_ sky130_fd_sc_hd__nand2_1
X_21782_ _00798_ _00932_ _01109_ VSS VSS VDD VDD _01112_ sky130_fd_sc_hd__nor3_1
X_21783_ _00798_ _00992_ _00965_ _01112_ VSS VSS VDD VDD _01113_
+ sky130_fd_sc_hd__a31oi_1
X_21784_ _00806_ _00855_ _01113_ VSS VSS VDD VDD _01114_ sky130_fd_sc_hd__or3_1
X_21785_ _00806_ _00822_ VSS VSS VDD VDD _01115_ sky130_fd_sc_hd__nor2_1
X_21786_ _12329_ net411 _00945_ VSS VSS VDD VDD _01116_ sky130_fd_sc_hd__o21ai_0
X_21787_ _00798_ _00942_ _01007_ VSS VSS VDD VDD _01117_ sky130_fd_sc_hd__nand3_1
X_21788_ _00798_ _01116_ _01117_ VSS VSS VDD VDD _01118_ sky130_fd_sc_hd__o21ai_1
X_21789_ _00938_ _00822_ VSS VSS VDD VDD _01119_ sky130_fd_sc_hd__nor2_2
X_21790_ _00798_ _01101_ VSS VSS VDD VDD _01120_ sky130_fd_sc_hd__nand2_1
X_21791_ _00798_ _00929_ _00934_ _01030_ _01120_ VSS VSS VDD
+ VDD _01121_ sky130_fd_sc_hd__o32ai_2
X_21792_ _01115_ _01118_ _01119_ _01121_ VSS VSS VDD VDD _01122_
+ sky130_fd_sc_hd__a22oi_1
X_21793_ _00811_ _00816_ VSS VSS VDD VDD _01123_ sky130_fd_sc_hd__nand2_1
X_21794_ _01111_ _01114_ _01122_ _01123_ VSS VSS VDD VDD _01124_
+ sky130_fd_sc_hd__a31oi_2
X_21795_ _00797_ _00862_ VSS VSS VDD VDD _01125_ sky130_fd_sc_hd__nor2_2
X_21796_ net553 _00884_ _01101_ _00993_ _01125_ VSS VSS VDD
+ VDD _01126_ sky130_fd_sc_hd__a32o_1
X_21797_ _00777_ net412 VSS VSS VDD VDD _01127_ sky130_fd_sc_hd__nor2_1
X_21798_ _00798_ _01127_ _00784_ VSS VSS VDD VDD _01128_ sky130_fd_sc_hd__o21ai_1
X_21799_ _00798_ _01029_ _00874_ _00822_ VSS VSS VDD VDD _01129_
+ sky130_fd_sc_hd__a211oi_1
X_21800_ _00822_ _01126_ _01128_ _01129_ _00903_ VSS VSS VDD
+ VDD _01130_ sky130_fd_sc_hd__a221oi_2
X_21801_ _12342_ _00917_ _01067_ _00797_ VSS VSS VDD VDD _01131_
+ sky130_fd_sc_hd__a22oi_1
X_21802_ _12340_ _01015_ _00880_ _12338_ VSS VSS VDD VDD _01132_
+ sky130_fd_sc_hd__a2bb2oi_1
X_21803_ _01131_ _01132_ net413 VSS VSS VDD VDD _01133_ sky130_fd_sc_hd__a21oi_1
X_21804_ _00911_ _00857_ _00968_ _01133_ _00816_ VSS VSS VDD
+ VDD _01134_ sky130_fd_sc_hd__a311oi_1
X_21805_ _00973_ _01130_ _01134_ VSS VSS VDD VDD _01135_ sky130_fd_sc_hd__nor3_1
X_21806_ _00811_ _00903_ VSS VSS VDD VDD _01136_ sky130_fd_sc_hd__nand2_1
X_21807_ _00853_ net410 _00798_ VSS VSS VDD VDD _01137_ sky130_fd_sc_hd__a21oi_2
X_21808_ _00798_ _00945_ _01049_ _01137_ _01048_ VSS VSS VDD
+ VDD _01138_ sky130_fd_sc_hd__a32oi_4
X_21809_ net672 _00841_ VSS VSS VDD VDD _01139_ sky130_fd_sc_hd__nand2_1
X_21810_ _00777_ _00783_ net410 VSS VSS VDD VDD _01140_ sky130_fd_sc_hd__nand3_1
X_21811_ net666 _00889_ _01139_ _01140_ VSS VSS VDD VDD _01141_
+ sky130_fd_sc_hd__o211ai_1
X_21812_ _01107_ _01138_ _01119_ _01141_ VSS VSS VDD VDD _01142_
+ sky130_fd_sc_hd__a2bb2oi_1
X_21813_ net637 _00855_ VSS VSS VDD VDD _01143_ sky130_fd_sc_hd__nand2_1
X_21814_ _00797_ _00855_ VSS VSS VDD VDD _01144_ sky130_fd_sc_hd__nor2_1
X_21815_ _00798_ _00822_ VSS VSS VDD VDD _01145_ sky130_fd_sc_hd__nor2_1
X_21816_ _01144_ _01145_ VSS VSS VDD VDD _01146_ sky130_fd_sc_hd__nor2_1
X_21817_ net553 _01143_ _01146_ _12329_ net412 VSS VSS VDD
+ VDD _01147_ sky130_fd_sc_hd__o221ai_1
X_21818_ _00806_ _01136_ VSS VSS VDD VDD _01148_ sky130_fd_sc_hd__nor2_1
X_21819_ _00784_ _00822_ VSS VSS VDD VDD _01149_ sky130_fd_sc_hd__nor2_1
X_21820_ _00841_ _01143_ _01149_ _00950_ VSS VSS VDD VDD _01150_
+ sky130_fd_sc_hd__o22ai_1
X_21821_ _00822_ _00841_ _01150_ net672 VSS VSS VDD VDD _01151_
+ sky130_fd_sc_hd__a22oi_1
X_21822_ _01147_ _01148_ _01151_ VSS VSS VDD VDD _01152_ sky130_fd_sc_hd__nand3_1
X_21823_ _01136_ _01142_ _01152_ VSS VSS VDD VDD _01153_ sky130_fd_sc_hd__o21ai_0
X_21824_ _12330_ net666 _00908_ VSS VSS VDD VDD _01154_ sky130_fd_sc_hd__a21oi_1
X_21825_ _00777_ _00903_ VSS VSS VDD VDD _01155_ sky130_fd_sc_hd__nand2_1
X_21826_ _00853_ _00903_ _01155_ net666 VSS VSS VDD VDD _01156_
+ sky130_fd_sc_hd__o211ai_1
X_21827_ _00903_ _00840_ net412 VSS VSS VDD VDD _01157_ sky130_fd_sc_hd__a21oi_1
X_21828_ net412 _01154_ _01156_ _01157_ _00855_ VSS VSS VDD
+ VDD _01158_ sky130_fd_sc_hd__a221oi_2
X_21829_ _12340_ _00919_ VSS VSS VDD VDD _01159_ sky130_fd_sc_hd__nand2_1
X_21830_ _00816_ _00855_ VSS VSS VDD VDD _01160_ sky130_fd_sc_hd__nand2_2
X_21831_ _01139_ _01159_ _01160_ VSS VSS VDD VDD _01161_ sky130_fd_sc_hd__a21oi_1
X_21832_ net410 _00905_ VSS VSS VDD VDD _01162_ sky130_fd_sc_hd__nand2_1
X_21833_ _01067_ _01137_ VSS VSS VDD VDD _01163_ sky130_fd_sc_hd__nand2b_1
X_21834_ _01011_ _01162_ _01163_ _00924_ VSS VSS VDD VDD _01164_
+ sky130_fd_sc_hd__a31oi_1
X_21835_ _00940_ _01158_ _01161_ _01164_ VSS VSS VDD VDD _01165_
+ sky130_fd_sc_hd__nor4_1
X_21836_ _01124_ _01135_ _01153_ _01165_ VSS VSS VDD VDD _00123_
+ sky130_fd_sc_hd__nor4_1
X_21837_ _00798_ _00938_ _00884_ _01101_ VSS VSS VDD VDD _01166_
+ sky130_fd_sc_hd__nand4_1
X_21838_ net553 _00938_ _01094_ VSS VSS VDD VDD _01167_ sky130_fd_sc_hd__nand3_1
X_21839_ _00798_ _00979_ _01048_ VSS VSS VDD VDD _01168_ sky130_fd_sc_hd__nand3_1
X_21840_ _00806_ _00911_ _01168_ _01160_ VSS VSS VDD VDD _01169_
+ sky130_fd_sc_hd__a31oi_1
X_21841_ net666 net413 VSS VSS VDD VDD _01170_ sky130_fd_sc_hd__nand2_1
X_21842_ _00863_ _01170_ _00777_ VSS VSS VDD VDD _01171_ sky130_fd_sc_hd__a21oi_1
X_21843_ net666 _00822_ _00783_ VSS VSS VDD VDD _01172_ sky130_fd_sc_hd__o21ai_0
X_21844_ _00777_ _01172_ _00841_ VSS VSS VDD VDD _01173_ sky130_fd_sc_hd__a21oi_1
X_21845_ _12328_ _01144_ _01145_ _00777_ net673 VSS VSS VDD
+ VDD _01174_ sky130_fd_sc_hd__a221oi_1
X_21846_ net672 _01173_ _01174_ VSS VSS VDD VDD _01175_ sky130_fd_sc_hd__a21oi_1
X_21847_ _00938_ _00816_ _01171_ _01175_ VSS VSS VDD VDD _01176_
+ sky130_fd_sc_hd__nor4_1
X_21848_ _01166_ _01167_ _01169_ _01176_ VSS VSS VDD VDD _01177_
+ sky130_fd_sc_hd__a31oi_2
X_21849_ _12328_ _00798_ VSS VSS VDD VDD _01178_ sky130_fd_sc_hd__nor2_1
X_21850_ _01178_ _00951_ net412 VSS VSS VDD VDD _01179_ sky130_fd_sc_hd__o21ai_0
X_21851_ _00798_ _00864_ _00889_ VSS VSS VDD VDD _01180_ sky130_fd_sc_hd__nor3b_1
X_21852_ _00993_ _01048_ net553 VSS VSS VDD VDD _01181_ sky130_fd_sc_hd__a21oi_1
X_21853_ _00855_ _01180_ _01181_ VSS VSS VDD VDD _01182_ sky130_fd_sc_hd__nor3_1
X_21854_ _00878_ _01179_ _01182_ VSS VSS VDD VDD _01183_ sky130_fd_sc_hd__a21oi_1
X_21855_ _00938_ _00903_ _01183_ VSS VSS VDD VDD _01184_ sky130_fd_sc_hd__nand3_1
X_21856_ _12329_ _00806_ net667 VSS VSS VDD VDD _01185_ sky130_fd_sc_hd__o21ai_0
X_21857_ _00806_ _01033_ _01185_ _00798_ VSS VSS VDD VDD _01186_
+ sky130_fd_sc_hd__o211ai_1
X_21858_ net553 _00938_ VSS VSS VDD VDD _01187_ sky130_fd_sc_hd__nand2_1
X_21859_ _00798_ _00806_ VSS VSS VDD VDD _01188_ sky130_fd_sc_hd__nand2_1
X_21860_ _01187_ _01188_ _12340_ VSS VSS VDD VDD _01189_ sky130_fd_sc_hd__a21oi_1
X_21861_ _00806_ _01042_ _01189_ VSS VSS VDD VDD _01190_ sky130_fd_sc_hd__a21oi_1
X_21862_ _00969_ _01186_ _01190_ _00899_ VSS VSS VDD VDD _01191_
+ sky130_fd_sc_hd__a31oi_2
X_21863_ net553 _00995_ VSS VSS VDD VDD _01192_ sky130_fd_sc_hd__nand2_1
X_21864_ _00862_ _01120_ _01192_ _00864_ VSS VSS VDD VDD _01193_
+ sky130_fd_sc_hd__o22ai_1
X_21865_ _00822_ _00996_ _00938_ VSS VSS VDD VDD _01194_ sky130_fd_sc_hd__a21oi_1
X_21866_ _00822_ _01193_ _01194_ VSS VSS VDD VDD _01195_ sky130_fd_sc_hd__o21ai_1
X_21867_ _12329_ _00798_ net667 VSS VSS VDD VDD _01196_ sky130_fd_sc_hd__nand3_1
X_21868_ _00899_ _00816_ VSS VSS VDD VDD _01197_ sky130_fd_sc_hd__nand2_1
X_21869_ _00998_ _01115_ _01196_ _01197_ VSS VSS VDD VDD _01198_
+ sky130_fd_sc_hd__a31oi_1
X_21870_ _00960_ _01048_ _00798_ VSS VSS VDD VDD _01199_ sky130_fd_sc_hd__a21oi_1
X_21871_ _00885_ _01199_ _00938_ net413 VSS VSS VDD VDD _01200_
+ sky130_fd_sc_hd__o211ai_2
X_21872_ _00797_ net409 VSS VSS VDD VDD _01201_ sky130_fd_sc_hd__nand2_2
X_21873_ _00784_ _01201_ _01058_ VSS VSS VDD VDD _01202_ sky130_fd_sc_hd__o21ai_0
X_21874_ _00979_ _00983_ _00798_ VSS VSS VDD VDD _01203_ sky130_fd_sc_hd__a21oi_1
X_21875_ _00986_ _01107_ _01203_ VSS VSS VDD VDD _01204_ sky130_fd_sc_hd__nor3_1
X_21876_ _00899_ _00903_ VSS VSS VDD VDD _01205_ sky130_fd_sc_hd__nand2_1
X_21877_ _01119_ _01202_ _01204_ _01205_ VSS VSS VDD VDD _01206_
+ sky130_fd_sc_hd__a211oi_1
X_21878_ _00822_ net412 VSS VSS VDD VDD _01207_ sky130_fd_sc_hd__nand2_1
X_21879_ _00855_ net672 _00836_ VSS VSS VDD VDD _01208_ sky130_fd_sc_hd__nand3_1
X_21880_ _00783_ _00884_ _01144_ _00806_ VSS VSS VDD VDD _01209_
+ sky130_fd_sc_hd__a31o_1
X_21881_ _00777_ _00783_ _01207_ _01208_ _01209_ VSS VSS VDD
+ VDD _01210_ sky130_fd_sc_hd__a41oi_1
X_21882_ _00777_ _00892_ _00911_ net672 VSS VSS VDD VDD _01211_
+ sky130_fd_sc_hd__o22ai_1
X_21883_ _00871_ _01089_ _12340_ VSS VSS VDD VDD _01212_ sky130_fd_sc_hd__a21oi_1
X_21884_ net412 _00836_ _00871_ net553 _00855_ VSS VSS VDD
+ VDD _01213_ sky130_fd_sc_hd__o221ai_1
X_21885_ _00855_ _01211_ _01212_ _01213_ VSS VSS VDD VDD _01214_
+ sky130_fd_sc_hd__o31ai_1
X_21886_ _01210_ _01214_ VSS VSS VDD VDD _01215_ sky130_fd_sc_hd__nand2_1
X_21887_ _01195_ _01198_ _01200_ _01206_ _01215_ VSS VSS VDD
+ VDD _01216_ sky130_fd_sc_hd__a32o_1
X_21888_ _01177_ _01184_ _01191_ _01216_ VSS VSS VDD VDD _00124_
+ sky130_fd_sc_hd__a31oi_1
X_21889_ _00783_ _00917_ _01140_ VSS VSS VDD VDD _01217_ sky130_fd_sc_hd__o21ai_0
X_21890_ _12335_ _00880_ VSS VSS VDD VDD _01218_ sky130_fd_sc_hd__nand2_1
X_21891_ _12344_ net666 _00830_ VSS VSS VDD VDD _01219_ sky130_fd_sc_hd__o21ai_0
X_21892_ _01075_ _01131_ net413 VSS VSS VDD VDD _01220_ sky130_fd_sc_hd__a21oi_1
X_21893_ net413 _01218_ _01219_ _01220_ _00806_ VSS VSS VDD
+ VDD _01221_ sky130_fd_sc_hd__a311oi_1
X_21894_ _12340_ _00892_ _00889_ net666 VSS VSS VDD VDD _01222_
+ sky130_fd_sc_hd__o22ai_1
X_21895_ net553 _00964_ _00942_ _01107_ _01222_ VSS VSS VDD
+ VDD _01223_ sky130_fd_sc_hd__a311oi_1
X_21896_ _01119_ _01217_ _01221_ _01197_ _01223_ VSS VSS VDD
+ VDD _01224_ sky130_fd_sc_hd__a2111oi_0
X_21897_ _12328_ net412 VSS VSS VDD VDD _01225_ sky130_fd_sc_hd__nand2b_1
X_21898_ _01225_ _00993_ net666 VSS VSS VDD VDD _01226_ sky130_fd_sc_hd__a21oi_1
X_21899_ _00872_ _00964_ net666 VSS VSS VDD VDD _01227_ sky130_fd_sc_hd__a21oi_1
X_21900_ net500 _00917_ _01227_ _00855_ VSS VSS VDD VDD _01228_
+ sky130_fd_sc_hd__a211o_1
X_21901_ _00822_ _01014_ _01226_ _01228_ _00938_ VSS VSS VDD
+ VDD _01229_ sky130_fd_sc_hd__o311a_1
X_21902_ net666 _00871_ VSS VSS VDD VDD _01230_ sky130_fd_sc_hd__nor2_1
X_21903_ _00806_ _00855_ VSS VSS VDD VDD _01231_ sky130_fd_sc_hd__nand2_1
X_21904_ net553 _00884_ _01101_ _01230_ _01231_ VSS VSS VDD
+ VDD _01232_ sky130_fd_sc_hd__a311oi_1
X_21905_ _12333_ net667 _01033_ net553 _01107_ VSS VSS VDD
+ VDD _01233_ sky130_fd_sc_hd__a221oi_1
X_21906_ _01136_ _01229_ _01232_ _01233_ VSS VSS VDD VDD _01234_
+ sky130_fd_sc_hd__nor4_1
X_21907_ _00968_ _01016_ net672 VSS VSS VDD VDD _01235_ sky130_fd_sc_hd__a21oi_1
X_21908_ _01231_ _01235_ VSS VSS VDD VDD _01236_ sky130_fd_sc_hd__nor2_1
X_21909_ _00952_ _01236_ VSS VSS VDD VDD _01237_ sky130_fd_sc_hd__nand2_1
X_21910_ _12340_ _00798_ VSS VSS VDD VDD _01238_ sky130_fd_sc_hd__nand2_2
X_21911_ net411 _01238_ _00896_ _00806_ _01007_ VSS VSS VDD
+ VDD _01239_ sky130_fd_sc_hd__o2111ai_4
X_21912_ _00822_ _00975_ VSS VSS VDD VDD _01240_ sky130_fd_sc_hd__nor2_1
X_21913_ _00784_ _00857_ _01240_ VSS VSS VDD VDD _01241_ sky130_fd_sc_hd__a21oi_1
X_21914_ _12338_ _01207_ _01143_ net412 VSS VSS VDD VDD _01242_
+ sky130_fd_sc_hd__o22ai_1
X_21915_ _12342_ _00798_ _01207_ VSS VSS VDD VDD _01243_ sky130_fd_sc_hd__nor3_1
X_21916_ _00798_ _01242_ _01243_ _00806_ _00956_ VSS VSS VDD
+ VDD _01244_ sky130_fd_sc_hd__a2111oi_0
X_21917_ net500 _01241_ _01244_ VSS VSS VDD VDD _01245_ sky130_fd_sc_hd__o21ai_0
X_21918_ _01237_ _01239_ _01245_ _01123_ VSS VSS VDD VDD _01246_
+ sky130_fd_sc_hd__a31oi_1
X_21919_ _12338_ net667 _01058_ VSS VSS VDD VDD _01247_ sky130_fd_sc_hd__a21oi_1
X_21920_ net553 _00992_ _01101_ _01247_ VSS VSS VDD VDD _01248_
+ sky130_fd_sc_hd__a31oi_1
X_21921_ _12342_ _00917_ VSS VSS VDD VDD _01249_ sky130_fd_sc_hd__nand2_1
X_21922_ _12338_ net667 VSS VSS VDD VDD _01250_ sky130_fd_sc_hd__nand2_1
X_21923_ _00855_ _01249_ _01250_ _00806_ VSS VSS VDD VDD _01251_
+ sky130_fd_sc_hd__a31oi_1
X_21924_ _00855_ _01248_ _01251_ VSS VSS VDD VDD _01252_ sky130_fd_sc_hd__o21ai_0
X_21925_ _12342_ _01201_ VSS VSS VDD VDD _01253_ sky130_fd_sc_hd__nor2_1
X_21926_ _01107_ _01247_ _01253_ VSS VSS VDD VDD _01254_ sky130_fd_sc_hd__nor3_1
X_21927_ _00954_ _01139_ _01119_ _01218_ _01254_ VSS VSS VDD
+ VDD _01255_ sky130_fd_sc_hd__a41oi_1
X_21928_ _01252_ _01255_ _01205_ VSS VSS VDD VDD _01256_ sky130_fd_sc_hd__a21oi_1
X_21929_ _01224_ _01234_ _01246_ _01256_ VSS VSS VDD VDD _00125_
+ sky130_fd_sc_hd__nor4_1
X_21930_ _12330_ _12335_ net411 _00889_ net553 VSS VSS VDD
+ VDD _01257_ sky130_fd_sc_hd__o311a_1
X_21931_ _00798_ _00871_ _01101_ _01257_ VSS VSS VDD VDD _01258_
+ sky130_fd_sc_hd__a31oi_1
X_21932_ _12349_ net409 VSS VSS VDD VDD _01259_ sky130_fd_sc_hd__nor2_1
X_21933_ _12333_ _00798_ net411 _01106_ VSS VSS VDD VDD _01260_
+ sky130_fd_sc_hd__a211oi_1
X_21934_ _00798_ _00890_ _01048_ _01137_ _00903_ VSS VSS VDD
+ VDD _01261_ sky130_fd_sc_hd__a221oi_1
X_21935_ _00981_ _01259_ _01260_ _01261_ _00822_ VSS VSS VDD
+ VDD _01262_ sky130_fd_sc_hd__o32ai_1
X_21936_ _00816_ _01258_ _01262_ VSS VSS VDD VDD _01263_ sky130_fd_sc_hd__o21ai_1
X_21937_ net500 net411 _01109_ VSS VSS VDD VDD _01264_ sky130_fd_sc_hd__a21oi_1
X_21938_ _12333_ _00832_ _01264_ net553 _00943_ VSS VSS VDD
+ VDD _01265_ sky130_fd_sc_hd__o221ai_1
X_21939_ _00900_ _01263_ _01265_ VSS VSS VDD VDD _01266_ sky130_fd_sc_hd__nand3_1
X_21940_ net553 _00884_ _01101_ _01125_ VSS VSS VDD VDD _01267_
+ sky130_fd_sc_hd__a31oi_1
X_21941_ _12344_ _01201_ VSS VSS VDD VDD _01268_ sky130_fd_sc_hd__nor2_1
X_21942_ net500 _00862_ _00905_ _00981_ _01268_ VSS VSS VDD
+ VDD _01269_ sky130_fd_sc_hd__a2111oi_0
X_21943_ _12333_ _00880_ net413 VSS VSS VDD VDD _01270_ sky130_fd_sc_hd__a21oi_1
X_21944_ net409 _00911_ _01125_ net500 _01270_ VSS VSS VDD
+ VDD _01271_ sky130_fd_sc_hd__o221ai_1
X_21945_ _12358_ net411 VSS VSS VDD VDD _01272_ sky130_fd_sc_hd__nand2_1
X_21946_ _12333_ net553 net409 _00911_ VSS VSS VDD VDD _01273_
+ sky130_fd_sc_hd__o211ai_1
X_21947_ _01272_ _01273_ _00855_ VSS VSS VDD VDD _01274_ sky130_fd_sc_hd__a21oi_1
X_21948_ _00816_ _01271_ _01274_ VSS VSS VDD VDD _01275_ sky130_fd_sc_hd__a21oi_1
X_21949_ _00924_ _01267_ _01269_ _01275_ _01038_ VSS VSS VDD
+ VDD _01276_ sky130_fd_sc_hd__o221ai_1
X_21950_ _12328_ net667 _00884_ VSS VSS VDD VDD _01277_ sky130_fd_sc_hd__o21ai_0
X_21951_ _12330_ _00918_ _01277_ net553 _00981_ VSS VSS VDD
+ VDD _01278_ sky130_fd_sc_hd__a221oi_1
X_21952_ _01023_ _01238_ _00830_ VSS VSS VDD VDD _01279_ sky130_fd_sc_hd__a21o_1
X_21953_ _00855_ _01279_ VSS VSS VDD VDD _01280_ sky130_fd_sc_hd__nand2_1
X_21954_ _12342_ _00798_ net410 _00949_ VSS VSS VDD VDD _01281_
+ sky130_fd_sc_hd__a211oi_1
X_21955_ _12340_ net410 _00965_ net666 VSS VSS VDD VDD _01282_
+ sky130_fd_sc_hd__o211ai_1
X_21956_ net553 _00930_ _01067_ _01282_ _00943_ VSS VSS VDD
+ VDD _01283_ sky130_fd_sc_hd__o311ai_1
X_21957_ _00816_ _01280_ _01281_ _01283_ VSS VSS VDD VDD _01284_
+ sky130_fd_sc_hd__o31ai_1
X_21958_ _00777_ _00798_ _00830_ VSS VSS VDD VDD _01285_ sky130_fd_sc_hd__o21ai_0
X_21959_ _00777_ _00784_ _01285_ VSS VSS VDD VDD _01286_ sky130_fd_sc_hd__a21oi_1
X_21960_ _12347_ _12356_ _00830_ VSS VSS VDD VDD _01287_ sky130_fd_sc_hd__nor3_1
X_21961_ _01286_ _01287_ _00936_ VSS VSS VDD VDD _01288_ sky130_fd_sc_hd__o21ai_0
X_21962_ _00806_ _00811_ _01288_ VSS VSS VDD VDD _01289_ sky130_fd_sc_hd__nand3_1
X_21963_ net409 _00845_ _01238_ VSS VSS VDD VDD _01290_ sky130_fd_sc_hd__nand3_1
X_21964_ _12348_ _00830_ _00903_ VSS VSS VDD VDD _01291_ sky130_fd_sc_hd__a21oi_1
X_21965_ _00903_ _01098_ _01290_ _01291_ net413 VSS VSS VDD
+ VDD _01292_ sky130_fd_sc_hd__a221oi_1
X_21966_ _00777_ _00832_ _01132_ VSS VSS VDD VDD _01293_ sky130_fd_sc_hd__o21a_1
X_21967_ _01014_ _00981_ VSS VSS VDD VDD _01294_ sky130_fd_sc_hd__nor2_1
X_21968_ _01011_ _01162_ _01294_ _00940_ VSS VSS VDD VDD _01295_
+ sky130_fd_sc_hd__a31oi_1
X_21969_ _00963_ _01293_ _01295_ VSS VSS VDD VDD _01296_ sky130_fd_sc_hd__o21ai_1
X_21970_ _01278_ _01284_ _01289_ _01292_ _01296_ VSS VSS VDD
+ VDD _01297_ sky130_fd_sc_hd__o32a_1
X_21971_ _01266_ _01276_ _01297_ VSS VSS VDD VDD _00126_ sky130_fd_sc_hd__nand3_2
X_21972_ _12340_ net553 _01082_ VSS VSS VDD VDD _01298_ sky130_fd_sc_hd__a21oi_1
X_21973_ _12356_ net410 VSS VSS VDD VDD _01299_ sky130_fd_sc_hd__nor2_1
X_21974_ net410 _01298_ _01299_ VSS VSS VDD VDD _01300_ sky130_fd_sc_hd__a21oi_1
X_21975_ _01160_ _00976_ VSS VSS VDD VDD _01301_ sky130_fd_sc_hd__nor2_1
X_21976_ _00834_ _00892_ _01301_ VSS VSS VDD VDD _01302_ sky130_fd_sc_hd__o21ai_0
X_21977_ _00983_ _00894_ _00798_ VSS VSS VDD VDD _01303_ sky130_fd_sc_hd__a21oi_1
X_21978_ _00922_ _01127_ net553 VSS VSS VDD VDD _01304_ sky130_fd_sc_hd__o21ai_2
X_21979_ _00903_ _01044_ _01304_ VSS VSS VDD VDD _01305_ sky130_fd_sc_hd__nand3_1
X_21980_ _00903_ _00986_ _01303_ _01305_ net413 VSS VSS VDD
+ VDD _01306_ sky130_fd_sc_hd__o311ai_2
X_21981_ _00924_ _01300_ _01302_ _01306_ _00900_ VSS VSS VDD
+ VDD _01307_ sky130_fd_sc_hd__o2111ai_2
X_21982_ _00911_ _00950_ net672 VSS VSS VDD VDD _01308_ sky130_fd_sc_hd__a21oi_1
X_21983_ _01280_ _01308_ VSS VSS VDD VDD _01309_ sky130_fd_sc_hd__nor2_1
X_21984_ _12344_ _00832_ VSS VSS VDD VDD _01310_ sky130_fd_sc_hd__nor2_1
X_21985_ _00956_ _01310_ _00822_ VSS VSS VDD VDD _01311_ sky130_fd_sc_hd__o21ai_0
X_21986_ _00854_ _00919_ _01311_ VSS VSS VDD VDD _01312_ sky130_fd_sc_hd__o21ai_0
X_21987_ net411 _00845_ _01238_ _01268_ VSS VSS VDD VDD _01313_
+ sky130_fd_sc_hd__a31oi_2
X_21988_ _12328_ net667 VSS VSS VDD VDD _01314_ sky130_fd_sc_hd__nand2_1
X_21989_ _00894_ _01314_ _01170_ VSS VSS VDD VDD _01315_ sky130_fd_sc_hd__a21oi_1
X_21990_ net553 _00855_ _00975_ _00976_ VSS VSS VDD VDD _01316_
+ sky130_fd_sc_hd__nor4_1
X_21991_ _01039_ _01315_ _01316_ VSS VSS VDD VDD _01317_ sky130_fd_sc_hd__nor3_1
X_21992_ net413 _01313_ _01317_ VSS VSS VDD VDD _01318_ sky130_fd_sc_hd__o21ai_2
X_21993_ _00991_ _01309_ _01312_ _01318_ VSS VSS VDD VDD _01319_
+ sky130_fd_sc_hd__o31a_1
X_21994_ _00864_ _01286_ _00943_ VSS VSS VDD VDD _01320_ sky130_fd_sc_hd__o21ai_1
X_21995_ _12340_ net672 _00998_ _00798_ VSS VSS VDD VDD _01321_
+ sky130_fd_sc_hd__o211ai_1
X_21996_ _00798_ _01029_ _01067_ _01321_ _00969_ VSS VSS VDD
+ VDD _01322_ sky130_fd_sc_hd__o311ai_1
X_21997_ _00798_ _00998_ _01250_ VSS VSS VDD VDD _01323_ sky130_fd_sc_hd__nand3_1
X_21998_ _00798_ _00994_ _01048_ _00924_ _01178_ VSS VSS VDD
+ VDD _01324_ sky130_fd_sc_hd__a311oi_4
X_21999_ _00936_ _01006_ _01323_ _01324_ _00812_ VSS VSS VDD
+ VDD _01325_ sky130_fd_sc_hd__a311oi_1
X_22000_ _00777_ _00918_ _01029_ _01145_ VSS VSS VDD VDD _01326_
+ sky130_fd_sc_hd__a22oi_1
X_22001_ _00783_ net553 VSS VSS VDD VDD _01327_ sky130_fd_sc_hd__nand2_1
X_22002_ _12342_ _00822_ _00892_ _01207_ _01327_ VSS VSS VDD
+ VDD _01328_ sky130_fd_sc_hd__o32ai_1
X_22003_ _00903_ _01328_ VSS VSS VDD VDD _01329_ sky130_fd_sc_hd__nor2_1
X_22004_ net673 _01143_ VSS VSS VDD VDD _01330_ sky130_fd_sc_hd__nor2_1
X_22005_ _00857_ _01330_ _00784_ VSS VSS VDD VDD _01331_ sky130_fd_sc_hd__o21ai_0
X_22006_ _01326_ _01329_ _01331_ VSS VSS VDD VDD _01332_ sky130_fd_sc_hd__nand3_1
X_22007_ _00889_ _01101_ _00798_ VSS VSS VDD VDD _01333_ sky130_fd_sc_hd__a21oi_1
X_22008_ _12342_ _00880_ _01333_ _00855_ VSS VSS VDD VDD _01334_
+ sky130_fd_sc_hd__a211o_1
X_22009_ _01101_ _00995_ _01145_ _00816_ VSS VSS VDD VDD _01335_
+ sky130_fd_sc_hd__a31oi_1
X_22010_ _01334_ _01335_ _00940_ VSS VSS VDD VDD _01336_ sky130_fd_sc_hd__a21oi_1
X_22011_ _01320_ _01322_ _01325_ _01332_ _01336_ VSS VSS VDD
+ VDD _01337_ sky130_fd_sc_hd__a32oi_1
X_22012_ _01307_ _01319_ _01337_ VSS VSS VDD VDD _00127_ sky130_fd_sc_hd__nand3_1
X_22013_ sa00_sr\[7\] sa00_sr\[0\] sa20_sr\[1\] VSS VSS VDD
+ VDD _01338_ sky130_fd_sc_hd__xor3_1
X_22014_ _10489_ _10490_ _01338_ VSS VSS VDD VDD _01339_ sky130_fd_sc_hd__xnor3_4
X_22015_ net493 text_in_r\[97\] VSS VSS VDD VDD _01340_ sky130_fd_sc_hd__nand2_1
X_22016_ net493 _01339_ _01340_ VSS VSS VDD VDD _01341_ sky130_fd_sc_hd__o21a_1
X_22017_ u0.w\[0\]\[1\] _01341_ VSS VSS VDD VDD _01342_ sky130_fd_sc_hd__xor2_4
X_22018_ net588 VSS VSS VDD VDD _01343_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_9_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22022_ sa30_sr\[7\] _05874_ _05885_ VSS VSS VDD VDD _01346_
+ sky130_fd_sc_hd__xnor3_4
X_22023_ text_in_r\[96\] _01346_ net662 VSS VSS VDD VDD _01347_
+ sky130_fd_sc_hd__mux2i_4
X_22024_ u0.w\[0\]\[0\] _01347_ VSS VSS VDD VDD _01348_ sky130_fd_sc_hd__xor2_4
X_22025_ _01348_ VSS VSS VDD VDD _01349_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_9_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22027_ sa30_sr\[1\] sa00_sr\[2\] VSS VSS VDD VDD _01350_
+ sky130_fd_sc_hd__xor2_1
X_22028_ _05893_ _01350_ VSS VSS VDD VDD _01351_ sky130_fd_sc_hd__xnor2_2
X_22029_ text_in_r\[98\] _01351_ net661 VSS VSS VDD VDD _01352_
+ sky130_fd_sc_hd__mux2i_4
X_22030_ _01352_ u0.w\[0\]\[2\] VSS VSS VDD VDD _01353_ sky130_fd_sc_hd__xnor2_4
X_22031_ _01353_ VSS VSS VDD VDD _01354_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_9_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22042_ _05927_ _10545_ _10546_ VSS VSS VDD VDD _01362_ sky130_fd_sc_hd__xnor3_4
X_22043_ text_in_r\[99\] net493 VSS VSS VDD VDD _01363_ sky130_fd_sc_hd__nand2b_1
X_22044_ net493 _01362_ _01363_ u0.w\[0\]\[3\] VSS VSS VDD
+ VDD _01364_ sky130_fd_sc_hd__o211a_2
X_22045_ net493 text_in_r\[99\] VSS VSS VDD VDD _01365_ sky130_fd_sc_hd__and2_0
X_22046_ net547 _01362_ _01365_ u0.w\[0\]\[3\] VSS VSS VDD
+ VDD _01366_ sky130_fd_sc_hd__a211oi_4
X_22047_ _01366_ _01364_ VSS VSS VDD VDD _01367_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_9_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22049_ net407 _01367_ VSS VSS VDD VDD _01369_ sky130_fd_sc_hd__nand2_2
X_22050_ _01348_ _01354_ VSS VSS VDD VDD _01370_ sky130_fd_sc_hd__nand2_2
X_22051_ net493 _01362_ _01363_ u0.w\[0\]\[3\] VSS VSS VDD
+ VDD _01371_ sky130_fd_sc_hd__o211ai_4
X_22052_ net547 _01362_ _01365_ u0.w\[0\]\[3\] VSS VSS VDD
+ VDD _01372_ sky130_fd_sc_hd__a211o_2
X_22053_ _01371_ _01372_ VSS VSS VDD VDD _01373_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_9_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22055_ _01343_ _01373_ VSS VSS VDD VDD _01375_ sky130_fd_sc_hd__nor2_2
X_22056_ _12369_ _01369_ _01370_ _01375_ VSS VSS VDD VDD _01376_
+ sky130_fd_sc_hd__o22ai_1
X_22057_ _05949_ _10537_ _10538_ VSS VSS VDD VDD _01377_ sky130_fd_sc_hd__xnor3_2
X_22058_ text_in_r\[100\] _01377_ net547 VSS VSS VDD VDD _01378_
+ sky130_fd_sc_hd__mux2i_4
X_22059_ u0.w\[0\]\[4\] _01378_ VSS VSS VDD VDD _01379_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_9_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22061_ sa00_sr\[4\] sa20_sr\[5\] VSS VSS VDD VDD _01381_
+ sky130_fd_sc_hd__xor2_1
X_22062_ _10515_ _01381_ VSS VSS VDD VDD _01382_ sky130_fd_sc_hd__xnor2_2
X_22063_ text_in_r\[101\] _01382_ net547 VSS VSS VDD VDD _01383_
+ sky130_fd_sc_hd__mux2i_4
X_22064_ u0.w\[0\]\[5\] _01383_ VSS VSS VDD VDD _01384_ sky130_fd_sc_hd__xor2_4
X_22065_ net406 _01384_ VSS VSS VDD VDD _01385_ sky130_fd_sc_hd__nor2_4
X_22066_ u0.w\[0\]\[5\] _01383_ VSS VSS VDD VDD _01386_ sky130_fd_sc_hd__xnor2_4
X_22067_ _01343_ _01349_ net408 VSS VSS VDD VDD _01387_ sky130_fd_sc_hd__nand3_1
X_22068_ net748 _01370_ _01387_ net406 VSS VSS VDD VDD _01388_
+ sky130_fd_sc_hd__a31o_2
XTAP_TAPCELL_ROW_9_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22072_ _01343_ _01354_ VSS VSS VDD VDD _01392_ sky130_fd_sc_hd__nand2_1
X_22073_ _12366_ _01354_ _01373_ _01392_ VSS VSS VDD VDD _01393_
+ sky130_fd_sc_hd__o211a_1
X_22074_ _01386_ _01388_ _01393_ VSS VSS VDD VDD _01394_ sky130_fd_sc_hd__nor3_1
X_22075_ u0.w\[0\]\[4\] _01378_ VSS VSS VDD VDD _01395_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_8_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22079_ _12378_ _01367_ VSS VSS VDD VDD _01399_ sky130_fd_sc_hd__nand2_1
X_22080_ _01343_ _01373_ VSS VSS VDD VDD _01400_ sky130_fd_sc_hd__nand2_4
X_22081_ _01343_ _01367_ VSS VSS VDD VDD _01401_ sky130_fd_sc_hd__nor2_2
X_22082_ _01401_ _01370_ _01384_ VSS VSS VDD VDD _01402_ sky130_fd_sc_hd__o21ai_0
X_22083_ net407 _01399_ _01400_ _01402_ VSS VSS VDD VDD _01403_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_8_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22085_ net589 _01367_ VSS VSS VDD VDD _01405_ sky130_fd_sc_hd__nor2_4
X_22086_ _12378_ _01373_ VSS VSS VDD VDD _01406_ sky130_fd_sc_hd__nor2_1
X_22087_ net407 _01405_ _01406_ VSS VSS VDD VDD _01407_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_8_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22089_ _01354_ _01373_ VSS VSS VDD VDD _01409_ sky130_fd_sc_hd__nor2_2
X_22090_ _12365_ _01409_ VSS VSS VDD VDD _01410_ sky130_fd_sc_hd__nand2_1
X_22091_ _01349_ _01373_ VSS VSS VDD VDD _01411_ sky130_fd_sc_hd__nand2_2
X_22092_ _01407_ _01410_ _01411_ _01384_ VSS VSS VDD VDD _01412_
+ sky130_fd_sc_hd__a31oi_1
X_22093_ sa00_sr\[5\] sa20_sr\[6\] VSS VSS VDD VDD _01413_
+ sky130_fd_sc_hd__xnor2_1
X_22094_ _10523_ _01413_ VSS VSS VDD VDD _01414_ sky130_fd_sc_hd__xnor2_1
X_22095_ net492 _01414_ VSS VSS VDD VDD _01415_ sky130_fd_sc_hd__nor2_1
X_22096_ net492 text_in_r\[102\] _01415_ VSS VSS VDD VDD _01416_
+ sky130_fd_sc_hd__a21oi_4
X_22097_ u0.w\[0\]\[6\] _01416_ VSS VSS VDD VDD _01417_ sky130_fd_sc_hd__xor2_4
X_22098_ _05971_ _10529_ VSS VSS VDD VDD _01418_ sky130_fd_sc_hd__xnor2_2
X_22099_ text_in_r\[103\] _01418_ net547 VSS VSS VDD VDD _01419_
+ sky130_fd_sc_hd__mux2i_4
X_22100_ u0.w\[0\]\[7\] _01419_ VSS VSS VDD VDD _01420_ sky130_fd_sc_hd__xnor2_4
X_22101_ _01417_ _01420_ VSS VSS VDD VDD _01421_ sky130_fd_sc_hd__nor2_4
X_22102_ _01395_ _01403_ _01412_ _01421_ VSS VSS VDD VDD _01422_
+ sky130_fd_sc_hd__o31ai_1
X_22103_ _01376_ _01385_ _01394_ _01422_ VSS VSS VDD VDD _01423_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_8_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22107_ _01354_ _01367_ VSS VSS VDD VDD _01427_ sky130_fd_sc_hd__nor2_4
X_22108_ _12374_ _01427_ VSS VSS VDD VDD _01428_ sky130_fd_sc_hd__nand2_1
X_22109_ _12365_ _01371_ _01372_ VSS VSS VDD VDD _01429_ sky130_fd_sc_hd__nand3_4
X_22110_ net406 _01428_ _01429_ VSS VSS VDD VDD _01430_ sky130_fd_sc_hd__nand3_1
X_22111_ _01388_ _01430_ VSS VSS VDD VDD _01431_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_8_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22113_ _01349_ _01373_ VSS VSS VDD VDD _01433_ sky130_fd_sc_hd__nor2_4
X_22114_ _01395_ _01433_ VSS VSS VDD VDD _01434_ sky130_fd_sc_hd__nand2_2
X_22115_ _12369_ net748 _01434_ _01354_ VSS VSS VDD VDD _01435_
+ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_8_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22117_ _12366_ _01373_ VSS VSS VDD VDD _01437_ sky130_fd_sc_hd__nand2_1
X_22118_ _12369_ _01367_ VSS VSS VDD VDD _01438_ sky130_fd_sc_hd__nand2_4
X_22119_ net408 _01367_ VSS VSS VDD VDD _01439_ sky130_fd_sc_hd__nor2_8
X_22120_ net408 _01437_ _01438_ _01439_ _12364_ VSS VSS VDD
+ VDD _01440_ sky130_fd_sc_hd__a32oi_1
X_22121_ net595 _01373_ VSS VSS VDD VDD _01441_ sky130_fd_sc_hd__nand2_1
X_22122_ _01349_ _01367_ VSS VSS VDD VDD _01442_ sky130_fd_sc_hd__nand2_8
X_22123_ _12372_ _01373_ VSS VSS VDD VDD _01443_ sky130_fd_sc_hd__nor2_1
X_22124_ _12365_ _01367_ VSS VSS VDD VDD _01444_ sky130_fd_sc_hd__nor2_1
X_22125_ net407 _01443_ _01444_ VSS VSS VDD VDD _01445_ sky130_fd_sc_hd__nor3_1
X_22126_ net407 _01441_ _01442_ _01445_ net406 VSS VSS VDD
+ VDD _01446_ sky130_fd_sc_hd__a311oi_1
X_22127_ net406 _01440_ _01446_ _01384_ VSS VSS VDD VDD _01447_
+ sky130_fd_sc_hd__a211oi_1
X_22128_ u0.w\[0\]\[6\] _01416_ VSS VSS VDD VDD _01448_ sky130_fd_sc_hd__xnor2_4
X_22129_ _01448_ _01420_ VSS VSS VDD VDD _01449_ sky130_fd_sc_hd__nand2_4
X_22130_ _01384_ _01431_ _01435_ _01447_ _01449_ VSS VSS VDD
+ VDD _01450_ sky130_fd_sc_hd__a311oi_1
XTAP_TAPCELL_ROW_8_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22132_ u0.w\[0\]\[7\] _01419_ VSS VSS VDD VDD _01452_ sky130_fd_sc_hd__xor2_4
X_22133_ _01448_ _01452_ VSS VSS VDD VDD _01453_ sky130_fd_sc_hd__nor2_1
X_22134_ _01386_ _01453_ VSS VSS VDD VDD _01454_ sky130_fd_sc_hd__nand2_1
X_22135_ _12366_ _01373_ VSS VSS VDD VDD _01455_ sky130_fd_sc_hd__nor2_1
X_22136_ net592 _01349_ _01367_ VSS VSS VDD VDD _01456_ sky130_fd_sc_hd__nor3_2
X_22137_ _01354_ _01455_ _01456_ VSS VSS VDD VDD _01457_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_8_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22139_ _01354_ _01373_ VSS VSS VDD VDD _01459_ sky130_fd_sc_hd__nand2_4
X_22140_ _12372_ _01459_ _01379_ VSS VSS VDD VDD _01460_ sky130_fd_sc_hd__o21ai_1
X_22141_ _12366_ _01367_ VSS VSS VDD VDD _01461_ sky130_fd_sc_hd__nor2_2
X_22142_ _01343_ _01433_ _01461_ VSS VSS VDD VDD _01462_ sky130_fd_sc_hd__a21oi_1
X_22143_ net407 _01373_ VSS VSS VDD VDD _01463_ sky130_fd_sc_hd__nor2_2
X_22144_ net407 _01462_ _01463_ _12374_ _01379_ VSS VSS VDD
+ VDD _01464_ sky130_fd_sc_hd__a221o_1
X_22145_ _01457_ _01460_ _01464_ VSS VSS VDD VDD _01465_ sky130_fd_sc_hd__o21ai_1
X_22146_ _01343_ _01348_ _01353_ VSS VSS VDD VDD _01466_ sky130_fd_sc_hd__nand3_1
X_22147_ _12369_ net756 _01466_ VSS VSS VDD VDD _01467_ sky130_fd_sc_hd__o21ai_1
X_22148_ _01367_ _01467_ _01395_ VSS VSS VDD VDD _01468_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_8_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22150_ _12364_ _01369_ VSS VSS VDD VDD _01470_ sky130_fd_sc_hd__nor2_2
X_22151_ _01442_ _01437_ net408 VSS VSS VDD VDD _01471_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_8_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22153_ _12385_ net748 _01439_ _12365_ _01395_ VSS VSS VDD
+ VDD _01473_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_8_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22155_ _01386_ _01448_ _01452_ VSS VSS VDD VDD _01475_ sky130_fd_sc_hd__nor3_1
X_22156_ _01468_ _01470_ _01471_ _01473_ _01475_ VSS VSS VDD
+ VDD _01476_ sky130_fd_sc_hd__o311ai_0
X_22157_ _01454_ _01465_ _01476_ VSS VSS VDD VDD _01477_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_8_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22159_ _01354_ _01367_ VSS VSS VDD VDD _01479_ sky130_fd_sc_hd__nand2_2
X_22160_ _01427_ _01479_ VSS VSS VDD VDD _01480_ sky130_fd_sc_hd__nand2b_1
X_22161_ _12365_ _01369_ VSS VSS VDD VDD _01481_ sky130_fd_sc_hd__nor2_1
X_22162_ _12372_ _01439_ _01480_ _12364_ _01481_ VSS VSS VDD
+ VDD _01482_ sky130_fd_sc_hd__a221oi_1
X_22163_ _01384_ _01482_ VSS VSS VDD VDD _01483_ sky130_fd_sc_hd__nand2_1
X_22164_ net594 _01348_ VSS VSS VDD VDD _01484_ sky130_fd_sc_hd__nor2_1
X_22165_ _01367_ _01484_ VSS VSS VDD VDD _01485_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_8_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22167_ _12364_ _01373_ _01354_ VSS VSS VDD VDD _01487_ sky130_fd_sc_hd__o21ai_0
X_22168_ _12372_ _01364_ _01366_ VSS VSS VDD VDD _01488_ sky130_fd_sc_hd__or3_1
X_22169_ _12365_ _01373_ VSS VSS VDD VDD _01489_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_8_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22171_ net408 _01488_ _01489_ VSS VSS VDD VDD _01491_ sky130_fd_sc_hd__nand3_1
X_22172_ _01485_ _01487_ _01386_ _01491_ VSS VSS VDD VDD _01492_
+ sky130_fd_sc_hd__o211ai_1
X_22173_ _01348_ _01354_ VSS VSS VDD VDD _01493_ sky130_fd_sc_hd__nor2_4
X_22174_ _01343_ _01349_ VSS VSS VDD VDD _01494_ sky130_fd_sc_hd__nor2_2
X_22175_ _01493_ _01494_ _01367_ VSS VSS VDD VDD _01495_ sky130_fd_sc_hd__o21ai_0
X_22176_ _01367_ _01493_ _01494_ VSS VSS VDD VDD _01496_ sky130_fd_sc_hd__or3_1
X_22177_ _01386_ _01495_ _01496_ VSS VSS VDD VDD _01497_ sky130_fd_sc_hd__nand3_1
X_22178_ _12365_ _01354_ VSS VSS VDD VDD _01498_ sky130_fd_sc_hd__nand2b_1
X_22179_ _01343_ net756 VSS VSS VDD VDD _01499_ sky130_fd_sc_hd__nor2_1
X_22180_ _01401_ _01498_ _01489_ _01499_ _01384_ VSS VSS VDD
+ VDD _01500_ sky130_fd_sc_hd__o221ai_1
X_22181_ _01497_ _01500_ _01395_ VSS VSS VDD VDD _01501_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_8_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22183_ _01417_ _01452_ VSS VSS VDD VDD _01503_ sky130_fd_sc_hd__nand2_2
X_22184_ _01395_ _01483_ _01492_ _01501_ _01503_ VSS VSS VDD
+ VDD _01504_ sky130_fd_sc_hd__a311oi_1
X_22185_ _01423_ _01450_ _01477_ _01504_ VSS VSS VDD VDD _00128_
+ sky130_fd_sc_hd__or4_1
X_22186_ _01349_ _01354_ VSS VSS VDD VDD _01505_ sky130_fd_sc_hd__nor2_2
X_22187_ net747 net408 VSS VSS VDD VDD _01506_ sky130_fd_sc_hd__nor2_4
X_22188_ _01343_ _01367_ VSS VSS VDD VDD _01507_ sky130_fd_sc_hd__nand2_4
X_22189_ _12364_ _01354_ _01505_ VSS VSS VDD VDD _01508_ sky130_fd_sc_hd__a21oi_1
X_22190_ _01505_ _01506_ _01507_ _01508_ net748 VSS VSS VDD
+ VDD _01509_ sky130_fd_sc_hd__o32a_1
X_22191_ net747 _01373_ VSS VSS VDD VDD _01510_ sky130_fd_sc_hd__nand2_4
X_22192_ _01438_ _01510_ _01354_ VSS VSS VDD VDD _01511_ sky130_fd_sc_hd__a21oi_1
X_22193_ _01353_ _01405_ _01375_ _01384_ VSS VSS VDD VDD _01512_
+ sky130_fd_sc_hd__o31ai_1
XTAP_TAPCELL_ROW_8_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22195_ _01384_ _01509_ _01511_ _01512_ _01379_ VSS VSS VDD
+ VDD _01514_ sky130_fd_sc_hd__o221ai_1
X_22196_ _12372_ _01354_ _01493_ _01343_ _01367_ VSS VSS VDD
+ VDD _01515_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_8_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22198_ _12388_ _01386_ _01373_ VSS VSS VDD VDD _01517_ sky130_fd_sc_hd__nor3_1
X_22199_ _01515_ _01517_ _01395_ VSS VSS VDD VDD _01518_ sky130_fd_sc_hd__o21ai_0
X_22200_ _01514_ _01518_ _01448_ VSS VSS VDD VDD _01519_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_8_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22202_ net522 net747 _01373_ VSS VSS VDD VDD _01521_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_8_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22204_ _01461_ _01521_ _01354_ VSS VSS VDD VDD _01523_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_7_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22206_ _12365_ _01364_ _01366_ VSS VSS VDD VDD _01525_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_7_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22208_ _12378_ _01373_ VSS VSS VDD VDD _01527_ sky130_fd_sc_hd__nand2_2
X_22209_ net408 _01525_ _01527_ _01386_ VSS VSS VDD VDD _01528_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_7_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22211_ _12364_ _01367_ VSS VSS VDD VDD _01530_ sky130_fd_sc_hd__nand2_1
X_22212_ _12366_ net748 _01530_ VSS VSS VDD VDD _01531_ sky130_fd_sc_hd__o21ai_0
X_22213_ _01510_ _01525_ net408 VSS VSS VDD VDD _01532_ sky130_fd_sc_hd__a21oi_1
X_22214_ net408 _01531_ _01532_ _01384_ VSS VSS VDD VDD _01533_
+ sky130_fd_sc_hd__a211oi_1
X_22215_ _01523_ _01528_ _01533_ VSS VSS VDD VDD _01534_ sky130_fd_sc_hd__a21oi_1
X_22216_ _01395_ _01417_ _01534_ VSS VSS VDD VDD _01535_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_7_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22219_ _12364_ _01373_ VSS VSS VDD VDD _01538_ sky130_fd_sc_hd__nand2b_2
X_22220_ _01538_ _01507_ net408 VSS VSS VDD VDD _01539_ sky130_fd_sc_hd__a21oi_1
X_22221_ _01343_ _01349_ _01373_ VSS VSS VDD VDD _01540_ sky130_fd_sc_hd__nand3_4
X_22222_ _01525_ _01540_ _01354_ VSS VSS VDD VDD _01541_ sky130_fd_sc_hd__a21oi_1
X_22223_ _01349_ _01459_ VSS VSS VDD VDD _01542_ sky130_fd_sc_hd__nor2_1
X_22224_ _01541_ _01542_ _01384_ VSS VSS VDD VDD _01543_ sky130_fd_sc_hd__o21ai_2
X_22225_ _01384_ _01511_ _01539_ _01543_ VSS VSS VDD VDD _01544_
+ sky130_fd_sc_hd__o31ai_1
X_22226_ _01379_ _01417_ _01544_ VSS VSS VDD VDD _01545_ sky130_fd_sc_hd__nor3_1
X_22227_ net406 _01384_ VSS VSS VDD VDD _01546_ sky130_fd_sc_hd__nand2_4
X_22228_ _12364_ _01373_ VSS VSS VDD VDD _01547_ sky130_fd_sc_hd__nand2_1
X_22229_ _12369_ _01373_ VSS VSS VDD VDD _01548_ sky130_fd_sc_hd__nor2_1
X_22230_ _01349_ _01367_ VSS VSS VDD VDD _01549_ sky130_fd_sc_hd__nor2_2
X_22231_ net407 _01548_ _01549_ VSS VSS VDD VDD _01550_ sky130_fd_sc_hd__nor3_1
X_22232_ net407 _01547_ _01429_ _01550_ VSS VSS VDD VDD _01551_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_7_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22234_ net406 _01386_ VSS VSS VDD VDD _01552_ sky130_fd_sc_hd__nand2_4
X_22235_ net522 _01409_ _01552_ VSS VSS VDD VDD _01553_ sky130_fd_sc_hd__a21oi_1
X_22236_ _01354_ _01399_ VSS VSS VDD VDD _01554_ sky130_fd_sc_hd__nand2_1
X_22237_ _01553_ _01540_ _01554_ _01449_ VSS VSS VDD VDD _01555_
+ sky130_fd_sc_hd__a31oi_2
X_22238_ _01546_ _01551_ _01555_ VSS VSS VDD VDD _01556_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_7_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22240_ _12365_ _01354_ VSS VSS VDD VDD _01558_ sky130_fd_sc_hd__nand2_1
X_22241_ _01343_ _01442_ _01558_ _01367_ VSS VSS VDD VDD _01559_
+ sky130_fd_sc_hd__o22ai_1
X_22242_ net747 _01480_ _01559_ _01386_ VSS VSS VDD VDD _01560_
+ sky130_fd_sc_hd__a211oi_1
X_22243_ _12369_ _01373_ VSS VSS VDD VDD _01561_ sky130_fd_sc_hd__nand2_1
X_22244_ _01343_ _01349_ _01373_ VSS VSS VDD VDD _01562_ sky130_fd_sc_hd__a21oi_1
X_22245_ net407 _01562_ VSS VSS VDD VDD _01563_ sky130_fd_sc_hd__nor2_1
X_22246_ net407 _01525_ _01561_ _01563_ _01384_ VSS VSS VDD
+ VDD _01564_ sky130_fd_sc_hd__a311oi_1
X_22247_ _01560_ _01564_ _01395_ VSS VSS VDD VDD _01565_ sky130_fd_sc_hd__o21ai_0
X_22248_ _01411_ _01479_ _01343_ VSS VSS VDD VDD _01566_ sky130_fd_sc_hd__a21oi_1
X_22249_ _01506_ _01566_ _01395_ VSS VSS VDD VDD _01567_ sky130_fd_sc_hd__o21ai_0
X_22250_ _01429_ _01561_ VSS VSS VDD VDD _01568_ sky130_fd_sc_hd__nand2_1
X_22251_ _01343_ net406 _01549_ VSS VSS VDD VDD _01569_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_7_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22253_ _01442_ _01569_ net408 VSS VSS VDD VDD _01571_ sky130_fd_sc_hd__a21oi_1
X_22254_ net408 net406 _01568_ _01571_ _01454_ VSS VSS VDD
+ VDD _01572_ sky130_fd_sc_hd__a311oi_1
X_22255_ _12378_ net408 VSS VSS VDD VDD _01573_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_7_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22257_ _01558_ _01573_ _01373_ VSS VSS VDD VDD _01575_ sky130_fd_sc_hd__a21oi_1
X_22258_ _12369_ _01459_ _01480_ _01343_ VSS VSS VDD VDD _01576_
+ sky130_fd_sc_hd__a2bb2oi_1
X_22259_ _01468_ _01575_ _01576_ _01395_ VSS VSS VDD VDD _01577_
+ sky130_fd_sc_hd__o22ai_1
X_22260_ _01556_ _01565_ _01567_ _01572_ _01577_ _01475_ VSS
+ VSS VDD VDD _01578_ sky130_fd_sc_hd__a222oi_1
X_22261_ _01420_ _01519_ _01535_ _01545_ _01578_ VSS VSS VDD
+ VDD _00129_ sky130_fd_sc_hd__o41a_1
X_22262_ _01448_ _01452_ VSS VSS VDD VDD _01579_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_7_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22264_ _12374_ _01373_ _01507_ VSS VSS VDD VDD _01581_ sky130_fd_sc_hd__a21boi_0
X_22265_ _01395_ _01384_ VSS VSS VDD VDD _01582_ sky130_fd_sc_hd__nand2_1
X_22266_ _12369_ net408 VSS VSS VDD VDD _01583_ sky130_fd_sc_hd__nor2_1
X_22267_ net408 _01581_ _01582_ _01583_ VSS VSS VDD VDD _01584_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_7_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22269_ _12378_ _01373_ VSS VSS VDD VDD _01586_ sky130_fd_sc_hd__nand2b_1
X_22270_ _12374_ _01373_ VSS VSS VDD VDD _01587_ sky130_fd_sc_hd__nor2_1
X_22271_ _01354_ _01549_ _01587_ VSS VSS VDD VDD _01588_ sky130_fd_sc_hd__nor3_1
X_22272_ _01354_ _01507_ _01586_ _01588_ VSS VSS VDD VDD _01589_
+ sky130_fd_sc_hd__a31oi_1
X_22273_ _12374_ _01367_ VSS VSS VDD VDD _01590_ sky130_fd_sc_hd__nor2_1
X_22274_ _01354_ _01433_ _01590_ VSS VSS VDD VDD _01591_ sky130_fd_sc_hd__nor3_1
X_22275_ _12378_ _01367_ VSS VSS VDD VDD _01592_ sky130_fd_sc_hd__nor2_2
X_22276_ net407 _01548_ _01592_ VSS VSS VDD VDD _01593_ sky130_fd_sc_hd__nor3_1
X_22277_ _01591_ _01593_ VSS VSS VDD VDD _01594_ sky130_fd_sc_hd__nor2_1
X_22278_ _01552_ _01589_ _01594_ _01546_ VSS VSS VDD VDD _01595_
+ sky130_fd_sc_hd__o22ai_1
X_22279_ net408 _01510_ _01525_ VSS VSS VDD VDD _01596_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_7_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22281_ _12374_ net748 _01429_ _01354_ VSS VSS VDD VDD _01598_
+ sky130_fd_sc_hd__o211ai_1
X_22282_ _01395_ _01386_ VSS VSS VDD VDD _01599_ sky130_fd_sc_hd__nand2_8
X_22283_ _01596_ _01598_ _01599_ VSS VSS VDD VDD _01600_ sky130_fd_sc_hd__a21oi_1
X_22284_ _01429_ _01538_ _01354_ VSS VSS VDD VDD _01601_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_7_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22286_ _12369_ _01354_ net748 VSS VSS VDD VDD _01603_ sky130_fd_sc_hd__and3_1
X_22287_ _01601_ _01603_ _01385_ VSS VSS VDD VDD _01604_ sky130_fd_sc_hd__o21ai_0
X_22288_ _01379_ _01373_ VSS VSS VDD VDD _01605_ sky130_fd_sc_hd__nand2_2
X_22289_ _01395_ _01373_ VSS VSS VDD VDD _01606_ sky130_fd_sc_hd__nor2_1
X_22290_ net756 _01379_ net748 VSS VSS VDD VDD _01607_ sky130_fd_sc_hd__nor3_1
X_22291_ net747 net756 _01606_ _01607_ _01343_ VSS VSS VDD
+ VDD _01608_ sky130_fd_sc_hd__o221ai_1
X_22292_ _01379_ _01373_ VSS VSS VDD VDD _01609_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_7_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22294_ _12383_ _01609_ _01386_ VSS VSS VDD VDD _01611_ sky130_fd_sc_hd__a21oi_1
X_22295_ _12392_ _01605_ _01608_ _01611_ VSS VSS VDD VDD _01612_
+ sky130_fd_sc_hd__o211ai_2
X_22296_ _12366_ _12369_ VSS VSS VDD VDD _01613_ sky130_fd_sc_hd__nor2_2
X_22297_ _01373_ _01613_ net407 VSS VSS VDD VDD _01614_ sky130_fd_sc_hd__o21ai_1
X_22298_ _12372_ net748 _01354_ VSS VSS VDD VDD _01615_ sky130_fd_sc_hd__o21ai_0
X_22299_ _01395_ _01384_ VSS VSS VDD VDD _01616_ sky130_fd_sc_hd__nor2_4
X_22300_ _01485_ _01614_ _01615_ _01562_ _01616_ VSS VSS VDD
+ VDD _01617_ sky130_fd_sc_hd__o221ai_1
X_22301_ _01453_ _01604_ _01612_ _01617_ VSS VSS VDD VDD _01618_
+ sky130_fd_sc_hd__nand4_1
X_22302_ _01579_ _01584_ _01595_ _01600_ _01618_ VSS VSS VDD
+ VDD _01619_ sky130_fd_sc_hd__o41ai_1
X_22303_ _01405_ _01499_ _12365_ VSS VSS VDD VDD _01620_ sky130_fd_sc_hd__o21ai_0
X_22304_ _01349_ _01353_ VSS VSS VDD VDD _01621_ sky130_fd_sc_hd__nand2_2
X_22305_ net594 _01354_ VSS VSS VDD VDD _01622_ sky130_fd_sc_hd__nor2_1
X_22306_ _01375_ _01621_ _01442_ _01622_ VSS VSS VDD VDD _01623_
+ sky130_fd_sc_hd__a22oi_1
X_22307_ _12364_ _01367_ _01429_ _01354_ VSS VSS VDD VDD _01624_
+ sky130_fd_sc_hd__o211a_1
X_22308_ net408 _01400_ _01488_ _01624_ _01386_ VSS VSS VDD
+ VDD _01625_ sky130_fd_sc_hd__a311oi_2
X_22309_ _01386_ _01620_ _01623_ _01625_ VSS VSS VDD VDD _01626_
+ sky130_fd_sc_hd__a31oi_1
X_22310_ _01395_ _01626_ VSS VSS VDD VDD _01627_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_7_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22312_ _01373_ _01494_ _01622_ VSS VSS VDD VDD _01629_ sky130_fd_sc_hd__nor3_1
X_22313_ _12388_ net748 VSS VSS VDD VDD _01630_ sky130_fd_sc_hd__nor2_1
X_22314_ _01629_ _01630_ VSS VSS VDD VDD _01631_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_7_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22316_ net748 _01466_ _01498_ VSS VSS VDD VDD _01633_ sky130_fd_sc_hd__nand3_1
X_22317_ _12385_ _01373_ _01384_ VSS VSS VDD VDD _01634_ sky130_fd_sc_hd__a21oi_1
X_22318_ _01384_ _01631_ _01633_ _01634_ _01379_ VSS VSS VDD
+ VDD _01635_ sky130_fd_sc_hd__a221oi_1
X_22319_ _01449_ _01627_ _01635_ VSS VSS VDD VDD _01636_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_7_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22321_ _12378_ _01369_ VSS VSS VDD VDD _01638_ sky130_fd_sc_hd__nor2_1
X_22322_ _01442_ _01510_ _01392_ VSS VSS VDD VDD _01639_ sky130_fd_sc_hd__a21oi_1
X_22323_ _01442_ _01489_ _01354_ VSS VSS VDD VDD _01640_ sky130_fd_sc_hd__a21oi_1
X_22324_ net407 _01405_ _01455_ VSS VSS VDD VDD _01641_ sky130_fd_sc_hd__nor3_1
X_22325_ _01640_ _01641_ net406 VSS VSS VDD VDD _01642_ sky130_fd_sc_hd__o21ai_1
X_22326_ net406 _01638_ _01639_ _01642_ VSS VSS VDD VDD _01643_
+ sky130_fd_sc_hd__o31ai_1
X_22327_ _01343_ _01348_ _01367_ VSS VSS VDD VDD _01644_ sky130_fd_sc_hd__nand3_4
X_22328_ _01438_ _01489_ net407 VSS VSS VDD VDD _01645_ sky130_fd_sc_hd__a21oi_1
X_22329_ net407 _01441_ _01644_ _01645_ net406 VSS VSS VDD
+ VDD _01646_ sky130_fd_sc_hd__a311oi_1
X_22330_ _01442_ _01527_ net408 VSS VSS VDD VDD _01647_ sky130_fd_sc_hd__a21oi_1
X_22331_ _12369_ _01427_ _01647_ _01395_ _01375_ VSS VSS VDD
+ VDD _01648_ sky130_fd_sc_hd__a2111oi_0
X_22332_ _01386_ _01646_ _01648_ VSS VSS VDD VDD _01649_ sky130_fd_sc_hd__nor3_1
X_22333_ _01386_ _01643_ _01649_ _01503_ VSS VSS VDD VDD _01650_
+ sky130_fd_sc_hd__a211oi_1
X_22334_ _01619_ _01636_ _01650_ VSS VSS VDD VDD _00130_ sky130_fd_sc_hd__nor3_1
X_22335_ _12372_ _01373_ VSS VSS VDD VDD _01651_ sky130_fd_sc_hd__nand2_1
X_22336_ _01587_ _01651_ _01354_ VSS VSS VDD VDD _01652_ sky130_fd_sc_hd__nand3b_1
X_22337_ _01367_ _01613_ VSS VSS VDD VDD _01653_ sky130_fd_sc_hd__nand2_2
X_22338_ net407 _01540_ _01653_ net406 VSS VSS VDD VDD _01654_
+ sky130_fd_sc_hd__a31oi_1
X_22339_ _12378_ _01354_ _01493_ _01605_ VSS VSS VDD VDD _01655_
+ sky130_fd_sc_hd__a211oi_1
X_22340_ _01652_ _01654_ _01655_ VSS VSS VDD VDD _01656_ sky130_fd_sc_hd__a21oi_1
X_22341_ _01386_ _01656_ VSS VSS VDD VDD _01657_ sky130_fd_sc_hd__nor2_1
X_22342_ net407 _01441_ net747 VSS VSS VDD VDD _01658_ sky130_fd_sc_hd__a21oi_1
X_22343_ _01343_ _01439_ _01470_ _01658_ _01599_ VSS VSS VDD
+ VDD _01659_ sky130_fd_sc_hd__a2111oi_4
X_22344_ _12374_ _01367_ VSS VSS VDD VDD _01660_ sky130_fd_sc_hd__nand2_4
X_22345_ _01442_ _01586_ net407 VSS VSS VDD VDD _01661_ sky130_fd_sc_hd__a21oi_1
X_22346_ net407 _01489_ _01660_ _01661_ VSS VSS VDD VDD _01662_
+ sky130_fd_sc_hd__a31oi_1
X_22347_ _01552_ _01662_ _01421_ VSS VSS VDD VDD _01663_ sky130_fd_sc_hd__o21ai_1
X_22348_ _01417_ _01452_ VSS VSS VDD VDD _01664_ sky130_fd_sc_hd__nor2_4
X_22349_ _12372_ _01439_ _01433_ net522 _01640_ VSS VSS VDD
+ VDD _01665_ sky130_fd_sc_hd__a221oi_2
X_22350_ _01373_ _01493_ VSS VSS VDD VDD _01666_ sky130_fd_sc_hd__nand2_1
X_22351_ _01373_ _01370_ _01666_ VSS VSS VDD VDD _01667_ sky130_fd_sc_hd__o21ai_0
X_22352_ _12365_ _01459_ _01409_ _12372_ VSS VSS VDD VDD _01668_
+ sky130_fd_sc_hd__a2bb2oi_1
X_22353_ _01385_ _01664_ _01668_ VSS VSS VDD VDD _01669_ sky130_fd_sc_hd__nand3_1
X_22354_ _01343_ _01667_ _01669_ VSS VSS VDD VDD _01670_ sky130_fd_sc_hd__a21oi_1
X_22355_ net522 _01367_ VSS VSS VDD VDD _01671_ sky130_fd_sc_hd__nand2_1
X_22356_ net407 _01406_ _01590_ VSS VSS VDD VDD _01672_ sky130_fd_sc_hd__nor3_1
X_22357_ net407 _01671_ _01489_ _01672_ _01395_ VSS VSS VDD
+ VDD _01673_ sky130_fd_sc_hd__a311oi_2
X_22358_ net406 _01409_ _01506_ _01494_ VSS VSS VDD VDD _01674_
+ sky130_fd_sc_hd__nor4_1
X_22359_ _01386_ _01449_ _01673_ _01674_ VSS VSS VDD VDD _01675_
+ sky130_fd_sc_hd__nor4_2
X_22360_ _01664_ _01616_ _01665_ _01670_ _01675_ VSS VSS VDD
+ VDD _01676_ sky130_fd_sc_hd__a311oi_4
X_22361_ _01354_ _01379_ VSS VSS VDD VDD _01677_ sky130_fd_sc_hd__nor2_1
X_22362_ _01349_ _01677_ VSS VSS VDD VDD _01678_ sky130_fd_sc_hd__nand2_1
X_22363_ net593 _01349_ VSS VSS VDD VDD _01679_ sky130_fd_sc_hd__nor2_1
X_22364_ _01354_ _01379_ VSS VSS VDD VDD _01680_ sky130_fd_sc_hd__nand2_1
X_22365_ net590 _01379_ _01621_ _01679_ _01680_ VSS VSS VDD
+ VDD _01681_ sky130_fd_sc_hd__a32oi_1
X_22366_ _01678_ _01681_ _01386_ net748 VSS VSS VDD VDD _01682_
+ sky130_fd_sc_hd__a211oi_1
X_22367_ _12365_ _01373_ VSS VSS VDD VDD _01683_ sky130_fd_sc_hd__nand2b_2
X_22368_ net407 _01399_ _01683_ VSS VSS VDD VDD _01684_ sky130_fd_sc_hd__nand3_1
X_22369_ _01354_ _01400_ _01438_ VSS VSS VDD VDD _01685_ sky130_fd_sc_hd__nand3_1
X_22370_ _01684_ _01685_ _01599_ VSS VSS VDD VDD _01686_ sky130_fd_sc_hd__a21oi_1
X_22371_ net407 _01530_ _01651_ VSS VSS VDD VDD _01687_ sky130_fd_sc_hd__and3_1
X_22372_ _01354_ _01429_ _01510_ _01552_ _01687_ VSS VSS VDD
+ VDD _01688_ sky130_fd_sc_hd__a311oi_1
X_22373_ _01682_ _01686_ _01688_ VSS VSS VDD VDD _01689_ sky130_fd_sc_hd__nor3_1
X_22374_ _01353_ _01379_ VSS VSS VDD VDD _01690_ sky130_fd_sc_hd__nand2_2
X_22375_ _12366_ net748 _01444_ _01386_ VSS VSS VDD VDD _01691_
+ sky130_fd_sc_hd__a22oi_2
X_22376_ _01427_ _01463_ VSS VSS VDD VDD _01692_ sky130_fd_sc_hd__nor2_1
X_22377_ _12374_ _01692_ _01666_ VSS VSS VDD VDD _01693_ sky130_fd_sc_hd__a21boi_1
X_22378_ _01690_ _01691_ _01693_ _01599_ _01452_ VSS VSS VDD
+ VDD _01694_ sky130_fd_sc_hd__o221ai_4
X_22379_ _01399_ _01411_ net407 VSS VSS VDD VDD _01695_ sky130_fd_sc_hd__a21oi_1
X_22380_ net407 _01683_ _01653_ _01695_ net406 VSS VSS VDD
+ VDD _01696_ sky130_fd_sc_hd__a311oi_1
X_22381_ _12372_ _01367_ _01525_ VSS VSS VDD VDD _01697_ sky130_fd_sc_hd__o21ai_0
X_22382_ net522 _01427_ _01697_ _01354_ _01395_ VSS VSS VDD
+ VDD _01698_ sky130_fd_sc_hd__a221oi_1
X_22383_ _01386_ _01696_ _01698_ VSS VSS VDD VDD _01699_ sky130_fd_sc_hd__nor3_1
X_22384_ _01386_ _01452_ VSS VSS VDD VDD _01700_ sky130_fd_sc_hd__nor2_1
X_22385_ _01354_ _01395_ VSS VSS VDD VDD _01701_ sky130_fd_sc_hd__nand2_1
X_22386_ _01353_ _01395_ VSS VSS VDD VDD _01702_ sky130_fd_sc_hd__nor2_1
X_22387_ _01677_ _01702_ VSS VSS VDD VDD _01703_ sky130_fd_sc_hd__nor2_1
X_22388_ _01343_ _01701_ _01703_ _12365_ VSS VSS VDD VDD _01704_
+ sky130_fd_sc_hd__o22ai_1
X_22389_ net748 _01700_ _01704_ _01448_ VSS VSS VDD VDD _01705_
+ sky130_fd_sc_hd__a31oi_2
X_22390_ _01452_ _01689_ _01694_ _01699_ _01705_ VSS VSS VDD
+ VDD _01706_ sky130_fd_sc_hd__o221ai_4
X_22391_ _01657_ _01659_ _01663_ _01676_ _01706_ VSS VSS VDD
+ VDD _00131_ sky130_fd_sc_hd__o311ai_4
X_22392_ _01379_ _01386_ VSS VSS VDD VDD _01707_ sky130_fd_sc_hd__nor2_1
X_22393_ _12378_ _01459_ _01549_ _01354_ VSS VSS VDD VDD _01708_
+ sky130_fd_sc_hd__o22ai_1
X_22394_ _01707_ _01708_ VSS VSS VDD VDD _01709_ sky130_fd_sc_hd__nand2_1
X_22395_ _01438_ _01538_ _01354_ VSS VSS VDD VDD _01710_ sky130_fd_sc_hd__a21oi_1
X_22396_ _01384_ _01523_ _01710_ _01512_ VSS VSS VDD VDD _01711_
+ sky130_fd_sc_hd__o22ai_1
X_22397_ _12369_ net756 VSS VSS VDD VDD _01712_ sky130_fd_sc_hd__nand2_1
X_22398_ _01498_ _01712_ net748 VSS VSS VDD VDD _01713_ sky130_fd_sc_hd__a21oi_1
X_22399_ _01384_ _01388_ _01713_ VSS VSS VDD VDD _01714_ sky130_fd_sc_hd__nor3_1
X_22400_ _01379_ _01711_ _01714_ VSS VSS VDD VDD _01715_ sky130_fd_sc_hd__a21oi_1
X_22401_ _01709_ _01715_ _01417_ VSS VSS VDD VDD _01716_ sky130_fd_sc_hd__a21oi_1
X_22402_ _12374_ _01463_ VSS VSS VDD VDD _01717_ sky130_fd_sc_hd__nand2_1
X_22403_ _01401_ _01433_ net407 VSS VSS VDD VDD _01718_ sky130_fd_sc_hd__o21ai_1
X_22404_ _01717_ _01540_ _01718_ _01546_ VSS VSS VDD VDD _01719_
+ sky130_fd_sc_hd__a31oi_4
X_22405_ _01442_ _01547_ net756 VSS VSS VDD VDD _01720_ sky130_fd_sc_hd__a21oi_1
X_22406_ _12366_ _01354_ net748 _01644_ _01707_ VSS VSS VDD
+ VDD _01721_ sky130_fd_sc_hd__o311ai_0
X_22407_ _01720_ _01721_ VSS VSS VDD VDD _01722_ sky130_fd_sc_hd__nor2_1
X_22408_ _01343_ _01369_ VSS VSS VDD VDD _01723_ sky130_fd_sc_hd__nor2_1
X_22409_ _01354_ _01660_ _01723_ _01552_ _01456_ VSS VSS VDD
+ VDD _01724_ sky130_fd_sc_hd__a2111oi_2
X_22410_ _12376_ net748 VSS VSS VDD VDD _01725_ sky130_fd_sc_hd__nor2_1
X_22411_ net748 _01558_ _01725_ VSS VSS VDD VDD _01726_ sky130_fd_sc_hd__a21oi_1
X_22412_ _01599_ _01726_ _01417_ VSS VSS VDD VDD _01727_ sky130_fd_sc_hd__o21ai_0
X_22413_ _01719_ _01722_ _01724_ _01727_ _01452_ VSS VSS VDD
+ VDD _01728_ sky130_fd_sc_hd__o41ai_1
X_22414_ _01489_ _01660_ net407 VSS VSS VDD VDD _01729_ sky130_fd_sc_hd__a21oi_1
X_22415_ net407 _01644_ _01586_ _01729_ _01379_ VSS VSS VDD
+ VDD _01730_ sky130_fd_sc_hd__a311oi_1
X_22416_ _12374_ _01354_ _01395_ VSS VSS VDD VDD _01731_ sky130_fd_sc_hd__or3_1
X_22417_ _01568_ _01680_ _01731_ VSS VSS VDD VDD _01732_ sky130_fd_sc_hd__o21ai_0
X_22418_ _01384_ _01448_ _01730_ _01732_ VSS VSS VDD VDD _01733_
+ sky130_fd_sc_hd__nor4_1
X_22419_ _01354_ _01547_ _01507_ VSS VSS VDD VDD _01734_ sky130_fd_sc_hd__nand3_1
X_22420_ _01354_ _01461_ _01660_ _01379_ VSS VSS VDD VDD _01735_
+ sky130_fd_sc_hd__o211ai_1
X_22421_ _01386_ _01448_ _01735_ VSS VSS VDD VDD _01736_ sky130_fd_sc_hd__nand3_1
X_22422_ _01395_ _01621_ _01734_ _01736_ VSS VSS VDD VDD _01737_
+ sky130_fd_sc_hd__a31oi_1
X_22423_ _12364_ net756 VSS VSS VDD VDD _01738_ sky130_fd_sc_hd__nand2b_1
X_22424_ _01392_ _01738_ _01373_ VSS VSS VDD VDD _01739_ sky130_fd_sc_hd__a21oi_1
X_22425_ _12369_ net748 _01644_ net756 VSS VSS VDD VDD _01740_
+ sky130_fd_sc_hd__o211ai_1
X_22426_ net756 _01375_ _01592_ _01740_ _01379_ VSS VSS VDD
+ VDD _01741_ sky130_fd_sc_hd__o311ai_1
X_22427_ _01468_ _01739_ _01741_ _01384_ _01417_ VSS VSS VDD
+ VDD _01742_ sky130_fd_sc_hd__o2111a_1
X_22428_ _01353_ _01379_ net747 VSS VSS VDD VDD _01743_ sky130_fd_sc_hd__o21ai_0
X_22429_ _01343_ _01743_ _01493_ VSS VSS VDD VDD _01744_ sky130_fd_sc_hd__a21oi_1
X_22430_ _01343_ _01677_ _01702_ _12364_ _01373_ VSS VSS VDD
+ VDD _01745_ sky130_fd_sc_hd__a221oi_1
X_22431_ _01373_ _01744_ _01745_ VSS VSS VDD VDD _01746_ sky130_fd_sc_hd__a21oi_1
X_22432_ _01434_ _01690_ _01343_ VSS VSS VDD VDD _01747_ sky130_fd_sc_hd__a21oi_1
X_22433_ _01386_ _01417_ _01746_ _01747_ VSS VSS VDD VDD _01748_
+ sky130_fd_sc_hd__nor4_1
X_22434_ _01733_ _01737_ _01742_ _01748_ VSS VSS VDD VDD _01749_
+ sky130_fd_sc_hd__nor4_1
X_22435_ _01716_ _01728_ _01749_ _01452_ VSS VSS VDD VDD _00132_
+ sky130_fd_sc_hd__o22ai_2
X_22436_ _01349_ _01405_ _01666_ VSS VSS VDD VDD _01750_ sky130_fd_sc_hd__o21ai_1
X_22437_ _12369_ _01354_ VSS VSS VDD VDD _01751_ sky130_fd_sc_hd__nand2_1
X_22438_ _01621_ _01751_ net748 VSS VSS VDD VDD _01752_ sky130_fd_sc_hd__a21oi_1
X_22439_ _01386_ _01388_ _01752_ VSS VSS VDD VDD _01753_ sky130_fd_sc_hd__nor3_1
X_22440_ _01385_ _01750_ _01753_ VSS VSS VDD VDD _01754_ sky130_fd_sc_hd__a21oi_1
X_22441_ net407 _01590_ VSS VSS VDD VDD _01755_ sky130_fd_sc_hd__nor2_1
X_22442_ net407 _01441_ _01525_ _01755_ _01644_ VSS VSS VDD
+ VDD _01756_ sky130_fd_sc_hd__a32oi_2
X_22443_ _01488_ _01527_ net408 VSS VSS VDD VDD _01757_ sky130_fd_sc_hd__a21oi_1
X_22444_ net408 _01485_ _01757_ _01386_ VSS VSS VDD VDD _01758_
+ sky130_fd_sc_hd__a211oi_1
X_22445_ _01386_ _01756_ _01758_ VSS VSS VDD VDD _01759_ sky130_fd_sc_hd__a21oi_1
X_22446_ _01379_ _01421_ VSS VSS VDD VDD _01760_ sky130_fd_sc_hd__nand2_1
X_22447_ _01579_ _01754_ _01759_ _01760_ VSS VSS VDD VDD _01761_
+ sky130_fd_sc_hd__o22ai_1
X_22448_ _01343_ _01439_ _01540_ VSS VSS VDD VDD _01762_ sky130_fd_sc_hd__o21ai_0
X_22449_ _01385_ _01762_ _01448_ VSS VSS VDD VDD _01763_ sky130_fd_sc_hd__a21oi_1
X_22450_ _01343_ _01409_ _01401_ VSS VSS VDD VDD _01764_ sky130_fd_sc_hd__a21oi_1
X_22451_ net747 _01427_ _01463_ _12372_ VSS VSS VDD VDD _01765_
+ sky130_fd_sc_hd__a22oi_1
X_22452_ net747 _01764_ _01765_ VSS VSS VDD VDD _01766_ sky130_fd_sc_hd__o21ai_0
X_22453_ _01437_ _01429_ net408 VSS VSS VDD VDD _01767_ sky130_fd_sc_hd__a21oi_1
X_22454_ net522 _01427_ _01546_ _01767_ VSS VSS VDD VDD _01768_
+ sky130_fd_sc_hd__a211oi_1
X_22455_ _12364_ _01373_ _01527_ VSS VSS VDD VDD _01769_ sky130_fd_sc_hd__o21ai_0
X_22456_ _01354_ _01769_ _01582_ _01481_ VSS VSS VDD VDD _01770_
+ sky130_fd_sc_hd__a211oi_1
X_22457_ _01616_ _01766_ _01768_ _01770_ VSS VSS VDD VDD _01771_
+ sky130_fd_sc_hd__a211oi_1
X_22458_ _01438_ _01616_ VSS VSS VDD VDD _01772_ sky130_fd_sc_hd__nand2_1
X_22459_ _12374_ _01439_ _01457_ _01772_ VSS VSS VDD VDD _01773_
+ sky130_fd_sc_hd__a211oi_2
X_22460_ _01354_ _01548_ _01461_ _01407_ _01385_ VSS VSS VDD
+ VDD _01774_ sky130_fd_sc_hd__o311a_1
X_22461_ net407 _01561_ VSS VSS VDD VDD _01775_ sky130_fd_sc_hd__nand2_1
X_22462_ _01348_ net407 _01373_ VSS VSS VDD VDD _01776_ sky130_fd_sc_hd__nor3_1
X_22463_ net407 _01489_ _01660_ _01776_ net406 VSS VSS VDD
+ VDD _01777_ sky130_fd_sc_hd__a311oi_1
X_22464_ net406 _01644_ _01775_ _01777_ _01386_ VSS VSS VDD
+ VDD _01778_ sky130_fd_sc_hd__a311oi_1
X_22465_ _01417_ _01773_ _01774_ _01778_ _01420_ VSS VSS VDD
+ VDD _01779_ sky130_fd_sc_hd__o41ai_2
X_22466_ _01763_ _01771_ _01779_ VSS VSS VDD VDD _01780_ sky130_fd_sc_hd__a21oi_1
X_22467_ net408 _01489_ _01525_ _01757_ VSS VSS VDD VDD _01781_
+ sky130_fd_sc_hd__a31oi_1
X_22468_ _01373_ _01751_ VSS VSS VDD VDD _01782_ sky130_fd_sc_hd__nand2_1
X_22469_ _12378_ _01479_ _01782_ _01386_ VSS VSS VDD VDD _01783_
+ sky130_fd_sc_hd__o211ai_1
X_22470_ _01386_ _01781_ _01783_ VSS VSS VDD VDD _01784_ sky130_fd_sc_hd__o21ai_0
X_22471_ _01400_ _01505_ _01506_ _01653_ _01354_ VSS VSS VDD
+ VDD _01785_ sky130_fd_sc_hd__o32ai_1
X_22472_ _12372_ net748 _01484_ _01427_ _01582_ VSS VSS VDD
+ VDD _01786_ sky130_fd_sc_hd__a221oi_1
X_22473_ _01503_ _01786_ VSS VSS VDD VDD _01787_ sky130_fd_sc_hd__nor2_1
X_22474_ _01599_ _01785_ _01787_ VSS VSS VDD VDD _01788_ sky130_fd_sc_hd__o21ai_0
X_22475_ _01379_ _01784_ _01788_ VSS VSS VDD VDD _01789_ sky130_fd_sc_hd__a21oi_1
X_22476_ _01761_ _01780_ _01789_ VSS VSS VDD VDD _00133_ sky130_fd_sc_hd__nor3_1
X_22477_ _01538_ _01660_ _01354_ VSS VSS VDD VDD _01790_ sky130_fd_sc_hd__a21oi_1
X_22478_ _12366_ _01463_ _01790_ VSS VSS VDD VDD _01791_ sky130_fd_sc_hd__a21oi_1
X_22479_ _01373_ _01613_ _01683_ _01354_ VSS VSS VDD VDD _01792_
+ sky130_fd_sc_hd__o211ai_1
X_22480_ net407 _01510_ _01660_ VSS VSS VDD VDD _01793_ sky130_fd_sc_hd__nand3_1
X_22481_ _01384_ _01792_ _01793_ VSS VSS VDD VDD _01794_ sky130_fd_sc_hd__nand3_1
X_22482_ _01384_ _01791_ _01794_ VSS VSS VDD VDD _01795_ sky130_fd_sc_hd__o21ai_0
X_22483_ _01343_ _01354_ _01562_ VSS VSS VDD VDD _01796_ sky130_fd_sc_hd__o21ai_0
X_22484_ _12381_ _12390_ net748 _01796_ VSS VSS VDD VDD _01797_
+ sky130_fd_sc_hd__o31ai_1
X_22485_ _01354_ _01455_ _01592_ VSS VSS VDD VDD _01798_ sky130_fd_sc_hd__nor3_1
X_22486_ net407 _01521_ _01590_ VSS VSS VDD VDD _01799_ sky130_fd_sc_hd__nor3_1
X_22487_ _01386_ _01798_ _01799_ VSS VSS VDD VDD _01800_ sky130_fd_sc_hd__nor3_1
X_22488_ _01386_ _01797_ _01800_ _01379_ VSS VSS VDD VDD _01801_
+ sky130_fd_sc_hd__a211oi_1
X_22489_ _01379_ _01795_ _01801_ _01417_ VSS VSS VDD VDD _01802_
+ sky130_fd_sc_hd__a211oi_1
X_22490_ _01373_ _01613_ _01354_ VSS VSS VDD VDD _01803_ sky130_fd_sc_hd__a21oi_1
X_22491_ _01354_ _01442_ _01489_ _01803_ _01644_ VSS VSS VDD
+ VDD _01804_ sky130_fd_sc_hd__a32oi_1
X_22492_ _01395_ _01804_ VSS VSS VDD VDD _01805_ sky130_fd_sc_hd__nand2_1
X_22493_ net522 _01493_ net748 VSS VSS VDD VDD _01806_ sky130_fd_sc_hd__o21ai_0
X_22494_ _01460_ _01806_ VSS VSS VDD VDD _01807_ sky130_fd_sc_hd__nand2b_1
X_22495_ _12365_ _01354_ VSS VSS VDD VDD _01808_ sky130_fd_sc_hd__nor2_1
X_22496_ _01354_ _01679_ _01808_ VSS VSS VDD VDD _01809_ sky130_fd_sc_hd__a21oi_1
X_22497_ _12383_ net748 VSS VSS VDD VDD _01810_ sky130_fd_sc_hd__nand2_1
X_22498_ net748 _01809_ _01810_ VSS VSS VDD VDD _01811_ sky130_fd_sc_hd__o21ai_0
X_22499_ _01683_ _01507_ _01677_ _01452_ _01384_ VSS VSS VDD
+ VDD _01812_ sky130_fd_sc_hd__a311oi_1
X_22500_ _01462_ _01701_ _01812_ VSS VSS VDD VDD _01813_ sky130_fd_sc_hd__o21ai_0
X_22501_ _01379_ _01811_ _01813_ VSS VSS VDD VDD _01814_ sky130_fd_sc_hd__a21oi_1
X_22502_ _01700_ _01805_ _01807_ _01814_ _01664_ VSS VSS VDD
+ VDD _01815_ sky130_fd_sc_hd__a311oi_2
X_22503_ _01343_ _01395_ _01434_ _01354_ VSS VSS VDD VDD _01816_
+ sky130_fd_sc_hd__o211ai_1
X_22504_ _12374_ _01379_ net748 VSS VSS VDD VDD _01817_ sky130_fd_sc_hd__o21ai_0
X_22505_ _01379_ _01489_ _01817_ net756 VSS VSS VDD VDD _01818_
+ sky130_fd_sc_hd__o211ai_1
X_22506_ _01816_ _01818_ net747 _01605_ VSS VSS VDD VDD _01819_
+ sky130_fd_sc_hd__o2bb2ai_1
X_22507_ net522 _01505_ _01411_ VSS VSS VDD VDD _01820_ sky130_fd_sc_hd__a21boi_0
X_22508_ net522 _01433_ _01506_ VSS VSS VDD VDD _01821_ sky130_fd_sc_hd__a21oi_1
X_22509_ _12378_ _01820_ _01821_ VSS VSS VDD VDD _01822_ sky130_fd_sc_hd__o21ai_1
X_22510_ net748 _01493_ _01679_ VSS VSS VDD VDD _01823_ sky130_fd_sc_hd__a21oi_1
X_22511_ _01395_ _01592_ _01622_ VSS VSS VDD VDD _01824_ sky130_fd_sc_hd__o21ai_0
X_22512_ _01379_ _01823_ _01824_ _01421_ _01386_ VSS VSS VDD
+ VDD _01825_ sky130_fd_sc_hd__o2111ai_1
X_22513_ _01379_ _01822_ _01825_ VSS VSS VDD VDD _01826_ sky130_fd_sc_hd__a21oi_1
X_22514_ _01384_ _01421_ _01819_ _01826_ VSS VSS VDD VDD _01827_
+ sky130_fd_sc_hd__a31oi_1
X_22515_ net407 _01671_ VSS VSS VDD VDD _01828_ sky130_fd_sc_hd__nand2_1
X_22516_ net406 _01652_ _01828_ VSS VSS VDD VDD _01829_ sky130_fd_sc_hd__and3_1
X_22517_ _01395_ net748 _01467_ _01829_ VSS VSS VDD VDD _01830_
+ sky130_fd_sc_hd__a31oi_1
X_22518_ _12374_ _01354_ net748 _01622_ VSS VSS VDD VDD _01831_
+ sky130_fd_sc_hd__a211oi_1
X_22519_ _12382_ net748 _01831_ VSS VSS VDD VDD _01832_ sky130_fd_sc_hd__a21oi_1
X_22520_ _01481_ _01552_ _01695_ VSS VSS VDD VDD _01833_ sky130_fd_sc_hd__nor3_1
X_22521_ _01503_ _01833_ VSS VSS VDD VDD _01834_ sky130_fd_sc_hd__nor2_1
X_22522_ _01386_ _01830_ _01832_ _01599_ _01834_ VSS VSS VDD
+ VDD _01835_ sky130_fd_sc_hd__o221ai_1
X_22523_ _01802_ _01815_ _01827_ _01835_ VSS VSS VDD VDD _00134_
+ sky130_fd_sc_hd__o211ai_1
X_22524_ _01439_ _01609_ _01349_ VSS VSS VDD VDD _01836_ sky130_fd_sc_hd__o21ai_0
X_22525_ _01505_ _01606_ VSS VSS VDD VDD _01837_ sky130_fd_sc_hd__nand2_1
X_22526_ _01836_ _01837_ net522 VSS VSS VDD VDD _01838_ sky130_fd_sc_hd__a21oi_1
X_22527_ _01354_ _01489_ _01701_ VSS VSS VDD VDD _01839_ sky130_fd_sc_hd__o21ai_0
X_22528_ _01386_ _01838_ _01839_ VSS VSS VDD VDD _01840_ sky130_fd_sc_hd__nor3_1
X_22529_ _01442_ _01459_ _01343_ VSS VSS VDD VDD _01841_ sky130_fd_sc_hd__a21oi_1
X_22530_ _01456_ _01841_ _01395_ VSS VSS VDD VDD _01842_ sky130_fd_sc_hd__o21ai_0
X_22531_ _01367_ _01621_ _01479_ VSS VSS VDD VDD _01843_ sky130_fd_sc_hd__o21ai_0
X_22532_ _01349_ _01369_ _01411_ VSS VSS VDD VDD _01844_ sky130_fd_sc_hd__o21ai_0
X_22533_ _01343_ _01843_ _01844_ net406 VSS VSS VDD VDD _01845_
+ sky130_fd_sc_hd__a22oi_1
X_22534_ _01842_ _01845_ _01384_ VSS VSS VDD VDD _01846_ sky130_fd_sc_hd__a21oi_1
X_22535_ _01503_ _01840_ _01846_ VSS VSS VDD VDD _01847_ sky130_fd_sc_hd__nor3_1
X_22536_ _12374_ _01353_ VSS VSS VDD VDD _01848_ sky130_fd_sc_hd__nand2_1
X_22537_ _01498_ _01848_ _01367_ VSS VSS VDD VDD _01849_ sky130_fd_sc_hd__a21oi_1
X_22538_ _12390_ _01367_ _01849_ _01386_ VSS VSS VDD VDD _01850_
+ sky130_fd_sc_hd__a211oi_1
X_22539_ _12376_ _01373_ VSS VSS VDD VDD _01851_ sky130_fd_sc_hd__nor2_1
X_22540_ _12366_ _01354_ _01373_ _01851_ _01384_ VSS VSS VDD
+ VDD _01852_ sky130_fd_sc_hd__a311oi_1
X_22541_ _01379_ _01850_ _01852_ VSS VSS VDD VDD _01853_ sky130_fd_sc_hd__nor3_1
X_22542_ net408 _01400_ _01525_ _01532_ _01546_ VSS VSS VDD
+ VDD _01854_ sky130_fd_sc_hd__a311oi_1
X_22543_ _01400_ _01493_ _01616_ VSS VSS VDD VDD _01855_ sky130_fd_sc_hd__o21ai_0
X_22544_ net748 _01392_ _01712_ _01855_ VSS VSS VDD VDD _01856_
+ sky130_fd_sc_hd__a31oi_1
X_22545_ _01853_ _01854_ _01856_ _01453_ VSS VSS VDD VDD _01857_
+ sky130_fd_sc_hd__nor4b_1
X_22546_ _12365_ _01692_ VSS VSS VDD VDD _01858_ sky130_fd_sc_hd__nor2_1
X_22547_ net408 _01442_ _01527_ VSS VSS VDD VDD _01859_ sky130_fd_sc_hd__and3_1
X_22548_ _01354_ _01581_ _01859_ net406 VSS VSS VDD VDD _01860_
+ sky130_fd_sc_hd__a211o_1
X_22549_ _01395_ _01542_ _01638_ _01858_ _01860_ VSS VSS VDD
+ VDD _01861_ sky130_fd_sc_hd__o41ai_1
X_22550_ _01549_ _01776_ VSS VSS VDD VDD _01862_ sky130_fd_sc_hd__nor2_1
X_22551_ net522 _01862_ VSS VSS VDD VDD _01863_ sky130_fd_sc_hd__nor2_1
X_22552_ _12364_ _01409_ _01552_ _01542_ _01863_ VSS VSS VDD
+ VDD _01864_ sky130_fd_sc_hd__a2111oi_1
X_22553_ _12374_ _01479_ _01385_ VSS VSS VDD VDD _01865_ sky130_fd_sc_hd__o21ai_0
X_22554_ net408 _01507_ _01527_ _01865_ VSS VSS VDD VDD _01866_
+ sky130_fd_sc_hd__a31oi_1
X_22555_ _01384_ _01861_ _01864_ _01866_ _01579_ VSS VSS VDD
+ VDD _01867_ sky130_fd_sc_hd__a2111oi_2
X_22556_ net407 _01443_ _01485_ VSS VSS VDD VDD _01868_ sky130_fd_sc_hd__nor3_1
X_22557_ net407 _01525_ _01538_ _01868_ _01384_ VSS VSS VDD
+ VDD _01869_ sky130_fd_sc_hd__a311oi_1
X_22558_ _01461_ _01507_ _01354_ VSS VSS VDD VDD _01870_ sky130_fd_sc_hd__nand3b_1
X_22559_ _01738_ _01870_ _01386_ VSS VSS VDD VDD _01871_ sky130_fd_sc_hd__a21oi_1
X_22560_ _01354_ _01510_ _01660_ VSS VSS VDD VDD _01872_ sky130_fd_sc_hd__nand3_1
X_22561_ _01614_ _01872_ _01401_ VSS VSS VDD VDD _01873_ sky130_fd_sc_hd__a21oi_1
X_22562_ _12369_ net748 _01796_ _01384_ VSS VSS VDD VDD _01874_
+ sky130_fd_sc_hd__o211ai_1
X_22563_ _01384_ _01873_ _01874_ _01664_ _01379_ VSS VSS VDD
+ VDD _01875_ sky130_fd_sc_hd__o2111ai_1
X_22564_ _01379_ _01449_ _01869_ _01871_ _01875_ VSS VSS VDD
+ VDD _01876_ sky130_fd_sc_hd__o41ai_1
X_22565_ _01847_ _01857_ _01867_ _01876_ VSS VSS VDD VDD _00135_
+ sky130_fd_sc_hd__nor4_1
X_22566_ sa01_sr\[7\] sa01_sr\[0\] sa21_sr\[1\] VSS VSS VDD
+ VDD _01877_ sky130_fd_sc_hd__xor3_1
X_22567_ _11059_ _11060_ _01877_ VSS VSS VDD VDD _01878_ sky130_fd_sc_hd__xnor3_4
X_22568_ net493 text_in_r\[65\] VSS VSS VDD VDD _01879_ sky130_fd_sc_hd__nand2_1
X_22569_ net493 _01878_ _01879_ VSS VSS VDD VDD _01880_ sky130_fd_sc_hd__o21a_1
X_22570_ _01880_ u0.w\[1\]\[1\] VSS VSS VDD VDD _01881_ sky130_fd_sc_hd__xor2_4
X_22571_ net405 VSS VSS VDD VDD _01882_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_7_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22573_ net689 _06477_ _06489_ VSS VSS VDD VDD _01883_ sky130_fd_sc_hd__xnor3_4
X_22574_ text_in_r\[64\] _01883_ _05879_ VSS VSS VDD VDD _01884_
+ sky130_fd_sc_hd__mux2i_4
X_22575_ u0.w\[1\]\[0\] _01884_ VSS VSS VDD VDD _01885_ sky130_fd_sc_hd__xor2_4
X_22576_ net404 VSS VSS VDD VDD _01886_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_7_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22579_ sa30_sub\[1\] sa01_sr\[2\] VSS VSS VDD VDD _01888_
+ sky130_fd_sc_hd__xor2_2
X_22580_ _06495_ _01888_ VSS VSS VDD VDD _01889_ sky130_fd_sc_hd__xnor2_4
X_22581_ text_in_r\[66\] _01889_ _05879_ VSS VSS VDD VDD _01890_
+ sky130_fd_sc_hd__mux2i_4
X_22582_ u0.w\[1\]\[2\] _01890_ VSS VSS VDD VDD _01891_ sky130_fd_sc_hd__xnor2_4
X_22583_ net402 VSS VSS VDD VDD _01892_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_7_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22591_ _06605_ _11088_ VSS VSS VDD VDD _01897_ sky130_fd_sc_hd__xnor2_4
X_22592_ net547 _01897_ VSS VSS VDD VDD _01898_ sky130_fd_sc_hd__nand2_4
X_22593_ _05879_ text_in_r\[71\] _01898_ VSS VSS VDD VDD _01899_
+ sky130_fd_sc_hd__o21ai_4
X_22594_ u0.w\[1\]\[7\] _01899_ VSS VSS VDD VDD _01900_ sky130_fd_sc_hd__xor2_2
X_22595_ sa01_sr\[5\] sa21_sr\[6\] VSS VSS VDD VDD _01901_
+ sky130_fd_sc_hd__xnor2_2
X_22596_ _11083_ _01901_ VSS VSS VDD VDD _01902_ sky130_fd_sc_hd__xnor2_4
X_22597_ net493 _01902_ VSS VSS VDD VDD _01903_ sky130_fd_sc_hd__nor2_4
X_22598_ net493 text_in_r\[70\] _01903_ VSS VSS VDD VDD _01904_
+ sky130_fd_sc_hd__a21oi_4
X_22599_ u0.w\[1\]\[6\] _01904_ VSS VSS VDD VDD _01905_ sky130_fd_sc_hd__xnor2_4
X_22600_ _01900_ _01905_ VSS VSS VDD VDD _01906_ sky130_fd_sc_hd__nor2_2
X_22601_ sa30_sub\[4\] sa01_sr\[5\] VSS VSS VDD VDD _01907_
+ sky130_fd_sc_hd__xor2_2
X_22602_ _06560_ _01907_ VSS VSS VDD VDD _01908_ sky130_fd_sc_hd__xnor2_4
X_22603_ text_in_r\[69\] _01908_ _05879_ VSS VSS VDD VDD _01909_
+ sky130_fd_sc_hd__mux2i_4
X_22604_ u0.w\[1\]\[5\] _01909_ VSS VSS VDD VDD _01910_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_6_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22607_ net493 u0.w\[1\]\[3\] VSS VSS VDD VDD _01913_ sky130_fd_sc_hd__nor2b_1
X_22608_ u0.w\[1\]\[3\] net493 VSS VSS VDD VDD _01914_ sky130_fd_sc_hd__nor2_1
X_22609_ _06527_ _11096_ _11097_ VSS VSS VDD VDD _01915_ sky130_fd_sc_hd__xnor3_4
X_22610_ _01913_ _01914_ _01915_ VSS VSS VDD VDD _01916_ sky130_fd_sc_hd__mux2i_4
X_22611_ u0.w\[1\]\[3\] _05879_ VSS VSS VDD VDD _01917_ sky130_fd_sc_hd__nor2_1
X_22612_ u0.w\[1\]\[3\] net493 VSS VSS VDD VDD _01918_ sky130_fd_sc_hd__nand2_1
X_22613_ text_in_r\[67\] _01918_ VSS VSS VDD VDD _01919_ sky130_fd_sc_hd__nor2_1
X_22614_ text_in_r\[67\] _01917_ _01919_ VSS VSS VDD VDD _01920_
+ sky130_fd_sc_hd__a21oi_4
X_22615_ _01916_ _01920_ VSS VSS VDD VDD _01921_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_6_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22617_ _01892_ _01921_ VSS VSS VDD VDD _01923_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_6_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22622_ net403 _01921_ VSS VSS VDD VDD _01928_ sky130_fd_sc_hd__nand2_2
X_22623_ _01916_ _01920_ VSS VSS VDD VDD _01929_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_6_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22626_ _01892_ _01929_ VSS VSS VDD VDD _01932_ sky130_fd_sc_hd__nand2_2
X_22627_ net675 _01928_ _01932_ VSS VSS VDD VDD _01933_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_6_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22629_ _12398_ _12401_ VSS VSS VDD VDD _01935_ sky130_fd_sc_hd__nor2_4
X_22630_ net403 _01929_ VSS VSS VDD VDD _01936_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_6_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22632_ _12396_ _01923_ _01933_ net404 _01935_ _01936_ VSS
+ VSS VDD VDD _01938_ sky130_fd_sc_hd__a222oi_1
XTAP_TAPCELL_ROW_6_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22635_ _12398_ _01929_ VSS VSS VDD VDD _01941_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_6_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22637_ net675 _01886_ _01921_ VSS VSS VDD VDD _01943_ sky130_fd_sc_hd__nor3_2
XTAP_TAPCELL_ROW_6_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22639_ _01891_ _01921_ VSS VSS VDD VDD _01945_ sky130_fd_sc_hd__nor2_4
X_22640_ _12406_ _01945_ VSS VSS VDD VDD _01946_ sky130_fd_sc_hd__nand2_1
X_22641_ _01892_ _01941_ _01943_ _01946_ _01910_ VSS VSS VDD
+ VDD _01947_ sky130_fd_sc_hd__o311ai_0
X_22642_ _06512_ _11117_ _11118_ VSS VSS VDD VDD _01948_ sky130_fd_sc_hd__xor3_4
X_22643_ text_in_r\[68\] _01948_ _05879_ VSS VSS VDD VDD _01949_
+ sky130_fd_sc_hd__mux2i_4
X_22644_ _01949_ u0.w\[1\]\[4\] VSS VSS VDD VDD _01950_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_6_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22647_ _01910_ _01938_ _01947_ net678 VSS VSS VDD VDD _01953_
+ sky130_fd_sc_hd__o211ai_1
X_22648_ _01909_ u0.w\[1\]\[5\] VSS VSS VDD VDD _01954_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_6_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22652_ _01892_ _01921_ VSS VSS VDD VDD _01958_ sky130_fd_sc_hd__nand2_4
X_22653_ _12404_ _01958_ VSS VSS VDD VDD _01959_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_5_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22655_ _12398_ _01929_ VSS VSS VDD VDD _01961_ sky130_fd_sc_hd__nand2_2
X_22656_ _01881_ _01886_ VSS VSS VDD VDD _01962_ sky130_fd_sc_hd__nor2_2
X_22657_ _01892_ _01961_ _01962_ _01928_ VSS VSS VDD VDD _01963_
+ sky130_fd_sc_hd__o22ai_1
XTAP_TAPCELL_ROW_5_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22661_ _12417_ _01929_ _01936_ _12397_ _01910_ VSS VSS VDD
+ VDD _01967_ sky130_fd_sc_hd__a221o_1
X_22662_ u0.w\[1\]\[4\] _01949_ VSS VSS VDD VDD _01968_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_5_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22665_ net679 _01959_ _01963_ _01967_ _01968_ VSS VSS VDD
+ VDD _01971_ sky130_fd_sc_hd__o311ai_0
XTAP_TAPCELL_ROW_5_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22668_ _12397_ _01921_ VSS VSS VDD VDD _01974_ sky130_fd_sc_hd__nor2_2
X_22669_ _12406_ _01929_ VSS VSS VDD VDD _01975_ sky130_fd_sc_hd__nor2_1
X_22670_ _01974_ _01975_ net401 VSS VSS VDD VDD _01976_ sky130_fd_sc_hd__o21ai_0
X_22671_ _12401_ _01958_ net679 _01976_ VSS VSS VDD VDD _01977_
+ sky130_fd_sc_hd__o211ai_1
X_22672_ _12401_ _01921_ VSS VSS VDD VDD _01978_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_5_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22675_ _01941_ _01978_ net402 VSS VSS VDD VDD _01981_ sky130_fd_sc_hd__o21ai_0
X_22676_ _12396_ _01936_ net679 VSS VSS VDD VDD _01982_ sky130_fd_sc_hd__a21oi_1
X_22677_ _01981_ _01982_ net678 VSS VSS VDD VDD _01983_ sky130_fd_sc_hd__a21oi_1
X_22678_ _01977_ _01983_ VSS VSS VDD VDD _01984_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_5_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22680_ _12397_ _01892_ VSS VSS VDD VDD _01986_ sky130_fd_sc_hd__nand2_1
X_22681_ _01882_ net402 VSS VSS VDD VDD _01987_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_5_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22684_ _01921_ _01986_ _01987_ _01968_ VSS VSS VDD VDD _01990_
+ sky130_fd_sc_hd__a31oi_1
X_22685_ net611 _01892_ VSS VSS VDD VDD _01991_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_5_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22688_ _12404_ net401 VSS VSS VDD VDD _01994_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_5_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22690_ _01991_ _01994_ _01929_ VSS VSS VDD VDD _01996_ sky130_fd_sc_hd__o21ai_0
X_22691_ _01910_ _01990_ _01996_ VSS VSS VDD VDD _01997_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_5_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22694_ net404 _01892_ VSS VSS VDD VDD _02000_ sky130_fd_sc_hd__nand2_2
X_22695_ _01882_ _01991_ VSS VSS VDD VDD _02001_ sky130_fd_sc_hd__nand2_1
X_22696_ _01929_ _02000_ _02001_ _01968_ VSS VSS VDD VDD _02002_
+ sky130_fd_sc_hd__a31oi_2
X_22697_ _12401_ _01936_ VSS VSS VDD VDD _02003_ sky130_fd_sc_hd__nand2_1
X_22698_ net679 _02002_ _02003_ VSS VSS VDD VDD _02004_ sky130_fd_sc_hd__nand3_1
X_22699_ u0.w\[1\]\[7\] _01899_ VSS VSS VDD VDD _02005_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_5_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22701_ _02005_ _01905_ VSS VSS VDD VDD _02007_ sky130_fd_sc_hd__nand2_4
X_22702_ _01984_ _01997_ _02004_ _02007_ VSS VSS VDD VDD _02008_
+ sky130_fd_sc_hd__a31oi_1
X_22703_ net403 _01929_ VSS VSS VDD VDD _02009_ sky130_fd_sc_hd__xnor2_4
X_22704_ _12396_ _02009_ VSS VSS VDD VDD _02010_ sky130_fd_sc_hd__nor2_1
X_22705_ _12397_ _01923_ _01959_ _02010_ VSS VSS VDD VDD _02011_
+ sky130_fd_sc_hd__a211oi_1
X_22706_ net675 net404 VSS VSS VDD VDD _02012_ sky130_fd_sc_hd__nor2_1
X_22707_ _01882_ _01936_ _01923_ _02012_ VSS VSS VDD VDD _02013_
+ sky130_fd_sc_hd__a22oi_1
X_22708_ net404 _01945_ VSS VSS VDD VDD _02014_ sky130_fd_sc_hd__nand2_1
X_22709_ _12398_ _01928_ _02013_ _01905_ _02014_ VSS VSS VDD
+ VDD _02015_ sky130_fd_sc_hd__o2111ai_1
X_22710_ _01905_ _02011_ net678 net679 _02015_ VSS VSS VDD
+ VDD _02016_ sky130_fd_sc_hd__o2111ai_1
X_22711_ net405 _01921_ VSS VSS VDD VDD _02017_ sky130_fd_sc_hd__nand2_2
X_22712_ _12397_ net402 VSS VSS VDD VDD _02018_ sky130_fd_sc_hd__nor2_2
X_22713_ _01882_ net402 VSS VSS VDD VDD _02019_ sky130_fd_sc_hd__nor2_2
X_22714_ _12397_ _01921_ VSS VSS VDD VDD _02020_ sky130_fd_sc_hd__nand2_4
X_22715_ _02019_ _02020_ VSS VSS VDD VDD _02021_ sky130_fd_sc_hd__nor2_1
X_22716_ _02017_ _02018_ _02021_ VSS VSS VDD VDD _02022_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_5_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22718_ _12410_ _01929_ VSS VSS VDD VDD _02024_ sky130_fd_sc_hd__nand2_1
X_22719_ _01882_ _01921_ VSS VSS VDD VDD _02025_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_5_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22721_ _01886_ net402 VSS VSS VDD VDD _02027_ sky130_fd_sc_hd__nor2_1
X_22722_ net402 _02024_ _02025_ _02017_ _02027_ VSS VSS VDD
+ VDD _02028_ sky130_fd_sc_hd__a32oi_1
XTAP_TAPCELL_ROW_5_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22724_ _01954_ _01968_ VSS VSS VDD VDD _02030_ sky130_fd_sc_hd__nand2_1
X_22725_ _01905_ _02028_ _02030_ VSS VSS VDD VDD _02031_ sky130_fd_sc_hd__a21oi_1
X_22726_ _01905_ _02022_ _02031_ VSS VSS VDD VDD _02032_ sky130_fd_sc_hd__o21ai_2
X_22727_ u0.w\[1\]\[6\] _01904_ VSS VSS VDD VDD _02033_ sky130_fd_sc_hd__xor2_4
X_22728_ net403 _01929_ VSS VSS VDD VDD _02034_ sky130_fd_sc_hd__nand2_4
X_22729_ _01882_ _01921_ VSS VSS VDD VDD _02035_ sky130_fd_sc_hd__nor2_1
X_22730_ _12401_ _02034_ _02035_ _02000_ VSS VSS VDD VDD _02036_
+ sky130_fd_sc_hd__o22ai_2
X_22731_ _12410_ _01929_ VSS VSS VDD VDD _02037_ sky130_fd_sc_hd__nand2b_1
X_22732_ _01892_ _02025_ _02037_ VSS VSS VDD VDD _02038_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_5_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22734_ net404 _01929_ VSS VSS VDD VDD _02040_ sky130_fd_sc_hd__nor2_4
X_22735_ _12397_ _01923_ _01950_ _02040_ VSS VSS VDD VDD _02041_
+ sky130_fd_sc_hd__a211oi_1
X_22736_ _01950_ _02036_ _02038_ _02041_ VSS VSS VDD VDD _02042_
+ sky130_fd_sc_hd__a22oi_1
X_22737_ _01892_ _01950_ VSS VSS VDD VDD _02043_ sky130_fd_sc_hd__nand2_2
X_22738_ _01882_ _01886_ VSS VSS VDD VDD _02044_ sky130_fd_sc_hd__nor2_1
X_22739_ _01968_ _02044_ VSS VSS VDD VDD _02045_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_4_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22741_ _01905_ _01921_ _01954_ VSS VSS VDD VDD _02047_ sky130_fd_sc_hd__nor3_1
X_22742_ _12404_ net678 VSS VSS VDD VDD _02048_ sky130_fd_sc_hd__nand2_1
X_22743_ _01886_ _01950_ _02048_ net401 VSS VSS VDD VDD _02049_
+ sky130_fd_sc_hd__o211ai_1
X_22744_ _12396_ _02043_ _02045_ _02047_ _02049_ VSS VSS VDD
+ VDD _02050_ sky130_fd_sc_hd__o2111ai_1
X_22745_ _01882_ _01886_ VSS VSS VDD VDD _02051_ sky130_fd_sc_hd__nand2_4
X_22746_ net403 _01968_ VSS VSS VDD VDD _02052_ sky130_fd_sc_hd__nand2_1
X_22747_ _02051_ _02043_ _02052_ net404 VSS VSS VDD VDD _02053_
+ sky130_fd_sc_hd__o22ai_1
X_22748_ net405 net608 VSS VSS VDD VDD _02054_ sky130_fd_sc_hd__nand2_1
X_22749_ net401 _01950_ VSS VSS VDD VDD _02055_ sky130_fd_sc_hd__nand2_1
X_22750_ _01950_ _02054_ _02055_ _12397_ VSS VSS VDD VDD _02056_
+ sky130_fd_sc_hd__o22ai_1
X_22751_ _01929_ _01954_ VSS VSS VDD VDD _02057_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_4_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22753_ _02053_ _02056_ _02057_ _02033_ VSS VSS VDD VDD _02059_
+ sky130_fd_sc_hd__o211ai_1
X_22754_ _02033_ net679 _02042_ _02050_ _02059_ VSS VSS VDD
+ VDD _02060_ sky130_fd_sc_hd__o311a_1
X_22755_ _02016_ _02032_ _02060_ _02005_ VSS VSS VDD VDD _02061_
+ sky130_fd_sc_hd__a31oi_1
X_22756_ _01906_ _01953_ _01971_ _02008_ _02061_ VSS VSS VDD
+ VDD _00136_ sky130_fd_sc_hd__a311oi_1
X_22757_ net405 net404 _01929_ VSS VSS VDD VDD _02062_ sky130_fd_sc_hd__nor3_1
X_22758_ _01882_ _02034_ VSS VSS VDD VDD _02063_ sky130_fd_sc_hd__nor2_1
X_22759_ _01892_ _02024_ _02062_ _02063_ VSS VSS VDD VDD _02064_
+ sky130_fd_sc_hd__a211oi_1
X_22760_ _01886_ _01929_ VSS VSS VDD VDD _02065_ sky130_fd_sc_hd__nor2_4
X_22761_ _12397_ _01929_ VSS VSS VDD VDD _02066_ sky130_fd_sc_hd__nand2_1
X_22762_ _12396_ _01916_ _01920_ VSS VSS VDD VDD _02067_ sky130_fd_sc_hd__and3_2
X_22763_ _01892_ _02067_ VSS VSS VDD VDD _02068_ sky130_fd_sc_hd__nor2_1
X_22764_ _02066_ _02068_ VSS VSS VDD VDD _02069_ sky130_fd_sc_hd__nand2_1
X_22765_ net403 _01978_ _02065_ _02069_ _01954_ VSS VSS VDD
+ VDD _02070_ sky130_fd_sc_hd__o311ai_0
X_22766_ net679 _02064_ _02070_ VSS VSS VDD VDD _02071_ sky130_fd_sc_hd__o21ai_0
X_22767_ net608 _01921_ VSS VSS VDD VDD _02072_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_4_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22769_ _01886_ _02009_ VSS VSS VDD VDD _02073_ sky130_fd_sc_hd__nor2_1
X_22770_ _12397_ _01936_ _02072_ net546 _02073_ VSS VSS VDD
+ VDD _02074_ sky130_fd_sc_hd__a221oi_1
X_22771_ _12397_ _01929_ VSS VSS VDD VDD _02075_ sky130_fd_sc_hd__nand2b_4
X_22772_ _12401_ _01921_ VSS VSS VDD VDD _02076_ sky130_fd_sc_hd__nand2_1
X_22773_ _01929_ _02051_ net403 VSS VSS VDD VDD _02077_ sky130_fd_sc_hd__a21oi_1
X_22774_ net403 _02075_ _02076_ _02077_ _01954_ VSS VSS VDD
+ VDD _02078_ sky130_fd_sc_hd__a311oi_1
X_22775_ net679 _02074_ _02078_ _01968_ VSS VSS VDD VDD _02079_
+ sky130_fd_sc_hd__a211oi_1
X_22776_ _01968_ _02071_ _02079_ VSS VSS VDD VDD _02080_ sky130_fd_sc_hd__a21oi_1
X_22777_ _01886_ _01892_ VSS VSS VDD VDD _02081_ sky130_fd_sc_hd__nand2_1
X_22778_ _01945_ _02040_ net675 VSS VSS VDD VDD _02082_ sky130_fd_sc_hd__o21ai_0
X_22779_ _02081_ _02082_ _01968_ VSS VSS VDD VDD _02083_ sky130_fd_sc_hd__a21oi_1
X_22780_ net676 _01950_ VSS VSS VDD VDD _02084_ sky130_fd_sc_hd__nand2_1
X_22781_ _02065_ _02084_ _02072_ VSS VSS VDD VDD _02085_ sky130_fd_sc_hd__a21oi_1
X_22782_ net403 _02085_ VSS VSS VDD VDD _02086_ sky130_fd_sc_hd__nor2_1
X_22783_ _02066_ _02076_ _02052_ VSS VSS VDD VDD _02087_ sky130_fd_sc_hd__a21oi_1
X_22784_ net679 _02083_ _02086_ _02087_ VSS VSS VDD VDD _02088_
+ sky130_fd_sc_hd__nor4_1
XTAP_TAPCELL_ROW_4_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22786_ _12410_ _01921_ VSS VSS VDD VDD _02090_ sky130_fd_sc_hd__nor2_2
X_22787_ net677 _01886_ _01929_ VSS VSS VDD VDD _02091_ sky130_fd_sc_hd__nor3_4
X_22788_ _02090_ _02091_ net403 VSS VSS VDD VDD _02092_ sky130_fd_sc_hd__o21ai_0
X_22789_ _01892_ _02066_ _02076_ VSS VSS VDD VDD _02093_ sky130_fd_sc_hd__nand3_1
X_22790_ _12401_ _01958_ _02009_ net675 VSS VSS VDD VDD _02094_
+ sky130_fd_sc_hd__o22ai_1
X_22791_ net678 _02094_ _01954_ VSS VSS VDD VDD _02095_ sky130_fd_sc_hd__o21ai_0
X_22792_ net678 _02092_ _02093_ _02095_ VSS VSS VDD VDD _02096_
+ sky130_fd_sc_hd__a31oi_1
X_22793_ _02040_ _01978_ net402 VSS VSS VDD VDD _02097_ sky130_fd_sc_hd__o21a_1
X_22794_ net405 _01929_ VSS VSS VDD VDD _02098_ sky130_fd_sc_hd__nand2_2
X_22795_ _02025_ _02098_ net402 VSS VSS VDD VDD _02099_ sky130_fd_sc_hd__a21oi_1
X_22796_ _01910_ net678 VSS VSS VDD VDD _02100_ sky130_fd_sc_hd__nor2_4
X_22797_ _02097_ _02099_ _02100_ VSS VSS VDD VDD _02101_ sky130_fd_sc_hd__o21ai_1
X_22798_ net405 _01921_ VSS VSS VDD VDD _02102_ sky130_fd_sc_hd__nor2_4
X_22799_ net404 net402 VSS VSS VDD VDD _02103_ sky130_fd_sc_hd__nand2_1
X_22800_ _02102_ _02081_ _02103_ VSS VSS VDD VDD _02104_ sky130_fd_sc_hd__and3_1
X_22801_ _12396_ _01892_ VSS VSS VDD VDD _02105_ sky130_fd_sc_hd__nand2_1
X_22802_ _02105_ _02103_ _01929_ VSS VSS VDD VDD _02106_ sky130_fd_sc_hd__a21oi_1
X_22803_ _01954_ _01950_ VSS VSS VDD VDD _02107_ sky130_fd_sc_hd__nor2_4
X_22804_ _02104_ _02106_ _02107_ VSS VSS VDD VDD _02108_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_4_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22806_ _12404_ _01892_ _01929_ VSS VSS VDD VDD _02110_ sky130_fd_sc_hd__a21oi_1
X_22807_ _01892_ _02051_ _02110_ VSS VSS VDD VDD _02111_ sky130_fd_sc_hd__o21ai_1
X_22808_ _12420_ _01921_ _01910_ net678 _02111_ VSS VSS VDD
+ VDD _02112_ sky130_fd_sc_hd__o311ai_4
X_22809_ _01900_ _02101_ _02108_ _02112_ VSS VSS VDD VDD _02113_
+ sky130_fd_sc_hd__nand4_1
X_22810_ _01900_ _02088_ _02096_ _02113_ _02033_ VSS VSS VDD
+ VDD _02114_ sky130_fd_sc_hd__o311ai_0
X_22811_ _12396_ _01929_ VSS VSS VDD VDD _02115_ sky130_fd_sc_hd__nor2_1
X_22812_ net402 _02102_ _02115_ VSS VSS VDD VDD _02116_ sky130_fd_sc_hd__nor3_1
X_22813_ _12396_ _01929_ _01941_ VSS VSS VDD VDD _02117_ sky130_fd_sc_hd__a21oi_1
X_22814_ _01974_ _02065_ _01892_ VSS VSS VDD VDD _02118_ sky130_fd_sc_hd__o21ai_1
X_22815_ _01892_ _02117_ _02118_ _01968_ VSS VSS VDD VDD _02119_
+ sky130_fd_sc_hd__o211ai_1
X_22816_ _01968_ _02097_ _02116_ _02119_ VSS VSS VDD VDD _02120_
+ sky130_fd_sc_hd__o31ai_2
XTAP_TAPCELL_ROW_4_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22818_ net404 _01936_ VSS VSS VDD VDD _02122_ sky130_fd_sc_hd__nand2_1
X_22819_ _01974_ _02062_ net403 VSS VSS VDD VDD _02123_ sky130_fd_sc_hd__o21ai_0
X_22820_ _02122_ _02123_ _01968_ VSS VSS VDD VDD _02124_ sky130_fd_sc_hd__a21oi_1
X_22821_ _01929_ _02012_ _01941_ VSS VSS VDD VDD _02125_ sky130_fd_sc_hd__a21oi_1
X_22822_ net403 net678 _02125_ VSS VSS VDD VDD _02126_ sky130_fd_sc_hd__nor3_1
X_22823_ _01892_ _01950_ VSS VSS VDD VDD _02127_ sky130_fd_sc_hd__nor2_1
X_22824_ _12410_ _01921_ VSS VSS VDD VDD _02128_ sky130_fd_sc_hd__nand2_2
X_22825_ _02127_ _02075_ _02128_ VSS VSS VDD VDD _02129_ sky130_fd_sc_hd__and3_1
X_22826_ _02005_ _02033_ VSS VSS VDD VDD _02130_ sky130_fd_sc_hd__nor2_4
X_22827_ _01910_ _02124_ _02126_ _02129_ _02130_ VSS VSS VDD
+ VDD _02131_ sky130_fd_sc_hd__o41ai_1
X_22828_ _01910_ _02120_ _02131_ VSS VSS VDD VDD _02132_ sky130_fd_sc_hd__a21o_1
X_22829_ _02007_ _02080_ _02114_ _02132_ VSS VSS VDD VDD _00137_
+ sky130_fd_sc_hd__o211a_1
X_22830_ _12406_ _01921_ VSS VSS VDD VDD _02133_ sky130_fd_sc_hd__nand2_1
X_22831_ net401 _02133_ VSS VSS VDD VDD _02134_ sky130_fd_sc_hd__nand2_1
X_22832_ _12401_ net401 _02102_ _02134_ _01954_ VSS VSS VDD
+ VDD _02135_ sky130_fd_sc_hd__o221ai_2
X_22833_ _01886_ _01921_ VSS VSS VDD VDD _02136_ sky130_fd_sc_hd__nor2_1
X_22834_ _01892_ _02136_ _01975_ VSS VSS VDD VDD _02137_ sky130_fd_sc_hd__nor3_1
X_22835_ _12410_ _01929_ VSS VSS VDD VDD _02138_ sky130_fd_sc_hd__nor2_1
X_22836_ net401 _01978_ _02138_ VSS VSS VDD VDD _02139_ sky130_fd_sc_hd__nor3_1
X_22837_ net678 _02137_ _02139_ VSS VSS VDD VDD _02140_ sky130_fd_sc_hd__nor3_1
X_22838_ net678 _02135_ _02140_ VSS VSS VDD VDD _02141_ sky130_fd_sc_hd__a21oi_1
X_22839_ _01892_ _02133_ VSS VSS VDD VDD _02142_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_4_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22841_ _01974_ _02065_ net401 VSS VSS VDD VDD _02144_ sky130_fd_sc_hd__o21ai_0
X_22842_ _01974_ _02142_ _02144_ VSS VSS VDD VDD _02145_ sky130_fd_sc_hd__o21ai_0
X_22843_ _01910_ _01968_ VSS VSS VDD VDD _02146_ sky130_fd_sc_hd__nand2_4
X_22844_ _01886_ _01921_ VSS VSS VDD VDD _02147_ sky130_fd_sc_hd__nand2_1
X_22845_ _12406_ _01929_ VSS VSS VDD VDD _02148_ sky130_fd_sc_hd__nand2_2
X_22846_ _12410_ _01921_ net401 VSS VSS VDD VDD _02149_ sky130_fd_sc_hd__a21oi_1
X_22847_ net401 _02147_ _02148_ _02149_ _02098_ VSS VSS VDD
+ VDD _02150_ sky130_fd_sc_hd__a32oi_1
X_22848_ _02146_ _02150_ _02130_ VSS VSS VDD VDD _02151_ sky130_fd_sc_hd__o21ai_0
X_22849_ net678 _02135_ _02145_ _02151_ VSS VSS VDD VDD _02152_
+ sky130_fd_sc_hd__a31oi_1
X_22850_ _01910_ _02141_ _02152_ VSS VSS VDD VDD _02153_ sky130_fd_sc_hd__o21ai_1
X_22851_ net405 _01886_ _01892_ VSS VSS VDD VDD _02154_ sky130_fd_sc_hd__nor3_2
XTAP_TAPCELL_ROW_4_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_22853_ _12417_ _01921_ VSS VSS VDD VDD _02156_ sky130_fd_sc_hd__nand2_1
X_22854_ _01954_ _01968_ VSS VSS VDD VDD _02157_ sky130_fd_sc_hd__nor2_2
X_22855_ _01921_ _02018_ _02154_ _02156_ _02157_ VSS VSS VDD
+ VDD _02158_ sky130_fd_sc_hd__o311ai_1
X_22856_ _12420_ _01929_ VSS VSS VDD VDD _02159_ sky130_fd_sc_hd__nor2_1
X_22857_ _01954_ _01950_ VSS VSS VDD VDD _02160_ sky130_fd_sc_hd__nand2_1
X_22858_ _01929_ _02054_ _01987_ _02159_ _02160_ VSS VSS VDD
+ VDD _02161_ sky130_fd_sc_hd__a311o_1
X_22859_ net405 _01929_ VSS VSS VDD VDD _02162_ sky130_fd_sc_hd__nor2_4
X_22860_ _02162_ _02019_ _12397_ VSS VSS VDD VDD _02163_ sky130_fd_sc_hd__o21a_1
X_22861_ _01991_ _02098_ _01987_ _02072_ VSS VSS VDD VDD _02164_
+ sky130_fd_sc_hd__o22ai_1
X_22862_ _01974_ _02067_ VSS VSS VDD VDD _02165_ sky130_fd_sc_hd__nor2_1
X_22863_ _12404_ _01929_ VSS VSS VDD VDD _02166_ sky130_fd_sc_hd__nand2b_1
X_22864_ net402 _02025_ _02166_ VSS VSS VDD VDD _02167_ sky130_fd_sc_hd__nand3_1
X_22865_ net401 _02165_ _02167_ net679 VSS VSS VDD VDD _02168_
+ sky130_fd_sc_hd__o211ai_2
X_22866_ net679 _02163_ _02164_ _02168_ _01968_ VSS VSS VDD
+ VDD _02169_ sky130_fd_sc_hd__o311ai_1
X_22867_ _02005_ _02158_ _02161_ _02169_ VSS VSS VDD VDD _02170_
+ sky130_fd_sc_hd__nand4_1
X_22868_ _12401_ net401 VSS VSS VDD VDD _02171_ sky130_fd_sc_hd__nor2_1
X_22869_ _02171_ _02154_ _01929_ VSS VSS VDD VDD _02172_ sky130_fd_sc_hd__o21ai_0
X_22870_ _01990_ _02172_ VSS VSS VDD VDD _02173_ sky130_fd_sc_hd__nand2_1
X_22871_ _01921_ _01968_ VSS VSS VDD VDD _02174_ sky130_fd_sc_hd__nand2_1
X_22872_ _12410_ _01892_ VSS VSS VDD VDD _02175_ sky130_fd_sc_hd__and2_0
X_22873_ _12401_ net401 VSS VSS VDD VDD _02176_ sky130_fd_sc_hd__and2_0
X_22874_ _02175_ _02176_ VSS VSS VDD VDD _02177_ sky130_fd_sc_hd__nor2_1
X_22875_ _01929_ _01968_ VSS VSS VDD VDD _02178_ sky130_fd_sc_hd__nand2_1
X_22876_ net612 net401 VSS VSS VDD VDD _02179_ sky130_fd_sc_hd__nor2_1
X_22877_ net405 _02179_ VSS VSS VDD VDD _02180_ sky130_fd_sc_hd__nor2_1
X_22878_ _02174_ _02177_ _02178_ _02180_ _01954_ VSS VSS VDD
+ VDD _02181_ sky130_fd_sc_hd__o221a_1
X_22879_ _01910_ _01950_ VSS VSS VDD VDD _02182_ sky130_fd_sc_hd__nand2_4
X_22880_ _01882_ _01892_ VSS VSS VDD VDD _02183_ sky130_fd_sc_hd__nand2_1
X_22881_ _02040_ _02136_ _02183_ _02034_ _12410_ VSS VSS VDD
+ VDD _02184_ sky130_fd_sc_hd__o32a_1
X_22882_ _12397_ net401 _01921_ VSS VSS VDD VDD _02185_ sky130_fd_sc_hd__nand3_1
X_22883_ net404 _02034_ _02107_ _02185_ VSS VSS VDD VDD _02186_
+ sky130_fd_sc_hd__o211ai_2
X_22884_ _12398_ _01921_ _01892_ VSS VSS VDD VDD _02187_ sky130_fd_sc_hd__o21ai_0
X_22885_ _02162_ _02187_ VSS VSS VDD VDD _02188_ sky130_fd_sc_hd__nor2_1
X_22886_ _02182_ _02184_ _02186_ _02188_ VSS VSS VDD VDD _02189_
+ sky130_fd_sc_hd__o22ai_1
X_22887_ _02173_ _02181_ _02189_ VSS VSS VDD VDD _02190_ sky130_fd_sc_hd__a21oi_1
X_22888_ _02005_ _02190_ _02033_ VSS VSS VDD VDD _02191_ sky130_fd_sc_hd__o21ai_0
X_22889_ _12404_ _01929_ VSS VSS VDD VDD _02192_ sky130_fd_sc_hd__nor2_1
X_22890_ net405 net608 _01929_ VSS VSS VDD VDD _02193_ sky130_fd_sc_hd__o21ai_1
X_22891_ _02192_ _01892_ _02193_ VSS VSS VDD VDD _02194_ sky130_fd_sc_hd__nand3b_1
X_22892_ _01921_ _01935_ VSS VSS VDD VDD _02195_ sky130_fd_sc_hd__nor2_1
X_22893_ _01921_ _02051_ _02195_ VSS VSS VDD VDD _02196_ sky130_fd_sc_hd__a21oi_1
X_22894_ net401 _02196_ VSS VSS VDD VDD _02197_ sky130_fd_sc_hd__nand2_1
X_22895_ _01892_ _01962_ VSS VSS VDD VDD _02198_ sky130_fd_sc_hd__nand2_1
X_22896_ _12415_ _01929_ VSS VSS VDD VDD _02199_ sky130_fd_sc_hd__nand2_1
X_22897_ _01929_ _02198_ _02199_ VSS VSS VDD VDD _02200_ sky130_fd_sc_hd__o21ai_0
X_22898_ _12401_ _01945_ _02165_ net402 _01954_ VSS VSS VDD
+ VDD _02201_ sky130_fd_sc_hd__a221oi_1
X_22899_ net679 _02200_ _02201_ _01968_ VSS VSS VDD VDD _02202_
+ sky130_fd_sc_hd__a211oi_1
X_22900_ _02107_ _02194_ _02197_ _02202_ VSS VSS VDD VDD _02203_
+ sky130_fd_sc_hd__a31oi_1
X_22901_ _12424_ _01921_ VSS VSS VDD VDD _02204_ sky130_fd_sc_hd__nand2_1
X_22902_ _01921_ _02180_ _02204_ VSS VSS VDD VDD _02205_ sky130_fd_sc_hd__o21ai_0
X_22903_ _02005_ _02033_ VSS VSS VDD VDD _02206_ sky130_fd_sc_hd__nand2_2
X_22904_ _02100_ _02205_ _02206_ VSS VSS VDD VDD _02207_ sky130_fd_sc_hd__a21oi_1
X_22905_ _02153_ _02170_ _02191_ _02203_ _02207_ VSS VSS VDD
+ VDD _00138_ sky130_fd_sc_hd__a32oi_1
X_22906_ _01978_ net402 _02017_ VSS VSS VDD VDD _02208_ sky130_fd_sc_hd__nor3b_1
X_22907_ net402 _02020_ _02037_ _02208_ VSS VSS VDD VDD _02209_
+ sky130_fd_sc_hd__a31oi_1
X_22908_ _12396_ _01921_ VSS VSS VDD VDD _02210_ sky130_fd_sc_hd__nor2_1
X_22909_ _01892_ _02147_ _02075_ VSS VSS VDD VDD _02211_ sky130_fd_sc_hd__nand3_1
X_22910_ _01892_ _02192_ _02210_ _02211_ _01968_ VSS VSS VDD
+ VDD _02212_ sky130_fd_sc_hd__o311ai_0
X_22911_ _01968_ _02209_ _02212_ VSS VSS VDD VDD _02213_ sky130_fd_sc_hd__o21ai_1
X_22912_ net405 _02043_ _02052_ VSS VSS VDD VDD _02214_ sky130_fd_sc_hd__o21ai_0
X_22913_ _12397_ _02043_ _02214_ VSS VSS VDD VDD _02215_ sky130_fd_sc_hd__a21oi_1
X_22914_ _01886_ _01968_ VSS VSS VDD VDD _02216_ sky130_fd_sc_hd__nor2_1
X_22915_ _01991_ _02084_ _02183_ _02216_ VSS VSS VDD VDD _02217_
+ sky130_fd_sc_hd__o22ai_1
X_22916_ _01886_ _02127_ _02217_ _01921_ VSS VSS VDD VDD _02218_
+ sky130_fd_sc_hd__a22oi_1
X_22917_ _01921_ _02215_ _02218_ net679 VSS VSS VDD VDD _02219_
+ sky130_fd_sc_hd__o211ai_1
X_22918_ net679 _02213_ _02219_ VSS VSS VDD VDD _02220_ sky130_fd_sc_hd__o21ai_1
X_22919_ net401 _02090_ _01975_ VSS VSS VDD VDD _02221_ sky130_fd_sc_hd__nor3_1
X_22920_ net401 _02020_ _02098_ _02221_ VSS VSS VDD VDD _02222_
+ sky130_fd_sc_hd__a31oi_1
X_22921_ _01923_ _01968_ _02044_ _02179_ _01954_ VSS VSS VDD
+ VDD _02223_ sky130_fd_sc_hd__o41ai_1
X_22922_ _01968_ _02222_ _02223_ VSS VSS VDD VDD _02224_ sky130_fd_sc_hd__a21oi_1
X_22923_ _01921_ _01991_ VSS VSS VDD VDD _02225_ sky130_fd_sc_hd__nand2_1
X_22924_ _02014_ _02225_ net546 VSS VSS VDD VDD _02226_ sky130_fd_sc_hd__a21oi_1
X_22925_ _12397_ _01958_ _02157_ VSS VSS VDD VDD _02227_ sky130_fd_sc_hd__o21ai_0
X_22926_ _12404_ _01923_ _02226_ _02227_ VSS VSS VDD VDD _02228_
+ sky130_fd_sc_hd__a211oi_1
X_22927_ _01921_ _02054_ VSS VSS VDD VDD _02229_ sky130_fd_sc_hd__nor2_1
X_22928_ _12404_ _01892_ _01921_ _02186_ _02229_ VSS VSS VDD
+ VDD _02230_ sky130_fd_sc_hd__a311oi_1
X_22929_ _02224_ _02228_ _02230_ VSS VSS VDD VDD _02231_ sky130_fd_sc_hd__nor3_2
X_22930_ net401 _01921_ _01910_ VSS VSS VDD VDD _02232_ sky130_fd_sc_hd__nor3_1
X_22931_ net401 _02057_ _02232_ VSS VSS VDD VDD _02233_ sky130_fd_sc_hd__a21oi_1
X_22932_ _01910_ _02017_ _01961_ VSS VSS VDD VDD _02234_ sky130_fd_sc_hd__o21ai_0
X_22933_ _12404_ _01958_ _01910_ _01968_ VSS VSS VDD VDD _02235_
+ sky130_fd_sc_hd__o31ai_1
X_22934_ net401 _02234_ _02235_ VSS VSS VDD VDD _02236_ sky130_fd_sc_hd__a21oi_1
X_22935_ _12397_ _02233_ _02236_ VSS VSS VDD VDD _02237_ sky130_fd_sc_hd__o21ai_0
X_22936_ _01921_ _01991_ _02009_ _12406_ _02182_ VSS VSS VDD
+ VDD _02238_ sky130_fd_sc_hd__a221oi_1
X_22937_ net401 _02090_ _02065_ VSS VSS VDD VDD _02239_ sky130_fd_sc_hd__nor3_1
X_22938_ _12397_ _01929_ VSS VSS VDD VDD _02240_ sky130_fd_sc_hd__nor2_1
X_22939_ _01929_ _01935_ _02240_ _01892_ VSS VSS VDD VDD _02241_
+ sky130_fd_sc_hd__a211oi_1
X_22940_ _02160_ _02239_ _02241_ VSS VSS VDD VDD _02242_ sky130_fd_sc_hd__nor3_1
X_22941_ _02005_ _01905_ _02238_ _02242_ VSS VSS VDD VDD _02243_
+ sky130_fd_sc_hd__nor4_1
X_22942_ net401 _02020_ _02148_ VSS VSS VDD VDD _02244_ sky130_fd_sc_hd__nand3_1
X_22943_ _02072_ _02138_ _01892_ VSS VSS VDD VDD _02245_ sky130_fd_sc_hd__o21ai_0
X_22944_ _02244_ _02245_ _02146_ VSS VSS VDD VDD _02246_ sky130_fd_sc_hd__a21oi_1
X_22945_ net401 _02017_ net613 VSS VSS VDD VDD _02247_ sky130_fd_sc_hd__a21oi_1
X_22946_ net405 _01958_ _02034_ _12396_ VSS VSS VDD VDD _02248_
+ sky130_fd_sc_hd__o22ai_1
X_22947_ _02182_ _02247_ _02248_ VSS VSS VDD VDD _02249_ sky130_fd_sc_hd__nor3_1
X_22948_ _01991_ _01910_ _02175_ _02174_ _02130_ VSS VSS VDD
+ VDD _02250_ sky130_fd_sc_hd__o41ai_1
X_22949_ _12406_ net401 _01929_ VSS VSS VDD VDD _02251_ sky130_fd_sc_hd__o21ai_1
X_22950_ net401 _01935_ _02251_ VSS VSS VDD VDD _02252_ sky130_fd_sc_hd__a21oi_2
X_22951_ _02252_ _02160_ _02111_ VSS VSS VDD VDD _02253_ sky130_fd_sc_hd__nor3b_1
X_22952_ _02246_ _02249_ _02250_ _02253_ VSS VSS VDD VDD _02254_
+ sky130_fd_sc_hd__nor4_1
X_22953_ _02237_ _02243_ _02254_ VSS VSS VDD VDD _02255_ sky130_fd_sc_hd__a21oi_1
X_22954_ _02206_ _02220_ _02231_ _02007_ _02255_ VSS VSS VDD
+ VDD _00139_ sky130_fd_sc_hd__o221ai_4
X_22955_ net403 _02102_ _02067_ VSS VSS VDD VDD _02256_ sky130_fd_sc_hd__nor3_1
X_22956_ _01892_ _02148_ _01941_ VSS VSS VDD VDD _02257_ sky130_fd_sc_hd__a21oi_1
X_22957_ _01991_ _02182_ _02256_ _02257_ _02146_ VSS VSS VDD
+ VDD _02258_ sky130_fd_sc_hd__o32ai_1
X_22958_ net546 _02055_ _02105_ _01950_ VSS VSS VDD VDD _02259_
+ sky130_fd_sc_hd__o22ai_1
X_22959_ _01929_ _02259_ VSS VSS VDD VDD _02260_ sky130_fd_sc_hd__nand2_1
X_22960_ net404 _02043_ net405 VSS VSS VDD VDD _02261_ sky130_fd_sc_hd__a21oi_1
X_22961_ _01991_ _02261_ _01921_ VSS VSS VDD VDD _02262_ sky130_fd_sc_hd__o21ai_0
X_22962_ _01886_ _01921_ _01968_ VSS VSS VDD VDD _02263_ sky130_fd_sc_hd__nor3_1
X_22963_ _02127_ _02263_ net405 VSS VSS VDD VDD _02264_ sky130_fd_sc_hd__o21ai_0
X_22964_ _02260_ _02262_ _02264_ _01910_ VSS VSS VDD VDD _02265_
+ sky130_fd_sc_hd__a31oi_1
X_22965_ _02007_ _02258_ _02265_ VSS VSS VDD VDD _02266_ sky130_fd_sc_hd__or3_1
X_22966_ _02018_ _02176_ _01921_ VSS VSS VDD VDD _02267_ sky130_fd_sc_hd__o21ai_1
X_22967_ _02002_ _02267_ _02126_ net679 VSS VSS VDD VDD _02268_
+ sky130_fd_sc_hd__a211oi_1
X_22968_ _12410_ _01958_ _02065_ _01892_ net678 VSS VSS VDD
+ VDD _02269_ sky130_fd_sc_hd__o221ai_1
X_22969_ _02162_ _02035_ _01892_ VSS VSS VDD VDD _02270_ sky130_fd_sc_hd__o21ai_0
X_22970_ _01978_ _02067_ net403 VSS VSS VDD VDD _02271_ sky130_fd_sc_hd__o21ai_0
X_22971_ _01968_ _02270_ _02271_ VSS VSS VDD VDD _02272_ sky130_fd_sc_hd__nand3_1
X_22972_ _02269_ _02272_ _01910_ VSS VSS VDD VDD _02273_ sky130_fd_sc_hd__a21oi_1
X_22973_ _02268_ _02273_ _02130_ VSS VSS VDD VDD _02274_ sky130_fd_sc_hd__o21ai_0
X_22974_ _02005_ _01905_ VSS VSS VDD VDD _02275_ sky130_fd_sc_hd__nor2_2
X_22975_ _01929_ _01962_ VSS VSS VDD VDD _02276_ sky130_fd_sc_hd__nand2_1
X_22976_ _02072_ _02067_ _01892_ VSS VSS VDD VDD _02277_ sky130_fd_sc_hd__o21ai_0
X_22977_ _12398_ _01928_ net679 _02276_ _02277_ VSS VSS VDD
+ VDD _02278_ sky130_fd_sc_hd__o2111ai_2
X_22978_ _12408_ _01921_ VSS VSS VDD VDD _02279_ sky130_fd_sc_hd__nand2_1
X_22979_ _01921_ _01986_ _02279_ _01910_ VSS VSS VDD VDD _02280_
+ sky130_fd_sc_hd__o211ai_2
X_22980_ net678 _02278_ _02280_ VSS VSS VDD VDD _02281_ sky130_fd_sc_hd__nand3_1
X_22981_ _12406_ _01929_ VSS VSS VDD VDD _02282_ sky130_fd_sc_hd__nand2b_1
X_22982_ _02057_ _02282_ VSS VSS VDD VDD _02283_ sky130_fd_sc_hd__nor2b_1
X_22983_ _01923_ _01910_ _01936_ VSS VSS VDD VDD _02284_ sky130_fd_sc_hd__a21oi_1
X_22984_ _01929_ _01991_ _01954_ _02091_ VSS VSS VDD VDD _02285_
+ sky130_fd_sc_hd__a31oi_1
X_22985_ net403 _02283_ _02284_ _01882_ _02285_ VSS VSS VDD
+ VDD _02286_ sky130_fd_sc_hd__o221ai_1
X_22986_ _01968_ _02286_ VSS VSS VDD VDD _02287_ sky130_fd_sc_hd__nand2_1
X_22987_ _02275_ _02281_ _02287_ VSS VSS VDD VDD _02288_ sky130_fd_sc_hd__nand3_1
X_22988_ _12406_ _01892_ _02093_ VSS VSS VDD VDD _02289_ sky130_fd_sc_hd__o21ai_1
X_22989_ _12410_ net401 _01986_ VSS VSS VDD VDD _02290_ sky130_fd_sc_hd__a21boi_0
X_22990_ _02154_ _02251_ _02290_ _01929_ VSS VSS VDD VDD _02291_
+ sky130_fd_sc_hd__o22ai_2
X_22991_ _02182_ _02291_ _01906_ VSS VSS VDD VDD _02292_ sky130_fd_sc_hd__o21ai_1
X_22992_ _12401_ _01929_ VSS VSS VDD VDD _02293_ sky130_fd_sc_hd__nor2_1
X_22993_ _12396_ _01929_ VSS VSS VDD VDD _02294_ sky130_fd_sc_hd__nand2_1
X_22994_ net403 _02294_ VSS VSS VDD VDD _02295_ sky130_fd_sc_hd__nand2_1
X_22995_ net403 _02035_ _02293_ _02295_ _02091_ VSS VSS VDD
+ VDD _02296_ sky130_fd_sc_hd__o32ai_2
X_22996_ _02019_ _02154_ _02178_ VSS VSS VDD VDD _02297_ sky130_fd_sc_hd__nor3_1
X_22997_ _02174_ _02177_ _01954_ VSS VSS VDD VDD _02298_ sky130_fd_sc_hd__o21ai_0
X_22998_ net678 _02296_ _02297_ _02298_ VSS VSS VDD VDD _02299_
+ sky130_fd_sc_hd__a211oi_1
X_22999_ _02107_ _02289_ _02292_ _02299_ VSS VSS VDD VDD _02300_
+ sky130_fd_sc_hd__a211o_1
X_23000_ _02266_ _02274_ _02288_ _02300_ VSS VSS VDD VDD _00140_
+ sky130_fd_sc_hd__nand4_2
X_23001_ _12401_ _01929_ _01936_ _12406_ _01963_ VSS VSS VDD
+ VDD _02301_ sky130_fd_sc_hd__a221oi_1
X_23002_ _02033_ _01968_ VSS VSS VDD VDD _02302_ sky130_fd_sc_hd__nor2_2
X_23003_ _02162_ _02090_ _01892_ VSS VSS VDD VDD _02303_ sky130_fd_sc_hd__o21ai_0
X_23004_ _01981_ _02302_ _02303_ net679 VSS VSS VDD VDD _02304_
+ sky130_fd_sc_hd__a31oi_1
X_23005_ _01892_ _01929_ VSS VSS VDD VDD _02305_ sky130_fd_sc_hd__nor2_1
X_23006_ _12404_ _01945_ _02305_ net404 VSS VSS VDD VDD _02306_
+ sky130_fd_sc_hd__a22oi_1
X_23007_ _01921_ _01968_ VSS VSS VDD VDD _02307_ sky130_fd_sc_hd__nor2_2
X_23008_ _02305_ _02307_ net546 VSS VSS VDD VDD _02308_ sky130_fd_sc_hd__o21ai_0
X_23009_ _02034_ _01968_ _02307_ net546 VSS VSS VDD VDD _02309_
+ sky130_fd_sc_hd__a211oi_1
X_23010_ _01882_ _02174_ VSS VSS VDD VDD _02310_ sky130_fd_sc_hd__nor2_1
X_23011_ _02309_ _02310_ _01886_ VSS VSS VDD VDD _02311_ sky130_fd_sc_hd__o21ai_0
X_23012_ net678 _02306_ _02308_ _02311_ _02033_ VSS VSS VDD
+ VDD _02312_ sky130_fd_sc_hd__o2111ai_1
X_23013_ _02033_ net678 _02301_ _02304_ _02312_ VSS VSS VDD
+ VDD _02313_ sky130_fd_sc_hd__o311a_1
X_23014_ _02033_ _01950_ VSS VSS VDD VDD _02314_ sky130_fd_sc_hd__nand2_1
X_23015_ _12396_ _01921_ _02128_ VSS VSS VDD VDD _02315_ sky130_fd_sc_hd__o21ai_0
X_23016_ _12397_ _02034_ VSS VSS VDD VDD _02316_ sky130_fd_sc_hd__nor2_1
X_23017_ _01892_ _02315_ _02316_ VSS VSS VDD VDD _02317_ sky130_fd_sc_hd__a21oi_1
X_23018_ net403 _02076_ _01943_ VSS VSS VDD VDD _02318_ sky130_fd_sc_hd__a21oi_1
X_23019_ _12398_ _01921_ VSS VSS VDD VDD _02319_ sky130_fd_sc_hd__nand2_1
X_23020_ _02319_ _02066_ net403 VSS VSS VDD VDD _02320_ sky130_fd_sc_hd__a21oi_1
X_23021_ _01882_ _01928_ _02033_ VSS VSS VDD VDD _02321_ sky130_fd_sc_hd__o21ai_0
X_23022_ _02033_ _02318_ _02320_ _02321_ _01968_ VSS VSS VDD
+ VDD _02322_ sky130_fd_sc_hd__o221ai_1
X_23023_ net404 _01932_ _02244_ _02302_ VSS VSS VDD VDD _02323_
+ sky130_fd_sc_hd__o211ai_1
X_23024_ _02314_ _02317_ net679 _02322_ _02323_ VSS VSS VDD
+ VDD _02324_ sky130_fd_sc_hd__o2111ai_1
X_23025_ _02005_ _02324_ VSS VSS VDD VDD _02325_ sky130_fd_sc_hd__nand2_1
X_23026_ _01886_ _01928_ _02091_ VSS VSS VDD VDD _02326_ sky130_fd_sc_hd__a21oi_1
X_23027_ _12401_ _01958_ _02034_ _02051_ _01954_ VSS VSS VDD
+ VDD _02327_ sky130_fd_sc_hd__o221ai_1
X_23028_ net679 _02326_ _02327_ _02073_ net678 VSS VSS VDD
+ VDD _02328_ sky130_fd_sc_hd__o221ai_2
X_23029_ _02128_ _02166_ net402 VSS VSS VDD VDD _02329_ sky130_fd_sc_hd__a21oi_1
X_23030_ _02305_ _02051_ _02329_ VSS VSS VDD VDD _02330_ sky130_fd_sc_hd__a21oi_1
X_23031_ net401 _01943_ _01975_ VSS VSS VDD VDD _02331_ sky130_fd_sc_hd__nor3_1
X_23032_ net401 _02017_ _02075_ _02331_ _02146_ VSS VSS VDD
+ VDD _02332_ sky130_fd_sc_hd__a311oi_1
X_23033_ _02100_ _02330_ _02332_ VSS VSS VDD VDD _02333_ sky130_fd_sc_hd__a21oi_1
X_23034_ net402 _02020_ _02075_ _02329_ _01910_ VSS VSS VDD
+ VDD _02334_ sky130_fd_sc_hd__a311oi_1
X_23035_ _12410_ net402 _01929_ VSS VSS VDD VDD _02335_ sky130_fd_sc_hd__o21ai_0
X_23036_ _01910_ _02003_ _02335_ net678 VSS VSS VDD VDD _02336_
+ sky130_fd_sc_hd__a31o_1
X_23037_ _02162_ _02081_ _02103_ _01935_ _01923_ VSS VSS VDD
+ VDD _02337_ sky130_fd_sc_hd__a32oi_1
X_23038_ net405 _01892_ VSS VSS VDD VDD _02338_ sky130_fd_sc_hd__nor2_1
X_23039_ _12404_ _01929_ _02040_ _02338_ _01910_ VSS VSS VDD
+ VDD _02339_ sky130_fd_sc_hd__a221oi_1
X_23040_ _01910_ _02337_ _02339_ VSS VSS VDD VDD _02340_ sky130_fd_sc_hd__a21oi_1
X_23041_ _02334_ _02336_ _02340_ _01968_ VSS VSS VDD VDD _02341_
+ sky130_fd_sc_hd__o22ai_1
X_23042_ _02130_ _02328_ _02333_ _02341_ _02275_ VSS VSS VDD
+ VDD _02342_ sky130_fd_sc_hd__a32oi_1
X_23043_ _02313_ _02325_ _02342_ VSS VSS VDD VDD _00141_ sky130_fd_sc_hd__o21ai_0
X_23044_ _12397_ _01892_ _02198_ VSS VSS VDD VDD _02343_ sky130_fd_sc_hd__o21a_1
X_23045_ _01929_ _02343_ _02199_ _01968_ VSS VSS VDD VDD _02344_
+ sky130_fd_sc_hd__o211ai_1
X_23046_ _01941_ _01943_ _01892_ VSS VSS VDD VDD _02345_ sky130_fd_sc_hd__o21ai_0
X_23047_ _01892_ _02102_ _02240_ _02345_ net678 VSS VSS VDD
+ VDD _02346_ sky130_fd_sc_hd__o311ai_0
X_23048_ _01910_ _02344_ _02346_ VSS VSS VDD VDD _02347_ sky130_fd_sc_hd__nand3_1
X_23049_ _12404_ _01968_ VSS VSS VDD VDD _02348_ sky130_fd_sc_hd__nand2_1
X_23050_ _12397_ _01950_ VSS VSS VDD VDD _02349_ sky130_fd_sc_hd__nand2_1
X_23051_ _01892_ _01968_ _01935_ VSS VSS VDD VDD _02350_ sky130_fd_sc_hd__nor3_1
X_23052_ _01892_ _02348_ _02349_ _02350_ VSS VSS VDD VDD _02351_
+ sky130_fd_sc_hd__a31oi_1
X_23053_ net610 _01968_ net546 VSS VSS VDD VDD _02352_ sky130_fd_sc_hd__o21ai_0
X_23054_ _01886_ _02043_ _02352_ VSS VSS VDD VDD _02353_ sky130_fd_sc_hd__o21ai_0
X_23055_ _01991_ _02353_ _01929_ VSS VSS VDD VDD _02354_ sky130_fd_sc_hd__o21ai_0
X_23056_ _01929_ _02351_ _02354_ net679 VSS VSS VDD VDD _02355_
+ sky130_fd_sc_hd__o211ai_1
X_23057_ _01886_ _01921_ _01968_ VSS VSS VDD VDD _02356_ sky130_fd_sc_hd__nand3_1
X_23058_ _02020_ _02148_ _01968_ VSS VSS VDD VDD _02357_ sky130_fd_sc_hd__a21oi_1
X_23059_ net401 _02178_ VSS VSS VDD VDD _02358_ sky130_fd_sc_hd__nand2_1
X_23060_ _01882_ _01950_ _01892_ VSS VSS VDD VDD _02359_ sky130_fd_sc_hd__o21ai_0
X_23061_ _02357_ _02358_ _02359_ _02263_ VSS VSS VDD VDD _02360_
+ sky130_fd_sc_hd__o22ai_1
X_23062_ _01905_ _01954_ _02356_ _02360_ _02005_ VSS VSS VDD
+ VDD _02361_ sky130_fd_sc_hd__a41o_1
X_23063_ _02316_ _02239_ VSS VSS VDD VDD _02362_ sky130_fd_sc_hd__or2_0
X_23064_ _12404_ _01921_ VSS VSS VDD VDD _02363_ sky130_fd_sc_hd__nand2_1
X_23065_ _02282_ _02363_ net401 VSS VSS VDD VDD _02364_ sky130_fd_sc_hd__a21oi_1
X_23066_ _01910_ _02063_ _02364_ _01968_ _02033_ VSS VSS VDD
+ VDD _02365_ sky130_fd_sc_hd__o311ai_1
X_23067_ _01910_ _02362_ _02365_ VSS VSS VDD VDD _02366_ sky130_fd_sc_hd__a21oi_1
X_23068_ _12406_ _01892_ _01929_ VSS VSS VDD VDD _02367_ sky130_fd_sc_hd__a21oi_1
X_23069_ _12414_ _01929_ _01987_ _02367_ _01954_ VSS VSS VDD
+ VDD _02368_ sky130_fd_sc_hd__a221oi_2
X_23070_ _01954_ _02172_ _02314_ _02368_ VSS VSS VDD VDD _02369_
+ sky130_fd_sc_hd__a211oi_1
X_23071_ _01991_ _02307_ VSS VSS VDD VDD _02370_ sky130_fd_sc_hd__nand2_1
X_23072_ _01950_ _02138_ net403 VSS VSS VDD VDD _02371_ sky130_fd_sc_hd__o21a_1
X_23073_ _02216_ _02371_ _01882_ VSS VSS VDD VDD _02372_ sky130_fd_sc_hd__o21ai_1
X_23074_ net405 net609 net401 VSS VSS VDD VDD _02373_ sky130_fd_sc_hd__nand3_1
X_23075_ _02147_ _02373_ _12410_ VSS VSS VDD VDD _02374_ sky130_fd_sc_hd__a21oi_1
X_23076_ _02179_ _02229_ _02374_ _01968_ VSS VSS VDD VDD _02375_
+ sky130_fd_sc_hd__o31ai_1
X_23077_ _02370_ _02372_ _02375_ net679 _02033_ VSS VSS VDD
+ VDD _02376_ sky130_fd_sc_hd__a311oi_1
X_23078_ _02361_ _02366_ _02369_ _02376_ VSS VSS VDD VDD _02377_
+ sky130_fd_sc_hd__nor4_1
X_23079_ _01892_ _02193_ _02133_ _01910_ VSS VSS VDD VDD _02378_
+ sky130_fd_sc_hd__a31o_1
X_23080_ net402 _01961_ _02128_ _02378_ VSS VSS VDD VDD _02379_
+ sky130_fd_sc_hd__a31oi_1
X_23081_ net405 net402 _02193_ VSS VSS VDD VDD _02380_ sky130_fd_sc_hd__a21oi_2
X_23082_ _12413_ _12422_ _01929_ VSS VSS VDD VDD _02381_ sky130_fd_sc_hd__nor3_1
X_23083_ _01954_ _02380_ _02381_ VSS VSS VDD VDD _02382_ sky130_fd_sc_hd__nor3_1
X_23084_ _01968_ _02379_ _02382_ VSS VSS VDD VDD _02383_ sky130_fd_sc_hd__nor3_1
X_23085_ net608 _01921_ VSS VSS VDD VDD _02384_ sky130_fd_sc_hd__nand2_1
X_23086_ net401 _02195_ _02240_ VSS VSS VDD VDD _02385_ sky130_fd_sc_hd__nor3_1
X_23087_ net401 _02384_ _02148_ _02385_ VSS VSS VDD VDD _02386_
+ sky130_fd_sc_hd__a31oi_1
X_23088_ _02030_ _02386_ VSS VSS VDD VDD _02387_ sky130_fd_sc_hd__nor2_1
X_23089_ _12396_ _01929_ _02148_ VSS VSS VDD VDD _02388_ sky130_fd_sc_hd__o21ai_0
X_23090_ _12398_ _01945_ _02388_ net401 _02146_ VSS VSS VDD
+ VDD _02389_ sky130_fd_sc_hd__a221oi_1
X_23091_ _02007_ _02383_ _02387_ _02389_ VSS VSS VDD VDD _02390_
+ sky130_fd_sc_hd__nor4_1
X_23092_ _01906_ _02347_ _02355_ _02377_ _02390_ VSS VSS VDD
+ VDD _00142_ sky130_fd_sc_hd__a311o_1
X_23093_ _12408_ _01921_ VSS VSS VDD VDD _02391_ sky130_fd_sc_hd__nor2_1
X_23094_ _12398_ _01892_ _01921_ _02391_ VSS VSS VDD VDD _02392_
+ sky130_fd_sc_hd__a31oi_1
X_23095_ _02157_ _02392_ _02206_ VSS VSS VDD VDD _02393_ sky130_fd_sc_hd__a21oi_1
X_23096_ _12401_ _01892_ VSS VSS VDD VDD _02394_ sky130_fd_sc_hd__nor2_1
X_23097_ _02019_ _02394_ _01929_ VSS VSS VDD VDD _02395_ sky130_fd_sc_hd__o21ai_0
X_23098_ _01991_ _02025_ _02395_ VSS VSS VDD VDD _02396_ sky130_fd_sc_hd__o21ai_1
X_23099_ _01892_ _02162_ _01974_ _02118_ VSS VSS VDD VDD _02397_
+ sky130_fd_sc_hd__o31ai_2
X_23100_ _12406_ net402 _02018_ VSS VSS VDD VDD _02398_ sky130_fd_sc_hd__a21oi_1
X_23101_ _01929_ _02398_ VSS VSS VDD VDD _02399_ sky130_fd_sc_hd__nor2_1
X_23102_ _12422_ _01929_ _02160_ _02399_ VSS VSS VDD VDD _02400_
+ sky130_fd_sc_hd__a211oi_2
X_23103_ _02107_ _02396_ _02397_ _02100_ _02400_ VSS VSS VDD
+ VDD _02401_ sky130_fd_sc_hd__a221oi_4
X_23104_ _01936_ _02307_ _01886_ VSS VSS VDD VDD _02402_ sky130_fd_sc_hd__o21ai_0
X_23105_ net404 _01923_ _01968_ VSS VSS VDD VDD _02403_ sky130_fd_sc_hd__nand3_1
X_23106_ _02402_ _02403_ net546 VSS VSS VDD VDD _02404_ sky130_fd_sc_hd__a21oi_1
X_23107_ _02043_ _02185_ _02275_ VSS VSS VDD VDD _02405_ sky130_fd_sc_hd__nand3_1
X_23108_ net404 _01936_ _01950_ _02033_ VSS VSS VDD VDD _02406_
+ sky130_fd_sc_hd__a211oi_1
X_23109_ _12410_ _02034_ _02009_ _12397_ _02406_ VSS VSS VDD
+ VDD _02407_ sky130_fd_sc_hd__o221ai_1
X_23110_ net403 _02128_ VSS VSS VDD VDD _02408_ sky130_fd_sc_hd__nand2_1
X_23111_ _02102_ _02142_ _02408_ _02072_ _02302_ VSS VSS VDD
+ VDD _02409_ sky130_fd_sc_hd__o221ai_1
X_23112_ _01954_ _02407_ _02409_ VSS VSS VDD VDD _02410_ sky130_fd_sc_hd__and3_1
X_23113_ _02404_ _02405_ _02410_ _02005_ VSS VSS VDD VDD _02411_
+ sky130_fd_sc_hd__o22ai_1
X_23114_ _01892_ _02072_ _02065_ VSS VSS VDD VDD _02412_ sky130_fd_sc_hd__a21oi_1
X_23115_ _12396_ _01923_ VSS VSS VDD VDD _02413_ sky130_fd_sc_hd__nand2_1
X_23116_ net546 _02412_ _02406_ _02413_ VSS VSS VDD VDD _02414_
+ sky130_fd_sc_hd__o211ai_1
X_23117_ _02035_ _02138_ net403 VSS VSS VDD VDD _02415_ sky130_fd_sc_hd__o21ai_1
X_23118_ _12406_ _01932_ _02302_ _02415_ VSS VSS VDD VDD _02416_
+ sky130_fd_sc_hd__o211ai_1
X_23119_ _01932_ _02225_ net546 VSS VSS VDD VDD _02417_ sky130_fd_sc_hd__a21oi_1
X_23120_ _01882_ _02065_ VSS VSS VDD VDD _02418_ sky130_fd_sc_hd__nand2_1
X_23121_ _01936_ _02072_ net546 VSS VSS VDD VDD _02419_ sky130_fd_sc_hd__o21ai_0
X_23122_ net404 _01923_ _01950_ _02040_ VSS VSS VDD VDD _02420_
+ sky130_fd_sc_hd__a211oi_1
X_23123_ _01950_ _02418_ _02419_ _02420_ VSS VSS VDD VDD _02421_
+ sky130_fd_sc_hd__a31oi_1
X_23124_ _02417_ _02421_ _02033_ VSS VSS VDD VDD _02422_ sky130_fd_sc_hd__o21ai_0
X_23125_ _01910_ _02414_ _02416_ _02422_ VSS VSS VDD VDD _02423_
+ sky130_fd_sc_hd__nand4_1
X_23126_ _01882_ _02000_ _01929_ VSS VSS VDD VDD _02424_ sky130_fd_sc_hd__a21oi_1
X_23127_ _02146_ _02252_ _02424_ VSS VSS VDD VDD _02425_ sky130_fd_sc_hd__nor3_1
X_23128_ _12404_ _01929_ _02062_ net401 VSS VSS VDD VDD _02426_
+ sky130_fd_sc_hd__a211o_1
X_23129_ _02157_ _02069_ _02426_ VSS VSS VDD VDD _02427_ sky130_fd_sc_hd__and3_1
X_23130_ _12396_ _01892_ VSS VSS VDD VDD _02428_ sky130_fd_sc_hd__nor2_1
X_23131_ net403 _01941_ _02102_ VSS VSS VDD VDD _02429_ sky130_fd_sc_hd__nor3_1
X_23132_ _02428_ _02429_ _01950_ VSS VSS VDD VDD _02430_ sky130_fd_sc_hd__o21ai_0
X_23133_ _01950_ _02293_ _02380_ _02430_ _01954_ VSS VSS VDD
+ VDD _02431_ sky130_fd_sc_hd__o311ai_0
X_23134_ _02007_ _02425_ _02427_ _02431_ VSS VSS VDD VDD _02432_
+ sky130_fd_sc_hd__nor4b_1
X_23135_ _02393_ _02401_ _02411_ _02423_ _02432_ VSS VSS VDD
+ VDD _00143_ sky130_fd_sc_hd__a221o_1
X_23136_ sa02_sr\[7\] sa02_sr\[0\] sa20_sub\[1\] VSS VSS VDD
+ VDD _02433_ sky130_fd_sc_hd__xor3_1
X_23137_ _11612_ _11613_ _02433_ VSS VSS VDD VDD _02434_ sky130_fd_sc_hd__xnor3_1
X_23138_ net493 text_in_r\[33\] VSS VSS VDD VDD _02435_ sky130_fd_sc_hd__nand2_1
X_23139_ net493 _02434_ _02435_ VSS VSS VDD VDD _02436_ sky130_fd_sc_hd__o21a_1
X_23140_ u0.w\[2\]\[1\] _02436_ VSS VSS VDD VDD _02437_ sky130_fd_sc_hd__xor2_4
X_23141_ net400 VSS VSS VDD VDD _02438_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_4_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23144_ sa12_sr\[0\] sa20_sub\[0\] sa31_sub\[7\] VSS VSS
+ VDD VDD _02440_ sky130_fd_sc_hd__xnor3_1
X_23145_ _07074_ _02440_ VSS VSS VDD VDD _02441_ sky130_fd_sc_hd__xor2_2
X_23146_ text_in_r\[32\] _02441_ _05879_ VSS VSS VDD VDD _02442_
+ sky130_fd_sc_hd__mux2i_4
X_23147_ u0.w\[2\]\[0\] _02442_ VSS VSS VDD VDD _02443_ sky130_fd_sc_hd__xor2_4
X_23148_ net715 VSS VSS VDD VDD _02444_ sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_4_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23150_ sa31_sub\[1\] sa02_sr\[2\] VSS VSS VDD VDD _02445_
+ sky130_fd_sc_hd__xor2_1
X_23151_ _07094_ _02445_ VSS VSS VDD VDD _02446_ sky130_fd_sc_hd__xnor2_2
X_23152_ text_in_r\[34\] _02446_ _05879_ VSS VSS VDD VDD _02447_
+ sky130_fd_sc_hd__mux2i_4
X_23153_ u0.w\[2\]\[2\] _02447_ VSS VSS VDD VDD _02448_ sky130_fd_sc_hd__xnor2_4
X_23154_ net399 VSS VSS VDD VDD _02449_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_4_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23161_ sa20_sub\[7\] _07084_ _09455_ VSS VSS VDD VDD _02453_
+ sky130_fd_sc_hd__xnor3_1
X_23162_ net493 _02453_ VSS VSS VDD VDD _02454_ sky130_fd_sc_hd__nor2_1
X_23163_ net493 text_in_r\[39\] _02454_ VSS VSS VDD VDD _02455_
+ sky130_fd_sc_hd__a21oi_4
X_23164_ u0.w\[2\]\[7\] _02455_ VSS VSS VDD VDD _02456_ sky130_fd_sc_hd__xnor2_4
X_23165_ sa31_sub\[5\] sa02_sr\[6\] VSS VSS VDD VDD _02457_
+ sky130_fd_sc_hd__xnor2_2
X_23166_ _07116_ _02457_ VSS VSS VDD VDD _02458_ sky130_fd_sc_hd__xnor2_4
X_23167_ net493 text_in_r\[38\] VSS VSS VDD VDD _02459_ sky130_fd_sc_hd__nand2_1
X_23168_ net493 _02458_ _02459_ VSS VSS VDD VDD _02460_ sky130_fd_sc_hd__o21ai_2
X_23169_ u0.w\[2\]\[6\] _02460_ VSS VSS VDD VDD _02461_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_4_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23171_ sa02_sr\[4\] sa20_sub\[5\] VSS VSS VDD VDD _02463_
+ sky130_fd_sc_hd__xnor2_2
X_23172_ _11635_ _02463_ VSS VSS VDD VDD _02464_ sky130_fd_sc_hd__xnor2_4
X_23173_ net493 _02464_ VSS VSS VDD VDD _02465_ sky130_fd_sc_hd__nor2_4
X_23174_ net530 text_in_r\[37\] _02465_ VSS VSS VDD VDD _02466_
+ sky130_fd_sc_hd__a21oi_4
X_23175_ u0.w\[2\]\[5\] _02466_ VSS VSS VDD VDD _02467_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_4_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23178_ _07135_ _11665_ _11666_ VSS VSS VDD VDD _02470_ sky130_fd_sc_hd__xor3_4
X_23179_ text_in_r\[36\] _02470_ _05879_ VSS VSS VDD VDD _02471_
+ sky130_fd_sc_hd__mux2i_4
X_23180_ u0.w\[2\]\[4\] _02471_ VSS VSS VDD VDD _02472_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_4_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23183_ _07148_ _11646_ _11647_ VSS VSS VDD VDD _02475_ sky130_fd_sc_hd__xnor3_4
X_23184_ text_in_r\[35\] net530 VSS VSS VDD VDD _02476_ sky130_fd_sc_hd__nand2b_1
X_23185_ net530 _02475_ _02476_ u0.w\[2\]\[3\] VSS VSS VDD
+ VDD _02477_ sky130_fd_sc_hd__o211a_2
X_23186_ net530 text_in_r\[35\] VSS VSS VDD VDD _02478_ sky130_fd_sc_hd__and2_0
X_23187_ _05879_ _02475_ _02478_ u0.w\[2\]\[3\] VSS VSS VDD
+ VDD _02479_ sky130_fd_sc_hd__a211oi_4
X_23188_ _02477_ _02479_ VSS VSS VDD VDD _02480_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_4_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23192_ net400 net717 VSS VSS VDD VDD _02484_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_3_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23194_ _02444_ net398 VSS VSS VDD VDD _02486_ sky130_fd_sc_hd__nand2_2
X_23195_ _02484_ _02486_ VSS VSS VDD VDD _02487_ sky130_fd_sc_hd__nand2_1
X_23196_ net615 _02487_ VSS VSS VDD VDD _02488_ sky130_fd_sc_hd__xnor2_1
X_23197_ _02479_ _02477_ VSS VSS VDD VDD _02489_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_3_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23200_ _02438_ _02444_ _02489_ VSS VSS VDD VDD _02492_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_3_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23203_ _12428_ _02480_ VSS VSS VDD VDD _02495_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_3_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23207_ _12429_ _02480_ VSS VSS VDD VDD _02499_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_3_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23209_ _12436_ net615 _02499_ net399 VSS VSS VDD VDD _02501_
+ sky130_fd_sc_hd__o211ai_1
X_23210_ net399 _02492_ _02495_ _02472_ _02501_ VSS VSS VDD
+ VDD _02502_ sky130_fd_sc_hd__o311ai_0
X_23211_ _02472_ _02488_ _02502_ VSS VSS VDD VDD _02503_ sky130_fd_sc_hd__o21ai_0
X_23212_ u0.w\[2\]\[4\] _02471_ VSS VSS VDD VDD _02504_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_3_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23215_ net400 _02480_ VSS VSS VDD VDD _02507_ sky130_fd_sc_hd__nand2_4
X_23216_ _12429_ net399 VSS VSS VDD VDD _02508_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_3_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23219_ _02438_ net399 VSS VSS VDD VDD _02511_ sky130_fd_sc_hd__nor2_1
X_23220_ _02511_ _02499_ VSS VSS VDD VDD _02512_ sky130_fd_sc_hd__nor2_1
X_23221_ _02507_ _02508_ _02512_ VSS VSS VDD VDD _02513_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_3_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23223_ _02449_ _02480_ VSS VSS VDD VDD _02515_ sky130_fd_sc_hd__nand2_8
X_23224_ net397 _02489_ VSS VSS VDD VDD _02516_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_3_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23227_ _12429_ net399 _02489_ VSS VSS VDD VDD _02519_ sky130_fd_sc_hd__nand3_1
X_23228_ _12436_ _02515_ _02516_ _12428_ _02519_ VSS VSS VDD
+ VDD _02520_ sky130_fd_sc_hd__o221ai_1
X_23229_ _02504_ _02520_ VSS VSS VDD VDD _02521_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_3_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23231_ _02504_ _02513_ _02521_ _02467_ VSS VSS VDD VDD _02523_
+ sky130_fd_sc_hd__a211oi_1
X_23232_ _02467_ _02503_ _02523_ VSS VSS VDD VDD _02524_ sky130_fd_sc_hd__a21oi_1
X_23233_ u0.w\[2\]\[5\] _02466_ VSS VSS VDD VDD _02525_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_3_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23240_ net397 _02489_ VSS VSS VDD VDD _02532_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_2_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23244_ net717 _02449_ VSS VSS VDD VDD _02536_ sky130_fd_sc_hd__nand2_1
X_23245_ _02438_ net751 VSS VSS VDD VDD _02537_ sky130_fd_sc_hd__nor2_2
X_23246_ _12433_ _02532_ _02536_ _02537_ VSS VSS VDD VDD _02538_
+ sky130_fd_sc_hd__o22ai_1
XTAP_TAPCELL_ROW_2_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23249_ net721 _02489_ VSS VSS VDD VDD _02541_ sky130_fd_sc_hd__nor2_1
X_23250_ _12442_ _02480_ VSS VSS VDD VDD _02542_ sky130_fd_sc_hd__nor2_4
X_23251_ _02444_ net751 VSS VSS VDD VDD _02543_ sky130_fd_sc_hd__nand2_4
X_23252_ net399 _02541_ _02542_ _02519_ _02543_ VSS VSS VDD
+ VDD _02544_ sky130_fd_sc_hd__o311ai_0
X_23253_ _02472_ _02544_ VSS VSS VDD VDD _02545_ sky130_fd_sc_hd__nor2_1
X_23254_ _02472_ _02538_ _02545_ VSS VSS VDD VDD _02546_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_2_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23258_ net398 net751 VSS VSS VDD VDD _02550_ sky130_fd_sc_hd__nand2_1
X_23259_ _02448_ _02489_ VSS VSS VDD VDD _02551_ sky130_fd_sc_hd__nor2_4
X_23260_ net614 _02449_ net751 VSS VSS VDD VDD _02552_ sky130_fd_sc_hd__nor3_1
X_23261_ _02551_ _02552_ _02438_ VSS VSS VDD VDD _02553_ sky130_fd_sc_hd__o21ai_0
X_23262_ net714 _02449_ _02489_ VSS VSS VDD VDD _02554_ sky130_fd_sc_hd__nand3_2
X_23263_ _12430_ _02550_ _02553_ _02554_ _02472_ VSS VSS VDD
+ VDD _02555_ sky130_fd_sc_hd__o2111ai_1
X_23264_ _02438_ _02489_ VSS VSS VDD VDD _02556_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_2_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23267_ _12442_ _02489_ VSS VSS VDD VDD _02559_ sky130_fd_sc_hd__nand2_1
X_23268_ _02438_ _02480_ VSS VSS VDD VDD _02560_ sky130_fd_sc_hd__nand2_4
X_23269_ net398 _02559_ _02560_ VSS VSS VDD VDD _02561_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_2_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23272_ _02556_ _02536_ _02561_ _02504_ VSS VSS VDD VDD _02564_
+ sky130_fd_sc_hd__o211ai_1
X_23273_ u0.w\[2\]\[7\] _02455_ VSS VSS VDD VDD _02565_ sky130_fd_sc_hd__xor2_4
X_23274_ _02565_ _02461_ VSS VSS VDD VDD _02566_ sky130_fd_sc_hd__nand2_4
X_23275_ _02525_ _02555_ _02564_ _02566_ VSS VSS VDD VDD _02567_
+ sky130_fd_sc_hd__a31oi_1
X_23276_ _02525_ _02546_ _02567_ VSS VSS VDD VDD _02568_ sky130_fd_sc_hd__o21ai_1
X_23277_ _02461_ VSS VSS VDD VDD _02569_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_2_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23279_ net723 _02449_ _02480_ VSS VSS VDD VDD _02571_ sky130_fd_sc_hd__o21ai_0
X_23280_ _12430_ _12433_ VSS VSS VDD VDD _02572_ sky130_fd_sc_hd__nor2_1
X_23281_ _02449_ net751 VSS VSS VDD VDD _02573_ sky130_fd_sc_hd__nor2_4
X_23282_ net614 _02571_ _02572_ _02551_ _02573_ VSS VSS VDD
+ VDD _02574_ sky130_fd_sc_hd__a221oi_1
X_23283_ _12428_ _02532_ _02472_ VSS VSS VDD VDD _02575_ sky130_fd_sc_hd__o21ai_1
X_23284_ _12449_ net750 _02551_ _12429_ _02472_ VSS VSS VDD
+ VDD _02576_ sky130_fd_sc_hd__a221o_1
X_23285_ _02574_ _02575_ _02525_ _02576_ VSS VSS VDD VDD _02577_
+ sky130_fd_sc_hd__o211ai_1
X_23286_ _02569_ _02577_ _02565_ VSS VSS VDD VDD _02578_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_2_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23288_ _12430_ _02489_ VSS VSS VDD VDD _02580_ sky130_fd_sc_hd__nor2_1
X_23289_ net400 _02444_ net751 VSS VSS VDD VDD _02581_ sky130_fd_sc_hd__nor3_2
X_23290_ _02449_ _02580_ _02581_ VSS VSS VDD VDD _02582_ sky130_fd_sc_hd__nor3_2
XTAP_TAPCELL_ROW_2_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23292_ net398 _02480_ VSS VSS VDD VDD _02584_ sky130_fd_sc_hd__nor2_4
X_23293_ _12438_ _02584_ VSS VSS VDD VDD _02585_ sky130_fd_sc_hd__nand2_1
X_23294_ _02472_ _02585_ VSS VSS VDD VDD _02586_ sky130_fd_sc_hd__nand2_1
X_23295_ _02438_ net718 _02480_ VSS VSS VDD VDD _02587_ sky130_fd_sc_hd__nand3_1
X_23296_ _12430_ net615 _02587_ net398 VSS VSS VDD VDD _02588_
+ sky130_fd_sc_hd__o211ai_1
X_23297_ _12436_ _02515_ _02588_ _02504_ VSS VSS VDD VDD _02589_
+ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_2_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23299_ _02565_ _02525_ VSS VSS VDD VDD _02591_ sky130_fd_sc_hd__nor2_1
X_23300_ _02582_ _02586_ _02589_ _02591_ VSS VSS VDD VDD _02592_
+ sky130_fd_sc_hd__o211a_1
X_23301_ net718 _02480_ VSS VSS VDD VDD _02593_ sky130_fd_sc_hd__nor2_2
X_23302_ _12429_ net615 VSS VSS VDD VDD _02594_ sky130_fd_sc_hd__nand2b_4
X_23303_ _12436_ net615 _02594_ _02449_ VSS VSS VDD VDD _02595_
+ sky130_fd_sc_hd__o211ai_1
X_23304_ _02449_ _02556_ _02593_ _02595_ _02472_ VSS VSS VDD
+ VDD _02596_ sky130_fd_sc_hd__o311a_1
X_23305_ _12430_ _02480_ VSS VSS VDD VDD _02597_ sky130_fd_sc_hd__nand2_1
X_23306_ _12433_ _02489_ VSS VSS VDD VDD _02598_ sky130_fd_sc_hd__nand2_2
X_23307_ net398 _02597_ _02598_ VSS VSS VDD VDD _02599_ sky130_fd_sc_hd__and3_1
X_23308_ _12428_ _02551_ _02599_ _02472_ VSS VSS VDD VDD _02600_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_2_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23310_ _02438_ _02444_ net751 VSS VSS VDD VDD _02602_ sky130_fd_sc_hd__a21oi_2
X_23311_ _12433_ net750 _02602_ _02449_ _02554_ VSS VSS VDD
+ VDD _02603_ sky130_fd_sc_hd__o221ai_1
X_23312_ _12433_ _02515_ _02504_ VSS VSS VDD VDD _02604_ sky130_fd_sc_hd__o21ai_0
X_23313_ _12429_ _02477_ _02479_ VSS VSS VDD VDD _02605_ sky130_fd_sc_hd__nor3_2
X_23314_ _12438_ _02489_ VSS VSS VDD VDD _02606_ sky130_fd_sc_hd__nor2_2
X_23315_ _02605_ _02606_ net399 VSS VSS VDD VDD _02607_ sky130_fd_sc_hd__o21a_1
X_23316_ _02504_ _02603_ _02604_ _02607_ _02525_ VSS VSS VDD
+ VDD _02608_ sky130_fd_sc_hd__o221ai_1
X_23317_ _02525_ _02596_ _02600_ _02608_ VSS VSS VDD VDD _02609_
+ sky130_fd_sc_hd__o31a_1
X_23318_ _02578_ _02592_ _02609_ _02569_ VSS VSS VDD VDD _02610_
+ sky130_fd_sc_hd__o22ai_2
X_23319_ _02456_ _02461_ _02524_ _02568_ _02610_ VSS VSS VDD
+ VDD _00144_ sky130_fd_sc_hd__o311ai_4
X_23320_ _02456_ _02461_ VSS VSS VDD VDD _02611_ sky130_fd_sc_hd__nor2_4
X_23321_ _02438_ _02489_ VSS VSS VDD VDD _02612_ sky130_fd_sc_hd__nand2_4
X_23322_ _02444_ _02449_ VSS VSS VDD VDD _02613_ sky130_fd_sc_hd__nor2_1
X_23323_ net715 net397 VSS VSS VDD VDD _02614_ sky130_fd_sc_hd__nor2_2
X_23324_ _12428_ net614 net398 VSS VSS VDD VDD _02615_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_2_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23326_ _02612_ _02613_ _02614_ _02615_ net750 VSS VSS VDD
+ VDD _02617_ sky130_fd_sc_hd__o32ai_1
X_23327_ net721 _02489_ VSS VSS VDD VDD _02618_ sky130_fd_sc_hd__nand2_1
X_23328_ _12433_ _02477_ _02479_ VSS VSS VDD VDD _02619_ sky130_fd_sc_hd__nor3_2
X_23329_ _02444_ net751 _02619_ _02449_ VSS VSS VDD VDD _02620_
+ sky130_fd_sc_hd__a211oi_1
X_23330_ _02449_ _02560_ _02618_ _02620_ _02467_ VSS VSS VDD
+ VDD _02621_ sky130_fd_sc_hd__a311oi_1
X_23331_ _02467_ _02617_ _02621_ VSS VSS VDD VDD _02622_ sky130_fd_sc_hd__a21oi_1
X_23332_ _02438_ _02444_ net398 VSS VSS VDD VDD _02623_ sky130_fd_sc_hd__nand3_1
X_23333_ _12436_ _02449_ VSS VSS VDD VDD _02624_ sky130_fd_sc_hd__nand2_1
X_23334_ _12452_ _02467_ net615 VSS VSS VDD VDD _02625_ sky130_fd_sc_hd__nor3_1
X_23335_ net615 _02623_ _02624_ _02625_ _02504_ VSS VSS VDD
+ VDD _02626_ sky130_fd_sc_hd__a311o_1
X_23336_ net396 _02622_ _02626_ VSS VSS VDD VDD _02627_ sky130_fd_sc_hd__o21ai_0
X_23337_ _12442_ _02584_ VSS VSS VDD VDD _02628_ sky130_fd_sc_hd__nand2_1
X_23338_ net722 net615 VSS VSS VDD VDD _02629_ sky130_fd_sc_hd__nor2_1
X_23339_ _02492_ _02629_ net399 VSS VSS VDD VDD _02630_ sky130_fd_sc_hd__o21ai_0
X_23340_ _02467_ _02504_ VSS VSS VDD VDD _02631_ sky130_fd_sc_hd__nand2_1
X_23341_ _02628_ _02630_ _02631_ VSS VSS VDD VDD _02632_ sky130_fd_sc_hd__a21oi_1
X_23342_ _02456_ _02461_ VSS VSS VDD VDD _02633_ sky130_fd_sc_hd__nand2_4
X_23343_ _02525_ _02504_ VSS VSS VDD VDD _02634_ sky130_fd_sc_hd__nand2_1
X_23344_ _12429_ _02489_ VSS VSS VDD VDD _02635_ sky130_fd_sc_hd__nand2_2
X_23345_ _12428_ net751 VSS VSS VDD VDD _02636_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_2_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23347_ _02635_ _02636_ _02449_ VSS VSS VDD VDD _02638_ sky130_fd_sc_hd__a21oi_1
X_23348_ _02449_ _02598_ _02543_ VSS VSS VDD VDD _02639_ sky130_fd_sc_hd__and3_1
X_23349_ _12433_ net615 _02605_ _02449_ VSS VSS VDD VDD _02640_
+ sky130_fd_sc_hd__a211o_1
X_23350_ net399 _02602_ _02640_ VSS VSS VDD VDD _02641_ sky130_fd_sc_hd__o21ai_0
X_23351_ _02467_ _02472_ VSS VSS VDD VDD _02642_ sky130_fd_sc_hd__nand2_1
X_23352_ _02634_ _02638_ _02639_ _02641_ _02642_ VSS VSS VDD
+ VDD _02643_ sky130_fd_sc_hd__o32ai_1
XTAP_TAPCELL_ROW_2_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23354_ _12429_ _02449_ VSS VSS VDD VDD _02644_ sky130_fd_sc_hd__nand2_1
X_23355_ net750 _02644_ _02516_ _02444_ VSS VSS VDD VDD _02645_
+ sky130_fd_sc_hd__o22ai_1
X_23356_ _02525_ _02472_ VSS VSS VDD VDD _02646_ sky130_fd_sc_hd__nand2_4
X_23357_ net722 _02593_ _02645_ _02646_ VSS VSS VDD VDD _02647_
+ sky130_fd_sc_hd__a211oi_1
X_23358_ _02632_ _02633_ _02643_ _02647_ VSS VSS VDD VDD _02648_
+ sky130_fd_sc_hd__nor4_1
X_23359_ _02611_ _02627_ _02648_ VSS VSS VDD VDD _02649_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_2_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23361_ _12429_ _02477_ _02479_ VSS VSS VDD VDD _02651_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_2_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23363_ _12433_ _02489_ _02651_ VSS VSS VDD VDD _02653_ sky130_fd_sc_hd__o21ai_1
X_23364_ net397 _02653_ VSS VSS VDD VDD _02654_ sky130_fd_sc_hd__nor2_1
X_23365_ net716 _02480_ VSS VSS VDD VDD _02655_ sky130_fd_sc_hd__nand2_4
X_23366_ net400 _02655_ VSS VSS VDD VDD _02656_ sky130_fd_sc_hd__nor2_1
X_23367_ _02449_ _02656_ _02542_ VSS VSS VDD VDD _02657_ sky130_fd_sc_hd__nor3_1
X_23368_ _12433_ _02515_ _02516_ net400 VSS VSS VDD VDD _02658_
+ sky130_fd_sc_hd__o22ai_1
X_23369_ net395 _02658_ VSS VSS VDD VDD _02659_ sky130_fd_sc_hd__nand2_1
X_23370_ net395 _02654_ _02657_ _02659_ _02525_ VSS VSS VDD
+ VDD _02660_ sky130_fd_sc_hd__o311ai_1
X_23371_ _02565_ _02461_ VSS VSS VDD VDD _02661_ sky130_fd_sc_hd__nor2_1
X_23372_ _02525_ net396 VSS VSS VDD VDD _02662_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_2_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23374_ net715 _02489_ VSS VSS VDD VDD _02664_ sky130_fd_sc_hd__nand2_1
X_23375_ _02449_ _02664_ _02543_ VSS VSS VDD VDD _02665_ sky130_fd_sc_hd__nand3_1
X_23376_ _02449_ _02653_ _02665_ VSS VSS VDD VDD _02666_ sky130_fd_sc_hd__o21ai_0
X_23377_ _02662_ _02666_ VSS VSS VDD VDD _02667_ sky130_fd_sc_hd__nand2_1
X_23378_ _02525_ net395 VSS VSS VDD VDD _02668_ sky130_fd_sc_hd__nor2_4
X_23379_ _02444_ _02480_ VSS VSS VDD VDD _02669_ sky130_fd_sc_hd__nor2_2
X_23380_ net397 _02669_ _02438_ VSS VSS VDD VDD _02670_ sky130_fd_sc_hd__o21ai_0
X_23381_ _02438_ _02655_ _02668_ _02670_ _02532_ VSS VSS VDD
+ VDD _02671_ sky130_fd_sc_hd__o2111ai_1
X_23382_ _02660_ _02661_ _02667_ _02671_ VSS VSS VDD VDD _02672_
+ sky130_fd_sc_hd__nand4_1
X_23383_ _02438_ _02444_ net751 VSS VSS VDD VDD _02673_ sky130_fd_sc_hd__nand3_4
X_23384_ _02651_ _02673_ _02449_ VSS VSS VDD VDD _02674_ sky130_fd_sc_hd__a21oi_1
X_23385_ _02444_ _02515_ VSS VSS VDD VDD _02675_ sky130_fd_sc_hd__nor2_1
X_23386_ _12428_ net750 _02612_ _02449_ VSS VSS VDD VDD _02676_
+ sky130_fd_sc_hd__o211ai_1
X_23387_ net397 _02655_ _02598_ VSS VSS VDD VDD _02677_ sky130_fd_sc_hd__nand3_1
X_23388_ _02668_ _02676_ _02677_ _02566_ VSS VSS VDD VDD _02678_
+ sky130_fd_sc_hd__a31oi_1
X_23389_ _02655_ _02651_ net397 VSS VSS VDD VDD _02679_ sky130_fd_sc_hd__a21oi_1
X_23390_ _12430_ net615 VSS VSS VDD VDD _02680_ sky130_fd_sc_hd__nand2b_1
X_23391_ _12428_ net750 VSS VSS VDD VDD _02681_ sky130_fd_sc_hd__nand2_1
X_23392_ _02680_ _02681_ _02449_ VSS VSS VDD VDD _02682_ sky130_fd_sc_hd__a21oi_1
X_23393_ _02525_ _02679_ _02682_ VSS VSS VDD VDD _02683_ sky130_fd_sc_hd__nor3_1
X_23394_ _12442_ net751 VSS VSS VDD VDD _02684_ sky130_fd_sc_hd__nand2_4
X_23395_ _02438_ _02444_ _02489_ VSS VSS VDD VDD _02685_ sky130_fd_sc_hd__nand3_1
X_23396_ _02680_ _02685_ net397 VSS VSS VDD VDD _02686_ sky130_fd_sc_hd__a21oi_1
X_23397_ net397 _02651_ _02684_ _02686_ _02467_ VSS VSS VDD
+ VDD _02687_ sky130_fd_sc_hd__a311oi_1
X_23398_ _02683_ _02687_ net395 VSS VSS VDD VDD _02688_ sky130_fd_sc_hd__o21ai_0
X_23399_ _02646_ _02674_ _02675_ _02678_ _02688_ VSS VSS VDD
+ VDD _02689_ sky130_fd_sc_hd__o311ai_0
X_23400_ _02649_ _02672_ _02689_ VSS VSS VDD VDD _00145_ sky130_fd_sc_hd__and3_1
X_23401_ _12430_ _02489_ VSS VSS VDD VDD _02690_ sky130_fd_sc_hd__nand2_2
X_23402_ _02690_ _02507_ VSS VSS VDD VDD _02691_ sky130_fd_sc_hd__nand2_1
X_23403_ _02444_ _02489_ VSS VSS VDD VDD _02692_ sky130_fd_sc_hd__nand2_2
X_23404_ _02692_ _02499_ _02449_ VSS VSS VDD VDD _02693_ sky130_fd_sc_hd__a21oi_1
X_23405_ _02449_ _02691_ _02693_ VSS VSS VDD VDD _02694_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_1_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23407_ _02438_ _02449_ _02664_ _02543_ VSS VSS VDD VDD _02696_
+ sky130_fd_sc_hd__nand4_1
X_23408_ _12442_ _02532_ _02696_ net396 VSS VSS VDD VDD _02697_
+ sky130_fd_sc_hd__o211ai_1
X_23409_ net396 _02694_ _02697_ VSS VSS VDD VDD _02698_ sky130_fd_sc_hd__o21ai_0
X_23410_ _02438_ net399 VSS VSS VDD VDD _02699_ sky130_fd_sc_hd__nand2_1
X_23411_ _02438_ net716 VSS VSS VDD VDD _02700_ sky130_fd_sc_hd__nand2_1
X_23412_ _12433_ _02449_ VSS VSS VDD VDD _02701_ sky130_fd_sc_hd__nand2b_1
X_23413_ _02532_ _02700_ _02701_ net615 net396 VSS VSS VDD
+ VDD _02702_ sky130_fd_sc_hd__o221ai_2
X_23414_ net615 _02644_ _02699_ _02702_ VSS VSS VDD VDD _02703_
+ sky130_fd_sc_hd__a31oi_1
X_23415_ _02449_ _02489_ VSS VSS VDD VDD _02704_ sky130_fd_sc_hd__nor2_4
X_23416_ _02692_ _02684_ net397 VSS VSS VDD VDD _02705_ sky130_fd_sc_hd__a21oi_1
X_23417_ _12433_ _02704_ _02705_ _02537_ VSS VSS VDD VDD _02706_
+ sky130_fd_sc_hd__a211oi_1
X_23418_ net396 _02706_ _02525_ VSS VSS VDD VDD _02707_ sky130_fd_sc_hd__o21ai_1
X_23419_ _02525_ _02698_ _02703_ _02707_ VSS VSS VDD VDD _02708_
+ sky130_fd_sc_hd__o22ai_1
X_23420_ _12438_ _02480_ VSS VSS VDD VDD _02709_ sky130_fd_sc_hd__nand2_1
X_23421_ _02651_ _02709_ net397 VSS VSS VDD VDD _02710_ sky130_fd_sc_hd__a21oi_1
X_23422_ net397 _02655_ _02651_ _02710_ VSS VSS VDD VDD _02711_
+ sky130_fd_sc_hd__a31oi_1
X_23423_ _02449_ _02669_ _02606_ VSS VSS VDD VDD _02712_ sky130_fd_sc_hd__nor3_1
X_23424_ _12442_ _02489_ VSS VSS VDD VDD _02713_ sky130_fd_sc_hd__nor2_1
X_23425_ net397 _02619_ _02713_ VSS VSS VDD VDD _02714_ sky130_fd_sc_hd__nor3_1
X_23426_ _02712_ _02714_ net395 VSS VSS VDD VDD _02715_ sky130_fd_sc_hd__o21ai_1
X_23427_ net397 _02612_ _02709_ VSS VSS VDD VDD _02716_ sky130_fd_sc_hd__nand3_1
X_23428_ net396 _02716_ _02701_ _02467_ VSS VSS VDD VDD _02717_
+ sky130_fd_sc_hd__a31oi_1
X_23429_ _12442_ _02480_ VSS VSS VDD VDD _02718_ sky130_fd_sc_hd__nand2b_1
X_23430_ _02444_ _02489_ VSS VSS VDD VDD _02719_ sky130_fd_sc_hd__nor2_1
X_23431_ _12438_ net751 VSS VSS VDD VDD _02720_ sky130_fd_sc_hd__nor2_1
X_23432_ _02449_ _02719_ _02720_ VSS VSS VDD VDD _02721_ sky130_fd_sc_hd__nor3_1
X_23433_ _02449_ _02612_ _02718_ _02721_ VSS VSS VDD VDD _02722_
+ sky130_fd_sc_hd__a31oi_1
X_23434_ _02668_ _02711_ _02715_ _02717_ _02722_ _02662_ VSS
+ VSS VDD VDD _02723_ sky130_fd_sc_hd__a222oi_1
X_23435_ _02489_ _02572_ VSS VSS VDD VDD _02724_ sky130_fd_sc_hd__nand2_2
X_23436_ _02673_ _02724_ _02449_ VSS VSS VDD VDD _02725_ sky130_fd_sc_hd__a21oi_1
X_23437_ _12436_ net615 VSS VSS VDD VDD _02726_ sky130_fd_sc_hd__nand2_1
X_23438_ _02685_ _02726_ net397 VSS VSS VDD VDD _02727_ sky130_fd_sc_hd__a21oi_1
X_23439_ _02725_ _02727_ _02504_ VSS VSS VDD VDD _02728_ sky130_fd_sc_hd__o21ai_0
X_23440_ net397 _02651_ _02636_ _02584_ _12433_ VSS VSS VDD
+ VDD _02729_ sky130_fd_sc_hd__a32oi_1
X_23441_ net396 _02729_ VSS VSS VDD VDD _02730_ sky130_fd_sc_hd__nand2_1
X_23442_ _12447_ net750 net395 VSS VSS VDD VDD _02731_ sky130_fd_sc_hd__a21oi_1
X_23443_ _02515_ _02700_ _02731_ VSS VSS VDD VDD _02732_ sky130_fd_sc_hd__o21ai_0
X_23444_ _12456_ net750 _02612_ _02614_ net395 VSS VSS VDD
+ VDD _02733_ sky130_fd_sc_hd__o221ai_1
X_23445_ _02732_ _02733_ _02467_ VSS VSS VDD VDD _02734_ sky130_fd_sc_hd__a21oi_1
X_23446_ _02456_ _02569_ VSS VSS VDD VDD _02735_ sky130_fd_sc_hd__nand2_4
X_23447_ _02467_ _02728_ _02730_ _02734_ _02735_ VSS VSS VDD
+ VDD _02736_ sky130_fd_sc_hd__a311o_1
X_23448_ _02566_ _02723_ _02736_ VSS VSS VDD VDD _02737_ sky130_fd_sc_hd__o21ai_0
X_23449_ _02438_ net614 net399 net615 _02508_ VSS VSS VDD
+ VDD _02738_ sky130_fd_sc_hd__a311oi_1
X_23450_ _12449_ net615 _02738_ VSS VSS VDD VDD _02739_ sky130_fd_sc_hd__a21oi_1
X_23451_ _02699_ _02593_ _02537_ _02486_ VSS VSS VDD VDD _02740_
+ sky130_fd_sc_hd__a2bb2oi_1
X_23452_ _02541_ _02511_ _12429_ VSS VSS VDD VDD _02741_ sky130_fd_sc_hd__o21ai_0
X_23453_ _02740_ _02741_ _02472_ VSS VSS VDD VDD _02742_ sky130_fd_sc_hd__a21oi_1
X_23454_ _02472_ _02739_ _02742_ _02525_ VSS VSS VDD VDD _02743_
+ sky130_fd_sc_hd__a211oi_2
X_23455_ _12436_ net750 VSS VSS VDD VDD _02744_ sky130_fd_sc_hd__nand2_1
X_23456_ net399 _02507_ _02744_ VSS VSS VDD VDD _02745_ sky130_fd_sc_hd__nand3_1
X_23457_ _02449_ _02651_ _02636_ VSS VSS VDD VDD _02746_ sky130_fd_sc_hd__nand3_1
X_23458_ _12452_ net750 net396 VSS VSS VDD VDD _02747_ sky130_fd_sc_hd__o21ai_0
X_23459_ net750 _02699_ _02484_ _02747_ VSS VSS VDD VDD _02748_
+ sky130_fd_sc_hd__a31oi_1
X_23460_ _02504_ _02745_ _02746_ _02748_ _02467_ VSS VSS VDD
+ VDD _02749_ sky130_fd_sc_hd__a311oi_1
X_23461_ _02633_ _02743_ _02749_ VSS VSS VDD VDD _02750_ sky130_fd_sc_hd__nor3_1
X_23462_ _02611_ _02708_ _02737_ _02750_ VSS VSS VDD VDD _00146_
+ sky130_fd_sc_hd__a211oi_1
X_23463_ _12436_ net750 VSS VSS VDD VDD _02751_ sky130_fd_sc_hd__nor2_1
X_23464_ net399 _02605_ _02751_ VSS VSS VDD VDD _02752_ sky130_fd_sc_hd__nor3_1
X_23465_ net399 _02690_ _02507_ _02752_ _02467_ VSS VSS VDD
+ VDD _02753_ sky130_fd_sc_hd__a311oi_1
X_23466_ _02690_ _02594_ _02449_ _02525_ VSS VSS VDD VDD _02754_
+ sky130_fd_sc_hd__a211oi_1
X_23467_ _12438_ _02516_ VSS VSS VDD VDD _02755_ sky130_fd_sc_hd__nand2_1
X_23468_ _02444_ _02704_ VSS VSS VDD VDD _02756_ sky130_fd_sc_hd__nand2_2
X_23469_ net399 _02719_ _02542_ VSS VSS VDD VDD _02757_ sky130_fd_sc_hd__nor3_1
X_23470_ net399 _02594_ _02724_ _02757_ _02646_ VSS VSS VDD
+ VDD _02758_ sky130_fd_sc_hd__a311oi_1
X_23471_ _02668_ _02755_ _02756_ _02758_ _02461_ VSS VSS VDD
+ VDD _02759_ sky130_fd_sc_hd__a311oi_1
X_23472_ _02472_ _02753_ _02754_ _02759_ VSS VSS VDD VDD _02760_
+ sky130_fd_sc_hd__o31ai_1
X_23473_ _12438_ net751 _02726_ VSS VSS VDD VDD _02761_ sky130_fd_sc_hd__o21ai_2
X_23474_ _02449_ _02761_ _02725_ VSS VSS VDD VDD _02762_ sky130_fd_sc_hd__a21oi_1
X_23475_ _02525_ _02692_ _02718_ _02449_ VSS VSS VDD VDD _02763_
+ sky130_fd_sc_hd__o211ai_1
X_23476_ _12438_ _02489_ VSS VSS VDD VDD _02764_ sky130_fd_sc_hd__nand2_4
X_23477_ _02467_ _02499_ _02764_ VSS VSS VDD VDD _02765_ sky130_fd_sc_hd__nand3_1
X_23478_ _02467_ _02655_ _02765_ net398 VSS VSS VDD VDD _02766_
+ sky130_fd_sc_hd__o211ai_1
X_23479_ net399 _02507_ net614 VSS VSS VDD VDD _02767_ sky130_fd_sc_hd__a21oi_1
X_23480_ _02438_ _02551_ _02575_ _02767_ _02525_ VSS VSS VDD
+ VDD _02768_ sky130_fd_sc_hd__a2111oi_2
X_23481_ _02504_ _02763_ _02766_ _02768_ VSS VSS VDD VDD _02769_
+ sky130_fd_sc_hd__a31oi_1
X_23482_ _02646_ _02762_ _02769_ _02461_ VSS VSS VDD VDD _02770_
+ sky130_fd_sc_hd__o211ai_1
X_23483_ _12436_ _02573_ VSS VSS VDD VDD _02771_ sky130_fd_sc_hd__nand2_1
X_23484_ _12429_ _02515_ _02771_ VSS VSS VDD VDD _02772_ sky130_fd_sc_hd__o21ai_0
X_23485_ _02554_ _02756_ net721 VSS VSS VDD VDD _02773_ sky130_fd_sc_hd__a21oi_1
X_23486_ _12436_ _02551_ _02669_ net721 net396 VSS VSS VDD
+ VDD _02774_ sky130_fd_sc_hd__a221o_1
X_23487_ _02504_ _02772_ _02773_ _02774_ _02693_ VSS VSS VDD
+ VDD _02775_ sky130_fd_sc_hd__o32ai_1
X_23488_ _02606_ _02542_ _02449_ VSS VSS VDD VDD _02776_ sky130_fd_sc_hd__o21ai_0
X_23489_ net398 _02594_ _02612_ VSS VSS VDD VDD _02777_ sky130_fd_sc_hd__nand3_1
X_23490_ _02504_ _02776_ _02777_ VSS VSS VDD VDD _02778_ sky130_fd_sc_hd__nand3_1
X_23491_ _02438_ _02444_ VSS VSS VDD VDD _02779_ sky130_fd_sc_hd__nor2_1
X_23492_ _02573_ _02779_ _02614_ net396 VSS VSS VDD VDD _02780_
+ sky130_fd_sc_hd__o31ai_1
X_23493_ _02778_ _02780_ _02467_ VSS VSS VDD VDD _02781_ sky130_fd_sc_hd__a21oi_1
X_23494_ _02467_ _02775_ _02781_ _02633_ VSS VSS VDD VDD _02782_
+ sky130_fd_sc_hd__a211oi_2
X_23495_ _02449_ _02651_ _02543_ VSS VSS VDD VDD _02783_ sky130_fd_sc_hd__nand3_1
X_23496_ _02449_ _02495_ _02751_ _02783_ _02662_ VSS VSS VDD
+ VDD _02784_ sky130_fd_sc_hd__o311ai_1
X_23497_ _02467_ _02472_ VSS VSS VDD VDD _02785_ sky130_fd_sc_hd__nor2_2
X_23498_ _02556_ _02605_ _02449_ VSS VSS VDD VDD _02786_ sky130_fd_sc_hd__o21ai_0
X_23499_ net614 _02704_ VSS VSS VDD VDD _02787_ sky130_fd_sc_hd__nand2_1
X_23500_ _02785_ _02786_ _02787_ _02735_ VSS VSS VDD VDD _02788_
+ sky130_fd_sc_hd__a31oi_1
X_23501_ _02784_ _02788_ VSS VSS VDD VDD _02789_ sky130_fd_sc_hd__nand2_1
X_23502_ _02438_ _02449_ _02655_ _02556_ _02486_ VSS VSS VDD
+ VDD _02790_ sky130_fd_sc_hd__a32oi_1
X_23503_ _02519_ _02790_ _02646_ VSS VSS VDD VDD _02791_ sky130_fd_sc_hd__a21oi_1
X_23504_ _12442_ net615 _02499_ net399 VSS VSS VDD VDD _02792_
+ sky130_fd_sc_hd__o211ai_1
X_23505_ net399 _02556_ _02619_ VSS VSS VDD VDD _02793_ sky130_fd_sc_hd__or3_1
X_23506_ _02792_ _02793_ _02642_ VSS VSS VDD VDD _02794_ sky130_fd_sc_hd__a21oi_1
X_23507_ _02789_ _02791_ _02794_ VSS VSS VDD VDD _02795_ sky130_fd_sc_hd__nor3_1
X_23508_ _02565_ _02760_ _02770_ _02782_ _02795_ VSS VSS VDD
+ VDD _00147_ sky130_fd_sc_hd__a311oi_1
X_23509_ _12429_ _02449_ net750 VSS VSS VDD VDD _02796_ sky130_fd_sc_hd__nand3_1
X_23510_ _12440_ net615 VSS VSS VDD VDD _02797_ sky130_fd_sc_hd__nand2_1
X_23511_ _02438_ _02532_ VSS VSS VDD VDD _02798_ sky130_fd_sc_hd__nor2_1
X_23512_ _02449_ _02764_ _02798_ net396 _02656_ VSS VSS VDD
+ VDD _02799_ sky130_fd_sc_hd__a2111oi_1
X_23513_ net396 _02796_ _02797_ _02799_ VSS VSS VDD VDD _02800_
+ sky130_fd_sc_hd__a31oi_1
X_23514_ _02597_ _02692_ _02449_ VSS VSS VDD VDD _02801_ sky130_fd_sc_hd__a21oi_1
X_23515_ _12428_ _02515_ _02664_ _02438_ VSS VSS VDD VDD _02802_
+ sky130_fd_sc_hd__o22ai_1
X_23516_ _02669_ _02556_ net398 VSS VSS VDD VDD _02803_ sky130_fd_sc_hd__o21ai_0
X_23517_ _02504_ _02585_ _02673_ _02803_ VSS VSS VDD VDD _02804_
+ sky130_fd_sc_hd__nand4_2
X_23518_ net395 _02801_ _02802_ _02804_ _02525_ VSS VSS VDD
+ VDD _02805_ sky130_fd_sc_hd__o311ai_0
X_23519_ _02525_ _02800_ _02805_ VSS VSS VDD VDD _02806_ sky130_fd_sc_hd__o21ai_0
X_23520_ _02449_ _02764_ _02580_ VSS VSS VDD VDD _02807_ sky130_fd_sc_hd__a21oi_1
X_23521_ _02449_ _02612_ _02636_ VSS VSS VDD VDD _02808_ sky130_fd_sc_hd__nand3_1
X_23522_ net396 _02486_ _02808_ VSS VSS VDD VDD _02809_ sky130_fd_sc_hd__nand3_1
X_23523_ net396 _02807_ _02809_ VSS VSS VDD VDD _02810_ sky130_fd_sc_hd__o21ai_0
X_23524_ net398 net395 VSS VSS VDD VDD _02811_ sky130_fd_sc_hd__nor2_1
X_23525_ net398 net396 VSS VSS VDD VDD _02812_ sky130_fd_sc_hd__nor2_1
X_23526_ _02499_ _02764_ _02811_ _02812_ _02653_ VSS VSS VDD
+ VDD _02813_ sky130_fd_sc_hd__a32oi_1
X_23527_ _12438_ net395 _02449_ VSS VSS VDD VDD _02814_ sky130_fd_sc_hd__a21oi_1
X_23528_ net395 _02581_ _02713_ _02814_ VSS VSS VDD VDD _02815_
+ sky130_fd_sc_hd__o31ai_1
X_23529_ _02813_ _02815_ _02461_ VSS VSS VDD VDD _02816_ sky130_fd_sc_hd__a21oi_1
X_23530_ _02461_ _02810_ _02525_ _02565_ _02816_ VSS VSS VDD
+ VDD _02817_ sky130_fd_sc_hd__a2111oi_0
X_23531_ _12433_ net398 _02508_ VSS VSS VDD VDD _02818_ sky130_fd_sc_hd__a21oi_1
X_23532_ net750 _02536_ _02623_ VSS VSS VDD VDD _02819_ sky130_fd_sc_hd__nand3_1
X_23533_ net750 _02818_ _02819_ net396 VSS VSS VDD VDD _02820_
+ sky130_fd_sc_hd__o211ai_1
X_23534_ net400 net614 _02489_ VSS VSS VDD VDD _02821_ sky130_fd_sc_hd__o21ai_2
X_23535_ _02597_ _02821_ _02812_ VSS VSS VDD VDD _02822_ sky130_fd_sc_hd__nand3_1
X_23536_ _12428_ net751 _02619_ _02449_ VSS VSS VDD VDD _02823_
+ sky130_fd_sc_hd__a211oi_1
X_23537_ _02449_ _02560_ _02618_ _02823_ net396 VSS VSS VDD
+ VDD _02824_ sky130_fd_sc_hd__a311oi_1
X_23538_ net614 _02704_ _02718_ _02449_ net395 VSS VSS VDD
+ VDD _02825_ sky130_fd_sc_hd__a221oi_1
X_23539_ _02467_ _02824_ _02825_ VSS VSS VDD VDD _02826_ sky130_fd_sc_hd__nor3_1
X_23540_ _02467_ _02820_ _02822_ _02826_ VSS VSS VDD VDD _02827_
+ sky130_fd_sc_hd__a31oi_1
X_23541_ _02444_ _02811_ _02438_ VSS VSS VDD VDD _02828_ sky130_fd_sc_hd__o21ai_0
X_23542_ net615 _02486_ _02828_ VSS VSS VDD VDD _02829_ sky130_fd_sc_hd__and3_1
X_23543_ _02449_ net395 VSS VSS VDD VDD _02830_ sky130_fd_sc_hd__nor2_1
X_23544_ _02438_ _02830_ _02812_ _12428_ net615 VSS VSS VDD
+ VDD _02831_ sky130_fd_sc_hd__a221oi_1
X_23545_ net395 _02664_ VSS VSS VDD VDD _02832_ sky130_fd_sc_hd__nor2_1
X_23546_ net398 net395 _02832_ VSS VSS VDD VDD _02833_ sky130_fd_sc_hd__a21oi_1
X_23547_ _02467_ _02633_ VSS VSS VDD VDD _02834_ sky130_fd_sc_hd__nor2_1
X_23548_ _02829_ _02831_ _02833_ _02438_ _02834_ VSS VSS VDD
+ VDD _02835_ sky130_fd_sc_hd__o221ai_1
X_23549_ _12433_ _02830_ _02812_ VSS VSS VDD VDD _02836_ sky130_fd_sc_hd__nor3_1
X_23550_ _02449_ net395 _02700_ VSS VSS VDD VDD _02837_ sky130_fd_sc_hd__nor3_1
X_23551_ _12442_ net398 net396 VSS VSS VDD VDD _02838_ sky130_fd_sc_hd__nor3_1
X_23552_ _02438_ net715 net396 VSS VSS VDD VDD _02839_ sky130_fd_sc_hd__a21oi_1
X_23553_ _12428_ net395 VSS VSS VDD VDD _02840_ sky130_fd_sc_hd__nor2_1
X_23554_ net400 _02449_ VSS VSS VDD VDD _02841_ sky130_fd_sc_hd__nand2_1
X_23555_ _02449_ _02839_ _02840_ net750 _02841_ VSS VSS VDD
+ VDD _02842_ sky130_fd_sc_hd__o311ai_1
X_23556_ net750 _02836_ _02837_ _02838_ _02842_ VSS VSS VDD
+ VDD _02843_ sky130_fd_sc_hd__o41ai_1
X_23557_ _02525_ _02661_ _02843_ VSS VSS VDD VDD _02844_ sky130_fd_sc_hd__nand3_1
X_23558_ _02566_ _02827_ _02835_ _02844_ VSS VSS VDD VDD _02845_
+ sky130_fd_sc_hd__o211ai_1
X_23559_ _02611_ _02806_ _02817_ _02845_ VSS VSS VDD VDD _00148_
+ sky130_fd_sc_hd__a211o_1
X_23560_ _12438_ _02551_ VSS VSS VDD VDD _02846_ sky130_fd_sc_hd__nand2_1
X_23561_ _02588_ _02598_ _02662_ _02846_ VSS VSS VDD VDD _02847_
+ sky130_fd_sc_hd__nand4_1
X_23562_ net398 _02499_ _02764_ _02584_ _02444_ VSS VSS VDD
+ VDD _02848_ sky130_fd_sc_hd__a32oi_1
X_23563_ _02449_ _02507_ _02559_ _02599_ _02525_ VSS VSS VDD
+ VDD _02849_ sky130_fd_sc_hd__a311oi_1
X_23564_ _02525_ _02848_ _02849_ _02504_ VSS VSS VDD VDD _02850_
+ sky130_fd_sc_hd__a211o_1
X_23565_ _12433_ net615 _02467_ VSS VSS VDD VDD _02851_ sky130_fd_sc_hd__a21oi_1
X_23566_ net398 _02581_ _02851_ _02504_ VSS VSS VDD VDD _02852_
+ sky130_fd_sc_hd__o211ai_1
X_23567_ _02847_ _02850_ _02852_ _02633_ VSS VSS VDD VDD _02853_
+ sky130_fd_sc_hd__a31oi_1
X_23568_ _12436_ net615 _02684_ VSS VSS VDD VDD _02854_ sky130_fd_sc_hd__o21ai_1
X_23569_ _02492_ _02854_ _02449_ VSS VSS VDD VDD _02855_ sky130_fd_sc_hd__mux2i_1
X_23570_ net398 _02581_ _02606_ VSS VSS VDD VDD _02856_ sky130_fd_sc_hd__nor3_1
X_23571_ net398 _02507_ _02651_ _02856_ _02525_ VSS VSS VDD
+ VDD _02857_ sky130_fd_sc_hd__a311oi_1
X_23572_ _02525_ _02855_ _02857_ VSS VSS VDD VDD _02858_ sky130_fd_sc_hd__a21oi_1
X_23573_ net614 _02516_ VSS VSS VDD VDD _02859_ sky130_fd_sc_hd__nor2_1
X_23574_ _12433_ _02551_ _02602_ net399 _02859_ VSS VSS VDD
+ VDD _02860_ sky130_fd_sc_hd__a221oi_1
X_23575_ net614 _02704_ _02587_ VSS VSS VDD VDD _02861_ sky130_fd_sc_hd__o21ai_0
X_23576_ _02668_ _02861_ _02566_ VSS VSS VDD VDD _02862_ sky130_fd_sc_hd__a21oi_1
X_23577_ _02646_ _02860_ _02862_ VSS VSS VDD VDD _02863_ sky130_fd_sc_hd__o21ai_0
X_23578_ _02504_ _02858_ _02863_ VSS VSS VDD VDD _02864_ sky130_fd_sc_hd__a21oi_1
X_23579_ _02449_ net750 VSS VSS VDD VDD _02865_ sky130_fd_sc_hd__nand2_1
X_23580_ _12442_ _02865_ VSS VSS VDD VDD _02866_ sky130_fd_sc_hd__nor2_1
X_23581_ _12433_ _02449_ net750 VSS VSS VDD VDD _02867_ sky130_fd_sc_hd__a21oi_1
X_23582_ _02866_ _02867_ _02467_ VSS VSS VDD VDD _02868_ sky130_fd_sc_hd__o21ai_0
X_23583_ _02594_ _02635_ _02449_ VSS VSS VDD VDD _02869_ sky130_fd_sc_hd__a21oi_1
X_23584_ _02449_ _02854_ _02869_ VSS VSS VDD VDD _02870_ sky130_fd_sc_hd__a21oi_1
X_23585_ _02525_ _02870_ VSS VSS VDD VDD _02871_ sky130_fd_sc_hd__nand2_1
X_23586_ _02560_ _02613_ _02614_ _02724_ _02449_ VSS VSS VDD
+ VDD _02872_ sky130_fd_sc_hd__o32ai_1
X_23587_ _02467_ net395 VSS VSS VDD VDD _02873_ sky130_fd_sc_hd__nor2_1
X_23588_ net750 _02623_ _02744_ _02873_ VSS VSS VDD VDD _02874_
+ sky130_fd_sc_hd__o211ai_1
X_23589_ _02642_ _02872_ _02874_ _02611_ VSS VSS VDD VDD _02875_
+ sky130_fd_sc_hd__o211ai_2
X_23590_ _02504_ _02868_ _02871_ _02875_ VSS VSS VDD VDD _02876_
+ sky130_fd_sc_hd__a31oi_1
X_23591_ _02472_ _02489_ VSS VSS VDD VDD _02877_ sky130_fd_sc_hd__nand2_2
X_23592_ _02550_ _02877_ _02438_ VSS VSS VDD VDD _02878_ sky130_fd_sc_hd__a21oi_1
X_23593_ _12436_ _02584_ VSS VSS VDD VDD _02879_ sky130_fd_sc_hd__nand2_1
X_23594_ _02787_ _02879_ _02472_ VSS VSS VDD VDD _02880_ sky130_fd_sc_hd__a21oi_1
X_23595_ _02472_ _02573_ _02877_ _02444_ _02438_ VSS VSS VDD
+ VDD _02881_ sky130_fd_sc_hd__o2111ai_1
X_23596_ net614 _02472_ _02507_ _02881_ VSS VSS VDD VDD _02882_
+ sky130_fd_sc_hd__o31ai_1
X_23597_ _02525_ _02878_ _02880_ _02882_ VSS VSS VDD VDD _02883_
+ sky130_fd_sc_hd__nor4_1
X_23598_ _02597_ _02635_ net398 VSS VSS VDD VDD _02884_ sky130_fd_sc_hd__a21oi_1
X_23599_ net400 _02704_ _02884_ net396 VSS VSS VDD VDD _02885_
+ sky130_fd_sc_hd__a211oi_1
X_23600_ _12428_ net615 _02684_ VSS VSS VDD VDD _02886_ sky130_fd_sc_hd__o21ai_0
X_23601_ _12429_ _02532_ VSS VSS VDD VDD _02887_ sky130_fd_sc_hd__nor2_1
X_23602_ _02449_ _02886_ _02887_ net395 VSS VSS VDD VDD _02888_
+ sky130_fd_sc_hd__a211oi_1
X_23603_ _02467_ _02885_ _02888_ VSS VSS VDD VDD _02889_ sky130_fd_sc_hd__nor3_1
X_23604_ _02735_ _02883_ _02889_ VSS VSS VDD VDD _02890_ sky130_fd_sc_hd__nor3_1
X_23605_ _02853_ _02864_ _02876_ _02890_ VSS VSS VDD VDD _00149_
+ sky130_fd_sc_hd__nor4_1
X_23606_ _02580_ _02581_ _02449_ VSS VSS VDD VDD _02891_ sky130_fd_sc_hd__o21ai_0
X_23607_ net397 _02700_ VSS VSS VDD VDD _02892_ sky130_fd_sc_hd__nor2_1
X_23608_ _12429_ _02449_ net615 VSS VSS VDD VDD _02893_ sky130_fd_sc_hd__o21ai_0
X_23609_ _12447_ net615 _02892_ _02893_ VSS VSS VDD VDD _02894_
+ sky130_fd_sc_hd__o22ai_1
X_23610_ _02668_ _02777_ _02891_ _02894_ _02662_ VSS VSS VDD
+ VDD _02895_ sky130_fd_sc_hd__a32oi_1
X_23611_ net750 _02818_ _02554_ net396 VSS VSS VDD VDD _02896_
+ sky130_fd_sc_hd__o211ai_1
X_23612_ net614 _02449_ VSS VSS VDD VDD _02897_ sky130_fd_sc_hd__nor2_1
X_23613_ net400 _02897_ net750 VSS VSS VDD VDD _02898_ sky130_fd_sc_hd__o21ai_0
X_23614_ _12436_ _02515_ _02898_ net395 VSS VSS VDD VDD _02899_
+ sky130_fd_sc_hd__o211ai_1
X_23615_ _02582_ _02896_ _02899_ _02525_ VSS VSS VDD VDD _02900_
+ sky130_fd_sc_hd__o211ai_1
X_23616_ _02438_ net396 VSS VSS VDD VDD _02901_ sky130_fd_sc_hd__nor2_1
X_23617_ _02832_ _02901_ _02449_ VSS VSS VDD VDD _02902_ sky130_fd_sc_hd__o21ai_0
X_23618_ _12429_ net396 net750 VSS VSS VDD VDD _02903_ sky130_fd_sc_hd__a21oi_1
X_23619_ _02449_ _02903_ VSS VSS VDD VDD _02904_ sky130_fd_sc_hd__nor2_1
X_23620_ _12438_ _02877_ _02904_ VSS VSS VDD VDD _02905_ sky130_fd_sc_hd__o21ai_0
X_23621_ net396 _02543_ _02902_ _02905_ _02525_ VSS VSS VDD
+ VDD _02906_ sky130_fd_sc_hd__o2111ai_1
X_23622_ _02449_ _02484_ _02543_ VSS VSS VDD VDD _02907_ sky130_fd_sc_hd__o21a_1
X_23623_ net400 _02669_ _02614_ VSS VSS VDD VDD _02908_ sky130_fd_sc_hd__a21oi_1
X_23624_ _12442_ _02907_ _02908_ VSS VSS VDD VDD _02909_ sky130_fd_sc_hd__o21ai_0
X_23625_ net395 _02614_ _02713_ net397 VSS VSS VDD VDD _02910_
+ sky130_fd_sc_hd__a2bb2oi_1
X_23626_ _02486_ _02877_ _02910_ net400 VSS VSS VDD VDD _02911_
+ sky130_fd_sc_hd__o22ai_1
X_23627_ _02662_ _02909_ _02911_ _02467_ VSS VSS VDD VDD _02912_
+ sky130_fd_sc_hd__a22oi_1
X_23628_ _02449_ _02761_ _02798_ net396 VSS VSS VDD VDD _02913_
+ sky130_fd_sc_hd__a211o_1
X_23629_ net399 _02719_ _02542_ _02532_ _12429_ VSS VSS VDD
+ VDD _02914_ sky130_fd_sc_hd__o32ai_2
X_23630_ _12438_ _02449_ _02489_ VSS VSS VDD VDD _02915_ sky130_fd_sc_hd__a21oi_1
X_23631_ _12446_ net750 _02699_ _02915_ net395 VSS VSS VDD
+ VDD _02916_ sky130_fd_sc_hd__a221oi_1
X_23632_ net395 _02914_ _02916_ _02525_ VSS VSS VDD VDD _02917_
+ sky130_fd_sc_hd__a211oi_1
X_23633_ _02525_ _02702_ _02913_ _02917_ _02461_ VSS VSS VDD
+ VDD _02918_ sky130_fd_sc_hd__a311oi_1
X_23634_ _02461_ _02906_ _02912_ _02918_ _02456_ VSS VSS VDD
+ VDD _02919_ sky130_fd_sc_hd__a311oi_1
X_23635_ _12428_ net750 _02764_ VSS VSS VDD VDD _02920_ sky130_fd_sc_hd__o21ai_0
X_23636_ _12430_ _02584_ _02920_ net397 VSS VSS VDD VDD _02921_
+ sky130_fd_sc_hd__a22oi_1
X_23637_ net400 net397 _02821_ VSS VSS VDD VDD _02922_ sky130_fd_sc_hd__a21oi_1
X_23638_ _12445_ _12454_ net750 net396 VSS VSS VDD VDD _02923_
+ sky130_fd_sc_hd__o31ai_1
X_23639_ net396 _02921_ _02922_ _02923_ VSS VSS VDD VDD _02924_
+ sky130_fd_sc_hd__o22ai_1
X_23640_ _02449_ _02821_ _02709_ VSS VSS VDD VDD _02925_ sky130_fd_sc_hd__nand3_1
X_23641_ net397 _02690_ _02684_ VSS VSS VDD VDD _02926_ sky130_fd_sc_hd__nand3_1
X_23642_ _12433_ net615 _02499_ VSS VSS VDD VDD _02927_ sky130_fd_sc_hd__o21ai_0
X_23643_ net397 _02655_ _02764_ VSS VSS VDD VDD _02928_ sky130_fd_sc_hd__and3_1
X_23644_ _02449_ _02690_ _02927_ _02928_ VSS VSS VDD VDD _02929_
+ sky130_fd_sc_hd__a31oi_1
X_23645_ _02873_ _02925_ _02926_ _02929_ _02785_ VSS VSS VDD
+ VDD _02930_ sky130_fd_sc_hd__a32o_1
X_23646_ _02467_ _02924_ _02930_ _02633_ VSS VSS VDD VDD _02931_
+ sky130_fd_sc_hd__a211oi_1
X_23647_ _02661_ _02895_ _02900_ _02919_ _02931_ VSS VSS VDD
+ VDD _00150_ sky130_fd_sc_hd__a311oi_1
X_23648_ _02449_ _02593_ _02719_ VSS VSS VDD VDD _02932_ sky130_fd_sc_hd__a21oi_1
X_23649_ _12428_ _02573_ _02631_ VSS VSS VDD VDD _02933_ sky130_fd_sc_hd__a21oi_1
X_23650_ net722 _02932_ _02933_ VSS VSS VDD VDD _02934_ sky130_fd_sc_hd__o21ai_2
X_23651_ _12442_ _02532_ _02516_ _12429_ _02785_ VSS VSS VDD
+ VDD _02935_ sky130_fd_sc_hd__o221ai_1
X_23652_ _02934_ _02935_ _02675_ VSS VSS VDD VDD _02936_ sky130_fd_sc_hd__a21oi_1
X_23653_ net397 _02692_ _02684_ VSS VSS VDD VDD _02937_ sky130_fd_sc_hd__nand3_1
X_23654_ _02449_ _02612_ _02709_ VSS VSS VDD VDD _02938_ sky130_fd_sc_hd__nand3_1
X_23655_ _02873_ _02937_ _02938_ VSS VSS VDD VDD _02939_ sky130_fd_sc_hd__nand3_1
X_23656_ _02537_ _02713_ net397 VSS VSS VDD VDD _02940_ sky130_fd_sc_hd__o21ai_0
X_23657_ _12438_ _02865_ _02668_ _02940_ VSS VSS VDD VDD _02941_
+ sky130_fd_sc_hd__o211ai_2
X_23658_ _02939_ _02941_ VSS VSS VDD VDD _02942_ sky130_fd_sc_hd__nand2_1
X_23659_ _12433_ net398 VSS VSS VDD VDD _02943_ sky130_fd_sc_hd__nand2b_1
X_23660_ _02841_ _02943_ net615 VSS VSS VDD VDD _02944_ sky130_fd_sc_hd__a21oi_1
X_23661_ _02560_ _02897_ net395 VSS VSS VDD VDD _02945_ sky130_fd_sc_hd__o21ai_0
X_23662_ _12440_ net615 VSS VSS VDD VDD _02946_ sky130_fd_sc_hd__nor2_1
X_23663_ _12430_ _02449_ net615 _02946_ VSS VSS VDD VDD _02947_
+ sky130_fd_sc_hd__a31oi_1
X_23664_ _02944_ _02945_ _02947_ net395 VSS VSS VDD VDD _02948_
+ sky130_fd_sc_hd__o22ai_2
X_23665_ _12454_ net615 VSS VSS VDD VDD _02949_ sky130_fd_sc_hd__nor2_1
X_23666_ _12438_ net397 net750 _02508_ VSS VSS VDD VDD _02950_
+ sky130_fd_sc_hd__a211oi_1
X_23667_ net395 _02949_ _02950_ _02525_ VSS VSS VDD VDD _02951_
+ sky130_fd_sc_hd__o31ai_1
X_23668_ net397 _02651_ _02560_ _02679_ net396 VSS VSS VDD
+ VDD _02952_ sky130_fd_sc_hd__a311oi_1
X_23669_ _02525_ _02948_ _02951_ _02952_ VSS VSS VDD VDD _02953_
+ sky130_fd_sc_hd__o22ai_1
X_23670_ _02673_ _02744_ net399 VSS VSS VDD VDD _02954_ sky130_fd_sc_hd__a21oi_1
X_23671_ _02638_ _02954_ _02472_ VSS VSS VDD VDD _02955_ sky130_fd_sc_hd__o21ai_0
X_23672_ _02449_ _02543_ VSS VSS VDD VDD _02956_ sky130_fd_sc_hd__nand2_1
X_23673_ _02472_ _02556_ VSS VSS VDD VDD _02957_ sky130_fd_sc_hd__nor2_1
X_23674_ _02532_ _02572_ _02956_ _02720_ _02957_ VSS VSS VDD
+ VDD _02958_ sky130_fd_sc_hd__o221ai_2
X_23675_ _02461_ _02467_ _02955_ _02958_ VSS VSS VDD VDD _02959_
+ sky130_fd_sc_hd__nand4_1
X_23676_ _12428_ _02449_ VSS VSS VDD VDD _02960_ sky130_fd_sc_hd__nor2_1
X_23677_ _02449_ _02680_ _02612_ _02960_ VSS VSS VDD VDD _02961_
+ sky130_fd_sc_hd__a31oi_1
X_23678_ _12433_ net750 net395 VSS VSS VDD VDD _02962_ sky130_fd_sc_hd__o21ai_0
X_23679_ net395 _02961_ _02962_ _02922_ VSS VSS VDD VDD _02963_
+ sky130_fd_sc_hd__o22ai_1
X_23680_ _02461_ _02525_ _02963_ _02565_ VSS VSS VDD VDD _02964_
+ sky130_fd_sc_hd__a31oi_1
X_23681_ _02461_ _02953_ _02959_ _02964_ VSS VSS VDD VDD _02965_
+ sky130_fd_sc_hd__o211ai_1
X_23682_ _02444_ _02532_ _02543_ VSS VSS VDD VDD _02966_ sky130_fd_sc_hd__o21ai_0
X_23683_ _02551_ _02593_ net400 VSS VSS VDD VDD _02967_ sky130_fd_sc_hd__o21ai_0
X_23684_ _02587_ _02967_ _02504_ VSS VSS VDD VDD _02968_ sky130_fd_sc_hd__a21oi_1
X_23685_ _02865_ _02756_ net400 VSS VSS VDD VDD _02969_ sky130_fd_sc_hd__a21oi_1
X_23686_ _02504_ _02966_ _02968_ _02969_ VSS VSS VDD VDD _02970_
+ sky130_fd_sc_hd__a211oi_1
X_23687_ _02515_ _02877_ net614 VSS VSS VDD VDD _02971_ sky130_fd_sc_hd__a21oi_1
X_23688_ net614 _02504_ _02573_ _02971_ VSS VSS VDD VDD _02972_
+ sky130_fd_sc_hd__a31oi_1
X_23689_ _02467_ _02811_ VSS VSS VDD VDD _02973_ sky130_fd_sc_hd__nor2_1
X_23690_ _02449_ _02499_ _02972_ net400 _02973_ VSS VSS VDD
+ VDD _02974_ sky130_fd_sc_hd__o221ai_1
X_23691_ _02525_ _02970_ _02974_ _02611_ VSS VSS VDD VDD _02975_
+ sky130_fd_sc_hd__o211ai_2
X_23692_ _02566_ _02936_ _02942_ _02965_ _02975_ VSS VSS VDD
+ VDD _00151_ sky130_fd_sc_hd__o311a_1
X_23693_ sa03_sr\[7\] sa03_sr\[0\] sa21_sub\[1\] VSS VSS VDD
+ VDD _02976_ sky130_fd_sc_hd__xor3_1
X_23694_ _00771_ _00772_ _02976_ VSS VSS VDD VDD _02977_ sky130_fd_sc_hd__xnor3_1
X_23695_ net655 text_in_r\[1\] VSS VSS VDD VDD _02978_ sky130_fd_sc_hd__nand2_1
X_23696_ net655 _02977_ _02978_ VSS VSS VDD VDD _02979_ sky130_fd_sc_hd__o21a_1
X_23697_ u0.tmp_w\[1\] _02979_ VSS VSS VDD VDD _02980_ sky130_fd_sc_hd__xor2_4
X_23698_ net695 VSS VSS VDD VDD _02981_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_1_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23701_ sa10_sub\[0\] sa21_sub\[0\] sa32_sub\[7\] VSS VSS
+ VDD VDD _02983_ sky130_fd_sc_hd__xnor3_1
X_23702_ _07657_ _02983_ VSS VSS VDD VDD _02984_ sky130_fd_sc_hd__xor2_1
X_23703_ text_in_r\[0\] _02984_ net490 VSS VSS VDD VDD _02985_
+ sky130_fd_sc_hd__mux2i_4
X_23704_ u0.tmp_w\[0\] _02985_ VSS VSS VDD VDD _02986_ sky130_fd_sc_hd__xor2_4
X_23705_ net533 VSS VSS VDD VDD _02987_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_1_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23708_ sa32_sub\[1\] sa03_sr\[2\] VSS VSS VDD VDD _02989_
+ sky130_fd_sc_hd__xor2_1
X_23709_ _07678_ _02989_ VSS VSS VDD VDD _02990_ sky130_fd_sc_hd__xnor2_1
X_23710_ text_in_r\[2\] _02990_ net490 VSS VSS VDD VDD _02991_
+ sky130_fd_sc_hd__mux2i_4
X_23711_ _02991_ u0.tmp_w\[2\] VSS VSS VDD VDD _02992_ sky130_fd_sc_hd__xnor2_4
X_23712_ net560 VSS VSS VDD VDD _02993_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_1_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23722_ _07701_ _07712_ _00818_ VSS VSS VDD VDD _03000_ sky130_fd_sc_hd__xnor3_1
X_23723_ net530 text_in_r\[4\] VSS VSS VDD VDD _03001_ sky130_fd_sc_hd__nand2_1
X_23724_ net530 _03000_ _03001_ VSS VSS VDD VDD _03002_ sky130_fd_sc_hd__o21a_2
X_23725_ u0.tmp_w\[4\] _03002_ VSS VSS VDD VDD _03003_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_1_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23729_ _07723_ _00825_ _00826_ VSS VSS VDD VDD _03007_ sky130_fd_sc_hd__xnor3_2
X_23730_ text_in_r\[3\] net530 VSS VSS VDD VDD _03008_ sky130_fd_sc_hd__nand2b_1
X_23731_ net657 _03007_ _03008_ u0.tmp_w\[3\] VSS VSS VDD
+ VDD _03009_ sky130_fd_sc_hd__o211a_2
X_23732_ net530 text_in_r\[3\] VSS VSS VDD VDD _03010_ sky130_fd_sc_hd__and2_0
X_23733_ net512 _03007_ _03010_ u0.tmp_w\[3\] VSS VSS VDD
+ VDD _03011_ sky130_fd_sc_hd__a211oi_4
X_23734_ _03011_ _03009_ VSS VSS VDD VDD _03012_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_1_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23738_ _02981_ _03012_ VSS VSS VDD VDD _03016_ sky130_fd_sc_hd__nor2_1
X_23739_ _03011_ _03009_ VSS VSS VDD VDD _03017_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_1_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23743_ _12474_ net586 VSS VSS VDD VDD _03021_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_0_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23746_ _03016_ _03021_ net392 VSS VSS VDD VDD _03024_ sky130_fd_sc_hd__o21ai_0
X_23747_ net393 _03017_ VSS VSS VDD VDD _03025_ sky130_fd_sc_hd__nor2_2
X_23748_ net502 _03025_ VSS VSS VDD VDD _03026_ sky130_fd_sc_hd__nand2_1
X_23749_ _02987_ _03017_ VSS VSS VDD VDD _03027_ sky130_fd_sc_hd__nor2_4
X_23750_ net696 _03012_ VSS VSS VDD VDD _03028_ sky130_fd_sc_hd__nor2_4
X_23751_ _03027_ _03028_ _02993_ VSS VSS VDD VDD _03029_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23755_ net562 _03017_ VSS VSS VDD VDD _03033_ sky130_fd_sc_hd__nand2_4
X_23756_ _12462_ _03033_ VSS VSS VDD VDD _03034_ sky130_fd_sc_hd__nor2_1
X_23757_ _03003_ _03034_ VSS VSS VDD VDD _03035_ sky130_fd_sc_hd__nor2_1
X_23758_ net391 _03024_ _03026_ _03029_ _03035_ VSS VSS VDD
+ VDD _03036_ sky130_fd_sc_hd__a32oi_1
XTAP_TAPCELL_ROW_0_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23764_ _02987_ net561 VSS VSS VDD VDD _03041_ sky130_fd_sc_hd__nand2_4
X_23765_ _12462_ net586 _03041_ _03003_ VSS VSS VDD VDD _03042_
+ sky130_fd_sc_hd__a211oi_1
X_23766_ net502 _02993_ _03003_ _03042_ VSS VSS VDD VDD _03043_
+ sky130_fd_sc_hd__a31oi_1
X_23767_ sa32_sub\[4\] sa03_sr\[4\] sa03_sr\[5\] VSS VSS VDD
+ VDD _03044_ sky130_fd_sc_hd__xnor3_1
X_23768_ _07700_ _03044_ VSS VSS VDD VDD _03045_ sky130_fd_sc_hd__xor2_1
X_23769_ text_in_r\[5\] _03045_ net490 VSS VSS VDD VDD _03046_
+ sky130_fd_sc_hd__mux2i_4
X_23770_ u0.tmp_w\[5\] _03046_ VSS VSS VDD VDD _03047_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_0_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23773_ sa32_sub\[5\] sa03_sr\[6\] VSS VSS VDD VDD _03050_
+ sky130_fd_sc_hd__xnor2_1
X_23774_ _07705_ _03050_ VSS VSS VDD VDD _03051_ sky130_fd_sc_hd__xnor2_1
X_23775_ net530 text_in_r\[6\] VSS VSS VDD VDD _03052_ sky130_fd_sc_hd__nand2_1
X_23776_ net530 _03051_ _03052_ VSS VSS VDD VDD _03053_ sky130_fd_sc_hd__o21ai_2
X_23777_ u0.tmp_w\[6\] _03053_ VSS VSS VDD VDD _03054_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_0_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23779_ _07670_ _09941_ VSS VSS VDD VDD _03056_ sky130_fd_sc_hd__xnor2_1
X_23780_ sa21_sub\[7\] _03056_ VSS VSS VDD VDD _03057_ sky130_fd_sc_hd__xnor2_1
X_23781_ text_in_r\[7\] _03057_ net512 VSS VSS VDD VDD _03058_
+ sky130_fd_sc_hd__mux2i_4
X_23782_ u0.tmp_w\[7\] _03058_ VSS VSS VDD VDD _03059_ sky130_fd_sc_hd__xor2_4
X_23783_ _03054_ _03059_ VSS VSS VDD VDD _03060_ sky130_fd_sc_hd__nand2b_4
X_23784_ net390 _03060_ VSS VSS VDD VDD _03061_ sky130_fd_sc_hd__nor2_1
X_23785_ net394 _03043_ _03061_ VSS VSS VDD VDD _03062_ sky130_fd_sc_hd__o21ai_0
X_23786_ net394 _03017_ VSS VSS VDD VDD _03063_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_0_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23789_ _12474_ _03012_ VSS VSS VDD VDD _03066_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23792_ _03063_ _03066_ net392 VSS VSS VDD VDD _03069_ sky130_fd_sc_hd__a21oi_1
X_23793_ _02987_ _03017_ VSS VSS VDD VDD _03070_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_0_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23796_ _12461_ net392 _03012_ VSS VSS VDD VDD _03073_ sky130_fd_sc_hd__nand3_1
X_23797_ net391 _03070_ _03073_ VSS VSS VDD VDD _03074_ sky130_fd_sc_hd__nand3_1
X_23798_ u0.tmp_w\[4\] _03002_ VSS VSS VDD VDD _03075_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_0_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23802_ _02981_ _03017_ VSS VSS VDD VDD _03079_ sky130_fd_sc_hd__nor2_1
X_23803_ net392 _03012_ VSS VSS VDD VDD _03080_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_0_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23807_ _02987_ net392 _03079_ _03080_ _12465_ VSS VSS VDD
+ VDD _03084_ sky130_fd_sc_hd__o32ai_1
X_23808_ net389 _03084_ VSS VSS VDD VDD _03085_ sky130_fd_sc_hd__nand2_1
X_23809_ u0.tmp_w\[5\] _03046_ VSS VSS VDD VDD _03086_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_0_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23812_ _03086_ _03060_ VSS VSS VDD VDD _03089_ sky130_fd_sc_hd__nor2_1
X_23813_ _03069_ _03074_ _03085_ _03089_ VSS VSS VDD VDD _03090_
+ sky130_fd_sc_hd__o211ai_1
X_23814_ _03036_ _03062_ _03090_ VSS VSS VDD VDD _03091_ sky130_fd_sc_hd__o21ai_0
X_23815_ net696 _02987_ _02993_ VSS VSS VDD VDD _03092_ sky130_fd_sc_hd__nor3_2
X_23816_ _12465_ net393 VSS VSS VDD VDD _03093_ sky130_fd_sc_hd__nor2_2
X_23817_ _03012_ _03092_ _03093_ _03075_ VSS VSS VDD VDD _03094_
+ sky130_fd_sc_hd__o31ai_2
XTAP_TAPCELL_ROW_0_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23819_ net533 _03017_ VSS VSS VDD VDD _03096_ sky130_fd_sc_hd__nor2_2
X_23820_ _12462_ net586 _03096_ VSS VSS VDD VDD _03097_ sky130_fd_sc_hd__a21oi_1
X_23821_ _12460_ _03080_ _03097_ net393 VSS VSS VDD VDD _03098_
+ sky130_fd_sc_hd__o22ai_1
X_23822_ _03094_ _03098_ VSS VSS VDD VDD _03099_ sky130_fd_sc_hd__or2_0
XTAP_TAPCELL_ROW_0_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23824_ u0.tmp_w\[7\] _03058_ VSS VSS VDD VDD _03101_ sky130_fd_sc_hd__xnor2_4
X_23825_ _03054_ _03101_ VSS VSS VDD VDD _03102_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_0_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23827_ net392 _03012_ VSS VSS VDD VDD _03104_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_0_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23831_ _12481_ _03012_ _03104_ _12461_ _03075_ VSS VSS VDD
+ VDD _03108_ sky130_fd_sc_hd__a221oi_1
X_23832_ _03047_ _03102_ _03108_ VSS VSS VDD VDD _03109_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_0_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23837_ _12462_ _03012_ VSS VSS VDD VDD _03114_ sky130_fd_sc_hd__nor2_4
X_23838_ net394 _02987_ _03017_ VSS VSS VDD VDD _03115_ sky130_fd_sc_hd__nor3_4
X_23839_ _02993_ _03114_ _03115_ VSS VSS VDD VDD _03116_ sky130_fd_sc_hd__nor3_1
X_23840_ _12470_ _03025_ _03116_ net391 VSS VSS VDD VDD _03117_
+ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23842_ _02993_ _03017_ VSS VSS VDD VDD _03119_ sky130_fd_sc_hd__nand2_8
X_23843_ _12468_ _03119_ VSS VSS VDD VDD _03120_ sky130_fd_sc_hd__nor2_1
X_23844_ _12462_ _03012_ VSS VSS VDD VDD _03121_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23846_ net394 _02987_ _03017_ VSS VSS VDD VDD _03123_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23848_ _03121_ _03123_ _02993_ VSS VSS VDD VDD _03125_ sky130_fd_sc_hd__a21oi_1
X_23849_ net389 _03120_ _03125_ VSS VSS VDD VDD _03126_ sky130_fd_sc_hd__nor3_1
X_23850_ _03086_ _03102_ _03117_ _03126_ VSS VSS VDD VDD _03127_
+ sky130_fd_sc_hd__nor4_1
X_23851_ _03099_ _03109_ _03127_ VSS VSS VDD VDD _03128_ sky130_fd_sc_hd__a21oi_1
X_23852_ _12461_ _02993_ VSS VSS VDD VDD _03129_ sky130_fd_sc_hd__nand2_2
X_23853_ _02981_ net393 VSS VSS VDD VDD _03130_ sky130_fd_sc_hd__nand2_4
X_23854_ net586 _03129_ _03130_ net391 VSS VSS VDD VDD _03131_
+ sky130_fd_sc_hd__a31oi_2
X_23855_ net533 _02993_ VSS VSS VDD VDD _03132_ sky130_fd_sc_hd__nor2_2
X_23856_ _12468_ net393 VSS VSS VDD VDD _03133_ sky130_fd_sc_hd__nor2_1
X_23857_ _03132_ _03133_ _03012_ VSS VSS VDD VDD _03134_ sky130_fd_sc_hd__o21ai_0
X_23858_ _12460_ _03104_ VSS VSS VDD VDD _03135_ sky130_fd_sc_hd__nand2_1
X_23859_ _12465_ _03017_ VSS VSS VDD VDD _03136_ sky130_fd_sc_hd__nor2_4
X_23860_ _03136_ _03114_ net393 VSS VSS VDD VDD _03137_ sky130_fd_sc_hd__o21ai_0
X_23861_ _03135_ _03137_ _03075_ VSS VSS VDD VDD _03138_ sky130_fd_sc_hd__a21oi_1
X_23862_ _03131_ _03134_ _03138_ VSS VSS VDD VDD _03139_ sky130_fd_sc_hd__a21oi_1
X_23863_ _02981_ _02987_ net586 VSS VSS VDD VDD _03140_ sky130_fd_sc_hd__a21oi_1
X_23864_ _12465_ _03012_ VSS VSS VDD VDD _03141_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23866_ net502 _03025_ _03141_ net391 VSS VSS VDD VDD _03143_
+ sky130_fd_sc_hd__a211oi_1
X_23867_ _02993_ _03140_ _03143_ VSS VSS VDD VDD _03144_ sky130_fd_sc_hd__o21ai_0
X_23868_ _12461_ _03017_ VSS VSS VDD VDD _03145_ sky130_fd_sc_hd__nor2_2
X_23869_ _12470_ _03012_ VSS VSS VDD VDD _03146_ sky130_fd_sc_hd__nor2_1
X_23870_ _03145_ _03146_ net393 VSS VSS VDD VDD _03147_ sky130_fd_sc_hd__o21ai_0
X_23871_ _12465_ _03119_ _03147_ net391 VSS VSS VDD VDD _03148_
+ sky130_fd_sc_hd__o211ai_1
X_23872_ _03054_ _03101_ VSS VSS VDD VDD _03149_ sky130_fd_sc_hd__nand2b_2
X_23873_ _03086_ _03144_ _03148_ _03149_ VSS VSS VDD VDD _03150_
+ sky130_fd_sc_hd__a31oi_1
X_23874_ _03086_ _03139_ _03150_ VSS VSS VDD VDD _03151_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23876_ net533 net390 _02993_ VSS VSS VDD VDD _03153_ sky130_fd_sc_hd__a21oi_1
X_23877_ _02993_ net390 VSS VSS VDD VDD _03154_ sky130_fd_sc_hd__nor2_1
X_23878_ net533 net392 VSS VSS VDD VDD _03155_ sky130_fd_sc_hd__nor2_2
X_23879_ _12461_ _03154_ _03155_ net390 VSS VSS VDD VDD _03156_
+ sky130_fd_sc_hd__a22oi_1
X_23880_ net394 _03153_ _03156_ VSS VSS VDD VDD _03157_ sky130_fd_sc_hd__o21ai_0
X_23881_ _12461_ net392 net390 _03012_ VSS VSS VDD VDD _03158_
+ sky130_fd_sc_hd__o31ai_1
X_23882_ net696 _02986_ VSS VSS VDD VDD _03159_ sky130_fd_sc_hd__nand2_1
X_23883_ _03041_ _03159_ _03086_ VSS VSS VDD VDD _03160_ sky130_fd_sc_hd__a21oi_1
X_23884_ _03012_ _03157_ _03158_ _03160_ VSS VSS VDD VDD _03161_
+ sky130_fd_sc_hd__o22ai_2
X_23885_ _02993_ _03012_ VSS VSS VDD VDD _03162_ sky130_fd_sc_hd__nand2_4
X_23886_ _03033_ _03162_ VSS VSS VDD VDD _03163_ sky130_fd_sc_hd__and2_0
X_23887_ _12468_ _03119_ _03163_ _12460_ _03073_ VSS VSS VDD
+ VDD _03164_ sky130_fd_sc_hd__o221ai_1
X_23888_ _03086_ _03164_ net391 VSS VSS VDD VDD _03165_ sky130_fd_sc_hd__a21oi_1
X_23889_ _12468_ _03012_ VSS VSS VDD VDD _03166_ sky130_fd_sc_hd__nand2_2
X_23890_ _12461_ _03012_ _03166_ VSS VSS VDD VDD _03167_ sky130_fd_sc_hd__o21ai_0
X_23891_ _02981_ _02987_ _03017_ VSS VSS VDD VDD _03168_ sky130_fd_sc_hd__nand3_4
X_23892_ _12460_ _03012_ VSS VSS VDD VDD _03169_ sky130_fd_sc_hd__nand2_1
X_23893_ _02993_ _03168_ _03169_ VSS VSS VDD VDD _03170_ sky130_fd_sc_hd__nand3_1
X_23894_ _02993_ _03167_ _03170_ VSS VSS VDD VDD _03171_ sky130_fd_sc_hd__o21ai_0
X_23895_ _03047_ _03171_ VSS VSS VDD VDD _03172_ sky130_fd_sc_hd__nand2_1
X_23896_ _03054_ _03059_ VSS VSS VDD VDD _03173_ sky130_fd_sc_hd__nand2_8
X_23897_ net391 _03161_ _03165_ _03172_ _03173_ VSS VSS VDD
+ VDD _03174_ sky130_fd_sc_hd__a221o_1
X_23898_ _03091_ _03128_ _03151_ _03174_ VSS VSS VDD VDD _00152_
+ sky130_fd_sc_hd__nand4b_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23900_ _12462_ _03012_ _03169_ net393 VSS VSS VDD VDD _03176_
+ sky130_fd_sc_hd__o211ai_1
X_23901_ _12461_ VSS VSS VDD VDD _03177_ sky130_fd_sc_hd__clkinvlp_4
X_23902_ _03177_ _03012_ VSS VSS VDD VDD _03178_ sky130_fd_sc_hd__nand2_4
X_23903_ net538 _03017_ VSS VSS VDD VDD _03179_ sky130_fd_sc_hd__nand2_4
X_23904_ _02993_ _03178_ _03179_ VSS VSS VDD VDD _03180_ sky130_fd_sc_hd__nand3_1
X_23905_ _12465_ _03012_ VSS VSS VDD VDD _03181_ sky130_fd_sc_hd__nand2_1
X_23906_ _03179_ _03181_ _02993_ VSS VSS VDD VDD _03182_ sky130_fd_sc_hd__a21oi_1
X_23907_ _02981_ _03012_ VSS VSS VDD VDD _03183_ sky130_fd_sc_hd__nand2_2
X_23908_ _12460_ net586 VSS VSS VDD VDD _03184_ sky130_fd_sc_hd__nand2b_1
X_23909_ _03183_ _03184_ net393 VSS VSS VDD VDD _03185_ sky130_fd_sc_hd__a21oi_1
X_23910_ net391 _03182_ _03185_ VSS VSS VDD VDD _03186_ sky130_fd_sc_hd__nor3_1
X_23911_ net391 _03176_ _03180_ _03186_ VSS VSS VDD VDD _03187_
+ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23913_ _12474_ net586 _02993_ VSS VSS VDD VDD _03189_ sky130_fd_sc_hd__a21oi_1
X_23914_ _03178_ _03189_ net389 VSS VSS VDD VDD _03190_ sky130_fd_sc_hd__a21oi_1
X_23915_ _02987_ _03012_ VSS VSS VDD VDD _03191_ sky130_fd_sc_hd__nand2_4
X_23916_ net394 _03191_ VSS VSS VDD VDD _03192_ sky130_fd_sc_hd__nor2_1
X_23917_ _03114_ _03192_ _02993_ VSS VSS VDD VDD _03193_ sky130_fd_sc_hd__o21ai_0
X_23918_ net539 _02993_ _03017_ VSS VSS VDD VDD _03194_ sky130_fd_sc_hd__nand3_1
X_23919_ net389 _03194_ VSS VSS VDD VDD _03195_ sky130_fd_sc_hd__nand2_1
X_23920_ _03168_ _03178_ _02993_ VSS VSS VDD VDD _03196_ sky130_fd_sc_hd__a21oi_1
X_23921_ _03190_ _03193_ _03195_ _03196_ VSS VSS VDD VDD _03197_
+ sky130_fd_sc_hd__o2bb2ai_1
X_23922_ _03089_ _03187_ _03197_ _03061_ VSS VSS VDD VDD _03198_
+ sky130_fd_sc_hd__a22oi_1
X_23923_ _02987_ _02993_ VSS VSS VDD VDD _03199_ sky130_fd_sc_hd__nor2_1
X_23924_ _12460_ _02993_ _03199_ VSS VSS VDD VDD _03200_ sky130_fd_sc_hd__a21oi_1
X_23925_ _03155_ _03183_ _03199_ _03200_ _03012_ VSS VSS VDD
+ VDD _03201_ sky130_fd_sc_hd__o32ai_1
X_23926_ _03063_ _03183_ net393 VSS VSS VDD VDD _03202_ sky130_fd_sc_hd__a21oi_1
X_23927_ _03047_ _03182_ _03202_ VSS VSS VDD VDD _03203_ sky130_fd_sc_hd__nor3_1
X_23928_ net390 _03201_ _03203_ VSS VSS VDD VDD _03204_ sky130_fd_sc_hd__a21oi_1
X_23929_ _12468_ _02993_ VSS VSS VDD VDD _03205_ sky130_fd_sc_hd__nand2_1
X_23930_ net394 net502 VSS VSS VDD VDD _03206_ sky130_fd_sc_hd__nor2_2
X_23931_ net392 _03206_ VSS VSS VDD VDD _03207_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23933_ _12484_ _03047_ net586 VSS VSS VDD VDD _03209_ sky130_fd_sc_hd__nor3_1
X_23934_ net586 _03205_ _03207_ _03209_ VSS VSS VDD VDD _03210_
+ sky130_fd_sc_hd__a31oi_2
X_23935_ _03075_ _03210_ _03173_ VSS VSS VDD VDD _03211_ sky130_fd_sc_hd__a21oi_1
X_23936_ net389 _03204_ _03211_ VSS VSS VDD VDD _03212_ sky130_fd_sc_hd__o21ai_0
X_23937_ _12465_ net586 VSS VSS VDD VDD _03213_ sky130_fd_sc_hd__nand2_1
X_23938_ net392 _03178_ _03213_ VSS VSS VDD VDD _03214_ sky130_fd_sc_hd__nand3_1
X_23939_ net392 _03140_ _03214_ net388 VSS VSS VDD VDD _03215_
+ sky130_fd_sc_hd__o211ai_1
X_23940_ _12474_ _02993_ VSS VSS VDD VDD _03216_ sky130_fd_sc_hd__nand2_1
X_23941_ _03130_ _03216_ net586 VSS VSS VDD VDD _03217_ sky130_fd_sc_hd__a21oi_1
X_23942_ _12465_ _03003_ VSS VSS VDD VDD _03218_ sky130_fd_sc_hd__nor2_1
X_23943_ _03206_ _03033_ _03218_ VSS VSS VDD VDD _03219_ sky130_fd_sc_hd__nor3_1
X_23944_ _03003_ _03217_ _03219_ VSS VSS VDD VDD _03220_ sky130_fd_sc_hd__a21oi_1
X_23945_ net390 _03215_ _03220_ VSS VSS VDD VDD _03221_ sky130_fd_sc_hd__nand3_1
X_23946_ _02993_ _03012_ VSS VSS VDD VDD _03222_ sky130_fd_sc_hd__xnor2_2
X_23947_ _12461_ _03104_ _03222_ net502 _03096_ net394 VSS
+ VSS VDD VDD _03223_ sky130_fd_sc_hd__a222oi_1
X_23948_ net389 _03223_ VSS VSS VDD VDD _03224_ sky130_fd_sc_hd__nand2_1
X_23949_ _03177_ _03009_ _03011_ VSS VSS VDD VDD _03225_ sky130_fd_sc_hd__nor3_2
X_23950_ _12460_ _03017_ VSS VSS VDD VDD _03226_ sky130_fd_sc_hd__and2_2
X_23951_ _03225_ _03226_ net393 VSS VSS VDD VDD _03227_ sky130_fd_sc_hd__o21ai_2
X_23952_ _02987_ _03012_ VSS VSS VDD VDD _03228_ sky130_fd_sc_hd__nor2_4
X_23953_ _03136_ _03228_ _02993_ VSS VSS VDD VDD _03229_ sky130_fd_sc_hd__o21ai_0
X_23954_ net391 _03227_ _03229_ VSS VSS VDD VDD _03230_ sky130_fd_sc_hd__nand3_1
X_23955_ _03086_ _03224_ _03230_ _03149_ VSS VSS VDD VDD _03231_
+ sky130_fd_sc_hd__a31oi_1
X_23956_ _12474_ net561 VSS VSS VDD VDD _03232_ sky130_fd_sc_hd__nand2_1
X_23957_ _03129_ _03232_ net586 VSS VSS VDD VDD _03233_ sky130_fd_sc_hd__a21oi_1
X_23958_ _12465_ _03119_ _03222_ _02981_ VSS VSS VDD VDD _03234_
+ sky130_fd_sc_hd__a2bb2oi_1
X_23959_ _03094_ _03233_ _03234_ _03075_ VSS VSS VDD VDD _03235_
+ sky130_fd_sc_hd__o22ai_2
X_23960_ _03070_ _03162_ _02981_ VSS VSS VDD VDD _03236_ sky130_fd_sc_hd__a21oi_1
X_23961_ _03155_ _03236_ net389 VSS VSS VDD VDD _03237_ sky130_fd_sc_hd__o21ai_0
X_23962_ _02981_ net391 VSS VSS VDD VDD _03238_ sky130_fd_sc_hd__nor2_1
X_23963_ _03179_ _03238_ _03191_ VSS VSS VDD VDD _03239_ sky130_fd_sc_hd__o21ai_0
X_23964_ _12465_ _03017_ _03225_ VSS VSS VDD VDD _03240_ sky130_fd_sc_hd__a21oi_1
X_23965_ _02993_ _03075_ _03240_ _03047_ VSS VSS VDD VDD _03241_
+ sky130_fd_sc_hd__o31ai_1
X_23966_ _02993_ _03239_ _03241_ VSS VSS VDD VDD _03242_ sky130_fd_sc_hd__a21oi_1
X_23967_ _03086_ _03235_ _03237_ _03242_ _03102_ VSS VSS VDD
+ VDD _03243_ sky130_fd_sc_hd__a221oi_1
X_23968_ _03221_ _03231_ _03243_ VSS VSS VDD VDD _03244_ sky130_fd_sc_hd__a21oi_1
X_23969_ _03198_ _03212_ _03244_ VSS VSS VDD VDD _00153_ sky130_fd_sc_hd__nand3_1
X_23970_ _12462_ _12465_ VSS VSS VDD VDD _03245_ sky130_fd_sc_hd__nor2_2
X_23971_ _03012_ _03245_ VSS VSS VDD VDD _03246_ sky130_fd_sc_hd__nand2_1
X_23972_ _12468_ net586 _03192_ net393 VSS VSS VDD VDD _03247_
+ sky130_fd_sc_hd__a211oi_1
X_23973_ net393 _03168_ _03246_ _03247_ net389 VSS VSS VDD
+ VDD _03248_ sky130_fd_sc_hd__a311o_1
X_23974_ _12465_ _03025_ VSS VSS VDD VDD _03249_ sky130_fd_sc_hd__nand2_1
X_23975_ _02993_ _03145_ _03226_ _03249_ _03075_ VSS VSS VDD
+ VDD _03250_ sky130_fd_sc_hd__o311ai_1
X_23976_ _02981_ _03017_ _03132_ _03130_ _03096_ VSS VSS VDD
+ VDD _03251_ sky130_fd_sc_hd__o32a_1
X_23977_ _02981_ net561 VSS VSS VDD VDD _03252_ sky130_fd_sc_hd__nor2_1
X_23978_ _03028_ _03252_ _12461_ VSS VSS VDD VDD _03253_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_23980_ _03251_ _03253_ _03075_ VSS VSS VDD VDD _03255_ sky130_fd_sc_hd__a21oi_1
X_23981_ _12461_ net561 VSS VSS VDD VDD _03256_ sky130_fd_sc_hd__nor2_1
X_23982_ net586 _03092_ _03256_ VSS VSS VDD VDD _03257_ sky130_fd_sc_hd__nor3_1
X_23983_ _12481_ _03017_ _03257_ net391 VSS VSS VDD VDD _03258_
+ sky130_fd_sc_hd__a211oi_1
X_23984_ _03059_ _03086_ VSS VSS VDD VDD _03259_ sky130_fd_sc_hd__nor2_1
X_23985_ _03054_ _03255_ _03258_ _03259_ VSS VSS VDD VDD _03260_
+ sky130_fd_sc_hd__o31ai_1
X_23986_ _03054_ _03248_ _03250_ _03260_ VSS VSS VDD VDD _03261_
+ sky130_fd_sc_hd__a31oi_1
X_23987_ _12474_ _12465_ net393 VSS VSS VDD VDD _03262_ sky130_fd_sc_hd__mux2i_1
X_23988_ net586 _03262_ VSS VSS VDD VDD _03263_ sky130_fd_sc_hd__nand2_1
X_23989_ _02987_ _02993_ VSS VSS VDD VDD _03264_ sky130_fd_sc_hd__nand2_1
X_23990_ net394 _03017_ VSS VSS VDD VDD _03265_ sky130_fd_sc_hd__nor2_2
X_23991_ _03264_ _03265_ VSS VSS VDD VDD _03266_ sky130_fd_sc_hd__nand2_1
X_23992_ _03092_ _03093_ _03012_ VSS VSS VDD VDD _03267_ sky130_fd_sc_hd__o21ai_2
X_23993_ net391 _03263_ _03266_ _03131_ _03267_ VSS VSS VDD
+ VDD _03268_ sky130_fd_sc_hd__a32oi_1
X_23994_ _03047_ _03268_ VSS VSS VDD VDD _03269_ sky130_fd_sc_hd__nor2_1
X_23995_ _12461_ _03017_ VSS VSS VDD VDD _03270_ sky130_fd_sc_hd__nand2_8
X_23996_ _03270_ _03191_ _02993_ VSS VSS VDD VDD _03271_ sky130_fd_sc_hd__a21oi_1
X_23997_ _12462_ net586 VSS VSS VDD VDD _03272_ sky130_fd_sc_hd__nor2_1
X_23998_ net393 _03028_ _03272_ VSS VSS VDD VDD _03273_ sky130_fd_sc_hd__nor3_1
X_23999_ _12474_ _03080_ VSS VSS VDD VDD _03274_ sky130_fd_sc_hd__nor2_1
X_24000_ _02981_ _02993_ VSS VSS VDD VDD _03275_ sky130_fd_sc_hd__nand2_4
X_24001_ _03191_ _03179_ _03275_ VSS VSS VDD VDD _03276_ sky130_fd_sc_hd__a21oi_1
X_24002_ _03274_ _03276_ _03075_ VSS VSS VDD VDD _03277_ sky130_fd_sc_hd__o21ai_0
X_24003_ _03075_ _03271_ _03273_ _03277_ _03047_ VSS VSS VDD
+ VDD _03278_ sky130_fd_sc_hd__o311a_1
X_24004_ _03173_ _03269_ _03278_ VSS VSS VDD VDD _03279_ sky130_fd_sc_hd__nor3_1
X_24005_ _12470_ _03017_ _03145_ VSS VSS VDD VDD _03280_ sky130_fd_sc_hd__a21oi_1
X_24006_ net393 _03178_ _03179_ VSS VSS VDD VDD _03281_ sky130_fd_sc_hd__nand3_1
X_24007_ net393 _03280_ _03281_ VSS VSS VDD VDD _03282_ sky130_fd_sc_hd__o21ai_0
X_24008_ _12470_ _03012_ VSS VSS VDD VDD _03283_ sky130_fd_sc_hd__nand2_4
X_24009_ _12474_ _03017_ VSS VSS VDD VDD _03284_ sky130_fd_sc_hd__nand2b_2
X_24010_ _03183_ _03284_ net393 VSS VSS VDD VDD _03285_ sky130_fd_sc_hd__a21oi_1
X_24011_ net393 _03070_ _03283_ _03285_ _03075_ VSS VSS VDD
+ VDD _03286_ sky130_fd_sc_hd__a311oi_1
X_24012_ _03075_ _03282_ _03286_ VSS VSS VDD VDD _03287_ sky130_fd_sc_hd__a21oi_1
X_24013_ _12470_ _03017_ _02993_ VSS VSS VDD VDD _03288_ sky130_fd_sc_hd__a21oi_1
X_24014_ _03183_ _03288_ net391 _03047_ _03093_ VSS VSS VDD
+ VDD _03289_ sky130_fd_sc_hd__a2111oi_0
X_24015_ _03060_ _03289_ VSS VSS VDD VDD _03290_ sky130_fd_sc_hd__nor2_1
X_24016_ _02993_ _03027_ _03146_ VSS VSS VDD VDD _03291_ sky130_fd_sc_hd__nor3_1
X_24017_ _12474_ _03012_ VSS VSS VDD VDD _03292_ sky130_fd_sc_hd__nor2_1
X_24018_ net393 _03136_ _03292_ VSS VSS VDD VDD _03293_ sky130_fd_sc_hd__nor3_1
X_24019_ _03291_ _03293_ net391 _03086_ VSS VSS VDD VDD _03294_
+ sky130_fd_sc_hd__o211ai_1
X_24020_ _03086_ _03287_ _03290_ _03294_ VSS VSS VDD VDD _03295_
+ sky130_fd_sc_hd__o211a_1
X_24021_ _12488_ _03012_ _03266_ VSS VSS VDD VDD _03296_ sky130_fd_sc_hd__o21ai_0
X_24022_ _12479_ _03012_ _03003_ VSS VSS VDD VDD _03297_ sky130_fd_sc_hd__a21oi_1
X_24023_ net696 _02987_ net393 _03012_ _03297_ VSS VSS VDD
+ VDD _03298_ sky130_fd_sc_hd__o41ai_1
X_24024_ _03075_ _03296_ _03298_ VSS VSS VDD VDD _03299_ sky130_fd_sc_hd__o21ai_0
X_24025_ net393 _03145_ _03226_ VSS VSS VDD VDD _03300_ sky130_fd_sc_hd__nor3_1
X_24026_ net393 _03166_ _03063_ _03300_ _03075_ VSS VSS VDD
+ VDD _03301_ sky130_fd_sc_hd__a311oi_2
X_24027_ _12484_ _03012_ _03075_ VSS VSS VDD VDD _03302_ sky130_fd_sc_hd__o21ai_0
X_24028_ _03012_ _03159_ _03130_ _03302_ VSS VSS VDD VDD _03303_
+ sky130_fd_sc_hd__a31oi_2
X_24029_ _03054_ _03301_ _03303_ VSS VSS VDD VDD _03304_ sky130_fd_sc_hd__nor3_1
X_24030_ _03054_ _03299_ _03304_ _03047_ _03059_ VSS VSS VDD
+ VDD _03305_ sky130_fd_sc_hd__a2111oi_1
X_24031_ _03261_ _03279_ _03295_ _03305_ VSS VSS VDD VDD _00154_
+ sky130_fd_sc_hd__nor4_2
X_24032_ _12470_ _03017_ VSS VSS VDD VDD _03306_ sky130_fd_sc_hd__nor2_2
X_24033_ _12468_ net586 _03306_ net392 VSS VSS VDD VDD _03307_
+ sky130_fd_sc_hd__a211oi_4
X_24034_ net392 _03168_ _03246_ _03307_ VSS VSS VDD VDD _03308_
+ sky130_fd_sc_hd__a31oi_1
X_24035_ _12460_ _03080_ _03119_ net394 VSS VSS VDD VDD _03309_
+ sky130_fd_sc_hd__o22ai_1
X_24036_ net392 _03063_ net502 VSS VSS VDD VDD _03310_ sky130_fd_sc_hd__a21oi_1
X_24037_ _03309_ _03310_ net390 VSS VSS VDD VDD _03311_ sky130_fd_sc_hd__o21ai_0
X_24038_ net390 _03308_ _03311_ VSS VSS VDD VDD _03312_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_24040_ _03047_ _03012_ VSS VSS VDD VDD _03314_ sky130_fd_sc_hd__nor2_2
X_24041_ _03047_ _03270_ _03283_ _03314_ net502 VSS VSS VDD
+ VDD _03315_ sky130_fd_sc_hd__a32oi_1
X_24042_ _02987_ _03047_ _03012_ _03292_ net393 VSS VSS VDD
+ VDD _03316_ sky130_fd_sc_hd__a311oi_1
X_24043_ net393 _03315_ _03316_ VSS VSS VDD VDD _03317_ sky130_fd_sc_hd__a21oi_1
X_24044_ net391 _03317_ _03060_ VSS VSS VDD VDD _03318_ sky130_fd_sc_hd__a21oi_2
X_24045_ net391 _03312_ _03318_ VSS VSS VDD VDD _03319_ sky130_fd_sc_hd__o21ai_0
X_24046_ _12461_ net586 _03021_ VSS VSS VDD VDD _03320_ sky130_fd_sc_hd__a21oi_1
X_24047_ net392 _03016_ _03136_ VSS VSS VDD VDD _03321_ sky130_fd_sc_hd__nor3_1
X_24048_ net392 _03320_ _03321_ VSS VSS VDD VDD _03322_ sky130_fd_sc_hd__a21oi_1
X_24049_ _03132_ _03063_ _03228_ _03275_ _03073_ VSS VSS VDD
+ VDD _03323_ sky130_fd_sc_hd__o221ai_1
X_24050_ net390 _03323_ VSS VSS VDD VDD _03324_ sky130_fd_sc_hd__nor2_1
X_24051_ net390 _03322_ _03324_ VSS VSS VDD VDD _03325_ sky130_fd_sc_hd__a21oi_1
X_24052_ net393 _03086_ VSS VSS VDD VDD _03326_ sky130_fd_sc_hd__nor2_1
X_24053_ _03154_ _03326_ net502 VSS VSS VDD VDD _03327_ sky130_fd_sc_hd__o21ai_0
X_24054_ _12468_ net566 net390 VSS VSS VDD VDD _03328_ sky130_fd_sc_hd__nand3_1
X_24055_ net565 net390 VSS VSS VDD VDD _03329_ sky130_fd_sc_hd__nor2_1
X_24056_ net394 _03329_ VSS VSS VDD VDD _03330_ sky130_fd_sc_hd__nand2_1
X_24057_ net586 _03327_ _03328_ _03330_ VSS VSS VDD VDD _03331_
+ sky130_fd_sc_hd__nand4_1
X_24058_ _12461_ _03086_ VSS VSS VDD VDD _03332_ sky130_fd_sc_hd__xnor2_1
X_24059_ _12460_ net392 net390 VSS VSS VDD VDD _03333_ sky130_fd_sc_hd__nand3_1
X_24060_ net392 _03332_ _03333_ _03012_ VSS VSS VDD VDD _03334_
+ sky130_fd_sc_hd__o211ai_1
X_24061_ net391 _03331_ _03334_ _03102_ VSS VSS VDD VDD _03335_
+ sky130_fd_sc_hd__a31oi_1
X_24062_ net391 _03325_ _03335_ VSS VSS VDD VDD _03336_ sky130_fd_sc_hd__o21ai_0
X_24063_ _03054_ _03059_ VSS VSS VDD VDD _03337_ sky130_fd_sc_hd__nor2_2
X_24064_ _12470_ net586 net390 net392 VSS VSS VDD VDD _03338_
+ sky130_fd_sc_hd__a211oi_1
X_24065_ net394 _03012_ VSS VSS VDD VDD _03339_ sky130_fd_sc_hd__nand2_1
X_24066_ _03270_ _03339_ _03154_ VSS VSS VDD VDD _03340_ sky130_fd_sc_hd__a21boi_0
X_24067_ _12468_ _03017_ VSS VSS VDD VDD _03341_ sky130_fd_sc_hd__nand2b_1
X_24068_ _03191_ _03341_ net392 VSS VSS VDD VDD _03342_ sky130_fd_sc_hd__a21oi_1
X_24069_ _12461_ _03033_ VSS VSS VDD VDD _03343_ sky130_fd_sc_hd__nor2_1
X_24070_ _03086_ _03115_ _03342_ _03343_ VSS VSS VDD VDD _03344_
+ sky130_fd_sc_hd__nor4_1
X_24071_ _03066_ _03338_ _03340_ _03344_ net388 VSS VSS VDD
+ VDD _03345_ sky130_fd_sc_hd__a2111oi_0
X_24072_ _03086_ _03012_ VSS VSS VDD VDD _03346_ sky130_fd_sc_hd__nor2_1
X_24073_ _02981_ _03080_ _03264_ VSS VSS VDD VDD _03347_ sky130_fd_sc_hd__nand3_1
X_24074_ net390 _03228_ _03347_ VSS VSS VDD VDD _03348_ sky130_fd_sc_hd__a21oi_1
X_24075_ _12468_ net390 _03012_ VSS VSS VDD VDD _03349_ sky130_fd_sc_hd__nand3_1
X_24076_ _02987_ _03314_ VSS VSS VDD VDD _03350_ sky130_fd_sc_hd__nand2_1
X_24077_ _03349_ _03350_ _02993_ VSS VSS VDD VDD _03351_ sky130_fd_sc_hd__a21oi_1
X_24078_ net388 _03337_ VSS VSS VDD VDD _03352_ sky130_fd_sc_hd__nand2_1
X_24079_ _03256_ _03346_ _03348_ _03351_ _03352_ VSS VSS VDD
+ VDD _03353_ sky130_fd_sc_hd__a2111oi_1
X_24080_ _03337_ _03345_ _03353_ VSS VSS VDD VDD _03354_ sky130_fd_sc_hd__a21oi_1
X_24081_ _12461_ _03012_ _03246_ net392 VSS VSS VDD VDD _03355_
+ sky130_fd_sc_hd__o211ai_1
X_24082_ net392 _03021_ _03228_ _03355_ _03086_ VSS VSS VDD
+ VDD _03356_ sky130_fd_sc_hd__o311ai_0
X_24083_ _12470_ _03163_ _03132_ net586 _03086_ VSS VSS VDD
+ VDD _03357_ sky130_fd_sc_hd__a221oi_1
X_24084_ _03173_ net391 _03357_ VSS VSS VDD VDD _03358_ sky130_fd_sc_hd__nor3_1
X_24085_ _02981_ _03033_ VSS VSS VDD VDD _03359_ sky130_fd_sc_hd__nor2_1
X_24086_ _03178_ _03341_ VSS VSS VDD VDD _03360_ sky130_fd_sc_hd__nand2_1
X_24087_ _12461_ _03086_ _03012_ _03121_ VSS VSS VDD VDD _03361_
+ sky130_fd_sc_hd__o31ai_1
X_24088_ _03086_ _03359_ _03360_ _03329_ _03361_ net566 VSS
+ VSS VDD VDD _03362_ sky130_fd_sc_hd__a222oi_1
X_24089_ _03173_ net388 _03362_ VSS VSS VDD VDD _03363_ sky130_fd_sc_hd__nor3_1
X_24090_ _03356_ _03358_ _03363_ VSS VSS VDD VDD _03364_ sky130_fd_sc_hd__a21oi_1
X_24091_ _03319_ _03336_ _03354_ _03364_ VSS VSS VDD VDD _00155_
+ sky130_fd_sc_hd__nand4_1
X_24092_ _03003_ _03086_ VSS VSS VDD VDD _03365_ sky130_fd_sc_hd__nor2_2
X_24093_ _03115_ _03292_ net393 VSS VSS VDD VDD _03366_ sky130_fd_sc_hd__o21ai_0
X_24094_ _02993_ _03270_ _03283_ VSS VSS VDD VDD _03367_ sky130_fd_sc_hd__nand3_1
X_24095_ _03365_ _03366_ _03367_ _03102_ VSS VSS VDD VDD _03368_
+ sky130_fd_sc_hd__a31oi_1
X_24096_ _12470_ net393 VSS VSS VDD VDD _03369_ sky130_fd_sc_hd__nand2_1
X_24097_ net393 _03240_ _03369_ VSS VSS VDD VDD _03370_ sky130_fd_sc_hd__o21ai_0
X_24098_ _03075_ _03086_ VSS VSS VDD VDD _03371_ sky130_fd_sc_hd__nor2_1
X_24099_ net394 _03179_ VSS VSS VDD VDD _03372_ sky130_fd_sc_hd__nor2_2
X_24100_ net393 _03169_ VSS VSS VDD VDD _03373_ sky130_fd_sc_hd__nand2_1
X_24101_ net393 _03079_ _03141_ _03372_ _03373_ VSS VSS VDD
+ VDD _03374_ sky130_fd_sc_hd__o32a_1
X_24102_ _03092_ _03252_ _03012_ VSS VSS VDD VDD _03375_ sky130_fd_sc_hd__o21ai_0
X_24103_ _03263_ _03375_ _03075_ VSS VSS VDD VDD _03376_ sky130_fd_sc_hd__a21oi_1
X_24104_ _03075_ _03374_ _03376_ _03047_ VSS VSS VDD VDD _03377_
+ sky130_fd_sc_hd__a211oi_1
X_24105_ _03370_ _03371_ _03377_ VSS VSS VDD VDD _03378_ sky130_fd_sc_hd__a21oi_1
X_24106_ _02993_ _03114_ _03283_ _03003_ VSS VSS VDD VDD _03379_
+ sky130_fd_sc_hd__o211ai_1
X_24107_ net561 _03265_ _03226_ net388 _03041_ VSS VSS VDD
+ VDD _03380_ sky130_fd_sc_hd__o311ai_1
X_24108_ net390 _03379_ _03380_ VSS VSS VDD VDD _03381_ sky130_fd_sc_hd__nand3_1
X_24109_ _02993_ net388 VSS VSS VDD VDD _03382_ sky130_fd_sc_hd__nand2_1
X_24110_ net536 _03382_ net394 VSS VSS VDD VDD _03383_ sky130_fd_sc_hd__a21oi_1
X_24111_ _03012_ _03132_ _03383_ VSS VSS VDD VDD _03384_ sky130_fd_sc_hd__nor3_1
X_24112_ _03003_ _03130_ VSS VSS VDD VDD _03385_ sky130_fd_sc_hd__nor2_1
X_24113_ _12460_ _02993_ _03003_ net586 _03385_ VSS VSS VDD
+ VDD _03386_ sky130_fd_sc_hd__a311oi_1
X_24114_ _02993_ _03075_ VSS VSS VDD VDD _03387_ sky130_fd_sc_hd__nor2_1
X_24115_ net388 _03027_ _03387_ VSS VSS VDD VDD _03388_ sky130_fd_sc_hd__a21oi_1
X_24116_ _03384_ _03386_ _03388_ _02981_ _03086_ VSS VSS VDD
+ VDD _03389_ sky130_fd_sc_hd__o221ai_1
X_24117_ _03096_ _03226_ _02993_ VSS VSS VDD VDD _03390_ sky130_fd_sc_hd__o21a_1
X_24118_ _12472_ _03017_ VSS VSS VDD VDD _03391_ sky130_fd_sc_hd__nand2_1
X_24119_ _03017_ _03129_ _03391_ _03047_ VSS VSS VDD VDD _03392_
+ sky130_fd_sc_hd__o211ai_1
X_24120_ _03047_ _03034_ _03115_ _03390_ _03392_ VSS VSS VDD
+ VDD _03393_ sky130_fd_sc_hd__o41ai_1
X_24121_ _03306_ _03346_ _02993_ VSS VSS VDD VDD _03394_ sky130_fd_sc_hd__o21ai_0
X_24122_ net392 net390 _03012_ VSS VSS VDD VDD _03395_ sky130_fd_sc_hd__nand3_1
X_24123_ _03119_ _03395_ _02981_ VSS VSS VDD VDD _03396_ sky130_fd_sc_hd__a21oi_1
X_24124_ _03154_ _03096_ _03396_ _03372_ net388 VSS VSS VDD
+ VDD _03397_ sky130_fd_sc_hd__a2111oi_0
X_24125_ net388 _03393_ _03394_ _03397_ _03173_ VSS VSS VDD
+ VDD _03398_ sky130_fd_sc_hd__a221oi_1
X_24126_ _03337_ _03381_ _03389_ _03398_ VSS VSS VDD VDD _03399_
+ sky130_fd_sc_hd__a31o_1
X_24127_ _03027_ _02993_ _03270_ VSS VSS VDD VDD _03400_ sky130_fd_sc_hd__nand3b_1
X_24128_ _02993_ _03141_ _03192_ _03400_ _03047_ VSS VSS VDD
+ VDD _03401_ sky130_fd_sc_hd__o311ai_0
X_24129_ _12474_ _03119_ _03228_ _02993_ VSS VSS VDD VDD _03402_
+ sky130_fd_sc_hd__o22ai_1
X_24130_ _03086_ _03402_ net391 VSS VSS VDD VDD _03403_ sky130_fd_sc_hd__a21oi_1
X_24131_ _02993_ _03136_ _03226_ VSS VSS VDD VDD _03404_ sky130_fd_sc_hd__nor3_1
X_24132_ _03114_ _03192_ _03326_ VSS VSS VDD VDD _03405_ sky130_fd_sc_hd__o21ai_0
X_24133_ _03047_ _03202_ _03404_ _03405_ net391 VSS VSS VDD
+ VDD _03406_ sky130_fd_sc_hd__o311a_1
X_24134_ _03401_ _03403_ _03406_ _03060_ VSS VSS VDD VDD _03407_
+ sky130_fd_sc_hd__a211oi_1
X_24135_ _03368_ _03378_ _03399_ _03407_ VSS VSS VDD VDD _00156_
+ sky130_fd_sc_hd__a211oi_2
X_24136_ _12470_ VSS VSS VDD VDD _03408_ sky130_fd_sc_hd__inv_1
X_24137_ _03408_ _03119_ _03181_ _03047_ VSS VSS VDD VDD _03409_
+ sky130_fd_sc_hd__o211ai_1
X_24138_ _12465_ net586 _02993_ VSS VSS VDD VDD _03410_ sky130_fd_sc_hd__a21oi_1
X_24139_ _03115_ _03410_ _03086_ VSS VSS VDD VDD _03411_ sky130_fd_sc_hd__o21ai_0
X_24140_ _03125_ _03409_ _03411_ VSS VSS VDD VDD _03412_ sky130_fd_sc_hd__o21ai_1
X_24141_ _03101_ net391 _03412_ _03054_ VSS VSS VDD VDD _03413_
+ sky130_fd_sc_hd__a31oi_1
X_24142_ _03028_ _03225_ net393 VSS VSS VDD VDD _03414_ sky130_fd_sc_hd__o21ai_0
X_24143_ net393 _03146_ _03115_ _03414_ _03047_ VSS VSS VDD
+ VDD _03415_ sky130_fd_sc_hd__o311ai_2
X_24144_ _02993_ _03166_ _03284_ _03047_ VSS VSS VDD VDD _03416_
+ sky130_fd_sc_hd__a31oi_2
X_24145_ _03206_ _03033_ _03416_ VSS VSS VDD VDD _03417_ sky130_fd_sc_hd__o21ai_0
X_24146_ _03415_ _03417_ VSS VSS VDD VDD _03418_ sky130_fd_sc_hd__nand2_1
X_24147_ _03059_ net391 _03418_ VSS VSS VDD VDD _03419_ sky130_fd_sc_hd__nand3_1
X_24148_ _03270_ _03283_ VSS VSS VDD VDD _03420_ sky130_fd_sc_hd__nand2_1
X_24149_ net502 _03162_ _03420_ _02993_ VSS VSS VDD VDD _03421_
+ sky130_fd_sc_hd__o22ai_1
X_24150_ _12462_ _02993_ net586 _03275_ VSS VSS VDD VDD _03422_
+ sky130_fd_sc_hd__o211ai_1
X_24151_ net586 _03262_ _03422_ VSS VSS VDD VDD _03423_ sky130_fd_sc_hd__o21ai_0
X_24152_ _03259_ _03423_ net391 VSS VSS VDD VDD _03424_ sky130_fd_sc_hd__a21oi_1
X_24153_ _03086_ _03265_ _03346_ net502 VSS VSS VDD VDD _03425_
+ sky130_fd_sc_hd__a211oi_1
X_24154_ _02987_ _03314_ net561 VSS VSS VDD VDD _03426_ sky130_fd_sc_hd__o21ai_0
X_24155_ _03086_ _03028_ _03162_ VSS VSS VDD VDD _03427_ sky130_fd_sc_hd__o21ai_0
X_24156_ _03093_ _03314_ _03427_ net502 _03101_ VSS VSS VDD
+ VDD _03428_ sky130_fd_sc_hd__a221oi_1
X_24157_ _03425_ _03426_ _03428_ VSS VSS VDD VDD _03429_ sky130_fd_sc_hd__o21ai_0
X_24158_ _03059_ _03047_ _03421_ _03424_ _03429_ VSS VSS VDD
+ VDD _03430_ sky130_fd_sc_hd__o311ai_0
X_24159_ net394 _03075_ _03017_ VSS VSS VDD VDD _03431_ sky130_fd_sc_hd__o21ai_0
X_24160_ net394 _03365_ _03431_ VSS VSS VDD VDD _03432_ sky130_fd_sc_hd__a21oi_1
X_24161_ _03265_ _03387_ _03432_ VSS VSS VDD VDD _03433_ sky130_fd_sc_hd__a21oi_1
X_24162_ _03003_ net390 _03012_ _03205_ VSS VSS VDD VDD _03434_
+ sky130_fd_sc_hd__nand4_1
X_24163_ _02987_ _03033_ _03205_ _03017_ VSS VSS VDD VDD _03435_
+ sky130_fd_sc_hd__o22ai_1
X_24164_ net394 _03119_ _03434_ _03435_ _03003_ VSS VSS VDD
+ VDD _03436_ sky130_fd_sc_hd__a32oi_1
X_24165_ net502 _03433_ _03436_ net390 VSS VSS VDD VDD _03437_
+ sky130_fd_sc_hd__o211ai_1
X_24166_ _12462_ net586 _03225_ VSS VSS VDD VDD _03438_ sky130_fd_sc_hd__a21oi_1
X_24167_ net565 _03438_ VSS VSS VDD VDD _03439_ sky130_fd_sc_hd__nor2_1
X_24168_ _12460_ net586 VSS VSS VDD VDD _03440_ sky130_fd_sc_hd__nor2_1
X_24169_ _12474_ _03017_ _03440_ VSS VSS VDD VDD _03441_ sky130_fd_sc_hd__a21oi_1
X_24170_ _12461_ _03080_ _03441_ net567 net389 VSS VSS VDD
+ VDD _03442_ sky130_fd_sc_hd__o221ai_1
X_24171_ net389 _03359_ _03439_ _03442_ _03086_ VSS VSS VDD
+ VDD _03443_ sky130_fd_sc_hd__o311ai_1
X_24172_ net565 _03270_ _03178_ VSS VSS VDD VDD _03444_ sky130_fd_sc_hd__nand3_1
X_24173_ _03059_ net391 _03416_ _03444_ VSS VSS VDD VDD _03445_
+ sky130_fd_sc_hd__nand4_1
X_24174_ _03054_ _03445_ VSS VSS VDD VDD _03446_ sky130_fd_sc_hd__nand2_1
X_24175_ _12474_ _03162_ VSS VSS VDD VDD _03447_ sky130_fd_sc_hd__nor2_1
X_24176_ _12465_ _02993_ _03012_ VSS VSS VDD VDD _03448_ sky130_fd_sc_hd__a21oi_1
X_24177_ _03447_ _03448_ _03371_ VSS VSS VDD VDD _03449_ sky130_fd_sc_hd__o21ai_0
X_24178_ net394 _03012_ _03155_ _03199_ VSS VSS VDD VDD _03450_
+ sky130_fd_sc_hd__nor4_1
X_24179_ _02993_ _03246_ net390 VSS VSS VDD VDD _03451_ sky130_fd_sc_hd__o21ai_1
X_24180_ _02993_ _03168_ _03166_ _03086_ VSS VSS VDD VDD _03452_
+ sky130_fd_sc_hd__o211ai_2
X_24181_ _03450_ _03451_ net389 _03452_ VSS VSS VDD VDD _03453_
+ sky130_fd_sc_hd__o211ai_4
X_24182_ _03449_ _03453_ _03101_ VSS VSS VDD VDD _03454_ sky130_fd_sc_hd__a21oi_1
X_24183_ _03101_ _03437_ _03443_ _03446_ _03454_ VSS VSS VDD
+ VDD _03455_ sky130_fd_sc_hd__a311oi_1
X_24184_ _03413_ _03419_ _03430_ _03455_ VSS VSS VDD VDD _00157_
+ sky130_fd_sc_hd__a31o_1
X_24185_ net586 _03245_ _03115_ _02993_ VSS VSS VDD VDD _03456_
+ sky130_fd_sc_hd__a211oi_1
X_24186_ _02993_ _03270_ _03191_ _03456_ _03003_ VSS VSS VDD
+ VDD _03457_ sky130_fd_sc_hd__a311oi_2
X_24187_ _02981_ _03041_ net586 VSS VSS VDD VDD _03458_ sky130_fd_sc_hd__a21oi_1
X_24188_ net389 _03120_ _03458_ VSS VSS VDD VDD _03459_ sky130_fd_sc_hd__nor3_1
X_24189_ net696 _02987_ net563 VSS VSS VDD VDD _03460_ sky130_fd_sc_hd__nor3_1
X_24190_ _12461_ _02993_ net586 VSS VSS VDD VDD _03461_ sky130_fd_sc_hd__o21ai_0
X_24191_ _12479_ net586 _03460_ _03461_ VSS VSS VDD VDD _03462_
+ sky130_fd_sc_hd__o22ai_1
X_24192_ _03075_ _03462_ _03047_ VSS VSS VDD VDD _03463_ sky130_fd_sc_hd__o21ai_2
X_24193_ net392 _03114_ _03115_ VSS VSS VDD VDD _03464_ sky130_fd_sc_hd__nor3_1
X_24194_ net392 _03270_ _03339_ _03464_ _03003_ VSS VSS VDD
+ VDD _03465_ sky130_fd_sc_hd__a311oi_4
X_24195_ net390 _03457_ _03459_ _03463_ _03465_ VSS VSS VDD
+ VDD _03466_ sky130_fd_sc_hd__o32ai_4
X_24196_ net392 _03021_ _03228_ _03080_ _12461_ VSS VSS VDD
+ VDD _03467_ sky130_fd_sc_hd__o32ai_1
X_24197_ _12470_ _02993_ _03012_ VSS VSS VDD VDD _03468_ sky130_fd_sc_hd__a21oi_1
X_24198_ _12478_ _03012_ _03130_ _03468_ _03003_ VSS VSS VDD
+ VDD _03469_ sky130_fd_sc_hd__a221oi_1
X_24199_ _03003_ _03467_ _03469_ VSS VSS VDD VDD _03470_ sky130_fd_sc_hd__a21oi_1
X_24200_ _02993_ _03079_ net391 VSS VSS VDD VDD _03471_ sky130_fd_sc_hd__o21ai_0
X_24201_ net391 _03267_ _03307_ _03471_ _03086_ VSS VSS VDD
+ VDD _03472_ sky130_fd_sc_hd__o221ai_2
X_24202_ _03086_ _03470_ _03472_ VSS VSS VDD VDD _03473_ sky130_fd_sc_hd__o21ai_0
X_24203_ _03102_ _03466_ _03473_ _03173_ VSS VSS VDD VDD _03474_
+ sky130_fd_sc_hd__o22ai_1
X_24204_ _03408_ _12460_ _03017_ VSS VSS VDD VDD _03475_ sky130_fd_sc_hd__mux2i_1
X_24205_ net393 _03047_ _03475_ _03025_ _12462_ VSS VSS VDD
+ VDD _03476_ sky130_fd_sc_hd__a32o_1
X_24206_ net391 _03476_ VSS VSS VDD VDD _03477_ sky130_fd_sc_hd__nand2_1
X_24207_ _02981_ _02993_ _03140_ VSS VSS VDD VDD _03478_ sky130_fd_sc_hd__o21ai_1
X_24208_ _12477_ _12486_ _03012_ _03478_ net388 VSS VSS VDD
+ VDD _03479_ sky130_fd_sc_hd__o311ai_1
X_24209_ _03477_ _03479_ VSS VSS VDD VDD _03480_ sky130_fd_sc_hd__nand2_1
X_24210_ net390 _03337_ VSS VSS VDD VDD _03481_ sky130_fd_sc_hd__nand2_1
X_24211_ _03003_ net586 VSS VSS VDD VDD _03482_ sky130_fd_sc_hd__nor2_1
X_24212_ _02981_ net388 VSS VSS VDD VDD _03483_ sky130_fd_sc_hd__nor2_1
X_24213_ _02987_ _02993_ _03003_ net394 VSS VSS VDD VDD _03484_
+ sky130_fd_sc_hd__a211oi_1
X_24214_ _12474_ _02993_ net388 _03012_ VSS VSS VDD VDD _03485_
+ sky130_fd_sc_hd__nor4_1
X_24215_ _03027_ _03483_ _03484_ _03485_ VSS VSS VDD VDD _03486_
+ sky130_fd_sc_hd__a211o_1
X_24216_ _03003_ _03155_ _03482_ _03132_ _03486_ VSS VSS VDD
+ VDD _03487_ sky130_fd_sc_hd__a221o_1
X_24217_ _03089_ _03487_ VSS VSS VDD VDD _03488_ sky130_fd_sc_hd__nand2_1
X_24218_ net388 _03027_ _03483_ net392 VSS VSS VDD VDD _03489_
+ sky130_fd_sc_hd__a211oi_1
X_24219_ _12470_ _03003_ _03012_ VSS VSS VDD VDD _03490_ sky130_fd_sc_hd__o21ai_0
X_24220_ _03003_ _03270_ _03490_ VSS VSS VDD VDD _03491_ sky130_fd_sc_hd__o21ai_0
X_24221_ _02993_ _03491_ VSS VSS VDD VDD _03492_ sky130_fd_sc_hd__nor2_1
X_24222_ net388 _03070_ _03489_ _03492_ _03061_ VSS VSS VDD
+ VDD _03493_ sky130_fd_sc_hd__o221ai_1
X_24223_ _12461_ net586 _03136_ VSS VSS VDD VDD _03494_ sky130_fd_sc_hd__a21oi_1
X_24224_ _03179_ _03283_ _02993_ VSS VSS VDD VDD _03495_ sky130_fd_sc_hd__a21oi_1
X_24225_ _02993_ _03494_ _03495_ _03476_ net389 VSS VSS VDD
+ VDD _03496_ sky130_fd_sc_hd__a2111oi_2
X_24226_ _12474_ _12470_ _02993_ VSS VSS VDD VDD _03497_ sky130_fd_sc_hd__mux2i_1
X_24227_ _03012_ _03497_ _03086_ VSS VSS VDD VDD _03498_ sky130_fd_sc_hd__o21ai_0
X_24228_ _12462_ _02993_ _03012_ VSS VSS VDD VDD _03499_ sky130_fd_sc_hd__o21ai_0
X_24229_ _02993_ _03206_ _03499_ VSS VSS VDD VDD _03500_ sky130_fd_sc_hd__a21oi_1
X_24230_ _03003_ _03498_ _03500_ VSS VSS VDD VDD _03501_ sky130_fd_sc_hd__nor3_1
X_24231_ _03496_ _03501_ _03337_ VSS VSS VDD VDD _03502_ sky130_fd_sc_hd__o21ai_0
X_24232_ _03480_ _03481_ _03488_ _03493_ _03502_ VSS VSS VDD
+ VDD _03503_ sky130_fd_sc_hd__o2111ai_1
X_24233_ _03474_ _03503_ VSS VSS VDD VDD _00158_ sky130_fd_sc_hd__nor2_1
X_24234_ _03028_ _03145_ net393 VSS VSS VDD VDD _03504_ sky130_fd_sc_hd__o21ai_1
X_24235_ _03180_ _03504_ net389 _03047_ VSS VSS VDD VDD _03505_
+ sky130_fd_sc_hd__a211oi_2
X_24236_ _12465_ _02993_ VSS VSS VDD VDD _03506_ sky130_fd_sc_hd__nor2_1
X_24237_ _03252_ _03506_ _03012_ VSS VSS VDD VDD _03507_ sky130_fd_sc_hd__o21ai_0
X_24238_ _03041_ _03028_ VSS VSS VDD VDD _03508_ sky130_fd_sc_hd__nand2_1
X_24239_ _12462_ _02993_ net586 VSS VSS VDD VDD _03509_ sky130_fd_sc_hd__nand3_1
X_24240_ _12472_ _03017_ _03509_ VSS VSS VDD VDD _03510_ sky130_fd_sc_hd__o21ai_1
X_24241_ _03371_ _03507_ _03508_ _03510_ _03365_ VSS VSS VDD
+ VDD _03511_ sky130_fd_sc_hd__a32o_1
X_24242_ _12470_ net564 _03256_ VSS VSS VDD VDD _03512_ sky130_fd_sc_hd__a21oi_1
X_24243_ _12486_ net586 VSS VSS VDD VDD _03513_ sky130_fd_sc_hd__nor2_1
X_24244_ _03017_ _03512_ _03513_ net390 _03003_ VSS VSS VDD
+ VDD _03514_ sky130_fd_sc_hd__a2111oi_0
X_24245_ _03505_ _03511_ _03514_ VSS VSS VDD VDD _03515_ sky130_fd_sc_hd__nor3_1
X_24246_ _03166_ _03168_ net392 VSS VSS VDD VDD _03516_ sky130_fd_sc_hd__a21oi_1
X_24247_ net389 _03227_ VSS VSS VDD VDD _03517_ sky130_fd_sc_hd__nand2_1
X_24248_ _03179_ _03283_ net392 VSS VSS VDD VDD _03518_ sky130_fd_sc_hd__a21oi_1
X_24249_ _03080_ _03245_ _03063_ VSS VSS VDD VDD _03519_ sky130_fd_sc_hd__o21ai_0
X_24250_ _03518_ _03519_ net391 VSS VSS VDD VDD _03520_ sky130_fd_sc_hd__o21ai_0
X_24251_ _03516_ _03517_ _03520_ VSS VSS VDD VDD _03521_ sky130_fd_sc_hd__o21a_1
X_24252_ net388 _03080_ net502 VSS VSS VDD VDD _03522_ sky130_fd_sc_hd__o21ai_0
X_24253_ net537 _03104_ _03482_ _03522_ _02981_ VSS VSS VDD
+ VDD _03523_ sky130_fd_sc_hd__o311ai_1
X_24254_ _03173_ net390 VSS VSS VDD VDD _03524_ sky130_fd_sc_hd__nor2_1
X_24255_ _02993_ _03270_ _03382_ _03523_ _03524_ VSS VSS VDD
+ VDD _03525_ sky130_fd_sc_hd__o2111ai_1
X_24256_ _03102_ _03515_ _03521_ _03481_ _03525_ VSS VSS VDD
+ VDD _03526_ sky130_fd_sc_hd__o221ai_1
X_24257_ _03041_ _03275_ _03017_ VSS VSS VDD VDD _03527_ sky130_fd_sc_hd__a21oi_1
X_24258_ _12470_ _03162_ VSS VSS VDD VDD _03528_ sky130_fd_sc_hd__nor2_1
X_24259_ _03339_ _03284_ _02993_ VSS VSS VDD VDD _03529_ sky130_fd_sc_hd__a21oi_1
X_24260_ _03528_ _03529_ net390 VSS VSS VDD VDD _03530_ sky130_fd_sc_hd__o21ai_0
X_24261_ _03498_ _03527_ _03530_ net388 VSS VSS VDD VDD _03531_
+ sky130_fd_sc_hd__o211ai_1
X_24262_ net392 _03191_ _03179_ VSS VSS VDD VDD _03532_ sky130_fd_sc_hd__o21ai_0
X_24263_ _12460_ net392 _03012_ VSS VSS VDD VDD _03533_ sky130_fd_sc_hd__nand3_1
X_24264_ net390 _03194_ _03533_ VSS VSS VDD VDD _03534_ sky130_fd_sc_hd__nand3_1
X_24265_ _02981_ _03532_ _03534_ VSS VSS VDD VDD _03535_ sky130_fd_sc_hd__a21oi_1
X_24266_ _12474_ _03080_ _03194_ VSS VSS VDD VDD _03536_ sky130_fd_sc_hd__o21ai_0
X_24267_ _03177_ _03222_ _03536_ net390 VSS VSS VDD VDD _03537_
+ sky130_fd_sc_hd__a211oi_1
X_24268_ _03535_ _03537_ net391 VSS VSS VDD VDD _03538_ sky130_fd_sc_hd__o21ai_1
X_24269_ _03531_ _03538_ _03060_ VSS VSS VDD VDD _03539_ sky130_fd_sc_hd__a21oi_1
X_24270_ _12460_ net392 VSS VSS VDD VDD _03540_ sky130_fd_sc_hd__nand2_1
X_24271_ _03114_ _03265_ _02993_ VSS VSS VDD VDD _03541_ sky130_fd_sc_hd__o21ai_1
X_24272_ net388 _03141_ VSS VSS VDD VDD _03542_ sky130_fd_sc_hd__nor2_1
X_24273_ net388 _03540_ _03541_ _03542_ _03478_ VSS VSS VDD
+ VDD _03543_ sky130_fd_sc_hd__a32oi_1
X_24274_ net390 _03149_ _03543_ VSS VSS VDD VDD _03544_ sky130_fd_sc_hd__nor3_1
X_24275_ _03119_ _03191_ _02981_ VSS VSS VDD VDD _03545_ sky130_fd_sc_hd__a21oi_1
X_24276_ _03372_ _03545_ net388 VSS VSS VDD VDD _03546_ sky130_fd_sc_hd__o21ai_0
X_24277_ net535 _03033_ _03162_ VSS VSS VDD VDD _03547_ sky130_fd_sc_hd__o21ai_0
X_24278_ _02987_ _03080_ _03070_ VSS VSS VDD VDD _03548_ sky130_fd_sc_hd__o21ai_0
X_24279_ _02981_ _03547_ _03548_ _03003_ VSS VSS VDD VDD _03549_
+ sky130_fd_sc_hd__a22oi_1
X_24280_ _03546_ _03549_ _03173_ _03086_ VSS VSS VDD VDD _03550_
+ sky130_fd_sc_hd__a211oi_1
X_24281_ _03526_ _03539_ _03544_ _03550_ VSS VSS VDD VDD _00159_
+ sky130_fd_sc_hd__or4_1
X_24282_ dcnt\[1\] dcnt\[3\] dcnt\[2\] VSS VSS VDD VDD _03551_
+ sky130_fd_sc_hd__nor3_1
X_24283_ net496 dcnt\[0\] _03551_ VSS VSS VDD VDD _00160_
+ sky130_fd_sc_hd__and3b_1
X_24284_ u0.w\[0\]\[24\] sa00_sr\[0\] VSS VSS VDD VDD _00185_
+ sky130_fd_sc_hd__xor2_4
X_24285_ u0.w\[0\]\[25\] sa00_sr\[1\] VSS VSS VDD VDD _00186_
+ sky130_fd_sc_hd__xor2_2
X_24286_ u0.w\[0\]\[26\] sa00_sr\[2\] VSS VSS VDD VDD _00187_
+ sky130_fd_sc_hd__xor2_4
X_24287_ u0.w\[0\]\[27\] sa00_sr\[3\] VSS VSS VDD VDD _00188_
+ sky130_fd_sc_hd__xor2_4
X_24288_ u0.w\[0\]\[28\] sa00_sr\[4\] VSS VSS VDD VDD _00189_
+ sky130_fd_sc_hd__xor2_4
X_24289_ u0.w\[0\]\[29\] sa00_sr\[5\] VSS VSS VDD VDD _00190_
+ sky130_fd_sc_hd__xor2_4
X_24290_ u0.w\[0\]\[30\] sa00_sr\[6\] VSS VSS VDD VDD _00191_
+ sky130_fd_sc_hd__xor2_2
X_24291_ u0.w\[0\]\[31\] sa00_sr\[7\] VSS VSS VDD VDD _00192_
+ sky130_fd_sc_hd__xor2_1
X_24292_ u0.w\[1\]\[24\] sa01_sr\[0\] VSS VSS VDD VDD _00281_
+ sky130_fd_sc_hd__xor2_2
X_24293_ u0.w\[1\]\[25\] sa01_sr\[1\] VSS VSS VDD VDD _00282_
+ sky130_fd_sc_hd__xor2_2
X_24294_ u0.w\[1\]\[26\] sa01_sr\[2\] VSS VSS VDD VDD _00283_
+ sky130_fd_sc_hd__xor2_4
X_24295_ u0.w\[1\]\[27\] sa01_sr\[3\] VSS VSS VDD VDD _00284_
+ sky130_fd_sc_hd__xor2_2
X_24296_ u0.w\[1\]\[28\] sa01_sr\[4\] VSS VSS VDD VDD _00285_
+ sky130_fd_sc_hd__xor2_2
X_24297_ u0.w\[1\]\[29\] sa01_sr\[5\] VSS VSS VDD VDD _00286_
+ sky130_fd_sc_hd__xor2_2
X_24298_ u0.w\[1\]\[30\] sa01_sr\[6\] VSS VSS VDD VDD _00287_
+ sky130_fd_sc_hd__xor2_4
X_24299_ u0.w\[1\]\[31\] sa01_sr\[7\] VSS VSS VDD VDD _00288_
+ sky130_fd_sc_hd__xor2_4
X_24300_ u0.w\[2\]\[24\] sa02_sr\[0\] VSS VSS VDD VDD _00241_
+ sky130_fd_sc_hd__xor2_4
X_24301_ u0.w\[2\]\[25\] sa02_sr\[1\] VSS VSS VDD VDD _00242_
+ sky130_fd_sc_hd__xor2_2
X_24302_ u0.w\[2\]\[26\] sa02_sr\[2\] VSS VSS VDD VDD _00243_
+ sky130_fd_sc_hd__xor2_1
X_24303_ u0.w\[2\]\[27\] sa02_sr\[3\] VSS VSS VDD VDD _00244_
+ sky130_fd_sc_hd__xor2_2
X_24304_ u0.w\[2\]\[28\] sa02_sr\[4\] VSS VSS VDD VDD _00245_
+ sky130_fd_sc_hd__xor2_4
X_24305_ u0.w\[2\]\[29\] sa02_sr\[5\] VSS VSS VDD VDD _00246_
+ sky130_fd_sc_hd__xor2_4
X_24306_ u0.w\[2\]\[30\] sa02_sr\[6\] VSS VSS VDD VDD _00247_
+ sky130_fd_sc_hd__xor2_4
X_24307_ u0.w\[2\]\[31\] sa02_sr\[7\] VSS VSS VDD VDD _00248_
+ sky130_fd_sc_hd__xor2_1
X_24308_ u0.tmp_w\[24\] sa03_sr\[0\] VSS VSS VDD VDD _00209_
+ sky130_fd_sc_hd__xor2_4
X_24309_ u0.tmp_w\[25\] sa03_sr\[1\] VSS VSS VDD VDD _00210_
+ sky130_fd_sc_hd__xor2_4
X_24310_ u0.tmp_w\[26\] sa03_sr\[2\] VSS VSS VDD VDD _00211_
+ sky130_fd_sc_hd__xor2_4
X_24311_ u0.tmp_w\[27\] sa03_sr\[3\] VSS VSS VDD VDD _00212_
+ sky130_fd_sc_hd__xor2_4
X_24312_ u0.tmp_w\[28\] sa03_sr\[4\] VSS VSS VDD VDD _00213_
+ sky130_fd_sc_hd__xor2_1
X_24313_ u0.tmp_w\[29\] sa03_sr\[5\] VSS VSS VDD VDD _00214_
+ sky130_fd_sc_hd__xor2_1
X_24314_ u0.tmp_w\[30\] sa03_sr\[6\] VSS VSS VDD VDD _00215_
+ sky130_fd_sc_hd__xor2_1
X_24315_ u0.tmp_w\[31\] sa03_sr\[7\] VSS VSS VDD VDD _00216_
+ sky130_fd_sc_hd__xor2_1
X_24316_ u0.w\[0\]\[16\] sa10_sr\[0\] VSS VSS VDD VDD _00177_
+ sky130_fd_sc_hd__xor2_1
X_24317_ u0.w\[0\]\[17\] sa10_sr\[1\] VSS VSS VDD VDD _00178_
+ sky130_fd_sc_hd__xor2_1
X_24318_ u0.w\[0\]\[18\] sa10_sr\[2\] VSS VSS VDD VDD _00179_
+ sky130_fd_sc_hd__xor2_1
X_24319_ u0.w\[0\]\[19\] sa10_sr\[3\] VSS VSS VDD VDD _00180_
+ sky130_fd_sc_hd__xor2_1
X_24320_ u0.w\[0\]\[20\] sa10_sr\[4\] VSS VSS VDD VDD _00181_
+ sky130_fd_sc_hd__xor2_4
X_24321_ u0.w\[0\]\[21\] sa10_sr\[5\] VSS VSS VDD VDD _00182_
+ sky130_fd_sc_hd__xor2_4
X_24322_ u0.w\[0\]\[22\] sa10_sr\[6\] VSS VSS VDD VDD _00183_
+ sky130_fd_sc_hd__xor2_1
X_24323_ u0.w\[0\]\[23\] sa10_sr\[7\] VSS VSS VDD VDD _00184_
+ sky130_fd_sc_hd__xor2_1
X_24324_ u0.w\[1\]\[16\] sa11_sr\[0\] VSS VSS VDD VDD _00273_
+ sky130_fd_sc_hd__xor2_2
X_24325_ u0.w\[1\]\[17\] sa11_sr\[1\] VSS VSS VDD VDD _00274_
+ sky130_fd_sc_hd__xor2_1
X_24326_ u0.w\[1\]\[18\] sa11_sr\[2\] VSS VSS VDD VDD _00275_
+ sky130_fd_sc_hd__xor2_4
X_24327_ u0.w\[1\]\[19\] sa11_sr\[3\] VSS VSS VDD VDD _00276_
+ sky130_fd_sc_hd__xor2_1
X_24328_ u0.w\[1\]\[20\] sa11_sr\[4\] VSS VSS VDD VDD _00277_
+ sky130_fd_sc_hd__xor2_1
X_24329_ u0.w\[1\]\[21\] sa11_sr\[5\] VSS VSS VDD VDD _00278_
+ sky130_fd_sc_hd__xor2_1
X_24330_ u0.w\[1\]\[22\] sa11_sr\[6\] VSS VSS VDD VDD _00279_
+ sky130_fd_sc_hd__xor2_4
X_24331_ u0.w\[1\]\[23\] sa11_sr\[7\] VSS VSS VDD VDD _00280_
+ sky130_fd_sc_hd__xor2_1
X_24332_ u0.w\[2\]\[16\] sa12_sr\[0\] VSS VSS VDD VDD _00233_
+ sky130_fd_sc_hd__xor2_4
X_24333_ u0.w\[2\]\[17\] sa12_sr\[1\] VSS VSS VDD VDD _00234_
+ sky130_fd_sc_hd__xor2_1
X_24334_ u0.w\[2\]\[18\] sa12_sr\[2\] VSS VSS VDD VDD _00235_
+ sky130_fd_sc_hd__xor2_1
X_24335_ u0.w\[2\]\[19\] sa12_sr\[3\] VSS VSS VDD VDD _00236_
+ sky130_fd_sc_hd__xor2_2
X_24336_ u0.w\[2\]\[20\] sa12_sr\[4\] VSS VSS VDD VDD _00237_
+ sky130_fd_sc_hd__xor2_1
X_24337_ u0.w\[2\]\[21\] sa12_sr\[5\] VSS VSS VDD VDD _00238_
+ sky130_fd_sc_hd__xor2_1
X_24338_ u0.w\[2\]\[22\] sa12_sr\[6\] VSS VSS VDD VDD _00239_
+ sky130_fd_sc_hd__xor2_1
X_24339_ u0.w\[2\]\[23\] sa12_sr\[7\] VSS VSS VDD VDD _00240_
+ sky130_fd_sc_hd__xor2_1
X_24340_ u0.tmp_w\[16\] sa10_sub\[0\] VSS VSS VDD VDD _00201_
+ sky130_fd_sc_hd__xor2_1
X_24341_ u0.tmp_w\[17\] sa10_sub\[1\] VSS VSS VDD VDD _00202_
+ sky130_fd_sc_hd__xor2_2
X_24342_ u0.tmp_w\[18\] sa10_sub\[2\] VSS VSS VDD VDD _00203_
+ sky130_fd_sc_hd__xor2_4
X_24343_ u0.tmp_w\[19\] sa10_sub\[3\] VSS VSS VDD VDD _00204_
+ sky130_fd_sc_hd__xor2_4
X_24344_ u0.tmp_w\[20\] sa10_sub\[4\] VSS VSS VDD VDD _00205_
+ sky130_fd_sc_hd__xor2_4
X_24345_ u0.tmp_w\[21\] sa10_sub\[5\] VSS VSS VDD VDD _00206_
+ sky130_fd_sc_hd__xor2_4
X_24346_ u0.tmp_w\[22\] sa10_sub\[6\] VSS VSS VDD VDD _00207_
+ sky130_fd_sc_hd__xor2_4
X_24347_ u0.tmp_w\[23\] sa10_sub\[7\] VSS VSS VDD VDD _00208_
+ sky130_fd_sc_hd__xor2_4
X_24348_ u0.w\[0\]\[8\] sa20_sr\[0\] VSS VSS VDD VDD _00169_
+ sky130_fd_sc_hd__xor2_1
X_24349_ u0.w\[0\]\[9\] sa20_sr\[1\] VSS VSS VDD VDD _00170_
+ sky130_fd_sc_hd__xor2_4
X_24350_ u0.w\[0\]\[10\] sa20_sr\[2\] VSS VSS VDD VDD _00171_
+ sky130_fd_sc_hd__xor2_4
X_24351_ u0.w\[0\]\[11\] sa20_sr\[3\] VSS VSS VDD VDD _00172_
+ sky130_fd_sc_hd__xor2_4
X_24352_ u0.w\[0\]\[12\] sa20_sr\[4\] VSS VSS VDD VDD _00173_
+ sky130_fd_sc_hd__xor2_4
X_24353_ u0.w\[0\]\[13\] sa20_sr\[5\] VSS VSS VDD VDD _00174_
+ sky130_fd_sc_hd__xor2_4
X_24354_ u0.w\[0\]\[14\] sa20_sr\[6\] VSS VSS VDD VDD _00175_
+ sky130_fd_sc_hd__xor2_4
X_24355_ u0.w\[0\]\[15\] sa20_sr\[7\] VSS VSS VDD VDD _00176_
+ sky130_fd_sc_hd__xor2_4
X_24356_ u0.w\[1\]\[8\] sa21_sr\[0\] VSS VSS VDD VDD _00257_
+ sky130_fd_sc_hd__xor2_2
X_24357_ u0.w\[1\]\[9\] sa21_sr\[1\] VSS VSS VDD VDD _00258_
+ sky130_fd_sc_hd__xor2_4
X_24358_ u0.w\[1\]\[10\] sa21_sr\[2\] VSS VSS VDD VDD _00259_
+ sky130_fd_sc_hd__xor2_2
X_24359_ u0.w\[1\]\[11\] sa21_sr\[3\] VSS VSS VDD VDD _00260_
+ sky130_fd_sc_hd__xor2_2
X_24360_ u0.w\[1\]\[12\] sa21_sr\[4\] VSS VSS VDD VDD _00261_
+ sky130_fd_sc_hd__xor2_4
X_24361_ u0.w\[1\]\[13\] sa21_sr\[5\] VSS VSS VDD VDD _00262_
+ sky130_fd_sc_hd__xor2_1
X_24362_ u0.w\[1\]\[14\] sa21_sr\[6\] VSS VSS VDD VDD _00263_
+ sky130_fd_sc_hd__xor2_4
X_24363_ u0.w\[1\]\[15\] sa21_sr\[7\] VSS VSS VDD VDD _00264_
+ sky130_fd_sc_hd__xor2_2
X_24364_ u0.w\[2\]\[8\] sa20_sub\[0\] VSS VSS VDD VDD _00225_
+ sky130_fd_sc_hd__xor2_2
X_24365_ u0.w\[2\]\[9\] sa20_sub\[1\] VSS VSS VDD VDD _00226_
+ sky130_fd_sc_hd__xor2_1
X_24366_ u0.w\[2\]\[10\] sa20_sub\[2\] VSS VSS VDD VDD _00227_
+ sky130_fd_sc_hd__xor2_4
X_24367_ u0.w\[2\]\[11\] sa20_sub\[3\] VSS VSS VDD VDD _00228_
+ sky130_fd_sc_hd__xor2_4
X_24368_ u0.w\[2\]\[12\] sa20_sub\[4\] VSS VSS VDD VDD _00229_
+ sky130_fd_sc_hd__xor2_4
X_24369_ u0.w\[2\]\[13\] sa20_sub\[5\] VSS VSS VDD VDD _00230_
+ sky130_fd_sc_hd__xor2_4
X_24370_ u0.w\[2\]\[14\] sa20_sub\[6\] VSS VSS VDD VDD _00231_
+ sky130_fd_sc_hd__xor2_4
X_24371_ u0.w\[2\]\[15\] sa20_sub\[7\] VSS VSS VDD VDD _00232_
+ sky130_fd_sc_hd__xor2_4
X_24372_ u0.tmp_w\[8\] sa21_sub\[0\] VSS VSS VDD VDD _00193_
+ sky130_fd_sc_hd__xor2_2
X_24373_ u0.tmp_w\[9\] sa21_sub\[1\] VSS VSS VDD VDD _00194_
+ sky130_fd_sc_hd__xor2_4
X_24374_ u0.tmp_w\[10\] sa21_sub\[2\] VSS VSS VDD VDD _00195_
+ sky130_fd_sc_hd__xor2_1
X_24375_ u0.tmp_w\[11\] sa21_sub\[3\] VSS VSS VDD VDD _00196_
+ sky130_fd_sc_hd__xor2_2
X_24376_ u0.tmp_w\[12\] sa21_sub\[4\] VSS VSS VDD VDD _00197_
+ sky130_fd_sc_hd__xor2_4
X_24377_ u0.tmp_w\[13\] sa21_sub\[5\] VSS VSS VDD VDD _00198_
+ sky130_fd_sc_hd__xor2_2
X_24378_ u0.tmp_w\[14\] sa21_sub\[6\] VSS VSS VDD VDD _00199_
+ sky130_fd_sc_hd__xor2_4
X_24379_ u0.tmp_w\[15\] sa21_sub\[7\] VSS VSS VDD VDD _00200_
+ sky130_fd_sc_hd__xor2_4
X_24380_ u0.w\[0\]\[0\] sa30_sr\[0\] VSS VSS VDD VDD _00161_
+ sky130_fd_sc_hd__xor2_4
X_24381_ u0.w\[0\]\[1\] sa30_sr\[1\] VSS VSS VDD VDD _00162_
+ sky130_fd_sc_hd__xor2_4
X_24382_ u0.w\[0\]\[2\] sa30_sr\[2\] VSS VSS VDD VDD _00163_
+ sky130_fd_sc_hd__xor2_1
X_24383_ u0.w\[0\]\[3\] sa30_sr\[3\] VSS VSS VDD VDD _00164_
+ sky130_fd_sc_hd__xor2_4
X_24384_ u0.w\[0\]\[4\] sa30_sr\[4\] VSS VSS VDD VDD _00165_
+ sky130_fd_sc_hd__xor2_4
X_24385_ u0.w\[0\]\[5\] sa30_sr\[5\] VSS VSS VDD VDD _00166_
+ sky130_fd_sc_hd__xor2_4
X_24386_ u0.w\[0\]\[6\] sa30_sr\[6\] VSS VSS VDD VDD _00167_
+ sky130_fd_sc_hd__xor2_1
X_24387_ u0.w\[0\]\[7\] sa30_sr\[7\] VSS VSS VDD VDD _00168_
+ sky130_fd_sc_hd__xor2_2
X_24388_ u0.w\[1\]\[0\] sa30_sub\[0\] VSS VSS VDD VDD _00249_
+ sky130_fd_sc_hd__xor2_1
X_24389_ u0.w\[1\]\[1\] sa30_sub\[1\] VSS VSS VDD VDD _00250_
+ sky130_fd_sc_hd__xor2_4
X_24390_ u0.w\[1\]\[2\] sa30_sub\[2\] VSS VSS VDD VDD _00251_
+ sky130_fd_sc_hd__xor2_4
X_24391_ u0.w\[1\]\[3\] sa30_sub\[3\] VSS VSS VDD VDD _00252_
+ sky130_fd_sc_hd__xor2_1
X_24392_ u0.w\[1\]\[4\] sa30_sub\[4\] VSS VSS VDD VDD _00253_
+ sky130_fd_sc_hd__xor2_4
X_24393_ u0.w\[1\]\[5\] sa30_sub\[5\] VSS VSS VDD VDD _00254_
+ sky130_fd_sc_hd__xor2_2
X_24394_ u0.w\[1\]\[6\] sa30_sub\[6\] VSS VSS VDD VDD _00255_
+ sky130_fd_sc_hd__xor2_1
X_24395_ u0.w\[1\]\[7\] net692 VSS VSS VDD VDD _00256_ sky130_fd_sc_hd__xor2_4
X_24396_ u0.w\[2\]\[0\] sa31_sub\[0\] VSS VSS VDD VDD _00217_
+ sky130_fd_sc_hd__xor2_1
X_24397_ u0.w\[2\]\[1\] sa31_sub\[1\] VSS VSS VDD VDD _00218_
+ sky130_fd_sc_hd__xor2_4
X_24398_ u0.w\[2\]\[2\] sa31_sub\[2\] VSS VSS VDD VDD _00219_
+ sky130_fd_sc_hd__xor2_1
X_24399_ u0.w\[2\]\[3\] sa31_sub\[3\] VSS VSS VDD VDD _00220_
+ sky130_fd_sc_hd__xor2_1
X_24400_ u0.w\[2\]\[4\] sa31_sub\[4\] VSS VSS VDD VDD _00221_
+ sky130_fd_sc_hd__xor2_1
X_24401_ u0.w\[2\]\[5\] sa31_sub\[5\] VSS VSS VDD VDD _00222_
+ sky130_fd_sc_hd__xor2_2
X_24402_ u0.w\[2\]\[6\] sa31_sub\[6\] VSS VSS VDD VDD _00223_
+ sky130_fd_sc_hd__xor2_2
X_24403_ u0.w\[2\]\[7\] sa31_sub\[7\] VSS VSS VDD VDD _00224_
+ sky130_fd_sc_hd__xor2_4
X_24404_ u0.tmp_w\[0\] sa32_sub\[0\] VSS VSS VDD VDD _00265_
+ sky130_fd_sc_hd__xor2_4
X_24405_ u0.tmp_w\[1\] sa32_sub\[1\] VSS VSS VDD VDD _00266_
+ sky130_fd_sc_hd__xor2_2
X_24406_ u0.tmp_w\[2\] sa32_sub\[2\] VSS VSS VDD VDD _00267_
+ sky130_fd_sc_hd__xor2_4
X_24407_ u0.tmp_w\[3\] sa32_sub\[3\] VSS VSS VDD VDD _00268_
+ sky130_fd_sc_hd__xor2_1
X_24408_ u0.tmp_w\[4\] sa32_sub\[4\] VSS VSS VDD VDD _00269_
+ sky130_fd_sc_hd__xor2_4
X_24409_ u0.tmp_w\[5\] sa32_sub\[5\] VSS VSS VDD VDD _00270_
+ sky130_fd_sc_hd__xor2_1
X_24410_ u0.tmp_w\[6\] sa32_sub\[6\] VSS VSS VDD VDD _00271_
+ sky130_fd_sc_hd__xor2_1
X_24411_ u0.tmp_w\[7\] sa32_sub\[7\] VSS VSS VDD VDD _00272_
+ sky130_fd_sc_hd__xor2_4
X_24412_ u0.r0.rcnt\[0\] VSS VSS VDD VDD u0.r0.rcnt_next\[0\]
+ sky130_fd_sc_hd__inv_1
X_24413_ u0.r0.rcnt\[1\] VSS VSS VDD VDD _12490_ sky130_fd_sc_hd__inv_1
X_24414_ dcnt\[2\] dcnt\[3\] VSS VSS VDD VDD _03552_ sky130_fd_sc_hd__nor2b_1
X_24415_ dcnt\[1\] dcnt\[0\] VSS VSS VDD VDD _03553_ sky130_fd_sc_hd__nor2_1
X_24416_ dcnt\[2\] _03552_ _03553_ VSS VSS VDD VDD _03554_
+ sky130_fd_sc_hd__mux2i_1
X_24417_ net496 _03554_ net130 VSS VSS VDD VDD _00407_ sky130_fd_sc_hd__nor3b_1
X_24418_ u0.r0.rcnt\[2\] _12498_ VSS VSS VDD VDD _03555_ sky130_fd_sc_hd__xnor2_1
X_24419_ _12496_ _03555_ net497 VSS VSS VDD VDD _00409_ sky130_fd_sc_hd__a21o_1
X_24420_ u0.r0.rcnt\[2\] _12498_ VSS VSS VDD VDD _03556_ sky130_fd_sc_hd__xor2_2
X_24421_ u0.r0.rcnt\[2\] u0.r0.rcnt\[1\] u0.r0.rcnt\[0\] VSS
+ VSS VDD VDD _03557_ sky130_fd_sc_hd__nand3_2
X_24422_ u0.r0.rcnt\[3\] _03557_ VSS VSS VDD VDD _03558_ sky130_fd_sc_hd__xor2_4
X_24423_ u0.r0.rcnt_next\[1\] _03558_ VSS VSS VDD VDD _03559_
+ sky130_fd_sc_hd__nor2_1
X_24424_ _12491_ _03558_ _03559_ VSS VSS VDD VDD _03560_ sky130_fd_sc_hd__a21oi_1
X_24425_ net497 _03556_ _03560_ VSS VSS VDD VDD _00410_ sky130_fd_sc_hd__nor3_1
X_24426_ _12491_ _12494_ _03558_ VSS VSS VDD VDD _03561_ sky130_fd_sc_hd__mux2i_1
X_24427_ net497 _03556_ _03561_ VSS VSS VDD VDD _00411_ sky130_fd_sc_hd__nor3_1
X_24428_ _12496_ _12492_ _03558_ VSS VSS VDD VDD _03562_ sky130_fd_sc_hd__mux2i_1
X_24429_ net497 _03556_ _03562_ VSS VSS VDD VDD _00412_ sky130_fd_sc_hd__nor3_1
X_24430_ u0.r0.rcnt_next\[1\] _03556_ _03558_ VSS VSS VDD
+ VDD _03563_ sky130_fd_sc_hd__nor3_1
X_24431_ _12496_ _03556_ _03558_ _03563_ VSS VSS VDD VDD _03564_
+ sky130_fd_sc_hd__a31oi_1
X_24432_ net497 _03564_ VSS VSS VDD VDD _00413_ sky130_fd_sc_hd__nor2_1
X_24433_ _03555_ _03558_ VSS VSS VDD VDD _03565_ sky130_fd_sc_hd__xnor2_1
X_24434_ net497 _03565_ _12491_ VSS VSS VDD VDD _00414_ sky130_fd_sc_hd__nor3b_1
X_24435_ net497 _03555_ VSS VSS VDD VDD _00419_ sky130_fd_sc_hd__nor2_1
X_24436_ _12494_ _03558_ _00419_ VSS VSS VDD VDD _00415_ sky130_fd_sc_hd__and3_1
X_24437_ _12492_ _03558_ _00419_ VSS VSS VDD VDD _00416_ sky130_fd_sc_hd__and3_1
X_24438_ net497 u0.r0.rcnt\[0\] VSS VSS VDD VDD _00417_ sky130_fd_sc_hd__nor2_1
X_24439_ net497 u0.r0.rcnt_next\[1\] VSS VSS VDD VDD _00418_
+ sky130_fd_sc_hd__nor2b_1
X_24440_ net497 _03558_ VSS VSS VDD VDD _00420_ sky130_fd_sc_hd__nor2_1
X_24441_ dcnt\[0\] _03551_ VSS VSS VDD VDD _03566_ sky130_fd_sc_hd__nor2_1
X_24442_ net496 _03566_ net130 VSS VSS VDD VDD _00405_ sky130_fd_sc_hd__o21a_1
X_24443_ dcnt\[1\] dcnt\[0\] net496 VSS VSS VDD VDD _03567_
+ sky130_fd_sc_hd__a21oi_1
X_24444_ dcnt\[3\] dcnt\[2\] _03553_ VSS VSS VDD VDD _03568_
+ sky130_fd_sc_hd__o21ai_0
X_24445_ _03567_ _03568_ net130 VSS VSS VDD VDD _00406_ sky130_fd_sc_hd__a21boi_0
X_24446_ dcnt\[1\] dcnt\[0\] dcnt\[2\] dcnt\[3\] VSS VSS VDD
+ VDD _03569_ sky130_fd_sc_hd__o31a_1
X_24447_ net496 _03569_ net130 VSS VSS VDD VDD _00408_ sky130_fd_sc_hd__o21a_1
X_24448_ net489 net705 VSS VSS VDD VDD _11828_ _11829_ sky130_fd_sc_hd__ha_4
X_24449_ net489 net705 VSS VSS VDD VDD _11830_ _11831_ sky130_fd_sc_hd__ha_2
X_24450_ net489 _03586_ VSS VSS VDD VDD _11833_ _11834_ sky130_fd_sc_hd__ha_4
X_24451_ net489 _03586_ VSS VSS VDD VDD _11835_ _11836_ sky130_fd_sc_hd__ha_4
X_24452_ _03593_ net703 VSS VSS VDD VDD _11838_ _11839_ sky130_fd_sc_hd__ha_4
X_24453_ _03593_ net702 VSS VSS VDD VDD _11840_ _11841_ sky130_fd_sc_hd__ha_4
X_24454_ _03593_ _03586_ VSS VSS VDD VDD _11842_ _11843_ sky130_fd_sc_hd__ha_4
X_24455_ _03593_ _03586_ VSS VSS VDD VDD _11844_ _11845_ sky130_fd_sc_hd__ha_4
X_24456_ net489 _03617_ VSS VSS VDD VDD _11847_ _11848_ sky130_fd_sc_hd__ha_1
X_24457_ net489 _03617_ VSS VSS VDD VDD _11849_ _11850_ sky130_fd_sc_hd__ha_1
X_24458_ net489 _03618_ VSS VSS VDD VDD _11852_ _11853_ sky130_fd_sc_hd__ha_1
X_24459_ net489 _03618_ VSS VSS VDD VDD _11854_ _11855_ sky130_fd_sc_hd__ha_1
X_24460_ _03593_ _03617_ VSS VSS VDD VDD _11856_ _11857_ sky130_fd_sc_hd__ha_1
X_24461_ _03593_ _03617_ VSS VSS VDD VDD _11858_ _11859_ sky130_fd_sc_hd__ha_1
X_24462_ net483 net484 VSS VSS VDD VDD _11862_ _11863_ sky130_fd_sc_hd__ha_4
X_24463_ net483 net484 VSS VSS VDD VDD _11864_ _11865_ sky130_fd_sc_hd__ha_4
X_24464_ net483 _03691_ VSS VSS VDD VDD _11867_ _11868_ sky130_fd_sc_hd__ha_4
X_24465_ net483 _03691_ VSS VSS VDD VDD _11869_ _11870_ sky130_fd_sc_hd__ha_4
X_24466_ _03696_ net484 VSS VSS VDD VDD _11872_ _11873_ sky130_fd_sc_hd__ha_2
X_24467_ _03696_ _03690_ VSS VSS VDD VDD _11874_ _11875_ sky130_fd_sc_hd__ha_4
X_24468_ _03696_ _03691_ VSS VSS VDD VDD _11876_ _11877_ sky130_fd_sc_hd__ha_2
X_24469_ _03696_ _03691_ VSS VSS VDD VDD _11878_ _11879_ sky130_fd_sc_hd__ha_4
X_24470_ net483 _03702_ VSS VSS VDD VDD _11881_ _11882_ sky130_fd_sc_hd__ha_1
X_24471_ net483 _03702_ VSS VSS VDD VDD _11883_ _11884_ sky130_fd_sc_hd__ha_1
X_24472_ net483 _03704_ VSS VSS VDD VDD _11886_ _11887_ sky130_fd_sc_hd__ha_1
X_24473_ net483 _03704_ VSS VSS VDD VDD _11888_ _11889_ sky130_fd_sc_hd__ha_1
X_24474_ _03696_ _03702_ VSS VSS VDD VDD _11890_ _11891_ sky130_fd_sc_hd__ha_1
X_24475_ _03696_ _03702_ VSS VSS VDD VDD _11892_ _11893_ sky130_fd_sc_hd__ha_1
X_24476_ net487 net488 VSS VSS VDD VDD _11896_ _11897_ sky130_fd_sc_hd__ha_4
X_24477_ net487 net488 VSS VSS VDD VDD _11898_ _11899_ sky130_fd_sc_hd__ha_4
X_24478_ _03630_ _03625_ VSS VSS VDD VDD _11901_ _11902_ sky130_fd_sc_hd__ha_4
X_24479_ _03630_ _03625_ VSS VSS VDD VDD _11903_ _11904_ sky130_fd_sc_hd__ha_4
X_24480_ _03631_ net488 VSS VSS VDD VDD _11906_ _11907_ sky130_fd_sc_hd__ha_4
X_24481_ _03631_ _03624_ VSS VSS VDD VDD _11908_ _11909_ sky130_fd_sc_hd__ha_4
X_24482_ _03631_ _03625_ VSS VSS VDD VDD _11910_ _11911_ sky130_fd_sc_hd__ha_4
X_24483_ _03631_ _03625_ VSS VSS VDD VDD _11912_ _11913_ sky130_fd_sc_hd__ha_4
X_24484_ net487 _03637_ VSS VSS VDD VDD _11915_ _11916_ sky130_fd_sc_hd__ha_1
X_24485_ _03630_ _03637_ VSS VSS VDD VDD _11917_ _11918_ sky130_fd_sc_hd__ha_2
X_24486_ net487 _03639_ VSS VSS VDD VDD _11920_ _11921_ sky130_fd_sc_hd__ha_1
X_24487_ _03630_ _03639_ VSS VSS VDD VDD _11922_ _11923_ sky130_fd_sc_hd__ha_1
X_24488_ _03631_ _03637_ VSS VSS VDD VDD _11924_ _11925_ sky130_fd_sc_hd__ha_1
X_24489_ _03631_ _03637_ VSS VSS VDD VDD _11926_ _11927_ sky130_fd_sc_hd__ha_1
X_24490_ _03777_ _03772_ VSS VSS VDD VDD _11930_ _11931_ sky130_fd_sc_hd__ha_4
X_24491_ _03777_ _03772_ VSS VSS VDD VDD _11932_ _11933_ sky130_fd_sc_hd__ha_4
X_24492_ _03777_ _03773_ VSS VSS VDD VDD _11935_ _11936_ sky130_fd_sc_hd__ha_4
X_24493_ _03777_ _03773_ VSS VSS VDD VDD _11937_ _11938_ sky130_fd_sc_hd__ha_4
X_24494_ _03778_ _03772_ VSS VSS VDD VDD _11940_ _11941_ sky130_fd_sc_hd__ha_4
X_24495_ _03778_ _03772_ VSS VSS VDD VDD _11942_ _11943_ sky130_fd_sc_hd__ha_4
X_24496_ _03778_ _03773_ VSS VSS VDD VDD _11944_ _11945_ sky130_fd_sc_hd__ha_4
X_24497_ _03778_ _03773_ VSS VSS VDD VDD _11946_ _11947_ sky130_fd_sc_hd__ha_4
X_24498_ net482 _03777_ VSS VSS VDD VDD _11949_ _11950_ sky130_fd_sc_hd__ha_1
X_24499_ net481 _03777_ VSS VSS VDD VDD _11951_ _11952_ sky130_fd_sc_hd__ha_1
X_24500_ _03784_ _03777_ VSS VSS VDD VDD _11954_ _11955_ sky130_fd_sc_hd__ha_1
X_24501_ _03784_ _03777_ VSS VSS VDD VDD _11956_ _11957_ sky130_fd_sc_hd__ha_1
X_24502_ _03784_ _03778_ VSS VSS VDD VDD _11958_ _11959_ sky130_fd_sc_hd__ha_1
X_24503_ _03784_ _03778_ VSS VSS VDD VDD _11960_ _11961_ sky130_fd_sc_hd__ha_1
X_24504_ net732 net472 VSS VSS VDD VDD _11964_ _11965_ sky130_fd_sc_hd__ha_4
X_24505_ net734 net724 VSS VSS VDD VDD _11966_ _11967_ sky130_fd_sc_hd__ha_4
X_24506_ _05890_ _05884_ VSS VSS VDD VDD _11969_ _11970_ sky130_fd_sc_hd__ha_4
X_24507_ _05891_ net472 VSS VSS VDD VDD _11972_ _11973_ sky130_fd_sc_hd__ha_4
X_24508_ _05891_ net472 VSS VSS VDD VDD _11974_ _11975_ sky130_fd_sc_hd__ha_4
X_24509_ _05891_ _05884_ VSS VSS VDD VDD _11976_ _11977_ sky130_fd_sc_hd__ha_1
X_24510_ _05891_ _05884_ VSS VSS VDD VDD _11978_ _11979_ sky130_fd_sc_hd__ha_4
X_24511_ net470 net730 VSS VSS VDD VDD _11981_ _11982_ sky130_fd_sc_hd__ha_1
X_24512_ net471 _05884_ VSS VSS VDD VDD _11983_ _11984_ sky130_fd_sc_hd__ha_1
X_24513_ net471 _05884_ VSS VSS VDD VDD _11985_ _11986_ sky130_fd_sc_hd__ha_1
X_24514_ _05900_ net727 VSS VSS VDD VDD _11988_ _11989_ sky130_fd_sc_hd__ha_1
X_24515_ _05900_ net724 VSS VSS VDD VDD _11990_ _11991_ sky130_fd_sc_hd__ha_1
X_24516_ _05900_ _05884_ VSS VSS VDD VDD _11992_ _11993_ sky130_fd_sc_hd__ha_1
X_24517_ net465 net466 VSS VSS VDD VDD _11996_ _11997_ sky130_fd_sc_hd__ha_4
X_24518_ net504 net581 VSS VSS VDD VDD _11998_ _11999_ sky130_fd_sc_hd__ha_4
X_24519_ _06493_ _06487_ VSS VSS VDD VDD _12001_ _12002_ sky130_fd_sc_hd__ha_4
X_24520_ _06494_ net466 VSS VSS VDD VDD _12004_ _12005_ sky130_fd_sc_hd__ha_4
X_24521_ _06494_ net467 VSS VSS VDD VDD _12006_ _12007_ sky130_fd_sc_hd__ha_4
X_24522_ _06494_ _06487_ VSS VSS VDD VDD _12008_ _12009_ sky130_fd_sc_hd__ha_1
X_24523_ _06494_ _06487_ VSS VSS VDD VDD _12010_ _12011_ sky130_fd_sc_hd__ha_4
X_24524_ net670 net585 VSS VSS VDD VDD _12013_ _12014_ sky130_fd_sc_hd__ha_1
X_24525_ _06503_ _06487_ VSS VSS VDD VDD _12015_ _12016_ sky130_fd_sc_hd__ha_1
X_24526_ _06503_ _06487_ VSS VSS VDD VDD _12017_ _12018_ sky130_fd_sc_hd__ha_1
X_24527_ _06505_ net467 VSS VSS VDD VDD _12020_ _12021_ sky130_fd_sc_hd__ha_1
X_24528_ _06505_ net585 VSS VSS VDD VDD _12022_ _12023_ sky130_fd_sc_hd__ha_1
X_24529_ _06505_ _06487_ VSS VSS VDD VDD _12024_ _12025_ sky130_fd_sc_hd__ha_1
X_24530_ _07089_ net648 VSS VSS VDD VDD _12028_ _12029_ sky130_fd_sc_hd__ha_4
X_24531_ _07089_ net648 VSS VSS VDD VDD _12030_ _12031_ sky130_fd_sc_hd__ha_4
X_24532_ _07089_ _07082_ VSS VSS VDD VDD _12033_ _12034_ sky130_fd_sc_hd__ha_4
X_24533_ _07090_ net648 VSS VSS VDD VDD _12036_ _12037_ sky130_fd_sc_hd__ha_4
X_24534_ _07090_ net648 VSS VSS VDD VDD _12038_ _12039_ sky130_fd_sc_hd__ha_4
X_24535_ _07090_ _07082_ VSS VSS VDD VDD _12040_ _12041_ sky130_fd_sc_hd__ha_1
X_24536_ _07090_ _07082_ VSS VSS VDD VDD _12042_ _12043_ sky130_fd_sc_hd__ha_4
X_24537_ net462 net648 VSS VSS VDD VDD _12045_ _12046_ sky130_fd_sc_hd__ha_1
X_24538_ net462 _07082_ VSS VSS VDD VDD _12047_ _12048_ sky130_fd_sc_hd__ha_1
X_24539_ net463 _07082_ VSS VSS VDD VDD _12049_ _12050_ sky130_fd_sc_hd__ha_1
X_24540_ _07100_ net548 VSS VSS VDD VDD _12052_ _12053_ sky130_fd_sc_hd__ha_1
X_24541_ _07100_ net648 VSS VSS VDD VDD _12054_ _12055_ sky130_fd_sc_hd__ha_1
X_24542_ _07100_ _07082_ VSS VSS VDD VDD _12056_ _12057_ sky130_fd_sc_hd__ha_1
X_24543_ net576 net456 VSS VSS VDD VDD _12060_ _12061_ sky130_fd_sc_hd__ha_4
X_24544_ net580 net456 VSS VSS VDD VDD _12062_ _12063_ sky130_fd_sc_hd__ha_4
X_24545_ net578 _07668_ VSS VSS VDD VDD _12065_ _12066_ sky130_fd_sc_hd__ha_4
X_24546_ _07676_ net456 VSS VSS VDD VDD _12068_ _12069_ sky130_fd_sc_hd__ha_4
X_24547_ _07676_ net456 VSS VSS VDD VDD _12070_ _12071_ sky130_fd_sc_hd__ha_4
X_24548_ _07676_ _07668_ VSS VSS VDD VDD _12072_ _12073_ sky130_fd_sc_hd__ha_1
X_24549_ _07676_ _07668_ VSS VSS VDD VDD _12074_ _12075_ sky130_fd_sc_hd__ha_4
X_24550_ net455 net574 VSS VSS VDD VDD _12077_ _12078_ sky130_fd_sc_hd__ha_1
X_24551_ net453 _07668_ VSS VSS VDD VDD _12079_ _12080_ sky130_fd_sc_hd__ha_1
X_24552_ _07683_ _07668_ VSS VSS VDD VDD _12081_ _12082_ sky130_fd_sc_hd__ha_1
X_24553_ _07684_ net456 VSS VSS VDD VDD _12084_ _12085_ sky130_fd_sc_hd__ha_1
X_24554_ _07684_ net573 VSS VSS VDD VDD _12086_ _12087_ sky130_fd_sc_hd__ha_1
X_24555_ _07684_ _07668_ VSS VSS VDD VDD _12088_ _12089_ sky130_fd_sc_hd__ha_1
X_24556_ net698 _08237_ VSS VSS VDD VDD _12092_ _12093_ sky130_fd_sc_hd__ha_4
X_24557_ net698 _08237_ VSS VSS VDD VDD _12094_ _12095_ sky130_fd_sc_hd__ha_4
X_24558_ net698 _08238_ VSS VSS VDD VDD _12097_ _12098_ sky130_fd_sc_hd__ha_4
X_24559_ _08244_ net445 VSS VSS VDD VDD _12100_ _12101_ sky130_fd_sc_hd__ha_4
X_24560_ _08244_ net446 VSS VSS VDD VDD _12102_ _12103_ sky130_fd_sc_hd__ha_4
X_24561_ _08244_ _08238_ VSS VSS VDD VDD _12104_ _12105_ sky130_fd_sc_hd__ha_1
X_24562_ _08244_ _08238_ VSS VSS VDD VDD _12106_ _12107_ sky130_fd_sc_hd__ha_4
X_24563_ net442 net446 VSS VSS VDD VDD _12109_ _12110_ sky130_fd_sc_hd__ha_1
X_24564_ net443 _08238_ VSS VSS VDD VDD _12111_ _12112_ sky130_fd_sc_hd__ha_1
X_24565_ net443 _08238_ VSS VSS VDD VDD _12113_ _12114_ sky130_fd_sc_hd__ha_1
X_24566_ _08250_ net446 VSS VSS VDD VDD _12116_ _12117_ sky130_fd_sc_hd__ha_1
X_24567_ _08250_ net446 VSS VSS VDD VDD _12118_ _12119_ sky130_fd_sc_hd__ha_1
X_24568_ _08250_ _08238_ VSS VSS VDD VDD _12120_ _12121_ sky130_fd_sc_hd__ha_1
X_24569_ net544 net440 VSS VSS VDD VDD _12124_ _12125_ sky130_fd_sc_hd__ha_4
X_24570_ net543 net440 VSS VSS VDD VDD _12126_ _12127_ sky130_fd_sc_hd__ha_4
X_24571_ _08811_ _08806_ VSS VSS VDD VDD _12129_ _12130_ sky130_fd_sc_hd__ha_4
X_24572_ _08812_ net440 VSS VSS VDD VDD _12132_ _12133_ sky130_fd_sc_hd__ha_4
X_24573_ _08812_ net440 VSS VSS VDD VDD _12134_ _12135_ sky130_fd_sc_hd__ha_4
X_24574_ _08812_ _08806_ VSS VSS VDD VDD _12136_ _12137_ sky130_fd_sc_hd__ha_1
X_24575_ _08812_ _08806_ VSS VSS VDD VDD _12138_ _12139_ sky130_fd_sc_hd__ha_4
X_24576_ net439 net440 VSS VSS VDD VDD _12141_ _12142_ sky130_fd_sc_hd__ha_1
X_24577_ net439 _08806_ VSS VSS VDD VDD _12143_ _12144_ sky130_fd_sc_hd__ha_1
X_24578_ net438 _08806_ VSS VSS VDD VDD _12145_ _12146_ sky130_fd_sc_hd__ha_1
X_24579_ _08818_ net440 VSS VSS VDD VDD _12148_ _12149_ sky130_fd_sc_hd__ha_1
X_24580_ _08818_ net440 VSS VSS VDD VDD _12150_ _12151_ sky130_fd_sc_hd__ha_1
X_24581_ _08818_ _08806_ VSS VSS VDD VDD _12152_ _12153_ sky130_fd_sc_hd__ha_1
X_24582_ net596 net602 VSS VSS VDD VDD _12156_ _12157_ sky130_fd_sc_hd__ha_4
X_24583_ net599 net437 VSS VSS VDD VDD _12158_ _12159_ sky130_fd_sc_hd__ha_4
X_24584_ net599 _09364_ VSS VSS VDD VDD _12161_ _12162_ sky130_fd_sc_hd__ha_4
X_24585_ _09370_ net602 VSS VSS VDD VDD _12164_ _12165_ sky130_fd_sc_hd__ha_2
X_24586_ _09370_ net605 VSS VSS VDD VDD _12166_ _12167_ sky130_fd_sc_hd__ha_4
X_24587_ _09370_ _09364_ VSS VSS VDD VDD _12168_ _12169_ sky130_fd_sc_hd__ha_1
X_24588_ _09370_ _09364_ VSS VSS VDD VDD _12170_ _12171_ sky130_fd_sc_hd__ha_4
X_24589_ net435 net601 VSS VSS VDD VDD _12173_ _12174_ sky130_fd_sc_hd__ha_1
X_24590_ net744 _09364_ VSS VSS VDD VDD _12175_ _12176_ sky130_fd_sc_hd__ha_1
X_24591_ net434 _09364_ VSS VSS VDD VDD _12177_ _12178_ sky130_fd_sc_hd__ha_1
X_24592_ _09375_ net437 VSS VSS VDD VDD _12180_ _12181_ sky130_fd_sc_hd__ha_1
X_24593_ _09375_ net601 VSS VSS VDD VDD _12182_ _12183_ sky130_fd_sc_hd__ha_1
X_24594_ _09375_ _09364_ VSS VSS VDD VDD _12184_ _12185_ sky130_fd_sc_hd__ha_1
X_24595_ net517 net558 VSS VSS VDD VDD _12188_ _12189_ sky130_fd_sc_hd__ha_4
X_24596_ net517 net557 VSS VSS VDD VDD _12190_ _12191_ sky130_fd_sc_hd__ha_4
X_24597_ net517 _09923_ VSS VSS VDD VDD _12193_ _12194_ sky130_fd_sc_hd__ha_4
X_24598_ _09929_ net556 VSS VSS VDD VDD _12196_ _12197_ sky130_fd_sc_hd__ha_4
X_24599_ _09929_ net554 VSS VSS VDD VDD _12198_ _12199_ sky130_fd_sc_hd__ha_4
X_24600_ _09929_ _09923_ VSS VSS VDD VDD _12200_ _12201_ sky130_fd_sc_hd__ha_1
X_24601_ _09929_ _09923_ VSS VSS VDD VDD _12202_ _12203_ sky130_fd_sc_hd__ha_4
X_24602_ net432 net433 VSS VSS VDD VDD _12205_ _12206_ sky130_fd_sc_hd__ha_1
X_24603_ net431 _09923_ VSS VSS VDD VDD _12207_ _12208_ sky130_fd_sc_hd__ha_1
X_24604_ net430 _09923_ VSS VSS VDD VDD _12209_ _12210_ sky130_fd_sc_hd__ha_1
X_24605_ _09936_ net433 VSS VSS VDD VDD _12212_ _12213_ sky130_fd_sc_hd__ha_1
X_24606_ _09936_ net433 VSS VSS VDD VDD _12214_ _12215_ sky130_fd_sc_hd__ha_1
X_24607_ _09936_ _09923_ VSS VSS VDD VDD _12216_ _12217_ sky130_fd_sc_hd__ha_1
X_24608_ net524 net682 VSS VSS VDD VDD _12220_ _12221_ sky130_fd_sc_hd__ha_4
X_24609_ _10499_ net680 VSS VSS VDD VDD _12222_ _12223_ sky130_fd_sc_hd__ha_4
X_24610_ net524 _10495_ VSS VSS VDD VDD _12225_ _12226_ sky130_fd_sc_hd__ha_4
X_24611_ _10499_ _10495_ VSS VSS VDD VDD _12227_ _12228_ sky130_fd_sc_hd__ha_4
X_24612_ _10500_ net683 VSS VSS VDD VDD _12230_ _12231_ sky130_fd_sc_hd__ha_4
X_24613_ _10500_ net683 VSS VSS VDD VDD _12232_ _12233_ sky130_fd_sc_hd__ha_4
X_24614_ _10500_ _10495_ VSS VSS VDD VDD _12234_ _12235_ sky130_fd_sc_hd__ha_4
X_24615_ _10500_ _10495_ VSS VSS VDD VDD _12236_ _12237_ sky130_fd_sc_hd__ha_4
X_24616_ net587 net683 VSS VSS VDD VDD _12239_ _12240_ sky130_fd_sc_hd__ha_1
X_24617_ _10507_ _10495_ VSS VSS VDD VDD _12241_ _12242_ sky130_fd_sc_hd__ha_1
X_24618_ net686 _10495_ VSS VSS VDD VDD _12243_ _12244_ sky130_fd_sc_hd__ha_1
X_24619_ _10509_ net681 VSS VSS VDD VDD _12246_ _12247_ sky130_fd_sc_hd__ha_1
X_24620_ _10509_ net683 VSS VSS VDD VDD _12248_ _12249_ sky130_fd_sc_hd__ha_1
X_24621_ _10509_ _10495_ VSS VSS VDD VDD _12250_ _12251_ sky130_fd_sc_hd__ha_1
X_24622_ _10509_ _10495_ VSS VSS VDD VDD _12252_ _12253_ sky130_fd_sc_hd__ha_1
X_24623_ net621 net626 VSS VSS VDD VDD _12256_ _12257_ sky130_fd_sc_hd__ha_4
X_24624_ net623 net628 VSS VSS VDD VDD _12258_ _12259_ sky130_fd_sc_hd__ha_4
X_24625_ net622 _11065_ VSS VSS VDD VDD _12261_ _12262_ sky130_fd_sc_hd__ha_4
X_24626_ net623 _11065_ VSS VSS VDD VDD _12263_ _12264_ sky130_fd_sc_hd__ha_4
X_24627_ _11071_ net627 VSS VSS VDD VDD _12266_ _12267_ sky130_fd_sc_hd__ha_2
X_24628_ _11071_ net629 VSS VSS VDD VDD _12268_ _12269_ sky130_fd_sc_hd__ha_4
X_24629_ _11071_ _11065_ VSS VSS VDD VDD _12270_ _12271_ sky130_fd_sc_hd__ha_4
X_24630_ _11071_ _11065_ VSS VSS VDD VDD _12272_ _12273_ sky130_fd_sc_hd__ha_4
X_24631_ net421 net626 VSS VSS VDD VDD _12275_ _12276_ sky130_fd_sc_hd__ha_1
X_24632_ net422 _11065_ VSS VSS VDD VDD _12277_ _12278_ sky130_fd_sc_hd__ha_1
X_24633_ net420 _11065_ VSS VSS VDD VDD _12279_ _12280_ sky130_fd_sc_hd__ha_1
X_24634_ _11076_ net630 VSS VSS VDD VDD _12282_ _12283_ sky130_fd_sc_hd__ha_1
X_24635_ _11076_ net626 VSS VSS VDD VDD _12284_ _12285_ sky130_fd_sc_hd__ha_1
X_24636_ _11076_ _11065_ VSS VSS VDD VDD _12286_ _12287_ sky130_fd_sc_hd__ha_1
X_24637_ _11076_ _11065_ VSS VSS VDD VDD _12288_ _12289_ sky130_fd_sc_hd__ha_1
X_24638_ _11622_ net710 VSS VSS VDD VDD _12292_ _12293_ sky130_fd_sc_hd__ha_4
X_24639_ net418 net419 VSS VSS VDD VDD _12294_ _12295_ sky130_fd_sc_hd__ha_4
X_24640_ net418 _11618_ VSS VSS VDD VDD _12297_ _12298_ sky130_fd_sc_hd__ha_4
X_24641_ net418 _11618_ VSS VSS VDD VDD _12299_ _12300_ sky130_fd_sc_hd__ha_4
X_24642_ _11623_ net419 VSS VSS VDD VDD _12302_ _12303_ sky130_fd_sc_hd__ha_4
X_24643_ _11623_ net419 VSS VSS VDD VDD _12304_ _12305_ sky130_fd_sc_hd__ha_4
X_24644_ _11623_ _11618_ VSS VSS VDD VDD _12306_ _12307_ sky130_fd_sc_hd__ha_4
X_24645_ _11623_ _11618_ VSS VSS VDD VDD _12308_ _12309_ sky130_fd_sc_hd__ha_4
X_24646_ net417 net419 VSS VSS VDD VDD _12311_ _12312_ sky130_fd_sc_hd__ha_1
X_24647_ net417 _11618_ VSS VSS VDD VDD _12313_ _12314_ sky130_fd_sc_hd__ha_1
X_24648_ _11627_ _11618_ VSS VSS VDD VDD _12315_ _12316_ sky130_fd_sc_hd__ha_1
X_24649_ _11628_ net419 VSS VSS VDD VDD _12318_ _12319_ sky130_fd_sc_hd__ha_1
X_24650_ _11628_ net419 VSS VSS VDD VDD _12320_ _12321_ sky130_fd_sc_hd__ha_1
X_24651_ _11628_ _11618_ VSS VSS VDD VDD _12322_ _12323_ sky130_fd_sc_hd__ha_1
X_24652_ _11628_ _11618_ VSS VSS VDD VDD _12324_ _12325_ sky130_fd_sc_hd__ha_1
X_24653_ _00783_ net634 VSS VSS VDD VDD _12328_ _12329_ sky130_fd_sc_hd__ha_4
X_24654_ _00783_ net634 VSS VSS VDD VDD _12330_ _12331_ sky130_fd_sc_hd__ha_4
X_24655_ _00783_ _00777_ VSS VSS VDD VDD _12333_ _12334_ sky130_fd_sc_hd__ha_4
X_24656_ _00783_ _00777_ VSS VSS VDD VDD _12335_ _12336_ sky130_fd_sc_hd__ha_4
X_24657_ _00784_ net637 VSS VSS VDD VDD _12338_ _12339_ sky130_fd_sc_hd__ha_4
X_24658_ _00784_ net637 VSS VSS VDD VDD _12340_ _12341_ sky130_fd_sc_hd__ha_4
X_24659_ _00784_ _00777_ VSS VSS VDD VDD _12342_ _12343_ sky130_fd_sc_hd__ha_4
X_24660_ _00784_ _00777_ VSS VSS VDD VDD _12344_ _12345_ sky130_fd_sc_hd__ha_4
X_24661_ _00797_ net635 VSS VSS VDD VDD _12347_ _12348_ sky130_fd_sc_hd__ha_1
X_24662_ _00797_ _00777_ VSS VSS VDD VDD _12349_ _12350_ sky130_fd_sc_hd__ha_1
X_24663_ _00797_ _00777_ VSS VSS VDD VDD _12351_ _12352_ sky130_fd_sc_hd__ha_1
X_24664_ _00798_ net500 VSS VSS VDD VDD _12354_ _12355_ sky130_fd_sc_hd__ha_1
X_24665_ _00798_ net635 VSS VSS VDD VDD _12356_ _12357_ sky130_fd_sc_hd__ha_1
X_24666_ _00798_ _00777_ VSS VSS VDD VDD _12358_ _12359_ sky130_fd_sc_hd__ha_1
X_24667_ _00798_ _00777_ VSS VSS VDD VDD _12360_ _12361_ sky130_fd_sc_hd__ha_1
X_24668_ _01348_ net594 VSS VSS VDD VDD _12364_ _12365_ sky130_fd_sc_hd__ha_4
X_24669_ _01348_ net590 VSS VSS VDD VDD _12366_ _12367_ sky130_fd_sc_hd__ha_4
X_24670_ _01348_ _01343_ VSS VSS VDD VDD _12369_ _12370_ sky130_fd_sc_hd__ha_4
X_24671_ _01349_ net590 VSS VSS VDD VDD _12372_ _12373_ sky130_fd_sc_hd__ha_4
X_24672_ _01349_ net591 VSS VSS VDD VDD _12374_ _12375_ sky130_fd_sc_hd__ha_4
X_24673_ _01349_ _01343_ VSS VSS VDD VDD _12376_ _12377_ sky130_fd_sc_hd__ha_1
X_24674_ _01349_ _01343_ VSS VSS VDD VDD _12378_ _12379_ sky130_fd_sc_hd__ha_4
X_24675_ net756 net522 VSS VSS VDD VDD _12381_ _12382_ sky130_fd_sc_hd__ha_1
X_24676_ _01353_ _01343_ VSS VSS VDD VDD _12383_ _12384_ sky130_fd_sc_hd__ha_1
X_24677_ _01353_ _01343_ VSS VSS VDD VDD _12385_ _12386_ sky130_fd_sc_hd__ha_1
X_24678_ _01354_ net522 VSS VSS VDD VDD _12388_ _12389_ sky130_fd_sc_hd__ha_1
X_24679_ _01354_ net588 VSS VSS VDD VDD _12390_ _12391_ sky130_fd_sc_hd__ha_1
X_24680_ _01354_ _01343_ VSS VSS VDD VDD _12392_ _12393_ sky130_fd_sc_hd__ha_1
X_24681_ net404 net675 VSS VSS VDD VDD _12396_ _12397_ sky130_fd_sc_hd__ha_4
X_24682_ net404 net405 VSS VSS VDD VDD _12398_ _12399_ sky130_fd_sc_hd__ha_4
X_24683_ _01885_ _01882_ VSS VSS VDD VDD _12401_ _12402_ sky130_fd_sc_hd__ha_4
X_24684_ _01886_ _01881_ VSS VSS VDD VDD _12404_ _12405_ sky130_fd_sc_hd__ha_4
X_24685_ _01886_ net405 VSS VSS VDD VDD _12406_ _12407_ sky130_fd_sc_hd__ha_4
X_24686_ _01886_ _01882_ VSS VSS VDD VDD _12408_ _12409_ sky130_fd_sc_hd__ha_1
X_24687_ _01886_ _01882_ VSS VSS VDD VDD _12410_ _12411_ sky130_fd_sc_hd__ha_4
X_24688_ net402 net405 VSS VSS VDD VDD _12413_ _12414_ sky130_fd_sc_hd__ha_1
X_24689_ net402 _01882_ VSS VSS VDD VDD _12415_ _12416_ sky130_fd_sc_hd__ha_1
X_24690_ net403 _01882_ VSS VSS VDD VDD _12417_ _12418_ sky130_fd_sc_hd__ha_1
X_24691_ _01892_ net405 VSS VSS VDD VDD _12420_ _12421_ sky130_fd_sc_hd__ha_1
X_24692_ _01892_ net405 VSS VSS VDD VDD _12422_ _12423_ sky130_fd_sc_hd__ha_1
X_24693_ _01892_ _01882_ VSS VSS VDD VDD _12424_ _12425_ sky130_fd_sc_hd__ha_1
X_24694_ net714 net719 VSS VSS VDD VDD _12428_ _12429_ sky130_fd_sc_hd__ha_4
X_24695_ net714 net719 VSS VSS VDD VDD _12430_ _12431_ sky130_fd_sc_hd__ha_4
X_24696_ net715 _02438_ VSS VSS VDD VDD _12433_ _12434_ sky130_fd_sc_hd__ha_4
X_24697_ _02444_ net400 VSS VSS VDD VDD _12436_ _12437_ sky130_fd_sc_hd__ha_4
X_24698_ _02444_ net400 VSS VSS VDD VDD _12438_ _12439_ sky130_fd_sc_hd__ha_4
X_24699_ _02444_ _02438_ VSS VSS VDD VDD _12440_ _12441_ sky130_fd_sc_hd__ha_1
X_24700_ _02444_ _02438_ VSS VSS VDD VDD _12442_ _12443_ sky130_fd_sc_hd__ha_4
X_24701_ net397 net400 VSS VSS VDD VDD _12445_ _12446_ sky130_fd_sc_hd__ha_1
X_24702_ net397 _02438_ VSS VSS VDD VDD _12447_ _12448_ sky130_fd_sc_hd__ha_1
X_24703_ net399 _02438_ VSS VSS VDD VDD _12449_ _12450_ sky130_fd_sc_hd__ha_1
X_24704_ _02449_ net722 VSS VSS VDD VDD _12452_ _12453_ sky130_fd_sc_hd__ha_1
X_24705_ _02449_ net400 VSS VSS VDD VDD _12454_ _12455_ sky130_fd_sc_hd__ha_1
X_24706_ _02449_ _02438_ VSS VSS VDD VDD _12456_ _12457_ sky130_fd_sc_hd__ha_1
X_24707_ net533 net394 VSS VSS VDD VDD _12460_ _12461_ sky130_fd_sc_hd__ha_4
X_24708_ net534 net394 VSS VSS VDD VDD _12462_ _12463_ sky130_fd_sc_hd__ha_4
X_24709_ _02986_ _02981_ VSS VSS VDD VDD _12465_ _12466_ sky130_fd_sc_hd__ha_4
X_24710_ _02987_ net394 VSS VSS VDD VDD _12468_ _12469_ sky130_fd_sc_hd__ha_4
X_24711_ _02987_ net394 VSS VSS VDD VDD _12470_ _12471_ sky130_fd_sc_hd__ha_4
X_24712_ _02987_ _02981_ VSS VSS VDD VDD _12472_ _12473_ sky130_fd_sc_hd__ha_1
X_24713_ _02987_ _02981_ VSS VSS VDD VDD _12474_ _12475_ sky130_fd_sc_hd__ha_4
X_24714_ net392 net394 VSS VSS VDD VDD _12477_ _12478_ sky130_fd_sc_hd__ha_1
X_24715_ net561 _02981_ VSS VSS VDD VDD _12479_ _12480_ sky130_fd_sc_hd__ha_1
X_24716_ net393 _02981_ VSS VSS VDD VDD _12481_ _12482_ sky130_fd_sc_hd__ha_1
X_24717_ _02993_ net695 VSS VSS VDD VDD _12484_ _12485_ sky130_fd_sc_hd__ha_1
X_24718_ _02993_ net394 VSS VSS VDD VDD _12486_ _12487_ sky130_fd_sc_hd__ha_1
X_24719_ _02993_ _02981_ VSS VSS VDD VDD _12488_ _12489_ sky130_fd_sc_hd__ha_1
X_24720_ u0.r0.rcnt_next\[0\] _12490_ VSS VSS VDD VDD _12491_
+ u0.r0.rcnt_next\[1\] sky130_fd_sc_hd__ha_1
X_24721_ u0.r0.rcnt_next\[0\] u0.r0.rcnt\[1\] VSS VSS VDD
+ VDD _12492_ _12493_ sky130_fd_sc_hd__ha_1
X_24722_ u0.r0.rcnt\[0\] _12490_ VSS VSS VDD VDD _12494_ _12495_
+ sky130_fd_sc_hd__ha_1
X_24723_ u0.r0.rcnt\[0\] u0.r0.rcnt\[1\] VSS VSS VDD VDD _12496_
+ _12497_ sky130_fd_sc_hd__ha_1
X_24724_ u0.r0.rcnt\[0\] u0.r0.rcnt\[1\] VSS VSS VDD VDD _12498_
+ _12499_ sky130_fd_sc_hd__ha_1
Xdcnt\[0\]$_SDFFE_PN0P_ clknet_leaf_31_clk _00405_ VSS VSS
+ VDD VDD dcnt\[0\] sky130_fd_sc_hd__dfxtp_1
Xdcnt\[1\]$_SDFFE_PN0P_ clknet_leaf_31_clk _00406_ VSS VSS
+ VDD VDD dcnt\[1\] sky130_fd_sc_hd__dfxtp_1
Xdcnt\[2\]$_SDFFE_PP0P_ clknet_leaf_30_clk _00407_ VSS VSS
+ VDD VDD dcnt\[2\] sky130_fd_sc_hd__dfxtp_1
Xdcnt\[3\]$_SDFFE_PN0P_ clknet_leaf_30_clk _00408_ VSS VSS
+ VDD VDD dcnt\[3\] sky130_fd_sc_hd__dfxtp_1
Xdone$_DFF_P_ clknet_leaf_31_clk _00160_ VSS VSS VDD VDD net259
+ sky130_fd_sc_hd__dfxtp_1
Xld_r$_DFF_P_ clknet_leaf_12_clk net495 VSS VSS VDD VDD ld_r
+ sky130_fd_sc_hd__dfxtp_4
Xsa00_sr\[0\]$_DFF_P_ clknet_leaf_51_clk _00032_ VSS VSS VDD
+ VDD sa00_sr\[0\] sky130_fd_sc_hd__dfxtp_4
Xsa00_sr\[1\]$_DFF_P_ clknet_leaf_52_clk _00033_ VSS VSS VDD
+ VDD sa00_sr\[1\] sky130_fd_sc_hd__dfxtp_2
Xsa00_sr\[2\]$_DFF_P_ clknet_leaf_51_clk _00034_ VSS VSS VDD
+ VDD sa00_sr\[2\] sky130_fd_sc_hd__dfxtp_4
Xsa00_sr\[3\]$_DFF_P_ clknet_leaf_49_clk _00035_ VSS VSS VDD
+ VDD sa00_sr\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa00_sr\[4\]$_DFF_P_ clknet_leaf_51_clk _00036_ VSS VSS VDD
+ VDD sa00_sr\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa00_sr\[5\]$_DFF_P_ clknet_leaf_52_clk _00037_ VSS VSS VDD
+ VDD sa00_sr\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa00_sr\[6\]$_DFF_P_ clknet_leaf_51_clk _00038_ VSS VSS VDD
+ VDD sa00_sr\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa00_sr\[7\]$_DFF_P_ clknet_leaf_52_clk _00039_ VSS VSS VDD
+ VDD sa00_sr\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa01_sr\[0\]$_DFF_P_ clknet_leaf_45_clk _00040_ VSS VSS VDD
+ VDD sa01_sr\[0\] sky130_fd_sc_hd__dfxtp_2
Xsa01_sr\[1\]$_DFF_P_ clknet_leaf_40_clk _00041_ VSS VSS VDD
+ VDD sa01_sr\[1\] sky130_fd_sc_hd__dfxtp_2
Xsa01_sr\[2\]$_DFF_P_ clknet_leaf_47_clk _00042_ VSS VSS VDD
+ VDD sa01_sr\[2\] sky130_fd_sc_hd__dfxtp_2
Xsa01_sr\[3\]$_DFF_P_ clknet_leaf_40_clk _00043_ VSS VSS VDD
+ VDD sa01_sr\[3\] sky130_fd_sc_hd__dfxtp_2
Xsa01_sr\[4\]$_DFF_P_ clknet_leaf_45_clk _00044_ VSS VSS VDD
+ VDD sa01_sr\[4\] sky130_fd_sc_hd__dfxtp_2
Xsa01_sr\[5\]$_DFF_P_ clknet_leaf_44_clk _00045_ VSS VSS VDD
+ VDD sa01_sr\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa01_sr\[6\]$_DFF_P_ clknet_leaf_44_clk _00046_ VSS VSS VDD
+ VDD sa01_sr\[6\] sky130_fd_sc_hd__dfxtp_2
Xsa01_sr\[7\]$_DFF_P_ clknet_leaf_44_clk _00047_ VSS VSS VDD
+ VDD sa01_sr\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa02_sr\[0\]$_DFF_P_ clknet_leaf_27_clk _00048_ VSS VSS VDD
+ VDD sa02_sr\[0\] sky130_fd_sc_hd__dfxtp_2
Xsa02_sr\[1\]$_DFF_P_ clknet_leaf_27_clk _00049_ VSS VSS VDD
+ VDD sa02_sr\[1\] sky130_fd_sc_hd__dfxtp_2
Xsa02_sr\[2\]$_DFF_P_ clknet_leaf_17_clk _00050_ VSS VSS VDD
+ VDD sa02_sr\[2\] sky130_fd_sc_hd__dfxtp_2
Xsa02_sr\[3\]$_DFF_P_ clknet_leaf_16_clk _00051_ VSS VSS VDD
+ VDD sa02_sr\[3\] sky130_fd_sc_hd__dfxtp_2
Xsa02_sr\[4\]$_DFF_P_ clknet_leaf_16_clk _00052_ VSS VSS VDD
+ VDD sa02_sr\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa02_sr\[5\]$_DFF_P_ clknet_leaf_15_clk _00053_ VSS VSS VDD
+ VDD sa02_sr\[5\] sky130_fd_sc_hd__dfxtp_2
Xsa02_sr\[6\]$_DFF_P_ clknet_leaf_17_clk _00054_ VSS VSS VDD
+ VDD sa02_sr\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa02_sr\[7\]$_DFF_P_ clknet_leaf_16_clk _00055_ VSS VSS VDD
+ VDD sa02_sr\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa03_sr\[0\]$_DFF_P_ clknet_leaf_67_clk _00056_ VSS VSS VDD
+ VDD sa03_sr\[0\] sky130_fd_sc_hd__dfxtp_4
Xsa03_sr\[1\]$_DFF_P_ clknet_leaf_67_clk _00057_ VSS VSS VDD
+ VDD sa03_sr\[1\] sky130_fd_sc_hd__dfxtp_2
Xsa03_sr\[2\]$_DFF_P_ clknet_leaf_68_clk _00058_ VSS VSS VDD
+ VDD sa03_sr\[2\] sky130_fd_sc_hd__dfxtp_4
Xsa03_sr\[3\]$_DFF_P_ clknet_leaf_67_clk _00059_ VSS VSS VDD
+ VDD sa03_sr\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa03_sr\[4\]$_DFF_P_ clknet_leaf_67_clk _00060_ VSS VSS VDD
+ VDD sa03_sr\[4\] sky130_fd_sc_hd__dfxtp_1
Xsa03_sr\[5\]$_DFF_P_ clknet_leaf_67_clk _00061_ VSS VSS VDD
+ VDD sa03_sr\[5\] sky130_fd_sc_hd__dfxtp_1
Xsa03_sr\[6\]$_DFF_P_ clknet_leaf_68_clk _00062_ VSS VSS VDD
+ VDD sa03_sr\[6\] sky130_fd_sc_hd__dfxtp_2
Xsa03_sr\[7\]$_DFF_P_ clknet_leaf_68_clk _00063_ VSS VSS VDD
+ VDD sa03_sr\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa10_sr\[0\]$_DFF_P_ clknet_leaf_48_clk _00072_ VSS VSS VDD
+ VDD sa10_sr\[0\] sky130_fd_sc_hd__dfxtp_2
Xsa10_sr\[1\]$_DFF_P_ clknet_leaf_49_clk _00073_ VSS VSS VDD
+ VDD sa10_sr\[1\] sky130_fd_sc_hd__dfxtp_2
Xsa10_sr\[2\]$_DFF_P_ clknet_leaf_48_clk _00074_ VSS VSS VDD
+ VDD sa10_sr\[2\] sky130_fd_sc_hd__dfxtp_2
Xsa10_sr\[3\]$_DFF_P_ clknet_leaf_47_clk _00075_ VSS VSS VDD
+ VDD sa10_sr\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa10_sr\[4\]$_DFF_P_ clknet_leaf_48_clk _00076_ VSS VSS VDD
+ VDD sa10_sr\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa10_sr\[5\]$_DFF_P_ clknet_leaf_48_clk _00077_ VSS VSS VDD
+ VDD sa10_sr\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa10_sr\[6\]$_DFF_P_ clknet_leaf_49_clk _00078_ VSS VSS VDD
+ VDD sa10_sr\[6\] sky130_fd_sc_hd__dfxtp_2
Xsa10_sr\[7\]$_DFF_P_ clknet_leaf_49_clk _00079_ VSS VSS VDD
+ VDD sa10_sr\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa11_sr\[0\]$_DFF_P_ clknet_leaf_15_clk _00080_ VSS VSS VDD
+ VDD sa11_sr\[0\] sky130_fd_sc_hd__dfxtp_4
Xsa11_sr\[1\]$_DFF_P_ clknet_leaf_47_clk _00081_ VSS VSS VDD
+ VDD sa11_sr\[1\] sky130_fd_sc_hd__dfxtp_2
Xsa11_sr\[2\]$_DFF_P_ clknet_leaf_46_clk _00082_ VSS VSS VDD
+ VDD sa11_sr\[2\] sky130_fd_sc_hd__dfxtp_2
Xsa11_sr\[3\]$_DFF_P_ clknet_leaf_50_clk _00083_ VSS VSS VDD
+ VDD sa11_sr\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa11_sr\[4\]$_DFF_P_ clknet_leaf_13_clk _00084_ VSS VSS VDD
+ VDD sa11_sr\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa11_sr\[5\]$_DFF_P_ clknet_leaf_50_clk _00085_ VSS VSS VDD
+ VDD sa11_sr\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa11_sr\[6\]$_DFF_P_ clknet_leaf_46_clk _00086_ VSS VSS VDD
+ VDD sa11_sr\[6\] sky130_fd_sc_hd__dfxtp_2
Xsa11_sr\[7\]$_DFF_P_ clknet_leaf_35_clk _00087_ VSS VSS VDD
+ VDD sa11_sr\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa12_sr\[0\]$_DFF_P_ clknet_leaf_17_clk _00088_ VSS VSS VDD
+ VDD sa12_sr\[0\] sky130_fd_sc_hd__dfxtp_2
Xsa12_sr\[1\]$_DFF_P_ clknet_leaf_17_clk _00089_ VSS VSS VDD
+ VDD sa12_sr\[1\] sky130_fd_sc_hd__dfxtp_2
Xsa12_sr\[2\]$_DFF_P_ clknet_leaf_17_clk _00090_ VSS VSS VDD
+ VDD sa12_sr\[2\] sky130_fd_sc_hd__dfxtp_2
Xsa12_sr\[3\]$_DFF_P_ clknet_leaf_17_clk _00091_ VSS VSS VDD
+ VDD sa12_sr\[3\] sky130_fd_sc_hd__dfxtp_2
Xsa12_sr\[4\]$_DFF_P_ clknet_leaf_15_clk _00092_ VSS VSS VDD
+ VDD sa12_sr\[4\] sky130_fd_sc_hd__dfxtp_2
Xsa12_sr\[5\]$_DFF_P_ clknet_leaf_17_clk _00093_ VSS VSS VDD
+ VDD sa12_sr\[5\] sky130_fd_sc_hd__dfxtp_2
Xsa12_sr\[6\]$_DFF_P_ clknet_leaf_18_clk _00094_ VSS VSS VDD
+ VDD sa12_sr\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa12_sr\[7\]$_DFF_P_ clknet_leaf_18_clk _00095_ VSS VSS VDD
+ VDD sa12_sr\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa13_sr\[0\]$_DFF_P_ clknet_leaf_66_clk _00064_ VSS VSS VDD
+ VDD sa10_sub\[0\] sky130_fd_sc_hd__dfxtp_4
Xsa13_sr\[1\]$_DFF_P_ clknet_leaf_66_clk _00065_ VSS VSS VDD
+ VDD sa10_sub\[1\] sky130_fd_sc_hd__dfxtp_4
Xsa13_sr\[2\]$_DFF_P_ clknet_leaf_65_clk _00066_ VSS VSS VDD
+ VDD sa10_sub\[2\] sky130_fd_sc_hd__dfxtp_4
Xsa13_sr\[3\]$_DFF_P_ clknet_leaf_67_clk _00067_ VSS VSS VDD
+ VDD sa10_sub\[3\] sky130_fd_sc_hd__dfxtp_2
Xsa13_sr\[4\]$_DFF_P_ clknet_leaf_67_clk _00068_ VSS VSS VDD
+ VDD sa10_sub\[4\] sky130_fd_sc_hd__dfxtp_2
Xsa13_sr\[5\]$_DFF_P_ clknet_leaf_66_clk _00069_ VSS VSS VDD
+ VDD sa10_sub\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa13_sr\[6\]$_DFF_P_ clknet_leaf_66_clk _00070_ VSS VSS VDD
+ VDD sa10_sub\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa13_sr\[7\]$_DFF_P_ clknet_leaf_66_clk _00071_ VSS VSS VDD
+ VDD sa10_sub\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa20_sr\[0\]$_DFF_P_ clknet_leaf_50_clk _00112_ VSS VSS VDD
+ VDD sa20_sr\[0\] sky130_fd_sc_hd__dfxtp_2
Xsa20_sr\[1\]$_DFF_P_ clknet_leaf_50_clk _00113_ VSS VSS VDD
+ VDD sa20_sr\[1\] sky130_fd_sc_hd__dfxtp_4
Xsa20_sr\[2\]$_DFF_P_ clknet_leaf_36_clk _00114_ VSS VSS VDD
+ VDD sa20_sr\[2\] sky130_fd_sc_hd__dfxtp_4
Xsa20_sr\[3\]$_DFF_P_ clknet_leaf_50_clk _00115_ VSS VSS VDD
+ VDD sa20_sr\[3\] sky130_fd_sc_hd__dfxtp_2
Xsa20_sr\[4\]$_DFF_P_ clknet_leaf_36_clk _00116_ VSS VSS VDD
+ VDD sa20_sr\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa20_sr\[5\]$_DFF_P_ clknet_leaf_51_clk _00117_ VSS VSS VDD
+ VDD sa20_sr\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa20_sr\[6\]$_DFF_P_ clknet_leaf_50_clk _00118_ VSS VSS VDD
+ VDD sa20_sr\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa20_sr\[7\]$_DFF_P_ clknet_leaf_50_clk _00119_ VSS VSS VDD
+ VDD sa20_sr\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa21_sr\[0\]$_DFF_P_ clknet_leaf_45_clk _00120_ VSS VSS VDD
+ VDD sa21_sr\[0\] sky130_fd_sc_hd__dfxtp_2
Xsa21_sr\[1\]$_DFF_P_ clknet_leaf_45_clk _00121_ VSS VSS VDD
+ VDD sa21_sr\[1\] sky130_fd_sc_hd__dfxtp_2
Xsa21_sr\[2\]$_DFF_P_ clknet_leaf_44_clk _00122_ VSS VSS VDD
+ VDD sa21_sr\[2\] sky130_fd_sc_hd__dfxtp_2
Xsa21_sr\[3\]$_DFF_P_ clknet_leaf_55_clk _00123_ VSS VSS VDD
+ VDD sa21_sr\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa21_sr\[4\]$_DFF_P_ clknet_leaf_55_clk _00124_ VSS VSS VDD
+ VDD sa21_sr\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa21_sr\[5\]$_DFF_P_ clknet_leaf_55_clk _00125_ VSS VSS VDD
+ VDD sa21_sr\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa21_sr\[6\]$_DFF_P_ clknet_leaf_58_clk _00126_ VSS VSS VDD
+ VDD sa21_sr\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa21_sr\[7\]$_DFF_P_ clknet_leaf_45_clk _00127_ VSS VSS VDD
+ VDD sa21_sr\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa22_sr\[0\]$_DFF_P_ clknet_leaf_17_clk _00096_ VSS VSS VDD
+ VDD sa20_sub\[0\] sky130_fd_sc_hd__dfxtp_2
Xsa22_sr\[1\]$_DFF_P_ clknet_leaf_27_clk _00097_ VSS VSS VDD
+ VDD sa20_sub\[1\] sky130_fd_sc_hd__dfxtp_2
Xsa22_sr\[2\]$_DFF_P_ clknet_leaf_15_clk _00098_ VSS VSS VDD
+ VDD sa20_sub\[2\] sky130_fd_sc_hd__dfxtp_4
Xsa22_sr\[3\]$_DFF_P_ clknet_leaf_35_clk _00099_ VSS VSS VDD
+ VDD sa20_sub\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa22_sr\[4\]$_DFF_P_ clknet_leaf_35_clk _00100_ VSS VSS VDD
+ VDD sa20_sub\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa22_sr\[5\]$_DFF_P_ clknet_leaf_36_clk _00101_ VSS VSS VDD
+ VDD sa20_sub\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa22_sr\[6\]$_DFF_P_ clknet_leaf_36_clk _00102_ VSS VSS VDD
+ VDD sa20_sub\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa22_sr\[7\]$_DFF_P_ clknet_leaf_36_clk _00103_ VSS VSS VDD
+ VDD sa20_sub\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa23_sr\[0\]$_DFF_P_ clknet_leaf_61_clk _00104_ VSS VSS VDD
+ VDD sa21_sub\[0\] sky130_fd_sc_hd__dfxtp_4
Xsa23_sr\[1\]$_DFF_P_ clknet_leaf_62_clk _00105_ VSS VSS VDD
+ VDD sa21_sub\[1\] sky130_fd_sc_hd__dfxtp_4
Xsa23_sr\[2\]$_DFF_P_ clknet_leaf_61_clk _00106_ VSS VSS VDD
+ VDD sa21_sub\[2\] sky130_fd_sc_hd__dfxtp_4
Xsa23_sr\[3\]$_DFF_P_ clknet_leaf_62_clk _00107_ VSS VSS VDD
+ VDD sa21_sub\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa23_sr\[4\]$_DFF_P_ clknet_leaf_62_clk _00108_ VSS VSS VDD
+ VDD sa21_sub\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa23_sr\[5\]$_DFF_P_ clknet_leaf_61_clk _00109_ VSS VSS VDD
+ VDD sa21_sub\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa23_sr\[6\]$_DFF_P_ clknet_leaf_61_clk _00110_ VSS VSS VDD
+ VDD sa21_sub\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa23_sr\[7\]$_DFF_P_ clknet_leaf_55_clk _00111_ VSS VSS VDD
+ VDD sa21_sub\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa30_sr\[0\]$_DFF_P_ clknet_leaf_13_clk _00152_ VSS VSS VDD
+ VDD sa30_sr\[0\] sky130_fd_sc_hd__dfxtp_4
Xsa30_sr\[1\]$_DFF_P_ clknet_leaf_13_clk _00153_ VSS VSS VDD
+ VDD sa30_sr\[1\] sky130_fd_sc_hd__dfxtp_4
Xsa30_sr\[2\]$_DFF_P_ clknet_leaf_13_clk _00154_ VSS VSS VDD
+ VDD sa30_sr\[2\] sky130_fd_sc_hd__dfxtp_4
Xsa30_sr\[3\]$_DFF_P_ clknet_leaf_13_clk _00155_ VSS VSS VDD
+ VDD sa30_sr\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa30_sr\[4\]$_DFF_P_ clknet_leaf_13_clk _00156_ VSS VSS VDD
+ VDD sa30_sr\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa30_sr\[5\]$_DFF_P_ clknet_leaf_12_clk _00157_ VSS VSS VDD
+ VDD sa30_sr\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa30_sr\[6\]$_DFF_P_ clknet_leaf_13_clk _00158_ VSS VSS VDD
+ VDD sa30_sr\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa30_sr\[7\]$_DFF_P_ clknet_leaf_12_clk _00159_ VSS VSS VDD
+ VDD sa30_sr\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa31_sr\[0\]$_DFF_P_ clknet_leaf_35_clk _00128_ VSS VSS VDD
+ VDD sa30_sub\[0\] sky130_fd_sc_hd__dfxtp_4
Xsa31_sr\[1\]$_DFF_P_ clknet_leaf_34_clk _00129_ VSS VSS VDD
+ VDD sa30_sub\[1\] sky130_fd_sc_hd__dfxtp_4
Xsa31_sr\[2\]$_DFF_P_ clknet_leaf_34_clk _00130_ VSS VSS VDD
+ VDD sa30_sub\[2\] sky130_fd_sc_hd__dfxtp_4
Xsa31_sr\[3\]$_DFF_P_ clknet_leaf_34_clk _00131_ VSS VSS VDD
+ VDD sa30_sub\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa31_sr\[4\]$_DFF_P_ clknet_leaf_34_clk _00132_ VSS VSS VDD
+ VDD sa30_sub\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa31_sr\[5\]$_DFF_P_ clknet_leaf_35_clk _00133_ VSS VSS VDD
+ VDD sa30_sub\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa31_sr\[6\]$_DFF_P_ clknet_leaf_34_clk _00134_ VSS VSS VDD
+ VDD sa30_sub\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa31_sr\[7\]$_DFF_P_ clknet_leaf_34_clk _00135_ VSS VSS VDD
+ VDD sa30_sub\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa32_sr\[0\]$_DFF_P_ clknet_leaf_23_clk _00136_ VSS VSS VDD
+ VDD sa31_sub\[0\] sky130_fd_sc_hd__dfxtp_4
Xsa32_sr\[1\]$_DFF_P_ clknet_leaf_22_clk _00137_ VSS VSS VDD
+ VDD sa31_sub\[1\] sky130_fd_sc_hd__dfxtp_4
Xsa32_sr\[2\]$_DFF_P_ clknet_leaf_30_clk _00138_ VSS VSS VDD
+ VDD sa31_sub\[2\] sky130_fd_sc_hd__dfxtp_4
Xsa32_sr\[3\]$_DFF_P_ clknet_leaf_22_clk _00139_ VSS VSS VDD
+ VDD sa31_sub\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa32_sr\[4\]$_DFF_P_ clknet_leaf_27_clk _00140_ VSS VSS VDD
+ VDD sa31_sub\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa32_sr\[5\]$_DFF_P_ clknet_leaf_23_clk _00141_ VSS VSS VDD
+ VDD sa31_sub\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa32_sr\[6\]$_DFF_P_ clknet_leaf_23_clk _00142_ VSS VSS VDD
+ VDD sa31_sub\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa32_sr\[7\]$_DFF_P_ clknet_leaf_27_clk _00143_ VSS VSS VDD
+ VDD sa31_sub\[7\] sky130_fd_sc_hd__dfxtp_4
Xsa33_sr\[0\]$_DFF_P_ clknet_leaf_11_clk _00144_ VSS VSS VDD
+ VDD sa32_sub\[0\] sky130_fd_sc_hd__dfxtp_2
Xsa33_sr\[1\]$_DFF_P_ clknet_leaf_0_clk _00145_ VSS VSS VDD
+ VDD sa32_sub\[1\] sky130_fd_sc_hd__dfxtp_4
Xsa33_sr\[2\]$_DFF_P_ clknet_leaf_1_clk _00146_ VSS VSS VDD
+ VDD sa32_sub\[2\] sky130_fd_sc_hd__dfxtp_4
Xsa33_sr\[3\]$_DFF_P_ clknet_leaf_1_clk _00147_ VSS VSS VDD
+ VDD sa32_sub\[3\] sky130_fd_sc_hd__dfxtp_4
Xsa33_sr\[4\]$_DFF_P_ clknet_leaf_0_clk _00148_ VSS VSS VDD
+ VDD sa32_sub\[4\] sky130_fd_sc_hd__dfxtp_4
Xsa33_sr\[5\]$_DFF_P_ clknet_leaf_2_clk _00149_ VSS VSS VDD
+ VDD sa32_sub\[5\] sky130_fd_sc_hd__dfxtp_4
Xsa33_sr\[6\]$_DFF_P_ clknet_leaf_1_clk _00150_ VSS VSS VDD
+ VDD sa32_sub\[6\] sky130_fd_sc_hd__dfxtp_4
Xsa33_sr\[7\]$_DFF_P_ clknet_leaf_0_clk _00151_ VSS VSS VDD
+ VDD sa32_sub\[7\] sky130_fd_sc_hd__dfxtp_4
Xtext_in_r\[0\]$_DFFE_PP_ clknet_leaf_70_clk net131 net495
+ VSS VSS VDD VDD text_in_r\[0\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[100\]$_DFFE_PP_ clknet_leaf_39_clk net132 net496
+ VSS VSS VDD VDD text_in_r\[100\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[101\]$_DFFE_PP_ clknet_leaf_38_clk net133 net496
+ VSS VSS VDD VDD text_in_r\[101\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[102\]$_DFFE_PP_ clknet_leaf_39_clk net134 net496
+ VSS VSS VDD VDD text_in_r\[102\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[103\]$_DFFE_PP_ clknet_leaf_40_clk net135 net652
+ VSS VSS VDD VDD text_in_r\[103\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[104\]$_DFFE_PP_ clknet_leaf_19_clk net136 net497
+ VSS VSS VDD VDD text_in_r\[104\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[105\]$_DFFE_PP_ clknet_leaf_16_clk net137 net497
+ VSS VSS VDD VDD text_in_r\[105\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[106\]$_DFFE_PP_ clknet_leaf_39_clk net138 net496
+ VSS VSS VDD VDD text_in_r\[106\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[107\]$_DFFE_PP_ clknet_leaf_37_clk net139 net496
+ VSS VSS VDD VDD text_in_r\[107\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[108\]$_DFFE_PP_ clknet_leaf_37_clk net140 net496
+ VSS VSS VDD VDD text_in_r\[108\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[109\]$_DFFE_PP_ clknet_leaf_38_clk net141 net496
+ VSS VSS VDD VDD text_in_r\[109\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[10\]$_DFFE_PP_ clknet_leaf_60_clk net142 net494
+ VSS VSS VDD VDD text_in_r\[10\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[110\]$_DFFE_PP_ clknet_leaf_38_clk net143 net496
+ VSS VSS VDD VDD text_in_r\[110\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[111\]$_DFFE_PP_ clknet_leaf_38_clk net144 net496
+ VSS VSS VDD VDD text_in_r\[111\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[112\]$_DFFE_PP_ clknet_leaf_50_clk net145 net495
+ VSS VSS VDD VDD text_in_r\[112\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[113\]$_DFFE_PP_ clknet_leaf_46_clk net146 net652
+ VSS VSS VDD VDD text_in_r\[113\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[114\]$_DFFE_PP_ clknet_leaf_72_clk net147 net129
+ VSS VSS VDD VDD text_in_r\[114\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[115\]$_DFFE_PP_ clknet_leaf_59_clk net148 net494
+ VSS VSS VDD VDD text_in_r\[115\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[116\]$_DFFE_PP_ clknet_leaf_42_clk net149 net652
+ VSS VSS VDD VDD text_in_r\[116\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[117\]$_DFFE_PP_ clknet_leaf_61_clk net150 net652
+ VSS VSS VDD VDD text_in_r\[117\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[118\]$_DFFE_PP_ clknet_leaf_43_clk net151 net652
+ VSS VSS VDD VDD text_in_r\[118\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[119\]$_DFFE_PP_ clknet_leaf_43_clk net152 net652
+ VSS VSS VDD VDD text_in_r\[119\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[11\]$_DFFE_PP_ clknet_leaf_60_clk net153 net494
+ VSS VSS VDD VDD text_in_r\[11\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[120\]$_DFFE_PP_ clknet_leaf_58_clk net154 net652
+ VSS VSS VDD VDD text_in_r\[120\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[121\]$_DFFE_PP_ clknet_leaf_41_clk net155 net652
+ VSS VSS VDD VDD text_in_r\[121\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[122\]$_DFFE_PP_ clknet_leaf_43_clk net156 net652
+ VSS VSS VDD VDD text_in_r\[122\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[123\]$_DFFE_PP_ clknet_leaf_59_clk net157 net652
+ VSS VSS VDD VDD text_in_r\[123\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[124\]$_DFFE_PP_ clknet_leaf_63_clk net158 net494
+ VSS VSS VDD VDD text_in_r\[124\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[125\]$_DFFE_PP_ clknet_leaf_58_clk net159 net652
+ VSS VSS VDD VDD text_in_r\[125\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[126\]$_DFFE_PP_ clknet_leaf_59_clk net160 net652
+ VSS VSS VDD VDD text_in_r\[126\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[127\]$_DFFE_PP_ clknet_leaf_56_clk net161 net652
+ VSS VSS VDD VDD text_in_r\[127\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[12\]$_DFFE_PP_ clknet_leaf_59_clk net162 net494
+ VSS VSS VDD VDD text_in_r\[12\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[13\]$_DFFE_PP_ clknet_leaf_60_clk net163 net494
+ VSS VSS VDD VDD text_in_r\[13\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[14\]$_DFFE_PP_ clknet_leaf_60_clk net164 net494
+ VSS VSS VDD VDD text_in_r\[14\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[15\]$_DFFE_PP_ clknet_leaf_59_clk net165 net494
+ VSS VSS VDD VDD text_in_r\[15\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[16\]$_DFFE_PP_ clknet_leaf_70_clk net166 net495
+ VSS VSS VDD VDD text_in_r\[16\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[17\]$_DFFE_PP_ clknet_leaf_2_clk net167 net497
+ VSS VSS VDD VDD text_in_r\[17\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[18\]$_DFFE_PP_ clknet_leaf_4_clk net168 net496
+ VSS VSS VDD VDD text_in_r\[18\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[19\]$_DFFE_PP_ clknet_leaf_4_clk net169 net497
+ VSS VSS VDD VDD text_in_r\[19\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[1\]$_DFFE_PP_ clknet_leaf_69_clk net170 net495
+ VSS VSS VDD VDD text_in_r\[1\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[20\]$_DFFE_PP_ clknet_leaf_72_clk net171 net495
+ VSS VSS VDD VDD text_in_r\[20\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[21\]$_DFFE_PP_ clknet_leaf_71_clk net172 net495
+ VSS VSS VDD VDD text_in_r\[21\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[22\]$_DFFE_PP_ clknet_leaf_71_clk net173 net495
+ VSS VSS VDD VDD text_in_r\[22\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[23\]$_DFFE_PP_ clknet_leaf_71_clk net174 net495
+ VSS VSS VDD VDD text_in_r\[23\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[24\]$_DFFE_PP_ clknet_leaf_70_clk net175 net495
+ VSS VSS VDD VDD text_in_r\[24\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[25\]$_DFFE_PP_ clknet_leaf_71_clk net176 net495
+ VSS VSS VDD VDD text_in_r\[25\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[26\]$_DFFE_PP_ clknet_leaf_71_clk net177 net495
+ VSS VSS VDD VDD text_in_r\[26\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[27\]$_DFFE_PP_ clknet_leaf_71_clk net178 net495
+ VSS VSS VDD VDD text_in_r\[27\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[28\]$_DFFE_PP_ clknet_leaf_70_clk net179 net495
+ VSS VSS VDD VDD text_in_r\[28\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[29\]$_DFFE_PP_ clknet_leaf_70_clk net180 net495
+ VSS VSS VDD VDD text_in_r\[29\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[2\]$_DFFE_PP_ clknet_leaf_69_clk net181 net495
+ VSS VSS VDD VDD text_in_r\[2\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[30\]$_DFFE_PP_ clknet_leaf_71_clk net182 net495
+ VSS VSS VDD VDD text_in_r\[30\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[31\]$_DFFE_PP_ clknet_leaf_71_clk net183 net495
+ VSS VSS VDD VDD text_in_r\[31\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[32\]$_DFFE_PP_ clknet_leaf_30_clk net184 net496
+ VSS VSS VDD VDD text_in_r\[32\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[33\]$_DFFE_PP_ clknet_leaf_20_clk net185 net496
+ VSS VSS VDD VDD text_in_r\[33\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[34\]$_DFFE_PP_ clknet_leaf_26_clk net186 net496
+ VSS VSS VDD VDD text_in_r\[34\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[35\]$_DFFE_PP_ clknet_leaf_3_clk net187 net497
+ VSS VSS VDD VDD text_in_r\[35\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[36\]$_DFFE_PP_ clknet_leaf_24_clk net188 net496
+ VSS VSS VDD VDD text_in_r\[36\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[37\]$_DFFE_PP_ clknet_leaf_2_clk net189 net497
+ VSS VSS VDD VDD text_in_r\[37\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[38\]$_DFFE_PP_ clknet_leaf_28_clk net190 net496
+ VSS VSS VDD VDD text_in_r\[38\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[39\]$_DFFE_PP_ clknet_leaf_18_clk net191 net497
+ VSS VSS VDD VDD text_in_r\[39\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[3\]$_DFFE_PP_ clknet_leaf_69_clk net192 net495
+ VSS VSS VDD VDD text_in_r\[3\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[40\]$_DFFE_PP_ clknet_leaf_22_clk net193 net496
+ VSS VSS VDD VDD text_in_r\[40\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[41\]$_DFFE_PP_ clknet_leaf_22_clk net194 net496
+ VSS VSS VDD VDD text_in_r\[41\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[42\]$_DFFE_PP_ clknet_leaf_22_clk net195 net496
+ VSS VSS VDD VDD text_in_r\[42\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[43\]$_DFFE_PP_ clknet_leaf_33_clk net196 net496
+ VSS VSS VDD VDD text_in_r\[43\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[44\]$_DFFE_PP_ clknet_leaf_33_clk net197 net496
+ VSS VSS VDD VDD text_in_r\[44\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[45\]$_DFFE_PP_ clknet_leaf_33_clk net198 net496
+ VSS VSS VDD VDD text_in_r\[45\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[46\]$_DFFE_PP_ clknet_leaf_33_clk net199 net496
+ VSS VSS VDD VDD text_in_r\[46\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[47\]$_DFFE_PP_ clknet_leaf_33_clk net200 net496
+ VSS VSS VDD VDD text_in_r\[47\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[48\]$_DFFE_PP_ clknet_leaf_22_clk net201 net497
+ VSS VSS VDD VDD text_in_r\[48\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[49\]$_DFFE_PP_ clknet_leaf_24_clk net202 net496
+ VSS VSS VDD VDD text_in_r\[49\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[4\]$_DFFE_PP_ clknet_leaf_70_clk net203 net495
+ VSS VSS VDD VDD text_in_r\[4\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[50\]$_DFFE_PP_ clknet_leaf_19_clk net204 net497
+ VSS VSS VDD VDD text_in_r\[50\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[51\]$_DFFE_PP_ clknet_leaf_16_clk net205 net497
+ VSS VSS VDD VDD text_in_r\[51\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[52\]$_DFFE_PP_ clknet_leaf_22_clk net206 net496
+ VSS VSS VDD VDD text_in_r\[52\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[53\]$_DFFE_PP_ clknet_leaf_33_clk net207 net496
+ VSS VSS VDD VDD text_in_r\[53\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[54\]$_DFFE_PP_ clknet_leaf_32_clk net208 net496
+ VSS VSS VDD VDD text_in_r\[54\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[55\]$_DFFE_PP_ clknet_leaf_25_clk net209 net496
+ VSS VSS VDD VDD text_in_r\[55\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[56\]$_DFFE_PP_ clknet_leaf_25_clk net210 net496
+ VSS VSS VDD VDD text_in_r\[56\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[57\]$_DFFE_PP_ clknet_leaf_23_clk net211 net496
+ VSS VSS VDD VDD text_in_r\[57\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[58\]$_DFFE_PP_ clknet_leaf_24_clk net212 net496
+ VSS VSS VDD VDD text_in_r\[58\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[59\]$_DFFE_PP_ clknet_leaf_24_clk net213 net496
+ VSS VSS VDD VDD text_in_r\[59\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[5\]$_DFFE_PP_ clknet_leaf_70_clk net214 net495
+ VSS VSS VDD VDD text_in_r\[5\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[60\]$_DFFE_PP_ clknet_leaf_27_clk net215 net496
+ VSS VSS VDD VDD text_in_r\[60\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[61\]$_DFFE_PP_ clknet_leaf_32_clk net216 net496
+ VSS VSS VDD VDD text_in_r\[61\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[62\]$_DFFE_PP_ clknet_leaf_32_clk net217 net496
+ VSS VSS VDD VDD text_in_r\[62\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[63\]$_DFFE_PP_ clknet_leaf_25_clk net218 net496
+ VSS VSS VDD VDD text_in_r\[63\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[64\]$_DFFE_PP_ clknet_leaf_20_clk net219 net496
+ VSS VSS VDD VDD text_in_r\[64\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[65\]$_DFFE_PP_ clknet_leaf_29_clk net220 net496
+ VSS VSS VDD VDD text_in_r\[65\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[66\]$_DFFE_PP_ clknet_leaf_21_clk net221 net496
+ VSS VSS VDD VDD text_in_r\[66\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[67\]$_DFFE_PP_ clknet_leaf_28_clk net222 net496
+ VSS VSS VDD VDD text_in_r\[67\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[68\]$_DFFE_PP_ clknet_leaf_29_clk net223 net496
+ VSS VSS VDD VDD text_in_r\[68\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[69\]$_DFFE_PP_ clknet_leaf_20_clk net224 net496
+ VSS VSS VDD VDD text_in_r\[69\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[6\]$_DFFE_PP_ clknet_leaf_71_clk net225 net495
+ VSS VSS VDD VDD text_in_r\[6\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[70\]$_DFFE_PP_ clknet_leaf_29_clk net226 net496
+ VSS VSS VDD VDD text_in_r\[70\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[71\]$_DFFE_PP_ clknet_leaf_20_clk net227 net496
+ VSS VSS VDD VDD text_in_r\[71\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[72\]$_DFFE_PP_ clknet_leaf_41_clk net228 net652
+ VSS VSS VDD VDD text_in_r\[72\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[73\]$_DFFE_PP_ clknet_leaf_42_clk net229 net652
+ VSS VSS VDD VDD text_in_r\[73\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[74\]$_DFFE_PP_ clknet_leaf_42_clk net230 net652
+ VSS VSS VDD VDD text_in_r\[74\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[75\]$_DFFE_PP_ clknet_leaf_64_clk net231 net495
+ VSS VSS VDD VDD text_in_r\[75\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[76\]$_DFFE_PP_ clknet_leaf_64_clk net232 net495
+ VSS VSS VDD VDD text_in_r\[76\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[77\]$_DFFE_PP_ clknet_leaf_63_clk net233 net494
+ VSS VSS VDD VDD text_in_r\[77\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[78\]$_DFFE_PP_ clknet_leaf_64_clk net234 net495
+ VSS VSS VDD VDD text_in_r\[78\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[79\]$_DFFE_PP_ clknet_leaf_63_clk net235 net494
+ VSS VSS VDD VDD text_in_r\[79\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[7\]$_DFFE_PP_ clknet_leaf_70_clk net236 net495
+ VSS VSS VDD VDD text_in_r\[7\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[80\]$_DFFE_PP_ clknet_leaf_41_clk net237 net652
+ VSS VSS VDD VDD text_in_r\[80\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[81\]$_DFFE_PP_ clknet_leaf_42_clk net238 net652
+ VSS VSS VDD VDD text_in_r\[81\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[82\]$_DFFE_PP_ clknet_leaf_42_clk net239 net652
+ VSS VSS VDD VDD text_in_r\[82\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[83\]$_DFFE_PP_ clknet_leaf_43_clk net240 net652
+ VSS VSS VDD VDD text_in_r\[83\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[84\]$_DFFE_PP_ clknet_leaf_41_clk net241 net652
+ VSS VSS VDD VDD text_in_r\[84\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[85\]$_DFFE_PP_ clknet_leaf_42_clk net242 net652
+ VSS VSS VDD VDD text_in_r\[85\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[86\]$_DFFE_PP_ clknet_leaf_58_clk net243 net652
+ VSS VSS VDD VDD text_in_r\[86\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[87\]$_DFFE_PP_ clknet_leaf_42_clk net244 net652
+ VSS VSS VDD VDD text_in_r\[87\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[88\]$_DFFE_PP_ clknet_leaf_43_clk net245 net652
+ VSS VSS VDD VDD text_in_r\[88\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[89\]$_DFFE_PP_ clknet_leaf_42_clk net246 net652
+ VSS VSS VDD VDD text_in_r\[89\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[8\]$_DFFE_PP_ clknet_leaf_69_clk net247 net495
+ VSS VSS VDD VDD text_in_r\[8\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[90\]$_DFFE_PP_ clknet_leaf_41_clk net248 net652
+ VSS VSS VDD VDD text_in_r\[90\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[91\]$_DFFE_PP_ clknet_leaf_41_clk net249 net652
+ VSS VSS VDD VDD text_in_r\[91\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[92\]$_DFFE_PP_ clknet_leaf_42_clk net250 net652
+ VSS VSS VDD VDD text_in_r\[92\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[93\]$_DFFE_PP_ clknet_leaf_63_clk net251 net494
+ VSS VSS VDD VDD text_in_r\[93\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[94\]$_DFFE_PP_ clknet_leaf_40_clk net252 net652
+ VSS VSS VDD VDD text_in_r\[94\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[95\]$_DFFE_PP_ clknet_leaf_43_clk net253 net652
+ VSS VSS VDD VDD text_in_r\[95\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[96\]$_DFFE_PP_ clknet_leaf_34_clk net254 net497
+ VSS VSS VDD VDD text_in_r\[96\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[97\]$_DFFE_PP_ clknet_leaf_30_clk net255 net496
+ VSS VSS VDD VDD text_in_r\[97\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[98\]$_DFFE_PP_ clknet_leaf_37_clk net256 net496
+ VSS VSS VDD VDD text_in_r\[98\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[99\]$_DFFE_PP_ clknet_leaf_33_clk net257 net496
+ VSS VSS VDD VDD text_in_r\[99\] sky130_fd_sc_hd__edfxtp_1
Xtext_in_r\[9\]$_DFFE_PP_ clknet_leaf_69_clk net258 net495
+ VSS VSS VDD VDD text_in_r\[9\] sky130_fd_sc_hd__edfxtp_1
Xtext_out\[0\]$_DFF_P_ clknet_leaf_69_clk _00265_ VSS VSS
+ VDD VDD net260 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[100\]$_DFF_P_ clknet_leaf_26_clk _00165_ VSS VSS
+ VDD VDD net261 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[101\]$_DFF_P_ clknet_leaf_30_clk _00166_ VSS VSS
+ VDD VDD net262 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[102\]$_DFF_P_ clknet_leaf_16_clk _00167_ VSS VSS
+ VDD VDD net263 sky130_fd_sc_hd__dfxtp_4
Xtext_out\[103\]$_DFF_P_ clknet_leaf_15_clk _00168_ VSS VSS
+ VDD VDD net264 sky130_fd_sc_hd__dfxtp_4
Xtext_out\[104\]$_DFF_P_ clknet_leaf_49_clk _00169_ VSS VSS
+ VDD VDD net265 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[105\]$_DFF_P_ clknet_leaf_37_clk _00170_ VSS VSS
+ VDD VDD net266 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[106\]$_DFF_P_ clknet_leaf_38_clk _00171_ VSS VSS
+ VDD VDD net267 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[107\]$_DFF_P_ clknet_leaf_38_clk _00172_ VSS VSS
+ VDD VDD net268 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[108\]$_DFF_P_ clknet_leaf_38_clk _00173_ VSS VSS
+ VDD VDD net269 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[109\]$_DFF_P_ clknet_leaf_39_clk _00174_ VSS VSS
+ VDD VDD net270 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[10\]$_DFF_P_ clknet_leaf_55_clk _00195_ VSS VSS
+ VDD VDD net271 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[110\]$_DFF_P_ clknet_leaf_38_clk _00175_ VSS VSS
+ VDD VDD net272 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[111\]$_DFF_P_ clknet_leaf_38_clk _00176_ VSS VSS
+ VDD VDD net273 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[112\]$_DFF_P_ clknet_leaf_48_clk _00177_ VSS VSS
+ VDD VDD net274 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[113\]$_DFF_P_ clknet_leaf_49_clk _00178_ VSS VSS
+ VDD VDD net275 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[114\]$_DFF_P_ clknet_leaf_48_clk _00179_ VSS VSS
+ VDD VDD net276 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[115\]$_DFF_P_ clknet_leaf_45_clk _00180_ VSS VSS
+ VDD VDD net277 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[116\]$_DFF_P_ clknet_leaf_58_clk _00181_ VSS VSS
+ VDD VDD net278 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[117\]$_DFF_P_ clknet_leaf_58_clk _00182_ VSS VSS
+ VDD VDD net279 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[118\]$_DFF_P_ clknet_leaf_46_clk _00183_ VSS VSS
+ VDD VDD net280 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[119\]$_DFF_P_ clknet_leaf_46_clk _00184_ VSS VSS
+ VDD VDD net281 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[11\]$_DFF_P_ clknet_leaf_60_clk _00196_ VSS VSS
+ VDD VDD net282 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[120\]$_DFF_P_ clknet_leaf_65_clk _00185_ VSS VSS
+ VDD VDD net283 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[121\]$_DFF_P_ clknet_leaf_57_clk _00186_ VSS VSS
+ VDD VDD net284 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[122\]$_DFF_P_ clknet_leaf_59_clk _00187_ VSS VSS
+ VDD VDD net285 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[123\]$_DFF_P_ clknet_leaf_59_clk _00188_ VSS VSS
+ VDD VDD net286 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[124\]$_DFF_P_ clknet_leaf_59_clk _00189_ VSS VSS
+ VDD VDD net287 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[125\]$_DFF_P_ clknet_leaf_58_clk _00190_ VSS VSS
+ VDD VDD net288 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[126\]$_DFF_P_ clknet_leaf_56_clk _00191_ VSS VSS
+ VDD VDD net289 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[127\]$_DFF_P_ clknet_leaf_56_clk _00192_ VSS VSS
+ VDD VDD net290 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[12\]$_DFF_P_ clknet_leaf_60_clk _00197_ VSS VSS
+ VDD VDD net291 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[13\]$_DFF_P_ clknet_leaf_60_clk _00198_ VSS VSS
+ VDD VDD net292 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[14\]$_DFF_P_ clknet_leaf_59_clk _00199_ VSS VSS
+ VDD VDD net293 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[15\]$_DFF_P_ clknet_leaf_60_clk _00200_ VSS VSS
+ VDD VDD net294 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[16\]$_DFF_P_ clknet_leaf_12_clk _00201_ VSS VSS
+ VDD VDD net295 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[17\]$_DFF_P_ clknet_leaf_2_clk _00202_ VSS VSS
+ VDD VDD net296 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[18\]$_DFF_P_ clknet_leaf_69_clk _00203_ VSS VSS
+ VDD VDD net297 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[19\]$_DFF_P_ clknet_leaf_69_clk _00204_ VSS VSS
+ VDD VDD net298 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[1\]$_DFF_P_ clknet_leaf_2_clk _00266_ VSS VSS VDD
+ VDD net299 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[20\]$_DFF_P_ clknet_leaf_69_clk _00205_ VSS VSS
+ VDD VDD net300 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[21\]$_DFF_P_ clknet_leaf_69_clk _00206_ VSS VSS
+ VDD VDD net301 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[22\]$_DFF_P_ clknet_leaf_69_clk _00207_ VSS VSS
+ VDD VDD net302 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[23\]$_DFF_P_ clknet_leaf_69_clk _00208_ VSS VSS
+ VDD VDD net303 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[24\]$_DFF_P_ clknet_leaf_70_clk _00209_ VSS VSS
+ VDD VDD net304 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[25\]$_DFF_P_ clknet_leaf_70_clk _00210_ VSS VSS
+ VDD VDD net305 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[26\]$_DFF_P_ clknet_leaf_70_clk _00211_ VSS VSS
+ VDD VDD net306 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[27\]$_DFF_P_ clknet_leaf_70_clk _00212_ VSS VSS
+ VDD VDD net307 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[28\]$_DFF_P_ clknet_leaf_67_clk _00213_ VSS VSS
+ VDD VDD net308 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[29\]$_DFF_P_ clknet_leaf_67_clk _00214_ VSS VSS
+ VDD VDD net309 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[2\]$_DFF_P_ clknet_leaf_71_clk _00267_ VSS VSS
+ VDD VDD net310 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[30\]$_DFF_P_ clknet_leaf_67_clk _00215_ VSS VSS
+ VDD VDD net311 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[31\]$_DFF_P_ clknet_leaf_68_clk _00216_ VSS VSS
+ VDD VDD net312 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[32\]$_DFF_P_ clknet_leaf_3_clk _00217_ VSS VSS
+ VDD VDD net313 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[33\]$_DFF_P_ clknet_leaf_30_clk _00218_ VSS VSS
+ VDD VDD net314 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[34\]$_DFF_P_ clknet_leaf_29_clk _00219_ VSS VSS
+ VDD VDD net315 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[35\]$_DFF_P_ clknet_leaf_21_clk _00220_ VSS VSS
+ VDD VDD net316 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[36\]$_DFF_P_ clknet_leaf_3_clk _00221_ VSS VSS
+ VDD VDD net317 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[37\]$_DFF_P_ clknet_leaf_26_clk _00222_ VSS VSS
+ VDD VDD net318 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[38\]$_DFF_P_ clknet_leaf_28_clk _00223_ VSS VSS
+ VDD VDD net319 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[39\]$_DFF_P_ clknet_leaf_29_clk _00224_ VSS VSS
+ VDD VDD net320 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[3\]$_DFF_P_ clknet_leaf_3_clk _00268_ VSS VSS VDD
+ VDD net321 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[40\]$_DFF_P_ clknet_leaf_28_clk _00225_ VSS VSS
+ VDD VDD net322 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[41\]$_DFF_P_ clknet_leaf_21_clk _00226_ VSS VSS
+ VDD VDD net323 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[42\]$_DFF_P_ clknet_leaf_24_clk _00227_ VSS VSS
+ VDD VDD net324 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[43\]$_DFF_P_ clknet_leaf_37_clk _00228_ VSS VSS
+ VDD VDD net325 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[44\]$_DFF_P_ clknet_leaf_37_clk _00229_ VSS VSS
+ VDD VDD net326 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[45\]$_DFF_P_ clknet_leaf_37_clk _00230_ VSS VSS
+ VDD VDD net327 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[46\]$_DFF_P_ clknet_leaf_37_clk _00231_ VSS VSS
+ VDD VDD net328 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[47\]$_DFF_P_ clknet_leaf_37_clk _00232_ VSS VSS
+ VDD VDD net329 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[48\]$_DFF_P_ clknet_leaf_28_clk _00233_ VSS VSS
+ VDD VDD net330 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[49\]$_DFF_P_ clknet_leaf_27_clk _00234_ VSS VSS
+ VDD VDD net331 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[4\]$_DFF_P_ clknet_leaf_70_clk _00269_ VSS VSS
+ VDD VDD net332 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[50\]$_DFF_P_ clknet_leaf_22_clk _00235_ VSS VSS
+ VDD VDD net333 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[51\]$_DFF_P_ clknet_leaf_28_clk _00236_ VSS VSS
+ VDD VDD net334 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[52\]$_DFF_P_ clknet_leaf_15_clk _00237_ VSS VSS
+ VDD VDD net335 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[53\]$_DFF_P_ clknet_leaf_15_clk _00238_ VSS VSS
+ VDD VDD net336 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[54\]$_DFF_P_ clknet_leaf_16_clk _00239_ VSS VSS
+ VDD VDD net337 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[55\]$_DFF_P_ clknet_leaf_16_clk _00240_ VSS VSS
+ VDD VDD net338 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[56\]$_DFF_P_ clknet_leaf_25_clk _00241_ VSS VSS
+ VDD VDD net339 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[57\]$_DFF_P_ clknet_leaf_24_clk _00242_ VSS VSS
+ VDD VDD net340 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[58\]$_DFF_P_ clknet_leaf_22_clk _00243_ VSS VSS
+ VDD VDD net341 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[59\]$_DFF_P_ clknet_leaf_23_clk _00244_ VSS VSS
+ VDD VDD net342 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[5\]$_DFF_P_ clknet_leaf_2_clk _00270_ VSS VSS VDD
+ VDD net343 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[60\]$_DFF_P_ clknet_leaf_33_clk _00245_ VSS VSS
+ VDD VDD net344 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[61\]$_DFF_P_ clknet_leaf_32_clk _00246_ VSS VSS
+ VDD VDD net345 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[62\]$_DFF_P_ clknet_leaf_32_clk _00247_ VSS VSS
+ VDD VDD net346 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[63\]$_DFF_P_ clknet_leaf_27_clk _00248_ VSS VSS
+ VDD VDD net347 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[64\]$_DFF_P_ clknet_leaf_3_clk _00249_ VSS VSS
+ VDD VDD net348 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[65\]$_DFF_P_ clknet_leaf_31_clk _00250_ VSS VSS
+ VDD VDD net349 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[66\]$_DFF_P_ clknet_leaf_31_clk _00251_ VSS VSS
+ VDD VDD net350 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[67\]$_DFF_P_ clknet_leaf_21_clk _00252_ VSS VSS
+ VDD VDD net351 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[68\]$_DFF_P_ clknet_leaf_30_clk _00253_ VSS VSS
+ VDD VDD net352 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[69\]$_DFF_P_ clknet_leaf_30_clk _00254_ VSS VSS
+ VDD VDD net353 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[6\]$_DFF_P_ clknet_leaf_2_clk _00271_ VSS VSS VDD
+ VDD net354 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[70\]$_DFF_P_ clknet_leaf_29_clk _00255_ VSS VSS
+ VDD VDD net355 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[71\]$_DFF_P_ clknet_leaf_31_clk _00256_ VSS VSS
+ VDD VDD net356 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[72\]$_DFF_P_ clknet_leaf_40_clk _00257_ VSS VSS
+ VDD VDD net357 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[73\]$_DFF_P_ clknet_leaf_41_clk _00258_ VSS VSS
+ VDD VDD net358 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[74\]$_DFF_P_ clknet_leaf_43_clk _00259_ VSS VSS
+ VDD VDD net359 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[75\]$_DFF_P_ clknet_leaf_59_clk _00260_ VSS VSS
+ VDD VDD net360 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[76\]$_DFF_P_ clknet_leaf_60_clk _00261_ VSS VSS
+ VDD VDD net361 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[77\]$_DFF_P_ clknet_leaf_55_clk _00262_ VSS VSS
+ VDD VDD net362 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[78\]$_DFF_P_ clknet_leaf_59_clk _00263_ VSS VSS
+ VDD VDD net363 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[79\]$_DFF_P_ clknet_leaf_58_clk _00264_ VSS VSS
+ VDD VDD net364 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[7\]$_DFF_P_ clknet_leaf_71_clk _00272_ VSS VSS
+ VDD VDD net365 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[80\]$_DFF_P_ clknet_leaf_19_clk _00273_ VSS VSS
+ VDD VDD net366 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[81\]$_DFF_P_ clknet_leaf_47_clk _00274_ VSS VSS
+ VDD VDD net367 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[82\]$_DFF_P_ clknet_leaf_42_clk _00275_ VSS VSS
+ VDD VDD net368 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[83\]$_DFF_P_ clknet_leaf_46_clk _00276_ VSS VSS
+ VDD VDD net369 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[84\]$_DFF_P_ clknet_leaf_57_clk _00277_ VSS VSS
+ VDD VDD net370 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[85\]$_DFF_P_ clknet_leaf_46_clk _00278_ VSS VSS
+ VDD VDD net371 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[86\]$_DFF_P_ clknet_leaf_43_clk _00279_ VSS VSS
+ VDD VDD net372 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[87\]$_DFF_P_ clknet_leaf_47_clk _00280_ VSS VSS
+ VDD VDD net373 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[88\]$_DFF_P_ clknet_leaf_43_clk _00281_ VSS VSS
+ VDD VDD net374 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[89\]$_DFF_P_ clknet_leaf_41_clk _00282_ VSS VSS
+ VDD VDD net375 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[8\]$_DFF_P_ clknet_leaf_60_clk _00193_ VSS VSS
+ VDD VDD net376 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[90\]$_DFF_P_ clknet_leaf_41_clk _00283_ VSS VSS
+ VDD VDD net377 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[91\]$_DFF_P_ clknet_leaf_41_clk _00284_ VSS VSS
+ VDD VDD net378 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[92\]$_DFF_P_ clknet_leaf_43_clk _00285_ VSS VSS
+ VDD VDD net379 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[93\]$_DFF_P_ clknet_leaf_43_clk _00286_ VSS VSS
+ VDD VDD net380 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[94\]$_DFF_P_ clknet_leaf_41_clk _00287_ VSS VSS
+ VDD VDD net381 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[95\]$_DFF_P_ clknet_leaf_40_clk _00288_ VSS VSS
+ VDD VDD net382 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[96\]$_DFF_P_ clknet_leaf_24_clk _00161_ VSS VSS
+ VDD VDD net383 sky130_fd_sc_hd__dfxtp_2
Xtext_out\[97\]$_DFF_P_ clknet_leaf_20_clk _00162_ VSS VSS
+ VDD VDD net384 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[98\]$_DFF_P_ clknet_leaf_25_clk _00163_ VSS VSS
+ VDD VDD net385 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[99\]$_DFF_P_ clknet_leaf_29_clk _00164_ VSS VSS
+ VDD VDD net386 sky130_fd_sc_hd__dfxtp_1
Xtext_out\[9\]$_DFF_P_ clknet_leaf_59_clk _00194_ VSS VSS
+ VDD VDD net387 sky130_fd_sc_hd__dfxtp_1
Xu0.r0.out\[24\]$_SDFF_PP1_ clknet_leaf_9_clk _00409_ VSS
+ VSS VDD VDD u0.r0.out\[24\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.out\[25\]$_SDFF_PP0_ clknet_leaf_6_clk _00410_ VSS
+ VSS VDD VDD u0.r0.out\[25\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.out\[26\]$_SDFF_PP0_ clknet_leaf_5_clk _00411_ VSS
+ VSS VDD VDD u0.r0.out\[26\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.out\[27\]$_SDFF_PP0_ clknet_leaf_8_clk _00412_ VSS
+ VSS VDD VDD u0.r0.out\[27\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.out\[28\]$_SDFF_PP0_ clknet_leaf_9_clk _00413_ VSS
+ VSS VDD VDD u0.r0.out\[28\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.out\[29\]$_SDFF_PP0_ clknet_leaf_5_clk _00414_ VSS
+ VSS VDD VDD u0.r0.out\[29\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.out\[30\]$_SDFF_PP0_ clknet_leaf_8_clk _00415_ VSS
+ VSS VDD VDD u0.r0.out\[30\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.out\[31\]$_SDFF_PP0_ clknet_leaf_8_clk _00416_ VSS
+ VSS VDD VDD u0.r0.out\[31\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.rcnt\[0\]$_SDFF_PP0_ clknet_leaf_5_clk _00417_ VSS
+ VSS VDD VDD u0.r0.rcnt\[0\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.rcnt\[1\]$_SDFF_PP0_ clknet_leaf_5_clk _00418_ VSS
+ VSS VDD VDD u0.r0.rcnt\[1\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.rcnt\[2\]$_SDFF_PP0_ clknet_leaf_8_clk _00419_ VSS
+ VSS VDD VDD u0.r0.rcnt\[2\] sky130_fd_sc_hd__dfxtp_1
Xu0.r0.rcnt\[3\]$_SDFF_PP0_ clknet_leaf_5_clk _00420_ VSS
+ VSS VDD VDD u0.r0.rcnt\[3\] sky130_fd_sc_hd__dfxtp_1
Xu0.u0.d\[0\]$_DFF_P_ clknet_leaf_0_clk _00000_ VSS VSS VDD
+ VDD u0.subword\[24\] sky130_fd_sc_hd__dfxtp_1
Xu0.u0.d\[1\]$_DFF_P_ clknet_leaf_8_clk _00001_ VSS VSS VDD
+ VDD u0.subword\[25\] sky130_fd_sc_hd__dfxtp_1
Xu0.u0.d\[2\]$_DFF_P_ clknet_leaf_8_clk _00002_ VSS VSS VDD
+ VDD u0.subword\[26\] sky130_fd_sc_hd__dfxtp_1
Xu0.u0.d\[3\]$_DFF_P_ clknet_leaf_0_clk _00003_ VSS VSS VDD
+ VDD u0.subword\[27\] sky130_fd_sc_hd__dfxtp_1
Xu0.u0.d\[4\]$_DFF_P_ clknet_leaf_0_clk _00004_ VSS VSS VDD
+ VDD u0.subword\[28\] sky130_fd_sc_hd__dfxtp_1
Xu0.u0.d\[5\]$_DFF_P_ clknet_leaf_0_clk _00005_ VSS VSS VDD
+ VDD u0.subword\[29\] sky130_fd_sc_hd__dfxtp_1
Xu0.u0.d\[6\]$_DFF_P_ clknet_leaf_8_clk _00006_ VSS VSS VDD
+ VDD u0.subword\[30\] sky130_fd_sc_hd__dfxtp_1
Xu0.u0.d\[7\]$_DFF_P_ clknet_leaf_9_clk _00007_ VSS VSS VDD
+ VDD u0.subword\[31\] sky130_fd_sc_hd__dfxtp_1
Xu0.u1.d\[0\]$_DFF_P_ clknet_leaf_51_clk _00008_ VSS VSS VDD
+ VDD u0.subword\[16\] sky130_fd_sc_hd__dfxtp_1
Xu0.u1.d\[1\]$_DFF_P_ clknet_leaf_66_clk _00009_ VSS VSS VDD
+ VDD u0.subword\[17\] sky130_fd_sc_hd__dfxtp_4
Xu0.u1.d\[2\]$_DFF_P_ clknet_leaf_53_clk _00010_ VSS VSS VDD
+ VDD u0.subword\[18\] sky130_fd_sc_hd__dfxtp_1
Xu0.u1.d\[3\]$_DFF_P_ clknet_leaf_57_clk _00011_ VSS VSS VDD
+ VDD u0.subword\[19\] sky130_fd_sc_hd__dfxtp_1
Xu0.u1.d\[4\]$_DFF_P_ clknet_leaf_56_clk _00012_ VSS VSS VDD
+ VDD u0.subword\[20\] sky130_fd_sc_hd__dfxtp_1
Xu0.u1.d\[5\]$_DFF_P_ clknet_leaf_56_clk _00013_ VSS VSS VDD
+ VDD u0.subword\[21\] sky130_fd_sc_hd__dfxtp_1
Xu0.u1.d\[6\]$_DFF_P_ clknet_leaf_52_clk _00014_ VSS VSS VDD
+ VDD u0.subword\[22\] sky130_fd_sc_hd__dfxtp_2
Xu0.u1.d\[7\]$_DFF_P_ clknet_leaf_46_clk _00015_ VSS VSS VDD
+ VDD u0.subword\[23\] sky130_fd_sc_hd__dfxtp_1
Xu0.u2.d\[0\]$_DFF_P_ clknet_leaf_56_clk _00016_ VSS VSS VDD
+ VDD u0.subword\[8\] sky130_fd_sc_hd__dfxtp_2
Xu0.u2.d\[1\]$_DFF_P_ clknet_leaf_11_clk _00017_ VSS VSS VDD
+ VDD u0.subword\[9\] sky130_fd_sc_hd__dfxtp_1
Xu0.u2.d\[2\]$_DFF_P_ clknet_leaf_12_clk _00018_ VSS VSS VDD
+ VDD u0.subword\[10\] sky130_fd_sc_hd__dfxtp_1
Xu0.u2.d\[3\]$_DFF_P_ clknet_leaf_65_clk _00019_ VSS VSS VDD
+ VDD u0.subword\[11\] sky130_fd_sc_hd__dfxtp_2
Xu0.u2.d\[4\]$_DFF_P_ clknet_leaf_65_clk _00020_ VSS VSS VDD
+ VDD u0.subword\[12\] sky130_fd_sc_hd__dfxtp_2
Xu0.u2.d\[5\]$_DFF_P_ clknet_leaf_54_clk _00021_ VSS VSS VDD
+ VDD u0.subword\[13\] sky130_fd_sc_hd__dfxtp_1
Xu0.u2.d\[6\]$_DFF_P_ clknet_leaf_65_clk _00022_ VSS VSS VDD
+ VDD u0.subword\[14\] sky130_fd_sc_hd__dfxtp_2
Xu0.u2.d\[7\]$_DFF_P_ clknet_leaf_51_clk _00023_ VSS VSS VDD
+ VDD u0.subword\[15\] sky130_fd_sc_hd__dfxtp_2
Xu0.u3.d\[0\]$_DFF_P_ clknet_leaf_23_clk _00024_ VSS VSS VDD
+ VDD u0.subword\[0\] sky130_fd_sc_hd__dfxtp_1
Xu0.u3.d\[1\]$_DFF_P_ clknet_leaf_20_clk _00025_ VSS VSS VDD
+ VDD u0.subword\[1\] sky130_fd_sc_hd__dfxtp_1
Xu0.u3.d\[2\]$_DFF_P_ clknet_leaf_25_clk _00026_ VSS VSS VDD
+ VDD u0.subword\[2\] sky130_fd_sc_hd__dfxtp_1
Xu0.u3.d\[3\]$_DFF_P_ clknet_leaf_23_clk _00027_ VSS VSS VDD
+ VDD u0.subword\[3\] sky130_fd_sc_hd__dfxtp_1
Xu0.u3.d\[4\]$_DFF_P_ clknet_leaf_22_clk _00028_ VSS VSS VDD
+ VDD u0.subword\[4\] sky130_fd_sc_hd__dfxtp_1
Xu0.u3.d\[5\]$_DFF_P_ clknet_leaf_22_clk _00029_ VSS VSS VDD
+ VDD u0.subword\[5\] sky130_fd_sc_hd__dfxtp_1
Xu0.u3.d\[6\]$_DFF_P_ clknet_leaf_20_clk _00030_ VSS VSS VDD
+ VDD u0.subword\[6\] sky130_fd_sc_hd__dfxtp_1
Xu0.u3.d\[7\]$_DFF_P_ clknet_leaf_21_clk _00031_ VSS VSS VDD
+ VDD u0.subword\[7\] sky130_fd_sc_hd__dfxtp_1
Xu0.w\[0\]\[0\]$_DFF_P_ clknet_leaf_24_clk _00289_ VSS VSS
+ VDD VDD u0.w\[0\]\[0\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[10\]$_DFF_P_ clknet_leaf_12_clk _00290_ VSS VSS
+ VDD VDD u0.w\[0\]\[10\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[11\]$_DFF_P_ clknet_leaf_53_clk _00291_ VSS VSS
+ VDD VDD u0.w\[0\]\[11\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[12\]$_DFF_P_ clknet_leaf_54_clk _00292_ VSS VSS
+ VDD VDD u0.w\[0\]\[12\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[13\]$_DFF_P_ clknet_leaf_55_clk _00293_ VSS VSS
+ VDD VDD u0.w\[0\]\[13\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[14\]$_DFF_P_ clknet_leaf_53_clk _00294_ VSS VSS
+ VDD VDD u0.w\[0\]\[14\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[15\]$_DFF_P_ clknet_leaf_57_clk _00295_ VSS VSS
+ VDD VDD u0.w\[0\]\[15\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[16\]$_DFF_P_ clknet_leaf_14_clk _00296_ VSS VSS
+ VDD VDD u0.w\[0\]\[16\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[17\]$_DFF_P_ clknet_leaf_1_clk _00297_ VSS VSS
+ VDD VDD u0.w\[0\]\[17\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[18\]$_DFF_P_ clknet_leaf_66_clk _00298_ VSS VSS
+ VDD VDD u0.w\[0\]\[18\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[19\]$_DFF_P_ clknet_leaf_57_clk _00299_ VSS VSS
+ VDD VDD u0.w\[0\]\[19\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[1\]$_DFF_P_ clknet_leaf_21_clk _00300_ VSS VSS
+ VDD VDD u0.w\[0\]\[1\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[20\]$_DFF_P_ clknet_leaf_57_clk _00301_ VSS VSS
+ VDD VDD u0.w\[0\]\[20\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[21\]$_DFF_P_ clknet_leaf_56_clk _00302_ VSS VSS
+ VDD VDD u0.w\[0\]\[21\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[22\]$_DFF_P_ clknet_leaf_49_clk _00303_ VSS VSS
+ VDD VDD u0.w\[0\]\[22\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[23\]$_DFF_P_ clknet_leaf_46_clk _00304_ VSS VSS
+ VDD VDD u0.w\[0\]\[23\] sky130_fd_sc_hd__dfxtp_2
Xu0.w\[0\]\[24\]$_DFF_P_ clknet_leaf_9_clk _00305_ VSS VSS
+ VDD VDD u0.w\[0\]\[24\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[25\]$_DFF_P_ clknet_leaf_6_clk _00306_ VSS VSS
+ VDD VDD u0.w\[0\]\[25\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[26\]$_DFF_P_ clknet_leaf_6_clk _00307_ VSS VSS
+ VDD VDD u0.w\[0\]\[26\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[27\]$_DFF_P_ clknet_leaf_8_clk _00308_ VSS VSS
+ VDD VDD u0.w\[0\]\[27\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[28\]$_DFF_P_ clknet_leaf_9_clk _00309_ VSS VSS
+ VDD VDD u0.w\[0\]\[28\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[29\]$_DFF_P_ clknet_leaf_8_clk _00310_ VSS VSS
+ VDD VDD u0.w\[0\]\[29\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[2\]$_DFF_P_ clknet_leaf_25_clk _00311_ VSS VSS
+ VDD VDD u0.w\[0\]\[2\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[30\]$_DFF_P_ clknet_leaf_11_clk _00312_ VSS VSS
+ VDD VDD u0.w\[0\]\[30\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[31\]$_DFF_P_ clknet_leaf_56_clk _00313_ VSS VSS
+ VDD VDD u0.w\[0\]\[31\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[3\]$_DFF_P_ clknet_leaf_25_clk _00314_ VSS VSS
+ VDD VDD u0.w\[0\]\[3\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[4\]$_DFF_P_ clknet_leaf_23_clk _00315_ VSS VSS
+ VDD VDD u0.w\[0\]\[4\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[5\]$_DFF_P_ clknet_leaf_24_clk _00316_ VSS VSS
+ VDD VDD u0.w\[0\]\[5\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[6\]$_DFF_P_ clknet_leaf_25_clk _00317_ VSS VSS
+ VDD VDD u0.w\[0\]\[6\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[7\]$_DFF_P_ clknet_leaf_21_clk _00318_ VSS VSS
+ VDD VDD u0.w\[0\]\[7\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[8\]$_DFF_P_ clknet_leaf_45_clk _00319_ VSS VSS
+ VDD VDD u0.w\[0\]\[8\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[0\]\[9\]$_DFF_P_ clknet_leaf_14_clk _00320_ VSS VSS
+ VDD VDD u0.w\[0\]\[9\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[0\]$_DFF_P_ clknet_leaf_3_clk _00321_ VSS VSS
+ VDD VDD u0.w\[1\]\[0\] sky130_fd_sc_hd__dfxtp_2
Xu0.w\[1\]\[10\]$_DFF_P_ clknet_leaf_14_clk _00322_ VSS VSS
+ VDD VDD u0.w\[1\]\[10\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[11\]$_DFF_P_ clknet_leaf_56_clk _00323_ VSS VSS
+ VDD VDD u0.w\[1\]\[11\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[12\]$_DFF_P_ clknet_leaf_54_clk _00324_ VSS VSS
+ VDD VDD u0.w\[1\]\[12\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[13\]$_DFF_P_ clknet_leaf_55_clk _00325_ VSS VSS
+ VDD VDD u0.w\[1\]\[13\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[14\]$_DFF_P_ clknet_leaf_53_clk _00326_ VSS VSS
+ VDD VDD u0.w\[1\]\[14\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[15\]$_DFF_P_ clknet_leaf_55_clk _00327_ VSS VSS
+ VDD VDD u0.w\[1\]\[15\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[16\]$_DFF_P_ clknet_leaf_18_clk _00328_ VSS VSS
+ VDD VDD u0.w\[1\]\[16\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[17\]$_DFF_P_ clknet_leaf_9_clk _00329_ VSS VSS
+ VDD VDD u0.w\[1\]\[17\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[18\]$_DFF_P_ clknet_leaf_6_clk _00330_ VSS VSS
+ VDD VDD u0.w\[1\]\[18\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[19\]$_DFF_P_ clknet_leaf_57_clk _00331_ VSS VSS
+ VDD VDD u0.w\[1\]\[19\] sky130_fd_sc_hd__dfxtp_2
Xu0.w\[1\]\[1\]$_DFF_P_ clknet_leaf_20_clk _00332_ VSS VSS
+ VDD VDD u0.w\[1\]\[1\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[20\]$_DFF_P_ clknet_leaf_56_clk _00333_ VSS VSS
+ VDD VDD u0.w\[1\]\[20\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[21\]$_DFF_P_ clknet_leaf_56_clk _00334_ VSS VSS
+ VDD VDD u0.w\[1\]\[21\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[22\]$_DFF_P_ clknet_leaf_51_clk _00335_ VSS VSS
+ VDD VDD u0.w\[1\]\[22\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[23\]$_DFF_P_ clknet_leaf_46_clk _00336_ VSS VSS
+ VDD VDD u0.w\[1\]\[23\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[24\]$_DFF_P_ clknet_leaf_7_clk _00337_ VSS VSS
+ VDD VDD u0.w\[1\]\[24\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[25\]$_DFF_P_ clknet_leaf_4_clk _00338_ VSS VSS
+ VDD VDD u0.w\[1\]\[25\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[26\]$_DFF_P_ clknet_leaf_18_clk _00339_ VSS VSS
+ VDD VDD u0.w\[1\]\[26\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[27\]$_DFF_P_ clknet_leaf_6_clk _00340_ VSS VSS
+ VDD VDD u0.w\[1\]\[27\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[28\]$_DFF_P_ clknet_leaf_5_clk _00341_ VSS VSS
+ VDD VDD u0.w\[1\]\[28\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[29\]$_DFF_P_ clknet_leaf_6_clk _00342_ VSS VSS
+ VDD VDD u0.w\[1\]\[29\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[2\]$_DFF_P_ clknet_leaf_25_clk _00343_ VSS VSS
+ VDD VDD u0.w\[1\]\[2\] sky130_fd_sc_hd__dfxtp_2
Xu0.w\[1\]\[30\]$_DFF_P_ clknet_leaf_5_clk _00344_ VSS VSS
+ VDD VDD u0.w\[1\]\[30\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[31\]$_DFF_P_ clknet_leaf_55_clk _00345_ VSS VSS
+ VDD VDD u0.w\[1\]\[31\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[3\]$_DFF_P_ clknet_leaf_24_clk _00346_ VSS VSS
+ VDD VDD u0.w\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xu0.w\[1\]\[4\]$_DFF_P_ clknet_leaf_23_clk _00347_ VSS VSS
+ VDD VDD u0.w\[1\]\[4\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[5\]$_DFF_P_ clknet_leaf_25_clk _00348_ VSS VSS
+ VDD VDD u0.w\[1\]\[5\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[6\]$_DFF_P_ clknet_leaf_26_clk _00349_ VSS VSS
+ VDD VDD u0.w\[1\]\[6\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[7\]$_DFF_P_ clknet_leaf_21_clk _00350_ VSS VSS
+ VDD VDD u0.w\[1\]\[7\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[1\]\[8\]$_DFF_P_ clknet_leaf_44_clk _00351_ VSS VSS
+ VDD VDD u0.w\[1\]\[8\] sky130_fd_sc_hd__dfxtp_2
Xu0.w\[1\]\[9\]$_DFF_P_ clknet_leaf_14_clk _00352_ VSS VSS
+ VDD VDD u0.w\[1\]\[9\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[0\]$_DFF_P_ clknet_leaf_3_clk _00353_ VSS VSS
+ VDD VDD u0.w\[2\]\[0\] sky130_fd_sc_hd__dfxtp_2
Xu0.w\[2\]\[10\]$_DFF_P_ clknet_leaf_11_clk _00354_ VSS VSS
+ VDD VDD u0.w\[2\]\[10\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[11\]$_DFF_P_ clknet_leaf_53_clk _00355_ VSS VSS
+ VDD VDD u0.w\[2\]\[11\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[12\]$_DFF_P_ clknet_leaf_54_clk _00356_ VSS VSS
+ VDD VDD u0.w\[2\]\[12\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[13\]$_DFF_P_ clknet_leaf_54_clk _00357_ VSS VSS
+ VDD VDD u0.w\[2\]\[13\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[14\]$_DFF_P_ clknet_leaf_56_clk _00358_ VSS VSS
+ VDD VDD u0.w\[2\]\[14\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[15\]$_DFF_P_ clknet_leaf_57_clk _00359_ VSS VSS
+ VDD VDD u0.w\[2\]\[15\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[16\]$_DFF_P_ clknet_leaf_18_clk _00360_ VSS VSS
+ VDD VDD u0.w\[2\]\[16\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[17\]$_DFF_P_ clknet_leaf_9_clk _00361_ VSS VSS
+ VDD VDD u0.w\[2\]\[17\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[18\]$_DFF_P_ clknet_leaf_7_clk _00362_ VSS VSS
+ VDD VDD u0.w\[2\]\[18\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[19\]$_DFF_P_ clknet_leaf_7_clk _00363_ VSS VSS
+ VDD VDD u0.w\[2\]\[19\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[1\]$_DFF_P_ clknet_leaf_4_clk _00364_ VSS VSS
+ VDD VDD u0.w\[2\]\[1\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[20\]$_DFF_P_ clknet_leaf_66_clk _00365_ VSS VSS
+ VDD VDD u0.w\[2\]\[20\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[21\]$_DFF_P_ clknet_leaf_66_clk _00366_ VSS VSS
+ VDD VDD u0.w\[2\]\[21\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[22\]$_DFF_P_ clknet_leaf_8_clk _00367_ VSS VSS
+ VDD VDD u0.w\[2\]\[22\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[23\]$_DFF_P_ clknet_leaf_11_clk _00368_ VSS VSS
+ VDD VDD u0.w\[2\]\[23\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[24\]$_DFF_P_ clknet_leaf_5_clk _00369_ VSS VSS
+ VDD VDD u0.w\[2\]\[24\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[25\]$_DFF_P_ clknet_leaf_4_clk _00370_ VSS VSS
+ VDD VDD u0.w\[2\]\[25\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[26\]$_DFF_P_ clknet_leaf_18_clk _00371_ VSS VSS
+ VDD VDD u0.w\[2\]\[26\] sky130_fd_sc_hd__dfxtp_2
Xu0.w\[2\]\[27\]$_DFF_P_ clknet_leaf_6_clk _00372_ VSS VSS
+ VDD VDD u0.w\[2\]\[27\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[28\]$_DFF_P_ clknet_leaf_6_clk _00373_ VSS VSS
+ VDD VDD u0.w\[2\]\[28\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[29\]$_DFF_P_ clknet_leaf_27_clk _00374_ VSS VSS
+ VDD VDD u0.w\[2\]\[29\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[2\]$_DFF_P_ clknet_leaf_2_clk _00375_ VSS VSS
+ VDD VDD u0.w\[2\]\[2\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[30\]$_DFF_P_ clknet_leaf_5_clk _00376_ VSS VSS
+ VDD VDD u0.w\[2\]\[30\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[31\]$_DFF_P_ clknet_leaf_5_clk _00377_ VSS VSS
+ VDD VDD u0.w\[2\]\[31\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[3\]$_DFF_P_ clknet_leaf_3_clk _00378_ VSS VSS
+ VDD VDD u0.w\[2\]\[3\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[4\]$_DFF_P_ clknet_leaf_3_clk _00379_ VSS VSS
+ VDD VDD u0.w\[2\]\[4\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[5\]$_DFF_P_ clknet_leaf_24_clk _00380_ VSS VSS
+ VDD VDD u0.w\[2\]\[5\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[6\]$_DFF_P_ clknet_leaf_24_clk _00381_ VSS VSS
+ VDD VDD u0.w\[2\]\[6\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[7\]$_DFF_P_ clknet_leaf_4_clk _00382_ VSS VSS
+ VDD VDD u0.w\[2\]\[7\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[8\]$_DFF_P_ clknet_leaf_44_clk _00383_ VSS VSS
+ VDD VDD u0.w\[2\]\[8\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[2\]\[9\]$_DFF_P_ clknet_leaf_18_clk _00384_ VSS VSS
+ VDD VDD u0.w\[2\]\[9\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[0\]$_DFF_P_ clknet_leaf_3_clk _03624_ VSS VSS
+ VDD VDD u0.tmp_w\[0\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[10\]$_DFF_P_ clknet_leaf_53_clk _03704_ VSS VSS
+ VDD VDD u0.tmp_w\[10\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[11\]$_DFF_P_ clknet_leaf_54_clk _03715_ VSS VSS
+ VDD VDD u0.tmp_w\[11\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[12\]$_DFF_P_ clknet_leaf_54_clk _03725_ VSS VSS
+ VDD VDD u0.tmp_w\[12\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[13\]$_DFF_P_ clknet_leaf_54_clk _03735_ VSS VSS
+ VDD VDD u0.tmp_w\[13\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[14\]$_DFF_P_ clknet_leaf_54_clk _03744_ VSS VSS
+ VDD VDD u0.tmp_w\[14\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[15\]$_DFF_P_ clknet_leaf_53_clk _03751_ VSS VSS
+ VDD VDD u0.tmp_w\[15\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[16\]$_DFF_P_ clknet_leaf_7_clk net708 VSS VSS
+ VDD VDD u0.tmp_w\[16\] sky130_fd_sc_hd__dfxtp_2
Xu0.w\[3\]\[17\]$_DFF_P_ clknet_leaf_1_clk _03592_ VSS VSS
+ VDD VDD u0.tmp_w\[17\] sky130_fd_sc_hd__dfxtp_2
Xu0.w\[3\]\[18\]$_DFF_P_ clknet_leaf_10_clk _03618_ VSS VSS
+ VDD VDD u0.tmp_w\[18\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[19\]$_DFF_P_ clknet_leaf_10_clk _03579_ VSS VSS
+ VDD VDD u0.tmp_w\[19\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[1\]$_DFF_P_ clknet_leaf_0_clk _03630_ VSS VSS
+ VDD VDD u0.tmp_w\[1\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[20\]$_DFF_P_ clknet_leaf_10_clk _03611_ VSS VSS
+ VDD VDD u0.tmp_w\[20\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[21\]$_DFF_P_ clknet_leaf_68_clk _03602_ VSS VSS
+ VDD VDD u0.tmp_w\[21\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[22\]$_DFF_P_ clknet_leaf_10_clk _03759_ VSS VSS
+ VDD VDD u0.tmp_w\[22\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[23\]$_DFF_P_ clknet_leaf_10_clk _03767_ VSS VSS
+ VDD VDD u0.tmp_w\[23\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[24\]$_DFF_P_ clknet_leaf_9_clk _03772_ VSS VSS
+ VDD VDD u0.tmp_w\[24\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[25\]$_DFF_P_ clknet_leaf_4_clk _03777_ VSS VSS
+ VDD VDD u0.tmp_w\[25\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[26\]$_DFF_P_ clknet_leaf_7_clk _03783_ VSS VSS
+ VDD VDD u0.tmp_w\[26\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[27\]$_DFF_P_ clknet_leaf_6_clk _03792_ VSS VSS
+ VDD VDD u0.tmp_w\[27\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[28\]$_DFF_P_ clknet_leaf_6_clk _03801_ VSS VSS
+ VDD VDD u0.tmp_w\[28\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[29\]$_DFF_P_ clknet_leaf_19_clk _03810_ VSS VSS
+ VDD VDD u0.tmp_w\[29\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[2\]$_DFF_P_ clknet_leaf_0_clk _03639_ VSS VSS
+ VDD VDD u0.tmp_w\[2\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[30\]$_DFF_P_ clknet_leaf_4_clk _00398_ VSS VSS
+ VDD VDD u0.tmp_w\[30\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[31\]$_DFF_P_ clknet_leaf_5_clk _03824_ VSS VSS
+ VDD VDD u0.tmp_w\[31\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[3\]$_DFF_P_ clknet_leaf_9_clk _03648_ VSS VSS
+ VDD VDD u0.tmp_w\[3\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[4\]$_DFF_P_ clknet_leaf_8_clk _03658_ VSS VSS
+ VDD VDD u0.tmp_w\[4\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[5\]$_DFF_P_ clknet_leaf_10_clk _03667_ VSS VSS
+ VDD VDD u0.tmp_w\[5\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[6\]$_DFF_P_ clknet_leaf_11_clk _03676_ VSS VSS
+ VDD VDD u0.tmp_w\[6\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[7\]$_DFF_P_ clknet_leaf_68_clk _03685_ VSS VSS
+ VDD VDD u0.tmp_w\[7\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[8\]$_DFF_P_ clknet_leaf_62_clk _03690_ VSS VSS
+ VDD VDD u0.tmp_w\[8\] sky130_fd_sc_hd__dfxtp_4
Xu0.w\[3\]\[9\]$_DFF_P_ clknet_leaf_14_clk _11860_ VSS VSS
+ VDD VDD u0.tmp_w\[9\] sky130_fd_sc_hd__dfxtp_4
XTAP_TAPCELL_ROW_58_1404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1873 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1874 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1875 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1876 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1877 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1878 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1879 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1880 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1881 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1882 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1883 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1884 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1885 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1886 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1887 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1888 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1889 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1890 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1891 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1892 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1893 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1894 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1895 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1896 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1897 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1898 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1899 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1900 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1901 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1902 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1903 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1904 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1905 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1906 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1907 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1908 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1909 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1910 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1911 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1912 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1913 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1914 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1915 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1916 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1917 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1918 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1919 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1920 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1921 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1922 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1923 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1924 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1925 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1926 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1927 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1928 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1929 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1930 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1931 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1932 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1933 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1934 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1935 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1936 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1937 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1938 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1939 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1940 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1941 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1942 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1943 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1944 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1945 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1946 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1947 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1948 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1949 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1950 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1951 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1952 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1953 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1954 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1955 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1956 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1957 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1958 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1959 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1960 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1961 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1962 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1963 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1964 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1965 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1966 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1967 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1968 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1969 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1970 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1971 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1972 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1973 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1974 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1975 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1976 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1977 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1978 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1979 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1980 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1981 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1982 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1983 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1984 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1985 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1986 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1987 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1988 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1989 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1990 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1991 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1992 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1993 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1994 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1995 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1996 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1997 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1998 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1999 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2000 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2001 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2002 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2003 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2004 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2005 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2006 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2007 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2008 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2009 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2010 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2011 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2012 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2013 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2014 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2015 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2016 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2017 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2018 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2019 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2020 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2021 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2022 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2023 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2024 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2025 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2026 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2027 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2028 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2029 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2030 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2031 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2032 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2033 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2034 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2035 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2036 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2037 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2038 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2039 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2040 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2041 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2042 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2043 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2044 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2045 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2046 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2047 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2048 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2049 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2050 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2051 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2052 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2053 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2054 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2055 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2056 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2057 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2058 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2059 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2060 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2061 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2062 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2063 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2064 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2065 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2066 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2067 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2068 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2069 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2070 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2071 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2072 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2073 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2074 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2075 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2076 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2077 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2078 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2079 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2080 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2081 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2082 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2083 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2084 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2085 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2086 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2087 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2088 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2089 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2090 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2091 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2092 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2093 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2094 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2095 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2096 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2097 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2098 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2099 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_2372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2873 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2874 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2875 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2876 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2877 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2878 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2879 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2880 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2881 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2882 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2883 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2884 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2885 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2886 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2887 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2888 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2889 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2890 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2891 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2892 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2893 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2894 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2895 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2896 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2897 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2898 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2899 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2900 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2901 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2902 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2903 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2904 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2905 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2906 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2907 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2908 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2909 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2910 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2911 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2912 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2913 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2914 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2915 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2916 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2917 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2918 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2919 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2920 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2921 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2922 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2923 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2924 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2925 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2926 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2927 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2928 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2929 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2930 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2931 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2932 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2933 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2934 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2935 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2936 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2937 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2938 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2939 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2940 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2941 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2942 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2943 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2944 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2945 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2946 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2947 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2948 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2949 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2950 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2951 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2952 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2953 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2954 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2955 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2956 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2957 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2958 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2959 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2960 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2961 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2962 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2963 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2964 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2965 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2966 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2967 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2968 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2969 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2970 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2971 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2972 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2973 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2974 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2975 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2976 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2977 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2978 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2979 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2980 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2981 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2982 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2983 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2984 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2985 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2986 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2987 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2988 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2989 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2990 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2991 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2992 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2993 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2994 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2995 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2996 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2997 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2998 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2999 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_3000 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_3001 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_3002 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_3003 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_3004 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_3005 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_3006 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_3007 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3008 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3009 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3010 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3011 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3012 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3013 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3014 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3015 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3016 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3017 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3018 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3019 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3020 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3021 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3022 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3023 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3024 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3025 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3026 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3027 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3028 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3029 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_3030 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3031 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3032 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3033 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3034 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3035 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3036 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3037 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3038 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3039 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3040 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3041 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3042 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3043 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3044 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3045 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3046 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3047 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3048 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3049 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3050 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3051 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3052 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3053 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_3054 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3055 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3056 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3057 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3058 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3059 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3060 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3061 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3062 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3063 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3064 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3065 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3066 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3067 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3068 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3069 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3070 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3071 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3072 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3073 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3074 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3075 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3076 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_3077 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3078 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3079 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3080 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3081 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3082 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3083 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3084 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3085 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3086 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3087 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3088 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3089 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3090 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3091 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3092 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3093 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3094 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3095 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3096 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3097 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3098 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3099 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_3289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3873 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3874 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3875 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3876 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3877 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3878 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3879 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3880 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3881 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3882 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3883 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3884 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3885 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3886 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3887 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3888 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3889 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3890 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3891 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3892 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3893 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3894 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3895 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3896 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3897 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3898 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3899 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3900 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3901 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3902 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3903 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3904 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3905 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3906 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3907 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3908 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3909 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3910 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3911 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3912 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3913 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3914 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3915 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3916 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3917 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3918 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3919 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3920 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3921 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3922 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3923 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3924 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3925 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3926 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3927 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3928 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3929 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3930 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3931 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3932 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3933 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3934 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3935 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3936 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3937 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3938 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3939 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3940 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3941 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3942 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3943 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3944 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3945 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3946 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3947 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3948 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3949 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3950 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3951 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3952 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3953 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3954 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3955 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3956 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3957 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3958 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3959 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3960 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3961 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3962 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3963 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3964 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3965 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3966 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3967 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3968 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3969 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3970 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3971 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3972 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3973 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3974 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3975 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3976 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3977 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3978 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3979 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3980 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3981 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3982 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3983 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3984 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3985 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3986 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3987 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3988 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3989 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3990 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3991 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3992 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3993 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3994 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_3995 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_3996 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_3997 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_3998 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_3999 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4000 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4001 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4002 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4003 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4004 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4005 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4006 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4007 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4008 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4009 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4010 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4011 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4012 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4013 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4014 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4015 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4016 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_4017 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4018 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4019 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4020 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4021 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4022 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4023 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4024 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4025 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4026 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4027 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4028 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4029 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4030 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4031 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4032 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4033 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4034 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4035 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4036 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4037 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4038 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4039 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4040 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_4041 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4042 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4043 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4044 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4045 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4046 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4047 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4048 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4049 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4050 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4051 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4052 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4053 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4054 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4055 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4056 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4057 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4058 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4059 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4060 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4061 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4062 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4063 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_4064 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4065 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4066 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4067 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4068 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4069 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4070 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4071 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4072 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4073 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4074 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4075 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4076 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4077 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4078 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4079 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4080 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4081 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4082 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4083 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4084 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4085 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4086 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4087 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_4088 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4089 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4090 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4091 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4092 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4093 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4094 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4095 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4096 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4097 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4098 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4099 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_4111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_174_4135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_4158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_4182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_4205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_4229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_4252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_190_4511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_191_4534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_192_4558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_193_4581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_194_4605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_195_4628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_196_4652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_197_4675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_198_4699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_199_4722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_200_4746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_201_4769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_202_4793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_203_4816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_204_4840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_205_4863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4873 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4874 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4875 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4876 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4877 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4878 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4879 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4880 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4881 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4882 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4883 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4884 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4885 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4886 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_206_4887 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4888 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4889 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4890 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4891 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4892 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4893 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4894 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4895 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4896 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4897 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4898 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4899 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4900 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4901 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4902 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4903 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4904 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4905 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4906 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4907 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4908 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4909 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_207_4910 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4911 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4912 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4913 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4914 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4915 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4916 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4917 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4918 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4919 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4920 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4921 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4922 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4923 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4924 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4925 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4926 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4927 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4928 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4929 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4930 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4931 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4932 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4933 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_208_4934 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4935 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4936 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4937 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4938 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4939 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4940 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4941 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4942 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4943 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4944 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4945 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4946 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4947 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4948 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4949 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4950 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4951 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4952 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4953 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4954 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4955 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4956 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_209_4957 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4958 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4959 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4960 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4961 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4962 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4963 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4964 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4965 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4966 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4967 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4968 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4969 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4970 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4971 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4972 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4973 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4974 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4975 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4976 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4977 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4978 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4979 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4980 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_210_4981 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4982 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4983 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4984 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4985 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4986 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4987 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4988 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4989 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4990 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4991 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4992 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4993 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4994 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4995 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4996 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4997 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4998 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_4999 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_5000 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_5001 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_5002 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_5003 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_211_5004 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5005 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5006 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5007 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5008 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5009 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5010 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5011 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5012 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5013 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5014 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5015 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5016 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5017 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5018 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5019 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5020 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5021 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5022 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5023 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5024 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5025 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5026 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5027 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_212_5028 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5029 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5030 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5031 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5032 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5033 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5034 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5035 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5036 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5037 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5038 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5039 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5040 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5041 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5042 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5043 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5044 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5045 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5046 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5047 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5048 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5049 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5050 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_213_5051 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5052 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5053 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5054 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5055 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5056 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5057 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5058 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5059 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5060 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5061 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5062 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5063 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5064 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5065 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5066 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5067 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5068 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5069 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5070 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5071 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5072 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5073 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5074 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_214_5075 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5076 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5077 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5078 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5079 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5080 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5081 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5082 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5083 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5084 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5085 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5086 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5087 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5088 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5089 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5090 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5091 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5092 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5093 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5094 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5095 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5096 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5097 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_215_5098 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5099 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_216_5122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_217_5145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_218_5169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_219_5192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_220_5216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_221_5239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_222_5263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_223_5286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_224_5310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_225_5333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_226_5357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_227_5380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_228_5404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_229_5427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_230_5451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_231_5474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_232_5498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_233_5521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_234_5545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_235_5568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_236_5592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_237_5615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_238_5639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_239_5662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_240_5709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 key[0] VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_1
Xinput2 key[100] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput3 key[101] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput4 key[102] VSS VSS VDD VDD net4 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput5 key[103] VSS VSS VDD VDD net5 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput6 key[104] VSS VSS VDD VDD net6 sky130_fd_sc_hd__buf_2
Xinput7 key[105] VSS VSS VDD VDD net7 sky130_fd_sc_hd__buf_2
Xinput8 key[106] VSS VSS VDD VDD net8 sky130_fd_sc_hd__buf_2
Xinput9 key[107] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_4
Xinput10 key[108] VSS VSS VDD VDD net10 sky130_fd_sc_hd__buf_2
Xinput11 key[109] VSS VSS VDD VDD net11 sky130_fd_sc_hd__buf_2
Xinput12 key[10] VSS VSS VDD VDD net12 sky130_fd_sc_hd__buf_2
Xinput13 key[110] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_2
Xinput14 key[111] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_2
Xinput15 key[112] VSS VSS VDD VDD net15 sky130_fd_sc_hd__buf_2
Xinput16 key[113] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_2
Xinput17 key[114] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_8
Xinput18 key[115] VSS VSS VDD VDD net18 sky130_fd_sc_hd__buf_2
Xinput19 key[116] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_2
Xinput20 key[117] VSS VSS VDD VDD net20 sky130_fd_sc_hd__buf_2
Xinput21 key[118] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_4
Xinput22 key[119] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_2
Xinput23 key[11] VSS VSS VDD VDD net23 sky130_fd_sc_hd__buf_2
Xinput24 key[120] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
Xinput25 key[121] VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_1
Xinput26 key[122] VSS VSS VDD VDD net26 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput27 key[123] VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_1
Xinput28 key[124] VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_1
Xinput29 key[125] VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_1
Xinput30 key[126] VSS VSS VDD VDD net30 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput31 key[127] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_2
Xinput32 key[12] VSS VSS VDD VDD net32 sky130_fd_sc_hd__buf_2
Xinput33 key[13] VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_2
Xinput34 key[14] VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_4
Xinput35 key[15] VSS VSS VDD VDD net35 sky130_fd_sc_hd__buf_2
Xinput36 key[16] VSS VSS VDD VDD net36 sky130_fd_sc_hd__clkbuf_1
Xinput37 key[17] VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_2
Xinput38 key[18] VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkbuf_2
Xinput39 key[19] VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_1
Xinput40 key[1] VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_1
Xinput41 key[20] VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_1
Xinput42 key[21] VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_4
Xinput43 key[22] VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_1
Xinput44 key[23] VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_4
Xinput45 key[24] VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_2
Xinput46 key[25] VSS VSS VDD VDD net46 sky130_fd_sc_hd__clkbuf_4
Xinput47 key[26] VSS VSS VDD VDD net47 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput48 key[27] VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkbuf_2
Xinput49 key[28] VSS VSS VDD VDD net49 sky130_fd_sc_hd__buf_2
Xinput50 key[29] VSS VSS VDD VDD net50 sky130_fd_sc_hd__clkbuf_2
Xinput51 key[2] VSS VSS VDD VDD net51 sky130_fd_sc_hd__clkbuf_1
Xinput52 key[30] VSS VSS VDD VDD net52 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput53 key[31] VSS VSS VDD VDD net53 sky130_fd_sc_hd__clkbuf_1
Xinput54 key[32] VSS VSS VDD VDD net54 sky130_fd_sc_hd__clkbuf_1
Xinput55 key[33] VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkbuf_1
Xinput56 key[34] VSS VSS VDD VDD net56 sky130_fd_sc_hd__clkbuf_1
Xinput57 key[35] VSS VSS VDD VDD net57 sky130_fd_sc_hd__clkbuf_1
Xinput58 key[36] VSS VSS VDD VDD net58 sky130_fd_sc_hd__clkbuf_1
Xinput59 key[37] VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_1
Xinput60 key[38] VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkbuf_1
Xinput61 key[39] VSS VSS VDD VDD net61 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput62 key[3] VSS VSS VDD VDD net62 sky130_fd_sc_hd__clkbuf_1
Xinput63 key[40] VSS VSS VDD VDD net63 sky130_fd_sc_hd__clkbuf_2
Xinput64 key[41] VSS VSS VDD VDD net64 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput65 key[42] VSS VSS VDD VDD net65 sky130_fd_sc_hd__buf_2
Xinput66 key[43] VSS VSS VDD VDD net66 sky130_fd_sc_hd__buf_2
Xinput67 key[44] VSS VSS VDD VDD net67 sky130_fd_sc_hd__clkbuf_2
Xinput68 key[45] VSS VSS VDD VDD net68 sky130_fd_sc_hd__buf_2
Xinput69 key[46] VSS VSS VDD VDD net69 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput70 key[47] VSS VSS VDD VDD net70 sky130_fd_sc_hd__clkbuf_2
Xinput71 key[48] VSS VSS VDD VDD net71 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput72 key[49] VSS VSS VDD VDD net72 sky130_fd_sc_hd__clkbuf_2
Xinput73 key[4] VSS VSS VDD VDD net73 sky130_fd_sc_hd__clkbuf_1
Xinput74 key[50] VSS VSS VDD VDD net74 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput75 key[51] VSS VSS VDD VDD net75 sky130_fd_sc_hd__clkbuf_2
Xinput76 key[52] VSS VSS VDD VDD net76 sky130_fd_sc_hd__buf_4
Xinput77 key[53] VSS VSS VDD VDD net77 sky130_fd_sc_hd__buf_4
Xinput78 key[54] VSS VSS VDD VDD net78 sky130_fd_sc_hd__buf_2
Xinput79 key[55] VSS VSS VDD VDD net79 sky130_fd_sc_hd__clkbuf_4
Xinput80 key[56] VSS VSS VDD VDD net80 sky130_fd_sc_hd__clkbuf_1
Xinput81 key[57] VSS VSS VDD VDD net81 sky130_fd_sc_hd__clkbuf_1
Xinput82 key[58] VSS VSS VDD VDD net82 sky130_fd_sc_hd__clkbuf_1
Xinput83 key[59] VSS VSS VDD VDD net83 sky130_fd_sc_hd__clkbuf_2
Xinput84 key[5] VSS VSS VDD VDD net84 sky130_fd_sc_hd__clkbuf_1
Xinput85 key[60] VSS VSS VDD VDD net85 sky130_fd_sc_hd__clkbuf_1
Xinput86 key[61] VSS VSS VDD VDD net86 sky130_fd_sc_hd__clkbuf_2
Xinput87 key[62] VSS VSS VDD VDD net87 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput88 key[63] VSS VSS VDD VDD net88 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput89 key[64] VSS VSS VDD VDD net89 sky130_fd_sc_hd__clkbuf_1
Xinput90 key[65] VSS VSS VDD VDD net90 sky130_fd_sc_hd__clkbuf_1
Xinput91 key[66] VSS VSS VDD VDD net91 sky130_fd_sc_hd__clkbuf_1
Xinput92 key[67] VSS VSS VDD VDD net92 sky130_fd_sc_hd__clkbuf_1
Xinput93 key[68] VSS VSS VDD VDD net93 sky130_fd_sc_hd__clkbuf_2
Xinput94 key[69] VSS VSS VDD VDD net94 sky130_fd_sc_hd__clkbuf_2
Xinput95 key[6] VSS VSS VDD VDD net95 sky130_fd_sc_hd__clkbuf_1
Xinput96 key[70] VSS VSS VDD VDD net96 sky130_fd_sc_hd__clkbuf_1
Xinput97 key[71] VSS VSS VDD VDD net97 sky130_fd_sc_hd__clkbuf_1
Xinput98 key[72] VSS VSS VDD VDD net98 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput99 key[73] VSS VSS VDD VDD net99 sky130_fd_sc_hd__buf_2
Xinput100 key[74] VSS VSS VDD VDD net100 sky130_fd_sc_hd__buf_2
Xinput101 key[75] VSS VSS VDD VDD net101 sky130_fd_sc_hd__clkbuf_2
Xinput102 key[76] VSS VSS VDD VDD net102 sky130_fd_sc_hd__clkbuf_1
Xinput103 key[77] VSS VSS VDD VDD net103 sky130_fd_sc_hd__clkbuf_1
Xinput104 key[78] VSS VSS VDD VDD net104 sky130_fd_sc_hd__clkbuf_1
Xinput105 key[79] VSS VSS VDD VDD net105 sky130_fd_sc_hd__clkbuf_2
Xinput106 key[7] VSS VSS VDD VDD net106 sky130_fd_sc_hd__clkbuf_4
Xinput107 key[80] VSS VSS VDD VDD net107 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput108 key[81] VSS VSS VDD VDD net108 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput109 key[82] VSS VSS VDD VDD net109 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput110 key[83] VSS VSS VDD VDD net110 sky130_fd_sc_hd__clkbuf_2
Xinput111 key[84] VSS VSS VDD VDD net111 sky130_fd_sc_hd__clkbuf_2
Xinput112 key[85] VSS VSS VDD VDD net112 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput113 key[86] VSS VSS VDD VDD net113 sky130_fd_sc_hd__buf_6
Xinput114 key[87] VSS VSS VDD VDD net114 sky130_fd_sc_hd__clkbuf_2
Xinput115 key[88] VSS VSS VDD VDD net115 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput116 key[89] VSS VSS VDD VDD net116 sky130_fd_sc_hd__clkbuf_4
Xinput117 key[8] VSS VSS VDD VDD net117 sky130_fd_sc_hd__clkbuf_1
Xinput118 key[90] VSS VSS VDD VDD net118 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput119 key[91] VSS VSS VDD VDD net119 sky130_fd_sc_hd__buf_2
Xinput120 key[92] VSS VSS VDD VDD net120 sky130_fd_sc_hd__clkbuf_4
Xinput121 key[93] VSS VSS VDD VDD net121 sky130_fd_sc_hd__buf_2
Xinput122 key[94] VSS VSS VDD VDD net122 sky130_fd_sc_hd__buf_2
Xinput123 key[95] VSS VSS VDD VDD net123 sky130_fd_sc_hd__clkbuf_4
Xinput124 key[96] VSS VSS VDD VDD net124 sky130_fd_sc_hd__buf_2
Xinput125 key[97] VSS VSS VDD VDD net125 sky130_fd_sc_hd__buf_2
Xinput126 key[98] VSS VSS VDD VDD net126 sky130_fd_sc_hd__clkbuf_2
Xinput127 key[99] VSS VSS VDD VDD net127 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput128 key[9] VSS VSS VDD VDD net128 sky130_fd_sc_hd__clkbuf_1
Xinput129 ld VSS VSS VDD VDD net129 sky130_fd_sc_hd__buf_8
Xinput130 rst VSS VSS VDD VDD net130 sky130_fd_sc_hd__clkbuf_2
Xinput131 text_in[0] VSS VSS VDD VDD net131 sky130_fd_sc_hd__clkbuf_1
Xinput132 text_in[100] VSS VSS VDD VDD net132 sky130_fd_sc_hd__clkbuf_1
Xinput133 text_in[101] VSS VSS VDD VDD net133 sky130_fd_sc_hd__clkbuf_1
Xinput134 text_in[102] VSS VSS VDD VDD net134 sky130_fd_sc_hd__clkbuf_1
Xinput135 text_in[103] VSS VSS VDD VDD net135 sky130_fd_sc_hd__clkbuf_1
Xinput136 text_in[104] VSS VSS VDD VDD net136 sky130_fd_sc_hd__clkbuf_2
Xinput137 text_in[105] VSS VSS VDD VDD net137 sky130_fd_sc_hd__clkbuf_4
Xinput138 text_in[106] VSS VSS VDD VDD net138 sky130_fd_sc_hd__clkbuf_1
Xinput139 text_in[107] VSS VSS VDD VDD net139 sky130_fd_sc_hd__clkbuf_1
Xinput140 text_in[108] VSS VSS VDD VDD net140 sky130_fd_sc_hd__clkbuf_1
Xinput141 text_in[109] VSS VSS VDD VDD net141 sky130_fd_sc_hd__clkbuf_1
Xinput142 text_in[10] VSS VSS VDD VDD net142 sky130_fd_sc_hd__clkbuf_1
Xinput143 text_in[110] VSS VSS VDD VDD net143 sky130_fd_sc_hd__clkbuf_1
Xinput144 text_in[111] VSS VSS VDD VDD net144 sky130_fd_sc_hd__clkbuf_1
Xinput145 text_in[112] VSS VSS VDD VDD net145 sky130_fd_sc_hd__clkbuf_4
Xinput146 text_in[113] VSS VSS VDD VDD net146 sky130_fd_sc_hd__buf_2
Xinput147 text_in[114] VSS VSS VDD VDD net147 sky130_fd_sc_hd__clkbuf_1
Xinput148 text_in[115] VSS VSS VDD VDD net148 sky130_fd_sc_hd__clkbuf_1
Xinput149 text_in[116] VSS VSS VDD VDD net149 sky130_fd_sc_hd__clkbuf_1
Xinput150 text_in[117] VSS VSS VDD VDD net150 sky130_fd_sc_hd__clkbuf_1
Xinput151 text_in[118] VSS VSS VDD VDD net151 sky130_fd_sc_hd__clkbuf_1
Xinput152 text_in[119] VSS VSS VDD VDD net152 sky130_fd_sc_hd__clkbuf_1
Xinput153 text_in[11] VSS VSS VDD VDD net153 sky130_fd_sc_hd__clkbuf_1
Xinput154 text_in[120] VSS VSS VDD VDD net154 sky130_fd_sc_hd__clkbuf_1
Xinput155 text_in[121] VSS VSS VDD VDD net155 sky130_fd_sc_hd__clkbuf_1
Xinput156 text_in[122] VSS VSS VDD VDD net156 sky130_fd_sc_hd__clkbuf_1
Xinput157 text_in[123] VSS VSS VDD VDD net157 sky130_fd_sc_hd__clkbuf_1
Xinput158 text_in[124] VSS VSS VDD VDD net158 sky130_fd_sc_hd__clkbuf_1
Xinput159 text_in[125] VSS VSS VDD VDD net159 sky130_fd_sc_hd__clkbuf_1
Xinput160 text_in[126] VSS VSS VDD VDD net160 sky130_fd_sc_hd__clkbuf_1
Xinput161 text_in[127] VSS VSS VDD VDD net161 sky130_fd_sc_hd__clkbuf_4
Xinput162 text_in[12] VSS VSS VDD VDD net162 sky130_fd_sc_hd__clkbuf_1
Xinput163 text_in[13] VSS VSS VDD VDD net163 sky130_fd_sc_hd__clkbuf_1
Xinput164 text_in[14] VSS VSS VDD VDD net164 sky130_fd_sc_hd__clkbuf_1
Xinput165 text_in[15] VSS VSS VDD VDD net165 sky130_fd_sc_hd__clkbuf_1
Xinput166 text_in[16] VSS VSS VDD VDD net166 sky130_fd_sc_hd__clkbuf_1
Xinput167 text_in[17] VSS VSS VDD VDD net167 sky130_fd_sc_hd__clkbuf_1
Xinput168 text_in[18] VSS VSS VDD VDD net168 sky130_fd_sc_hd__clkbuf_1
Xinput169 text_in[19] VSS VSS VDD VDD net169 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput170 text_in[1] VSS VSS VDD VDD net170 sky130_fd_sc_hd__clkbuf_1
Xinput171 text_in[20] VSS VSS VDD VDD net171 sky130_fd_sc_hd__clkbuf_1
Xinput172 text_in[21] VSS VSS VDD VDD net172 sky130_fd_sc_hd__clkbuf_1
Xinput173 text_in[22] VSS VSS VDD VDD net173 sky130_fd_sc_hd__clkbuf_1
Xinput174 text_in[23] VSS VSS VDD VDD net174 sky130_fd_sc_hd__clkbuf_1
Xinput175 text_in[24] VSS VSS VDD VDD net175 sky130_fd_sc_hd__clkbuf_1
Xinput176 text_in[25] VSS VSS VDD VDD net176 sky130_fd_sc_hd__clkbuf_1
Xinput177 text_in[26] VSS VSS VDD VDD net177 sky130_fd_sc_hd__clkbuf_1
Xinput178 text_in[27] VSS VSS VDD VDD net178 sky130_fd_sc_hd__clkbuf_1
Xinput179 text_in[28] VSS VSS VDD VDD net179 sky130_fd_sc_hd__clkbuf_1
Xinput180 text_in[29] VSS VSS VDD VDD net180 sky130_fd_sc_hd__clkbuf_1
Xinput181 text_in[2] VSS VSS VDD VDD net181 sky130_fd_sc_hd__clkbuf_1
Xinput182 text_in[30] VSS VSS VDD VDD net182 sky130_fd_sc_hd__clkbuf_1
Xinput183 text_in[31] VSS VSS VDD VDD net183 sky130_fd_sc_hd__clkbuf_1
Xinput184 text_in[32] VSS VSS VDD VDD net184 sky130_fd_sc_hd__clkbuf_1
Xinput185 text_in[33] VSS VSS VDD VDD net185 sky130_fd_sc_hd__clkbuf_1
Xinput186 text_in[34] VSS VSS VDD VDD net186 sky130_fd_sc_hd__clkbuf_1
Xinput187 text_in[35] VSS VSS VDD VDD net187 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput188 text_in[36] VSS VSS VDD VDD net188 sky130_fd_sc_hd__clkbuf_1
Xinput189 text_in[37] VSS VSS VDD VDD net189 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput190 text_in[38] VSS VSS VDD VDD net190 sky130_fd_sc_hd__clkbuf_1
Xinput191 text_in[39] VSS VSS VDD VDD net191 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput192 text_in[3] VSS VSS VDD VDD net192 sky130_fd_sc_hd__clkbuf_1
Xinput193 text_in[40] VSS VSS VDD VDD net193 sky130_fd_sc_hd__clkbuf_2
Xinput194 text_in[41] VSS VSS VDD VDD net194 sky130_fd_sc_hd__clkbuf_2
Xinput195 text_in[42] VSS VSS VDD VDD net195 sky130_fd_sc_hd__clkbuf_1
Xinput196 text_in[43] VSS VSS VDD VDD net196 sky130_fd_sc_hd__clkbuf_1
Xinput197 text_in[44] VSS VSS VDD VDD net197 sky130_fd_sc_hd__clkbuf_1
Xinput198 text_in[45] VSS VSS VDD VDD net198 sky130_fd_sc_hd__clkbuf_1
Xinput199 text_in[46] VSS VSS VDD VDD net199 sky130_fd_sc_hd__clkbuf_1
Xinput200 text_in[47] VSS VSS VDD VDD net200 sky130_fd_sc_hd__clkbuf_1
Xinput201 text_in[48] VSS VSS VDD VDD net201 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput202 text_in[49] VSS VSS VDD VDD net202 sky130_fd_sc_hd__clkbuf_1
Xinput203 text_in[4] VSS VSS VDD VDD net203 sky130_fd_sc_hd__clkbuf_1
Xinput204 text_in[50] VSS VSS VDD VDD net204 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput205 text_in[51] VSS VSS VDD VDD net205 sky130_fd_sc_hd__buf_2
Xinput206 text_in[52] VSS VSS VDD VDD net206 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput207 text_in[53] VSS VSS VDD VDD net207 sky130_fd_sc_hd__clkbuf_1
Xinput208 text_in[54] VSS VSS VDD VDD net208 sky130_fd_sc_hd__clkbuf_2
Xinput209 text_in[55] VSS VSS VDD VDD net209 sky130_fd_sc_hd__clkbuf_1
Xinput210 text_in[56] VSS VSS VDD VDD net210 sky130_fd_sc_hd__clkbuf_1
Xinput211 text_in[57] VSS VSS VDD VDD net211 sky130_fd_sc_hd__clkbuf_1
Xinput212 text_in[58] VSS VSS VDD VDD net212 sky130_fd_sc_hd__clkbuf_1
Xinput213 text_in[59] VSS VSS VDD VDD net213 sky130_fd_sc_hd__clkbuf_1
Xinput214 text_in[5] VSS VSS VDD VDD net214 sky130_fd_sc_hd__clkbuf_1
Xinput215 text_in[60] VSS VSS VDD VDD net215 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput216 text_in[61] VSS VSS VDD VDD net216 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput217 text_in[62] VSS VSS VDD VDD net217 sky130_fd_sc_hd__clkbuf_2
Xinput218 text_in[63] VSS VSS VDD VDD net218 sky130_fd_sc_hd__clkbuf_1
Xinput219 text_in[64] VSS VSS VDD VDD net219 sky130_fd_sc_hd__clkbuf_1
Xinput220 text_in[65] VSS VSS VDD VDD net220 sky130_fd_sc_hd__clkbuf_1
Xinput221 text_in[66] VSS VSS VDD VDD net221 sky130_fd_sc_hd__clkbuf_1
Xinput222 text_in[67] VSS VSS VDD VDD net222 sky130_fd_sc_hd__clkbuf_1
Xinput223 text_in[68] VSS VSS VDD VDD net223 sky130_fd_sc_hd__clkbuf_1
Xinput224 text_in[69] VSS VSS VDD VDD net224 sky130_fd_sc_hd__clkbuf_1
Xinput225 text_in[6] VSS VSS VDD VDD net225 sky130_fd_sc_hd__clkbuf_1
Xinput226 text_in[70] VSS VSS VDD VDD net226 sky130_fd_sc_hd__clkbuf_1
Xinput227 text_in[71] VSS VSS VDD VDD net227 sky130_fd_sc_hd__clkbuf_1
Xinput228 text_in[72] VSS VSS VDD VDD net228 sky130_fd_sc_hd__clkbuf_1
Xinput229 text_in[73] VSS VSS VDD VDD net229 sky130_fd_sc_hd__clkbuf_1
Xinput230 text_in[74] VSS VSS VDD VDD net230 sky130_fd_sc_hd__clkbuf_1
Xinput231 text_in[75] VSS VSS VDD VDD net231 sky130_fd_sc_hd__clkbuf_1
Xinput232 text_in[76] VSS VSS VDD VDD net232 sky130_fd_sc_hd__clkbuf_1
Xinput233 text_in[77] VSS VSS VDD VDD net233 sky130_fd_sc_hd__clkbuf_1
Xinput234 text_in[78] VSS VSS VDD VDD net234 sky130_fd_sc_hd__clkbuf_2
Xinput235 text_in[79] VSS VSS VDD VDD net235 sky130_fd_sc_hd__clkbuf_1
Xinput236 text_in[7] VSS VSS VDD VDD net236 sky130_fd_sc_hd__clkbuf_1
Xinput237 text_in[80] VSS VSS VDD VDD net237 sky130_fd_sc_hd__clkbuf_1
Xinput238 text_in[81] VSS VSS VDD VDD net238 sky130_fd_sc_hd__clkbuf_1
Xinput239 text_in[82] VSS VSS VDD VDD net239 sky130_fd_sc_hd__clkbuf_1
Xinput240 text_in[83] VSS VSS VDD VDD net240 sky130_fd_sc_hd__clkbuf_1
Xinput241 text_in[84] VSS VSS VDD VDD net241 sky130_fd_sc_hd__clkbuf_1
Xinput242 text_in[85] VSS VSS VDD VDD net242 sky130_fd_sc_hd__clkbuf_1
Xinput243 text_in[86] VSS VSS VDD VDD net243 sky130_fd_sc_hd__clkbuf_1
Xinput244 text_in[87] VSS VSS VDD VDD net244 sky130_fd_sc_hd__clkbuf_1
Xinput245 text_in[88] VSS VSS VDD VDD net245 sky130_fd_sc_hd__clkbuf_1
Xinput246 text_in[89] VSS VSS VDD VDD net246 sky130_fd_sc_hd__clkbuf_1
Xinput247 text_in[8] VSS VSS VDD VDD net247 sky130_fd_sc_hd__clkbuf_1
Xinput248 text_in[90] VSS VSS VDD VDD net248 sky130_fd_sc_hd__clkbuf_1
Xinput249 text_in[91] VSS VSS VDD VDD net249 sky130_fd_sc_hd__clkbuf_1
Xinput250 text_in[92] VSS VSS VDD VDD net250 sky130_fd_sc_hd__clkbuf_1
Xinput251 text_in[93] VSS VSS VDD VDD net251 sky130_fd_sc_hd__clkbuf_1
Xinput252 text_in[94] VSS VSS VDD VDD net252 sky130_fd_sc_hd__clkbuf_1
Xinput253 text_in[95] VSS VSS VDD VDD net253 sky130_fd_sc_hd__clkbuf_1
Xinput254 text_in[96] VSS VSS VDD VDD net254 sky130_fd_sc_hd__buf_4
Xinput255 text_in[97] VSS VSS VDD VDD net255 sky130_fd_sc_hd__clkbuf_1
Xinput256 text_in[98] VSS VSS VDD VDD net256 sky130_fd_sc_hd__clkbuf_1
Xinput257 text_in[99] VSS VSS VDD VDD net257 sky130_fd_sc_hd__clkbuf_2
Xinput258 text_in[9] VSS VSS VDD VDD net258 sky130_fd_sc_hd__clkbuf_1
Xoutput259 net259 VSS VSS VDD VDD done sky130_fd_sc_hd__clkbuf_1
Xoutput260 net260 VSS VSS VDD VDD text_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput261 net261 VSS VSS VDD VDD text_out[100] sky130_fd_sc_hd__clkbuf_1
Xoutput262 net262 VSS VSS VDD VDD text_out[101] sky130_fd_sc_hd__clkbuf_1
Xoutput263 net263 VSS VSS VDD VDD text_out[102] sky130_fd_sc_hd__clkbuf_1
Xoutput264 net264 VSS VSS VDD VDD text_out[103] sky130_fd_sc_hd__clkbuf_1
Xoutput265 net265 VSS VSS VDD VDD text_out[104] sky130_fd_sc_hd__clkbuf_1
Xoutput266 net266 VSS VSS VDD VDD text_out[105] sky130_fd_sc_hd__clkbuf_1
Xoutput267 net267 VSS VSS VDD VDD text_out[106] sky130_fd_sc_hd__clkbuf_1
Xoutput268 net268 VSS VSS VDD VDD text_out[107] sky130_fd_sc_hd__clkbuf_1
Xoutput269 net269 VSS VSS VDD VDD text_out[108] sky130_fd_sc_hd__clkbuf_1
Xoutput270 net270 VSS VSS VDD VDD text_out[109] sky130_fd_sc_hd__clkbuf_1
Xoutput271 net271 VSS VSS VDD VDD text_out[10] sky130_fd_sc_hd__clkbuf_1
Xoutput272 net272 VSS VSS VDD VDD text_out[110] sky130_fd_sc_hd__clkbuf_1
Xoutput273 net273 VSS VSS VDD VDD text_out[111] sky130_fd_sc_hd__clkbuf_1
Xoutput274 net274 VSS VSS VDD VDD text_out[112] sky130_fd_sc_hd__clkbuf_1
Xoutput275 net275 VSS VSS VDD VDD text_out[113] sky130_fd_sc_hd__clkbuf_1
Xoutput276 net276 VSS VSS VDD VDD text_out[114] sky130_fd_sc_hd__clkbuf_1
Xoutput277 net277 VSS VSS VDD VDD text_out[115] sky130_fd_sc_hd__clkbuf_1
Xoutput278 net278 VSS VSS VDD VDD text_out[116] sky130_fd_sc_hd__clkbuf_1
Xoutput279 net279 VSS VSS VDD VDD text_out[117] sky130_fd_sc_hd__clkbuf_1
Xoutput280 net280 VSS VSS VDD VDD text_out[118] sky130_fd_sc_hd__clkbuf_1
Xoutput281 net281 VSS VSS VDD VDD text_out[119] sky130_fd_sc_hd__clkbuf_1
Xoutput282 net282 VSS VSS VDD VDD text_out[11] sky130_fd_sc_hd__clkbuf_1
Xoutput283 net283 VSS VSS VDD VDD text_out[120] sky130_fd_sc_hd__clkbuf_1
Xoutput284 net284 VSS VSS VDD VDD text_out[121] sky130_fd_sc_hd__clkbuf_1
Xoutput285 net285 VSS VSS VDD VDD text_out[122] sky130_fd_sc_hd__clkbuf_1
Xoutput286 net286 VSS VSS VDD VDD text_out[123] sky130_fd_sc_hd__clkbuf_1
Xoutput287 net287 VSS VSS VDD VDD text_out[124] sky130_fd_sc_hd__clkbuf_1
Xoutput288 net288 VSS VSS VDD VDD text_out[125] sky130_fd_sc_hd__clkbuf_1
Xoutput289 net289 VSS VSS VDD VDD text_out[126] sky130_fd_sc_hd__clkbuf_1
Xoutput290 net290 VSS VSS VDD VDD text_out[127] sky130_fd_sc_hd__clkbuf_1
Xoutput291 net291 VSS VSS VDD VDD text_out[12] sky130_fd_sc_hd__clkbuf_1
Xoutput292 net292 VSS VSS VDD VDD text_out[13] sky130_fd_sc_hd__clkbuf_1
Xoutput293 net293 VSS VSS VDD VDD text_out[14] sky130_fd_sc_hd__clkbuf_1
Xoutput294 net294 VSS VSS VDD VDD text_out[15] sky130_fd_sc_hd__clkbuf_1
Xoutput295 net295 VSS VSS VDD VDD text_out[16] sky130_fd_sc_hd__clkbuf_1
Xoutput296 net296 VSS VSS VDD VDD text_out[17] sky130_fd_sc_hd__clkbuf_1
Xoutput297 net297 VSS VSS VDD VDD text_out[18] sky130_fd_sc_hd__clkbuf_1
Xoutput298 net298 VSS VSS VDD VDD text_out[19] sky130_fd_sc_hd__clkbuf_1
Xoutput299 net299 VSS VSS VDD VDD text_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput300 net300 VSS VSS VDD VDD text_out[20] sky130_fd_sc_hd__clkbuf_1
Xoutput301 net301 VSS VSS VDD VDD text_out[21] sky130_fd_sc_hd__clkbuf_1
Xoutput302 net302 VSS VSS VDD VDD text_out[22] sky130_fd_sc_hd__clkbuf_1
Xoutput303 net303 VSS VSS VDD VDD text_out[23] sky130_fd_sc_hd__clkbuf_1
Xoutput304 net304 VSS VSS VDD VDD text_out[24] sky130_fd_sc_hd__clkbuf_1
Xoutput305 net305 VSS VSS VDD VDD text_out[25] sky130_fd_sc_hd__clkbuf_1
Xoutput306 net306 VSS VSS VDD VDD text_out[26] sky130_fd_sc_hd__clkbuf_1
Xoutput307 net307 VSS VSS VDD VDD text_out[27] sky130_fd_sc_hd__clkbuf_1
Xoutput308 net308 VSS VSS VDD VDD text_out[28] sky130_fd_sc_hd__clkbuf_1
Xoutput309 net309 VSS VSS VDD VDD text_out[29] sky130_fd_sc_hd__clkbuf_1
Xoutput310 net310 VSS VSS VDD VDD text_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput311 net311 VSS VSS VDD VDD text_out[30] sky130_fd_sc_hd__clkbuf_1
Xoutput312 net312 VSS VSS VDD VDD text_out[31] sky130_fd_sc_hd__clkbuf_1
Xoutput313 net313 VSS VSS VDD VDD text_out[32] sky130_fd_sc_hd__clkbuf_1
Xoutput314 net314 VSS VSS VDD VDD text_out[33] sky130_fd_sc_hd__clkbuf_1
Xoutput315 net315 VSS VSS VDD VDD text_out[34] sky130_fd_sc_hd__clkbuf_1
Xoutput316 net316 VSS VSS VDD VDD text_out[35] sky130_fd_sc_hd__clkbuf_1
Xoutput317 net317 VSS VSS VDD VDD text_out[36] sky130_fd_sc_hd__clkbuf_1
Xoutput318 net318 VSS VSS VDD VDD text_out[37] sky130_fd_sc_hd__clkbuf_1
Xoutput319 net319 VSS VSS VDD VDD text_out[38] sky130_fd_sc_hd__clkbuf_1
Xoutput320 net320 VSS VSS VDD VDD text_out[39] sky130_fd_sc_hd__clkbuf_1
Xoutput321 net321 VSS VSS VDD VDD text_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput322 net322 VSS VSS VDD VDD text_out[40] sky130_fd_sc_hd__clkbuf_1
Xoutput323 net323 VSS VSS VDD VDD text_out[41] sky130_fd_sc_hd__clkbuf_1
Xoutput324 net324 VSS VSS VDD VDD text_out[42] sky130_fd_sc_hd__clkbuf_1
Xoutput325 net325 VSS VSS VDD VDD text_out[43] sky130_fd_sc_hd__clkbuf_1
Xoutput326 net326 VSS VSS VDD VDD text_out[44] sky130_fd_sc_hd__clkbuf_1
Xoutput327 net327 VSS VSS VDD VDD text_out[45] sky130_fd_sc_hd__clkbuf_1
Xoutput328 net328 VSS VSS VDD VDD text_out[46] sky130_fd_sc_hd__clkbuf_1
Xoutput329 net329 VSS VSS VDD VDD text_out[47] sky130_fd_sc_hd__clkbuf_1
Xoutput330 net330 VSS VSS VDD VDD text_out[48] sky130_fd_sc_hd__clkbuf_1
Xoutput331 net331 VSS VSS VDD VDD text_out[49] sky130_fd_sc_hd__clkbuf_1
Xoutput332 net332 VSS VSS VDD VDD text_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput333 net333 VSS VSS VDD VDD text_out[50] sky130_fd_sc_hd__clkbuf_1
Xoutput334 net334 VSS VSS VDD VDD text_out[51] sky130_fd_sc_hd__clkbuf_1
Xoutput335 net335 VSS VSS VDD VDD text_out[52] sky130_fd_sc_hd__clkbuf_1
Xoutput336 net336 VSS VSS VDD VDD text_out[53] sky130_fd_sc_hd__clkbuf_1
Xoutput337 net337 VSS VSS VDD VDD text_out[54] sky130_fd_sc_hd__clkbuf_1
Xoutput338 net338 VSS VSS VDD VDD text_out[55] sky130_fd_sc_hd__clkbuf_1
Xoutput339 net339 VSS VSS VDD VDD text_out[56] sky130_fd_sc_hd__clkbuf_1
Xoutput340 net340 VSS VSS VDD VDD text_out[57] sky130_fd_sc_hd__clkbuf_1
Xoutput341 net341 VSS VSS VDD VDD text_out[58] sky130_fd_sc_hd__clkbuf_1
Xoutput342 net342 VSS VSS VDD VDD text_out[59] sky130_fd_sc_hd__clkbuf_1
Xoutput343 net343 VSS VSS VDD VDD text_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput344 net344 VSS VSS VDD VDD text_out[60] sky130_fd_sc_hd__clkbuf_1
Xoutput345 net345 VSS VSS VDD VDD text_out[61] sky130_fd_sc_hd__clkbuf_1
Xoutput346 net346 VSS VSS VDD VDD text_out[62] sky130_fd_sc_hd__clkbuf_1
Xoutput347 net347 VSS VSS VDD VDD text_out[63] sky130_fd_sc_hd__clkbuf_1
Xoutput348 net348 VSS VSS VDD VDD text_out[64] sky130_fd_sc_hd__clkbuf_1
Xoutput349 net349 VSS VSS VDD VDD text_out[65] sky130_fd_sc_hd__clkbuf_1
Xoutput350 net350 VSS VSS VDD VDD text_out[66] sky130_fd_sc_hd__clkbuf_1
Xoutput351 net351 VSS VSS VDD VDD text_out[67] sky130_fd_sc_hd__clkbuf_1
Xoutput352 net352 VSS VSS VDD VDD text_out[68] sky130_fd_sc_hd__clkbuf_1
Xoutput353 net353 VSS VSS VDD VDD text_out[69] sky130_fd_sc_hd__clkbuf_1
Xoutput354 net354 VSS VSS VDD VDD text_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput355 net355 VSS VSS VDD VDD text_out[70] sky130_fd_sc_hd__clkbuf_1
Xoutput356 net356 VSS VSS VDD VDD text_out[71] sky130_fd_sc_hd__clkbuf_1
Xoutput357 net357 VSS VSS VDD VDD text_out[72] sky130_fd_sc_hd__clkbuf_1
Xoutput358 net358 VSS VSS VDD VDD text_out[73] sky130_fd_sc_hd__clkbuf_1
Xoutput359 net359 VSS VSS VDD VDD text_out[74] sky130_fd_sc_hd__clkbuf_1
Xoutput360 net360 VSS VSS VDD VDD text_out[75] sky130_fd_sc_hd__clkbuf_1
Xoutput361 net361 VSS VSS VDD VDD text_out[76] sky130_fd_sc_hd__clkbuf_1
Xoutput362 net362 VSS VSS VDD VDD text_out[77] sky130_fd_sc_hd__clkbuf_1
Xoutput363 net363 VSS VSS VDD VDD text_out[78] sky130_fd_sc_hd__clkbuf_1
Xoutput364 net364 VSS VSS VDD VDD text_out[79] sky130_fd_sc_hd__clkbuf_1
Xoutput365 net365 VSS VSS VDD VDD text_out[7] sky130_fd_sc_hd__clkbuf_1
Xoutput366 net366 VSS VSS VDD VDD text_out[80] sky130_fd_sc_hd__clkbuf_1
Xoutput367 net367 VSS VSS VDD VDD text_out[81] sky130_fd_sc_hd__clkbuf_1
Xoutput368 net368 VSS VSS VDD VDD text_out[82] sky130_fd_sc_hd__clkbuf_1
Xoutput369 net369 VSS VSS VDD VDD text_out[83] sky130_fd_sc_hd__clkbuf_1
Xoutput370 net370 VSS VSS VDD VDD text_out[84] sky130_fd_sc_hd__clkbuf_1
Xoutput371 net371 VSS VSS VDD VDD text_out[85] sky130_fd_sc_hd__clkbuf_1
Xoutput372 net372 VSS VSS VDD VDD text_out[86] sky130_fd_sc_hd__clkbuf_1
Xoutput373 net373 VSS VSS VDD VDD text_out[87] sky130_fd_sc_hd__clkbuf_1
Xoutput374 net374 VSS VSS VDD VDD text_out[88] sky130_fd_sc_hd__clkbuf_1
Xoutput375 net375 VSS VSS VDD VDD text_out[89] sky130_fd_sc_hd__clkbuf_1
Xoutput376 net376 VSS VSS VDD VDD text_out[8] sky130_fd_sc_hd__clkbuf_1
Xoutput377 net377 VSS VSS VDD VDD text_out[90] sky130_fd_sc_hd__clkbuf_1
Xoutput378 net378 VSS VSS VDD VDD text_out[91] sky130_fd_sc_hd__clkbuf_1
Xoutput379 net379 VSS VSS VDD VDD text_out[92] sky130_fd_sc_hd__clkbuf_1
Xoutput380 net380 VSS VSS VDD VDD text_out[93] sky130_fd_sc_hd__clkbuf_1
Xoutput381 net381 VSS VSS VDD VDD text_out[94] sky130_fd_sc_hd__clkbuf_1
Xoutput382 net382 VSS VSS VDD VDD text_out[95] sky130_fd_sc_hd__clkbuf_1
Xoutput383 net383 VSS VSS VDD VDD text_out[96] sky130_fd_sc_hd__clkbuf_1
Xoutput384 net384 VSS VSS VDD VDD text_out[97] sky130_fd_sc_hd__clkbuf_1
Xoutput385 net385 VSS VSS VDD VDD text_out[98] sky130_fd_sc_hd__clkbuf_1
Xoutput386 net386 VSS VSS VDD VDD text_out[99] sky130_fd_sc_hd__clkbuf_1
Xoutput387 net387 VSS VSS VDD VDD text_out[9] sky130_fd_sc_hd__clkbuf_1
Xload_slew388 net389 VSS VSS VDD VDD net388 sky130_fd_sc_hd__buf_16
Xload_slew389 _03075_ VSS VSS VDD VDD net389 sky130_fd_sc_hd__buf_16
Xmax_cap390 _03047_ VSS VSS VDD VDD net390 sky130_fd_sc_hd__buf_16
Xwire391 _03003_ VSS VSS VDD VDD net391 sky130_fd_sc_hd__buf_12
Xload_slew392 net561 VSS VSS VDD VDD net392 sky130_fd_sc_hd__buf_12
Xload_slew393 net561 VSS VSS VDD VDD net393 sky130_fd_sc_hd__buf_12
Xload_slew394 net695 VSS VSS VDD VDD net394 sky130_fd_sc_hd__buf_16
Xload_slew395 _02504_ VSS VSS VDD VDD net395 sky130_fd_sc_hd__buf_16
Xload_slew396 _02472_ VSS VSS VDD VDD net396 sky130_fd_sc_hd__buf_16
Xload_slew397 net398 VSS VSS VDD VDD net397 sky130_fd_sc_hd__buf_16
Xload_slew398 net399 VSS VSS VDD VDD net398 sky130_fd_sc_hd__buf_16
Xload_slew399 _02448_ VSS VSS VDD VDD net399 sky130_fd_sc_hd__buf_16
Xload_slew400 net719 VSS VSS VDD VDD net400 sky130_fd_sc_hd__buf_16
Xmax_cap401 net402 VSS VSS VDD VDD net401 sky130_fd_sc_hd__buf_16
Xload_slew402 _01891_ VSS VSS VDD VDD net402 sky130_fd_sc_hd__buf_16
Xload_slew403 _01891_ VSS VSS VDD VDD net403 sky130_fd_sc_hd__buf_16
Xmax_cap404 _01885_ VSS VSS VDD VDD net404 sky130_fd_sc_hd__buf_12
Xload_slew405 _01881_ VSS VSS VDD VDD net405 sky130_fd_sc_hd__buf_12
Xload_slew406 _01379_ VSS VSS VDD VDD net406 sky130_fd_sc_hd__buf_16
Xload_slew407 net408 VSS VSS VDD VDD net407 sky130_fd_sc_hd__buf_16
Xmax_cap408 _01353_ VSS VSS VDD VDD net408 sky130_fd_sc_hd__buf_16
Xload_slew409 net410 VSS VSS VDD VDD net409 sky130_fd_sc_hd__buf_16
Xmax_cap410 _00843_ VSS VSS VDD VDD net410 sky130_fd_sc_hd__buf_12
Xmax_cap411 _00830_ VSS VSS VDD VDD net411 sky130_fd_sc_hd__buf_16
Xload_slew412 _00830_ VSS VSS VDD VDD net412 sky130_fd_sc_hd__buf_12
Xload_slew413 _00822_ VSS VSS VDD VDD net413 sky130_fd_sc_hd__buf_16
Xwire414 _11715_ VSS VSS VDD VDD net414 sky130_fd_sc_hd__buf_12
Xload_slew415 _11627_ VSS VSS VDD VDD net415 sky130_fd_sc_hd__buf_16
Xload_slew416 _11627_ VSS VSS VDD VDD net416 sky130_fd_sc_hd__buf_16
Xload_slew417 _11627_ VSS VSS VDD VDD net417 sky130_fd_sc_hd__buf_16
Xload_slew418 _11622_ VSS VSS VDD VDD net418 sky130_fd_sc_hd__buf_12
Xload_slew419 _11617_ VSS VSS VDD VDD net419 sky130_fd_sc_hd__buf_12
Xload_slew420 net421 VSS VSS VDD VDD net420 sky130_fd_sc_hd__buf_16
Xload_slew421 net422 VSS VSS VDD VDD net421 sky130_fd_sc_hd__buf_16
Xload_slew422 _11075_ VSS VSS VDD VDD net422 sky130_fd_sc_hd__buf_12
Xmax_cap423 _10585_ VSS VSS VDD VDD net423 sky130_fd_sc_hd__buf_16
Xmax_cap424 net425 VSS VSS VDD VDD net424 sky130_fd_sc_hd__buf_16
Xmax_cap425 _10556_ VSS VSS VDD VDD net425 sky130_fd_sc_hd__buf_16
Xload_slew426 net427 VSS VSS VDD VDD net426 sky130_fd_sc_hd__buf_16
Xmax_cap427 _10550_ VSS VSS VDD VDD net427 sky130_fd_sc_hd__buf_16
Xload_slew428 _09998_ VSS VSS VDD VDD net428 sky130_fd_sc_hd__buf_12
Xload_slew429 _09990_ VSS VSS VDD VDD net429 sky130_fd_sc_hd__buf_16
Xwire430 _09935_ VSS VSS VDD VDD net430 sky130_fd_sc_hd__buf_12
Xload_slew431 net432 VSS VSS VDD VDD net431 sky130_fd_sc_hd__buf_16
Xload_slew432 _09935_ VSS VSS VDD VDD net432 sky130_fd_sc_hd__buf_12
Xload_slew433 net556 VSS VSS VDD VDD net433 sky130_fd_sc_hd__buf_16
Xload_slew434 net436 VSS VSS VDD VDD net434 sky130_fd_sc_hd__buf_16
Xmax_cap435 net436 VSS VSS VDD VDD net435 sky130_fd_sc_hd__buf_16
Xload_slew436 net743 VSS VSS VDD VDD net436 sky130_fd_sc_hd__buf_16
Xload_slew437 net601 VSS VSS VDD VDD net437 sky130_fd_sc_hd__buf_12
Xwire438 net638 VSS VSS VDD VDD net438 sky130_fd_sc_hd__buf_12
Xload_slew439 _08817_ VSS VSS VDD VDD net439 sky130_fd_sc_hd__buf_16
Xload_slew440 _08805_ VSS VSS VDD VDD net440 sky130_fd_sc_hd__buf_12
Xload_slew441 _08293_ VSS VSS VDD VDD net441 sky130_fd_sc_hd__buf_12
Xload_slew442 net443 VSS VSS VDD VDD net442 sky130_fd_sc_hd__buf_16
Xload_slew443 _08249_ VSS VSS VDD VDD net443 sky130_fd_sc_hd__buf_12
Xload_slew444 _08249_ VSS VSS VDD VDD net444 sky130_fd_sc_hd__buf_16
Xload_slew445 net446 VSS VSS VDD VDD net445 sky130_fd_sc_hd__buf_16
Xload_slew446 _08237_ VSS VSS VDD VDD net446 sky130_fd_sc_hd__buf_16
Xload_slew447 net448 VSS VSS VDD VDD net447 sky130_fd_sc_hd__buf_16
Xmax_cap448 _07740_ VSS VSS VDD VDD net448 sky130_fd_sc_hd__buf_16
Xload_slew449 _07728_ VSS VSS VDD VDD net449 sky130_fd_sc_hd__buf_16
Xload_slew450 _07728_ VSS VSS VDD VDD net450 sky130_fd_sc_hd__buf_16
Xmax_cap451 net452 VSS VSS VDD VDD net451 sky130_fd_sc_hd__buf_16
Xload_slew452 _07718_ VSS VSS VDD VDD net452 sky130_fd_sc_hd__buf_16
Xload_slew453 _07683_ VSS VSS VDD VDD net453 sky130_fd_sc_hd__buf_16
Xload_slew454 net455 VSS VSS VDD VDD net454 sky130_fd_sc_hd__buf_16
Xload_slew455 _07683_ VSS VSS VDD VDD net455 sky130_fd_sc_hd__buf_16
Xload_slew456 net569 VSS VSS VDD VDD net456 sky130_fd_sc_hd__buf_12
Xload_slew457 net458 VSS VSS VDD VDD net457 sky130_fd_sc_hd__buf_16
Xload_slew458 _07163_ VSS VSS VDD VDD net458 sky130_fd_sc_hd__buf_8
Xload_slew459 _07163_ VSS VSS VDD VDD net459 sky130_fd_sc_hd__buf_16
Xmax_cap460 _07131_ VSS VSS VDD VDD net460 sky130_fd_sc_hd__buf_16
Xload_slew461 net463 VSS VSS VDD VDD net461 sky130_fd_sc_hd__buf_16
Xmax_cap462 net463 VSS VSS VDD VDD net462 sky130_fd_sc_hd__buf_12
Xwire463 _07099_ VSS VSS VDD VDD net463 sky130_fd_sc_hd__buf_12
Xload_slew464 _06520_ VSS VSS VDD VDD net464 sky130_fd_sc_hd__buf_12
Xwire465 _06493_ VSS VSS VDD VDD net465 sky130_fd_sc_hd__buf_12
Xload_slew466 net467 VSS VSS VDD VDD net466 sky130_fd_sc_hd__buf_16
Xload_slew467 _06486_ VSS VSS VDD VDD net467 sky130_fd_sc_hd__buf_16
Xmax_cap468 _05958_ VSS VSS VDD VDD net468 sky130_fd_sc_hd__buf_16
Xload_slew469 _05954_ VSS VSS VDD VDD net469 sky130_fd_sc_hd__buf_16
Xmax_cap470 net471 VSS VSS VDD VDD net470 sky130_fd_sc_hd__buf_16
Xmax_cap471 _05899_ VSS VSS VDD VDD net471 sky130_fd_sc_hd__buf_16
Xmax_cap472 _05883_ VSS VSS VDD VDD net472 sky130_fd_sc_hd__buf_16
Xload_slew473 _03724_ VSS VSS VDD VDD net473 sky130_fd_sc_hd__buf_16
Xload_slew474 _03601_ VSS VSS VDD VDD net474 sky130_fd_sc_hd__buf_16
Xmax_cap475 net476 VSS VSS VDD VDD net475 sky130_fd_sc_hd__buf_16
Xload_slew476 _03800_ VSS VSS VDD VDD net476 sky130_fd_sc_hd__buf_16
Xwire477 _03791_ VSS VSS VDD VDD net477 sky130_fd_sc_hd__buf_16
Xload_slew478 net479 VSS VSS VDD VDD net478 sky130_fd_sc_hd__buf_16
Xload_slew479 _03791_ VSS VSS VDD VDD net479 sky130_fd_sc_hd__buf_16
Xmax_cap480 net481 VSS VSS VDD VDD net480 sky130_fd_sc_hd__buf_16
Xload_slew481 _03783_ VSS VSS VDD VDD net481 sky130_fd_sc_hd__buf_16
Xload_slew482 _03783_ VSS VSS VDD VDD net482 sky130_fd_sc_hd__buf_16
Xwire483 _11860_ VSS VSS VDD VDD net483 sky130_fd_sc_hd__buf_12
Xload_slew484 _03690_ VSS VSS VDD VDD net484 sky130_fd_sc_hd__buf_16
Xload_slew485 net486 VSS VSS VDD VDD net485 sky130_fd_sc_hd__buf_16
Xload_slew486 net753 VSS VSS VDD VDD net486 sky130_fd_sc_hd__buf_16
Xload_slew487 _03630_ VSS VSS VDD VDD net487 sky130_fd_sc_hd__buf_16
Xload_slew488 _03624_ VSS VSS VDD VDD net488 sky130_fd_sc_hd__buf_16
Xwire489 _03592_ VSS VSS VDD VDD net489 sky130_fd_sc_hd__buf_12
Xload_slew490 net491 VSS VSS VDD VDD net490 sky130_fd_sc_hd__buf_16
Xload_slew491 _05879_ VSS VSS VDD VDD net491 sky130_fd_sc_hd__buf_16
Xwire492 net493 VSS VSS VDD VDD net492 sky130_fd_sc_hd__buf_16
Xload_slew493 net653 VSS VSS VDD VDD net493 sky130_fd_sc_hd__buf_16
Xload_slew494 net495 VSS VSS VDD VDD net494 sky130_fd_sc_hd__buf_16
Xload_slew495 net497 VSS VSS VDD VDD net495 sky130_fd_sc_hd__buf_16
Xload_slew496 net497 VSS VSS VDD VDD net496 sky130_fd_sc_hd__buf_16
Xload_slew497 net129 VSS VSS VDD VDD net497 sky130_fd_sc_hd__buf_16
Xclkbuf_leaf_0_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_1_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_1_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_2_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_2_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_3_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_3_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_4_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_4_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_5_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_5_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_6_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_6_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_7_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_7_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_8_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_8_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_9_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_9_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_10_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_10_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_11_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_11_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_12_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_12_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_13_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_13_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_14_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_14_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_15_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_15_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_16_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_16_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_17_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_17_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_18_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_18_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_19_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_19_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_20_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_20_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_21_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_21_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_22_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_22_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_23_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_23_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_24_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_24_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_25_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_25_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_26_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_26_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_27_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_27_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_28_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_28_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_29_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_29_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_30_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_30_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_31_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_31_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_32_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_32_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_33_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_33_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_34_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_34_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_35_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_35_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_36_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_36_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_37_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_37_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_38_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_38_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_39_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_39_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_40_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_40_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_41_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_41_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_42_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_42_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_43_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_43_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_44_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_44_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_45_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_45_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_46_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_46_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_47_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_47_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_48_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_48_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_49_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_49_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_50_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_50_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_51_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_51_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_52_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_52_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_53_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_53_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_54_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_54_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_55_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_55_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_56_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_56_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_57_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_57_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_58_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_58_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_59_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_59_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_60_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_60_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_61_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_61_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_62_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_62_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_63_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_63_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_64_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_64_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_65_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_65_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_66_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_66_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_67_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_67_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_68_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_68_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_69_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_69_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_70_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_70_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_71_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_71_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_72_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_72_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_0_0_clk clknet_0_clk VSS VSS VDD VDD clknet_2_0_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_1_0_clk clknet_0_clk VSS VSS VDD VDD clknet_2_1_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_2_0_clk clknet_0_clk VSS VSS VDD VDD clknet_2_2_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_3_0_clk clknet_0_clk VSS VSS VDD VDD clknet_2_3_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_0__f_clk clknet_2_0_0_clk VSS VSS VDD VDD clknet_3_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_1__f_clk clknet_2_0_0_clk VSS VSS VDD VDD clknet_3_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_2__f_clk clknet_2_1_0_clk VSS VSS VDD VDD clknet_3_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_3__f_clk clknet_2_1_0_clk VSS VSS VDD VDD clknet_3_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_4__f_clk clknet_2_2_0_clk VSS VSS VDD VDD clknet_3_4__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_5__f_clk clknet_2_2_0_clk VSS VSS VDD VDD clknet_3_5__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_6__f_clk clknet_2_3_0_clk VSS VSS VDD VDD clknet_3_6__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_7__f_clk clknet_2_3_0_clk VSS VSS VDD VDD clknet_3_7__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_3_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__inv_6
Xclkload1 clknet_3_3__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkinv_16
Xclkload2 clknet_3_6__leaf_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__inv_6
Xclkload3 clknet_leaf_0_clk VSS VSS VDD VDD _unconnected_3
+ sky130_fd_sc_hd__clkbuf_8
Xclkload4 clknet_leaf_1_clk VSS VSS VDD VDD _unconnected_4
+ sky130_fd_sc_hd__clkinv_4
Xclkload5 clknet_leaf_2_clk VSS VSS VDD VDD _unconnected_5
+ sky130_fd_sc_hd__clkinv_2
Xclkload6 clknet_leaf_3_clk VSS VSS VDD VDD _unconnected_6
+ sky130_fd_sc_hd__clkbuf_1
Xclkload7 clknet_leaf_4_clk VSS VSS VDD VDD _unconnected_7
+ sky130_fd_sc_hd__clkinv_2
Xclkload8 clknet_leaf_5_clk VSS VSS VDD VDD _unconnected_8
+ sky130_fd_sc_hd__clkbuf_1
Xclkload9 clknet_leaf_6_clk VSS VSS VDD VDD _unconnected_9
+ sky130_fd_sc_hd__clkbuf_1
Xclkload10 clknet_leaf_7_clk VSS VSS VDD VDD _unconnected_10
+ sky130_fd_sc_hd__clkinv_4
Xclkload11 clknet_leaf_9_clk VSS VSS VDD VDD _unconnected_11
+ sky130_fd_sc_hd__clkbuf_8
Xclkload12 clknet_leaf_72_clk VSS VSS VDD VDD _unconnected_12
+ sky130_fd_sc_hd__inv_8
Xclkload13 clknet_leaf_10_clk VSS VSS VDD VDD _unconnected_13
+ sky130_fd_sc_hd__inv_6
Xclkload14 clknet_leaf_11_clk VSS VSS VDD VDD _unconnected_14
+ sky130_fd_sc_hd__inv_6
Xclkload15 clknet_leaf_12_clk VSS VSS VDD VDD _unconnected_15
+ sky130_fd_sc_hd__inv_6
Xclkload16 clknet_leaf_66_clk VSS VSS VDD VDD _unconnected_16
+ sky130_fd_sc_hd__bufinv_16
Xclkload17 clknet_leaf_67_clk VSS VSS VDD VDD _unconnected_17
+ sky130_fd_sc_hd__clkinv_2
Xclkload18 clknet_leaf_68_clk VSS VSS VDD VDD _unconnected_18
+ sky130_fd_sc_hd__inv_6
Xclkload19 clknet_leaf_69_clk VSS VSS VDD VDD _unconnected_19
+ sky130_fd_sc_hd__clkbuf_1
Xclkload20 clknet_leaf_71_clk VSS VSS VDD VDD _unconnected_20
+ sky130_fd_sc_hd__clkbuf_8
Xclkload21 clknet_leaf_18_clk VSS VSS VDD VDD _unconnected_21
+ sky130_fd_sc_hd__bufinv_16
Xclkload22 clknet_leaf_19_clk VSS VSS VDD VDD _unconnected_22
+ sky130_fd_sc_hd__inv_6
Xclkload23 clknet_leaf_20_clk VSS VSS VDD VDD _unconnected_23
+ sky130_fd_sc_hd__bufinv_16
Xclkload24 clknet_leaf_21_clk VSS VSS VDD VDD _unconnected_24
+ sky130_fd_sc_hd__bufinv_16
Xclkload25 clknet_leaf_22_clk VSS VSS VDD VDD _unconnected_25
+ sky130_fd_sc_hd__clkbuf_1
Xclkload26 clknet_leaf_23_clk VSS VSS VDD VDD _unconnected_26
+ sky130_fd_sc_hd__clkinv_2
Xclkload27 clknet_leaf_25_clk VSS VSS VDD VDD _unconnected_27
+ sky130_fd_sc_hd__clkbuf_1
Xclkload28 clknet_leaf_26_clk VSS VSS VDD VDD _unconnected_28
+ sky130_fd_sc_hd__inv_6
Xclkload29 clknet_leaf_27_clk VSS VSS VDD VDD _unconnected_29
+ sky130_fd_sc_hd__clkinv_2
Xclkload30 clknet_leaf_28_clk VSS VSS VDD VDD _unconnected_30
+ sky130_fd_sc_hd__clkinv_4
Xclkload31 clknet_leaf_29_clk VSS VSS VDD VDD _unconnected_31
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload32 clknet_leaf_30_clk VSS VSS VDD VDD _unconnected_32
+ sky130_fd_sc_hd__clkinv_2
Xclkload33 clknet_leaf_31_clk VSS VSS VDD VDD _unconnected_33
+ sky130_fd_sc_hd__clkinv_4
Xclkload34 clknet_leaf_13_clk VSS VSS VDD VDD _unconnected_34
+ sky130_fd_sc_hd__clkbuf_1
Xclkload35 clknet_leaf_14_clk VSS VSS VDD VDD _unconnected_35
+ sky130_fd_sc_hd__clkinv_2
Xclkload36 clknet_leaf_15_clk VSS VSS VDD VDD _unconnected_36
+ sky130_fd_sc_hd__clkbuf_1
Xclkload37 clknet_leaf_16_clk VSS VSS VDD VDD _unconnected_37
+ sky130_fd_sc_hd__clkbuf_1
Xclkload38 clknet_leaf_32_clk VSS VSS VDD VDD _unconnected_38
+ sky130_fd_sc_hd__clkinv_2
Xclkload39 clknet_leaf_33_clk VSS VSS VDD VDD _unconnected_39
+ sky130_fd_sc_hd__clkbuf_1
Xclkload40 clknet_leaf_34_clk VSS VSS VDD VDD _unconnected_40
+ sky130_fd_sc_hd__clkbuf_1
Xclkload41 clknet_leaf_35_clk VSS VSS VDD VDD _unconnected_41
+ sky130_fd_sc_hd__clkinv_2
Xclkload42 clknet_leaf_51_clk VSS VSS VDD VDD _unconnected_42
+ sky130_fd_sc_hd__bufinv_16
Xclkload43 clknet_leaf_53_clk VSS VSS VDD VDD _unconnected_43
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload44 clknet_leaf_54_clk VSS VSS VDD VDD _unconnected_44
+ sky130_fd_sc_hd__clkinv_2
Xclkload45 clknet_leaf_55_clk VSS VSS VDD VDD _unconnected_45
+ sky130_fd_sc_hd__clkbuf_8
Xclkload46 clknet_leaf_57_clk VSS VSS VDD VDD _unconnected_46
+ sky130_fd_sc_hd__bufinv_16
Xclkload47 clknet_leaf_62_clk VSS VSS VDD VDD _unconnected_47
+ sky130_fd_sc_hd__inv_6
Xclkload48 clknet_leaf_64_clk VSS VSS VDD VDD _unconnected_48
+ sky130_fd_sc_hd__inv_8
Xclkload49 clknet_leaf_65_clk VSS VSS VDD VDD _unconnected_49
+ sky130_fd_sc_hd__inv_6
Xclkload50 clknet_leaf_42_clk VSS VSS VDD VDD _unconnected_50
+ sky130_fd_sc_hd__clkbuf_8
Xclkload51 clknet_leaf_43_clk VSS VSS VDD VDD _unconnected_51
+ sky130_fd_sc_hd__clkbuf_1
Xclkload52 clknet_leaf_44_clk VSS VSS VDD VDD _unconnected_52
+ sky130_fd_sc_hd__clkinv_4
Xclkload53 clknet_leaf_45_clk VSS VSS VDD VDD _unconnected_53
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload54 clknet_leaf_58_clk VSS VSS VDD VDD _unconnected_54
+ sky130_fd_sc_hd__bufinv_16
Xclkload55 clknet_leaf_60_clk VSS VSS VDD VDD _unconnected_55
+ sky130_fd_sc_hd__clkbuf_8
Xclkload56 clknet_leaf_61_clk VSS VSS VDD VDD _unconnected_56
+ sky130_fd_sc_hd__inv_6
Xclkload57 clknet_leaf_63_clk VSS VSS VDD VDD _unconnected_57
+ sky130_fd_sc_hd__inv_6
Xclkload58 clknet_leaf_36_clk VSS VSS VDD VDD _unconnected_58
+ sky130_fd_sc_hd__clkbuf_16
Xclkload59 clknet_leaf_38_clk VSS VSS VDD VDD _unconnected_59
+ sky130_fd_sc_hd__clkbuf_1
Xclkload60 clknet_leaf_39_clk VSS VSS VDD VDD _unconnected_60
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload61 clknet_leaf_48_clk VSS VSS VDD VDD _unconnected_61
+ sky130_fd_sc_hd__clkinv_2
Xclkload62 clknet_leaf_40_clk VSS VSS VDD VDD _unconnected_62
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload63 clknet_leaf_46_clk VSS VSS VDD VDD _unconnected_63
+ sky130_fd_sc_hd__clkbuf_1
Xclkload64 clknet_leaf_47_clk VSS VSS VDD VDD _unconnected_64
+ sky130_fd_sc_hd__clkinv_4
Xclkload65 clknet_leaf_49_clk VSS VSS VDD VDD _unconnected_65
+ sky130_fd_sc_hd__bufinv_16
Xclkload66 clknet_leaf_50_clk VSS VSS VDD VDD _unconnected_66
+ sky130_fd_sc_hd__clkinv_2
Xclkload67 clknet_leaf_52_clk VSS VSS VDD VDD _unconnected_67
+ sky130_fd_sc_hd__inv_6
Xclone1 _09927_ u0.tmp_w\[16\] VSS VSS VDD VDD net498 sky130_fd_sc_hd__xor2_2
Xclone2 u0.w\[1\]\[16\] net668 VSS VSS VDD VDD net499 sky130_fd_sc_hd__xor2_2
Xclone3 net529 u0.tmp_w\[9\] VSS VSS VDD VDD net500 sky130_fd_sc_hd__xor2_2
Xclone4 net659 u0.w\[1\]\[8\] VSS VSS VDD VDD net501 sky130_fd_sc_hd__xor2_2
Xclone5 u0.tmp_w\[0\] _02985_ VSS VSS VDD VDD net502 sky130_fd_sc_hd__xor2_2
Xclone6 _07674_ u0.tmp_w\[24\] VSS VSS VDD VDD net503 sky130_fd_sc_hd__xor2_2
Xrebuffer7 _06493_ VSS VSS VDD VDD net504 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer8 net504 VSS VSS VDD VDD net505 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer9 net505 VSS VSS VDD VDD net506 sky130_fd_sc_hd__buf_2
Xrebuffer10 _06493_ VSS VSS VDD VDD net507 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer11 net507 VSS VSS VDD VDD net508 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer12 net507 VSS VSS VDD VDD net509 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer13 net507 VSS VSS VDD VDD net510 sky130_fd_sc_hd__dlygate4sd1_1
Xclone14 net646 u0.w\[1\]\[9\] VSS VSS VDD VDD net511 sky130_fd_sc_hd__xor2_2
Xclone15 net491 VSS VSS VDD VDD net512 sky130_fd_sc_hd__clkbuf_16
Xclone16 u0.w\[0\]\[24\] _05889_ VSS VSS VDD VDD net513 sky130_fd_sc_hd__xor2_2
Xclone17 u0.w\[0\]\[9\] _10493_ VSS VSS VDD VDD net514 sky130_fd_sc_hd__xor2_2
Xclone18 _10506_ _10504_ VSS VSS VDD VDD net515 sky130_fd_sc_hd__and2_2
Xclone19 u0.w\[0\]\[16\] _08242_ VSS VSS VDD VDD net516 sky130_fd_sc_hd__xor2_2
Xrebuffer20 _09928_ VSS VSS VDD VDD net517 sky130_fd_sc_hd__buf_4
Xrebuffer21 net517 VSS VSS VDD VDD net518 sky130_fd_sc_hd__buf_2
Xrebuffer22 net518 VSS VSS VDD VDD net519 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer23 net518 VSS VSS VDD VDD net520 sky130_fd_sc_hd__buf_4
Xrebuffer24 net517 VSS VSS VDD VDD net521 sky130_fd_sc_hd__dlygate4sd1_1
Xclone25 u0.w\[0\]\[1\] _01341_ VSS VSS VDD VDD net522 sky130_fd_sc_hd__xor2_2
Xrebuffer26 _10499_ VSS VSS VDD VDD net523 sky130_fd_sc_hd__buf_4
Xrebuffer27 _10499_ VSS VSS VDD VDD net524 sky130_fd_sc_hd__buf_4
Xrebuffer28 net524 VSS VSS VDD VDD net525 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer29 net525 VSS VSS VDD VDD net526 sky130_fd_sc_hd__buf_6
Xrebuffer30 net526 VSS VSS VDD VDD net527 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer31 net525 VSS VSS VDD VDD net528 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer32 _00775_ VSS VSS VDD VDD net529 sky130_fd_sc_hd__dlygate4sd1_1
Xsplit33 net653 VSS VSS VDD VDD net530 sky130_fd_sc_hd__buf_8
Xclone34 u0.w\[2\]\[16\] net739 VSS VSS VDD VDD net531 sky130_fd_sc_hd__xor2_2
Xclone35 _06500_ _06502_ VSS VSS VDD VDD net532 sky130_fd_sc_hd__and2_2
Xrebuffer36 _02986_ VSS VSS VDD VDD net533 sky130_fd_sc_hd__buf_12
Xrebuffer37 net533 VSS VSS VDD VDD net534 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer38 net533 VSS VSS VDD VDD net535 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer39 net533 VSS VSS VDD VDD net536 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer40 net536 VSS VSS VDD VDD net537 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer41 _02986_ VSS VSS VDD VDD net538 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer42 net538 VSS VSS VDD VDD net539 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer43 _08811_ VSS VSS VDD VDD net540 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer44 net540 VSS VSS VDD VDD net541 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer45 net540 VSS VSS VDD VDD net542 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer46 _08811_ VSS VSS VDD VDD net543 sky130_fd_sc_hd__buf_12
Xrebuffer47 net543 VSS VSS VDD VDD net544 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer48 net544 VSS VSS VDD VDD net545 sky130_fd_sc_hd__dlygate4sd1_1
Xclone49 u0.w\[1\]\[1\] _01880_ VSS VSS VDD VDD net546 sky130_fd_sc_hd__xor2_2
Xclone50 _05879_ VSS VSS VDD VDD net547 sky130_fd_sc_hd__clkbuf_16
Xclone51 u0.w\[2\]\[25\] _07080_ VSS VSS VDD VDD net548 sky130_fd_sc_hd__xor2_2
Xrebuffer52 _08805_ VSS VSS VDD VDD net549 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer53 net549 VSS VSS VDD VDD net550 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer54 net549 VSS VSS VDD VDD net551 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer55 net549 VSS VSS VDD VDD net552 sky130_fd_sc_hd__dlygate4sd1_1
Xclone56 _00796_ _00793_ VSS VSS VDD VDD net553 sky130_fd_sc_hd__nor2_4
Xrebuffer57 _09922_ VSS VSS VDD VDD net554 sky130_fd_sc_hd__buf_12
Xrebuffer58 net554 VSS VSS VDD VDD net555 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer59 net554 VSS VSS VDD VDD net556 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer60 net554 VSS VSS VDD VDD net557 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer61 net554 VSS VSS VDD VDD net558 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer62 net554 VSS VSS VDD VDD net559 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer63 _02992_ VSS VSS VDD VDD net560 sky130_fd_sc_hd__buf_8
Xrebuffer64 net560 VSS VSS VDD VDD net561 sky130_fd_sc_hd__buf_6
Xrebuffer65 net561 VSS VSS VDD VDD net562 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer66 net561 VSS VSS VDD VDD net563 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer67 net561 VSS VSS VDD VDD net564 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer68 net564 VSS VSS VDD VDD net565 sky130_fd_sc_hd__buf_4
Xrebuffer69 net565 VSS VSS VDD VDD net566 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer70 net565 VSS VSS VDD VDD net567 sky130_fd_sc_hd__buf_1
Xrebuffer71 _07667_ VSS VSS VDD VDD net568 sky130_fd_sc_hd__buf_12
Xrebuffer72 _07667_ VSS VSS VDD VDD net569 sky130_fd_sc_hd__buf_2
Xrebuffer73 net569 VSS VSS VDD VDD net570 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer74 net569 VSS VSS VDD VDD net571 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer75 net571 VSS VSS VDD VDD net572 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer76 net569 VSS VSS VDD VDD net573 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer77 net569 VSS VSS VDD VDD net574 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer78 net569 VSS VSS VDD VDD net575 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer79 _07675_ VSS VSS VDD VDD net576 sky130_fd_sc_hd__buf_12
Xrebuffer80 _07675_ VSS VSS VDD VDD net577 sky130_fd_sc_hd__buf_2
Xrebuffer81 _07675_ VSS VSS VDD VDD net578 sky130_fd_sc_hd__buf_2
Xrebuffer82 net578 VSS VSS VDD VDD net579 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer83 net578 VSS VSS VDD VDD net580 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer84 _06486_ VSS VSS VDD VDD net581 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer85 net581 VSS VSS VDD VDD net582 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer86 net582 VSS VSS VDD VDD net583 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer87 net582 VSS VSS VDD VDD net584 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer88 net581 VSS VSS VDD VDD net585 sky130_fd_sc_hd__dlygate4sd1_1
Xclone89 _03011_ _03009_ VSS VSS VDD VDD net586 sky130_fd_sc_hd__or2_2
Xclone90 _10506_ _10504_ VSS VSS VDD VDD net587 sky130_fd_sc_hd__and2_2
Xrebuffer91 _01342_ VSS VSS VDD VDD net588 sky130_fd_sc_hd__buf_12
Xrebuffer92 net588 VSS VSS VDD VDD net589 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer93 net588 VSS VSS VDD VDD net590 sky130_fd_sc_hd__buf_2
Xrebuffer94 net590 VSS VSS VDD VDD net591 sky130_fd_sc_hd__buf_6
Xrebuffer95 net588 VSS VSS VDD VDD net592 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer96 net592 VSS VSS VDD VDD net593 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer97 _01342_ VSS VSS VDD VDD net594 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer98 net594 VSS VSS VDD VDD net595 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer99 _09369_ VSS VSS VDD VDD net596 sky130_fd_sc_hd__buf_12
Xrebuffer100 net596 VSS VSS VDD VDD net597 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer101 net597 VSS VSS VDD VDD net598 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer102 _09369_ VSS VSS VDD VDD net599 sky130_fd_sc_hd__buf_2
Xrebuffer103 net599 VSS VSS VDD VDD net600 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer104 _09363_ VSS VSS VDD VDD net601 sky130_fd_sc_hd__buf_12
Xrebuffer105 net601 VSS VSS VDD VDD net602 sky130_fd_sc_hd__buf_8
Xrebuffer106 net602 VSS VSS VDD VDD net603 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer107 net602 VSS VSS VDD VDD net604 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer108 net601 VSS VSS VDD VDD net605 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer109 net605 VSS VSS VDD VDD net606 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer110 net605 VSS VSS VDD VDD net607 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer111 _01885_ VSS VSS VDD VDD net608 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer112 net608 VSS VSS VDD VDD net609 sky130_fd_sc_hd__buf_1
Xrebuffer113 net609 VSS VSS VDD VDD net610 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer114 net608 VSS VSS VDD VDD net611 sky130_fd_sc_hd__buf_2
Xrebuffer115 net608 VSS VSS VDD VDD net612 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer116 net612 VSS VSS VDD VDD net613 sky130_fd_sc_hd__dlygate4sd1_1
Xclone117 _02442_ u0.w\[2\]\[0\] VSS VSS VDD VDD net614 sky130_fd_sc_hd__xor2_2
Xclone118 _02479_ _02477_ VSS VSS VDD VDD net615 sky130_fd_sc_hd__or2_2
Xclone119 _03712_ net494 _03713_ VSS VSS VDD VDD net616 sky130_fd_sc_hd__o21a_2
Xwire1 _08860_ VSS VSS VDD VDD net617 sky130_fd_sc_hd__buf_12
Xload_slew2 _08849_ VSS VSS VDD VDD net618 sky130_fd_sc_hd__buf_16
Xload_slew3 _06569_ VSS VSS VDD VDD net619 sky130_fd_sc_hd__buf_16
Xload_slew4 _10519_ VSS VSS VDD VDD net620 sky130_fd_sc_hd__buf_12
Xrebuffer5 _11070_ VSS VSS VDD VDD net621 sky130_fd_sc_hd__buf_12
Xrebuffer6 net621 VSS VSS VDD VDD net622 sky130_fd_sc_hd__buf_12
Xrebuffer14 net622 VSS VSS VDD VDD net623 sky130_fd_sc_hd__buf_2
Xrebuffer15 net623 VSS VSS VDD VDD net624 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer16 net624 VSS VSS VDD VDD net625 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer17 _11064_ VSS VSS VDD VDD net626 sky130_fd_sc_hd__buf_12
Xrebuffer18 net626 VSS VSS VDD VDD net627 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer19 net626 VSS VSS VDD VDD net628 sky130_fd_sc_hd__buf_8
Xrebuffer25 net628 VSS VSS VDD VDD net629 sky130_fd_sc_hd__buf_6
Xrebuffer33 net629 VSS VSS VDD VDD net630 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer34 net629 VSS VSS VDD VDD net631 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer35 _00776_ VSS VSS VDD VDD net632 sky130_fd_sc_hd__buf_12
Xrebuffer49 net632 VSS VSS VDD VDD net633 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer50 net633 VSS VSS VDD VDD net634 sky130_fd_sc_hd__buf_6
Xrebuffer51 net634 VSS VSS VDD VDD net635 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer56 net634 VSS VSS VDD VDD net636 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer89 net633 VSS VSS VDD VDD net637 sky130_fd_sc_hd__buf_2
Xrebuffer90 _08817_ VSS VSS VDD VDD net638 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer117 net638 VSS VSS VDD VDD net639 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer118 net639 VSS VSS VDD VDD net640 sky130_fd_sc_hd__buf_8
Xrebuffer119 net640 VSS VSS VDD VDD net641 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer120 net640 VSS VSS VDD VDD net642 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer121 net640 VSS VSS VDD VDD net643 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer122 net643 VSS VSS VDD VDD net644 sky130_fd_sc_hd__buf_1
Xclone123 _06536_ _06534_ VSS VSS VDD VDD net645 sky130_fd_sc_hd__or2_2
Xrebuffer124 _11063_ VSS VSS VDD VDD net646 sky130_fd_sc_hd__buf_2
Xrebuffer125 _07081_ VSS VSS VDD VDD net647 sky130_fd_sc_hd__buf_12
Xrebuffer126 net647 VSS VSS VDD VDD net648 sky130_fd_sc_hd__buf_12
Xrebuffer127 net648 VSS VSS VDD VDD net649 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer128 net649 VSS VSS VDD VDD net650 sky130_fd_sc_hd__buf_2
Xrebuffer129 net648 VSS VSS VDD VDD net651 sky130_fd_sc_hd__dlygate4sd1_1
Xclone130 net495 VSS VSS VDD VDD net652 sky130_fd_sc_hd__clkbuf_16
Xrebuffer131 ld_r VSS VSS VDD VDD net653 sky130_fd_sc_hd__buf_6
Xrebuffer132 ld_r VSS VSS VDD VDD net654 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer133 net654 VSS VSS VDD VDD net655 sky130_fd_sc_hd__buf_2
Xrebuffer134 net655 VSS VSS VDD VDD net656 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer135 net655 VSS VSS VDD VDD net657 sky130_fd_sc_hd__dlygate4sd1_1
Xclone136 _11102_ _11100_ VSS VSS VDD VDD net658 sky130_fd_sc_hd__nor2_4
Xrebuffer137 _11069_ VSS VSS VDD VDD net659 sky130_fd_sc_hd__buf_2
Xrebuffer138 net491 VSS VSS VDD VDD net660 sky130_fd_sc_hd__buf_12
Xrebuffer139 net660 VSS VSS VDD VDD net661 sky130_fd_sc_hd__buf_6
Xrebuffer140 net660 VSS VSS VDD VDD net662 sky130_fd_sc_hd__buf_6
Xrebuffer141 net660 VSS VSS VDD VDD net663 sky130_fd_sc_hd__buf_2
Xclone142 _11075_ VSS VSS VDD VDD net664 sky130_fd_sc_hd__clkbuf_16
Xclone143 _11121_ u0.w\[1\]\[12\] VSS VSS VDD VDD net665 sky130_fd_sc_hd__xor2_2
Xclone144 _00793_ _00796_ VSS VSS VDD VDD net666 sky130_fd_sc_hd__nor2_4
Xclone145 u0.tmp_w\[11\] _00829_ VSS VSS VDD VDD net667 sky130_fd_sc_hd__xor2_2
Xrebuffer146 _08810_ VSS VSS VDD VDD net668 sky130_fd_sc_hd__dlygate4sd1_1
Xclone147 _06536_ _06534_ VSS VSS VDD VDD net669 sky130_fd_sc_hd__nor2_4
Xclone148 _06500_ _06502_ VSS VSS VDD VDD net670 sky130_fd_sc_hd__and2_2
Xrebuffer149 _00843_ VSS VSS VDD VDD net671 sky130_fd_sc_hd__buf_4
Xrebuffer150 net671 VSS VSS VDD VDD net672 sky130_fd_sc_hd__buf_12
Xrebuffer151 net672 VSS VSS VDD VDD net673 sky130_fd_sc_hd__dlygate4sd1_1
Xclone152 u0.w\[2\]\[24\] _07088_ VSS VSS VDD VDD net674 sky130_fd_sc_hd__xor2_2
Xrebuffer153 _01881_ VSS VSS VDD VDD net675 sky130_fd_sc_hd__buf_2
Xrebuffer154 net675 VSS VSS VDD VDD net676 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer155 net675 VSS VSS VDD VDD net677 sky130_fd_sc_hd__dlygate4sd1_1
Xclone156 _01949_ u0.w\[1\]\[4\] VSS VSS VDD VDD net678 sky130_fd_sc_hd__xor2_2
Xclone157 _01909_ u0.w\[1\]\[5\] VSS VSS VDD VDD net679 sky130_fd_sc_hd__xor2_2
Xrebuffer158 _10494_ VSS VSS VDD VDD net680 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer159 _10494_ VSS VSS VDD VDD net681 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer160 _10494_ VSS VSS VDD VDD net682 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer161 net682 VSS VSS VDD VDD net683 sky130_fd_sc_hd__buf_6
Xrebuffer162 net683 VSS VSS VDD VDD net684 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer163 net683 VSS VSS VDD VDD net685 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer164 _10507_ VSS VSS VDD VDD net686 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer165 net686 VSS VSS VDD VDD net687 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer166 _10507_ VSS VSS VDD VDD net688 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer167 sa30_sub\[7\] VSS VSS VDD VDD net689 sky130_fd_sc_hd__buf_4
Xrebuffer168 net689 VSS VSS VDD VDD net690 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer169 sa30_sub\[7\] VSS VSS VDD VDD net691 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer170 sa30_sub\[7\] VSS VSS VDD VDD net692 sky130_fd_sc_hd__buf_2
Xclone171 u0.w\[0\]\[11\] _10549_ VSS VSS VDD VDD net693 sky130_fd_sc_hd__xor2_2
Xclone172 _10549_ u0.w\[0\]\[11\] VSS VSS VDD VDD net694 sky130_fd_sc_hd__xnor2_2
Xrebuffer173 _02980_ VSS VSS VDD VDD net695 sky130_fd_sc_hd__buf_12
Xrebuffer174 net695 VSS VSS VDD VDD net696 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer175 _08243_ VSS VSS VDD VDD net697 sky130_fd_sc_hd__buf_12
Xrebuffer176 net697 VSS VSS VDD VDD net698 sky130_fd_sc_hd__buf_4
Xrebuffer177 net698 VSS VSS VDD VDD net699 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer178 net699 VSS VSS VDD VDD net700 sky130_fd_sc_hd__buf_6
Xclone179 _08265_ _08260_ VSS VSS VDD VDD net701 sky130_fd_sc_hd__and2_2
Xrebuffer180 _03585_ VSS VSS VDD VDD net702 sky130_fd_sc_hd__buf_6
Xrebuffer181 net702 VSS VSS VDD VDD net703 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer182 net703 VSS VSS VDD VDD net704 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer183 _03585_ VSS VSS VDD VDD net705 sky130_fd_sc_hd__buf_4
Xrebuffer184 net705 VSS VSS VDD VDD net706 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer185 net705 VSS VSS VDD VDD net707 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer186 _03585_ VSS VSS VDD VDD net708 sky130_fd_sc_hd__dlygate4sd1_1
Xclone187 net495 _03575_ _03577_ VSS VSS VDD VDD net709 sky130_fd_sc_hd__o21a_2
Xrebuffer188 _11617_ VSS VSS VDD VDD net710 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer189 net710 VSS VSS VDD VDD net711 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer190 net711 VSS VSS VDD VDD net712 sky130_fd_sc_hd__dlygate4sd1_1
Xclone191 _11654_ _11650_ VSS VSS VDD VDD net713 sky130_fd_sc_hd__and2_2
Xrebuffer192 _02443_ VSS VSS VDD VDD net714 sky130_fd_sc_hd__buf_8
Xrebuffer193 net714 VSS VSS VDD VDD net715 sky130_fd_sc_hd__buf_12
Xrebuffer194 net715 VSS VSS VDD VDD net716 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer195 net714 VSS VSS VDD VDD net717 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer196 net714 VSS VSS VDD VDD net718 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer197 _02437_ VSS VSS VDD VDD net719 sky130_fd_sc_hd__buf_12
Xrebuffer198 net719 VSS VSS VDD VDD net720 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer199 net720 VSS VSS VDD VDD net721 sky130_fd_sc_hd__buf_6
Xrebuffer200 net721 VSS VSS VDD VDD net722 sky130_fd_sc_hd__buf_6
Xrebuffer201 net720 VSS VSS VDD VDD net723 sky130_fd_sc_hd__buf_1
Xrebuffer202 _05883_ VSS VSS VDD VDD net724 sky130_fd_sc_hd__buf_2
Xrebuffer203 net724 VSS VSS VDD VDD net725 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer204 net724 VSS VSS VDD VDD net726 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer205 net724 VSS VSS VDD VDD net727 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer206 net724 VSS VSS VDD VDD net728 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer207 net728 VSS VSS VDD VDD net729 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer208 net724 VSS VSS VDD VDD net730 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer209 _05890_ VSS VSS VDD VDD net731 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer210 _05890_ VSS VSS VDD VDD net732 sky130_fd_sc_hd__buf_8
Xrebuffer211 net732 VSS VSS VDD VDD net733 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer212 net732 VSS VSS VDD VDD net734 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer213 net734 VSS VSS VDD VDD net735 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer214 net734 VSS VSS VDD VDD net736 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer215 net734 VSS VSS VDD VDD net737 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer216 _05890_ VSS VSS VDD VDD net738 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer217 _09368_ VSS VSS VDD VDD net739 sky130_fd_sc_hd__buf_2
Xclone218 _09402_ _09405_ VSS VSS VDD VDD net740 sky130_fd_sc_hd__or2_2
Xclone219 u0.w\[2\]\[20\] _09384_ VSS VSS VDD VDD net741 sky130_fd_sc_hd__xor2_2
Xclone220 _09405_ _09402_ VSS VSS VDD VDD net742 sky130_fd_sc_hd__nor2_4
Xrebuffer221 _09374_ VSS VSS VDD VDD net743 sky130_fd_sc_hd__buf_12
Xrebuffer222 net743 VSS VSS VDD VDD net744 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer223 net744 VSS VSS VDD VDD net745 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer224 net744 VSS VSS VDD VDD net746 sky130_fd_sc_hd__dlygate4sd1_1
Xclone225 u0.w\[0\]\[0\] _01347_ VSS VSS VDD VDD net747 sky130_fd_sc_hd__xor2_2
Xclone226 _01366_ _01364_ VSS VSS VDD VDD net748 sky130_fd_sc_hd__nor2_4
Xclone227 _08837_ _08834_ VSS VSS VDD VDD net749 sky130_fd_sc_hd__nor2_4
Xclone228 _02479_ _02477_ VSS VSS VDD VDD net750 sky130_fd_sc_hd__nor2_4
Xclone229 _02477_ _02479_ VSS VSS VDD VDD net751 sky130_fd_sc_hd__or2_2
Xclone230 net497 _03635_ _03636_ VSS VSS VDD VDD net752 sky130_fd_sc_hd__o21a_2
Xrebuffer231 _03647_ VSS VSS VDD VDD net753 sky130_fd_sc_hd__buf_12
Xrebuffer232 net753 VSS VSS VDD VDD net754 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer233 net754 VSS VSS VDD VDD net755 sky130_fd_sc_hd__buf_12
Xclone234 _01352_ u0.w\[0\]\[2\] VSS VSS VDD VDD net756 sky130_fd_sc_hd__xnor2_2
Xclone235 _11638_ u0.w\[2\]\[13\] VSS VSS VDD VDD net757 sky130_fd_sc_hd__xnor2_2
Xclone236 u0.w\[2\]\[12\] _11669_ VSS VSS VDD VDD net758 sky130_fd_sc_hd__xor2_2
XANTENNA_1 _00001_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_2 _00016_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_3 _00016_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_4 _00016_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_5 _00016_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_6 _00018_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_7 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_8 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_9 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_10 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_11 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_12 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_13 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_14 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_15 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_16 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_17 _00021_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_18 _00023_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_19 _00023_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_20 _00023_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_21 _00023_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_22 _00023_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_23 _00023_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_24 _00027_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_25 _00044_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_26 _00081_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_27 _00081_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_28 _00085_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_29 _00086_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_30 _00086_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_31 _00086_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_32 _00086_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_33 _00086_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_34 _00086_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_35 _00086_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_36 _00086_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_37 _00086_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_38 _00093_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_39 _00157_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_40 _00157_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_41 _00164_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_42 _00166_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_43 _00182_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_44 _00182_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_45 _00182_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_46 _00182_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_47 _00188_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_48 _00209_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_49 _00211_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_50 _00212_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_51 _00218_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_52 _00225_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_53 _00232_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_54 _00253_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_55 _00254_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_56 _00256_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_57 _00265_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_58 _00269_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_59 net309 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_60 net289 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_61 net283 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_62 net264 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_63 _01465_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_64 net217 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_65 _01878_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_66 _01878_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_67 net145 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_68 _02162_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_69 net113 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_70 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_71 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_72 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_73 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_74 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_75 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_76 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_77 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_78 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_79 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_80 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_81 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_82 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_83 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_84 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_85 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_86 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_87 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_88 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_89 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_90 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_91 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_92 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_93 net76 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_94 net21 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_95 net20 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_96 net17 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_97 net17 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_98 net7 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_99 net7 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_100 net7 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_101 net7 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_102 net7 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_103 net7 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_104 net7 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_105 _03574_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_106 _03574_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_107 _03581_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_108 _03581_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_109 _03581_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_110 _03581_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_111 _03635_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_112 _03681_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_113 _03681_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_114 _03762_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_115 _03930_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_116 _08002_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_117 _10664_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_118 net362 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_119 net335 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_120 net331 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_121 net311 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_122 net383 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_123 net333 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_124 net72 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_125 clk VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_126 sa30_sr\[3\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_127 sa30_sub\[0\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_128 text_in_r\[115\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_129 u0.tmp_w\[1\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_130 _00165_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_131 _00165_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_132 _00165_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_133 _00165_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_134 _00210_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_135 _00241_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_136 _00251_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_137 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_138 net77 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_139 net21 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_140 net21 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_141 net21 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_142 net17 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_143 net17 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_144 _00022_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_145 _00043_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_146 _00065_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_147 _00082_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_148 _00279_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_149 _00827_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_150 net21 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_151 net21 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_152 _03636_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_153 _07881_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_154 _11248_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_155 sa21_sub\[2\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_156 sa21_sub\[2\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_157 sa21_sub\[2\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_158 sa30_sub\[6\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_159 _07881_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS aes_cipher_top
