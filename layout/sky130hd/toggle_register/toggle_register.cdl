* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT toggle_register clk data_out[0] data_out[1] data_out[2]
+ data_out[3] data_out[4] data_out[5] data_out[6] data_out[7]
+ enable load_data[0] load_data[1] load_data[2] load_data[3]
+ load_data[4] load_data[5] load_data[6] load_data[7] load_en
+ rst_n toggle_mask[0] toggle_mask[1] toggle_mask[2] toggle_mask[3]
+ toggle_mask[4] toggle_mask[5] toggle_mask[6] toggle_mask[7]
X_35_ net11 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__buf_2
X_36_ net2 VSS VSS VDD VDD _09_ sky130_fd_sc_hd__buf_2
X_37_ _09_ net12 VSS VSS VDD VDD _10_ sky130_fd_sc_hd__nand2_1
X_38_ net11 VSS VSS VDD VDD _11_ sky130_fd_sc_hd__buf_4
X_39_ _11_ net20 VSS VSS VDD VDD _12_ sky130_fd_sc_hd__nor2b_1
X_40_ _08_ net20 net12 _09_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__nor4bb_1
X_41_ _08_ net3 _10_ _12_ _13_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__a221o_1
X_42_ _09_ net13 VSS VSS VDD VDD _14_ sky130_fd_sc_hd__nand2_1
X_43_ _11_ net21 VSS VSS VDD VDD _15_ sky130_fd_sc_hd__nor2b_1
X_44_ _08_ net21 net13 _09_ VSS VSS VDD VDD _16_ sky130_fd_sc_hd__nor4bb_1
X_45_ _08_ net4 _14_ _15_ _16_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__a221o_1
X_46_ _09_ net14 VSS VSS VDD VDD _17_ sky130_fd_sc_hd__nand2_1
X_47_ _11_ net22 VSS VSS VDD VDD _18_ sky130_fd_sc_hd__nor2b_1
X_48_ _11_ net22 net14 net2 VSS VSS VDD VDD _19_ sky130_fd_sc_hd__nor4bb_1
X_49_ _08_ net5 _17_ _18_ _19_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__a221o_1
X_50_ _09_ net15 VSS VSS VDD VDD _20_ sky130_fd_sc_hd__nand2_1
X_51_ _11_ net23 VSS VSS VDD VDD _21_ sky130_fd_sc_hd__nor2b_1
X_52_ _11_ net23 net15 net2 VSS VSS VDD VDD _22_ sky130_fd_sc_hd__nor4bb_1
X_53_ _08_ net6 _20_ _21_ _22_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__a221o_1
X_54_ _09_ net16 VSS VSS VDD VDD _23_ sky130_fd_sc_hd__nand2_1
X_55_ net11 net24 VSS VSS VDD VDD _24_ sky130_fd_sc_hd__nor2b_1
X_56_ _11_ net24 net16 net2 VSS VSS VDD VDD _25_ sky130_fd_sc_hd__nor4bb_1
X_57_ _08_ net7 _23_ _24_ _25_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__a221o_1
X_58_ _09_ net17 VSS VSS VDD VDD _26_ sky130_fd_sc_hd__nand2_1
X_59_ net11 net25 VSS VSS VDD VDD _27_ sky130_fd_sc_hd__nor2b_1
X_60_ _11_ net25 net17 net2 VSS VSS VDD VDD _28_ sky130_fd_sc_hd__nor4bb_1
X_61_ _08_ net8 _26_ _27_ _28_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__a221o_1
X_62_ _09_ net18 VSS VSS VDD VDD _29_ sky130_fd_sc_hd__nand2_1
X_63_ net11 net26 VSS VSS VDD VDD _30_ sky130_fd_sc_hd__nor2b_1
X_64_ _11_ net26 net18 net2 VSS VSS VDD VDD _31_ sky130_fd_sc_hd__nor4bb_1
X_65_ _08_ net9 _29_ _30_ _31_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__a221o_1
X_66_ _09_ net19 VSS VSS VDD VDD _32_ sky130_fd_sc_hd__nand2_1
X_67_ net11 net27 VSS VSS VDD VDD _33_ sky130_fd_sc_hd__nor2b_1
X_68_ _11_ net27 net19 net2 VSS VSS VDD VDD _34_ sky130_fd_sc_hd__nor4bb_1
X_69_ _08_ net10 _32_ _33_ _34_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__a221o_1
Xdata_out\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _00_ net1
+ VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _01_ net1
+ VSS VSS VDD VDD net21 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1
+ VSS VSS VDD VDD net22 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _03_ net1
+ VSS VSS VDD VDD net23 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[4\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _04_ net1
+ VSS VSS VDD VDD net24 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[5\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _05_ net1
+ VSS VSS VDD VDD net25 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _06_ net1
+ VSS VSS VDD VDD net26 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[7\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _07_ net1
+ VSS VSS VDD VDD net27 sky130_fd_sc_hd__dfrtp_1
Xhold1 net28 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 enable VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xinput2 load_data[0] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 load_data[1] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 load_data[2] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 load_data[3] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 load_data[4] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 load_data[5] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 load_data[6] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 load_data[7] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 load_en VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_2
Xinput11 toggle_mask[0] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput12 toggle_mask[1] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput13 toggle_mask[2] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput14 toggle_mask[3] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput15 toggle_mask[4] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput16 toggle_mask[5] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput17 toggle_mask[6] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xinput18 toggle_mask[7] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD data_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net21 VSS VSS VDD VDD data_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net22 VSS VSS VDD VDD data_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput22 net23 VSS VSS VDD VDD data_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput23 net24 VSS VSS VDD VDD data_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput24 net25 VSS VSS VDD VDD data_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput25 net26 VSS VSS VDD VDD data_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput26 net27 VSS VSS VDD VDD data_out[7] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xhold2 rst_n VSS VSS VDD VDD net28 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS toggle_register
