* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT sync_preset_register clk data_in[0] data_in[1] data_in[2]
+ data_in[3] data_in[4] data_in[5] data_in[6] data_in[7] data_out[0]
+ data_out[1] data_out[2] data_out[3] data_out[4] data_out[5]
+ data_out[6] data_out[7] enable rst_n sync_preset sync_rst
X_36_ net10 _08_ VDD VSS INV_X1
X_37_ _08_ net9 _09_ VDD VSS NAND2_X4
X_38_ sync_preset _10_ VDD VSS BUF_X4
X_39_ enable _11_ VDD VSS BUF_X4
X_40_ net11 net1 _11_ _12_ VDD VSS MUX2_X1
X_41_ _10_ _12_ _13_ VDD VSS NOR2_X1
X_42_ _09_ _13_ _00_ VDD VSS NOR2_X1
X_43_ net12 net2 _11_ _14_ VDD VSS MUX2_X1
X_44_ _10_ _14_ _15_ VDD VSS NOR2_X1
X_45_ _09_ _15_ _01_ VDD VSS NOR2_X1
X_46_ net13 net3 _11_ _16_ VDD VSS MUX2_X1
X_47_ _10_ _16_ _17_ VDD VSS NOR2_X1
X_48_ _09_ _17_ _02_ VDD VSS NOR2_X1
X_49_ net14 net4 _11_ _18_ VDD VSS MUX2_X1
X_50_ _10_ _18_ _19_ VDD VSS NOR2_X1
X_51_ _09_ _19_ _03_ VDD VSS NOR2_X1
X_52_ net15 net5 _11_ _20_ VDD VSS MUX2_X1
X_53_ _10_ _20_ _21_ VDD VSS NOR2_X1
X_54_ _09_ _21_ _04_ VDD VSS NOR2_X1
X_55_ net16 net6 _11_ _22_ VDD VSS MUX2_X1
X_56_ _10_ _22_ _23_ VDD VSS NOR2_X1
X_57_ _09_ _23_ _05_ VDD VSS NOR2_X1
X_58_ net17 net7 _11_ _24_ VDD VSS MUX2_X1
X_59_ _10_ _24_ _25_ VDD VSS NOR2_X1
X_60_ _09_ _25_ _06_ VDD VSS NOR2_X1
X_61_ net18 net8 _11_ _26_ VDD VSS MUX2_X1
X_62_ _10_ _26_ _27_ VDD VSS NOR2_X1
X_63_ _09_ _27_ _07_ VDD VSS NOR2_X1
Xdata_out\[0\]$_SDFFE_PP0P_ _00_ clknet_1_0__leaf_clk net11
+ _35_ VDD VSS DFF_X1
Xdata_out\[1\]$_SDFFE_PP0P_ _01_ clknet_1_0__leaf_clk net12
+ _34_ VDD VSS DFF_X1
Xdata_out\[2\]$_SDFFE_PP0P_ _02_ clknet_1_1__leaf_clk net13
+ _33_ VDD VSS DFF_X1
Xdata_out\[3\]$_SDFFE_PP0P_ _03_ clknet_1_1__leaf_clk net14
+ _32_ VDD VSS DFF_X1
Xdata_out\[4\]$_SDFFE_PP0P_ _04_ clknet_1_0__leaf_clk net15
+ _31_ VDD VSS DFF_X1
Xdata_out\[5\]$_SDFFE_PP0P_ _05_ clknet_1_1__leaf_clk net16
+ _30_ VDD VSS DFF_X1
Xdata_out\[6\]$_SDFFE_PP0P_ _06_ clknet_1_0__leaf_clk net17
+ _29_ VDD VSS DFF_X1
Xdata_out\[7\]$_SDFFE_PP0P_ _07_ clknet_1_1__leaf_clk net18
+ _28_ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_51 VDD VSS TAPCELL_X1
Xinput1 data_in[0] net1 VDD VSS BUF_X1
Xinput2 data_in[1] net2 VDD VSS BUF_X1
Xinput3 data_in[2] net3 VDD VSS BUF_X1
Xinput4 data_in[3] net4 VDD VSS BUF_X1
Xinput5 data_in[4] net5 VDD VSS BUF_X1
Xinput6 data_in[5] net6 VDD VSS BUF_X1
Xinput7 data_in[6] net7 VDD VSS BUF_X1
Xinput8 data_in[7] net8 VDD VSS BUF_X1
Xinput9 rst_n net9 VDD VSS BUF_X1
Xinput10 sync_rst net10 VDD VSS BUF_X1
Xoutput11 net11 data_out[0] VDD VSS BUF_X1
Xoutput12 net12 data_out[1] VDD VSS BUF_X1
Xoutput13 net13 data_out[2] VDD VSS BUF_X1
Xoutput14 net14 data_out[3] VDD VSS BUF_X1
Xoutput15 net15 data_out[4] VDD VSS BUF_X1
Xoutput16 net16 data_out[5] VDD VSS BUF_X1
Xoutput17 net17 data_out[6] VDD VSS BUF_X1
Xoutput18 net18 data_out[7] VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ CLKBUF_X3
.ENDS sync_preset_register
