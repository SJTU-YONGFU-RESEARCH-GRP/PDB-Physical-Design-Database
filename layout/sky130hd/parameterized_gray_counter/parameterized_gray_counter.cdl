* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_gray_counter binary_out[0] binary_out[1]
+ binary_out[2] binary_out[3] clk enable gray_out[0] gray_out[1]
+ gray_out[2] gray_out[3] rst_n
X_13_ net3 net1 VSS VSS VDD VDD _04_ sky130_fd_sc_hd__xor2_1
X_14_ net2 _04_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__and2_0
X_15_ net4 net7 net1 VSS VSS VDD VDD _05_ sky130_fd_sc_hd__mux2i_1
X_16_ _05_ net2 VSS VSS VDD VDD _01_ sky130_fd_sc_hd__nor2b_1
X_17_ _11_ net1 net5 VSS VSS VDD VDD _06_ sky130_fd_sc_hd__a21boi_0
X_18_ net5 net1 _11_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__and3b_1
X_19_ _06_ _07_ net2 VSS VSS VDD VDD _02_ sky130_fd_sc_hd__o21a_1
X_20_ net6 net2 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__nand2b_1
X_21_ net6 net2 VSS VSS VDD VDD _09_ sky130_fd_sc_hd__nand2_1
X_22_ net3 _12_ net1 VSS VSS VDD VDD _10_ sky130_fd_sc_hd__nand3_1
X_23_ _08_ _09_ _10_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__mux2i_1
X_24_ net5 net6 VSS VSS VDD VDD net9 sky130_fd_sc_hd__xor2_1
X_25_ net3 net4 VSS VSS VDD VDD _11_ net7 sky130_fd_sc_hd__ha_1
X_26_ net4 net5 VSS VSS VDD VDD _12_ net8 sky130_fd_sc_hd__ha_1
X_27_ net6 VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xbinary_count\[0\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _00_
+ VSS VSS VDD VDD net3 sky130_fd_sc_hd__dfxtp_1
Xbinary_count\[1\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _01_
+ VSS VSS VDD VDD net4 sky130_fd_sc_hd__dfxtp_1
Xbinary_count\[2\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _02_
+ VSS VSS VDD VDD net5 sky130_fd_sc_hd__dfxtp_1
Xbinary_count\[3\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _03_
+ VSS VSS VDD VDD net6 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 enable VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_2
Xinput2 rst_n VSS VSS VDD VDD net2 sky130_fd_sc_hd__dlymetal6s2s_1
Xoutput3 net3 VSS VSS VDD VDD binary_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput4 net4 VSS VSS VDD VDD binary_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net5 VSS VSS VDD VDD binary_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput6 net6 VSS VSS VDD VDD binary_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput7 net7 VSS VSS VDD VDD gray_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net8 VSS VSS VDD VDD gray_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net9 VSS VSS VDD VDD gray_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net10 VSS VSS VDD VDD gray_out[3] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
.ENDS parameterized_gray_counter
