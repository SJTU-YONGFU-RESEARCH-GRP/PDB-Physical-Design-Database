* cell parameterized_fft
* pin data_out_real[96]
* pin data_ready
* pin busy
* pin start
* pin data_valid_out
* pin data_valid_in
* pin data_out_imag[111]
* pin data_out_imag[95]
* pin data_out_imag[92]
* pin data_out_imag[94]
* pin data_out_imag[108]
* pin data_out_imag[109]
* pin data_out_imag[110]
* pin data_out_imag[64]
* pin data_out_imag[60]
* pin data_out_imag[93]
* pin data_out_imag[61]
* pin data_out_imag[15]
* pin data_out_imag[58]
* pin data_out_imag[62]
* pin data_out_imag[96]
* pin data_out_imag[127]
* pin data_out_imag[126]
* pin data_out_imag[12]
* pin data_out_imag[14]
* pin data_out_imag[0]
* pin data_out_real[0]
* pin data_in_real[0]
* pin data_out_imag[13]
* pin data_in_imag[0]
* pin data_out_imag[80]
* pin data_out_imag[79]
* pin data_out_imag[77]
* pin data_out_real[48]
* pin data_in_imag[14]
* pin data_in_imag[12]
* pin data_in_imag[15]
* pin data_in_imag[13]
* pin data_out_real[47]
* pin data_out_real[95]
* pin data_out_imag[63]
* pin data_out_real[35]
* pin data_out_real[84]
* pin data_out_imag[76]
* pin data_out_real[80]
* pin data_out_imag[32]
* pin data_out_real[36]
* pin data_out_imag[112]
* pin data_out_imag[78]
* pin data_out_imag[31]
* pin data_out_imag[125]
* pin data_out_imag[48]
* pin data_out_imag[30]
* pin data_out_imag[47]
* pin data_out_imag[46]
* pin data_out_imag[45]
* pin data_out_imag[124]
* pin data_out_real[4]
* pin data_out_real[52]
* pin data_out_imag[16]
* pin data_out_imag[29]
* pin data_out_real[51]
* pin data_out_imag[107]
* pin data_out_real[49]
* pin data_out_real[100]
* pin data_out_imag[44]
* pin data_out_real[115]
* pin data_out_imag[28]
* pin data_out_imag[75]
* pin data_out_imag[43]
* pin data_out_imag[27]
* pin data_in_imag[11]
* pin data_out_real[116]
* pin data_in_real[4]
* pin data_in_real[3]
* pin data_out_imag[59]
* pin data_out_real[101]
* pin data_out_real[67]
* pin data_out_imag[91]
* pin data_out_imag[26]
* pin data_out_imag[42]
* pin data_in_imag[10]
* pin data_out_real[68]
* pin data_out_imag[74]
* pin data_out_imag[113]
* pin data_out_real[117]
* pin data_out_imag[49]
* pin data_out_real[37]
* pin clk
* pin data_out_imag[17]
* pin data_out_real[69]
* pin data_in_imag[1]
* pin data_out_imag[1]
* pin data_out_imag[33]
* pin data_out_real[5]
* pin data_out_real[53]
* pin data_in_real[5]
* pin data_out_imag[65]
* pin data_out_real[54]
* pin data_in_imag[2]
* pin data_out_imag[34]
* pin data_out_imag[66]
* pin data_out_imag[50]
* pin data_out_real[70]
* pin data_out_imag[18]
* pin data_out_imag[81]
* pin data_out_imag[2]
* pin data_out_imag[19]
* pin data_in_imag[3]
* pin data_out_imag[35]
* pin data_out_imag[51]
* pin data_out_imag[84]
* pin data_out_imag[3]
* pin data_in_imag[4]
* pin data_out_imag[67]
* pin data_out_imag[52]
* pin data_out_imag[68]
* pin data_out_imag[36]
* pin data_out_imag[4]
* pin data_out_imag[9]
* pin data_out_imag[7]
* pin data_out_imag[20]
* pin data_out_imag[37]
* pin data_out_imag[6]
* pin data_out_imag[38]
* pin data_in_real[2]
* pin data_in_real[7]
* pin data_in_real[10]
* pin data_out_real[105]
* pin data_out_real[89]
* pin data_out_imag[106]
* pin data_in_imag[7]
* pin data_in_real[6]
* pin data_out_real[121]
* pin data_out_real[85]
* pin data_out_real[30]
* pin data_out_real[31]
* pin data_out_real[3]
* pin data_in_real[12]
* pin data_in_real[13]
* pin data_in_imag[8]
* pin data_out_imag[55]
* pin data_out_imag[120]
* pin data_out_real[82]
* pin data_out_imag[115]
* pin data_out_real[123]
* pin data_in_real[9]
* pin data_out_real[32]
* pin data_out_real[24]
* pin data_out_real[77]
* pin data_out_real[91]
* pin data_out_imag[11]
* pin data_in_imag[9]
* pin data_out_imag[8]
* pin data_out_imag[104]
* pin data_out_imag[102]
* pin data_out_imag[10]
* pin data_out_real[112]
* pin data_in_real[11]
* pin data_out_real[98]
* pin data_in_real[15]
* pin data_out_real[19]
* pin data_out_real[99]
* pin data_out_imag[122]
* pin data_out_real[55]
* pin data_out_imag[101]
* pin data_out_real[87]
* pin data_out_imag[105]
* pin data_out_imag[86]
* pin data_out_real[83]
* pin data_out_imag[57]
* pin data_out_real[122]
* pin data_out_imag[99]
* pin data_out_real[17]
* pin data_out_real[59]
* pin data_out_real[56]
* pin data_out_real[39]
* pin data_out_real[23]
* pin data_out_real[9]
* pin data_out_real[20]
* pin data_out_real[61]
* pin data_out_real[42]
* pin data_out_imag[103]
* pin data_out_real[57]
* pin data_out_real[21]
* pin data_out_imag[53]
* pin data_out_real[86]
* pin data_in_real[8]
* pin data_out_real[26]
* pin data_out_real[29]
* pin data_out_real[40]
* pin data_out_real[65]
* pin data_out_imag[121]
* pin data_out_real[124]
* pin data_out_real[64]
* pin data_out_real[22]
* pin data_out_real[45]
* pin data_out_imag[89]
* pin data_out_imag[56]
* pin data_out_imag[118]
* pin data_out_real[6]
* pin data_out_imag[40]
* pin data_out_imag[39]
* pin data_out_real[34]
* pin data_out_imag[24]
* pin data_out_real[7]
* pin data_out_imag[23]
* pin data_out_real[74]
* pin data_out_imag[71]
* pin data_out_real[2]
* pin rst_n
* pin data_out_real[104]
* pin data_out_imag[100]
* pin data_out_imag[90]
* pin data_out_real[18]
* pin data_out_imag[114]
* pin data_out_real[28]
* pin data_out_real[90]
* pin data_out_real[27]
* pin data_out_real[58]
* pin data_out_real[110]
* pin data_out_real[107]
* pin data_out_real[16]
* pin data_out_real[93]
* pin data_out_real[78]
* pin data_out_real[111]
* pin data_in_real[14]
* pin data_out_real[60]
* pin data_out_real[71]
* pin data_out_real[50]
* pin data_out_real[118]
* pin data_out_real[38]
* pin data_out_real[114]
* pin data_out_real[72]
* pin data_out_real[66]
* pin data_out_real[73]
* pin data_out_real[75]
* pin data_out_real[102]
* pin data_out_real[103]
* pin data_out_real[88]
* pin data_out_real[8]
* pin data_out_real[25]
* pin data_out_real[120]
* pin data_out_real[119]
* pin data_out_real[81]
* pin data_out_real[33]
* pin data_out_real[41]
* pin data_out_real[97]
* pin data_out_real[126]
* pin data_out_real[109]
* pin data_in_real[1]
* pin data_out_real[1]
* pin data_out_real[46]
* pin data_out_real[15]
* pin data_out_real[113]
* pin data_out_real[127]
* pin data_out_real[108]
* pin data_out_real[62]
* pin data_out_real[44]
* pin data_out_real[79]
* pin data_out_real[92]
* pin data_out_real[76]
* pin data_out_real[94]
* pin data_out_real[63]
* pin data_out_real[12]
* pin data_out_real[125]
* pin data_out_real[14]
* pin data_out_real[13]
* pin data_out_real[106]
* pin data_out_imag[98]
* pin data_out_real[43]
* pin data_out_real[11]
* pin data_out_real[10]
* pin data_out_imag[82]
* pin data_out_imag[123]
* pin data_out_imag[88]
* pin data_out_imag[116]
* pin data_out_imag[54]
* pin data_out_imag[97]
* pin data_out_imag[83]
* pin data_out_imag[119]
* pin data_out_imag[117]
* pin data_out_imag[87]
* pin data_out_imag[85]
* pin data_out_imag[5]
* pin data_in_imag[6]
* pin data_in_imag[5]
* pin data_out_imag[73]
* pin data_out_imag[72]
* pin data_out_imag[70]
* pin data_out_imag[69]
* pin data_out_imag[25]
* pin data_out_imag[21]
* pin data_out_imag[22]
* pin data_out_imag[41]
* pin NWELL
* pin PWELL,gf180mcu_gnd
.SUBCKT parameterized_fft 1 2 3 4 5 6 4181 4224 4225 4266 4267 4268 4269 4339
+ 4340 4341 4380 4381 4382 4383 4433 4434 4497 4498 4499 4566 4567 4632 4633
+ 4713 4715 4773 4869 4930 4931 4932 4933 4934 5012 5136 5137 5183 5306 5350
+ 5351 5352 5379 5493 5494 5495 5558 5559 5560 5561 5638 5781 5782 5804 5877
+ 5982 6032 6064 6099 6126 6127 6165 6281 6318 6319 6387 6388 6389 6418 6473
+ 6474 6500 6527 6578 6605 6606 6607 6608 6616 6691 6692 6701 6729 6746 6778
+ 6792 6858 6898 6899 6900 6915 6972 6973 7012 7150 7189 7190 7191 7192 7216
+ 7250 7251 7315 7424 7468 7469 7470 7532 7533 7693 7694 7822 7823 7974 8023
+ 8087 8088 8089 8133 8304 8305 8896 8946 8947 8949 8960 8965 8974 8977 8981
+ 8982 8983 8984 8997 9001 9002 9013 9014 9016 9017 9018 9019 9020 9023 9030
+ 9038 9039 9043 9055 9066 9069 9070 9074 9075 9076 9077 9078 9082 9083 9094
+ 9106 9108 9109 9110 9111 9113 9114 9116 9117 9118 9119 9120 9122 9125 9126
+ 9127 9134 9136 9139 9142 9144 9145 9146 9148 9149 9150 9151 9152 9153 9155
+ 9161 9162 9163 9164 9165 9166 9168 9169 9170 9171 9172 9173 9174 9175 9176
+ 9177 9178 9179 9180 9181 9182 9183 9184 9185 9186 9187 9188 9189 9190 9191
+ 9192 9193 9194 9195 9196 9197 9198 9199 9200 9201 9202 9203 9204 9205 9206
+ 9207 9208 9209 9210 9211 9212 9213 9214 9215 9216 9217 9218 9219 9220 9221
+ 9222 9223 9224 9225 9226 9227 9228 9229 9230 9231 9232 9233 9234 9235 9236
+ 9237 9238 9239 9240 9241 9242 9243 9244 9245 9246 9247 9248 9249 9250 9251
+ 9252 9253 9254 9255 9256 9257 9258 9259 9260 9261 9262 9263 9264
* net 1 data_out_real[96]
* net 2 data_ready
* net 3 busy
* net 4 start
* net 5 data_valid_out
* net 6 data_valid_in
* net 4181 data_out_imag[111]
* net 4224 data_out_imag[95]
* net 4225 data_out_imag[92]
* net 4266 data_out_imag[94]
* net 4267 data_out_imag[108]
* net 4268 data_out_imag[109]
* net 4269 data_out_imag[110]
* net 4339 data_out_imag[64]
* net 4340 data_out_imag[60]
* net 4341 data_out_imag[93]
* net 4380 data_out_imag[61]
* net 4381 data_out_imag[15]
* net 4382 data_out_imag[58]
* net 4383 data_out_imag[62]
* net 4433 data_out_imag[96]
* net 4434 data_out_imag[127]
* net 4497 data_out_imag[126]
* net 4498 data_out_imag[12]
* net 4499 data_out_imag[14]
* net 4566 data_out_imag[0]
* net 4567 data_out_real[0]
* net 4632 data_in_real[0]
* net 4633 data_out_imag[13]
* net 4713 data_in_imag[0]
* net 4715 data_out_imag[80]
* net 4773 data_out_imag[79]
* net 4869 data_out_imag[77]
* net 4930 data_out_real[48]
* net 4931 data_in_imag[14]
* net 4932 data_in_imag[12]
* net 4933 data_in_imag[15]
* net 4934 data_in_imag[13]
* net 5012 data_out_real[47]
* net 5136 data_out_real[95]
* net 5137 data_out_imag[63]
* net 5183 data_out_real[35]
* net 5306 data_out_real[84]
* net 5350 data_out_imag[76]
* net 5351 data_out_real[80]
* net 5352 data_out_imag[32]
* net 5379 data_out_real[36]
* net 5493 data_out_imag[112]
* net 5494 data_out_imag[78]
* net 5495 data_out_imag[31]
* net 5558 data_out_imag[125]
* net 5559 data_out_imag[48]
* net 5560 data_out_imag[30]
* net 5561 data_out_imag[47]
* net 5638 data_out_imag[46]
* net 5781 data_out_imag[45]
* net 5782 data_out_imag[124]
* net 5804 data_out_real[4]
* net 5877 data_out_real[52]
* net 5982 data_out_imag[16]
* net 6032 data_out_imag[29]
* net 6064 data_out_real[51]
* net 6099 data_out_imag[107]
* net 6126 data_out_real[49]
* net 6127 data_out_real[100]
* net 6165 data_out_imag[44]
* net 6281 data_out_real[115]
* net 6318 data_out_imag[28]
* net 6319 data_out_imag[75]
* net 6387 data_out_imag[43]
* net 6388 data_out_imag[27]
* net 6389 data_in_imag[11]
* net 6418 data_out_real[116]
* net 6473 data_in_real[4]
* net 6474 data_in_real[3]
* net 6500 data_out_imag[59]
* net 6527 data_out_real[101]
* net 6578 data_out_real[67]
* net 6605 data_out_imag[91]
* net 6606 data_out_imag[26]
* net 6607 data_out_imag[42]
* net 6608 data_in_imag[10]
* net 6616 data_out_real[68]
* net 6691 data_out_imag[74]
* net 6692 data_out_imag[113]
* net 6701 data_out_real[117]
* net 6729 data_out_imag[49]
* net 6746 data_out_real[37]
* net 6778 clk
* net 6792 data_out_imag[17]
* net 6858 data_out_real[69]
* net 6898 data_in_imag[1]
* net 6899 data_out_imag[1]
* net 6900 data_out_imag[33]
* net 6915 data_out_real[5]
* net 6972 data_out_real[53]
* net 6973 data_in_real[5]
* net 7012 data_out_imag[65]
* net 7150 data_out_real[54]
* net 7189 data_in_imag[2]
* net 7190 data_out_imag[34]
* net 7191 data_out_imag[66]
* net 7192 data_out_imag[50]
* net 7216 data_out_real[70]
* net 7250 data_out_imag[18]
* net 7251 data_out_imag[81]
* net 7315 data_out_imag[2]
* net 7424 data_out_imag[19]
* net 7468 data_in_imag[3]
* net 7469 data_out_imag[35]
* net 7470 data_out_imag[51]
* net 7532 data_out_imag[84]
* net 7533 data_out_imag[3]
* net 7693 data_in_imag[4]
* net 7694 data_out_imag[67]
* net 7822 data_out_imag[52]
* net 7823 data_out_imag[68]
* net 7974 data_out_imag[36]
* net 8023 data_out_imag[4]
* net 8087 data_out_imag[9]
* net 8088 data_out_imag[7]
* net 8089 data_out_imag[20]
* net 8133 data_out_imag[37]
* net 8304 data_out_imag[6]
* net 8305 data_out_imag[38]
* net 8896 data_in_real[2]
* net 8946 data_in_real[7]
* net 8947 data_in_real[10]
* net 8949 data_out_real[105]
* net 8960 data_out_real[89]
* net 8965 data_out_imag[106]
* net 8974 data_in_imag[7]
* net 8977 data_in_real[6]
* net 8981 data_out_real[121]
* net 8982 data_out_real[85]
* net 8983 data_out_real[30]
* net 8984 data_out_real[31]
* net 8997 data_out_real[3]
* net 9001 data_in_real[12]
* net 9002 data_in_real[13]
* net 9013 data_in_imag[8]
* net 9014 data_out_imag[55]
* net 9016 data_out_imag[120]
* net 9017 data_out_real[82]
* net 9018 data_out_imag[115]
* net 9019 data_out_real[123]
* net 9020 data_in_real[9]
* net 9023 data_out_real[32]
* net 9030 data_out_real[24]
* net 9038 data_out_real[77]
* net 9039 data_out_real[91]
* net 9043 data_out_imag[11]
* net 9055 data_in_imag[9]
* net 9066 data_out_imag[8]
* net 9069 data_out_imag[104]
* net 9070 data_out_imag[102]
* net 9074 data_out_imag[10]
* net 9075 data_out_real[112]
* net 9076 data_in_real[11]
* net 9077 data_out_real[98]
* net 9078 data_in_real[15]
* net 9082 data_out_real[19]
* net 9083 data_out_real[99]
* net 9094 data_out_imag[122]
* net 9106 data_out_real[55]
* net 9108 data_out_imag[101]
* net 9109 data_out_real[87]
* net 9110 data_out_imag[105]
* net 9111 data_out_imag[86]
* net 9113 data_out_real[83]
* net 9114 data_out_imag[57]
* net 9116 data_out_real[122]
* net 9117 data_out_imag[99]
* net 9118 data_out_real[17]
* net 9119 data_out_real[59]
* net 9120 data_out_real[56]
* net 9122 data_out_real[39]
* net 9125 data_out_real[23]
* net 9126 data_out_real[9]
* net 9127 data_out_real[20]
* net 9134 data_out_real[61]
* net 9136 data_out_real[42]
* net 9139 data_out_imag[103]
* net 9142 data_out_real[57]
* net 9144 data_out_real[21]
* net 9145 data_out_imag[53]
* net 9146 data_out_real[86]
* net 9148 data_in_real[8]
* net 9149 data_out_real[26]
* net 9150 data_out_real[29]
* net 9151 data_out_real[40]
* net 9152 data_out_real[65]
* net 9153 data_out_imag[121]
* net 9155 data_out_real[124]
* net 9161 data_out_real[64]
* net 9162 data_out_real[22]
* net 9163 data_out_real[45]
* net 9164 data_out_imag[89]
* net 9165 data_out_imag[56]
* net 9166 data_out_imag[118]
* net 9168 data_out_real[6]
* net 9169 data_out_imag[40]
* net 9170 data_out_imag[39]
* net 9171 data_out_real[34]
* net 9172 data_out_imag[24]
* net 9173 data_out_real[7]
* net 9174 data_out_imag[23]
* net 9175 data_out_real[74]
* net 9176 data_out_imag[71]
* net 9177 data_out_real[2]
* net 9178 rst_n
* net 9179 data_out_real[104]
* net 9180 data_out_imag[100]
* net 9181 data_out_imag[90]
* net 9182 data_out_real[18]
* net 9183 data_out_imag[114]
* net 9184 data_out_real[28]
* net 9185 data_out_real[90]
* net 9186 data_out_real[27]
* net 9187 data_out_real[58]
* net 9188 data_out_real[110]
* net 9189 data_out_real[107]
* net 9190 data_out_real[16]
* net 9191 data_out_real[93]
* net 9192 data_out_real[78]
* net 9193 data_out_real[111]
* net 9194 data_in_real[14]
* net 9195 data_out_real[60]
* net 9196 data_out_real[71]
* net 9197 data_out_real[50]
* net 9198 data_out_real[118]
* net 9199 data_out_real[38]
* net 9200 data_out_real[114]
* net 9201 data_out_real[72]
* net 9202 data_out_real[66]
* net 9203 data_out_real[73]
* net 9204 data_out_real[75]
* net 9205 data_out_real[102]
* net 9206 data_out_real[103]
* net 9207 data_out_real[88]
* net 9208 data_out_real[8]
* net 9209 data_out_real[25]
* net 9210 data_out_real[120]
* net 9211 data_out_real[119]
* net 9212 data_out_real[81]
* net 9213 data_out_real[33]
* net 9214 data_out_real[41]
* net 9215 data_out_real[97]
* net 9216 data_out_real[126]
* net 9217 data_out_real[109]
* net 9218 data_in_real[1]
* net 9219 data_out_real[1]
* net 9220 data_out_real[46]
* net 9221 data_out_real[15]
* net 9222 data_out_real[113]
* net 9223 data_out_real[127]
* net 9224 data_out_real[108]
* net 9225 data_out_real[62]
* net 9226 data_out_real[44]
* net 9227 data_out_real[79]
* net 9228 data_out_real[92]
* net 9229 data_out_real[76]
* net 9230 data_out_real[94]
* net 9231 data_out_real[63]
* net 9232 data_out_real[12]
* net 9233 data_out_real[125]
* net 9234 data_out_real[14]
* net 9235 data_out_real[13]
* net 9236 data_out_real[106]
* net 9237 data_out_imag[98]
* net 9238 data_out_real[43]
* net 9239 data_out_real[11]
* net 9240 data_out_real[10]
* net 9241 data_out_imag[82]
* net 9242 data_out_imag[123]
* net 9243 data_out_imag[88]
* net 9244 data_out_imag[116]
* net 9245 data_out_imag[54]
* net 9246 data_out_imag[97]
* net 9247 data_out_imag[83]
* net 9248 data_out_imag[119]
* net 9249 data_out_imag[117]
* net 9250 data_out_imag[87]
* net 9251 data_out_imag[85]
* net 9252 data_out_imag[5]
* net 9253 data_in_imag[6]
* net 9254 data_in_imag[5]
* net 9255 data_out_imag[73]
* net 9256 data_out_imag[72]
* net 9257 data_out_imag[70]
* net 9258 data_out_imag[69]
* net 9259 data_out_imag[25]
* net 9260 data_out_imag[21]
* net 9261 data_out_imag[22]
* net 9262 data_out_imag[41]
* net 9263 NWELL
* net 9264 PWELL,gf180mcu_gnd
* cell instance $3 r0 *1 547.68,5.04
X$3 10 9263 9264 1 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8 r0 *1 590.8,5.04
X$8 7 9263 9264 2 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11 r0 *1 564.48,5.04
X$11 8 9263 9264 3 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15 m0 *1 590.8,15.12
X$15 4 9263 9264 21 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $19 r0 *1 572.88,5.04
X$19 9 9263 9264 5 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $23 m0 *1 582.96,15.12
X$23 9264 9263 6 26 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $28 r0 *1 717.36,438.48
X$28 9264 9263 7 4097 4055 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30 m0 *1 706.16,438.48
X$30 9264 7 9263 4100 4013 3941 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $35 r0 *1 700,428.4
X$35 9264 7 3974 4056 2246 9263 gf180mcu_fd_sc_mcu9t5v0__dffsnq_4
* cell instance $38 m0 *1 714.56,438.48
X$38 9264 9263 4014 7 3837 4012 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42 m0 *1 663.04,418.32
X$42 9264 3809 9263 3836 3811 8 3808 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $50 r0 *1 658.56,408.24
X$50 9264 2246 8 2292 3746 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $53 r0 *1 665.28,418.32
X$53 9264 9263 3836 8 3837 3808 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56 m0 *1 655.2,418.32
X$56 9264 9263 9 3835 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61 m0 *1 640.64,408.24
X$61 9264 2246 9 2292 3812 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $63 r0 *1 650.16,408.24
X$63 9264 9263 3784 3806 21 9 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67 m0 *1 565.6,418.32
X$67 9264 9263 3814 3831 3806 10 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74 r0 *1 558.32,408.24
X$74 9264 2246 10 3974 3814 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $76 m0 *1 442.4,35.28
X$76 9263 11 12 9264 102 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $78 r0 *1 442.96,15.12
X$78 9264 9263 11 34 12 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $87 r0 *1 458.08,75.6
X$87 488 9263 224 324 9264 11 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $90 m0 *1 447.44,95.76
X$90 9264 78 35 11 937 721 9263 865 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $92 m0 *1 441.28,25.2
X$92 9264 103 32 15 34 77 11 9263 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $95 r0 *1 453.04,15.12
X$95 11 9264 16 35 9263 51 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $98 m0 *1 464.24,35.28
X$98 81 9263 12 119 9264 117 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $102 m0 *1 454.16,35.28
X$102 9263 78 9264 144 35 12 36 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $105 r0 *1 462,25.2
X$105 9263 12 79 9264 69 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $107 m0 *1 431.76,25.2
X$107 9263 12 51 9264 33 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $110 m0 *1 449.12,35.28
X$110 9264 9263 12 103 79 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $120 r0 *1 476,25.2
X$120 9263 37 52 80 82 12 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $123 m0 *1 492.8,35.28
X$123 9264 12 83 121 9263 gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* cell instance $125 r0 *1 448,15.12
X$125 9264 9263 13 68 14 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $128 m0 *1 448.56,15.12
X$128 9263 13 14 9264 15 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $130 m0 *1 465.36,25.2
X$130 9264 36 37 9263 13 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $136 r0 *1 467.6,15.12
X$136 9264 14 36 17 38 9263 37 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $143 m0 *1 509.6,45.36
X$143 9264 267 159 211 198 9263 16 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $145 m0 *1 474.32,25.2
X$145 9264 52 9263 71 16 81 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $148 m0 *1 457.52,45.36
X$148 38 16 17 9264 9263 197 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $150 r0 *1 459.76,35.28
X$150 9264 16 9263 77 119 106 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $152 m0 *1 468.16,55.44
X$152 9264 17 264 38 16 261 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $161 r0 *1 480.48,55.44
X$161 9263 297 9264 380 16 263 325 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $167 r0 *1 506.24,55.44
X$167 9263 327 328 17 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $170 m0 *1 479.36,35.28
X$170 9263 38 17 9264 82 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $175 r0 *1 459.76,15.12
X$175 9264 36 9263 79 17 38 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $180 r0 *1 454.72,35.28
X$180 9264 9263 38 35 17 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $182 m0 *1 470.96,35.28
X$182 78 38 17 120 9264 9263 119 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $190 r0 *1 644,15.12
X$190 18 9263 46 28 9264 280 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $194 m0 *1 650.16,15.12
X$194 19 20 23 39 9263 9264 18 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $196 r0 *1 650.16,15.12
X$196 20 19 27 28 65 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $198 m0 *1 658,15.12
X$198 19 9263 22 23 9264 27 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $200 m0 *1 669.76,25.2
X$200 9264 9263 40 19 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $202 m0 *1 650.72,25.2
X$202 65 9263 9264 22 19 20 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $207 r0 *1 659.68,15.12
X$207 9264 46 19 9263 22 39 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $220 m0 *1 663.04,35.28
X$220 9263 40 20 9264 132 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $222 r0 *1 655.76,35.28
X$222 9264 22 174 131 20 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $224 m0 *1 664.16,408.24
X$224 9264 9263 21 3837 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $236 m0 *1 658.56,25.2
X$236 22 23 40 9264 9263 95 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $240 m0 *1 641.76,45.36
X$240 9263 22 206 9264 202 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $243 r0 *1 648.48,45.36
X$243 9264 40 281 232 22 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $263 r0 *1 656.88,55.44
X$263 9264 23 281 237 405 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $265 m0 *1 651.84,45.36
X$265 9264 23 39 9263 206 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $267 m0 *1 708.4,25.2
X$267 25 99 24 9264 9263 44 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $270 m0 *1 701.68,45.36
X$270 9264 284 9263 204 170 24 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $273 r0 *1 691.6,15.12
X$273 24 25 45 42 9264 9263 43 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $275 r0 *1 713.44,55.44
X$275 9263 24 9264 171 340 285 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $283 m0 *1 694.4,55.44
X$283 9264 284 24 168 339 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $285 m0 *1 728.56,55.44
X$285 24 9264 285 171 9263 286 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $287 r0 *1 689.92,25.2
X$287 9264 140 45 25 24 9263 42 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $289 r0 *1 708.4,35.28
X$289 9263 24 170 9264 135 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $294 r0 *1 702.8,45.36
X$294 9263 341 287 235 25 45 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $297 m0 *1 698.88,35.28
X$297 9263 25 9264 62 134 99 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $300 m0 *1 706.16,55.44
X$300 9263 25 99 9264 172 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $306 m0 *1 708.96,45.36
X$306 9264 170 25 205 131 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $308 m0 *1 706.72,35.28
X$308 25 9264 99 62 9263 136 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $313 m0 *1 721.84,458.64
X$313 9264 9263 26 4055 4222 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $316 r0 *1 719.6,478.8
X$316 9263 3975 26 9264 4426 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $322 m0 *1 721.28,448.56
X$322 9264 4012 26 9263 4094 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $324 m0 *1 715.12,498.96
X$324 9264 4487 9263 4622 4725 26 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $334 r0 *1 410.48,25.2
X$334 9264 33 9263 143 31 29 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $336 m0 *1 400.96,25.2
X$336 32 9263 29 31 9264 49 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $339 m0 *1 407.12,25.2
X$339 29 9263 31 33 9264 76 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $342 m0 *1 374.08,75.6
X$342 9264 507 29 190 258 193 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $344 m0 *1 394.8,45.36
X$344 9263 29 31 9264 192 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $346 m0 *1 393.68,25.2
X$346 9264 9263 29 30 31 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $355 r0 *1 446.32,85.68
X$355 9264 29 696 601 9263 gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* cell instance $357 m0 *1 384.72,55.44
X$357 193 29 190 258 9263 9264 371 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $359 m0 *1 402.64,35.28
X$359 9264 155 31 101 32 29 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $361 r0 *1 393.68,25.2
X$361 9264 9263 30 75 48 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $364 r0 *1 385.28,25.2
X$364 9264 9263 30 73 47 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $378 r0 *1 416.08,55.44
X$378 9264 9263 31 348 259 320 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $380 r0 *1 396.48,35.28
X$380 9264 101 9263 153 31 32 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $415 r0 *1 508.48,25.2
X$415 9264 9263 36 84 123 124 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $426 m0 *1 470.4,105.84
X$426 778 9263 743 825 9264 37 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $429 r0 *1 474.32,75.6
X$429 9263 510 511 38 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $447 m0 *1 658,95.76
X$447 9264 667 9263 39 660 706 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $466 m0 *1 660.8,45.36
X$466 9264 100 40 168 203 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $469 r0 *1 689.36,35.28
X$469 9264 9263 60 97 41 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $471 m0 *1 683.2,25.2
X$471 9263 60 41 9264 61 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $474 r0 *1 700,25.2
X$474 9264 98 9263 62 41 60 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $476 m0 *1 677.04,25.2
X$476 98 9263 60 41 9264 59 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $479 r0 *1 700,55.44
X$479 9264 41 235 476 341 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $488 r0 *1 707.28,25.2
X$488 9264 44 42 64 135 284 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $490 m0 *1 719.6,25.2
X$490 9263 44 42 63 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $492 m0 *1 711.2,55.44
X$492 9264 286 340 42 284 615 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $494 m0 *1 683.76,176.4
X$494 9264 42 1489 1444 1218 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $502 m0 *1 688.24,25.2
X$502 9264 338 43 97 133 63 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $510 r0 *1 694.4,35.28
X$510 9264 9263 45 98 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $520 r0 *1 716.8,45.36
X$520 9264 99 45 237 236 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $527 r0 *1 398.72,25.2
X$527 9264 47 9263 48 72 49 50 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $530 r0 *1 375.76,25.2
X$530 76 9264 47 9263 154 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $535 r0 *1 467.6,25.2
X$535 9264 9263 47 71 120 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $538 m0 *1 383.04,35.28
X$538 9263 76 47 9264 116 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $544 r0 *1 429.52,25.2
X$544 9263 106 51 9264 48 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $548 m0 *1 392.56,35.28
X$548 9264 9263 152 101 49 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $557 m0 *1 422.24,45.36
X$557 195 9264 194 196 9263 50 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $569 r0 *1 575.12,25.2
X$569 9264 9263 53 104 54 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $571 m0 *1 600.32,35.28
X$571 9264 9263 53 56 92 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $573 r0 *1 598.64,35.28
X$573 9263 53 89 9264 55 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $575 r0 *1 577.36,35.28
X$575 9264 129 200 89 128 53 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $577 m0 *1 607.6,45.36
X$577 164 53 92 9264 9263 208 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $585 m0 *1 577.36,35.28
X$585 53 88 127 54 9263 9264 105 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $587 m0 *1 616.56,35.28
X$587 9263 53 9264 94 175 89 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $589 r0 *1 592.48,45.36
X$589 9264 53 230 229 90 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $591 r0 *1 581.84,25.2
X$591 9264 9263 54 89 128 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $598 r0 *1 590.8,25.2
X$598 9264 9263 91 90 55 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $603 m0 *1 590.8,25.2
X$603 9264 55 67 9263 70 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $607 m0 *1 603.12,25.2
X$607 9264 56 9263 67 66 57 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $609 r0 *1 598.08,25.2
X$609 9264 128 66 57 58 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $612 m0 *1 615.44,25.2
X$612 9264 9263 93 57 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $614 m0 *1 605.36,35.28
X$614 58 57 66 9264 9263 231 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $624 r0 *1 611.52,25.2
X$624 9264 9263 92 58 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $626 r0 *1 682.08,25.2
X$626 233 9263 9264 64 62 59 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $637 m0 *1 689.92,75.6
X$637 9264 60 563 521 235 562 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $639 m0 *1 682.64,35.28
X$639 9264 64 169 140 61 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $663 m0 *1 624.4,35.28
X$663 9264 9263 66 746 130 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $666 m0 *1 618.8,45.36
X$666 9264 164 66 165 166 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $679 r0 *1 439.6,25.2
X$679 9264 193 68 509 102 69 144 9263 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $688 m0 *1 586.32,35.28
X$688 9263 9264 230 90 70 87 86 88 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $695 r0 *1 579.6,45.36
X$695 9263 241 9264 129 228 70 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $697 m0 *1 579.04,45.36
X$697 9263 207 9264 129 210 70 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $703 m0 *1 342.16,35.28
X$703 9263 72 73 9264 109 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $708 m0 *1 333.76,35.28
X$708 9263 72 9264 73 108 137 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $718 r0 *1 360.08,45.36
X$718 9264 74 9263 141 244 243 209 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $720 m0 *1 358.4,35.28
X$720 9264 9263 110 74 111 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $722 m0 *1 363.44,35.28
X$722 9264 9263 75 176 114 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $724 m0 *1 369.04,35.28
X$724 9263 75 114 9264 141 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $733 r0 *1 403.76,35.28
X$733 9264 143 9263 186 76 156 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $740 m0 *1 490.56,65.52
X$740 9264 381 418 78 513 379 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $743 m0 *1 466.48,65.52
X$743 9264 535 323 78 379 224 9263 321 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $756 r0 *1 514.64,45.36
X$756 9264 160 78 226 212 269 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $763 r0 *1 475.44,55.44
X$763 9264 9263 379 80 324 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $766 r0 *1 448,105.84
X$766 9264 936 9263 810 777 197 81 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $768 m0 *1 473.76,75.6
X$768 9264 379 224 81 324 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $777 r0 *1 456.96,105.84
X$777 81 9263 197 866 9264 776 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $784 r0 *1 487.76,25.2
X$784 121 9264 83 9263 106 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $787 m0 *1 498.4,75.6
X$787 9264 514 273 9263 83 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $789 m0 *1 504.56,35.28
X$789 9264 122 9263 120 84 123 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $791 m0 *1 538.16,35.28
X$791 9264 9263 84 124 383 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $796 r0 *1 554.4,45.36
X$796 9264 85 227 9263 275 276 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $798 m0 *1 543.76,35.28
X$798 9264 329 124 85 125 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $801 r0 *1 546,35.28
X$801 9263 162 9264 85 199 125 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $804 m0 *1 563.36,35.28
X$804 105 9263 86 126 9264 125 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $806 r0 *1 563.36,35.28
X$806 9264 105 126 163 86 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $812 r0 *1 609.28,115.92
X$812 9264 9263 1159 703 87 697 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $815 r0 *1 593.6,126
X$815 9264 945 942 1024 572 702 87 1441 9263 gf180mcu_fd_sc_mcu9t5v0__oai33_4
* cell instance $817 m0 *1 569.52,35.28
X$817 9264 9263 127 87 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $833 m0 *1 571.2,95.76
X$833 670 9264 87 469 9263 268 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $835 m0 *1 572.88,85.68
X$835 9263 555 9264 469 629 87 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $837 r0 *1 599.76,105.84
X$837 9263 87 9264 785 831 759 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $839 m0 *1 590.8,126
X$839 9264 9263 944 959 87 999 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $841 m0 *1 586.88,105.84
X$841 88 9264 87 746 9263 800 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $843 r0 *1 572.32,55.44
X$843 9264 9263 333 87 469 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $846 m0 *1 577.92,55.44
X$846 9264 9263 275 210 87 228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $848 m0 *1 539.28,105.84
X$848 9264 517 783 827 88 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $850 r0 *1 546,95.76
X$850 9264 9263 88 699 698 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $853 r0 *1 579.04,95.76
X$853 9264 9263 88 697 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $855 r0 *1 520.8,85.68
X$855 9263 88 421 9264 657 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $859 r0 *1 565.6,55.44
X$859 9264 9263 382 384 88 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $869 r0 *1 602.56,95.76
X$869 9264 9263 471 88 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $873 r0 *1 595.84,95.76
X$873 344 9264 88 485 9263 702 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $878 m0 *1 568.4,45.36
X$878 88 9264 127 104 9263 126 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $888 r0 *1 606.48,35.28
X$888 9264 89 92 177 168 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $891 m0 *1 591.36,45.36
X$891 9264 9263 90 200 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $901 r0 *1 606.48,55.44
X$901 9264 390 91 334 231 128 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $904 r0 *1 594.16,55.44
X$904 9264 344 91 9263 386 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $907 r0 *1 614.88,25.2
X$907 9263 92 93 9264 94 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $921 r0 *1 630,35.28
X$921 9264 93 164 131 167 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $925 r0 *1 654.64,25.2
X$925 95 9263 132 96 9264 100 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $931 m0 *1 656.32,35.28
X$931 100 9264 95 132 9263 282 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $933 r0 *1 649.04,75.6
X$933 9264 471 529 96 560 624 9263 393 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $966 r0 *1 387.52,35.28
X$966 9264 115 9263 142 116 101 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $975 m0 *1 425.04,35.28
X$975 9264 118 117 9263 101 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1002 r0 *1 250.32,35.28
X$1002 9264 9263 107 145 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1004 r0 *1 280,45.36
X$1004 148 9263 107 109 9264 343 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1006 m0 *1 351.12,45.36
X$1006 9264 152 107 187 188 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $1012 r0 *1 273.28,35.28
X$1012 9264 149 148 9263 107 109 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1014 m0 *1 204.96,45.36
X$1014 9264 107 178 9263 179 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1017 r0 *1 338.24,35.28
X$1017 9264 108 9263 138 152 139 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1021 r0 *1 253.68,35.28
X$1021 9263 145 9264 108 146 147 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1029 r0 *1 269.92,45.36
X$1029 9263 309 240 217 148 109 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1034 m0 *1 338.24,65.52
X$1034 9264 111 137 368 110 369 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $1036 m0 *1 338.8,45.36
X$1036 9264 186 9263 219 111 110 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1038 m0 *1 356.16,65.52
X$1038 9264 294 9263 110 313 368 367 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1040 r0 *1 389.76,45.36
X$1040 9264 223 245 192 317 110 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $1047 m0 *1 353.36,35.28
X$1047 9263 110 111 9264 112 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1049 r0 *1 342.16,45.36
X$1049 110 9263 186 111 9264 185 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1064 m0 *1 365.68,65.52
X$1064 9264 111 315 370 692 487 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $1067 r0 *1 355.04,35.28
X$1067 9263 112 9264 176 189 113 142 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $1069 r0 *1 324.8,45.36
X$1069 183 9263 217 113 9264 242 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1071 m0 *1 324.24,45.36
X$1071 9263 183 113 9264 150 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1082 m0 *1 370.16,45.36
X$1082 9263 221 9264 153 222 114 190 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $1084 r0 *1 393.12,85.68
X$1084 9263 9264 599 634 598 188 457 115 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $1087 m0 *1 378,146.16
X$1087 1151 9263 9264 115 821 1107 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $1090 r0 *1 382.48,166.32
X$1090 9264 9263 1426 1428 115 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1097 m0 *1 413.84,95.76
X$1097 9264 115 600 462 195 193 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $1100 r0 *1 369.04,146.16
X$1100 1150 115 1055 1234 1151 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1102 m0 *1 400.96,146.16
X$1102 115 9264 1181 1183 9263 1182 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1105 m0 *1 369.04,136.08
X$1105 9263 652 9264 982 1055 115 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1109 r0 *1 423.92,35.28
X$1109 9264 9263 117 118 190 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $1116 m0 *1 431.2,55.44
X$1116 9264 9263 118 296 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1124 m0 *1 436.24,55.44
X$1124 9264 118 195 377 349 378 261 9263 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $1126 r0 *1 534.8,45.36
X$1126 9264 118 124 157 272 333 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $1138 m0 *1 501.76,55.44
X$1138 9263 121 273 9264 266 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1141 m0 *1 560.56,75.6
X$1141 9264 466 518 121 468 467 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $1151 m0 *1 540.96,45.36
X$1151 9264 161 331 163 274 121 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1154 r0 *1 504,35.28
X$1154 9263 157 124 9264 122 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1156 r0 *1 518,75.6
X$1156 516 9263 556 123 9264 515 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $1158 r0 *1 508.48,75.6
X$1158 9263 123 464 514 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $1160 r0 *1 504.56,65.52
X$1160 9264 327 464 123 382 9263 422 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $1162 m0 *1 516.88,85.68
X$1162 9263 9264 123 605 464 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $1164 m0 *1 511.84,35.28
X$1164 9263 123 124 9264 160 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1172 m0 *1 504,75.6
X$1172 9264 326 508 464 123 9263 422 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $1186 r0 *1 509.04,35.28
X$1186 9263 158 124 9264 159 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1202 m0 *1 619.92,85.68
X$1202 9264 127 558 610 611 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $1205 m0 *1 582.4,75.6
X$1205 9263 517 9264 534 388 127 386 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $1207 m0 *1 601.44,75.6
X$1207 9264 9263 466 437 127 472 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $1214 m0 *1 573.44,65.52
X$1214 9264 9263 439 407 127 385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1223 m0 *1 600.32,85.68
X$1223 9264 9263 571 390 127 609 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1225 m0 *1 565.04,65.52
X$1225 9264 9263 276 436 127 384 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1235 m0 *1 586.88,65.52
X$1235 9263 9264 231 128 386 425 438 387 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $1237 r0 *1 600.88,55.44
X$1237 9264 128 231 9263 388 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1246 r0 *1 618.24,35.28
X$1246 164 9264 165 166 9263 130 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1248 r0 *1 687.68,196.56
X$1248 9264 9263 131 1665 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $1251 r0 *1 704.48,126
X$1251 9263 988 131 1076 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $1265 m0 *1 692.16,115.92
X$1265 9264 872 709 558 131 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1268 r0 *1 703.36,196.56
X$1268 9263 9264 1629 131 1446 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $1274 r0 *1 709.52,146.16
X$1274 9263 9264 988 1223 131 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $1277 m0 *1 704.48,146.16
X$1277 9264 1169 237 9263 131 988 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1285 m0 *1 693.84,65.52
X$1285 403 9263 204 133 9264 559 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $1288 r0 *1 700,35.28
X$1288 9264 173 133 9263 136 134 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1298 m0 *1 329.28,45.36
X$1298 9264 9263 148 184 137 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1300 r0 *1 310.8,65.52
X$1300 9264 413 255 454 184 137 9263 308 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $1313 m0 *1 251.44,55.44
X$1313 9263 239 138 9264 291 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1315 r0 *1 345.52,35.28
X$1315 9264 9263 139 151 187 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1338 r0 *1 201.6,45.36
X$1338 9264 178 9263 146 288 213 179 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1341 r0 *1 210.56,45.36
X$1341 9264 9263 238 213 146 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1347 m0 *1 255.36,45.36
X$1347 182 9264 150 181 9263 147 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1359 m0 *1 267.12,45.36
X$1359 9264 358 182 180 149 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $1361 r0 *1 249.76,45.36
X$1361 239 9263 9264 150 182 180 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $1368 m0 *1 262.64,55.44
X$1368 9263 181 342 150 308 217 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1371 m0 *1 326.48,126
X$1371 9263 981 9264 961 151 960 739 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $1373 m0 *1 311.92,126
X$1373 9264 980 151 739 9263 650 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $1375 r0 *1 313.04,115.92
X$1375 9264 894 685 151 739 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $1378 r0 *1 320.32,126
X$1378 688 739 151 980 9263 9264 861 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1386 r0 *1 365.12,95.76
X$1386 9264 654 151 742 691 692 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $1389 m0 *1 343.84,55.44
X$1389 9264 189 257 9263 187 151 220 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $1391 r0 *1 349.44,45.36
X$1391 151 220 187 257 9263 9264 243 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1404 m0 *1 380.24,45.36
X$1404 9263 191 9264 154 209 190 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1407 r0 *1 389.76,65.52
X$1407 9263 155 458 415 598 371 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1409 m0 *1 384.72,65.52
X$1409 9264 371 367 155 415 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $1414 m0 *1 400.96,45.36
X$1414 9264 9263 192 246 156 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1418 m0 *1 414.4,45.36
X$1418 193 195 194 196 9263 9264 156 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1423 r0 *1 528.64,35.28
X$1423 9264 9263 158 157 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1426 r0 *1 490,65.52
X$1426 9263 271 225 157 508 421 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1437 r0 *1 483.84,105.84
X$1437 157 271 782 826 9263 9264 743 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1439 m0 *1 484.4,115.92
X$1439 9263 271 825 157 867 901 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1441 r0 *1 479.92,115.92
X$1441 9264 900 271 157 917 867 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $1443 m0 *1 483.84,85.68
X$1443 9263 271 511 157 657 602 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1445 m0 *1 486.08,55.44
X$1445 9263 298 9264 271 420 157 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1447 r0 *1 500.64,75.6
X$1447 555 157 271 422 9263 9264 512 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1450 m0 *1 506.24,95.76
X$1450 157 9264 271 658 9263 718 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1453 m0 *1 506.24,85.68
X$1453 604 158 199 658 9263 9264 510 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1455 m0 *1 524.16,55.44
X$1455 9264 226 271 161 270 158 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $1467 m0 *1 507.92,65.52
X$1467 9263 271 328 158 421 382 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1470 m0 *1 528.64,45.36
X$1470 158 199 161 270 9263 9264 211 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1472 m0 *1 530.32,85.68
X$1472 9264 515 516 556 9263 158 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $1486 r0 *1 542.08,55.44
X$1486 329 9263 268 607 9264 162 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1489 m0 *1 556.64,55.44
X$1489 163 9263 275 276 9264 277 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1491 r0 *1 532.56,75.6
X$1491 9264 573 331 163 556 516 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1498 m0 *1 529.76,75.6
X$1498 9264 464 163 331 606 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $1510 r0 *1 613.76,45.36
X$1510 9264 208 389 165 166 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $1514 r0 *1 619.92,146.16
X$1514 9264 165 1216 237 1213 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1516 m0 *1 625.52,156.24
X$1516 9264 166 1262 1311 1269 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $1524 r0 *1 624.4,156.24
X$1524 9264 9263 1261 166 1214 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1526 r0 *1 610.4,95.76
X$1526 9263 703 167 9264 759 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1531 m0 *1 654.08,75.6
X$1531 9264 433 167 426 336 427 278 9263 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $1535 r0 *1 540.4,126
X$1535 9264 903 1025 168 1027 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1537 r0 *1 570.08,216.72
X$1537 1976 9264 9263 168 1954 1911 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1539 r0 *1 640.08,196.56
X$1539 1717 9264 9263 168 1711 1754 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1543 r0 *1 512.96,226.8
X$1543 2113 9264 9263 168 2056 2057 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1545 r0 *1 672.56,196.56
X$1545 9264 9263 168 1712 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1551 m0 *1 190.96,156.24
X$1551 1242 9264 9263 168 1272 1243 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1554 m0 *1 346.08,156.24
X$1554 1278 9264 9263 168 1202 1328 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1557 r0 *1 107.52,257.04
X$1557 2259 9264 9263 168 1636 2316 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1560 r0 *1 225.68,267.12
X$1560 2604 9264 9263 168 2466 2359 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1562 r0 *1 134.96,156.24
X$1562 1241 9264 9263 168 1367 1289 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1565 m0 *1 483.28,236.88
X$1565 2116 9264 9263 168 2082 2025 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1568 m0 *1 435.68,236.88
X$1568 2180 9264 9263 168 2085 1792 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1571 m0 *1 380.8,236.88
X$1571 2147 9264 9263 168 2087 2133 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1574 r0 *1 259.28,236.88
X$1574 2204 9264 9263 168 2221 2170 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1577 m0 *1 278.88,156.24
X$1577 1201 9264 9263 168 1199 1232 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1580 m0 *1 422.24,136.08
X$1580 1057 9264 9263 168 1019 1058 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1583 m0 *1 328.16,236.88
X$1583 2175 9264 9263 168 2095 2132 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1585 m0 *1 458.08,136.08
X$1585 9264 984 168 866 1060 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $1588 m0 *1 152.88,297.36
X$1588 2725 9264 9263 168 2674 2726 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1590 m0 *1 190.96,287.28
X$1590 2765 9264 9263 168 2556 2533 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1593 m0 *1 117.6,287.28
X$1593 2613 9264 9263 168 2412 2529 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1624 m0 *1 116.48,186.48
X$1624 9264 1564 1408 168 1458 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1626 m0 *1 232.96,156.24
X$1626 9264 1193 1098 168 1194 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1629 m0 *1 572.88,146.16
X$1629 9264 1176 1121 168 1120 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1632 r0 *1 689.36,216.72
X$1632 9263 9264 1490 168 1446 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $1634 m0 *1 679.28,65.52
X$1634 169 9263 397 283 9264 395 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $1636 m0 *1 683.2,75.6
X$1636 9264 9263 169 426 527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1639 r0 *1 658.56,65.52
X$1639 9264 169 393 392 9263 278 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $1641 m0 *1 680.96,85.68
X$1641 9264 9263 561 623 169 564 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1646 r0 *1 670.88,65.52
X$1646 9263 426 9264 427 405 169 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1649 r0 *1 662.48,45.36
X$1649 9263 173 9264 279 203 169 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1656 r0 *1 713.44,35.28
X$1656 9264 170 172 9263 171 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1675 r0 *1 645.12,55.44
X$1675 9264 9263 335 280 336 173 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1679 r0 *1 677.6,45.36
X$1679 9264 233 283 234 9263 174 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $1684 m0 *1 602,45.36
X$1684 9263 175 200 9264 201 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1693 m0 *1 612.08,75.6
X$1693 9264 533 473 177 485 9263 474 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $1695 r0 *1 612.64,75.6
X$1695 9264 473 485 177 467 474 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $1697 r0 *1 625.52,55.44
X$1697 9264 9263 391 292 177 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $1711 m0 *1 205.52,126
X$1711 9264 973 929 9263 178 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1718 m0 *1 249.2,105.84
X$1718 214 180 806 737 9263 9264 803 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1720 m0 *1 227.36,45.36
X$1720 9264 180 181 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1722 r0 *1 218.4,65.52
X$1722 9264 248 214 180 586 449 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $1724 m0 *1 228.48,95.76
X$1724 214 9264 180 586 9263 484 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1726 r0 *1 224,85.68
X$1726 9264 531 214 180 449 586 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $1737 m0 *1 308,75.6
X$1737 9264 180 413 454 364 363 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $1739 m0 *1 271.6,65.52
X$1739 9263 346 411 180 308 434 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1743 r0 *1 255.92,55.44
X$1743 9264 308 247 181 307 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $1745 r0 *1 266,95.76
X$1745 9263 181 804 214 735 737 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1747 r0 *1 257.6,65.52
X$1747 9263 451 9264 357 214 449 181 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $1749 r0 *1 225.12,45.36
X$1749 9264 252 249 181 214 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $1751 m0 *1 241.92,45.36
X$1751 9264 290 182 181 239 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $1756 m0 *1 243.04,95.76
X$1756 9263 181 671 214 589 647 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1766 m0 *1 258.16,115.92
X$1766 9263 857 9264 181 884 214 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1769 m0 *1 241.92,75.6
X$1769 9263 501 9264 181 450 214 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1781 m0 *1 328.16,55.44
X$1781 185 9263 219 182 9264 218 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $1783 m0 *1 318.08,55.44
X$1783 311 9264 182 244 9263 256 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1787 m0 *1 334.32,105.84
X$1787 9263 687 9264 808 183 772 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1793 m0 *1 400.96,65.52
X$1793 9264 184 246 440 319 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $1799 m0 *1 355.6,75.6
X$1799 184 9264 455 505 9263 364 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1802 r0 *1 332.64,45.36
X$1802 218 9264 185 219 9263 217 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1805 r0 *1 325.92,55.44
X$1805 9264 553 414 366 219 185 218 9263 312 gf180mcu_fd_sc_mcu9t5v0__oai33_2
* cell instance $1825 r0 *1 371.28,45.36
X$1825 9264 9263 221 187 222 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1829 r0 *1 361.76,105.84
X$1829 9264 863 188 821 241 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $1836 r0 *1 395.36,55.44
X$1836 9264 316 188 9263 372 318 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1838 r0 *1 402.64,55.44
X$1838 9264 9263 319 188 372 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1847 r0 *1 379.12,75.6
X$1847 9264 506 460 190 193 315 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1858 m0 *1 365.12,95.76
X$1858 9264 596 691 692 654 655 191 9263 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $1860 r0 *1 383.6,55.44
X$1860 9263 316 9264 314 223 317 191 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $1867 r0 *1 376.32,105.84
X$1867 9264 9263 597 821 191 822 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1871 m0 *1 389.76,136.08
X$1871 191 9264 1018 1041 9263 1109 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1874 m0 *1 381.92,136.08
X$1874 9264 9263 742 191 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1885 r0 *1 416.08,95.76
X$1885 9264 742 195 462 193 600 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $1888 r0 *1 389.76,95.76
X$1888 9264 691 693 740 741 193 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $1891 r0 *1 376.32,55.44
X$1891 9264 193 9263 222 258 315 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1904 m0 *1 400.96,105.84
X$1904 193 693 740 741 9263 9264 599 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1907 r0 *1 415.52,45.36
X$1907 9264 245 195 194 196 193 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $1918 m0 *1 460.32,55.44
X$1918 262 224 260 263 9264 9263 194 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1920 m0 *1 435.12,95.76
X$1920 315 462 195 656 9263 9264 719 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1922 r0 *1 430.64,95.76
X$1922 315 462 195 694 9263 9264 695 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1924 r0 *1 417.2,85.68
X$1924 462 9263 195 654 9264 600 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $1927 m0 *1 417.76,105.84
X$1927 9263 9264 460 315 195 774 764 809 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $1943 r0 *1 405.44,85.68
X$1943 315 9264 460 195 9263 634 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1946 r0 *1 450.8,55.44
X$1946 9264 196 322 325 378 197 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1955 m0 *1 450.8,115.92
X$1955 9264 509 866 823 197 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $1959 r0 *1 455.84,95.76
X$1959 9264 720 9263 696 197 509 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1962 m0 *1 451.36,166.32
X$1962 9264 1331 197 509 1387 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $1971 r0 *1 455.84,166.32
X$1971 9263 9264 509 1253 197 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $1973 m0 *1 512.4,105.84
X$1973 198 9263 9264 658 782 745 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $1978 r0 *1 530.32,55.44
X$1978 9264 9263 199 271 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1994 r0 *1 615.44,65.52
X$1994 9263 201 389 485 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $1997 r0 *1 603.68,65.52
X$1997 201 9263 389 486 9264 425 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2002 m0 *1 602,65.52
X$2002 9264 344 9263 387 389 201 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2004 r0 *1 639.52,65.52
X$2004 9264 344 9263 435 202 336 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2007 m0 *1 646.8,65.52
X$2007 9263 336 202 391 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $2015 r0 *1 713.44,45.36
X$2015 9264 9263 279 205 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2022 r0 *1 561.12,126
X$2022 9264 207 382 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $2025 m0 *1 622.16,65.52
X$2025 9264 391 390 437 292 207 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $2027 r0 *1 656.88,126
X$2027 9264 1028 998 207 987 832 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $2031 m0 *1 681.52,126
X$2031 9264 949 207 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $2040 m0 *1 685.44,136.08
X$2040 9264 1028 207 906 987 1066 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $2060 m0 *1 503.44,45.36
X$2060 268 9263 266 265 9264 212 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2063 m0 *1 206.64,55.44
X$2063 9264 213 249 248 253 240 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2069 r0 *1 310.24,45.36
X$2069 9264 256 214 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2100 r0 *1 302.4,55.44
X$2100 9264 345 310 305 293 9263 215 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $2104 r0 *1 292.88,55.44
X$2104 9264 255 9263 362 215 310 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2106 r0 *1 295.12,45.36
X$2106 9263 310 215 9264 216 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2108 r0 *1 285.6,55.44
X$2108 293 305 310 215 9264 9263 361 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2110 r0 *1 286.16,45.36
X$2110 9264 9263 310 251 215 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2118 r0 *1 309.12,85.68
X$2118 652 504 590 591 9263 9264 215 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2120 m0 *1 294,55.44
X$2120 9264 345 354 216 255 256 365 9263 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $2133 r0 *1 274.96,55.44
X$2133 9263 343 9264 359 306 217 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2143 m0 *1 332.64,65.52
X$2143 9263 367 368 9264 218 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2153 r0 *1 337.68,115.92
X$2153 652 369 848 220 9264 9263 808 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2156 r0 *1 332.08,85.68
X$2156 369 592 220 630 9264 9263 673 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2158 r0 *1 332.08,75.6
X$2158 367 9263 592 220 9264 504 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2167 r0 *1 340.48,126
X$2167 9264 9263 980 220 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $2169 m0 *1 341.6,136.08
X$2169 9264 1054 1149 229 220 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2173 r0 *1 369.6,55.44
X$2173 295 9264 370 315 9263 221 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2180 m0 *1 374.64,105.84
X$2180 9264 9263 773 692 742 223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2183 m0 *1 385.28,105.84
X$2183 741 9263 740 223 9264 693 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $2188 r0 *1 455.84,65.52
X$2188 9264 9263 374 322 224 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2190 m0 *1 452.48,85.68
X$2190 9264 488 224 509 324 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $2196 r0 *1 448,45.36
X$2196 9264 321 259 263 261 224 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $2198 r0 *1 479.92,126
X$2198 9264 224 939 900 986 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $2207 r0 *1 488.32,45.36
X$2207 9264 9263 225 297 326 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2209 r0 *1 490.56,55.44
X$2209 9263 225 326 9264 381 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2214 r0 *1 556.08,55.44
X$2214 227 9263 275 276 9264 331 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2216 m0 *1 542.64,85.68
X$2216 9264 465 227 439 633 9263 516 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $2224 r0 *1 568.4,115.92
X$2224 9264 942 572 9263 227 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2228 m0 *1 553.84,65.52
X$2228 9264 9263 274 227 608 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2231 m0 *1 551.04,75.6
X$2231 9263 466 423 467 273 227 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $2235 m0 *1 560.56,166.32
X$2235 9264 1346 1389 229 659 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2238 r0 *1 435.12,246.96
X$2238 9264 2278 2230 229 2179 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2240 m0 *1 563.92,246.96
X$2240 9264 2235 2101 229 2059 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2243 r0 *1 679.84,196.56
X$2243 9264 9263 229 403 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $2245 r0 *1 532,226.8
X$2245 2143 9264 9263 229 2058 2099 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2247 m0 *1 90.16,236.88
X$2247 9264 2122 2121 229 1676 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2250 r0 *1 470.4,85.68
X$2250 9264 488 229 264 602 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $2252 r0 *1 384.72,246.96
X$2252 2274 9264 9263 229 2206 2226 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2254 r0 *1 271.6,257.04
X$2254 2363 9264 9263 229 2325 2223 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2256 m0 *1 474.88,246.96
X$2256 2249 9264 9263 229 2135 1880 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2258 r0 *1 288.4,136.08
X$2258 9264 1053 1102 229 672 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2260 m0 *1 322,246.96
X$2260 9264 2225 2176 229 2174 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2262 m0 *1 140,307.44
X$2262 9264 2814 2891 229 2704 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2300 r0 *1 87.92,186.48
X$2300 9264 1563 1409 229 1605 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2302 r0 *1 233.52,287.28
X$2302 9264 2676 2617 229 2677 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2305 r0 *1 126,136.08
X$2305 9264 1132 1093 229 1010 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2307 r0 *1 103.04,297.36
X$2307 9264 2724 2560 229 2773 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2310 m0 *1 188.72,307.44
X$2310 9264 2875 2534 229 2829 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2312 m0 *1 178.08,146.16
X$2312 9264 1174 1191 229 1143 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2314 m0 *1 418.32,126
X$2314 9264 1001 1020 229 934 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2317 m0 *1 531.44,115.92
X$2317 9264 868 870 229 422 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2320 m0 *1 670.88,105.84
X$2320 9264 796 750 229 751 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2323 r0 *1 625.52,226.8
X$2323 9264 2066 2067 229 1956 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2327 m0 *1 242.48,136.08
X$2327 9264 930 1051 229 1014 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2329 m0 *1 683.2,186.48
X$2329 9263 9264 1444 229 1446 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $2332 m0 *1 635.6,55.44
X$2332 9264 335 230 279 278 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $2346 r0 *1 657.44,95.76
X$2346 9264 232 9263 707 660 706 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2348 m0 *1 651.84,105.84
X$2348 9264 832 232 471 787 9263 392 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $2357 r0 *1 653.52,105.84
X$2357 9264 787 748 832 232 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $2359 m0 *1 664.72,85.68
X$2359 9264 529 232 559 9263 624 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $2367 m0 *1 666.4,65.52
X$2367 392 9264 393 233 9263 337 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2369 m0 *1 669.2,55.44
X$2369 283 9263 337 292 9264 234 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $2373 r0 *1 687.68,55.44
X$2373 338 401 395 9264 9263 234 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $2376 r0 *1 669.76,55.44
X$2376 234 9264 283 337 9263 394 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2379 m0 *1 707.84,75.6
X$2379 9263 235 526 9264 527 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2389 m0 *1 715.68,65.52
X$2389 9264 341 235 400 428 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2394 r0 *1 721.84,65.52
X$2394 9264 9263 236 432 520 401 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2397 m0 *1 748.72,146.16
X$2397 9264 1069 1165 237 1068 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $2399 m0 *1 688.8,246.96
X$2399 9264 1351 237 9263 gf180mcu_fd_sc_mcu9t5v0__inv_16
* cell instance $2401 m0 *1 734.72,156.24
X$2401 1266 1222 237 9264 9263 1129 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $2403 r0 *1 748.16,85.68
X$2403 9264 523 478 237 663 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2406 m0 *1 541.52,166.32
X$2406 1315 9264 9263 237 1302 1317 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2408 m0 *1 527.52,196.56
X$2408 1746 9264 9263 237 1627 1662 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2411 r0 *1 590.24,206.64
X$2411 1820 9264 9263 237 1750 1855 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2413 m0 *1 308,176.4
X$2413 1375 9264 9263 237 1469 1468 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2415 m0 *1 235.76,236.88
X$2415 2202 9264 9263 237 2092 1940 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2417 m0 *1 163.52,166.32
X$2417 1325 9264 9263 237 1460 1369 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2419 r0 *1 225.68,176.4
X$2419 1500 9264 9263 237 1574 1521 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2421 m0 *1 132.72,246.96
X$2421 2158 9264 9263 237 1689 2157 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2423 r0 *1 476,206.64
X$2423 1882 9264 9263 237 1795 1796 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2425 m0 *1 437.92,216.72
X$2425 1903 9264 9263 237 1847 1904 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2427 m0 *1 390.32,216.72
X$2427 1930 9264 9263 237 1842 1789 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2429 r0 *1 255.36,166.32
X$2429 1326 9264 9263 237 1420 1421 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2432 m0 *1 424.48,166.32
X$2432 1362 9264 9263 237 1401 1384 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2435 r0 *1 372.96,166.32
X$2435 1427 9264 9263 237 1382 1476 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2437 r0 *1 328.72,216.72
X$2437 1978 9264 9263 237 1946 1947 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2439 m0 *1 146.16,267.12
X$2439 2413 9264 9263 237 2124 2414 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2441 r0 *1 174.72,257.04
X$2441 2396 9264 9263 237 2264 2321 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2504 r0 *1 148.4,196.56
X$2504 9264 1645 1722 237 1598 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2506 r0 *1 188.16,246.96
X$2506 9264 2301 2168 237 2218 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2508 m0 *1 587.44,146.16
X$2508 9264 1157 1349 237 1124 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2511 r0 *1 644.56,216.72
X$2511 9264 1957 1960 237 1857 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2513 m0 *1 455.84,156.24
X$2513 9264 1112 1254 237 1279 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2515 m0 *1 726.32,176.4
X$2515 9264 1164 237 1222 1492 1493 1550 1491 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_4
* cell instance $2518 r0 *1 280.56,216.72
X$2518 9264 1975 1778 237 1942 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2521 r0 *1 714,126
X$2521 237 9263 910 1032 9264 1033 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2527 r0 *1 105.28,75.6
X$2527 9264 9263 238 491 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2529 m0 *1 81.2,75.6
X$2529 9263 238 482 9264 483 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2538 r0 *1 92.4,85.68
X$2538 9263 540 9264 577 619 238 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2548 r0 *1 607.6,105.84
X$2548 9264 334 241 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $2550 r0 *1 500.64,95.76
X$2550 9263 555 241 508 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $2552 m0 *1 304.64,95.76
X$2552 9264 686 454 685 241 650 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $2554 r0 *1 327.04,85.68
X$2554 9263 241 591 9264 630 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2556 m0 *1 298.48,105.84
X$2556 9264 241 805 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2560 r0 *1 420.56,75.6
X$2560 9264 241 416 375 262 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $2562 m0 *1 406,115.92
X$2562 9264 741 865 823 241 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $2580 m0 *1 257.04,105.84
X$2580 9264 736 549 735 241 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $2584 r0 *1 584.08,75.6
X$2584 9264 556 571 533 468 241 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2587 r0 *1 286.72,85.68
X$2587 553 242 550 672 9264 9263 412 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2589 m0 *1 258.16,85.68
X$2589 9264 625 503 242 451 549 359 9263 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $2591 m0 *1 278.88,55.44
X$2591 9264 242 307 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2599 m0 *1 287.28,95.76
X$2599 9264 9263 550 651 242 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2605 r0 *1 318.08,55.44
X$2605 346 9263 9264 244 311 312 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $2620 m0 *1 169.68,65.52
X$2620 9264 492 247 352 290 402 353 9263 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $2622 r0 *1 170.8,65.52
X$2622 9264 9263 351 445 247 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2624 r0 *1 177.52,65.52
X$2624 9264 247 351 350 9263 443 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $2626 r0 *1 172.48,55.44
X$2626 402 9263 9264 300 290 247 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $2632 r0 *1 190.96,55.44
X$2632 9264 350 248 249 253 306 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2635 r0 *1 194.32,65.52
X$2635 9264 9263 248 446 249 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2638 m0 *1 190.96,75.6
X$2638 9263 248 498 499 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $2650 r0 *1 181.44,75.6
X$2650 9264 499 644 498 249 447 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $2658 m0 *1 229.6,55.44
X$2658 9263 9264 251 303 289 304 250 252 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $2660 r0 *1 227.36,55.44
X$2660 9264 251 9263 302 250 404 355 301 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $2669 m0 *1 241.92,55.44
X$2669 9263 305 251 9264 254 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2672 r0 *1 220.64,75.6
X$2672 9264 626 500 307 252 547 309 9263 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $2675 r0 *1 243.6,75.6
X$2675 9264 9263 252 530 548 502 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $2682 r0 *1 240.8,55.44
X$2682 9264 9263 304 302 252 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2684 m0 *1 283.36,65.52
X$2684 9264 253 307 360 361 362 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2696 m0 *1 246.96,65.52
X$2696 9263 303 254 9264 408 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2701 r0 *1 351.68,65.52
X$2701 9264 255 505 455 314 313 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $2716 r0 *1 334.88,95.76
X$2716 9264 9263 688 257 687 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2720 r0 *1 374.08,65.52
X$2720 9264 9263 315 487 258 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2729 r0 *1 409.92,65.52
X$2729 9264 9263 258 461 259 373 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2733 m0 *1 420,75.6
X$2733 9264 9263 462 416 259 463 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $2735 m0 *1 411.04,55.44
X$2735 9264 295 260 262 296 259 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2737 r0 *1 426.72,55.44
X$2737 259 9264 376 9263 372 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2745 r0 *1 427.84,65.52
X$2745 9264 9263 370 417 259 463 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2751 r0 *1 419.44,65.52
X$2751 9264 9263 460 416 259 463 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2753 r0 *1 440.72,55.44
X$2753 9264 9263 262 377 260 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2759 r0 *1 425.04,146.16
X$2759 1203 1204 1250 1154 9264 9263 260 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2767 m0 *1 448.56,65.52
X$2767 9264 378 418 419 260 374 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $2772 r0 *1 445.76,55.44
X$2772 9264 9263 261 349 321 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2778 r0 *1 500.64,105.84
X$2778 9264 555 262 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2783 m0 *1 434,65.52
X$2783 9263 262 375 9264 376 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2785 m0 *1 386.4,115.92
X$2785 9264 823 862 865 740 262 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $2788 r0 *1 384.72,115.92
X$2788 9264 9263 262 688 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2806 m0 *1 425.04,115.92
X$2806 9264 9263 775 262 763 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2808 r0 *1 387.52,105.84
X$2808 9264 693 823 865 690 262 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2812 m0 *1 494.48,55.44
X$2812 9264 9263 298 262 421 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2825 m0 *1 534.8,136.08
X$2825 9264 9263 264 1063 605 1027 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2833 m0 *1 502.88,105.84
X$2833 745 9264 603 781 9263 265 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2835 m0 *1 511.28,55.44
X$2835 9264 267 268 9263 265 266 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2847 r0 *1 537.6,85.68
X$2847 9264 329 607 606 268 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $2849 m0 *1 566.16,95.76
X$2849 9264 9263 268 669 762 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2861 m0 *1 520.24,105.84
X$2861 782 9264 658 745 9263 269 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2867 m0 *1 546,65.52
X$2867 9263 423 9264 332 270 424 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2892 m0 *1 573.44,186.48
X$2892 9264 272 1589 1591 1554 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $2894 r0 *1 544.88,65.52
X$2894 9263 272 273 9264 330 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2897 r0 *1 632.24,65.52
X$2897 9264 272 9263 407 435 394 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2907 r0 *1 602,136.08
X$2907 9264 1125 272 9263 945 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2910 r0 *1 574,65.52
X$2910 9263 272 9264 438 469 385 470 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2914 m0 *1 633.36,126
X$2914 9264 272 947 9263 904 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $2916 m0 *1 549.36,55.44
X$2916 9264 272 273 9263 347 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2926 r0 *1 538.72,105.84
X$2926 9264 827 273 829 784 828 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $2947 m0 *1 552.16,186.48
X$2947 9264 1481 1850 277 1482 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $2950 m0 *1 633.92,95.76
X$2950 9264 797 611 705 278 615 336 9263 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $2958 m0 *1 633.36,85.68
X$2958 9264 9263 278 520 610 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $2960 r0 *1 635.6,85.68
X$2960 9264 278 705 615 336 9263 668 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $2963 r0 *1 635.6,55.44
X$2963 9263 279 436 278 335 334 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $2970 r0 *1 737.52,95.76
X$2970 9264 279 711 755 712 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $2983 r0 *1 655.2,85.68
X$2983 9264 9263 281 667 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2985 m0 *1 655.2,85.68
X$2985 9263 281 560 9264 475 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2993 m0 *1 657.44,115.92
X$2993 9264 750 716 282 707 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $2995 r0 *1 659.12,115.92
X$2995 750 9264 707 282 9263 786 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3018 m0 *1 708.4,65.52
X$3018 9264 287 9263 285 396 522 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3037 r0 *1 170.24,75.6
X$3037 9264 9263 497 288 642 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3040 m0 *1 167.44,95.76
X$3040 9264 288 642 9263 641 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3044 r0 *1 232.96,65.52
X$3044 9264 9263 289 449 586 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3049 r0 *1 185.92,55.44
X$3049 9263 290 300 9264 353 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3052 m0 *1 153.44,75.6
X$3052 290 9263 443 445 9264 495 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3054 m0 *1 145.6,75.6
X$3054 9264 9263 290 622 443 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3056 r0 *1 151.2,75.6
X$3056 9263 290 497 9264 490 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3059 r0 *1 137.2,75.6
X$3059 9264 290 445 544 443 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $3071 m0 *1 157.92,85.68
X$3071 9264 585 546 545 290 443 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $3073 m0 *1 139.44,95.76
X$3073 290 9264 444 582 9263 493 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3075 r0 *1 159.04,55.44
X$3075 299 9264 291 9263 496 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $3077 m0 *1 157.36,65.52
X$3077 9264 441 291 299 9263 gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* cell instance $3092 r0 *1 345.52,65.52
X$3092 9264 9263 293 313 314 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3094 m0 *1 231.84,65.52
X$3094 9263 293 355 9264 352 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3104 m0 *1 394.8,55.44
X$3104 9264 9263 319 294 318 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3111 r0 *1 380.8,65.52
X$3111 9264 9263 415 295 370 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3114 r0 *1 367.36,65.52
X$3114 9264 295 370 9263 456 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3131 m0 *1 252,65.52
X$3131 9263 356 9264 406 299 409 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3141 r0 *1 180.32,55.44
X$3141 9264 350 351 9263 300 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3144 m0 *1 226.8,65.52
X$3144 9264 9263 301 500 404 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3149 r0 *1 222.32,55.44
X$3149 9263 354 358 9264 301 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3160 m0 *1 241.92,65.52
X$3160 9264 9263 360 303 307 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3162 r0 *1 248.08,55.44
X$3162 9264 9263 305 304 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3181 r0 *1 277.2,115.92
X$3181 920 305 858 931 9263 9264 551 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $3184 r0 *1 339.92,85.68
X$3184 9263 9264 594 305 593 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $3193 m0 *1 270.48,75.6
X$3193 9264 649 9263 453 309 307 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3195 m0 *1 259.28,75.6
X$3195 9264 503 9263 452 309 307 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3199 m0 *1 232.4,126
X$3199 9264 1016 9263 974 958 309 307 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $3201 r0 *1 265.44,126
X$3201 307 9263 359 978 9264 977 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3216 r0 *1 268.24,105.84
X$3216 9264 845 806 359 307 9263 737 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $3219 r0 *1 274.4,176.4
X$3219 9264 1466 9263 1578 359 307 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3239 r0 *1 272.72,75.6
X$3239 9264 9263 550 309 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3246 m0 *1 305.2,85.68
X$3246 9264 653 310 590 504 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $3253 m0 *1 321.44,115.92
X$3253 9264 860 9263 311 861 960 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3269 r0 *1 346.08,55.44
X$3269 9264 313 314 9263 363 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3279 r0 *1 431.76,85.68
X$3279 9264 9263 600 315 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3282 r0 *1 402.64,65.52
X$3282 9264 9263 315 440 460 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3306 r0 *1 448,65.52
X$3306 9263 349 9264 418 317 419 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3313 m0 *1 385.28,156.24
X$3313 9264 742 318 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3321 m0 *1 391.44,176.4
X$3321 9264 9263 1475 1429 318 1331 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3323 r0 *1 422.24,176.4
X$3323 9264 9263 1379 1535 318 1401 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3325 r0 *1 417.2,166.32
X$3325 9264 9263 1382 1435 318 1330 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3334 m0 *1 421.12,65.52
X$3334 9264 374 375 9263 320 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3346 r0 *1 501.2,55.44
X$3346 9264 9263 328 323 327 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3351 m0 *1 490,95.76
X$3351 9264 718 324 603 514 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $3359 m0 *1 481.04,95.76
X$3359 9263 325 604 9264 722 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3361 m0 *1 474.32,85.68
X$3361 9264 9263 488 325 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $3364 r0 *1 468.16,105.84
X$3364 849 9263 9264 697 325 778 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $3367 m0 *1 476.56,105.84
X$3367 825 743 325 779 697 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3398 r0 *1 551.6,85.68
X$3398 572 9264 557 608 9263 329 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3400 r0 *1 548.24,55.44
X$3400 9264 330 9263 332 347 333 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3423 r0 *1 674.24,126
X$3423 9264 9263 334 949 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $3429 m0 *1 608.16,95.76
X$3429 9264 485 334 9263 703 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $3431 m0 *1 662.48,176.4
X$3431 9264 9329 1489 1545 334 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $3433 r0 *1 665.28,216.72
X$3433 9264 1967 1920 334 1961 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $3454 m0 *1 656.32,65.52
X$3454 9264 392 393 9263 336 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $3462 m0 *1 650.72,146.16
X$3462 9264 9263 1160 1217 336 1163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3464 r0 *1 643.44,146.16
X$3464 9264 9263 1213 1227 336 561 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3470 m0 *1 678.16,95.76
X$3470 9264 9263 1163 521 338 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3473 m0 *1 688.8,95.76
X$3473 9264 9263 338 666 339 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3479 m0 *1 693.84,95.76
X$3479 9263 338 9264 661 758 395 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3487 m0 *1 703.92,95.76
X$3487 9264 9263 339 558 662 661 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3493 r0 *1 706.16,65.52
X$3493 9264 9263 396 476 341 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3502 r0 *1 248.08,65.52
X$3502 450 484 342 356 410 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3511 r0 *1 599.76,115.92
X$3511 9263 830 344 486 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $3522 m0 *1 673.68,126
X$3522 9264 9263 949 344 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $3539 r0 *1 412.72,55.44
X$3539 9264 9263 416 348 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3548 r0 *1 180.32,105.84
X$3548 9264 350 643 816 841 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $3553 r0 *1 193.2,176.4
X$3553 9264 9263 1516 350 1517 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3555 m0 *1 193.76,105.84
X$3555 350 9264 733 498 9263 798 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3559 r0 *1 254.24,75.6
X$3559 9264 531 9263 351 734 532 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3568 r0 *1 170.24,85.68
X$3568 9264 352 640 528 583 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $3576 m0 *1 260.96,65.52
X$3576 9263 452 406 357 354 358 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $3579 m0 *1 173.04,95.76
X$3579 354 645 643 644 9264 9263 494 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3581 m0 *1 183.12,95.76
X$3581 9264 644 643 645 354 582 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $3584 r0 *1 207.2,65.52
X$3584 9264 9263 354 447 358 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3601 m0 *1 227.36,85.68
X$3601 9264 818 531 625 354 358 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $3603 m0 *1 176.96,85.68
X$3603 9263 354 645 9264 584 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3605 m0 *1 166.32,105.84
X$3605 9264 730 354 546 583 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $3629 m0 *1 274.4,95.76
X$3629 9264 9263 550 359 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3632 m0 *1 304.64,65.52
X$3632 9264 9263 360 363 364 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3644 r0 *1 301.28,75.6
X$3644 9264 550 364 363 413 454 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $3646 m0 *1 334.88,85.68
X$3646 9264 552 554 553 574 363 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3652 m0 *1 312.48,65.52
X$3652 9264 363 364 9263 365 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3668 m0 *1 328.72,105.84
X$3668 9264 9263 806 366 414 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3671 r0 *1 333.76,156.24
X$3671 9264 366 848 369 1360 1277 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3676 m0 *1 341.04,75.6
X$3676 9264 367 369 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3693 r0 *1 438.48,95.76
X$3693 764 9263 695 719 9264 368 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3696 r0 *1 334.88,105.84
X$3696 9264 895 9263 846 772 592 369 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $3701 m0 *1 348.32,166.32
X$3701 9263 9264 369 1329 848 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $3705 r0 *1 339.36,146.16
X$3705 369 9263 848 1202 9264 414 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3713 r0 *1 339.92,95.76
X$3713 9264 820 9263 689 592 369 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3716 m0 *1 328.16,95.76
X$3716 9264 807 9263 590 592 369 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3719 m0 *1 331.52,166.32
X$3719 9264 1380 9263 1527 848 369 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3741 m0 *1 415.52,65.52
X$3741 9264 9263 374 373 375 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3745 m0 *1 430.64,75.6
X$3745 9264 9263 375 374 463 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $3747 m0 *1 460.32,105.84
X$3747 9264 9263 697 374 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3749 m0 *1 360.08,105.84
X$3749 9264 9263 374 652 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3751 r0 *1 411.04,105.84
X$3751 809 9263 9264 763 374 824 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $3753 m0 *1 376.32,115.92
X$3753 9263 374 824 9264 864 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3769 r0 *1 430.08,105.84
X$3769 374 763 777 776 9263 9264 656 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $3772 m0 *1 355.6,95.76
X$3772 9263 374 690 9264 655 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3778 m0 *1 414.96,75.6
X$3778 9264 9263 508 461 375 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3782 r0 *1 418.32,126
X$3782 9264 375 983 1020 1001 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $3793 m0 *1 427.84,65.52
X$3793 9263 376 416 9264 417 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3804 r0 *1 478.8,65.52
X$3804 9264 9263 488 379 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3814 m0 *1 490,75.6
X$3814 379 9263 420 512 9264 513 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3817 r0 *1 484.96,75.6
X$3817 9264 380 488 9263 420 512 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $3826 r0 *1 556.08,95.76
X$3826 9264 382 701 470 670 9263 633 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $3830 r0 *1 178.64,126
X$3830 9264 971 920 1050 382 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $3832 r0 *1 254.8,95.76
X$3832 9264 684 9263 649 501 648 382 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $3834 m0 *1 169.12,136.08
X$3834 9264 9263 382 921 1049 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3836 r0 *1 366.24,115.92
X$3836 9264 864 692 824 862 382 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $3838 m0 *1 256.48,136.08
X$3838 9264 382 1094 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3858 m0 *1 334.32,115.92
X$3858 382 9264 807 859 9263 820 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3866 r0 *1 571.2,85.68
X$3866 9264 631 9263 632 383 669 468 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $3881 r0 *1 596.96,65.52
X$3881 9264 425 387 9263 469 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3884 r0 *1 609.84,65.52
X$3884 9264 9263 472 471 388 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3892 r0 *1 604.8,75.6
X$3892 9264 471 388 9263 609 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3907 r0 *1 614.88,85.68
X$3907 611 9264 627 390 9263 628 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3926 r0 *1 650.72,65.52
X$3926 9263 475 9264 393 433 392 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3947 r0 *1 705.04,85.68
X$3947 9264 9263 564 614 395 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3956 r0 *1 700,105.84
X$3956 9264 395 753 792 788 833 834 9263 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3960 m0 *1 682.64,105.84
X$3960 9264 395 795 9263 705 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3968 m0 *1 728,65.52
X$3968 9264 9263 397 432 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3973 r0 *1 731.92,65.52
X$3973 9263 429 430 9264 397 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3976 m0 *1 729.68,95.76
X$3976 9264 9263 398 664 714 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3978 m0 *1 738.08,75.6
X$3978 9264 524 753 479 398 480 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $3980 r0 *1 749.28,75.6
X$3980 9264 525 9263 567 481 398 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3985 m0 *1 733.04,65.52
X$3985 9264 9263 399 430 398 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3987 r0 *1 722.4,85.68
X$3987 9264 616 398 613 614 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $3991 m0 *1 738.08,65.52
X$3991 9264 9263 431 399 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3994 r0 *1 679.84,226.8
X$3994 9264 1628 400 9263 gf180mcu_fd_sc_mcu9t5v0__inv_16
* cell instance $3996 m0 *1 602.56,176.4
X$3996 9264 1390 1497 400 1391 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4000 r0 *1 142.24,246.96
X$4000 9264 2263 2161 400 2196 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4004 r0 *1 725.76,166.32
X$4004 9264 1394 1306 400 1445 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4008 r0 *1 639.52,136.08
X$4008 9264 1078 1077 400 561 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4010 m0 *1 520.24,156.24
X$4010 9264 1301 1257 400 1117 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4012 m0 *1 600.32,216.72
X$4012 9264 1922 1914 400 1856 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4015 r0 *1 224.56,186.48
X$4015 9264 1522 1519 400 1464 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4018 m0 *1 234.08,226.8
X$4018 9264 2001 1941 400 2002 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4020 r0 *1 126.56,226.8
X$4020 2197 9264 9263 400 1819 2039 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $4022 r0 *1 393.68,196.56
X$4022 9264 1697 1699 400 1698 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4024 m0 *1 423.92,176.4
X$4024 9264 1436 1477 400 1330 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4027 m0 *1 476,196.56
X$4027 9264 1677 1624 400 1623 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4031 m0 *1 257.6,196.56
X$4031 9264 1525 1579 400 1581 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4033 r0 *1 372.4,176.4
X$4033 9264 1558 1533 400 1475 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4091 m0 *1 177.52,176.4
X$4091 9264 1416 1414 400 1462 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4095 m0 *1 160.72,206.64
X$4095 9264 1765 1735 400 1646 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4098 m0 *1 747.6,126
X$4098 9264 990 954 711 400 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4100 r0 *1 173.04,246.96
X$4100 9264 2265 2165 400 2266 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4103 r0 *1 197.12,226.8
X$4103 9264 2076 2077 400 2047 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4105 m0 *1 439.04,206.64
X$4105 9264 1702 1743 400 1791 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4107 r0 *1 526.96,206.64
X$4107 9264 1822 1798 400 1708 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4109 m0 *1 726.32,75.6
X$4109 9264 477 429 400 401 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4111 m0 *1 649.04,246.96
X$4111 9264 2139 2239 400 2184 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4113 m0 *1 297.36,216.72
X$4113 9264 1900 1780 400 1836 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4116 r0 *1 315.28,176.4
X$4116 9264 1507 1584 400 1530 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4118 r0 *1 484.4,166.32
X$4118 9264 1255 1337 1437 400 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4120 r0 *1 343.28,206.64
X$4120 9264 1876 1785 400 1839 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4122 m0 *1 632.8,146.16
X$4122 9264 1161 1162 400 1160 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4131 m0 *1 726.88,136.08
X$4131 9264 9263 401 1034 909 951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4139 m0 *1 670.32,206.64
X$4139 9264 1757 1809 403 1760 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4149 r0 *1 267.68,65.52
X$4149 453 412 410 411 9263 9264 404 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $4164 m0 *1 201.6,75.6
X$4164 9263 408 448 9264 528 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4166 r0 *1 199.36,75.6
X$4166 9264 541 446 500 408 570 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $4176 r0 *1 275.52,65.52
X$4176 9264 409 412 410 411 453 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $4180 r0 *1 199.36,65.52
X$4180 9263 446 9264 409 448 447 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4182 m0 *1 280.56,85.68
X$4182 9264 551 410 550 552 548 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $4209 r0 *1 313.6,95.76
X$4209 9264 685 688 738 413 650 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $4248 m0 *1 482.72,126
X$4248 9264 940 986 9263 419 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4262 r0 *1 533.68,105.84
X$4262 9263 827 869 9264 421 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4268 r0 *1 506.24,85.68
X$4268 9264 9263 601 421 605 422 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4273 m0 *1 572.88,126
X$4273 9264 871 422 943 468 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $4287 r0 *1 549.92,65.52
X$4287 9264 9263 470 424 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4289 m0 *1 544.88,75.6
X$4289 9264 9263 424 465 517 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4294 m0 *1 601.44,126
X$4294 946 9263 670 425 9264 999 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4310 r0 *1 716.24,65.52
X$4310 9264 9263 427 428 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4319 m0 *1 734.72,95.76
X$4319 9264 9263 427 710 662 664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4323 m0 *1 714,95.76
X$4323 614 709 478 429 9264 9263 757 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4330 r0 *1 747.6,65.52
X$4330 9263 478 9264 477 479 429 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4335 r0 *1 735.84,75.6
X$4335 9264 9263 525 429 477 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4339 r0 *1 742,65.52
X$4339 9264 9263 481 477 431 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4343 r0 *1 741.44,75.6
X$4343 524 9263 9264 477 523 431 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $4345 m0 *1 735.84,85.68
X$4345 9264 431 616 566 617 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4359 m0 *1 255.36,156.24
X$4359 1245 9263 1197 1247 9264 434 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4383 r0 *1 144.48,95.76
X$4383 9264 641 494 639 544 441 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $4385 r0 *1 138.32,85.68
X$4385 9264 441 577 544 582 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $4393 m0 *1 86.24,75.6
X$4393 9264 441 489 9263 482 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4396 m0 *1 149.52,105.84
X$4396 9264 770 641 544 582 441 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $4398 m0 *1 146.72,95.76
X$4398 441 9264 544 641 9263 621 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $4400 m0 *1 91.84,75.6
X$4400 441 9264 442 490 9263 540 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $4402 r0 *1 78.96,85.68
X$4402 9263 442 536 9264 489 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4405 r0 *1 86.24,75.6
X$4405 9263 9264 491 537 538 442 539 490 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $4408 r0 *1 156.24,75.6
X$4408 9264 9263 494 442 495 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4415 m0 *1 138.88,75.6
X$4415 9264 9263 443 444 445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4426 r0 *1 138.88,95.76
X$4426 9264 9263 444 732 582 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4430 m0 *1 141.68,105.84
X$4430 9263 732 9264 639 765 444 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4456 r0 *1 218.96,85.68
X$4456 9263 449 586 9264 587 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4458 r0 *1 231.28,95.76
X$4458 449 9263 484 671 9264 715 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4461 r0 *1 224,95.76
X$4461 9264 449 9263 771 671 484 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4472 r0 *1 282.24,95.76
X$4472 9263 9264 685 449 650 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $4479 m0 *1 253.68,95.76
X$4479 9264 9263 548 451 588 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4481 r0 *1 252,85.68
X$4481 549 9263 503 451 9264 547 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4505 m0 *1 400.96,75.6
X$4505 457 9263 458 459 9264 455 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4509 r0 *1 363.44,75.6
X$4509 9264 739 456 506 507 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $4512 m0 *1 363.44,85.68
X$4512 9264 595 506 456 655 507 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $4517 r0 *1 399.28,75.6
X$4517 9264 459 9263 505 458 457 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4530 m0 *1 403.2,126
X$4530 9264 9263 459 824 742 934 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4577 r0 *1 552.72,75.6
X$4577 9264 515 468 466 467 534 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $4588 m0 *1 564.48,85.68
X$4588 9263 555 9264 466 632 467 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4591 r0 *1 561.12,85.68
X$4591 9264 467 466 9263 659 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $4607 r0 *1 580.72,105.84
X$4607 800 831 697 801 468 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $4609 r0 *1 579.04,126
X$4609 9264 9263 942 572 468 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $4622 r0 *1 590.8,136.08
X$4622 9264 9263 1122 1123 468 1124 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4625 m0 *1 589.68,95.76
X$4625 9263 469 670 572 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $4649 m0 *1 562.24,105.84
X$4649 9263 697 470 9264 802 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4651 r0 *1 574,75.6
X$4651 470 9264 572 557 9263 518 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $4654 r0 *1 578.48,176.4
X$4654 1483 9263 1484 1539 9264 470 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4656 m0 *1 548.24,95.76
X$4656 9264 9263 717 699 470 700 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4677 r0 *1 678.16,146.16
X$4677 9264 9263 1218 471 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $4681 r0 *1 615.44,95.76
X$4681 9264 473 555 9263 716 704 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4685 r0 *1 639.52,75.6
X$4685 9263 519 9264 558 474 520 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4695 r0 *1 706.72,75.6
X$4695 9264 9263 476 565 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4699 m0 *1 696.64,85.68
X$4699 9264 476 562 566 564 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4715 m0 *1 749.28,85.68
X$4715 478 9264 567 9263 618 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $4724 m0 *1 755.44,75.6
X$4724 9264 9263 523 480 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4737 r0 *1 22.96,186.48
X$4737 9264 9263 1035 1604 483 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4742 m0 *1 8.4,186.48
X$4742 9264 1560 1771 483 1551 1035 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $4765 r0 *1 95.2,297.36
X$4765 9264 9263 486 2872 2772 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4767 r0 *1 301.28,277.2
X$4767 9264 2538 9263 2539 2365 486 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4769 r0 *1 257.6,277.2
X$4769 9263 486 2467 9264 2569 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4804 r0 *1 484.96,156.24
X$4804 9264 1135 488 1387 1333 9263 1337 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $4806 m0 *1 75.04,85.68
X$4806 9264 9263 575 539 496 489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4820 r0 *1 103.04,85.68
X$4820 9263 491 577 9264 576 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4824 m0 *1 100.8,85.68
X$4824 9263 9264 577 638 491 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $4827 r0 *1 132.16,75.6
X$4827 9263 492 493 9264 543 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4831 m0 *1 129.92,85.68
X$4831 9263 9264 493 581 492 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $4840 m0 *1 166.32,115.92
X$4840 9264 854 9263 1607 546 494 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4848 r0 *1 156.8,85.68
X$4848 9264 495 584 496 579 497 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $4850 r0 *1 161.84,75.6
X$4850 496 9263 495 497 9264 546 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4856 m0 *1 83.44,85.68
X$4856 9264 496 965 536 539 568 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $4878 r0 *1 197.68,115.92
X$4878 9264 9263 893 498 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $4891 m0 *1 249.76,75.6
X$4891 9263 501 588 9264 530 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4898 r0 *1 258.16,85.68
X$4898 9264 9263 589 502 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4908 r0 *1 261.52,85.68
X$4908 9264 548 588 9263 503 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4933 m0 *1 88.48,216.72
X$4933 9263 508 1868 9264 1730 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4935 m0 *1 291.2,267.12
X$4935 508 2420 2365 2325 9264 9263 2421 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4962 r0 *1 469.28,75.6
X$4962 9264 9263 511 535 510 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4984 r0 *1 501.76,156.24
X$4984 9264 9263 1342 514 1336 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $4992 r0 *1 509.6,126
X$4992 9264 1023 1039 1038 515 606 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $5016 r0 *1 642.32,95.76
X$5016 519 9263 9264 749 748 758 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $5019 r0 *1 717.92,85.68
X$5019 9264 9263 662 520 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $5030 r0 *1 683.76,95.76
X$5030 9264 563 521 708 752 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5033 r0 *1 688.24,75.6
X$5033 9263 562 9264 563 522 521 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5035 r0 *1 688.8,85.68
X$5035 562 9264 521 563 9263 612 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $5039 r0 *1 712.32,75.6
X$5039 9263 565 522 9264 526 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5045 m0 *1 691.6,85.68
X$5045 9263 522 612 9264 623 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5069 m0 *1 152.32,85.68
X$5069 9264 9263 620 583 528 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $5071 r0 *1 145.04,105.84
X$5071 9263 528 730 9264 838 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5081 m0 *1 161.84,95.76
X$5081 9264 583 528 9263 545 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $5085 r0 *1 664.72,95.76
X$5085 9264 9263 750 529 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5099 r0 *1 282.24,75.6
X$5099 9263 552 551 9264 532 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5121 r0 *1 80.64,75.6
X$5121 9264 537 538 9263 536 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $5123 r0 *1 118.72,95.76
X$5123 9264 682 537 569 581 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $5126 m0 *1 112,115.92
X$5126 9264 638 853 537 919 879 9263 878 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $5136 m0 *1 82.88,95.76
X$5136 9264 9263 637 537 538 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $5140 r0 *1 101.92,105.84
X$5140 9263 814 9264 638 811 537 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5143 r0 *1 42.56,95.76
X$5143 9263 674 9264 676 538 677 635 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $5145 r0 *1 45.92,105.84
X$5145 9264 9263 850 837 538 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5147 m0 *1 50.4,105.84
X$5147 9264 538 9263 813 576 791 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $5157 m0 *1 81.2,105.84
X$5157 9264 729 727 542 9263 538 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $5166 m0 *1 115.92,85.68
X$5166 9264 542 580 541 579 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $5168 m0 *1 110.88,85.68
X$5168 9263 580 541 9264 578 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5174 m0 *1 101.92,115.92
X$5174 9264 814 851 9263 852 850 542 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $5176 r0 *1 74.48,105.84
X$5176 542 9263 725 726 9264 793 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5178 m0 *1 105.84,95.76
X$5178 9264 769 585 543 638 542 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $5181 r0 *1 53.2,105.84
X$5181 9264 678 542 727 680 677 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $5190 r0 *1 115.36,105.84
X$5190 542 727 839 840 9263 9264 853 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $5193 r0 *1 52.64,85.68
X$5193 9264 9263 543 636 585 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5202 r0 *1 52.64,95.76
X$5202 9264 677 9263 791 585 543 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $5227 m0 *1 218.96,85.68
X$5227 9264 9263 570 547 683 587 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5237 m0 *1 282.24,95.76
X$5237 9263 650 685 9264 548 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5241 r0 *1 245.28,85.68
X$5241 9264 9263 549 647 588 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5243 m0 *1 246.4,85.68
X$5243 9264 549 588 9263 589 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $5270 r0 *1 224.56,136.08
X$5270 9264 9263 553 1080 1199 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5272 m0 *1 187.6,136.08
X$5272 9263 553 1050 926 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $5275 r0 *1 204.96,136.08
X$5275 9263 553 1013 9264 973 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5281 m0 *1 159.6,136.08
X$5281 9264 9263 553 1047 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5284 r0 *1 166.32,126
X$5284 9263 553 1049 9264 922 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5286 m0 *1 287.84,136.08
X$5286 9264 9263 688 553 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5289 r0 *1 255.92,146.16
X$5289 553 735 1197 1198 9264 9263 1145 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5300 r0 *1 273.84,136.08
X$5300 9263 805 9264 1100 1178 553 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5303 m0 *1 335.44,95.76
X$5303 9264 554 594 593 689 673 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $5306 m0 *1 534.24,105.84
X$5306 9263 783 555 9264 784 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5309 r0 *1 551.04,95.76
X$5309 9264 9263 555 700 698 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5311 r0 *1 556.08,105.84
X$5311 9264 9263 830 555 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5327 m0 *1 562.24,115.92
X$5327 883 9263 9264 572 555 557 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $5330 m0 *1 570.08,115.92
X$5330 9264 9263 844 883 871 555 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5353 m0 *1 622.16,115.92
X$5353 9264 557 610 558 668 904 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $5355 m0 *1 541.52,95.76
X$5355 572 9264 557 717 9263 607 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $5359 r0 *1 619.92,115.92
X$5359 9264 942 610 558 668 904 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $5364 r0 *1 731.92,136.08
X$5364 9264 1067 1130 558 1164 1129 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $5375 r0 *1 622.16,85.68
X$5375 9263 558 610 9264 627 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5379 r0 *1 705.6,176.4
X$5379 1544 1444 1490 559 9263 9264 1352 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $5393 m0 *1 711.76,176.4
X$5393 9264 1446 559 9263 1393 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $5395 m0 *1 684.32,156.24
X$5395 9264 9263 1218 559 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $5397 m0 *1 694.4,186.48
X$5397 1444 9264 997 559 9263 1546 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $5405 m0 *1 665.28,95.76
X$5405 9263 706 660 9264 560 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5444 m0 *1 674.8,327.6
X$5444 9319 9264 9263 566 3091 2864 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5446 m0 *1 735.84,196.56
X$5446 9264 1666 1668 566 1669 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5449 r0 *1 679.84,236.88
X$5449 9264 2189 566 9263 gf180mcu_fd_sc_mcu9t5v0__inv_16
* cell instance $5453 m0 *1 637.28,166.32
X$5453 1304 9264 9263 566 1263 1392 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5455 r0 *1 622.16,176.4
X$5455 1597 9264 9263 566 1442 1540 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5457 m0 *1 729.12,126
X$5457 9264 953 952 566 951 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5460 r0 *1 550.48,206.64
X$5460 1875 9264 9263 566 1849 1851 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5462 m0 *1 494.48,206.64
X$5462 9264 1744 1705 566 1745 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5466 m0 *1 515.76,176.4
X$5466 9264 1479 1344 566 1480 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5468 m0 *1 188.72,186.48
X$5468 9264 1568 1518 566 1516 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5470 m0 *1 148.96,246.96
X$5470 2159 9264 9263 566 2215 2127 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5473 m0 *1 170.8,226.8
X$5473 9264 1995 1997 566 1996 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5476 m0 *1 234.08,216.72
X$5476 1896 9264 9263 566 1897 1775 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5478 r0 *1 206.08,216.72
X$5478 9264 1938 1892 566 1939 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5480 r0 *1 122.64,196.56
X$5480 1719 9264 9263 566 1457 1643 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5482 r0 *1 165.76,186.48
X$5482 1606 9264 9263 566 1607 1608 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5485 r0 *1 440.72,186.48
X$5485 1616 9264 9263 566 1618 1599 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5487 r0 *1 408.24,196.56
X$5487 1700 9264 9263 566 1843 1653 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5489 r0 *1 364.56,206.64
X$5489 1786 9264 9263 566 1787 1694 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5491 m0 *1 286.16,186.48
X$5491 1583 9264 9263 566 1527 1526 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5542 m0 *1 100.24,226.8
X$5542 9264 1992 1936 566 1993 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5544 r0 *1 674.24,327.6
X$5544 9264 566 3397 3093 3091 3092 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $5546 r0 *1 393.12,176.4
X$5546 9264 1559 1430 566 1331 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5549 r0 *1 248.08,186.48
X$5549 9264 1614 1612 566 1578 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5552 r0 *1 645.68,257.04
X$5552 9264 2386 2289 566 2191 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5555 m0 *1 347.2,176.4
X$5555 9264 1471 1472 566 1426 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5557 m0 *1 479.92,166.32
X$5557 9264 1399 1333 1336 566 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5559 r0 *1 595.28,226.8
X$5559 9264 2074 2062 566 2061 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5562 m0 *1 659.12,146.16
X$5562 9264 1126 1031 566 1163 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5564 m0 *1 707.28,156.24
X$5564 9264 1221 1264 566 1265 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5566 r0 *1 314.16,216.72
X$5566 9264 1781 1779 566 1945 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5571 r0 *1 101.92,75.6
X$5571 9264 9263 577 568 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5576 m0 *1 138.88,85.68
X$5576 9264 569 620 621 622 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $5579 r0 *1 110.32,85.68
X$5579 9264 576 665 579 578 569 581 9263 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $5584 r0 *1 110.32,95.76
X$5584 9263 638 9264 569 635 581 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5614 m0 *1 605.92,136.08
X$5614 9264 942 572 9263 1065 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $5618 m0 *1 573.44,136.08
X$5618 572 9264 942 1064 9263 871 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $5623 r0 *1 493.36,126
X$5623 9264 9263 573 1040 1023 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5628 m0 *1 488.88,136.08
X$5628 9264 939 573 1023 1062 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $5633 r0 *1 360.64,146.16
X$5633 9264 9263 574 1234 1329 1233 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5635 m0 *1 24.64,156.24
X$5635 9263 9264 1138 964 675 1284 1237 575 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $5640 r0 *1 21.84,146.16
X$5640 9263 676 9264 575 1185 1184 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5643 m0 *1 8.4,136.08
X$5643 9263 575 9264 1235 1003 964 886 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $5649 m0 *1 43.12,105.84
X$5649 9264 9263 576 1007 674 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5654 m0 *1 88.48,95.76
X$5654 9264 728 637 619 576 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $5682 m0 *1 119.28,105.84
X$5682 9264 579 580 9263 681 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $5685 r0 *1 109.76,105.84
X$5685 9264 9263 768 579 580 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $5688 r0 *1 165.76,115.92
X$5688 9264 9263 852 915 579 956 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5696 r0 *1 203.84,105.84
X$5696 760 9264 881 9263 580 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $5719 r0 *1 175.28,95.76
X$5719 9264 645 644 583 643 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $5749 r0 *1 242.48,105.84
X$5749 9264 9263 586 843 806 819 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5754 m0 *1 210.56,95.76
X$5754 9264 9263 646 683 587 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $5769 m0 *1 295.12,95.76
X$5769 9263 652 591 9264 588 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5782 m0 *1 364.56,126
X$5782 862 9263 807 591 9264 932 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5788 r0 *1 302.4,136.08
X$5788 9264 9263 1103 1053 591 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $5790 m0 *1 372.4,126
X$5790 9263 807 591 9264 933 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5800 r0 *1 384.16,136.08
X$5800 824 9263 1108 591 9264 1181 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5811 m0 *1 342.16,105.84
X$5811 9264 9263 773 592 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $5816 r0 *1 374.08,85.68
X$5816 596 9264 595 597 9263 593 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $5822 r0 *1 359.52,85.68
X$5822 9264 597 594 595 596 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $5843 m0 *1 388.64,95.76
X$5843 9263 688 690 9264 598 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5858 r0 *1 446.32,95.76
X$5858 601 9264 696 9263 600 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $5868 m0 *1 486.64,95.76
X$5868 9264 9263 602 604 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5871 r0 *1 479.92,95.76
X$5871 9264 9263 744 722 697 602 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5882 r0 *1 496.16,85.68
X$5882 9264 9263 657 603 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5887 m0 *1 486.08,105.84
X$5887 9263 604 697 9264 780 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5892 r0 *1 506.24,115.92
X$5892 9264 9263 938 781 605 782 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5895 m0 *1 506.24,156.24
X$5895 9264 9263 1279 1256 605 1117 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5897 m0 *1 507.36,176.4
X$5897 9264 9263 1437 1478 605 1480 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5904 m0 *1 541.52,146.16
X$5904 9264 9263 866 1177 605 1122 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5907 r0 *1 540.96,156.24
X$5907 9264 9263 1207 1316 605 1302 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5921 m0 *1 548.24,176.4
X$5921 9263 1481 1438 9264 608 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5943 r0 *1 725.2,95.76
X$5943 9264 613 614 708 754 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5945 m0 *1 721.28,95.76
X$5945 614 9264 616 613 9263 714 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $5960 r0 *1 676.48,95.76
X$5960 9264 9263 615 751 666 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5966 r0 *1 634.48,95.76
X$5966 9263 747 9264 748 704 615 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5971 r0 *1 715.68,95.76
X$5971 9263 757 616 792 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $5979 r0 *1 736.96,85.68
X$5979 9264 9263 710 617 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5982 m0 *1 749.28,95.76
X$5982 9264 9263 712 713 662 618 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6012 r0 *1 201.04,95.76
X$6012 626 9263 799 731 9264 646 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $6020 r0 *1 580.16,85.68
X$6020 9264 761 9263 631 629 628 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6051 m0 *1 43.12,95.76
X$6051 9264 9263 675 635 678 636 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6059 m0 *1 51.52,95.76
X$6059 9264 636 678 9263 674 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6078 m0 *1 126,105.84
X$6078 9264 639 732 677 640 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $6083 m0 *1 130.48,95.76
X$6083 639 9263 640 732 9264 682 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6087 r0 *1 131.6,105.84
X$6087 9263 9264 640 850 639 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $6104 m0 *1 211.12,126
X$6104 9264 642 929 958 1079 817 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $6126 m0 *1 218.4,105.84
X$6126 9264 715 771 733 760 975 9263 645 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $6142 r0 *1 263.2,146.16
X$6142 9264 1081 1197 648 920 9263 1198 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $6151 m0 *1 263.76,95.76
X$6151 9263 652 648 9264 649 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6154 m0 *1 285.04,105.84
X$6154 9264 9263 760 648 651 672 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6156 m0 *1 286.16,146.16
X$6156 1102 9264 1147 9263 648 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $6160 r0 *1 245.84,95.76
X$6160 9263 9264 649 736 684 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $6167 m0 *1 280.56,115.92
X$6167 685 650 859 858 805 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $6169 m0 *1 288.96,126
X$6169 650 9263 685 859 9264 931 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6179 m0 *1 281.68,126
X$6179 9264 859 9263 1017 685 650 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6186 r0 *1 281.12,105.84
X$6186 651 9263 9264 683 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $6188 r0 *1 285.6,115.92
X$6188 9264 651 979 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $6194 r0 *1 332.64,115.92
X$6194 9264 9263 652 895 894 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6199 m0 *1 313.04,105.84
X$6199 9263 9264 652 686 738 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $6203 r0 *1 248.08,115.92
X$6203 9263 652 856 9264 737 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6206 m0 *1 272.72,126
X$6206 9264 9263 652 920 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6225 r0 *1 328.16,126
X$6225 9263 652 894 9264 981 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6228 r0 *1 308.56,95.76
X$6228 9264 9263 805 653 686 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6254 r0 *1 574,105.84
X$6254 842 9264 844 801 9263 658 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $6268 r0 *1 660.8,136.08
X$6268 9264 1078 9263 660 1126 1077 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6277 r0 *1 701.12,95.76
X$6277 709 9264 753 9263 661 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $6282 m0 *1 702.8,105.84
X$6282 9264 662 753 792 788 833 834 9263 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $6284 m0 *1 743.12,105.84
X$6284 9263 662 789 9264 755 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6297 r0 *1 750.96,95.76
X$6297 9264 713 756 9263 663 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6303 r0 *1 101.92,146.16
X$6303 9264 1226 1142 1190 665 1009 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $6305 m0 *1 63.28,105.84
X$6305 9264 914 665 677 679 794 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6307 r0 *1 65.52,95.76
X$6307 9263 665 724 677 726 725 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $6309 r0 *1 90.72,156.24
X$6309 9264 1287 840 9263 1366 665 1009 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $6327 r0 *1 89.6,126
X$6327 9263 1011 9264 1009 970 665 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6331 m0 *1 62.16,146.16
X$6331 9263 1089 9264 1140 1009 1141 665 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $6333 r0 *1 63.84,146.16
X$6333 9263 1046 9264 1009 1188 665 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6335 r0 *1 71.12,156.24
X$6335 665 9264 1009 1010 9263 1364 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $6337 m0 *1 76.16,146.16
X$6337 9264 1072 1091 1009 665 9263 1088 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $6361 m0 *1 576.8,105.84
X$6361 9264 9263 670 761 698 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6363 r0 *1 550.48,176.4
X$6363 9264 670 1481 1438 1482 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $6388 r0 *1 289.52,105.84
X$6388 9264 9263 806 672 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6400 m0 *1 18.48,115.92
X$6400 811 9263 675 837 9264 877 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6402 r0 *1 17.36,126
X$6402 9263 675 965 9264 1004 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6411 m0 *1 22.4,146.16
X$6411 9264 9263 1137 675 1043 1167 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6413 r0 *1 22.96,126
X$6413 9264 9263 1005 966 675 965 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6416 r0 *1 29.68,136.08
X$6416 9263 675 9264 1086 1167 728 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6423 r0 *1 115.92,115.92
X$6423 677 9263 729 996 9264 727 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $6438 r0 *1 101.92,115.92
X$6438 9264 851 852 677 9263 1009 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $6449 r0 *1 75.04,95.76
X$6449 9263 681 9264 680 679 727 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6452 r0 *1 82.88,95.76
X$6452 727 9264 680 681 9263 794 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $6456 m0 *1 53.76,115.92
X$6456 9264 9263 727 888 680 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6463 m0 *1 76.72,115.92
X$6463 9264 9263 851 680 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $6467 m0 *1 58.8,115.92
X$6467 9264 727 680 9263 889 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6477 r0 *1 123.2,105.84
X$6477 9263 682 769 9264 815 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6484 r0 *1 192.08,126
X$6484 9264 841 972 683 977 971 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $6486 m0 *1 213.92,136.08
X$6486 9264 683 9263 1079 1015 1080 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6497 m0 *1 192.08,126
X$6497 9264 9263 816 957 683 927 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6503 r0 *1 250.88,105.84
X$6503 9263 688 684 9264 843 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6507 r0 *1 246.96,126
X$6507 9264 930 976 9263 684 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $6532 m0 *1 328.72,115.92
X$6532 9264 9263 860 687 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6539 r0 *1 328.16,105.84
X$6539 9264 9263 688 846 807 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6545 m0 *1 389.2,146.16
X$6545 9264 688 9263 1233 1109 1182 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6559 m0 *1 244.72,115.92
X$6559 9263 805 9264 856 819 688 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6562 r0 *1 327.6,115.92
X$6562 9263 688 807 9264 961 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6567 r0 *1 354.48,136.08
X$6567 9264 9263 1054 1105 690 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $6579 r0 *1 364.56,136.08
X$6579 9264 9263 1083 690 1106 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6581 r0 *1 357.28,126
X$6581 690 9263 894 738 9264 1002 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6584 r0 *1 370.72,136.08
X$6584 9263 822 690 9264 1152 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6586 r0 *1 374.64,126
X$6586 9264 1083 9263 1107 933 690 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6604 m0 *1 430.08,105.84
X$6604 9263 775 9264 776 694 777 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6616 m0 *1 578.48,115.92
X$6616 697 9263 871 831 9264 842 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6622 r0 *1 640.08,115.92
X$6622 716 787 697 1263 948 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $6646 m0 *1 571.76,105.84
X$6646 9264 9263 802 762 698 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6656 m0 *1 537.6,156.24
X$6656 1342 1204 1345 1276 9264 9263 698 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6662 m0 *1 552.72,105.84
X$6662 9263 828 829 701 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $6668 r0 *1 594.16,115.92
X$6668 9264 9263 959 945 703 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6679 m0 *1 602.56,105.84
X$6679 9264 9263 785 703 746 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6694 m0 *1 654.64,136.08
X$6694 9264 706 1030 948 1031 1077 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6706 m0 *1 725.76,206.64
X$6706 9264 1758 1815 708 1811 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $6709 r0 *1 632.8,176.4
X$6709 9264 1542 1541 708 1543 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $6723 m0 *1 724.64,115.92
X$6723 9264 907 908 708 873 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $6725 m0 *1 705.6,206.64
X$6725 9263 9264 1592 708 1629 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $6729 m0 *1 642.32,176.4
X$6729 9264 1443 1125 708 1488 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $6731 m0 *1 642.88,136.08
X$6731 9264 1030 948 708 1029 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $6733 r0 *1 687.12,156.24
X$6733 9264 1220 1219 708 1305 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $6737 m0 *1 692.16,105.84
X$6737 9263 709 753 9264 795 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6747 r0 *1 700,115.92
X$6747 709 9263 905 906 9264 788 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6750 r0 *1 738.64,115.92
X$6750 9264 710 874 9263 910 909 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6755 r0 *1 701.12,136.08
X$6755 9264 1351 1127 1075 1033 1128 9263 711 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $6758 m0 *1 748.16,105.84
X$6758 9263 789 711 9264 756 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6768 m0 *1 767.2,126
X$6768 9264 713 955 9263 1070 950 912 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $6782 m0 *1 642.32,105.84
X$6782 9264 9263 830 749 716 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6784 r0 *1 641.76,105.84
X$6784 9264 797 786 716 830 9263 748 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $6786 r0 *1 632.24,105.84
X$6786 830 716 786 748 9264 9263 947 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6811 r0 *1 476,105.84
X$6811 847 779 849 744 9263 9264 720 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $6813 m0 *1 450.8,105.84
X$6813 9264 9263 721 810 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6818 m0 *1 449.68,136.08
X$6818 9264 9263 721 1059 984 1022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6824 m0 *1 38.08,105.84
X$6824 9264 9263 723 767 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6827 m0 *1 15.12,105.84
X$6827 9263 723 724 9264 790 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6830 m0 *1 10.08,105.84
X$6830 9264 9263 723 885 724 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6832 m0 *1 93.52,105.84
X$6832 9264 729 768 727 730 731 9263 723 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $6843 r0 *1 103.04,95.76
X$6843 9264 9263 725 730 731 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6850 r0 *1 82.88,105.84
X$6850 9264 838 9263 766 726 725 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6857 r0 *1 92.96,105.84
X$6857 726 9263 9264 729 727 768 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $6863 m0 *1 109.2,126
X$6863 9264 9263 852 727 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6892 m0 *1 30.8,146.16
X$6892 9264 1085 728 9263 1138 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6895 r0 *1 31.36,126
X$6895 9264 9263 966 728 1086 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6904 r0 *1 86.24,115.92
X$6904 9264 851 729 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $6908 m0 *1 119.28,126
X$6908 9263 852 729 9264 919 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6934 r0 *1 258.72,105.84
X$6934 884 803 804 845 9264 9263 733 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6944 r0 *1 262.64,136.08
X$6944 1145 1082 1101 734 1052 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $6957 m0 *1 252.56,115.92
X$6957 9264 9263 857 735 737 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6960 m0 *1 265.44,146.16
X$6960 9264 9263 1101 1146 735 1178 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6962 m0 *1 276.64,146.16
X$6962 9263 1102 1147 9264 735 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6982 r0 *1 203.28,115.92
X$6982 9263 737 893 9264 882 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6987 r0 *1 392.56,126
X$6987 822 9263 1019 738 9264 1041 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6989 m0 *1 407.68,146.16
X$6989 821 9263 1110 738 9264 1183 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6997 r0 *1 312.48,136.08
X$6997 9264 1104 738 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $7025 r0 *1 390.88,136.08
X$7025 9264 9263 980 1108 742 1056 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7043 m0 *1 416.64,156.24
X$7043 9264 9263 1202 1280 742 1252 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7046 m0 *1 476.56,115.92
X$7046 778 743 825 780 9264 9263 847 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7066 r0 *1 492.8,136.08
X$7066 1135 9264 1116 1133 9263 745 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $7074 m0 *1 633.92,105.84
X$7074 9264 9263 786 747 748 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7092 m0 *1 658,126
X$7092 948 750 1077 1031 9264 9263 998 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7108 m0 *1 688.24,105.84
X$7108 9264 9263 752 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7121 m0 *1 728.56,105.84
X$7121 9264 9263 754 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7145 m0 *1 201.6,105.84
X$7145 9263 798 9264 799 817 760 880 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $7154 m0 *1 361.76,166.32
X$7154 9264 763 1204 9263 1381 1402 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $7168 r0 *1 13.44,105.84
X$7168 811 9264 765 9263 812 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7174 r0 *1 22.96,105.84
X$7174 9263 811 765 9264 835 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7181 r0 *1 36.96,105.84
X$7181 813 766 767 793 9263 9264 836 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $7183 r0 *1 19.6,115.92
X$7183 9264 913 885 967 813 766 9263 1044 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $7192 m0 *1 129.36,176.4
X$7192 9264 1412 9263 1457 996 769 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7194 m0 *1 108.08,156.24
X$7194 9264 1238 1288 1240 769 996 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $7196 m0 *1 125.44,166.32
X$7196 9263 9264 769 1322 996 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $7200 r0 *1 133.28,166.32
X$7200 769 9263 996 1367 9264 1449 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7203 m0 *1 108.08,166.32
X$7203 9264 1398 9263 1321 996 769 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7211 m0 *1 98.56,136.08
X$7211 9264 1073 1171 996 1074 769 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7214 r0 *1 101.92,136.08
X$7214 9264 1087 1225 995 769 996 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $7225 m0 *1 180.32,186.48
X$7225 9264 9263 1462 1570 770 1516 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7227 r0 *1 208.32,166.32
X$7227 9264 9263 1367 1418 770 1372 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7230 r0 *1 211.12,176.4
X$7230 9264 9263 1460 1520 770 1464 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7232 r0 *1 216.16,186.48
X$7232 9264 9263 1413 1573 770 1574 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7234 m0 *1 202.16,156.24
X$7234 9264 9263 1239 1244 770 1313 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7236 r0 *1 155.68,126
X$7236 9264 9263 851 924 770 1012 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $7239 m0 *1 159.6,146.16
X$7239 9264 9263 840 1049 770 1143 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $7247 r0 *1 343.84,105.84
X$7247 9264 773 848 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $7254 r0 *1 422.24,105.84
X$7254 9263 824 775 9264 774 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7277 r0 *1 462.56,126
X$7277 9264 1060 9263 778 1022 984 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7288 m0 *1 503.44,115.92
X$7288 9264 9263 867 781 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7304 r0 *1 507.92,136.08
X$7304 997 9264 1117 9263 782 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7307 m0 *1 546.56,115.92
X$7307 9264 830 9263 829 783 916 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7313 r0 *1 531.44,115.92
X$7313 9264 9263 868 783 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7329 r0 *1 668.08,105.84
X$7329 9264 9263 796 787 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $7344 r0 *1 745.92,115.92
X$7344 9264 9263 910 789 909 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7346 m0 *1 12.32,216.72
X$7346 790 1725 1770 1006 9264 9263 1885 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7348 r0 *1 12.88,206.64
X$7348 790 9263 1044 1770 9264 1814 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7383 r0 *1 582.4,115.92
X$7383 9263 831 800 9264 943 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7406 m0 *1 73.92,216.72
X$7406 9263 9264 805 1685 1934 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $7408 r0 *1 73.92,216.72
X$7408 9263 805 1934 9264 1970 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7414 r0 *1 207.76,257.04
X$7414 9264 805 2286 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $7416 r0 *1 79.52,146.16
X$7416 9264 805 1008 1047 1189 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $7432 r0 *1 63.84,257.04
X$7432 9263 805 2072 9264 2356 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7434 m0 *1 55.44,166.32
X$7434 9264 1354 1355 1320 805 9263 1003 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $7461 m0 *1 352.8,126
X$7461 9264 9263 894 807 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $7481 m0 *1 13.44,115.92
X$7481 9264 9263 811 887 837 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7488 r0 *1 12.32,115.92
X$7488 9264 9263 812 886 877 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7490 r0 *1 12.32,166.32
X$7490 9264 9263 812 1403 1007 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7492 m0 *1 12.88,176.4
X$7492 9264 9263 1825 1403 1404 812 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $7504 m0 *1 13.44,126
X$7504 9264 918 812 9263 965 877 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $7515 r0 *1 61.6,115.92
X$7515 9264 889 815 9263 890 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7519 r0 *1 53.76,115.92
X$7519 9263 888 9264 815 994 889 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7522 r0 *1 194.88,105.84
X$7522 855 9263 9264 841 817 816 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7529 m0 *1 194.88,115.92
X$7529 9264 841 816 9263 880 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7533 r0 *1 226.8,105.84
X$7533 9264 9263 818 817 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $7537 m0 *1 201.6,115.92
X$7537 9264 855 9263 881 882 817 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7544 r0 *1 212.24,126
X$7544 9264 9263 891 1013 817 1014 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7548 r0 *1 232.4,126
X$7548 9264 818 975 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $7554 r0 *1 222.88,146.16
X$7554 9264 9263 1143 1228 818 1194 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7571 r0 *1 364.56,126
X$7571 9263 821 9264 932 982 1002 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7575 r0 *1 408.8,126
X$7575 9263 1020 983 9264 821 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7577 r0 *1 407.68,115.92
X$7577 9264 9263 822 934 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7581 r0 *1 384.72,126
X$7581 1018 9263 9264 1019 822 859 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7588 m0 *1 400.96,115.92
X$7588 9263 865 823 9264 822 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7618 m0 *1 411.04,136.08
X$7618 1020 9264 983 9263 824 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7628 m0 *1 488.32,126
X$7628 9264 9263 826 901 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7633 r0 *1 471.52,136.08
X$7633 9263 1113 826 985 898 984 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $7640 m0 *1 535.92,126
X$7640 9264 902 870 827 941 903 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $7646 r0 *1 535.36,115.92
X$7646 9264 828 902 868 941 903 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $7657 r0 *1 720.16,126
X$7657 830 989 876 993 9264 9263 1034 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7659 m0 *1 702.8,126
X$7659 9264 9263 905 830 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7662 m0 *1 703.92,115.92
X$7662 872 9263 830 906 9264 833 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7664 m0 *1 720.72,126
X$7664 9264 9263 830 950 989 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7666 m0 *1 715.12,126
X$7666 9263 830 989 9264 910 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7699 m0 *1 709.52,136.08
X$7699 9264 1076 1075 1032 834 910 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7703 r0 *1 686,126
X$7703 987 949 1028 906 9264 9263 834 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7711 r0 *1 21.28,176.4
X$7711 9263 835 1267 9264 1511 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7713 r0 *1 17.36,166.32
X$7713 9264 835 9263 1363 1284 1236 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7715 r0 *1 30.24,166.32
X$7715 9264 9263 1007 835 1405 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $7718 r0 *1 19.04,136.08
X$7718 913 1085 836 835 9263 9264 1043 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $7728 m0 *1 17.36,166.32
X$7728 9264 1007 835 9263 1236 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $7732 r0 *1 33.04,146.16
X$7732 913 9263 836 1285 9264 1085 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $7734 r0 *1 9.52,146.16
X$7734 9264 836 1085 913 9263 1184 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $7741 m0 *1 20.72,126
X$7741 9264 913 836 9263 964 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7758 m0 *1 133.84,126
X$7758 9264 9263 839 920 923 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $7763 r0 *1 80.08,126
X$7763 840 9264 970 9263 1037 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7765 r0 *1 70.56,126
X$7765 9263 840 970 9264 968 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7768 r0 *1 130.48,115.92
X$7768 840 9264 1011 9263 879 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7770 m0 *1 87.92,176.4
X$7770 9263 1407 9264 1365 840 1366 1011 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $7781 r0 *1 106.96,166.32
X$7781 9264 1398 1410 9263 840 1011 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $7829 m0 *1 86.24,136.08
X$7829 9264 850 1008 1046 9263 1074 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $7837 m0 *1 94.08,156.24
X$7837 9264 1008 1239 850 9263 1190 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $7839 m0 *1 95.2,146.16
X$7839 9264 1092 1010 850 9263 1142 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $7841 r0 *1 85.12,136.08
X$7841 9264 1090 850 1092 9263 1073 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $7870 m0 *1 184.8,156.24
X$7870 854 9263 1191 1243 9264 1271 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7873 r0 *1 188.16,186.48
X$7873 1518 9264 854 1569 9263 1610 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $7879 m0 *1 201.6,186.48
X$7879 9263 1518 9264 1569 1571 854 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7881 r0 *1 194.88,186.48
X$7881 9264 1569 854 1534 1611 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $7886 m0 *1 246.96,126
X$7886 9264 9263 856 930 976 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $7894 r0 *1 327.04,136.08
X$7894 1104 9263 9264 859 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $7914 m0 *1 314.16,156.24
X$7914 9264 860 1204 9263 1249 1275 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $7921 m0 *1 371.28,115.92
X$7921 9264 9263 862 863 864 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7930 m0 *1 358.96,136.08
X$7930 9264 1054 1105 9263 862 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $7966 r0 *1 505.68,146.16
X$7966 9263 997 1256 9264 867 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7974 m0 *1 528.08,126
X$7974 870 903 941 902 9263 9264 869 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $7976 m0 *1 544.88,156.24
X$7976 9263 870 1257 9264 1276 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7978 r0 *1 549.92,115.92
X$7978 9264 9263 870 916 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8000 m0 *1 726.88,126
X$8000 9264 9263 873 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8004 m0 *1 736.4,115.92
X$8004 9264 9263 908 874 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8008 r0 *1 766.08,115.92
X$8008 9264 875 9263 912 876 911 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8010 m0 *1 765.52,115.92
X$8010 875 9263 911 876 9264 955 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8012 m0 *1 762.72,126
X$8012 9264 9263 954 875 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8014 r0 *1 738.08,126
X$8014 9264 909 992 876 1036 991 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $8018 r0 *1 724.08,115.92
X$8018 9264 952 876 907 908 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $8031 m0 *1 47.6,146.16
X$8031 1088 9263 1087 878 9264 1139 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8034 r0 *1 54.88,146.16
X$8034 878 1141 1238 1187 9264 9263 1086 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8037 r0 *1 47.6,146.16
X$8037 9264 1513 1088 9263 1087 878 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $8044 r0 *1 43.68,115.92
X$8044 9263 9264 914 913 878 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $8069 m0 *1 8.96,206.64
X$8069 9263 885 1725 9264 1759 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8080 r0 *1 4.48,136.08
X$8080 9264 887 1267 1003 964 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $8082 r0 *1 53.2,126
X$8082 9264 888 1045 969 890 1037 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $8095 m0 *1 171.36,126
X$8095 9263 891 925 9264 956 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8097 r0 *1 180.88,115.92
X$8097 9263 891 892 9264 915 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8103 m0 *1 180.88,126
X$8103 9264 971 925 9263 892 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8108 m0 *1 203.84,136.08
X$8108 9264 9263 893 971 1013 928 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8114 r0 *1 339.36,136.08
X$8114 9264 9263 894 1106 1104 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8126 r0 *1 345.52,146.16
X$8126 9264 894 1148 1149 9263 gf180mcu_fd_sc_mcu9t5v0__xor2_4
* cell instance $8130 r0 *1 467.04,115.92
X$8130 9263 898 896 9264 899 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8134 r0 *1 455.28,115.92
X$8134 9264 9263 898 897 896 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8136 r0 *1 454.16,126
X$8136 9263 1021 985 9264 896 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8139 m0 *1 451.92,126
X$8139 9264 9263 936 963 938 897 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8144 r0 *1 461.44,156.24
X$8144 1254 9264 898 9263 1318 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $8153 m0 *1 478.8,156.24
X$8153 9264 1255 917 9263 898 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8155 m0 *1 462.56,146.16
X$8155 9264 1112 898 9263 1114 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8158 m0 *1 465.36,126
X$8158 9264 9263 937 962 938 899 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8160 m0 *1 477.68,126
X$8160 9263 900 939 9264 940 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8166 m0 *1 482.72,136.08
X$8166 1061 9263 900 1040 9264 1084 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8175 r0 *1 534.24,126
X$8175 9263 1025 1026 9264 902 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8191 r0 *1 689.92,146.16
X$8191 9264 9263 1218 905 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8198 m0 *1 697.2,176.4
X$8198 9264 1489 906 1490 1444 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $8212 r0 *1 731.36,126
X$8212 908 9264 952 907 9263 993 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $8225 m0 *1 735.28,136.08
X$8225 9263 909 910 9264 1067 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8235 r0 *1 751.52,136.08
X$8235 9264 1130 1071 910 1068 9263 1131 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $8254 m0 *1 759.36,126
X$8254 9264 9263 953 911 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8264 m0 *1 763.28,136.08
X$8264 9263 1069 9264 912 1071 990 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8267 r0 *1 760.48,146.16
X$8267 1069 9264 990 912 9263 1131 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $8280 m0 *1 14.56,156.24
X$8280 1282 9263 9264 1085 913 1236 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8296 r0 *1 14.56,196.56
X$8296 9264 1725 1184 1236 1139 914 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8299 r0 *1 25.2,206.64
X$8299 9264 914 1139 9263 1770 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8309 r0 *1 501.2,126
X$8309 9264 9263 917 1000 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $8311 m0 *1 491.68,166.32
X$8311 9263 1337 1386 917 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $8321 m0 *1 516.88,136.08
X$8321 9263 944 1039 1024 997 917 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $8326 r0 *1 9.52,126
X$8326 964 1003 918 966 9263 9264 1035 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8330 r0 *1 226.24,126
X$8330 9264 9263 920 974 972 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8332 m0 *1 221.2,136.08
X$8332 9264 9263 920 1015 978 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8335 m0 *1 176.96,136.08
X$8335 9263 920 1097 9264 925 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8338 m0 *1 119.28,146.16
X$8338 9264 9263 920 1186 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8353 m0 *1 233.52,136.08
X$8353 9264 920 972 9263 1016 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8358 m0 *1 259.84,146.16
X$8358 9264 9263 1146 920 1100 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $8362 m0 *1 157.36,126
X$8362 9263 921 9264 922 924 923 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8369 r0 *1 137.76,136.08
X$8369 9264 923 1048 1093 1132 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $8378 m0 *1 131.04,136.08
X$8378 9263 1047 923 9264 1011 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8380 r0 *1 157.36,136.08
X$8380 9263 1095 9264 1096 1012 923 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8392 r0 *1 195.44,136.08
X$8392 9263 978 926 9264 927 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8394 m0 *1 201.6,126
X$8394 9264 9263 926 928 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8396 m0 *1 187.04,126
X$8396 9263 972 926 9264 957 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8407 m0 *1 210.56,156.24
X$8407 9264 929 1245 9263 1294 1271 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $8414 m0 *1 245.84,146.16
X$8414 9264 930 9263 1100 1229 1051 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8423 m0 *1 271.6,136.08
X$8423 1052 9263 9264 931 1017 1081 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8426 m0 *1 279.44,136.08
X$8426 9264 1017 931 9263 1082 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8435 m0 *1 369.04,146.16
X$8435 9264 9263 1150 1179 1152 933 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8442 m0 *1 446.88,126
X$8442 9264 9263 984 963 935 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8444 m0 *1 460.32,126
X$8444 9263 984 935 9264 962 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8447 r0 *1 448.56,136.08
X$8447 9264 9263 935 1113 1112 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $8467 r0 *1 526.4,146.16
X$8467 9264 941 1155 1208 1134 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $8487 r0 *1 575.68,126
X$8487 9264 9263 943 1120 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8494 m0 *1 502.32,136.08
X$8494 9264 1038 944 1024 1000 997 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $8502 r0 *1 519.68,136.08
X$8502 9264 1024 944 9263 1117 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8509 m0 *1 602.56,136.08
X$8509 9264 9263 1125 946 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8521 r0 *1 655.2,136.08
X$8521 9264 948 1030 9263 1170 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8532 r0 *1 721.84,146.16
X$8532 9264 1223 1066 950 1268 9263 1222 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $8541 m0 *1 703.92,166.32
X$8541 9264 951 1307 1352 1308 1353 1393 9263 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $8554 m0 *1 748.72,136.08
X$8554 990 9263 953 992 9264 1068 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $8562 r0 *1 758.24,126
X$8562 954 9263 990 991 9264 1068 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $8606 r0 *1 13.44,156.24
X$8606 964 9264 1003 1282 9263 1281 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $8628 r0 *1 39.2,136.08
X$8628 9263 967 968 9264 1726 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8633 r0 *1 48.72,136.08
X$8633 9263 9264 1087 967 1088 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $8636 r0 *1 38.64,126
X$8636 9264 994 1006 968 967 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $8646 r0 *1 62.16,156.24
X$8646 9264 1309 9263 1286 969 1319 1094 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $8666 r0 *1 257.04,126
X$8666 9264 977 9263 1014 972 979 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8677 r0 *1 282.8,156.24
X$8677 9264 972 1296 1232 9263 gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* cell instance $8688 r0 *1 234.64,166.32
X$8688 9264 9263 1272 1400 975 1374 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8694 r0 *1 239.68,186.48
X$8694 9264 9263 1464 1613 975 1578 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8697 m0 *1 254.8,176.4
X$8697 9264 9263 1372 1502 975 1420 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8699 r0 *1 259.84,186.48
X$8699 9264 9263 1574 1602 975 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8702 r0 *1 244.16,136.08
X$8702 9263 1099 1051 976 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $8714 r0 *1 278.32,146.16
X$8714 9264 9263 978 1199 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8723 r0 *1 339.36,176.4
X$8723 9264 9263 978 1557 1329 1470 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8725 r0 *1 301.84,156.24
X$8725 9264 9263 1194 1298 979 1299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8733 m0 *1 299.6,176.4
X$8733 9264 9263 1374 1505 979 1469 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8735 m0 *1 299.04,186.48
X$8735 9264 9263 1420 1603 979 1530 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8737 m0 *1 273.28,186.48
X$8737 9264 9263 1581 1555 979 1527 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8753 r0 *1 421.12,136.08
X$8753 9264 1057 1136 9263 983 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $8764 r0 *1 464.24,136.08
X$8764 9264 1060 9263 1115 1113 984 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8766 m0 *1 475.44,146.16
X$8766 9264 9263 984 1116 985 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8770 r0 *1 450.8,126
X$8770 9264 9263 984 1021 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8786 r0 *1 468.16,146.16
X$8786 9263 985 1084 9264 1206 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8788 m0 *1 451.92,146.16
X$8788 9263 985 1112 9264 1180 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8791 r0 *1 454.16,136.08
X$8791 9264 1113 9263 1059 1114 985 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8800 r0 *1 456.4,146.16
X$8800 9264 1113 985 1153 1207 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $8807 r0 *1 486.08,136.08
X$8807 9263 1115 1116 9264 986 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8809 r0 *1 563.36,136.08
X$8809 9264 9263 987 1133 1028 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8812 m0 *1 563.92,156.24
X$8812 9263 987 1028 9264 1204 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8826 r0 *1 701.68,378
X$8826 9263 987 3650 9264 2997 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8828 r0 *1 638.4,236.88
X$8828 9264 9263 2142 987 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $8834 m0 *1 696.08,156.24
X$8834 1219 1306 1264 9264 9263 988 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $8839 m0 *1 702.24,186.48
X$8839 9263 1489 9264 989 1444 1629 1490 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $8852 r0 *1 766.64,136.08
X$8852 9264 1068 9263 1070 990 1069 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8883 m0 *1 95.76,126
X$8883 9263 1010 1008 9264 995 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8902 m0 *1 661.92,186.48
X$8902 9264 9327 1592 1545 997 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $8946 m0 *1 18.48,136.08
X$8946 9264 9263 1042 1004 1043 1005 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8951 m0 *1 44.24,226.8
X$8951 9264 9263 1006 1991 1990 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8953 m0 *1 19.6,216.72
X$8953 1725 1006 1814 1863 9264 9263 2069 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8958 r0 *1 43.12,196.56
X$8958 9264 9263 1715 1672 1006 1640 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8961 r0 *1 8.4,216.72
X$8961 1725 9263 1006 1814 9264 1986 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8968 r0 *1 20.16,216.72
X$8968 9264 1965 1725 9263 1006 1814 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $8980 m0 *1 80.64,136.08
X$8980 9263 1090 1008 9264 1072 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9009 m0 *1 126,156.24
X$9009 9264 9263 1239 1010 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9011 r0 *1 122.08,146.16
X$9011 9263 1047 1010 9264 1240 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9045 r0 *1 229.6,136.08
X$9045 1051 9264 1099 9263 1013 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9069 r0 *1 399.28,136.08
X$9069 9264 9263 1019 1056 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9080 m0 *1 447.44,156.24
X$9080 9264 9263 1019 1206 1253 1207 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9085 m0 *1 429.52,146.16
X$9085 9263 1020 1058 9264 1154 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9101 m0 *1 456.96,146.16
X$9101 9264 1113 1180 9263 1022 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9116 r0 *1 530.32,136.08
X$9116 9263 1025 1118 9264 1063 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9120 m0 *1 524.16,146.16
X$9120 9264 9263 1156 1134 1025 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9122 m0 *1 534.24,166.32
X$9122 1317 1344 1025 1156 9264 9263 1345 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9130 m0 *1 534.24,146.16
X$9130 9264 1026 9263 1118 1119 1156 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9134 r0 *1 539.84,146.16
X$9134 9264 1026 1156 1122 1153 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $9137 m0 *1 600.32,146.16
X$9137 9263 1173 9264 1027 1211 1065 1158 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $9146 m0 *1 568.96,236.88
X$9146 2101 1028 2102 2103 9264 9263 2447 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9148 r0 *1 566.72,236.88
X$9148 9264 2182 2102 1028 2101 9263 2103 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $9167 m0 *1 680.4,277.2
X$9167 9264 2999 2437 2497 1028 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $9171 r0 *1 652.4,126
X$9171 9264 9263 1029 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9180 r0 *1 664.72,146.16
X$9180 9264 1126 9263 1224 1170 1031 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9182 m0 *1 653.52,156.24
X$9182 1031 9264 1170 9263 1217 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9197 r0 *1 719.6,156.24
X$9197 9264 9263 1307 1032 1308 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9203 m0 *1 10.64,196.56
X$9203 9264 9263 1035 1812 1235 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9206 m0 *1 15.68,196.56
X$9206 9263 1035 1235 9264 1639 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9220 m0 *1 773.92,136.08
X$9220 9264 9263 1069 1068 1036 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $9241 m0 *1 21.84,246.96
X$9241 9263 1771 1042 9264 2152 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9243 m0 *1 15.68,236.88
X$9243 9264 2150 2109 1042 2152 1987 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $9245 r0 *1 20.16,236.88
X$9245 1827 2031 1042 2069 9264 9263 2032 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9260 m0 *1 12.88,246.96
X$9260 9264 1044 9263 1281 2188 2151 1885 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $9263 r0 *1 11.76,236.88
X$9263 9263 1044 1281 9264 2149 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9271 m0 *1 27.44,216.72
X$9271 9264 2349 1683 1826 1045 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $9274 m0 *1 43.12,216.72
X$9274 9264 1045 9263 1989 1139 1494 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9279 r0 *1 80.08,136.08
X$9279 9263 1046 1092 9264 1091 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9281 r0 *1 76.72,136.08
X$9281 9264 9263 1046 1090 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9283 m0 *1 57.12,146.16
X$9283 9263 1186 1046 9264 1140 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9292 m0 *1 134.96,146.16
X$9292 9263 1093 1048 9264 1046 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9296 m0 *1 73.36,226.8
X$9296 9264 1047 1868 9263 1934 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $9299 r0 *1 116.48,277.2
X$9299 9264 9263 1047 2530 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $9303 m0 *1 150.08,146.16
X$9303 9263 1047 1143 9264 1096 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9305 r0 *1 69.44,136.08
X$9305 9263 1047 1090 9264 1089 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9307 r0 *1 76.72,166.32
X$9307 9263 1047 1189 9264 1397 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9311 r0 *1 106.96,317.52
X$9311 9263 2954 1047 2955 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $9332 r0 *1 69.44,246.96
X$9332 9264 9263 2213 1047 2192 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $9338 m0 *1 136.64,156.24
X$9338 9264 1241 1270 9263 1048 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $9349 r0 *1 192.08,146.16
X$9349 1191 9264 1192 9263 1049 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9354 r0 *1 181.44,136.08
X$9354 9264 9263 1097 1050 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $9361 r0 *1 249.76,146.16
X$9361 1051 9263 1098 1196 9264 1197 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9372 m0 *1 305.2,146.16
X$9372 9264 1053 1103 9263 1104 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $9388 m0 *1 420,146.16
X$9388 1058 9264 1111 9263 1110 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9391 r0 *1 431.2,136.08
X$9391 9263 1111 1058 1136 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $9407 r0 *1 481.04,136.08
X$9407 9264 9263 1115 1062 1061 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9409 m0 *1 471.52,156.24
X$9409 9264 1112 9263 1061 1255 1254 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9420 r0 *1 568.4,146.16
X$9420 9263 1209 1230 9264 1064 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9423 r0 *1 604.24,176.4
X$9423 9263 1447 9264 1302 1065 1348 1498 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $9425 r0 *1 605.36,166.32
X$9425 9264 9263 1065 1447 1391 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9427 r0 *1 598.64,176.4
X$9427 9264 9263 1480 1541 1065 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $9432 r0 *1 599.76,146.16
X$9432 9264 9263 1065 1173 1212 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9438 m0 *1 692.16,196.56
X$9438 9264 1493 1665 1628 1066 1351 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $9443 m0 *1 691.04,206.64
X$9443 9264 1549 1066 1628 1351 1665 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $9453 m0 *1 711.76,146.16
X$9453 9263 1265 9264 1169 1128 1066 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9505 r0 *1 652.96,146.16
X$9505 9263 1077 1224 9264 1227 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9542 m0 *1 107.52,146.16
X$9542 9264 9263 1171 1226 1085 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $9592 r0 *1 95.76,146.16
X$9592 9263 1239 1092 9264 1225 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9596 m0 *1 80.08,156.24
X$9596 9264 9263 1186 1189 1092 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $9604 m0 *1 182.56,327.6
X$9604 9264 9263 1094 3029 2704 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9606 r0 *1 152.32,136.08
X$9606 9264 9263 1094 1095 1143 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9608 r0 *1 88.48,267.12
X$9608 9264 9263 1094 2410 2314 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9610 m0 *1 78.4,267.12
X$9610 9264 9263 1094 2443 1676 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9615 m0 *1 265.44,347.76
X$9615 9264 9263 1094 3369 2729 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9633 m0 *1 117.6,347.76
X$9633 9264 1094 3066 9263 3158 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9635 m0 *1 238,347.76
X$9635 9264 3168 9263 3368 2964 1094 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9637 r0 *1 282.24,267.12
X$9637 1094 2288 2423 2324 9263 9264 2419 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $9640 m0 *1 93.52,347.76
X$9640 9264 1094 3353 3219 3215 2763 2111 9263 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $9646 r0 *1 178.64,146.16
X$9646 9264 1097 1192 1191 1174 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $9653 r0 *1 231.28,146.16
X$9653 1098 9264 1144 9263 1228 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9655 m0 *1 244.72,156.24
X$9655 9263 1098 1246 9264 1195 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9663 m0 *1 229.6,146.16
X$9663 9263 1098 1144 9264 1175 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9670 m0 *1 234.64,146.16
X$9670 9264 1193 1175 9263 1099 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $9684 r0 *1 301.28,146.16
X$9684 1102 9263 1232 1248 9264 1275 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9686 m0 *1 295.68,146.16
X$9686 9263 1147 1102 1103 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $9703 m0 *1 348.88,146.16
X$9703 9263 1148 1149 1105 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $9709 m0 *1 365.12,146.16
X$9709 9264 9263 1106 1179 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9717 r0 *1 407.12,136.08
X$9717 9264 9263 1110 1108 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9732 m0 *1 430.08,156.24
X$9732 9264 1205 1251 9263 1111 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $9784 r0 *1 539.84,136.08
X$9784 1156 9264 1119 9263 1177 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9788 m0 *1 529.2,146.16
X$9788 9264 9263 1155 1119 1208 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9793 m0 *1 581.28,166.32
X$9793 1121 9263 1259 1349 9264 1347 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9795 r0 *1 582.96,166.32
X$9795 1389 1121 1259 1349 9264 9263 1448 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9798 r0 *1 577.92,136.08
X$9798 9264 9263 1121 1209 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9814 m0 *1 600.32,166.32
X$9814 9263 1350 1357 9264 1123 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9821 m0 *1 613.76,146.16
X$9821 9264 9263 1124 1160 1159 1172 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9831 r0 *1 619.36,166.32
X$9831 9264 9263 1442 1125 1159 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $9834 r0 *1 644,166.32
X$9834 1125 9264 1392 1443 9263 1395 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $9836 r0 *1 634.48,166.32
X$9836 9263 1392 9264 1443 1262 1125 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9845 r0 *1 700,146.16
X$9845 9263 1264 1166 9264 1127 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9849 m0 *1 738.64,146.16
X$9849 9264 9263 1165 1164 1129 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $9882 r0 *1 7.84,267.12
X$9882 9263 1137 2442 9264 2455 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9884 m0 *1 24.64,226.8
X$9884 9264 1137 9263 2021 1826 1683 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9894 m0 *1 6.72,277.2
X$9894 9264 9263 2524 1137 2442 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $9911 r0 *1 56,156.24
X$9911 9264 9263 1141 1355 1238 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9913 m0 *1 58.24,156.24
X$9913 9263 1141 1238 9264 1286 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9934 r0 *1 238,156.24
X$9934 9264 9263 1295 1144 1314 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9948 r0 *1 290.08,146.16
X$9948 9264 1200 1201 9263 1147 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $9955 m0 *1 336,156.24
X$9955 9264 1278 1277 9263 1148 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $9960 r0 *1 348.88,166.32
X$9960 1149 9263 1380 1378 9264 1402 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9969 r0 *1 586.32,146.16
X$9969 9264 1210 1259 1153 1212 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $9971 r0 *1 329.28,166.32
X$9971 1424 9264 9263 1153 1379 1378 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $9973 m0 *1 304.64,156.24
X$9973 1274 9264 9263 1153 1299 1248 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $9975 r0 *1 216.72,166.32
X$9975 1371 9264 9263 1153 1372 1417 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $9978 r0 *1 432.32,146.16
X$9978 1205 9264 9263 1153 1252 1203 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $9998 r0 *1 243.04,166.32
X$9998 9264 1373 1196 1153 1374 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $10001 r0 *1 650.16,176.4
X$10001 9263 9264 1446 1153 1544 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $10006 m0 *1 549.92,156.24
X$10006 9264 9263 1315 1155 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10021 m0 *1 583.52,156.24
X$10021 9264 1273 1157 1259 1210 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $10024 m0 *1 600.32,156.24
X$10024 9264 9263 1157 1260 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10030 r0 *1 600.88,156.24
X$10030 1303 9263 1260 1350 9264 1158 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10033 m0 *1 617.12,156.24
X$10033 9264 9263 1212 1213 1159 1261 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10040 r0 *1 610.96,166.32
X$10040 9264 9263 1391 1263 1159 1396 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10050 r0 *1 631.68,146.16
X$10050 1215 1162 1161 1214 1216 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $10055 m0 *1 638.96,156.24
X$10055 9263 1216 9264 1162 1269 1161 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10058 r0 *1 631.12,156.24
X$10058 9264 9263 1311 1161 1304 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $10061 m0 *1 622.16,146.16
X$10061 1162 9264 1215 9263 1172 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10084 m0 *1 719.6,146.16
X$10084 9264 1221 9263 1168 1166 1264 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10089 r0 *1 693.28,146.16
X$10089 9264 1219 1220 9263 1166 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10099 r0 *1 728,156.24
X$10099 1306 9264 1168 9263 1266 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10131 m0 *1 568.4,146.16
X$10131 9264 9263 1176 1231 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10168 m0 *1 21.28,206.64
X$10168 9264 1726 1863 1184 1236 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $10177 r0 *1 12.88,186.48
X$10177 9263 1633 9264 1184 1560 1236 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10184 r0 *1 21.28,156.24
X$10184 9264 1185 1267 1363 1283 1237 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $10187 r0 *1 64.96,186.48
X$10187 9263 1186 1673 9264 1634 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10190 m0 *1 70.56,236.88
X$10190 9263 1186 1868 9264 1968 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10192 m0 *1 77.84,246.96
X$10192 9264 9263 1186 2154 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $10194 m0 *1 83.44,216.72
X$10194 9263 1186 1868 9264 1772 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10198 r0 *1 56,176.4
X$10198 9263 1186 1456 9264 1495 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10201 r0 *1 114.8,156.24
X$10201 9263 1186 1239 9264 1288 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10222 r0 *1 66.08,206.64
X$10222 9264 9263 1641 1186 1868 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $10224 m0 *1 65.52,246.96
X$10224 9264 9263 2212 1186 2192 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $10228 r0 *1 112,196.56
X$10228 1643 1245 1644 1686 9264 9263 1187 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10234 m0 *1 71.12,176.4
X$10234 1188 9263 1364 1406 9264 1455 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10237 r0 *1 66.08,166.32
X$10237 9264 9263 1188 1320 1364 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10239 r0 *1 61.04,166.32
X$10239 9263 1188 1364 9264 1319 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10242 m0 *1 63.84,176.4
X$10242 9264 1406 9263 1454 1364 1188 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10248 m0 *1 78.4,176.4
X$10248 9263 1366 1407 1189 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10267 r0 *1 185.36,156.24
X$10267 9264 1242 1312 9263 1192 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $10273 r0 *1 240.8,146.16
X$10273 9264 1193 1195 9263 1229 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10285 m0 *1 243.6,166.32
X$10285 9263 1196 1359 9264 1400 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10287 r0 *1 250.32,156.24
X$10287 9264 9263 1198 1314 1196 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10289 r0 *1 243.04,156.24
X$10289 9264 1373 9263 1295 1326 1196 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10308 m0 *1 253.12,166.32
X$10308 9264 9263 1359 1326 1198 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $10317 m0 *1 264.32,176.4
X$10317 9263 1422 1421 1198 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10324 r0 *1 290.08,166.32
X$10324 9263 1296 1232 1200 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10341 m0 *1 425.04,156.24
X$10341 9263 1300 1203 9264 1251 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10343 r0 *1 421.68,156.24
X$10343 1203 9264 1300 9263 1280 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10349 r0 *1 436.8,156.24
X$10349 9264 1204 1245 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $10375 m0 *1 532.56,156.24
X$10375 9263 1208 1258 9264 1316 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10377 r0 *1 526.4,156.24
X$10377 9264 1317 1208 1341 1301 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $10379 m0 *1 568.96,156.24
X$10379 9264 1231 1440 1209 1273 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $10391 r0 *1 580.72,146.16
X$10391 9264 9263 1230 1210 1211 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $10394 r0 *1 593.6,156.24
X$10394 9264 1303 9263 1211 1350 1260 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10417 m0 *1 631.68,166.32
X$10417 9264 9263 1356 1215 1262 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10432 r0 *1 670.88,176.4
X$10432 9264 9331 1489 1545 1218 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $10443 r0 *1 701.68,156.24
X$10443 9264 1307 1220 1219 1306 1264 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $10451 m0 *1 698.32,166.32
X$10451 9264 1351 1219 9263 1353 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10462 r0 *1 709.52,166.32
X$10462 9264 1308 1306 1221 1394 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $10535 m0 *1 21.28,196.56
X$10535 9264 9263 1236 1714 1404 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10580 m0 *1 201.6,166.32
X$10580 9263 1293 1243 1312 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10582 r0 *1 200.48,156.24
X$10582 9263 1243 1293 9264 1244 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10589 r0 *1 116.48,236.88
X$10589 2039 1245 2155 2195 9264 9263 1561 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10593 r0 *1 457.52,236.88
X$10593 1245 9263 2181 2084 9264 2144 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10595 m0 *1 276.08,246.96
X$10595 2223 2170 1245 1874 9264 9263 2224 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10600 m0 *1 208.32,277.2
X$10600 2534 1245 2169 2512 9264 9263 3069 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10619 m0 *1 226.24,267.12
X$10619 9264 2360 1898 2707 1245 2398 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $10621 r0 *1 137.2,236.88
X$10621 9264 2192 1245 9263 2125 2163 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $10626 r0 *1 476.56,216.72
X$10626 9264 2853 1245 9263 1984 1879 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $10629 m0 *1 240.24,166.32
X$10629 9264 9263 1295 1246 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10631 r0 *1 251.44,176.4
X$10631 1517 1421 1579 1612 9264 9263 1247 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10635 m0 *1 292.88,166.32
X$10635 9263 1327 1248 1297 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10638 m0 *1 302.4,166.32
X$10638 1248 9264 1327 9263 1298 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10645 r0 *1 304.08,176.4
X$10645 1466 1468 1584 1526 9264 9263 1249 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10651 r0 *1 414.96,176.4
X$10651 1428 1384 1477 1430 9264 9263 1250 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10660 r0 *1 453.04,156.24
X$10660 9264 9263 1252 1318 1253 1279 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10668 m0 *1 464.8,166.32
X$10668 9264 9263 1330 1332 1253 1336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10672 m0 *1 458.08,176.4
X$10672 9264 9263 1401 1504 1253 1437 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10685 r0 *1 515.76,156.24
X$10685 9264 9263 1256 1341 1340 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $10694 r0 *1 521.36,156.24
X$10694 9264 9263 1257 1338 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $10700 r0 *1 527.52,166.32
X$10700 1317 9264 1301 1341 9263 1258 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $10706 r0 *1 590.24,156.24
X$10706 9264 9263 1259 1303 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10725 r0 *1 629.44,166.32
X$10725 9263 1262 1395 9264 1396 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10750 r0 *1 717.92,186.48
X$10750 9264 1265 1632 1630 1546 1446 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $10756 r0 *1 11.2,246.96
X$10756 9264 9263 1267 2255 1714 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10759 r0 *1 16.24,246.96
X$10759 9263 1267 1714 9264 2294 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10770 m0 *1 10.64,236.88
X$10770 9263 1267 1363 9264 2031 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10773 m0 *1 720.72,156.24
X$10773 9263 1307 1308 1268 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10782 m0 *1 146.72,156.24
X$10782 9263 1290 1289 1270 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10792 r0 *1 210,156.24
X$10792 9264 9263 1272 1313 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10803 m0 *1 294.56,156.24
X$10803 9264 1274 1297 9263 1296 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $10816 m0 *1 338.8,166.32
X$10816 9263 1377 1328 1277 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10844 m0 *1 24.64,257.04
X$10844 9264 1771 1986 2151 2260 1283 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $10846 m0 *1 19.04,287.28
X$10846 9263 1771 1283 9264 2310 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10848 r0 *1 12.88,267.12
X$10848 9264 1771 2069 1990 1283 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $10851 r0 *1 15.68,277.2
X$10851 9263 9264 1283 2610 1771 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $10853 m0 *1 12.32,277.2
X$10853 1771 9263 1283 2069 9264 2523 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10862 m0 *1 18.48,277.2
X$10862 9264 1771 1283 1986 2151 2528 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $10865 r0 *1 34.72,156.24
X$10865 9264 1285 1284 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $10869 m0 *1 30.8,196.56
X$10869 9264 1671 1670 1284 1405 1683 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $10872 r0 *1 40.32,186.48
X$10872 9263 1284 1405 1684 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10880 r0 *1 39.2,176.4
X$10880 9263 1495 1551 1512 1405 1284 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $10882 r0 *1 42.56,166.32
X$10882 9264 9263 1285 1404 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $10886 m0 *1 37.52,176.4
X$10886 9263 9264 1285 1494 1405 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $10892 r0 *1 87.92,166.32
X$10892 1354 9263 9264 1287 1321 1365 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $10895 m0 *1 90.72,166.32
X$10895 1321 9264 1287 1365 9263 1309 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $10900 m0 *1 134.4,166.32
X$10900 1289 9264 1290 9263 1499 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10908 r0 *1 148.4,156.24
X$10908 9264 1368 1291 9263 1290 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $10913 m0 *1 143.92,166.32
X$10913 9263 1323 1310 1291 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10916 r0 *1 155.68,166.32
X$10916 9263 1369 1370 1292 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10918 r0 *1 160.72,156.24
X$10918 9264 1325 1292 9263 1310 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $10922 m0 *1 215.04,166.32
X$10922 9264 1371 1358 9263 1293 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $10926 r0 *1 203.84,176.4
X$10926 1518 1417 1521 1519 9264 9263 1294 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10952 r0 *1 364.56,166.32
X$10952 9264 9263 1299 1453 1329 1382 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10956 m0 *1 419.44,166.32
X$10956 9264 9263 1361 1300 1383 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10974 r0 *1 638.96,156.24
X$10974 9264 9263 1304 1356 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10983 r0 *1 684.88,156.24
X$10983 9264 9263 1305 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11012 m0 *1 153.44,166.32
X$11012 1323 9264 1310 9263 1324 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11056 m0 *1 62.16,206.64
X$11056 9263 1319 1727 9264 1728 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11059 r0 *1 54.32,196.56
X$11059 9264 1319 9263 1671 1456 1641 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11064 r0 *1 54.32,216.72
X$11064 9263 1320 1727 9264 1923 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11067 r0 *1 60.48,226.8
X$11067 9264 9263 1320 2035 1716 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11078 m0 *1 136.64,176.4
X$11078 9264 1456 1322 1499 1449 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $11080 m0 *1 161.28,196.56
X$11080 9264 9263 1646 1682 1322 1607 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11088 m0 *1 167.44,186.48
X$11088 9264 9263 1598 1553 1322 1462 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11090 m0 *1 164.08,176.4
X$11090 9264 9263 1459 1450 1322 1460 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11093 m0 *1 155.68,176.4
X$11093 9264 9263 1458 1324 1322 1413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11100 r0 *1 146.16,166.32
X$11100 1368 9264 9263 1552 1413 1323 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $11113 r0 *1 308,166.32
X$11113 9264 1375 1376 9263 1327 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $11120 m0 *1 359.52,176.4
X$11120 1472 1533 1476 1328 9264 9263 1381 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $11128 r0 *1 355.04,166.32
X$11128 9264 9263 1360 1328 1377 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $11131 m0 *1 366.8,176.4
X$11131 9264 9263 1469 1474 1329 1475 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11140 r0 *1 347.76,176.4
X$11140 9264 9263 1530 1531 1329 1426 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11156 r0 *1 464.8,166.32
X$11156 1333 9264 1335 9263 1332 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11160 m0 *1 474.88,166.32
X$11160 9263 1333 1335 9264 1334 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11170 r0 *1 474.32,166.32
X$11170 9264 1399 1334 9263 1386 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $11176 r0 *1 474.32,176.4
X$11176 9264 1387 1506 9263 1335 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $11190 m0 *1 484.96,176.4
X$11190 1337 9264 1386 9263 1504 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11192 m0 *1 511.84,166.32
X$11192 1338 9263 1388 1339 9264 1340 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11196 r0 *1 510.72,166.32
X$11196 9264 1341 1388 1339 1338 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $11201 m0 *1 518,166.32
X$11201 9264 1344 1339 1343 1342 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $11207 r0 *1 516.88,176.4
X$11207 9263 1339 1501 9264 1478 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11226 m0 *1 527.52,176.4
X$11226 1344 9264 1342 1343 9263 1501 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $11228 r0 *1 521.92,176.4
X$11228 9264 1343 1342 1534 1537 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $11247 m0 *1 568.4,176.4
X$11247 1346 9263 1482 1589 9264 1440 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $11249 r0 *1 562.24,166.32
X$11249 9264 9263 1346 1439 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11251 r0 *1 563.36,186.48
X$11251 9264 1346 1389 1482 9263 1538 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $11257 r0 *1 584.64,176.4
X$11257 9263 1347 9264 1348 1591 1390 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11260 m0 *1 608.72,186.48
X$11260 9264 1348 1487 1485 1486 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $11266 r0 *1 595.28,166.32
X$11266 9263 1349 9264 1348 1350 1390 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11268 m0 *1 592.48,166.32
X$11268 1349 9264 1390 1348 9263 1357 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $11271 m0 *1 583.52,176.4
X$11271 9263 1448 9264 1348 1484 1390 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11301 r0 *1 700,216.72
X$11301 9264 9333 1592 1545 1351 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $11303 m0 *1 677.04,257.04
X$11303 9264 2343 2756 1351 2296 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $11330 m0 *1 212.24,176.4
X$11330 9263 1419 1417 1358 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $11343 m0 *1 416.08,166.32
X$11343 9264 9263 1362 1361 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11365 r0 *1 22.4,226.8
X$11365 9263 1363 9264 1511 2032 2033 1604 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $11381 m0 *1 99.12,176.4
X$11381 9264 1409 1408 1366 1411 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $11400 r0 *1 165.2,166.32
X$11400 1369 9264 1370 9263 1450 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11409 r0 *1 174.72,166.32
X$11409 9264 1416 1415 9263 1370 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $11434 m0 *1 307.44,196.56
X$11434 9263 1451 1468 1376 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $11440 m0 *1 330.96,176.4
X$11440 9264 1424 1452 9263 1377 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $11442 r0 *1 329.84,176.4
X$11442 9263 1378 1425 9264 1557 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11444 r0 *1 339.36,166.32
X$11444 9263 1425 1378 1452 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $11456 m0 *1 343.84,176.4
X$11456 9264 9263 1379 1470 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11463 r0 *1 356.16,186.48
X$11463 1472 9264 1380 1585 9263 1638 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $11469 m0 *1 353.36,186.48
X$11469 9263 1472 9264 1585 1532 1380 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11471 r0 *1 339.36,186.48
X$11471 9264 1585 1380 1534 1615 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $11482 m0 *1 423.92,186.48
X$11482 9263 1383 1600 9264 1535 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11484 r0 *1 428.96,166.32
X$11484 9263 1384 9264 1436 1383 1385 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11495 r0 *1 430.64,176.4
X$11495 1384 9264 1436 1385 9263 1600 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $11500 m0 *1 418.88,186.48
X$11500 9263 1434 1477 9264 1385 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11516 r0 *1 479.92,176.4
X$11516 9264 1506 1387 1534 1536 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $11520 r0 *1 513.52,176.4
X$11520 9264 9263 1479 1388 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11523 m0 *1 570.08,196.56
X$11523 9264 9263 1389 1483 1440 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11531 r0 *1 576.24,166.32
X$11531 9264 9263 1590 1389 1440 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $11568 r0 *1 72.8,166.32
X$11568 9264 9263 1397 1406 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11598 m0 *1 54.32,176.4
X$11598 9264 1406 9263 1727 1404 1405 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11601 m0 *1 59.92,196.56
X$11601 9264 1642 1405 1404 1673 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $11605 m0 *1 57.68,186.48
X$11605 1405 9263 1404 1456 9264 1716 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11639 m0 *1 90.72,186.48
X$11639 9264 1563 9263 1407 1564 1409 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11646 r0 *1 133.28,206.64
X$11646 1408 1567 1722 1735 9264 9263 1644 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $11648 r0 *1 105.28,176.4
X$11648 1408 9264 1411 9263 1514 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11650 m0 *1 113.12,176.4
X$11650 1409 9263 1408 1411 9264 1410 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11662 m0 *1 113.12,196.56
X$11662 9264 1688 9263 1644 1564 1678 1675 1408
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $11664 r0 *1 106.96,196.56
X$11664 9263 1731 1409 9264 1686 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11666 m0 *1 91.84,196.56
X$11666 9263 1409 1675 9264 1673 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11687 m0 *1 128.8,196.56
X$11687 9263 9264 1515 1411 1635 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $11690 r0 *1 175.84,196.56
X$11690 1608 9264 1412 1609 9263 1649 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $11695 r0 *1 175.28,186.48
X$11695 9263 1608 9264 1609 1648 1412 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11697 m0 *1 181.44,196.56
X$11697 9264 1609 1412 1534 1650 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $11707 r0 *1 170.24,176.4
X$11707 1414 9264 1461 9263 1553 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11709 m0 *1 172.48,176.4
X$11709 9263 1414 1461 9264 1415 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11720 m0 *1 201.6,176.4
X$11720 1417 9264 1419 9263 1418 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11735 m0 *1 222.32,176.4
X$11735 9264 1500 1465 9263 1419 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $11744 r0 *1 258.72,176.4
X$11744 1421 9264 1422 9263 1502 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11754 m0 *1 258.16,186.48
X$11754 9264 1525 1580 9263 1422 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $11756 m0 *1 317.52,176.4
X$11756 9264 1423 1507 9263 1451 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $11758 r0 *1 313.6,186.48
X$11758 9263 1529 1584 9264 1423 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11766 m0 *1 375.2,176.4
X$11766 9264 1509 1427 9263 1425 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $11786 m0 *1 403.76,186.48
X$11786 9264 1432 1428 1534 1588 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $11788 r0 *1 404.88,176.4
X$11788 9263 1430 9264 1432 1431 1428 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11790 r0 *1 406,166.32
X$11790 1428 9264 1430 1432 9263 1433 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $11794 m0 *1 406.56,176.4
X$11794 9263 1431 1433 9264 1429 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11804 r0 *1 400.96,166.32
X$11804 9264 9263 1431 1434 1510 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11818 m0 *1 414.4,176.4
X$11818 1477 9264 1434 9263 1435 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11838 m0 *1 561.12,176.4
X$11838 9264 1438 1439 9263 1483 1484 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $11854 m0 *1 614.32,176.4
X$11854 9264 9263 1485 1441 1496 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11865 m0 *1 700.56,226.8
X$11865 9264 9328 2108 2020 1444 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $11867 m0 *1 689.36,226.8
X$11867 9263 1444 1592 1628 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $11885 m0 *1 727.44,186.48
X$11885 9263 1594 9264 1445 1547 1548 1549 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $11888 m0 *1 713.44,267.12
X$11888 9264 9263 2242 2441 2345 1446 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11891 m0 *1 677.6,196.56
X$11891 9264 1489 1446 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $11894 m0 *1 712.88,186.48
X$11894 9264 1547 1446 1593 1546 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $11896 m0 *1 649.6,186.48
X$11896 9263 9264 1446 1552 1544 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $11899 m0 *1 697.76,267.12
X$11899 1446 2108 2440 2107 9264 9263 2500 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $11917 r0 *1 727.44,196.56
X$11917 1446 9264 1666 1630 9263 1595 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $11920 r0 *1 723.52,206.64
X$11920 9264 1815 1548 1810 1446 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $11941 m0 *1 307.44,186.48
X$11941 1468 9264 1451 9263 1505 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11952 m0 *1 372.96,186.48
X$11952 1476 9264 1587 9263 1453 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11956 r0 *1 49.84,186.48
X$11956 9264 1454 1455 1562 9263 1640 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $11958 m0 *1 47.04,186.48
X$11958 9263 1513 9264 1672 1455 1454 1562 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $11966 r0 *1 70,196.56
X$11966 1684 1454 1455 1673 9263 9264 1889 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $11976 r0 *1 77.84,186.48
X$11976 9264 9263 1456 1605 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11984 m0 *1 85.12,206.64
X$11984 9264 9263 1729 1772 1456 1730 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11989 m0 *1 121.52,206.64
X$11989 9264 9263 1819 1734 1494 1457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11991 m0 *1 108.08,186.48
X$11991 9264 9263 1596 1514 1494 1458 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11998 m0 *1 137.76,196.56
X$11998 9264 9263 1636 1637 1494 1459 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12002 m0 *1 137.2,186.48
X$12002 9264 1565 1567 1552 1459 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12012 m0 *1 170.24,196.56
X$12012 9264 9263 1647 1461 1648 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12021 m0 *1 216.16,196.56
X$12021 9263 1519 1463 9264 1523 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12023 r0 *1 206.64,186.48
X$12023 1519 9264 1463 9263 1520 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12027 r0 *1 198.8,176.4
X$12027 9264 9263 1571 1463 1572 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12038 m0 *1 223.44,186.48
X$12038 9263 1521 1524 9264 1465 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12047 r0 *1 286.72,176.4
X$12047 1466 9264 1526 1467 9263 1503 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $12049 r0 *1 277.76,186.48
X$12049 9264 1467 1466 1534 1582 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12053 r0 *1 290.64,186.48
X$12053 9263 1526 9264 1467 1528 1466 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12078 m0 *1 346.64,186.48
X$12078 9264 9263 1471 1508 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12085 m0 *1 362.32,186.48
X$12085 9263 1473 1533 9264 1586 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12087 r0 *1 362.32,176.4
X$12087 1533 9264 1473 9263 1474 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12089 r0 *1 357.28,176.4
X$12089 9264 9263 1508 1473 1532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12101 m0 *1 382.48,186.48
X$12101 9263 1476 1587 9264 1509 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12126 r0 *1 563.92,176.4
X$12126 9264 1538 1554 1481 1482 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $12157 r0 *1 616,176.4
X$12157 1486 9263 1487 1485 9264 1498 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $12161 r0 *1 624.4,186.48
X$12161 9263 1540 9264 1542 1485 1541 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12167 m0 *1 621.04,176.4
X$12167 9264 9263 1497 1486 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12170 m0 *1 622.16,186.48
X$12170 9264 9263 1597 1487 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12175 r0 *1 646.24,176.4
X$12175 9264 9263 1488 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12178 m0 *1 678.72,246.96
X$12178 9264 9263 1489 1592 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $12183 r0 *1 677.6,246.96
X$12183 9264 2246 1489 2292 2242 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $12200 r0 *1 717.92,206.64
X$12200 9264 9263 1810 1629 1490 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $12202 m0 *1 686,236.88
X$12202 9263 1490 1592 2189 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $12219 r0 *1 711.76,236.88
X$12219 9264 9332 2244 2107 1490 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $12221 r0 *1 711.2,186.48
X$12221 9264 1629 1490 9263 1593 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $12223 m0 *1 744.8,186.48
X$12223 9264 9263 1491 1594 1550 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12225 r0 *1 734.16,196.56
X$12225 9264 1713 1491 1548 1813 1667 1758 9263
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $12228 r0 *1 733.6,176.4
X$12228 9264 9263 1492 1548 1547 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $12239 r0 *1 77.84,206.64
X$12239 9264 9263 1869 1818 1494 1729 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12254 m0 *1 146.72,216.72
X$12254 9264 9263 1926 1736 1494 1598 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12257 r0 *1 140,196.56
X$12257 9264 9263 1689 1690 1494 1646 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12260 m0 *1 35.84,206.64
X$12260 9263 1494 9264 1715 1886 1726 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12271 m0 *1 626.64,186.48
X$12271 1540 9264 1541 1542 9263 1496 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $12293 r0 *1 281.68,176.4
X$12293 9263 1528 1503 9264 1555 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12323 m0 *1 396.48,186.48
X$12323 9264 9263 1559 1510 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12329 r0 *1 35.84,176.4
X$12329 9264 9263 1561 1512 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12336 r0 *1 124.88,186.48
X$12336 9264 9263 1515 1678 1679 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12342 m0 *1 133.84,186.48
X$12342 9264 9263 1565 1515 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12356 m0 *1 229.6,196.56
X$12356 9263 1612 9264 1651 1601 1517 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12358 m0 *1 237.44,196.56
X$12358 1517 9264 1612 1651 9263 1652 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $12360 m0 *1 244.16,196.56
X$12360 9264 1651 1517 1534 1576 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12381 m0 *1 213.36,186.48
X$12381 1521 9264 1524 9263 1573 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12394 r0 *1 219.52,176.4
X$12394 9264 1522 1523 9263 1524 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $12422 r0 *1 293.44,176.4
X$12422 9264 9263 1556 1529 1528 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12428 r0 *1 304.08,186.48
X$12428 1584 9264 1529 9263 1603 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12443 r0 *1 351.12,186.48
X$12443 9263 1532 1638 9264 1531 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12482 r0 *1 653.52,186.48
X$12482 9263 9264 1592 1534 1544 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $12488 m0 *1 482.16,186.48
X$12488 9264 9263 1536 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12492 m0 *1 525.84,186.48
X$12492 9264 9263 1537 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12497 r0 *1 577.92,186.48
X$12497 9264 9263 1591 1539 1590 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12518 m0 *1 636.72,186.48
X$12518 9264 9263 1543 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12520 r0 *1 701.12,186.48
X$12520 9264 9263 1629 1544 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12526 m0 *1 667.52,196.56
X$12526 9263 9264 1592 1664 1544 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $12532 m0 *1 706.16,236.88
X$12532 9264 9263 1545 2140 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12544 r0 *1 706.16,226.8
X$12544 9264 9330 2244 2020 1545 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $12551 m0 *1 725.2,196.56
X$12551 9264 9263 1547 1631 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12557 m0 *1 738.64,186.48
X$12557 9263 1547 1595 9264 1550 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12564 m0 *1 728.56,196.56
X$12564 9264 1548 9263 1669 1631 1549 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12586 r0 *1 633.36,206.64
X$12586 9264 1858 1808 1552 1805 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12588 m0 *1 574.56,206.64
X$12588 1801 9264 9263 1552 1749 1710 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12591 r0 *1 523.6,216.72
X$12591 1952 9264 9263 1552 1906 1907 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12593 r0 *1 227.92,246.96
X$12593 2302 9264 9263 1552 2219 2270 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12596 r0 *1 188.16,267.12
X$12596 9264 2510 2416 1552 2415 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12601 m0 *1 436.8,226.8
X$12601 2010 9264 9263 1552 1883 2011 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12604 m0 *1 478.8,226.8
X$12604 2081 9264 9263 1552 1985 2012 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12607 m0 *1 380.8,226.8
X$12607 2007 9264 9263 1552 2008 1950 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12609 m0 *1 284.48,236.88
X$12609 9264 2117 2052 1552 2094 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12611 m0 *1 328.72,226.8
X$12611 2030 9264 9263 1552 2004 2005 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12613 r0 *1 127.68,257.04
X$12613 2394 9264 9263 1552 1926 2261 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12615 r0 *1 133.28,277.2
X$12615 2598 9264 9263 1552 2318 2463 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12618 r0 *1 164.08,277.2
X$12618 2656 9264 9263 1552 2465 2531 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12654 m0 *1 288.4,196.56
X$12654 9264 9263 1583 1556 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12664 m0 *1 367.36,186.48
X$12664 9264 1558 1586 9263 1587 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $12673 r0 *1 35.28,186.48
X$12673 9264 9263 1561 1633 1634 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12682 r0 *1 61.6,196.56
X$12682 9264 9263 1562 1685 1673 1641 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12695 r0 *1 138.88,186.48
X$12695 1567 9264 1566 9263 1637 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12700 r0 *1 129.92,186.48
X$12700 9263 9264 1567 1635 1566 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $12702 m0 *1 147.28,196.56
X$12702 9264 1645 1681 9263 1566 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $12713 r0 *1 132.16,196.56
X$12713 9263 1567 9264 1691 1679 1645 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12715 r0 *1 190.96,196.56
X$12715 9264 9263 1568 1572 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12728 m0 *1 193.2,196.56
X$12728 9263 1571 1610 9264 1570 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12748 m0 *1 240.8,186.48
X$12748 9264 9263 1575 1577 1601 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12750 r0 *1 246.4,196.56
X$12750 9264 9263 1614 1575 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12752 m0 *1 245.84,186.48
X$12752 9264 9263 1576 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12755 r0 *1 255.36,196.56
X$12755 9263 1577 1579 9264 1580 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12757 m0 *1 248.08,186.48
X$12757 1579 9264 1577 9263 1602 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12791 r0 *1 275.52,186.48
X$12791 9264 9263 1582 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12818 r0 *1 406,186.48
X$12818 9264 9263 1588 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12837 r0 *1 690.48,257.04
X$12837 9263 1592 2348 9264 2388 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12842 r0 *1 703.36,267.12
X$12842 9264 2499 2498 1592 2140 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12854 r0 *1 700.56,257.04
X$12854 1592 9264 2108 2107 9263 2645 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $12856 m0 *1 689.92,267.12
X$12856 1592 9263 2020 2295 9264 2439 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $12868 m0 *1 105.28,196.56
X$12868 9264 9263 1596 1676 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12880 r0 *1 445.76,206.64
X$12880 1743 1599 1792 1904 9264 9263 2084 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $12886 r0 *1 456.96,186.48
X$12886 9263 1599 9264 1622 1621 1619 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12888 r0 *1 450.24,186.48
X$12888 1619 9264 1599 1622 9263 1620 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $12896 r0 *1 238,196.56
X$12896 9263 1601 1652 9264 1613 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12913 m0 *1 25.2,337.68
X$12913 9264 1604 2032 9263 3107 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $12918 m0 *1 31.36,337.68
X$12918 9264 9263 3154 1604 2032 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $12922 m0 *1 73.36,196.56
X$12922 9264 9263 1605 1670 1685 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12928 r0 *1 167.44,196.56
X$12928 9264 9263 1606 1647 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12944 m0 *1 202.72,196.56
X$12944 9264 9263 1611 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12962 m0 *1 341.04,196.56
X$12962 9264 9263 1615 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12964 m0 *1 437.36,196.56
X$12964 9264 9263 1616 1617 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12967 m0 *1 440.72,196.56
X$12967 9264 9263 1617 1657 1621 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12971 r0 *1 429.52,196.56
X$12971 9264 9263 1618 1654 1701 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $12977 m0 *1 466.48,196.56
X$12977 9264 9263 1623 1680 1794 1618 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12979 r0 *1 450.24,236.88
X$12979 1619 2200 2230 2011 9264 9263 2181 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $12985 r0 *1 455.28,196.56
X$12985 9264 1622 1619 1664 1703 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12989 r0 *1 465.92,206.64
X$12989 9264 9263 1745 1619 1905 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $12994 m0 *1 455.28,196.56
X$12994 9263 1621 1620 9264 1680 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13009 m0 *1 497.28,196.56
X$13009 9264 9263 1627 1626 1661 1623 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13016 m0 *1 485.52,206.64
X$13016 1848 1624 1705 1880 9264 9263 1879 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13018 m0 *1 480.48,206.64
X$13018 9263 1625 1624 9264 1704 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13020 r0 *1 490,186.48
X$13020 1624 9264 1625 9263 1626 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13029 m0 *1 491.12,196.56
X$13029 9264 9263 1877 1625 1659 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13036 m0 *1 544.32,206.64
X$13036 9264 9263 1749 1721 1748 1627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13048 m0 *1 692.16,337.68
X$13048 9264 1628 3140 3141 2930 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $13054 m0 *1 679.28,307.44
X$13054 9264 2755 2868 1628 2869 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13056 m0 *1 721.84,196.56
X$13056 9264 9263 1629 1630 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13071 m0 *1 710.08,236.88
X$13071 9264 2141 2108 2107 1629 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $13082 r0 *1 738.08,206.64
X$13082 9263 9264 1632 1813 1667 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $13084 r0 *1 741.44,186.48
X$13084 9264 9263 1666 1632 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $13101 m0 *1 116.48,267.12
X$13101 9264 9263 1636 2444 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13116 m0 *1 17.36,226.8
X$13116 1986 2031 1639 2021 9264 9263 1987 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13121 r0 *1 40.88,206.64
X$13121 9264 1683 1827 1640 1684 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $13127 r0 *1 30.8,206.64
X$13127 9264 1640 1726 9263 1826 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $13131 m0 *1 57.12,216.72
X$13131 9264 9263 1887 1685 1933 1641 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13139 r0 *1 63.84,216.72
X$13139 9264 1888 1968 9263 1716 1970 1642 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $13143 m0 *1 63.28,226.8
X$13143 9264 9263 1716 1642 1933 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $13146 r0 *1 65.52,226.8
X$13146 9264 1642 1716 9263 2072 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $13151 r0 *1 112,206.64
X$13151 1643 9264 1731 1732 9263 1773 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13153 m0 *1 108.64,206.64
X$13153 9263 1643 9264 1732 1733 1731 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $13175 m0 *1 175.84,196.56
X$13175 9263 1648 1649 9264 1682 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13187 r0 *1 184.8,196.56
X$13187 9264 9263 1650 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13199 m0 *1 419.44,196.56
X$13199 1653 9264 1654 1655 9263 1656 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13202 r0 *1 417.76,196.56
X$13202 9263 1653 9264 1655 1790 1654 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $13211 m0 *1 420.56,206.64
X$13211 9264 1655 1654 1664 1742 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13217 r0 *1 418.88,206.64
X$13217 9263 1790 1656 9264 1846 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13220 m0 *1 445.76,196.56
X$13220 1743 9264 1657 9263 1658 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13223 m0 *1 450.8,206.64
X$13223 9263 1743 1657 9264 1724 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13229 r0 *1 453.04,206.64
X$13229 9264 9263 1795 1658 1794 1791 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13231 r0 *1 500.64,206.64
X$13231 9263 1659 1723 9264 1764 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13233 r0 *1 491.68,196.56
X$13233 9263 1705 9264 1660 1659 1706 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $13241 r0 *1 511.84,196.56
X$13241 9264 1660 1706 1664 1707 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13244 r0 *1 501.76,196.56
X$13244 1706 9264 1705 1660 9263 1723 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13247 m0 *1 506.24,206.64
X$13247 9264 9263 1708 1764 1661 1745 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13249 m0 *1 500.08,236.88
X$13249 9264 9263 2058 2137 1661 2082 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13252 m0 *1 493.92,246.96
X$13252 9264 2335 1661 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $13255 m0 *1 497.84,226.8
X$13255 9264 9263 2056 2024 1661 1985 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13258 m0 *1 500.64,216.72
X$13258 9264 9263 1906 1928 1661 1795 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13261 m0 *1 537.04,196.56
X$13261 1662 9264 1674 9263 1721 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13263 m0 *1 534.8,206.64
X$13263 9263 1662 1674 1763 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $13268 r0 *1 585.2,206.64
X$13268 9263 1710 1663 9264 1821 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13270 m0 *1 584.08,206.64
X$13270 9264 1820 1802 9263 1663 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $13274 r0 *1 589.68,196.56
X$13274 1710 9264 1663 9263 1718 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13277 m0 *1 669.76,307.44
X$13277 2935 9264 9263 2995 1664 9285 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13279 m0 *1 664.16,267.12
X$13279 2395 9264 9263 2496 1664 9287 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13281 r0 *1 668.08,277.2
X$13281 9264 9263 1664 2553 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13285 r0 *1 155.12,226.8
X$13285 9264 2041 2091 1664 2040 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13287 r0 *1 120.4,206.64
X$13287 9264 1732 1731 1664 1828 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13309 m0 *1 116.48,226.8
X$13309 9264 1937 1935 1664 1994 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13312 r0 *1 217.28,206.64
X$13312 9264 1830 1893 1664 1831 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13315 r0 *1 177.52,216.72
X$13315 9264 1998 1999 1664 1890 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13319 r0 *1 374.08,206.64
X$13319 9264 1695 1693 1664 1788 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13323 r0 *1 258.16,216.72
X$13323 9264 1776 1833 1664 1943 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13325 r0 *1 560,206.64
X$13325 9264 1852 1925 1664 1853 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13327 m0 *1 612.64,236.88
X$13327 9264 2064 2063 2142 1664 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13330 r0 *1 322.56,206.64
X$13330 9264 1782 1783 1664 1784 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13333 r0 *1 674.8,206.64
X$13333 1864 9264 9263 1665 1919 1861 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13342 m0 *1 740.32,206.64
X$13342 9264 1758 1667 1713 1666 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $13353 m0 *1 747.6,196.56
X$13353 9264 9263 1668 1667 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $13385 r0 *1 87.36,206.64
X$13385 9264 9263 1818 1730 1673 1772 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13392 r0 *1 530.32,196.56
X$13392 9264 1822 1709 9263 1674 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $13399 r0 *1 85.68,297.36
X$13399 2154 9264 1676 2722 9263 2771 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13403 r0 *1 80.08,277.2
X$13403 9263 1676 2072 9264 2594 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13406 r0 *1 85.12,267.12
X$13406 9264 9263 1676 2461 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13418 r0 *1 74.48,277.2
X$13418 9264 9263 2559 1676 2072 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $13421 m0 *1 58.24,307.44
X$13421 9264 9263 2769 2823 1676 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13423 r0 *1 61.04,246.96
X$13423 9264 9263 2258 2213 1676 2212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13426 m0 *1 50.96,287.28
X$13426 9264 1933 2459 2669 1676 2595 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $13430 r0 *1 481.6,196.56
X$13430 9264 1677 1704 9263 1797 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $13446 r0 *1 156.8,206.64
X$13446 9263 1722 1774 1681 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $13455 m0 *1 35.84,226.8
X$13455 9263 1683 1826 9264 1988 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13458 r0 *1 33.6,216.72
X$13458 9264 9263 1683 2211 1886 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13460 r0 *1 32.48,226.8
X$13460 9263 9264 1683 2151 1826 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $13470 r0 *1 101.92,206.64
X$13470 9264 9263 1731 1684 1993 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $13488 m0 *1 114.24,216.72
X$13488 9264 9263 1687 1688 1733 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13490 r0 *1 119.28,196.56
X$13490 9264 9263 1719 1687 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13493 m0 *1 133.28,206.64
X$13493 1735 9264 1688 9263 1690 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13495 m0 *1 136.64,216.72
X$13495 9263 1735 1688 9264 1870 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13506 m0 *1 130.48,257.04
X$13506 9264 9263 2318 2214 2090 1689 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13515 r0 *1 151.76,206.64
X$13515 9263 1722 1765 9264 1691 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13517 m0 *1 364,206.64
X$13517 9264 9263 1692 1738 1739 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13519 m0 *1 360.64,206.64
X$13519 9264 9263 1786 1692 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13521 r0 *1 372.4,196.56
X$13521 1693 9264 1694 1695 9263 1696 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13523 m0 *1 381.92,216.72
X$13523 9264 9263 1843 1693 1931 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $13526 m0 *1 371.84,216.72
X$13526 9263 1694 9264 1695 1739 1693 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $13538 m0 *1 377.44,206.64
X$13538 9263 1739 1696 9264 1769 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13541 m0 *1 389.76,206.64
X$13541 9264 1697 1766 9263 1740 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $13544 m0 *1 410.48,216.72
X$13544 9264 9263 1847 1884 1902 1698 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13550 m0 *1 369.04,206.64
X$13550 9264 9263 1698 1769 1881 1787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13552 m0 *1 400.96,206.64
X$13552 1699 9264 1741 9263 1884 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13554 r0 *1 392.56,206.64
X$13554 9263 1699 1741 9264 1766 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13559 r0 *1 409.92,206.64
X$13559 9264 9263 1700 1845 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13562 m0 *1 408.24,367.92
X$13562 9263 3238 2979 1701 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $13564 m0 *1 407.68,307.44
X$13564 9263 2787 3182 1701 2788 2789 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $13570 m0 *1 429.52,287.28
X$13570 1701 9264 2543 2666 9263 2739 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13572 r0 *1 421.12,267.12
X$13572 9264 9263 2485 2308 1701 2330 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13574 r0 *1 421.12,257.04
X$13574 9264 9263 2374 2228 1701 2331 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13577 r0 *1 440.16,196.56
X$13577 9264 1724 1702 9263 1793 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $13580 m0 *1 460.88,206.64
X$13580 9264 9263 1703 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13591 r0 *1 484.96,216.72
X$13591 1796 1706 2025 2012 9264 9263 1984 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13598 r0 *1 509.04,216.72
X$13598 9264 9263 1849 1706 2079 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $13606 m0 *1 516.88,206.64
X$13606 9264 9263 1707 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13608 m0 *1 552.72,206.64
X$13608 9264 9263 1750 1720 1748 1708 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13617 r0 *1 538.72,206.64
X$13617 9263 1798 1799 9264 1709 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13620 m0 *1 591.92,226.8
X$13620 2062 1710 1855 2022 9264 9263 2102 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13631 m0 *1 660.8,206.64
X$13631 9263 1761 9264 1711 1760 1756 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $13633 m0 *1 602,206.64
X$13633 9264 9263 1711 1718 1751 1749 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13636 m0 *1 670.88,216.72
X$13636 9264 1862 1860 1865 1712 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13662 m0 *1 628.32,206.64
X$13662 9264 9263 1717 1804 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13678 r0 *1 540.4,196.56
X$13678 1798 9264 1799 9263 1720 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13686 m0 *1 147.28,206.64
X$13686 1722 9264 1774 9263 1736 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13720 r0 *1 14.56,216.72
X$13720 9263 1725 1770 9264 1964 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13735 m0 *1 65.52,216.72
X$13735 9264 9263 1924 1888 1728 1869 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13760 m0 *1 116.48,206.64
X$13760 9263 1733 1773 9264 1734 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13779 m0 *1 319.2,216.72
X$13779 9264 9263 1839 1737 2003 1945 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13781 m0 *1 316.4,206.64
X$13781 9263 1838 1824 9264 1737 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13783 r0 *1 355.04,206.64
X$13783 1785 9264 1738 9263 1841 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13785 r0 *1 357.28,216.72
X$13785 9263 1785 1738 9264 1840 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13797 r0 *1 402.64,216.72
X$13797 9263 1789 1740 1981 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $13800 r0 *1 397.6,206.64
X$13800 1789 9264 1740 9263 1844 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13809 m0 *1 410.48,206.64
X$13809 9264 9263 1845 1741 1790 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13813 m0 *1 418.32,206.64
X$13813 9264 9263 1742 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13823 r0 *1 495.6,206.64
X$13823 9264 9263 1744 1877 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13833 m0 *1 524.72,206.64
X$13833 9264 1763 1746 9263 1747 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $13835 m0 *1 533.12,216.72
X$13835 9263 1907 1747 1927 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $13837 m0 *1 523.6,216.72
X$13837 1907 9264 1747 9263 1979 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13842 m0 *1 554.4,226.8
X$13842 1953 9263 9264 1748 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $13856 m0 *1 610.4,206.64
X$13856 9264 9263 1805 1762 1751 1750 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13862 r0 *1 602.56,236.88
X$13862 9264 9263 2184 2193 1751 2061 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13869 m0 *1 617.12,246.96
X$13869 9264 9263 2191 2185 1751 2142 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13872 r0 *1 596.4,246.96
X$13872 9264 2285 2237 2284 9263 1751 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $13874 r0 *1 612.08,206.64
X$13874 9264 9263 1857 1871 1751 1803 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13880 m0 *1 631.68,206.64
X$13880 9264 1858 9263 1807 1752 1808 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13883 r0 *1 638.96,216.72
X$13883 9264 1957 1958 9263 1752 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $13886 r0 *1 646.24,206.64
X$13886 9263 1753 1807 9264 1755 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13893 r0 *1 625.52,206.64
X$13893 9263 1804 9264 1807 1806 1753 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $13895 m0 *1 630.56,216.72
X$13895 9263 1804 9264 1753 2068 1915 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $13897 m0 *1 642.32,206.64
X$13897 9264 9263 1754 1753 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13899 r0 *1 644,246.96
X$13899 9264 2299 1754 2239 2289 9263 1960 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $13908 m0 *1 652.96,206.64
X$13908 9264 9263 1756 1761 1755 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13910 r0 *1 658.56,226.8
X$13910 9264 9263 1756 2019 2070 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13912 r0 *1 655.76,206.64
X$13912 9263 9264 1756 1866 1867 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $13921 r0 *1 656.88,216.72
X$13921 9263 1756 9264 1969 1916 1958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $13924 m0 *1 658.56,236.88
X$13924 9264 2106 1756 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $13927 r0 *1 677.6,216.72
X$13927 9264 9263 1757 1963 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13937 m0 *1 17.92,307.44
X$13937 9264 1759 9263 2866 2821 1990 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13939 m0 *1 7.28,307.44
X$13939 9264 9263 1759 2714 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13957 r0 *1 599.76,206.64
X$13957 1855 9264 1913 9263 1762 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13969 r0 *1 141.68,206.64
X$13969 9264 1765 1870 9263 1774 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $13981 r0 *1 295.12,206.64
X$13981 9263 1779 1782 9264 1767 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13983 m0 *1 306.32,206.64
X$13983 9263 1780 9264 1767 1768 1781 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $13985 r0 *1 286.72,206.64
X$13985 9264 9263 1777 1823 1768 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14013 r0 *1 10.08,277.2
X$14013 9264 9263 2522 1771 1812 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $14030 r0 *1 252,206.64
X$14030 1833 9264 1775 1776 9263 1834 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $14032 r0 *1 243.04,216.72
X$14032 1940 9263 1941 1775 9264 1898 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14036 r0 *1 249.2,216.72
X$14036 9263 1775 9264 1776 1832 1833 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14045 r0 *1 291.76,206.64
X$14045 9264 9263 1900 1777 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14047 m0 *1 277.2,216.72
X$14047 9264 1835 1823 1778 1975 1874 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $14049 m0 *1 291.76,226.8
X$14049 9263 1778 1977 9264 2028 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14053 m0 *1 292.88,206.64
X$14053 9264 1779 1778 1780 1874 1783 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $14063 m0 *1 310.24,216.72
X$14063 9263 1779 9264 1782 1838 1783 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14066 r0 *1 313.04,206.64
X$14066 1783 9264 1779 1782 9263 1824 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $14070 r0 *1 301.28,206.64
X$14070 1780 9264 1944 9263 1837 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14078 r0 *1 292.88,216.72
X$14078 9264 1900 9263 1977 1944 1780 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $14080 r0 *1 310.8,216.72
X$14080 9264 9263 1781 2029 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14098 r0 *1 336,206.64
X$14098 9264 9263 1787 1783 2053 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $14106 r0 *1 320.32,206.64
X$14106 9264 9263 1784 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14120 m0 *1 379.68,216.72
X$14120 9264 9263 1788 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14139 m0 *1 418.88,216.72
X$14139 9264 9263 1791 1846 1902 1843 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14141 r0 *1 440.72,236.88
X$14141 9263 2097 1792 2201 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $14144 m0 *1 445.2,236.88
X$14144 1792 9264 2097 9263 2145 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14149 m0 *1 448,216.72
X$14149 1904 9264 1793 9263 1983 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14151 r0 *1 451.92,216.72
X$14151 9263 1793 1904 1982 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $14156 r0 *1 461.44,216.72
X$14156 9264 9263 1985 1983 1794 1847 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14164 m0 *1 460.32,246.96
X$14164 9264 2430 1794 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $14166 r0 *1 459.76,226.8
X$14166 9264 9263 2082 2026 1794 1883 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14168 m0 *1 454.72,236.88
X$14168 9264 9263 2135 2145 1794 2085 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14181 r0 *1 486.08,206.64
X$14181 9263 1797 1796 1878 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $14184 m0 *1 491.12,216.72
X$14184 1796 9264 1797 9263 1928 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14205 r0 *1 543.76,206.64
X$14205 9264 9263 1800 1799 2016 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14209 m0 *1 543.76,216.72
X$14209 9264 9263 1875 1800 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14211 r0 *1 574,206.64
X$14211 9264 1801 1821 9263 1854 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $14216 r0 *1 592.48,216.72
X$14216 9263 1855 1912 9264 1802 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14219 m0 *1 612.08,216.72
X$14219 1856 1803 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14231 m0 *1 655.2,216.72
X$14231 9263 1866 9264 1805 1865 1917 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14235 r0 *1 624.96,236.88
X$14235 9264 2287 2067 1806 2066 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $14245 r0 *1 631.68,216.72
X$14245 9264 1858 9263 1915 1808 1859 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $14247 m0 *1 638.4,267.12
X$14247 9264 2503 2437 2435 2067 9263 1808 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $14253 m0 *1 638.4,216.72
X$14253 9263 1808 1859 9264 1867 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14257 r0 *1 689.92,206.64
X$14257 9263 1809 9264 1862 1816 1817 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14259 m0 *1 682.64,216.72
X$14259 9264 1860 1861 1809 1918 1920 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $14269 m0 *1 728,216.72
X$14269 9264 9263 1811 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $14272 m0 *1 7.28,287.28
X$14272 9264 9263 2591 2522 2455 1812 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14298 r0 *1 681.52,216.72
X$14298 9264 9263 1816 1966 1963 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14303 r0 *1 684.88,206.64
X$14303 9263 1864 1860 9264 1817 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14312 m0 *1 120.4,236.88
X$14312 9264 9263 2124 2089 2090 1819 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14339 m0 *1 11.76,257.04
X$14339 9263 9264 2309 2310 1825 2149 2525 2256
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $14341 r0 *1 19.6,378
X$14341 9263 1825 3474 9264 3603 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14343 m0 *1 19.6,378
X$14343 1825 9264 3474 9263 3518 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14349 m0 *1 26.88,246.96
X$14349 9264 9263 2248 2153 1825 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14369 m0 *1 14,267.12
X$14369 1827 9263 2031 2069 9264 2442 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14371 r0 *1 14,226.8
X$14371 9264 2109 1827 9263 2031 2069 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $14373 m0 *1 53.2,236.88
X$14373 9264 1923 2257 1990 1887 1827 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $14375 r0 *1 44.24,267.12
X$14375 9264 9263 2501 1827 1863 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $14377 m0 *1 123.2,216.72
X$14377 9264 9263 1828 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14380 m0 *1 207.2,216.72
X$14380 9264 9263 1829 1891 1894 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14382 m0 *1 203.84,216.72
X$14382 9264 9263 1938 1829 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14384 m0 *1 210,226.8
X$14384 9263 1892 1830 9264 2000 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14389 r0 *1 217.84,216.72
X$14389 9263 1892 9264 1830 1894 1893 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14392 m0 *1 212.24,216.72
X$14392 1893 9264 1892 1830 9263 1872 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $14394 m0 *1 220.64,216.72
X$14394 9264 9263 1831 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14397 m0 *1 243.6,216.72
X$14397 9264 9263 1873 1899 1832 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14399 m0 *1 250.88,216.72
X$14399 9263 1832 1834 9264 1929 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14404 r0 *1 225.12,257.04
X$14404 2617 1833 2359 2270 9264 9263 2360 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14413 r0 *1 268.24,226.8
X$14413 9264 9263 1945 1833 2171 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $14420 r0 *1 280.56,226.8
X$14420 9264 9263 1835 2051 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14424 r0 *1 286.16,226.8
X$14424 9263 2052 1835 9264 2118 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14427 r0 *1 302.4,216.72
X$14427 9264 9263 1946 1837 2003 1836 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14431 m0 *1 255.92,216.72
X$14431 9264 9263 1836 1929 1974 1897 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14439 m0 *1 310.24,226.8
X$14439 9264 9263 2029 1944 1838 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14441 m0 *1 360.64,216.72
X$14441 9264 9263 1842 1841 1881 1839 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14450 m0 *1 348.88,216.72
X$14450 9264 1876 1840 9263 1948 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $14456 m0 *1 402.08,216.72
X$14456 9264 9263 1883 1844 1902 1842 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14483 m0 *1 482.16,257.04
X$14483 9263 2280 1848 2404 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $14485 r0 *1 483.84,257.04
X$14485 1848 9264 2280 9263 2377 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14487 r0 *1 474.32,257.04
X$14487 2376 9264 9263 1850 2333 1848 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $14489 m0 *1 547.12,216.72
X$14489 9264 9263 1856 1908 1953 1849 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14497 r0 *1 270.48,246.96
X$14497 2052 9263 1850 2224 9264 2222 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14500 r0 *1 524.16,257.04
X$14500 2336 9264 9263 1850 2306 2337 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $14504 m0 *1 304.08,267.12
X$14504 9263 1850 2324 9264 2424 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14506 m0 *1 292.32,287.28
X$14506 9263 1850 2420 9264 2574 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14508 r0 *1 348.88,267.12
X$14508 9263 1850 2365 9264 2478 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14512 r0 *1 225.12,327.6
X$14512 9263 1850 3072 9264 3102 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14514 r0 *1 232.4,277.2
X$14514 9264 2530 1850 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $14539 r0 *1 222.32,307.44
X$14539 1850 9264 2049 2829 9263 2942 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $14541 m0 *1 610.96,257.04
X$14541 9263 2286 9264 2351 2352 1850 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14544 m0 *1 619.36,317.52
X$14544 9263 1850 2493 9264 2749 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14546 r0 *1 393.12,257.04
X$14546 9264 2370 2371 1850 2308 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $14549 r0 *1 558.32,257.04
X$14549 9264 2381 2104 1850 2234 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $14552 r0 *1 619.36,246.96
X$14552 9263 2286 9264 2287 2238 1850 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14554 m0 *1 417.76,267.12
X$14554 9264 2428 2200 1850 2276 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $14556 m0 *1 555.52,216.72
X$14556 1851 9264 1925 1852 9263 1909 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $14559 r0 *1 554.4,216.72
X$14559 9263 1851 9264 1852 2016 1925 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14565 m0 *1 562.24,216.72
X$14565 9264 9263 1853 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14567 m0 *1 576.8,216.72
X$14567 1911 9264 1854 9263 1955 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14570 m0 *1 571.76,216.72
X$14570 9263 1911 1854 9264 1910 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14589 m0 *1 663.04,216.72
X$14589 9263 1916 9264 1857 1919 1917 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14597 m0 *1 641.76,226.8
X$14597 9264 9263 2071 1859 1959 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14614 r0 *1 52.64,378
X$14614 1863 9263 2810 3155 9264 3533 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14617 r0 *1 45.92,378
X$14617 9264 9263 1863 3651 2810 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14645 r0 *1 82.88,236.88
X$14645 9264 1868 2120 2121 2122 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $14655 r0 *1 62.72,236.88
X$14655 9264 2190 1889 2035 2154 1868 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $14670 r0 *1 619.92,216.72
X$14670 1971 9264 1972 9263 1871 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14673 m0 *1 222.88,216.72
X$14673 9263 1894 1872 9264 1895 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14679 m0 *1 227.92,216.72
X$14679 9264 9263 1896 1873 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14705 m0 *1 479.92,216.72
X$14705 9264 1882 1878 9263 2013 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $14711 r0 *1 479.92,236.88
X$14711 9263 2136 1880 2231 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $14713 m0 *1 484.4,246.96
X$14713 1880 9264 2136 9263 2281 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14721 r0 *1 360.64,236.88
X$14721 9264 2272 1881 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $14730 m0 *1 357.84,226.8
X$14730 9264 9263 2008 1949 1881 1946 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14732 r0 *1 348.32,226.8
X$14732 9264 9263 2087 2086 1881 2004 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14734 r0 *1 352.24,236.88
X$14734 9264 9263 2206 2207 1881 2095 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14758 r0 *1 21.28,246.96
X$14758 9263 1885 2151 9264 2256 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14770 r0 *1 175.28,216.72
X$14770 9264 9263 1890 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14773 m0 *1 212.8,236.88
X$14773 2077 9264 1891 9263 2048 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14776 m0 *1 204.96,236.88
X$14776 9264 2076 9263 2167 1891 2077 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $14790 r0 *1 204.96,236.88
X$14790 9264 1892 2168 2077 2169 1893 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $14800 m0 *1 222.32,236.88
X$14800 9264 9263 1897 1893 2535 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $14809 m0 *1 225.68,226.8
X$14809 9264 9263 2002 1895 2049 1939 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14824 r0 *1 233.52,216.72
X$14824 1941 9264 1899 9263 1973 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14826 r0 *1 248.64,226.8
X$14826 9263 1941 1899 9264 2078 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14836 r0 *1 338.8,226.8
X$14836 2005 9264 1901 9263 2086 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14838 m0 *1 333.76,216.72
X$14838 9264 1978 1932 9263 1901 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $14840 m0 *1 338.24,226.8
X$14840 9263 2005 1901 2006 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $14842 r0 *1 413.28,236.88
X$14842 9264 2134 1902 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $14844 r0 *1 402.64,246.96
X$14844 9264 9263 2276 2277 1902 2206 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14846 r0 *1 402.08,226.8
X$14846 9264 9263 2085 2027 1902 2008 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14854 r0 *1 441.84,216.72
X$14854 9264 1903 1982 9263 1951 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $14867 m0 *1 460.88,307.44
X$14867 9263 2849 2794 9264 1905 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14870 m0 *1 468.72,307.44
X$14870 9263 2850 2796 1905 2851 2852 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $14874 r0 *1 542.64,216.72
X$14874 9264 9263 1954 1979 1953 1906 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14886 m0 *1 549.36,226.8
X$14886 9263 2016 1909 9264 1908 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14894 m0 *1 572.32,226.8
X$14894 9264 1910 1976 9263 2183 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $14903 m0 *1 576.24,236.88
X$14903 1911 9263 2063 2104 9264 2103 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14907 r0 *1 597.52,216.72
X$14907 1912 1913 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14910 m0 *1 593.6,216.72
X$14910 9264 1921 1922 9263 1912 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $14914 r0 *1 613.76,226.8
X$14914 9263 1972 1914 9264 1921 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14918 r0 *1 610.4,216.72
X$14918 1914 1971 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14920 m0 *1 609.28,226.8
X$14920 1914 2022 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14928 r0 *1 664.72,236.88
X$14928 2106 9263 9264 1917 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $14934 m0 *1 660.8,246.96
X$14934 9263 1917 9264 2247 2241 2187 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14936 m0 *1 668.64,246.96
X$14936 9263 2241 9264 2184 2296 1917 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14942 m0 *1 662.48,226.8
X$14942 9263 2019 9264 1917 1961 1956 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $14944 m0 *1 659.68,317.52
X$14944 9264 2937 2933 2805 1918 2925 1962 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $14946 r0 *1 675.36,297.36
X$14946 9264 1918 2805 2343 2756 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $14959 m0 *1 671.44,226.8
X$14959 9264 1962 1966 1920 1967 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $14978 m0 *1 45.36,287.28
X$14978 9264 9263 2719 2190 1924 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $14983 r0 *1 45.92,287.28
X$14983 9264 2190 1924 9263 2668 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $14993 r0 *1 566.72,226.8
X$14993 9264 9263 2061 1925 2198 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $14998 m0 *1 125.44,267.12
X$14998 9264 9263 2412 2357 2090 1926 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15005 m0 *1 522.48,226.8
X$15005 9264 1952 1927 9263 2014 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $15011 r0 *1 392.56,216.72
X$15011 9264 1930 1981 9263 2009 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $15016 r0 *1 360.08,267.12
X$15016 9264 9263 2479 2480 1931 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $15025 r0 *1 379.12,267.12
X$15025 9264 9263 2482 2426 1931 2328 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15027 m0 *1 376.88,267.12
X$15027 9263 2368 9264 2328 2454 1931 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $15029 r0 *1 369.6,246.96
X$15029 9264 2308 1931 2173 2307 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $15031 r0 *1 338.24,216.72
X$15031 9263 1947 1948 1932 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $15037 m0 *1 58.24,297.36
X$15037 9263 1933 2611 9264 2887 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $15039 m0 *1 59.92,267.12
X$15039 9263 1933 1968 9264 2407 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $15041 m0 *1 59.92,277.2
X$15041 9264 9263 2526 2457 1933 2502 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15048 m0 *1 35.84,287.28
X$15048 2456 9264 2610 1933 9263 2667 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $15055 m0 *1 113.68,257.04
X$15055 1935 2316 2261 2157 9264 9263 2155 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $15061 r0 *1 106.4,216.72
X$15061 1935 9264 1936 1937 9263 2023 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $15063 r0 *1 106.96,226.8
X$15063 9263 1936 9264 1937 2037 1935 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $15067 m0 *1 108.08,246.96
X$15067 9264 9263 2215 1935 2260 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $15074 m0 *1 103.04,246.96
X$15074 9263 1936 2121 9264 2195 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15088 r0 *1 208.88,226.8
X$15088 9263 2077 9264 2000 2114 1938 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $15090 r0 *1 190.4,226.8
X$15090 9264 9263 1939 1999 2042 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $15097 m0 *1 230.72,236.88
X$15097 9263 1940 2050 9264 2130 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15099 r0 *1 239.12,226.8
X$15099 1940 9264 2050 9263 2093 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15115 m0 *1 301.28,226.8
X$15115 9264 9263 2004 2028 2003 1942 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15119 m0 *1 245.84,226.8
X$15119 9264 9263 1942 1973 1974 2002 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15123 m0 *1 263.76,226.8
X$15123 9264 9263 1943 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15146 r0 *1 347.76,216.72
X$15146 1947 9264 1948 9263 1949 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15159 r0 *1 392.56,226.8
X$15159 9263 1950 2009 2088 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $15161 m0 *1 390.32,226.8
X$15161 1950 9264 2009 9263 2027 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15164 m0 *1 446.32,226.8
X$15164 2011 9264 1951 9263 2026 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15166 r0 *1 450.24,226.8
X$15166 9263 1951 2011 2083 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $15177 r0 *1 535.36,236.88
X$15177 9264 2100 1953 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $15180 m0 *1 538.72,246.96
X$15180 9264 9263 2234 2199 1953 2058 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15182 m0 *1 583.52,226.8
X$15182 9264 9263 1956 1955 2017 1954 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15198 m0 *1 638.4,226.8
X$15198 9264 9263 1957 1959 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15208 m0 *1 652.4,226.8
X$15208 9263 1960 2018 9264 1958 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15216 r0 *1 647.92,236.88
X$15216 9263 1960 9264 2139 2071 2187 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $15218 r0 *1 652.4,226.8
X$15218 9264 9263 1969 1960 2018 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $15225 r0 *1 672.56,307.44
X$15225 9263 2934 3096 2935 2696 1962 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $15232 r0 *1 10.08,307.44
X$15232 9263 1964 2349 9264 2821 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $15234 r0 *1 7.28,297.36
X$15234 1964 9264 2349 9263 2715 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15237 m0 *1 10.64,307.44
X$15237 1964 1990 2349 2714 9264 9263 2820 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $15240 r0 *1 16.8,297.36
X$15240 9264 9263 2807 1964 2349 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $15247 m0 *1 7.84,317.52
X$15247 9264 2714 9263 2950 2349 1964 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $15252 r0 *1 27.44,236.88
X$15252 9263 2153 9264 1988 2392 1965 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $15262 m0 *1 56.56,277.2
X$15262 9264 9263 1968 2458 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15264 m0 *1 69.44,267.12
X$15264 9263 2314 1968 9264 2408 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15271 r0 *1 58.8,267.12
X$15271 9263 2210 1968 9264 2457 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15295 m0 *1 600.32,226.8
X$15295 9264 9263 2073 1972 2105 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $15304 r0 *1 246.96,246.96
X$15304 9264 9263 2221 2304 1974 2219 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15306 m0 *1 252.56,438.48
X$15306 9264 3951 1974 3998 4068 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $15308 m0 *1 249.76,277.2
X$15308 9264 2514 1974 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15313 m0 *1 247.52,236.88
X$15313 9264 9263 2094 2093 1974 2092 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15335 r0 *1 533.12,216.72
X$15335 2057 9264 1980 9263 2015 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15339 m0 *1 532.56,226.8
X$15339 2014 1980 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15364 r0 *1 28.56,267.12
X$15364 9264 9263 1986 2456 2151 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $15368 m0 *1 25.2,267.12
X$15368 9263 1986 2151 9264 2406 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15370 r0 *1 14.56,257.04
X$15370 9264 2255 9263 2309 2151 1986 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $15397 r0 *1 41.44,226.8
X$15397 9264 9263 2034 1989 1988 1991 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15403 m0 *1 36.4,277.2
X$15403 9264 2718 2151 1990 2501 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $15422 m0 *1 33.6,317.52
X$15422 9264 3095 2883 2882 2821 1990 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $15426 r0 *1 103.04,236.88
X$15426 9264 9263 1992 2036 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15429 r0 *1 108.08,236.88
X$15429 9264 9263 2196 2123 2090 1993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15436 m0 *1 114.24,226.8
X$15436 9264 9263 1994 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15440 r0 *1 168.56,226.8
X$15440 9264 9263 1995 2043 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15443 m0 *1 162.96,236.88
X$15443 9264 9263 2111 2091 1996 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $15445 m0 *1 178.64,236.88
X$15445 9264 9263 2047 2046 2267 1996 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15451 r0 *1 183.12,226.8
X$15451 1999 9264 1997 1998 9263 2075 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $15454 m0 *1 182.56,226.8
X$15454 9263 1997 9264 1998 2045 1999 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $15471 r0 *1 233.52,226.8
X$15471 9264 2001 2078 9263 2050 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $15479 r0 *1 304.08,246.96
X$15479 9264 2422 2003 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $15487 m0 *1 298.48,246.96
X$15487 9264 9263 2173 2208 2003 2254 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15490 m0 *1 296.24,236.88
X$15490 9264 9263 2095 2118 2003 2094 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15507 m0 *1 347.76,226.8
X$15507 9264 2030 2006 9263 2096 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $15509 r0 *1 382.48,226.8
X$15509 9264 2007 2088 9263 2054 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $15524 r0 *1 435.12,226.8
X$15524 9264 2010 2083 9263 2097 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $15534 m0 *1 488.32,226.8
X$15534 2012 9264 2013 9263 2024 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15536 r0 *1 491.68,226.8
X$15536 9263 2012 2013 9264 2080 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15546 r0 *1 522.48,226.8
X$15546 9263 2057 2014 2112 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $15553 r0 *1 541.52,226.8
X$15553 9264 9263 2059 2015 2060 2056 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15562 r0 *1 590.24,257.04
X$15562 2284 9264 2237 2285 9263 2017 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $15565 m0 *1 584.64,267.12
X$15565 9264 9263 2433 2446 2017 2234 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15568 m0 *1 593.6,267.12
X$15568 9264 2234 2017 9263 2445 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $15571 r0 *1 681.52,277.2
X$15571 9264 9263 2588 2017 2589 2644 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15575 m0 *1 653.52,236.88
X$15575 9264 9263 2110 2018 2186 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $15581 m0 *1 728,257.04
X$15581 9264 9263 2245 2346 2345 2020 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15583 r0 *1 702.8,236.88
X$15583 9264 9263 2020 2107 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $15587 r0 *1 721.84,246.96
X$15587 9264 2246 2020 2292 2245 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $15598 m0 *1 705.04,267.12
X$15598 9264 9263 2344 2440 2020 2243 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15600 m0 *1 688.8,257.04
X$15600 9263 2293 2020 9264 2347 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15613 m0 *1 106.4,236.88
X$15613 9263 2037 2023 9264 2123 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15617 m0 *1 492.8,236.88
X$15617 9263 2025 2055 9264 2115 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15619 r0 *1 489.44,236.88
X$15619 2025 9264 2055 9263 2137 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15643 r0 *1 31.92,246.96
X$15643 9264 2031 9263 2209 2212 2210 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $15667 m0 *1 39.2,257.04
X$15667 9264 3053 2033 2150 2313 2312 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $15670 r0 *1 32.48,257.04
X$15670 9264 2311 2313 2150 2033 2312 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $15675 m0 *1 78.96,398.16
X$15675 9264 9263 2034 3692 2718 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $15677 m0 *1 84.56,398.16
X$15677 3663 9264 2034 9263 3684 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15680 m0 *1 40.88,398.16
X$15680 3062 3313 2034 2718 9264 9263 3652 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $15685 m0 *1 85.12,388.08
X$15685 9264 2034 3570 9263 3268 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $15689 r0 *1 101.92,226.8
X$15689 9264 9263 2037 2038 2036 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $15698 r0 *1 114.8,226.8
X$15698 2039 9264 2038 9263 2089 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15701 m0 *1 128.8,236.88
X$15701 9263 2039 2038 9264 2148 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15714 r0 *1 152.88,226.8
X$15714 9264 9263 2040 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15719 r0 *1 160.72,236.88
X$15719 2091 9264 2127 2041 9263 2164 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $15722 m0 *1 155.12,236.88
X$15722 9263 2127 9264 2041 2128 2091 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $15725 m0 *1 126,357.84
X$15725 3317 9263 3270 2042 9264 3316 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $15730 r0 *1 108.08,398.16
X$15730 9264 3684 3615 3750 2042 9263 3794 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $15733 r0 *1 171.92,226.8
X$15733 9264 9263 2045 2044 2043 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $15736 m0 *1 173.6,246.96
X$15736 9263 2165 2044 9264 2217 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15739 m0 *1 178.64,246.96
X$15739 2165 9264 2044 9263 2268 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15743 r0 *1 177.52,226.8
X$15743 9263 2045 2075 9264 2046 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15752 r0 *1 218.4,226.8
X$15752 9264 9263 2092 2048 2049 2047 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15763 r0 *1 203.28,297.36
X$15763 9264 2727 2049 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15774 m0 *1 215.04,246.96
X$15774 9264 9263 2219 2251 2049 2218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15776 r0 *1 207.76,267.12
X$15776 9264 9263 2466 2417 2049 2415 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15785 m0 *1 273.28,236.88
X$15785 9264 2117 9263 2131 2052 2051 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $15795 r0 *1 276.64,246.96
X$15795 2052 9263 2288 2224 9264 2401 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $15799 r0 *1 338.8,287.28
X$15799 9264 2053 9263 2681 2712 2661 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $15801 r0 *1 328.72,277.2
X$15801 9263 2540 2661 2053 2662 2575 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $15803 r0 *1 338.24,277.2
X$15803 2053 9263 2355 2609 9264 2558 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $15807 r0 *1 323.12,347.76
X$15807 9264 3276 3232 9263 3323 2053 3275 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $15816 r0 *1 328.16,317.52
X$15816 9263 2626 2780 2053 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $15819 r0 *1 330.96,307.44
X$15819 9264 2881 2053 9263 2476 2541 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $15821 m0 *1 334.32,297.36
X$15821 9263 2541 2713 2476 2420 2053 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $15823 m0 *1 390.32,236.88
X$15823 2133 9264 2054 9263 2146 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15825 r0 *1 394.8,236.88
X$15825 9263 2133 2054 2205 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $15834 r0 *1 486.08,226.8
X$15834 9264 2081 2080 9263 2055 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $15857 r0 *1 576.8,267.12
X$15857 9264 2491 2059 9263 2492 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $15863 m0 *1 541.52,236.88
X$15863 2100 2060 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15877 r0 *1 607.04,226.8
X$15877 2062 9264 2063 2064 9263 2065 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $15879 m0 *1 603.68,236.88
X$15879 9263 2062 9264 2064 2105 2063 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $15881 r0 *1 618.8,236.88
X$15881 9264 9263 2063 2185 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15897 r0 *1 610.96,236.88
X$15897 9263 2105 2065 9264 2193 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15900 m0 *1 627.76,236.88
X$15900 9264 2066 9263 2351 2067 2068 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $15914 r0 *1 637.28,226.8
X$15914 9263 2067 2068 9264 2070 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $15946 m0 *1 28.56,287.28
X$15946 2406 9263 2310 2072 9264 2716 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $15957 r0 *1 70.56,267.12
X$15957 9264 9263 2460 2408 2072 2409 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15962 r0 *1 591.92,226.8
X$15962 9264 9263 2074 2073 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15973 m0 *1 201.6,236.88
X$15973 9264 9263 2076 2129 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15993 r0 *1 506.24,388.08
X$15993 9264 3593 2919 3609 2079 3636 3637 9263
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $15997 r0 *1 474.32,347.76
X$15997 9264 2079 3186 3284 3285 3239 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $16003 m0 *1 506.8,388.08
X$16003 9263 3593 9264 3609 3336 2079 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $16005 r0 *1 500.64,388.08
X$16005 9264 9263 3607 2079 3609 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $16008 r0 *1 485.52,388.08
X$16008 2079 9264 3419 3588 9263 3634 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $16010 m0 *1 487.76,267.12
X$16010 9264 9263 2379 2333 2079 2377 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16044 r0 *1 404.32,236.88
X$16044 9264 9263 2179 2146 2134 2087 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16058 m0 *1 92.96,277.2
X$16058 9264 2528 2090 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $16065 r0 *1 109.2,267.12
X$16065 9264 9263 2462 2411 2090 2444 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16079 m0 *1 159.6,246.96
X$16079 2091 9263 2161 2127 9264 2163 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $16104 r0 *1 342.72,236.88
X$16104 2132 9264 2096 9263 2207 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $16106 m0 *1 337.68,236.88
X$16106 9263 2096 2132 2119 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16118 m0 *1 529.2,236.88
X$16118 2099 9264 2098 9263 2199 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $16120 m0 *1 523.04,246.96
X$16120 2138 2098 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16122 r0 *1 520.8,236.88
X$16122 9263 2099 2138 2232 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16129 r0 *1 522.48,337.68
X$16129 9264 3081 2100 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $16132 r0 *1 551.04,317.52
X$16132 9264 2992 2799 2100 3007 2991 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $16134 m0 *1 540.4,297.36
X$16134 9264 2800 2100 2581 2547 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $16140 r0 *1 556.08,337.68
X$16140 2100 3189 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16143 r0 *1 556.08,297.36
X$16143 2100 2813 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16147 m0 *1 575.68,246.96
X$16147 9263 2183 2101 2236 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16153 r0 *1 575.68,236.88
X$16153 9264 9263 2194 2101 2183 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $16169 r0 *1 570.08,257.04
X$16169 9263 2104 2283 2383 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16176 m0 *1 566.72,257.04
X$16176 9264 9263 2382 2104 2283 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $16187 m0 *1 652.96,287.28
X$16187 9263 2106 2495 9264 2651 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16192 m0 *1 651.28,297.36
X$16192 9263 9264 2752 2106 2753 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $16194 m0 *1 668.08,287.28
X$16194 9264 9263 2650 2106 2589 2587 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16197 m0 *1 711.2,257.04
X$16197 2554 9264 9263 2244 2107 9275 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $16203 r0 *1 707.84,257.04
X$16203 2389 9264 9263 2108 2107 9305 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $16211 r0 *1 717.36,257.04
X$16211 9263 2390 2108 9264 2393 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16213 m0 *1 712.32,246.96
X$16213 9264 9263 2244 2108 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $16226 m0 *1 698.32,257.04
X$16226 9264 9263 2348 2347 2108 2344 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16233 m0 *1 650.16,236.88
X$16233 9264 9263 2139 2110 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $16240 m0 *1 66.08,357.84
X$16240 9264 9263 3220 2111 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $16242 m0 *1 58.8,357.84
X$16242 9264 2111 9263 3450 3250 3313 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $16256 m0 *1 103.04,327.6
X$16256 9264 9263 2957 2773 2111 2763 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $16259 m0 *1 120.96,337.68
X$16259 9264 9263 3159 3067 2111 3109 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16263 m0 *1 519.12,236.88
X$16263 9264 2113 2112 9263 2138 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16272 r0 *1 198.24,236.88
X$16272 9264 9263 2129 2166 2114 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $16275 m0 *1 473.2,236.88
X$16275 9264 2116 2115 9263 2136 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16295 r0 *1 332.08,236.88
X$16295 9264 2175 2119 9263 2177 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16297 r0 *1 85.12,246.96
X$16297 2121 9264 2120 9263 2314 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $16300 m0 *1 103.04,257.04
X$16300 9264 2259 2297 9263 2120 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16303 m0 *1 85.68,246.96
X$16303 9263 2121 2120 9264 2210 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $16322 r0 *1 159.04,267.12
X$16322 9264 9263 2465 2507 2216 2124 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16329 m0 *1 135.52,277.2
X$16329 2414 2560 2529 2463 9264 9263 2125 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $16332 r0 *1 151.2,236.88
X$16332 2161 9264 2126 9263 2162 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $16335 m0 *1 156.24,257.04
X$16335 9263 2126 2161 9264 2353 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16338 r0 *1 146.16,236.88
X$16338 9264 9263 2160 2126 2128 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $16350 m0 *1 165.76,246.96
X$16350 9263 2128 2164 9264 2250 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16359 r0 *1 232.96,236.88
X$16359 9264 2202 2130 9263 2220 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16364 r0 *1 272.72,236.88
X$16364 9264 9263 2131 2172 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $16366 r0 *1 277.2,236.88
X$16366 2170 9264 2131 9263 2208 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $16381 r0 *1 426.16,337.68
X$16381 9264 2912 2134 3078 3079 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $16384 r0 *1 426.72,317.52
X$16384 9264 9263 2134 2981 3078 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $16386 m0 *1 418.32,347.76
X$16386 2906 9263 2134 3076 9264 3039 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $16388 r0 *1 411.6,357.84
X$16388 9264 3376 3078 2134 3331 3330 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $16390 m0 *1 417.2,307.44
X$16390 9264 9263 2134 2734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $16404 r0 *1 402.64,357.84
X$16404 9263 9264 2979 2134 3238 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $16408 m0 *1 491.68,257.04
X$16408 9264 9263 2306 2281 2335 2135 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16429 m0 *1 722.96,257.04
X$16429 9263 2390 2141 9264 2346 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16434 m0 *1 722.4,347.76
X$16434 9264 9263 3296 3249 2998 2142 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16437 r0 *1 720.16,347.76
X$16437 9264 2246 2142 2292 3296 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $16445 m0 *1 717.36,418.32
X$16445 9263 3650 9264 3838 3840 2142 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $16449 r0 *1 524.16,246.96
X$16449 9264 2143 2232 9263 2233 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16454 r0 *1 402.08,297.36
X$16454 2786 9263 2144 2733 9264 2767 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $16459 m0 *1 381.92,307.44
X$16459 9264 2905 2144 9263 2783 2784 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $16474 r0 *1 384.72,236.88
X$16474 9264 2147 2205 9263 2178 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16478 r0 *1 123.76,236.88
X$16478 9264 2197 2148 9263 2156 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16489 r0 *1 34.16,327.6
X$16489 9264 3064 3021 2768 3020 2150 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $16500 m0 *1 39.76,337.68
X$16500 2150 9264 2768 3020 9263 3152 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $16529 m0 *1 94.64,307.44
X$16529 9263 2772 2154 2769 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16533 m0 *1 77.84,297.36
X$16533 9263 2154 2722 9264 2720 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16535 m0 *1 81.76,317.52
X$16535 9264 9263 2154 2953 2722 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $16537 r0 *1 105.28,327.6
X$16537 9263 2154 2954 9264 3066 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16539 r0 *1 129.92,317.52
X$16539 9263 2154 2957 9264 3002 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $16541 r0 *1 176.4,307.44
X$16541 9264 9263 2894 2893 2154 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $16543 r0 *1 173.6,297.36
X$16543 9264 9263 2154 2621 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $16556 m0 *1 82.88,297.36
X$16556 2154 9264 2314 2722 9263 2723 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $16561 m0 *1 113.68,246.96
X$16561 9263 2156 2157 2298 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16564 m0 *1 123.2,246.96
X$16564 2157 9264 2156 9263 2214 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $16579 r0 *1 125.44,246.96
X$16579 9264 2158 2298 9263 2262 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16582 m0 *1 144.48,246.96
X$16582 9264 9263 2159 2160 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $16597 r0 *1 154,246.96
X$16597 9264 9263 2264 2162 2216 2196 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16610 r0 *1 200.48,246.96
X$16610 9264 2269 2166 2168 2301 2169 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $16614 m0 *1 204.96,246.96
X$16614 9263 2168 2167 9264 2251 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $16626 m0 *1 268.8,246.96
X$16626 9263 2170 2172 9264 2252 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16633 r0 *1 275.52,408.24
X$16633 9264 9263 3705 3772 2171 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $16635 r0 *1 265.44,438.48
X$16635 9264 4033 4032 3999 2171 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $16637 m0 *1 265.44,287.28
X$16637 9264 9263 2605 2622 2171 2570 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16641 r0 *1 263.2,327.6
X$16641 2171 9263 2774 3119 9264 3073 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $16643 m0 *1 260.4,398.16
X$16643 9264 3231 2171 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $16647 r0 *1 259.84,418.32
X$16647 9264 2171 9263 3853 3867 3772 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $16659 r0 *1 277.2,367.92
X$16659 9263 3501 9264 3502 3235 2171 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $16662 m0 *1 262.64,378
X$16662 9263 3543 9264 3502 3529 2171 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $16664 r0 *1 274.96,297.36
X$16664 9264 2730 2572 2729 2171 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $16667 m0 *1 276.64,297.36
X$16667 9264 2472 2729 2171 2730 2663 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $16672 r0 *1 324.8,236.88
X$16672 9264 9263 2173 2174 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $16676 m0 *1 371.84,267.12
X$16676 9264 9263 2326 2426 2173 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $16684 m0 *1 333.76,246.96
X$16684 9263 2176 2177 9264 2253 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $16686 r0 *1 335.44,246.96
X$16686 9263 2176 2177 2271 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16694 m0 *1 390.32,246.96
X$16694 2226 9264 2178 9263 2277 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $16696 m0 *1 380.8,246.96
X$16696 9263 2178 2226 2275 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16701 r0 *1 461.44,257.04
X$16701 9264 9263 2333 2332 2334 2179 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16710 r0 *1 455.84,257.04
X$16710 9264 2276 2179 9263 2405 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $16712 m0 *1 430.08,246.96
X$16712 9263 2230 2180 9264 2229 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16717 m0 *1 442.4,246.96
X$16717 9264 2201 2180 9263 2279 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16723 m0 *1 564.48,337.68
X$16723 9264 2182 9263 3466 2402 2743 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $16737 r0 *1 652.96,246.96
X$16737 9264 9263 2239 2186 2291 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $16739 r0 *1 658,246.96
X$16739 9263 2239 2240 2187 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16745 m0 *1 21.28,327.6
X$16745 9264 3062 2406 2610 2188 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $16754 r0 *1 677.04,337.68
X$16754 9264 2189 3201 3140 3197 3200 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $16761 r0 *1 673.68,317.52
X$16761 9264 9263 2868 3054 2189 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $16771 m0 *1 652.96,267.12
X$16771 9264 9263 2191 2436 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $16794 r0 *1 572.32,246.96
X$16794 9264 2237 2284 2285 2236 2194 9263 2339 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $16810 m0 *1 541.52,367.92
X$16810 2919 9263 2990 2198 9264 2989 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $16813 r0 *1 556.64,287.28
X$16813 9263 2548 9264 3305 2198 2381 2692 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $16819 m0 *1 556.08,367.92
X$16819 2198 3465 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16821 r0 *1 561.68,267.12
X$16821 2198 2515 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16823 m0 *1 557.2,307.44
X$16823 9264 9263 2856 2198 2798 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $16829 m0 *1 430.08,267.12
X$16829 9263 2375 2200 2453 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16832 m0 *1 439.6,267.12
X$16832 2200 9264 2375 9263 2429 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $16841 r0 *1 427.28,246.96
X$16841 9263 2200 9264 2229 2227 2278 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $16843 m0 *1 435.12,246.96
X$16843 9264 2203 2200 9263 2230 2201 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $16857 r0 *1 419.44,246.96
X$16857 9263 2227 9264 2203 2228 2308 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $16859 m0 *1 421.12,257.04
X$16859 9263 2227 9264 2203 2331 2330 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $16863 m0 *1 258.72,246.96
X$16863 9264 2204 2252 9263 2323 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16876 r0 *1 404.32,267.12
X$16876 2206 2483 2484 2308 9263 9264 2372 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $16888 m0 *1 30.8,267.12
X$16888 9263 2392 9264 2312 2310 2456 2209 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $16890 m0 *1 32.48,246.96
X$16890 9264 9263 2210 2248 2212 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $16893 m0 *1 68.32,277.2
X$16893 9263 2210 2458 9264 2502 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16895 m0 *1 82.32,277.2
X$16895 9264 9263 2671 2461 2260 2210 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $16907 m0 *1 30.8,297.36
X$16907 9264 2717 2211 2667 2595 2759 2719 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $16909 m0 *1 25.76,307.44
X$16909 9264 9263 2528 2822 2211 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $16914 r0 *1 25.2,297.36
X$16914 9263 2595 9264 2807 2760 2211 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $16926 m0 *1 64.4,257.04
X$16926 9263 2314 2213 9264 2350 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16938 r0 *1 162.96,246.96
X$16938 9264 9263 2266 2250 2216 2215 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16940 m0 *1 125.44,317.52
X$16940 9264 2671 9263 2940 2890 2216 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $16942 r0 *1 124.32,307.44
X$16942 2671 9263 2216 2890 9264 2825 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $16956 r0 *1 81.2,327.6
X$16956 9264 3065 2216 9263 3064 2889 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $16958 r0 *1 132.16,287.28
X$16958 9264 9263 2704 2614 2216 2412 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16960 m0 *1 150.64,287.28
X$16960 9264 9263 2615 2600 2216 2562 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16962 m0 *1 50.4,327.6
X$16962 9264 2216 3053 3097 2952 3021 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $16971 m0 *1 173.6,257.04
X$16971 9264 2265 2217 9263 2320 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $16976 m0 *1 183.68,257.04
X$16976 9264 9263 2218 2268 2267 2266 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16987 r0 *1 237.44,246.96
X$16987 2270 9264 2220 9263 2304 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $16989 m0 *1 237.44,257.04
X$16989 9263 2220 2270 2303 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $16993 m0 *1 292.88,246.96
X$16993 9264 9263 2221 2254 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $17000 r0 *1 266.56,307.44
X$17000 9263 2774 2222 9264 2901 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $17003 r0 *1 271.6,307.44
X$17003 9263 2619 2222 9264 2947 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $17007 m0 *1 266.56,257.04
X$17007 9264 2324 2323 2223 9263 gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* cell instance $17009 r0 *1 262.08,257.04
X$17009 9263 2323 2223 2362 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $17022 m0 *1 323.68,257.04
X$17022 9264 2225 2271 9263 2423 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $17024 r0 *1 325.36,246.96
X$17024 9264 9263 2271 2225 2365 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $17046 r0 *1 437.92,257.04
X$17046 9263 2279 2230 2354 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $17048 m0 *1 442.96,257.04
X$17048 2230 9264 2279 9263 2332 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $17059 r0 *1 483.84,246.96
X$17059 9264 2249 2231 9263 2280 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $17063 r0 *1 534.24,246.96
X$17063 9263 2337 2233 2305 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $17065 r0 *1 533.68,257.04
X$17065 2233 2282 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $17077 r0 *1 562.24,246.96
X$17077 9264 2236 2235 9263 2283 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $17088 r0 *1 591.92,277.2
X$17088 2237 9263 2550 2586 9264 2285 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $17091 m0 *1 589.68,337.68
X$17091 9263 2237 3135 2285 3084 3085 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $17093 r0 *1 576.8,307.44
X$17093 9264 2857 2237 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $17096 m0 *1 589.12,307.44
X$17096 9263 2764 9264 2858 2237 2285 2550 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $17098 r0 *1 580.72,277.2
X$17098 2597 2237 2550 2492 9263 9264 2300 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $17101 r0 *1 592.48,347.76
X$17101 3344 9264 2237 2284 9263 3468 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $17104 r0 *1 600.32,347.76
X$17104 9264 9263 3355 2285 2237 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $17116 r0 *1 585.76,317.52
X$17116 9264 2284 3004 2993 2237 2285 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $17118 m0 *1 579.6,277.2
X$17118 9264 2284 2490 2508 2237 2285 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $17124 m0 *1 619.36,257.04
X$17124 2300 9263 2339 2238 9264 2340 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $17133 r0 *1 667.52,246.96
X$17133 9264 9263 2247 2239 2240 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $17142 r0 *1 657.44,257.04
X$17142 9264 9263 2387 2240 2341 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $17150 m0 *1 715.68,367.92
X$17150 9264 9263 2243 3436 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $17152 r0 *1 700,357.84
X$17152 9264 2243 2292 3434 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17156 r0 *1 703.92,317.52
X$17156 9264 2996 3052 2243 2757 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $17158 r0 *1 703.36,246.96
X$17158 9264 9263 2295 2293 2244 2243 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $17161 r0 *1 722.4,257.04
X$17161 9264 9263 2391 2393 2345 2244 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $17168 m0 *1 726.88,267.12
X$17168 9264 2246 2244 2292 2391 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $17193 m0 *1 638.4,932.4
X$17193 9264 2246 8118 8527 8787 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $17196 r0 *1 675.36,418.32
X$17196 9264 3809 2292 3894 2246 9263 gf180mcu_fd_sc_mcu9t5v0__dffsnq_4
* cell instance $17198 r0 *1 706.72,378
X$17198 2499 9263 2246 2997 9264 3557 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $17203 r0 *1 759.92,982.8
X$17203 9264 9178 2246 9263 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $17205 r0 *1 851.2,730.8
X$17205 9264 2246 7253 6313 7375 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17207 m0 *1 609.84,619.92
X$17207 9264 2246 6301 4653 6277 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $17209 m0 *1 635.04,599.76
X$17209 9264 2246 4624 4653 5973 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $17760 r0 *1 799.12,932.4
X$17760 9264 2246 7774 8374 8848 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17762 m0 *1 845.6,851.76
X$17762 9264 2246 8272 8019 8416 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17764 r0 *1 849.52,579.6
X$17764 9264 2246 5294 4626 5857 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17766 m0 *1 748.16,932.4
X$17766 9264 2246 8846 8741 8845 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17768 r0 *1 899.36,519.12
X$17768 9264 2246 4928 4563 5148 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17770 m0 *1 897.12,529.2
X$17770 9264 2246 4564 4563 5079 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17773 m0 *1 887.6,509.04
X$17773 9264 2246 4491 2292 4780 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17776 r0 *1 899.36,498.96
X$17776 9264 2246 4342 2292 4779 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17778 r0 *1 837.76,902.16
X$17778 9264 2246 8339 8374 8706 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17780 m0 *1 841.68,579.6
X$17780 9264 2246 5720 4626 5736 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17782 m0 *1 831.6,902.16
X$17782 9264 2246 7716 8374 8705 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17785 r0 *1 850.64,670.32
X$17785 9264 2246 6687 6313 6796 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17787 m0 *1 952.56,579.6
X$17787 9264 2246 5780 4563 5783 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17789 r0 *1 210,690.48
X$17789 9264 2246 6951 6663 7076 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17791 m0 *1 843.36,640.08
X$17791 9264 2246 6410 6313 6494 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17793 m0 *1 809.76,982.8
X$17793 9264 2246 9141 8374 9060 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17795 r0 *1 211.68,680.4
X$17795 9264 2246 6579 6663 6952 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17797 m0 *1 756.56,660.24
X$17797 9264 2246 6239 6313 6638 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17799 r0 *1 955.36,539.28
X$17799 9264 2246 5290 4563 5289 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17801 r0 *1 781.76,952.56
X$17801 9264 2246 8942 8741 8973 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17803 r0 *1 969.36,549.36
X$17803 9264 2246 5425 4563 5424 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17805 r0 *1 742,952.56
X$17805 9264 2246 8971 8741 8943 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17807 m0 *1 844.48,982.8
X$17807 9264 2246 9104 8019 9105 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17809 m0 *1 838.88,972.72
X$17809 9264 2246 9103 8374 9062 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17811 r0 *1 842.24,972.72
X$17811 9264 2246 9167 8019 9063 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17814 r0 *1 830.48,498.96
X$17814 9264 2246 4343 4626 4707 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17816 m0 *1 204.96,781.2
X$17816 9264 2246 6166 6663 7878 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17818 m0 *1 873.04,609.84
X$17818 9264 2246 5636 4626 6095 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17820 m0 *1 894.32,882
X$17820 9264 2246 8066 8019 8673 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17822 r0 *1 968.8,529.2
X$17822 9264 2246 4772 4563 5139 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17824 r0 *1 763.28,942.48
X$17824 9264 2246 8915 8741 8914 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17827 m0 *1 204.4,700.56
X$17827 9264 2246 7036 6663 7131 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17829 m0 *1 961.52,609.84
X$17829 9264 2246 6164 4563 6098 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17831 m0 *1 953.12,599.76
X$17831 9264 2246 5981 4563 6034 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17833 m0 *1 754.32,509.04
X$17833 9264 2246 4505 4653 4766 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17836 r0 *1 747.04,498.96
X$17836 9264 2246 4489 4653 4488 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17838 m0 *1 230.16,720.72
X$17838 9264 2246 6753 6663 7317 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17840 m0 *1 203.28,710.64
X$17840 9264 2246 6192 6663 7193 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17843 r0 *1 959.28,559.44
X$17843 9264 2246 5557 4563 5556 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17845 m0 *1 779.52,509.04
X$17845 9264 2246 4436 4653 4784 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17847 r0 *1 785.68,509.04
X$17847 9264 2246 4227 4653 4864 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17850 r0 *1 794.08,861.84
X$17850 9264 2246 8147 8374 8533 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17852 r0 *1 800.24,942.48
X$17852 9264 2246 8192 8374 8850 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17855 r0 *1 819.28,942.48
X$17855 9264 2246 7752 8374 8851 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17857 r0 *1 841.68,569.52
X$17857 9264 2246 5635 4626 5735 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17859 m0 *1 232.96,690.48
X$17859 9264 2246 6748 6663 7013 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17862 r0 *1 925.12,589.68
X$17862 9264 2246 5291 4563 5924 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17864 r0 *1 816.48,529.2
X$17864 9264 2246 4709 4626 5073 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17866 m0 *1 923.44,619.92
X$17866 9264 2246 5920 6315 6253 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17868 r0 *1 831.6,619.92
X$17868 9264 2246 6103 6313 6244 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17870 m0 *1 932.4,609.84
X$17870 9264 2246 5847 4563 6036 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17872 m0 *1 834.96,730.8
X$17872 9264 2246 7353 6313 7428 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17874 m0 *1 819.84,972.72
X$17874 9264 2246 9012 8374 9011 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17876 r0 *1 816.48,972.72
X$17876 9264 2246 9102 8374 9061 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17879 m0 *1 927.92,599.76
X$17879 9264 2246 5135 4563 5985 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17881 r0 *1 734.16,932.4
X$17881 9264 2246 8878 8741 8885 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17883 r0 *1 744.8,660.24
X$17883 9264 2246 6590 6313 6722 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17886 r0 *1 924,509.04
X$17886 9264 2246 4431 4563 4943 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17889 r0 *1 819.28,861.84
X$17889 9264 2246 8427 8374 8506 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17891 r0 *1 968.8,509.04
X$17891 9264 2246 4714 4563 4868 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17893 m0 *1 800.24,972.72
X$17893 9264 2246 9059 8374 9058 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17895 r0 *1 904.4,871.92
X$17895 9264 2246 8262 8019 8603 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17898 m0 *1 928.48,509.04
X$17898 9264 2246 4384 4563 4866 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17900 r0 *1 820.96,670.32
X$17900 9264 2246 6835 6313 6836 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17902 m0 *1 847.28,650.16
X$17902 9264 2246 6599 6313 6600 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17904 r0 *1 771.12,549.36
X$17904 9264 2246 5367 4653 5453 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17907 r0 *1 809.76,519.12
X$17907 9264 2246 4708 4626 5161 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17909 r0 *1 845.04,700.56
X$17909 9264 2246 7026 6313 7138 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17911 r0 *1 757.68,912.24
X$17911 9264 2246 8247 8741 8807 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17913 m0 *1 756.56,922.32
X$17913 9264 2246 8208 8741 8762 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17915 r0 *1 746.48,720.72
X$17915 9264 2246 7090 6313 7303 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17917 r0 *1 879.2,519.12
X$17917 9264 2246 4770 4626 5149 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17919 r0 *1 865.2,599.76
X$17919 9264 2246 5928 4626 6028 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17922 r0 *1 912.8,529.2
X$17922 9264 2246 5010 4563 5145 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17924 r0 *1 783.44,529.2
X$17924 9264 2246 4704 4653 5163 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17926 m0 *1 948.64,529.2
X$17926 9264 2246 5011 4563 5084 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17929 r0 *1 826.56,690.48
X$17929 9264 2246 6936 6313 7008 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17931 r0 *1 207.2,660.24
X$17931 9264 2246 5808 6663 6702 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17934 r0 *1 227.36,710.64
X$17934 9264 2246 6953 6663 7218 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17936 m0 *1 943.6,519.12
X$17936 9264 2246 4496 4563 4941 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17938 m0 *1 865.76,529.2
X$17938 9264 2246 4768 4626 5078 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17941 r0 *1 790.16,882
X$17941 9264 2246 8248 8374 8597 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17943 m0 *1 969.36,529.2
X$17943 9264 2246 4929 4563 5080 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17945 r0 *1 784,569.52
X$17945 9264 2246 4716 4653 5703 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17947 m0 *1 953.68,559.44
X$17947 9264 2246 5492 4563 5499 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17949 r0 *1 944.16,589.68
X$17949 9264 2246 5717 4563 5925 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17952 r0 *1 931.84,559.44
X$17952 9264 2246 5554 4563 5553 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17954 r0 *1 770,972.72
X$17954 9264 2246 9100 8741 9099 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17957 m0 *1 752.08,882
X$17957 9264 2246 8009 8374 8622 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17959 m0 *1 740.88,982.8
X$17959 9264 2246 9098 8741 9140 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17961 r0 *1 811.44,579.6
X$17961 9264 2246 5707 4626 5706 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17963 r0 *1 749.84,972.72
X$17963 9264 2246 9065 8741 9147 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17966 r0 *1 841.68,589.68
X$17966 9264 2246 4501 4626 5845 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17968 r0 *1 852.32,882
X$17968 9264 2246 8010 8374 8601 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17970 r0 *1 758.8,529.2
X$17970 9264 2246 4924 4653 5072 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17972 m0 *1 751.52,972.72
X$17972 9264 2246 9054 8741 9010 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17974 m0 *1 840,932.4
X$17974 9264 2246 7970 8374 8853 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17976 r0 *1 850.64,942.48
X$17976 9264 2246 8916 8019 8918 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17979 m0 *1 967.68,589.68
X$17979 9264 2246 5927 4563 5929 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17981 m0 *1 827.12,942.48
X$17981 9264 2246 8250 8374 8852 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17983 m0 *1 923.44,539.28
X$17983 9264 2246 4771 4563 5225 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17985 r0 *1 781.2,962.64
X$17985 9264 2246 9057 8741 9056 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17987 m0 *1 913.36,569.52
X$17987 9264 2246 5423 4626 5728 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17989 m0 *1 836.64,519.12
X$17989 9264 2246 4711 4626 4925 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17991 m0 *1 854.56,942.48
X$17991 9264 2246 8917 8019 8881 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17993 m0 *1 846.72,529.2
X$17993 9264 2246 4712 4626 5076 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17996 r0 *1 754.32,882
X$17996 9264 2246 8127 8374 8557 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17998 r0 *1 752.64,539.28
X$17998 9264 2246 5213 4653 5301 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18000 r0 *1 834.96,519.12
X$18000 9264 2246 4710 4626 5008 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18002 r0 *1 931.84,529.2
X$18002 9264 2246 5134 4563 5133 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18004 m0 *1 217.28,730.8
X$18004 9264 2246 7096 6663 7363 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18006 m0 *1 771.12,539.28
X$18006 9264 2246 4705 4653 5238 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18009 r0 *1 833.28,640.08
X$18009 9264 2246 6551 6313 6550 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18011 r0 *1 225.12,750.96
X$18011 9264 2246 7134 6663 7594 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18013 m0 *1 804.16,579.6
X$18013 9264 2246 5705 4626 5795 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18015 r0 *1 780.08,932.4
X$18015 9264 2246 8214 8741 8879 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18017 r0 *1 875.84,529.2
X$18017 9264 2246 4927 4626 5151 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18019 r0 *1 213.36,761.04
X$18019 9264 2246 7252 6663 7666 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18022 m0 *1 204.4,660.24
X$18022 9264 2246 5878 6663 6649 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18024 m0 *1 800.8,529.2
X$18024 9264 2246 4767 4626 5162 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18027 m0 *1 210,670.32
X$18027 9264 2246 6693 6663 6747 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18029 r0 *1 855.68,932.4
X$18029 9264 2246 8880 8019 8854 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18031 m0 *1 779.52,932.4
X$18031 9264 2246 8072 8741 8847 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18033 r0 *1 928.48,569.52
X$18033 9264 2246 5555 4563 5716 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18035 r0 *1 790.72,972.72
X$18035 9264 2246 9101 8374 9107 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18038 m0 *1 867.44,922.32
X$18038 9264 2246 8187 8019 8827 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18040 r0 *1 868,912.24
X$18040 9264 2246 8279 8019 8799 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18042 m0 *1 810.32,922.32
X$18042 9264 2246 8120 8374 8828 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18044 m0 *1 224.56,771.12
X$18044 9264 2246 7316 6663 7730 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18046 r0 *1 969.36,569.52
X$18046 9264 2246 5719 4563 5718 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18048 r0 *1 272.16,892.08
X$18048 9264 2246 8174 7442 8675 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18050 m0 *1 562.24,660.24
X$18050 9264 2246 5077 6485 6675 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18052 m0 *1 572.32,640.08
X$18052 9264 2246 3831 6485 6572 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18054 m0 *1 547.68,680.4
X$18054 9264 2246 6774 6485 6826 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18057 r0 *1 549.36,851.76
X$18057 9264 2246 8333 8058 8512 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18059 r0 *1 353.36,922.32
X$18059 9264 2246 8836 8436 8814 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18062 r0 *1 593.6,841.68
X$18062 9264 2246 7796 8058 8431 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18065 r0 *1 599.2,640.08
X$18065 9264 2246 6487 6485 6539 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18067 m0 *1 253.12,902.16
X$18067 9264 2246 8713 8707 8733 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18070 r0 *1 249.2,892.08
X$18070 9264 2246 8656 8707 8655 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18072 r0 *1 588,871.92
X$18072 9264 2246 7748 8058 8524 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18075 r0 *1 604.8,882
X$18075 9264 2246 7799 8527 8589 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18077 m0 *1 252,871.92
X$18077 9264 2246 8111 7442 8515 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18079 r0 *1 557.76,871.92
X$18079 9264 2246 7571 8058 8551 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18082 m0 *1 487.76,861.84
X$18082 9264 2246 8237 8058 8486 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18084 m0 *1 492.24,841.68
X$18084 9264 2246 8239 8058 8351 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18086 r0 *1 530.32,861.84
X$18086 9264 2246 7942 8058 8522 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18088 m0 *1 310.8,912.24
X$18088 9264 2246 8053 8707 8767 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18090 r0 *1 509.6,861.84
X$18090 9264 2246 7745 8058 8487 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18092 r0 *1 321.44,892.08
X$18092 9264 2246 8037 8436 8659 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18094 r0 *1 439.04,801.36
X$18094 9264 2246 7886 6485 8055 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18096 m0 *1 570.64,831.6
X$18096 9264 2246 7676 8058 8322 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18098 r0 *1 556.08,831.6
X$18098 9264 2246 8002 8058 8332 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18100 m0 *1 570.64,851.76
X$18100 9264 2246 8406 8058 8407 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18102 r0 *1 332.08,922.32
X$18102 9264 2246 8811 8707 8810 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18106 r0 *1 306.88,912.24
X$18106 9264 2246 8226 8707 8742 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18108 m0 *1 296.8,902.16
X$18108 9264 2246 8054 8707 8658 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18110 m0 *1 329.84,902.16
X$18110 9264 2246 7945 8436 8660 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18113 r0 *1 350,902.16
X$18113 9264 2246 7996 8436 8735 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18115 r0 *1 249.2,952.56
X$18115 9264 2246 8954 8707 8953 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18117 m0 *1 580.16,952.56
X$18117 9264 2246 8909 8058 8908 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18119 m0 *1 580.16,932.4
X$18119 9264 2246 8840 8058 8860 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18122 m0 *1 710.08,337.68
X$18122 9264 2246 2496 2292 3142 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18125 r0 *1 721.84,317.52
X$18125 9264 2246 2995 2292 3051 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18127 r0 *1 545.44,932.4
X$18127 9264 2246 8839 8777 8893 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18130 r0 *1 579.6,942.48
X$18130 9264 2246 8907 8527 8923 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18132 m0 *1 241.36,932.4
X$18132 9264 2246 8831 8707 8855 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18135 r0 *1 501.76,962.64
X$18135 9264 2246 9000 8777 9022 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18137 r0 *1 500.64,972.72
X$18137 9264 2246 9089 8777 9131 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18139 m0 *1 502.32,972.72
X$18139 9264 2246 9090 8777 9157 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18141 r0 *1 525.28,972.72
X$18141 9264 2246 9132 8777 9158 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18143 m0 *1 534.24,972.72
X$18143 9264 2246 9036 8777 9035 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18146 r0 *1 575.68,972.72
X$18146 9264 2246 9093 8777 9092 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18149 r0 *1 594.72,972.72
X$18149 9264 2246 9005 8058 9004 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18152 m0 *1 600.32,972.72
X$18152 9264 2246 9042 8527 9041 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18154 m0 *1 560,972.72
X$18154 9264 2246 9091 8777 9037 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18157 r0 *1 560.56,942.48
X$18157 9264 2246 8906 8058 8924 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18159 m0 *1 568.4,962.64
X$18159 9264 2246 9003 8777 8964 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18161 r0 *1 553.84,952.56
X$18161 9264 2246 8936 8777 8987 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18163 r0 *1 556.64,972.72
X$18163 9264 2246 9135 8777 9160 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18165 m0 *1 552.72,982.8
X$18165 9264 2246 9133 8777 9159 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18167 r0 *1 528.64,892.08
X$18167 9264 2246 8178 8058 8666 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18170 r0 *1 252,922.32
X$18170 9264 2246 8832 8707 8856 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18173 r0 *1 278.88,902.16
X$18173 9264 2246 7944 7442 8714 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18176 r0 *1 271.04,922.32
X$18176 9264 2246 8833 8707 8857 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18179 m0 *1 482.72,882
X$18179 9264 2246 7515 8058 8618 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18182 r0 *1 559.44,922.32
X$18182 9264 2246 7673 8058 8783 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18184 m0 *1 570.08,922.32
X$18184 9264 2246 7963 8058 8784 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18186 r0 *1 599.2,912.24
X$18186 9264 2246 7798 8527 8785 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18189 m0 *1 575.68,912.24
X$18189 9264 2246 7843 8058 8773 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18191 m0 *1 265.44,952.56
X$18191 9264 2246 8926 8707 8925 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18193 m0 *1 502.32,942.48
X$18193 9264 2246 8869 8777 8838 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18195 m0 *1 534.24,942.48
X$18195 9264 2246 8905 8777 8871 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18198 m0 *1 274.96,962.64
X$18198 9264 2246 8956 8707 8955 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18201 m0 *1 530.88,952.56
X$18201 9264 2246 8935 8777 8950 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18203 r0 *1 505.68,932.4
X$18203 9264 2246 8870 8777 8892 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18205 r0 *1 521.36,942.48
X$18205 9264 2246 8904 8777 8903 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18207 m0 *1 294,962.64
X$18207 9264 2246 8988 8707 9064 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18210 m0 *1 497.28,952.56
X$18210 9264 2246 8934 8777 8933 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18212 m0 *1 488.32,912.24
X$18212 9264 2246 8778 8777 8747 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18214 m0 *1 487.2,902.16
X$18214 9264 2246 8287 8470 8686 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18216 m0 *1 285.6,932.4
X$18216 9264 2246 8809 8707 8834 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18218 m0 *1 542.64,922.32
X$18218 9264 2246 8177 8058 8782 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18220 m0 *1 540.96,912.24
X$18220 9264 2246 7909 8058 8719 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18223 m0 *1 522.48,922.32
X$18223 9264 2246 8781 8777 8780 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18225 m0 *1 517.44,902.16
X$18225 9264 2246 7962 8058 8687 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18227 m0 *1 503.44,922.32
X$18227 9264 2246 8238 8777 8779 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18229 r0 *1 655.76,821.52
X$18229 9264 2246 8291 6914 8325 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18232 r0 *1 277.2,821.52
X$18232 9264 2246 7978 7442 8284 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18234 r0 *1 399.28,851.76
X$18234 9264 2246 7997 8436 8508 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18236 m0 *1 663.04,660.24
X$18236 9264 2246 6591 6313 6633 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18238 m0 *1 746.48,468.72
X$18238 9264 2246 4336 3974 4265 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18240 r0 *1 747.04,468.72
X$18240 9264 2246 4337 3974 4335 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18242 m0 *1 286.72,801.36
X$18242 9264 2246 7951 7442 8092 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18245 m0 *1 742.56,498.96
X$18245 9264 2246 4625 4653 4651 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18248 m0 *1 636.16,650.16
X$18248 9264 2246 6488 4653 6575 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18250 m0 *1 616.56,670.32
X$18250 9264 2246 5641 6485 6811 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18252 m0 *1 616,660.24
X$18252 9264 2246 5014 6485 6631 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18255 m0 *1 850.64,498.96
X$18255 9264 2246 4226 4626 4628 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18258 m0 *1 838.88,488.88
X$18258 9264 2246 4338 4626 4490 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18260 r0 *1 827.68,488.88
X$18260 9264 2246 4180 4626 4649 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18262 m0 *1 380.8,851.76
X$18262 9264 2246 8328 8436 8395 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18264 r0 *1 241.92,821.52
X$18264 9264 2246 7896 7442 8221 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18266 r0 *1 700,831.6
X$18266 9264 2246 8373 6914 8348 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18268 r0 *1 716.8,488.88
X$18268 9264 2246 4485 3974 4514 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18270 m0 *1 243.6,841.68
X$18270 9264 2246 8173 7442 8419 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18272 r0 *1 806.4,488.88
X$18272 9264 2246 4272 4626 4650 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18274 r0 *1 609.84,821.52
X$18274 9264 2246 7629 6914 8244 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18276 m0 *1 289.52,831.6
X$18276 9264 2246 8165 7442 8270 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18279 m0 *1 262.08,821.52
X$18279 9264 2246 8046 7442 8266 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18282 r0 *1 729.68,650.16
X$18282 9264 2246 6498 6313 6595 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18284 r0 *1 613.2,851.76
X$18284 9264 2246 8246 6914 8443 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18286 m0 *1 638.96,841.68
X$18286 9264 2246 8040 6914 8367 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18288 r0 *1 367.36,851.76
X$18288 9264 2246 8052 8436 8507 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18290 m0 *1 810.32,498.96
X$18290 9264 2246 4273 4626 4627 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18292 m0 *1 233.52,761.04
X$18292 9264 2246 7217 6663 7695 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18294 r0 *1 319.2,761.04
X$18294 9264 2246 7101 7442 7701 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18297 r0 *1 329.28,771.12
X$18297 9264 2246 7326 7442 7732 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18299 m0 *1 295.68,761.04
X$18299 9264 2246 7441 6663 7699 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18301 r0 *1 310.24,771.12
X$18301 9264 2246 7731 7442 7828 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18303 m0 *1 674.24,740.88
X$18303 9264 2246 7452 6914 7491 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18306 m0 *1 683.76,720.72
X$18306 9264 2246 7238 6914 7272 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18309 r0 *1 673.68,720.72
X$18309 9264 2246 7119 6914 7301 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18311 m0 *1 275.52,761.04
X$18311 9264 2246 7285 6663 7645 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18313 r0 *1 715.12,710.64
X$18313 9264 2246 7176 6313 7212 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18316 r0 *1 310.8,791.28
X$18316 9264 2246 7994 7442 8136 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18318 r0 *1 267.12,761.04
X$18318 9264 2246 7075 6663 7698 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18320 r0 *1 643.44,680.4
X$18320 9264 2246 6775 6485 6912 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18323 r0 *1 448.56,841.68
X$18323 9264 2246 7957 8470 8387 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18326 m0 *1 422.24,851.76
X$18326 9264 2246 7954 8470 8426 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18329 m0 *1 440.72,861.84
X$18329 9264 2246 7905 8470 8483 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18331 m0 *1 656.32,700.56
X$18331 9264 2246 6882 6914 7064 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18333 r0 *1 243.04,801.36
X$18333 9264 2246 7999 7442 8043 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18335 m0 *1 659.12,680.4
X$18335 9264 2246 6718 6914 6856 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18337 m0 *1 440.16,831.6
X$18337 9264 2246 7855 6485 8285 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18339 r0 *1 277.76,781.2
X$18339 9264 2246 7668 6663 7927 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18341 r0 *1 660.8,750.96
X$18341 9264 2246 7578 6914 7609 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18343 r0 *1 348.32,750.96
X$18343 9264 2246 6754 7442 7647 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18345 m0 *1 234.08,781.2
X$18345 9264 2246 7729 6663 7824 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18347 r0 *1 419.44,821.52
X$18347 9264 2246 8156 8436 8315 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18349 r0 *1 618.8,690.48
X$18349 9264 2246 6829 6485 7000 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18351 r0 *1 234.64,781.2
X$18351 9264 2246 7783 6663 7893 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18354 r0 *1 348.32,851.76
X$18354 9264 2246 7899 8436 8465 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18356 m0 *1 600.32,801.36
X$18356 9264 2246 7797 6914 8005 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18359 r0 *1 530.32,761.04
X$18359 9264 2246 6825 6485 7672 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18362 r0 *1 949.2,488.88
X$18362 9264 2246 4432 4563 4492 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18364 m0 *1 950.88,498.96
X$18364 9264 2246 4379 4563 4631 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18367 r0 *1 969.36,488.88
X$18367 9264 2246 4435 4563 4495 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18369 m0 *1 969.92,498.96
X$18369 9264 2246 4565 4563 4717 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18371 m0 *1 307.44,851.76
X$18371 9264 2246 8228 7442 8391 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18373 r0 *1 723.52,428.4
X$18373 9264 2246 3975 3974 3976 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18375 m0 *1 311.92,861.84
X$18375 9264 2246 8434 7442 8505 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18377 r0 *1 565.6,801.36
X$18377 9264 2246 7907 8058 8059 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18379 m0 *1 526.4,730.8
X$18379 9264 2246 6743 6485 7341 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18381 r0 *1 330.4,841.68
X$18381 9264 2246 8057 7442 8355 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18384 m0 *1 580.16,690.48
X$18384 9264 2246 6827 6485 6971 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18387 m0 *1 518.56,680.4
X$18387 9264 2246 6824 6521 6823 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18390 r0 *1 342.72,892.08
X$18390 9264 2246 8227 8436 8677 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18392 m0 *1 525.84,710.64
X$18392 9264 2246 7060 6485 7169 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18394 m0 *1 537.04,831.6
X$18394 9264 2246 8235 8058 8320 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18397 r0 *1 525.28,831.6
X$18397 9264 2246 8003 8058 8388 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18399 r0 *1 501.2,771.12
X$18399 9264 2246 7570 6485 7742 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18401 r0 *1 728,448.56
X$18401 9264 2246 4178 3974 4184 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18403 r0 *1 679.84,851.76
X$18403 9264 2246 7806 6914 8475 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18405 r0 *1 270.48,861.84
X$18405 9264 2246 7958 7442 8503 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18407 r0 *1 711.76,458.64
X$18407 9264 2246 4264 3974 4220 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18410 r0 *1 566.72,730.8
X$18410 9264 2246 6932 6485 7387 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18412 r0 *1 705.6,851.76
X$18412 9264 2246 8031 6914 8494 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18415 r0 *1 673.12,619.92
X$18415 9264 2246 5643 4653 6306 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18418 m0 *1 240.8,851.76
X$18418 9264 2246 8104 7442 8460 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18420 r0 *1 679.28,841.68
X$18420 9264 2246 8372 6914 8371 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18422 r0 *1 675.92,831.6
X$18422 9264 2246 8334 6914 8349 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18424 m0 *1 554.96,761.04
X$18424 9264 2246 7575 6485 7720 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18429 r0 *1 567.28,781.2
X$18429 9264 2246 7859 6485 7910 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18431 m0 *1 726.32,428.4
X$18431 9264 2246 3892 3974 3891 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18433 m0 *1 929.04,498.96
X$18433 9264 2246 4494 4563 4641 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18435 r0 *1 856.8,488.88
X$18435 9264 2246 4378 2292 4562 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18437 m0 *1 338.8,821.52
X$18437 9264 2246 8167 7442 8225 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18439 m0 *1 546.56,740.88
X$18439 9264 2246 7055 6485 7552 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18441 r0 *1 565.04,700.56
X$18441 9264 2246 5771 6485 7214 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18443 m0 *1 309.68,831.6
X$18443 9264 2246 8051 7442 8309 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18446 m0 *1 870.8,498.96
X$18446 9264 2246 4228 2292 4629 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18449 r0 *1 234.08,700.56
X$18449 9264 2246 6703 6663 7195 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18451 m0 *1 400.96,912.24
X$18451 9264 2246 8716 8436 8715 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18453 m0 *1 969.36,740.88
X$18453 9264 2246 7361 7127 7467 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18455 r0 *1 955.92,710.64
X$18455 9264 2246 7249 7127 7248 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18458 m0 *1 901.04,851.76
X$18458 9264 2246 8459 8019 8458 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18460 m0 *1 961.52,730.8
X$18460 9264 2246 7360 7127 7362 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18463 r0 *1 968.8,811.44
X$18463 9264 2246 8263 8019 8264 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18466 r0 *1 404.32,912.24
X$18466 9264 2246 8775 8470 8743 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18468 m0 *1 868,861.84
X$18468 9264 2246 8078 8019 8531 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18470 r0 *1 276.64,690.48
X$18470 9264 2246 6750 6663 6977 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18473 r0 *1 387.52,922.32
X$18473 9264 2246 8837 8436 8816 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18475 m0 *1 409.92,902.16
X$18475 9264 2246 8685 8470 8708 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18478 r0 *1 904.96,841.68
X$18478 9264 2246 8376 8019 8378 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18481 r0 *1 249.76,680.4
X$18481 9264 2246 6665 6663 6860 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18483 m0 *1 406,932.4
X$18483 9264 2246 8865 8470 8859 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18485 r0 *1 279.44,720.72
X$18485 9264 2246 6749 6663 7280 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18487 r0 *1 417.2,952.56
X$18487 9264 2246 8963 8470 8979 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18489 m0 *1 336.56,710.64
X$18489 9264 2246 7155 6521 7154 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18491 m0 *1 408.8,942.48
X$18491 9264 2246 8866 8470 8886 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18493 r0 *1 969.36,680.4
X$18493 9264 2246 6950 6315 6897 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18495 r0 *1 899.36,710.64
X$18495 9264 2246 7128 7127 7247 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18497 r0 *1 841.68,821.52
X$18497 9264 2246 7679 8019 8313 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18499 m0 *1 239.12,740.88
X$18499 9264 2246 6619 6663 7471 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18502 r0 *1 941.92,831.6
X$18502 9264 2246 8345 8019 8346 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18505 m0 *1 929.6,821.52
X$18505 9264 2246 7889 8019 8265 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18507 m0 *1 926.8,811.44
X$18507 9264 2246 8131 8019 8085 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18509 r0 *1 924,690.48
X$18509 9264 2246 6938 6315 7015 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18511 r0 *1 967.12,700.56
X$18511 9264 2246 6901 6315 7129 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18513 m0 *1 969.36,710.64
X$18513 9264 2246 7188 7127 7194 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18515 m0 *1 946.96,690.48
X$18515 9264 2246 6949 6315 6948 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18517 m0 *1 961.52,841.68
X$18517 9264 2246 8377 8019 8418 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18519 m0 *1 946.96,700.56
X$18519 9264 2246 7074 6315 7130 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18521 m0 *1 961.52,831.6
X$18521 9264 2246 8303 8019 8306 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18523 r0 *1 939.12,740.88
X$18523 9264 2246 7423 7127 7535 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18526 r0 *1 918.96,720.72
X$18526 9264 2246 7313 7127 7366 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18528 r0 *1 917.28,740.88
X$18528 9264 2246 7411 7127 7474 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18531 m0 *1 944.16,740.88
X$18531 9264 2246 7359 7127 7472 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18533 m0 *1 837.76,821.52
X$18533 9264 2246 7636 7127 8258 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18535 m0 *1 922.88,700.56
X$18535 9264 2246 7066 7127 7133 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18537 m0 *1 943.04,720.72
X$18537 9264 2246 7314 7127 7318 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18539 m0 *1 374.08,882
X$18539 9264 2246 7947 8436 8609 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18541 m0 *1 403.76,892.08
X$18541 9264 2246 7900 8470 8678 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18544 m0 *1 703.36,549.36
X$18544 9264 2246 5128 4653 5210 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18546 r0 *1 725.76,549.36
X$18546 9264 2246 4863 4653 5332 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18548 m0 *1 864.08,791.28
X$18548 9264 2246 7812 7127 7929 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18550 r0 *1 879.2,791.28
X$18550 9264 2246 7923 7127 7925 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18552 r0 *1 269.36,650.16
X$18552 9264 2246 6451 6521 6651 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18554 r0 *1 879.2,821.52
X$18554 9264 2246 7918 8019 8311 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18556 r0 *1 367.92,912.24
X$18556 9264 2246 8774 8436 8801 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18558 r0 *1 856.8,841.68
X$18558 9264 2246 8018 8019 8423 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18560 m0 *1 292.88,670.32
X$18560 9264 2246 6623 6521 6751 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18563 r0 *1 280.56,670.32
X$18563 9264 2246 6618 6521 6814 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18565 r0 *1 912.24,811.44
X$18565 9264 2246 7821 8019 8083 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18568 r0 *1 262.08,660.24
X$18568 9264 2246 6705 6521 6731 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18570 m0 *1 263.2,660.24
X$18570 9264 2246 6556 6521 6652 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18572 r0 *1 234.64,650.16
X$18572 9264 2246 5226 6663 6617 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18574 m0 *1 239.12,660.24
X$18574 9264 2246 5518 6521 6694 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18577 m0 *1 361.76,892.08
X$18577 9264 2246 7952 8436 8661 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18580 r0 *1 233.52,670.32
X$18580 9264 2246 6704 6663 6795 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18582 m0 *1 872.48,811.44
X$18582 9264 2246 7591 8019 8082 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18585 m0 *1 380.8,892.08
X$18585 9264 2246 8155 8436 8684 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18588 m0 *1 866.32,670.32
X$18588 9264 2246 4926 6315 6790 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18590 r0 *1 471.52,932.4
X$18590 9264 2246 8868 8777 8890 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18592 r0 *1 873.04,640.08
X$18592 9264 2246 6495 6315 6552 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18594 m0 *1 402.64,972.72
X$18594 9264 2246 9031 8470 9068 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18597 r0 *1 928.48,640.08
X$18597 9264 2246 6505 6315 6567 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18600 r0 *1 915.6,650.16
X$18600 9264 2246 6603 6315 6650 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18603 r0 *1 907.76,660.24
X$18603 9264 2246 6688 6315 6727 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18605 r0 *1 407.68,972.72
X$18605 9264 2246 9128 8470 9032 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18607 r0 *1 965.44,670.32
X$18607 9264 2246 6843 6315 6842 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18610 m0 *1 922.32,680.4
X$18610 9264 2246 6844 6315 6845 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18612 r0 *1 946.4,670.32
X$18612 9264 2246 6841 6315 6840 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18615 r0 *1 946.96,650.16
X$18615 9264 2246 6648 6315 6689 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18617 r0 *1 451.36,962.64
X$18617 9264 2246 9034 8470 8998 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18619 m0 *1 758.8,861.84
X$18619 9264 2246 8032 8374 8449 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18621 r0 *1 479.36,972.72
X$18621 9264 2246 9087 8777 9156 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18623 m0 *1 469.84,972.72
X$18623 9264 2246 9088 8777 9154 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18625 r0 *1 927.92,660.24
X$18625 9264 2246 6647 6315 6646 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18627 m0 *1 732.48,861.84
X$18627 9264 2246 8338 8374 8495 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18629 m0 *1 968.8,660.24
X$18629 9264 2246 6604 6315 6690 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18631 r0 *1 771.12,841.68
X$18631 9264 2246 8296 8374 8428 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18634 m0 *1 479.36,962.64
X$18634 9264 2246 8999 8777 8986 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18636 m0 *1 470.96,952.56
X$18636 9264 2246 8932 8777 8952 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18638 m0 *1 897.68,650.16
X$18638 9264 2246 6592 6315 6602 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18640 m0 *1 929.04,670.32
X$18640 9264 2246 6728 6315 6793 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18642 m0 *1 450.24,942.48
X$18642 9264 2246 8867 8470 8888 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18644 r0 *1 423.36,942.48
X$18644 9264 2246 8901 8470 8900 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18646 r0 *1 427.84,972.72
X$18646 9264 2246 9085 8470 9033 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18648 m0 *1 421.68,972.72
X$18648 9264 2246 9084 8470 9071 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18651 r0 *1 448,972.72
X$18651 9264 2246 9130 8470 9129 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18653 m0 *1 448.56,972.72
X$18653 9264 2246 9021 8470 9086 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18655 r0 *1 899.36,630
X$18655 9264 2246 6249 6315 6450 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18657 m0 *1 431.2,952.56
X$18657 9264 2246 8951 8470 8931 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18659 m0 *1 872.48,720.72
X$18659 9264 2246 6887 6313 7255 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18661 m0 *1 968.24,640.08
X$18661 9264 2246 6386 6315 6555 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18663 r0 *1 312.48,740.88
X$18663 9264 2246 7392 7442 7390 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18666 r0 *1 879.2,720.72
X$18666 9264 2246 7312 7127 7370 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18668 r0 *1 381.36,962.64
X$18668 9264 2246 8996 8436 8995 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18670 m0 *1 380.8,972.72
X$18670 9264 2246 8962 8436 8961 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18673 r0 *1 374.08,972.72
X$18673 9264 2246 8994 8436 8993 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18675 r0 *1 373.52,942.48
X$18675 9264 2246 8898 8436 8897 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18678 r0 *1 968.24,640.08
X$18678 9264 2246 6499 6315 6559 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18680 r0 *1 301.28,720.72
X$18680 9264 2246 7282 7442 7281 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18682 m0 *1 945.84,640.08
X$18682 9264 2246 6497 6315 6496 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18684 m0 *1 918.96,630
X$18684 9264 2246 6026 6315 6396 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18686 r0 *1 392.56,942.48
X$18686 9264 2246 8899 8470 8948 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18689 m0 *1 376.32,942.48
X$18689 9264 2246 8864 8436 8884 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18691 r0 *1 450.8,942.48
X$18691 9264 2246 8902 8470 8922 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18693 m0 *1 841.12,761.04
X$18693 9264 2246 7412 7127 7585 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18696 m0 *1 365.68,932.4
X$18696 9264 2246 8815 8436 8858 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18699 r0 *1 304.08,700.56
X$18699 9264 2246 6752 6521 7200 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18701 m0 *1 946.4,630
X$18701 9264 2246 6385 6315 6384 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18703 m0 *1 883.68,690.48
X$18703 9264 2246 6886 6315 6946 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18705 r0 *1 840.56,781.2
X$18705 9264 2246 7680 7127 7868 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18707 r0 *1 304.64,972.72
X$18707 9264 2246 9124 8707 9123 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18709 r0 *1 639.52,922.32
X$18709 9264 2246 8117 8527 8820 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18711 r0 *1 322,962.64
X$18711 9264 2246 9027 8707 9015 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18714 r0 *1 665.84,902.16
X$18714 9264 2246 7805 8527 8771 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18716 r0 *1 664.72,932.4
X$18716 9264 2246 8891 8527 8875 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18718 m0 *1 663.04,932.4
X$18718 9264 2246 8876 8527 8889 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18721 m0 *1 302.4,972.72
X$18721 9264 2246 9026 8707 9025 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18723 r0 *1 661.36,922.32
X$18723 9264 2246 8842 8527 8829 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18725 m0 *1 617.12,871.92
X$18725 9264 2246 8184 8527 8526 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18727 m0 *1 324.24,952.56
X$18727 9264 2246 8920 8707 8895 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18729 r0 *1 308.56,952.56
X$18729 9264 2246 8975 8707 8957 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18732 r0 *1 309.68,932.4
X$18732 9264 2246 8861 8707 8882 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18735 m0 *1 818.72,841.68
X$18735 9264 2246 7862 8374 8343 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18737 m0 *1 307.44,942.48
X$18737 9264 2246 8919 8707 8894 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18739 m0 *1 615.44,922.32
X$18739 9264 2246 7749 8527 8786 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18741 m0 *1 626.08,902.16
X$18741 9264 2246 8116 8527 8692 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18743 m0 *1 670.32,599.76
X$18743 9264 2246 4862 4653 6063 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18746 m0 *1 609.84,982.8
X$18746 9264 2246 9040 8527 9137 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18749 r0 *1 950.32,619.92
X$18749 9264 2246 6316 6315 6248 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18752 r0 *1 648.48,972.72
X$18752 9264 2246 9095 8527 9115 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18755 r0 *1 645.68,962.64
X$18755 9264 2246 9046 8527 9072 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18757 m0 *1 637.84,982.8
X$18757 9264 2246 9138 8527 9007 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18759 r0 *1 327.04,972.72
X$18759 9264 2246 9081 8707 9080 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18761 r0 *1 608.72,932.4
X$18761 9264 2246 8872 8527 8841 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18764 r0 *1 627.76,932.4
X$18764 9264 2246 8874 8527 8873 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18767 m0 *1 348.32,972.72
X$18767 9264 2246 9029 8707 9028 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18769 r0 *1 969.36,619.92
X$18769 9264 2246 6250 6315 6317 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18772 r0 *1 665.28,952.56
X$18772 9264 2246 8969 8527 8980 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18774 r0 *1 646.24,952.56
X$18774 9264 2246 8968 8527 8985 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18776 r0 *1 352.24,972.72
X$18776 9264 2246 8991 8707 8990 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18779 r0 *1 624.96,972.72
X$18779 9264 2246 9073 8527 9044 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18782 m0 *1 622.16,972.72
X$18782 9264 2246 9045 8527 9006 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18784 m0 *1 636.72,952.56
X$18784 9264 2246 8938 8527 8937 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18787 r0 *1 614.88,952.56
X$18787 9264 2246 8967 8527 8966 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18789 r0 *1 610.4,942.48
X$18789 9264 2246 8911 8527 8910 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18791 r0 *1 670.32,871.92
X$18791 9264 2246 7860 8527 8592 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18794 r0 *1 273.28,972.72
X$18794 9264 2246 9121 8707 9143 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18796 m0 *1 272.72,972.72
X$18796 9264 2246 9079 8707 9024 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18798 r0 *1 703.36,871.92
X$18798 9264 2246 8189 6914 8530 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18800 m0 *1 726.88,882
X$18800 9264 2246 8336 8374 8570 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18802 r0 *1 724.08,922.32
X$18802 9264 2246 8337 8741 8822 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18805 r0 *1 705.04,922.32
X$18805 9264 2246 8123 8741 8821 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18807 m0 *1 730.24,912.24
X$18807 9264 2246 8294 8741 8697 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18809 m0 *1 327.04,932.4
X$18809 9264 2246 8862 8707 8883 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18812 m0 *1 707.84,912.24
X$18812 9264 2246 8070 8741 8759 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18814 m0 *1 351.12,952.56
X$18814 9264 2246 8929 8707 8928 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18817 r0 *1 355.04,952.56
X$18817 9264 2246 8959 8707 8976 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18819 m0 *1 646.8,892.08
X$18819 9264 2246 8185 8527 8669 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18821 r0 *1 330.4,952.56
X$18821 9264 2246 8958 8707 8927 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18824 m0 *1 648.48,871.92
X$18824 9264 2246 8062 8527 8528 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18826 m0 *1 682.64,902.16
X$18826 9264 2246 7753 8741 8695 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18829 m0 *1 346.64,932.4
X$18829 9264 2246 8835 8707 8812 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18832 r0 *1 948.08,781.2
X$18832 9264 2246 7926 7127 7875 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18834 m0 *1 968.24,801.36
X$18834 9264 2246 7973 8019 8021 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18836 r0 *1 967.12,801.36
X$18836 9264 2246 8132 8019 8086 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18838 r0 *1 794.08,831.6
X$18838 9264 2246 7863 8374 8316 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18840 m0 *1 644.56,589.68
X$18840 9264 2246 5491 4653 5835 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18842 r0 *1 952,761.04
X$18842 9264 2246 7691 7127 7764 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18845 r0 *1 960.4,750.96
X$18845 9264 2246 7592 7127 7643 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18847 r0 *1 932.96,761.04
X$18847 9264 2246 7690 7127 7689 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18850 m0 *1 969.36,781.2
X$18850 9264 2246 7877 7127 7876 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18852 m0 *1 919.52,801.36
X$18852 9264 2246 7916 8019 8020 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18854 r0 *1 920.64,781.2
X$18854 9264 2246 7865 7127 7874 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18856 r0 *1 946.4,801.36
X$18856 9264 2246 8022 8019 8090 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18858 m0 *1 959.84,771.12
X$18858 9264 2246 7692 7127 7765 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18860 m0 *1 918.96,771.12
X$18860 9264 2246 7688 7127 7687 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18862 m0 *1 921.76,750.96
X$18862 9264 2246 7409 7127 7421 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18864 m0 *1 860.72,761.04
X$18864 9264 2246 7517 7127 7530 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18867 r0 *1 320.88,670.32
X$18867 9264 2246 6622 6521 6815 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18870 r0 *1 876.96,750.96
X$18870 9264 2246 7520 7127 7588 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18872 m0 *1 300.72,660.24
X$18872 9264 2246 5496 6521 6732 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18874 m0 *1 329.84,680.4
X$18874 9264 2246 6706 6521 6816 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18876 r0 *1 309.68,660.24
X$18876 9264 2246 6609 6521 6733 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18879 m0 *1 913.92,761.04
X$18879 9264 2246 7580 7127 7644 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18881 r0 *1 473.76,922.32
X$18881 9264 2246 8830 8777 8819 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18883 r0 *1 409.92,871.92
X$18883 9264 2246 8482 8470 8545 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18886 r0 *1 315.84,650.16
X$18886 9264 2246 6287 6521 6620 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18888 m0 *1 674.8,952.56
X$18888 9264 2246 8939 8527 8945 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18891 m0 *1 698.32,972.72
X$18891 9264 2246 9051 8741 9009 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18893 m0 *1 692.16,962.64
X$18893 9264 2246 9008 8527 8940 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18896 m0 *1 465.36,871.92
X$18896 9264 2246 7670 8058 8572 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18898 r0 *1 710.08,942.48
X$18898 9264 2246 8912 8741 8921 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18900 m0 *1 727.44,962.64
X$18900 9264 2246 8913 8741 8944 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18902 r0 *1 720.72,952.56
X$18902 9264 2246 8972 8741 8941 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18904 m0 *1 685.44,932.4
X$18904 9264 2246 8844 8527 8843 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18907 r0 *1 701.12,952.56
X$18907 9264 2246 8970 8741 8978 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18910 r0 *1 700,932.4
X$18910 9264 2246 8877 8741 8887 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18912 m0 *1 449.68,912.24
X$18912 9264 2246 8776 8470 8769 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18915 m0 *1 449.68,922.32
X$18915 9264 2246 8817 8777 8805 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18917 m0 *1 430.64,922.32
X$18917 9264 2246 8818 8470 8804 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18919 r0 *1 468.16,902.16
X$18919 9264 2246 8718 8470 8717 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18921 m0 *1 717.36,972.72
X$18921 9264 2246 9097 8741 9067 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18923 r0 *1 700.56,972.72
X$18923 9264 2246 9050 8741 9049 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18925 r0 *1 423.36,912.24
X$18925 9264 2246 8746 8470 8802 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18928 m0 *1 967.68,750.96
X$18928 9264 2246 7531 7127 7593 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18931 m0 *1 454.16,902.16
X$18931 9264 2246 7935 8470 8662 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18933 m0 *1 676.48,982.8
X$18933 9264 2246 9048 8527 9047 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18935 r0 *1 441.28,882
X$18935 9264 2246 7903 8470 8637 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18938 r0 *1 460.88,892.08
X$18938 9264 2246 7904 8470 8663 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18940 r0 *1 679.84,972.72
X$18940 9264 2246 9096 8741 9112 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18942 m0 *1 420,912.24
X$18942 9264 2246 8745 8470 8744 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18944 r0 *1 720.72,972.72
X$18944 9264 2246 9053 8741 9052 9263 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $18969 r0 *1 356.72,246.96
X$18969 9263 2273 2253 9264 2307 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $18971 m0 *1 357.28,257.04
X$18971 9264 9263 2253 2328 2327 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $18984 r0 *1 22.96,317.52
X$18984 9264 9263 3019 2255 2886 2951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18989 m0 *1 66.64,367.92
X$18989 9264 2257 9263 3477 3155 2887 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $18995 m0 *1 58.24,378
X$18995 9264 3534 3571 3266 3523 2887 2257 9263
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $18998 r0 *1 66.08,378
X$18998 9264 2257 3155 9263 3534 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $19003 m0 *1 56,257.04
X$19003 9264 9263 2313 2258 2260 2350 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19010 m0 *1 83.44,267.12
X$19010 9264 9263 2702 2443 2260 2410 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $19014 r0 *1 63.84,267.12
X$19014 2314 9264 2260 2407 9263 2459 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $19023 r0 *1 115.92,246.96
X$19023 9263 2262 2261 2317 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $19027 m0 *1 120.96,257.04
X$19027 2261 9264 2262 9263 2357 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $19041 m0 *1 146.16,257.04
X$19041 9264 2263 2353 9263 2319 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $19043 r0 *1 179.76,267.12
X$19043 9264 9263 2415 2448 2267 2264 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19063 m0 *1 169.12,327.6
X$19063 9264 9263 3070 2960 2267 3055 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $19069 r0 *1 159.6,357.84
X$19069 9264 3367 3366 3270 9263 2267 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $19071 m0 *1 177.52,277.2
X$19071 9264 9263 2556 2532 2267 2465 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19076 r0 *1 203.28,267.12
X$19076 9264 9263 2269 2511 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19078 m0 *1 203.84,267.12
X$19078 9263 2416 2269 9264 2417 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19093 r0 *1 361.76,246.96
X$19093 9264 9263 2272 2273 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $19095 r0 *1 361.2,257.04
X$19095 9264 2480 2367 9263 2272 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $19099 r0 *1 355.6,448.56
X$19099 9264 4129 2273 3852 4035 4033 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $19101 m0 *1 364.56,448.56
X$19101 9264 2273 3962 4114 4041 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $19105 r0 *1 353.92,317.52
X$19105 9264 2972 2732 3010 3106 2841 2273 9263
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $19114 m0 *1 356.72,448.56
X$19114 9263 2273 9264 3671 4040 4035 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $19116 m0 *1 386.4,257.04
X$19116 9264 2274 2275 9263 2329 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $19121 r0 *1 455.84,267.12
X$19121 9264 9263 2521 2429 2430 2276 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19131 r0 *1 411.04,257.04
X$19131 9263 2372 9264 2665 2277 2373 2330 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $19138 m0 *1 432.32,257.04
X$19138 9264 2278 2354 9263 2375 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $19158 m0 *1 534.8,257.04
X$19158 9263 2337 2282 9264 2338 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19168 r0 *1 572.32,297.36
X$19168 9263 2802 9264 2745 2857 2597 2284 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $19170 r0 *1 571.2,327.6
X$19170 9264 3083 2764 3084 2992 2284 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $19186 m0 *1 584.64,378
X$19186 9264 2597 2285 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $19190 r0 *1 584.64,357.84
X$19190 9263 2285 3426 9264 3399 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19194 r0 *1 598.64,367.92
X$19194 9264 9263 2285 3482 3342 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19210 m0 *1 255.92,297.36
X$19210 9264 9263 2286 2728 2679 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19212 r0 *1 186.48,337.68
X$19212 9264 3164 9263 2286 3223 3165 3225 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $19215 r0 *1 166.32,337.68
X$19215 9263 2286 3027 9264 3207 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19217 m0 *1 165.76,347.76
X$19217 9264 9263 2286 3112 3027 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19230 m0 *1 206.08,337.68
X$19230 9264 3072 3167 2896 2286 9263 3318 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $19232 r0 *1 165.76,317.52
X$19232 9263 2959 9264 2958 2960 2286 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $19234 m0 *1 322.56,267.12
X$19234 9264 2365 2364 2355 2286 9263 2476 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $19236 m0 *1 313.6,267.12
X$19236 9264 9263 2470 2286 2324 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $19241 m0 *1 628.88,257.04
X$19241 2339 2300 2287 2397 2288 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19246 m0 *1 621.04,297.36
X$19246 9263 2749 2287 9264 2761 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19250 m0 *1 701.12,287.28
X$19250 2587 9263 2288 2645 9264 2646 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19252 m0 *1 701.12,297.36
X$19252 2697 9263 2288 2645 9264 2757 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19254 m0 *1 297.36,277.2
X$19254 9263 2288 2423 9264 2538 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19257 r0 *1 342.16,257.04
X$19257 9263 2288 2365 9264 2366 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19259 r0 *1 316.4,257.04
X$19259 9263 2288 2355 9264 2364 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19272 m0 *1 263.76,297.36
X$19272 9264 9263 2621 2288 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $19275 r0 *1 613.76,257.04
X$19275 9264 2385 2339 2300 2351 2288 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $19278 r0 *1 700,287.28
X$19278 9263 2644 2288 9264 2701 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19280 m0 *1 646.8,257.04
X$19280 9264 9263 2289 2290 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19286 r0 *1 647.36,267.12
X$19286 2289 9264 2342 9263 2495 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $19290 m0 *1 656.32,267.12
X$19290 9263 2289 9264 2395 2387 2435 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $19292 m0 *1 650.16,257.04
X$19292 9263 2341 9264 2342 2291 2290 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $19298 r0 *1 730.24,367.92
X$19298 9264 2292 9266 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $19307 r0 *1 700,367.92
X$19307 9264 2697 2292 3435 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $19309 r0 *1 700,347.76
X$19309 9264 2440 2292 3295 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $19314 m0 *1 680.4,388.08
X$19314 9264 2293 2292 3602 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $19319 r0 *1 622.72,408.24
X$19319 9264 3834 2292 3807 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $19321 m0 *1 675.92,398.16
X$19321 9264 3649 2292 3719 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $19323 m0 *1 679.28,287.28
X$19323 9264 2644 2292 2588 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $19326 r0 *1 664.72,287.28
X$19326 9264 2587 2292 2650 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $19357 m0 *1 730.24,378
X$19357 9264 3683 2292 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $19362 r0 *1 701.68,297.36
X$19362 2867 9264 9263 2293 2646 2806 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $19377 r0 *1 688.24,378
X$19377 9264 2293 3556 9263 3559 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $19382 m0 *1 30.8,367.92
X$19382 9263 2294 3155 9264 3437 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19385 m0 *1 29.68,347.76
X$19385 9263 9264 3062 3097 2294 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $19387 r0 *1 27.44,367.92
X$19387 2294 2717 3062 3155 9264 9263 3475 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $19389 m0 *1 19.04,367.92
X$19389 2406 9263 2294 2610 9264 3474 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19402 r0 *1 39.76,367.92
X$19402 9264 2717 2294 2311 3266 3062 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $19404 m0 *1 20.16,357.84
X$19404 9263 2406 2294 9264 3312 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19416 r0 *1 104.72,246.96
X$19416 9263 2315 2316 2297 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $19423 r0 *1 628.88,267.12
X$19423 2505 2433 2503 2299 9263 9264 2504 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $19428 r0 *1 602.56,257.04
X$19428 2300 2339 2352 9264 9263 2384 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $19433 r0 *1 623.84,267.12
X$19433 9263 2300 2339 9264 2493 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19450 m0 *1 227.36,257.04
X$19450 9264 2302 2303 9263 2322 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $19461 m0 *1 524.72,257.04
X$19461 9264 2336 2305 9263 2378 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $19464 m0 *1 535.92,267.12
X$19464 9264 9263 2306 2380 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19470 r0 *1 530.88,267.12
X$19470 9264 2306 2379 9263 2489 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $19503 m0 *1 88.48,347.76
X$19503 9264 9263 2311 3219 2462 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19505 r0 *1 36.96,378
X$19505 3558 9263 9264 2768 2311 3020 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $19507 r0 *1 36.4,357.84
X$19507 9264 3363 2952 3097 2883 2311 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $19522 r0 *1 33.04,337.68
X$19522 2311 2952 3097 2883 9263 9264 3264 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $19524 m0 *1 31.92,378
X$19524 2311 9264 2768 3020 9263 3519 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $19539 r0 *1 67.76,307.44
X$19539 9264 9263 2314 2888 2769 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19542 m0 *1 73.36,277.2
X$19542 9263 2314 2458 9264 2409 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19558 r0 *1 117.6,257.04
X$19558 9264 2394 2317 9263 2315 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $19562 m0 *1 106.96,267.12
X$19562 9263 2316 2315 9264 2411 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19574 r0 *1 152.32,277.2
X$19574 9264 9263 2318 2562 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19583 r0 *1 137.76,267.12
X$19583 9263 2414 2319 9264 2506 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19585 r0 *1 149.52,267.12
X$19585 2414 9264 2319 9263 2507 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $19589 m0 *1 181.44,267.12
X$19589 2321 9264 2320 9263 2448 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $19591 r0 *1 165.2,257.04
X$19591 9263 2321 2320 2358 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $19602 m0 *1 226.24,277.2
X$19602 9263 2322 2359 2557 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $19604 r0 *1 232.4,257.04
X$19604 9263 2359 2322 9264 2361 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19612 r0 *1 326.48,267.12
X$19612 9263 2324 2425 9264 2475 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19626 m0 *1 337.68,287.28
X$19626 9264 9263 2627 2324 2477 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $19628 r0 *1 333.76,267.12
X$19628 9264 9263 2326 2324 2520 2355 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19633 r0 *1 266,277.2
X$19633 9263 2568 2468 2572 2324 2605 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $19638 r0 *1 283.36,257.04
X$19638 9264 9263 2355 2325 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19642 m0 *1 372.96,277.2
X$19642 9264 2326 2369 2543 2542 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $19645 r0 *1 376.88,277.2
X$19645 9264 9263 2326 2608 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19648 m0 *1 372.4,287.28
X$19648 9264 9263 2369 2576 2326 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19651 m0 *1 378.56,287.28
X$19651 9263 2326 2542 9264 2628 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19657 r0 *1 351.68,257.04
X$19657 9263 2366 2326 9264 2327 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19669 m0 *1 400.96,257.04
X$19669 2371 9264 2329 9263 2330 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $19672 m0 *1 400.96,267.12
X$19672 9263 2371 2329 9264 2427 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19674 m0 *1 386.4,267.12
X$19674 9264 2369 2329 2371 2370 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $19690 m0 *1 449.68,267.12
X$19690 9264 2429 2332 9263 2451 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $19699 m0 *1 510.16,287.28
X$19699 9264 2580 9263 2636 2631 2334 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $19701 m0 *1 509.6,317.52
X$19701 3012 2334 2916 2988 2798 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19703 m0 *1 484.4,317.52
X$19703 9264 9263 2334 3013 3015 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19705 r0 *1 470.96,307.44
X$19705 9264 9263 2334 2913 2912 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19707 r0 *1 465.36,267.12
X$19707 9264 9263 2430 2334 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $19713 m0 *1 496.16,307.44
X$19713 9264 2855 2335 2795 2914 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $19715 m0 *1 488.88,287.28
X$19715 9264 2634 2335 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $19718 r0 *1 500.64,267.12
X$19718 9264 2335 2517 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $19724 m0 *1 491.68,317.52
X$19724 9263 2335 9264 2854 2985 2984 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $19727 r0 *1 490,307.44
X$19727 2335 2945 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $19738 m0 *1 540.96,267.12
X$19738 9264 2338 2431 2402 2403 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $19744 r0 *1 536.48,267.12
X$19744 9264 9263 2432 2338 2582 2380 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19759 m0 *1 623.28,267.12
X$19759 9264 2397 2340 2433 9263 2434 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $19763 m0 *1 647.36,267.12
X$19763 9264 9263 2386 2341 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19771 m0 *1 656.32,277.2
X$19771 9264 2342 2435 2497 2553 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $19778 m0 *1 677.04,297.36
X$19778 9264 9263 2696 2343 2755 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $19785 m0 *1 719.04,317.52
X$19785 9263 2929 2998 9264 2345 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19843 m0 *1 235.76,277.2
X$19843 9264 9263 2355 2361 2514 2513 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $19856 m0 *1 333.2,277.2
X$19856 9264 9263 2541 2519 2355 2477 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19858 r0 *1 321.44,267.12
X$19858 9263 2355 2425 9264 2473 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19862 m0 *1 67.76,297.36
X$19862 2611 9264 2356 9263 2721 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $19866 r0 *1 67.76,287.28
X$19866 9263 2611 2356 9264 2670 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $19872 m0 *1 171.36,267.12
X$19872 9264 2396 2358 9263 2563 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $19887 r0 *1 266.56,267.12
X$19887 9264 9263 2467 2363 2362 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $19889 m0 *1 267.12,267.12
X$19889 9264 2363 2362 9263 2418 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $19901 r0 *1 280,277.2
X$19901 9263 2571 9264 2607 2418 2572 2365 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $19918 m0 *1 350,267.12
X$19918 9263 2369 2366 2425 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $19923 r0 *1 351.12,307.44
X$19923 9264 2367 2841 2480 2948 2842 9263 2949 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $19925 m0 *1 358.4,337.68
X$19925 9264 2367 2479 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $19931 r0 *1 352.8,347.76
X$19931 9263 3308 9264 2367 3237 3075 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $19934 r0 *1 351.12,337.68
X$19934 3235 3034 3075 2367 9263 9264 3180 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $19936 r0 *1 341.6,408.24
X$19936 9264 2367 3734 3774 3776 3775 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $19938 r0 *1 370.16,267.12
X$19938 2481 9264 2479 2426 9263 2368 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $19942 r0 *1 371.84,277.2
X$19942 9264 9263 2369 2577 2608 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19945 m0 *1 352.8,277.2
X$19945 9264 9263 2369 2477 2478 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19948 m0 *1 345.52,287.28
X$19948 9264 2658 2369 2841 2516 2558 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $19955 m0 *1 380.8,297.36
X$19955 9264 2785 2733 2732 2369 2628 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $19971 r0 *1 407.12,337.68
X$19971 9264 2373 9263 3214 3076 3181 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $19973 m0 *1 431.2,337.68
X$19973 9264 9263 2373 3124 3079 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19979 m0 *1 425.04,357.84
X$19979 9264 2373 3362 9263 3360 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $19981 m0 *1 419.44,337.68
X$19981 9263 2979 3238 9264 2373 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19984 r0 *1 416.64,347.76
X$19984 9263 3330 9264 3283 3182 3331 2374 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $19993 m0 *1 475.44,267.12
X$19993 9264 2376 2404 9263 2544 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $19998 m0 *1 496.16,267.12
X$19998 9264 2377 2378 9263 2488 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $20003 m0 *1 525.28,267.12
X$20003 9264 9263 2378 2431 2379 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20009 m0 *1 530.32,267.12
X$20009 9264 2378 2379 9263 2403 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $20012 r0 *1 487.2,267.12
X$20012 9264 2450 2545 2378 9263 2518 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $20023 m0 *1 560.56,277.2
X$20023 9264 2381 2383 9263 2548 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $20026 m0 *1 556.08,267.12
X$20026 9263 2381 2432 9264 2449 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $20033 r0 *1 571.2,267.12
X$20033 9264 9263 2490 2381 2383 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $20036 m0 *1 574.56,267.12
X$20036 9264 9263 2446 2383 2382 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $20039 m0 *1 565.6,267.12
X$20039 9264 2382 9263 2449 2400 2432 2383 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $20054 r0 *1 596.96,257.04
X$20054 9264 9263 2399 2385 2384 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $20059 m0 *1 600.32,267.12
X$20059 9264 2509 2400 2445 2385 2384 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $20071 r0 *1 684.32,388.08
X$20071 9264 9263 3719 2388 3556 3649 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $20074 r0 *1 714.56,287.28
X$20074 2697 2389 2647 2645 9264 9263 2698 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $20078 r0 *1 704.48,277.2
X$20078 9263 2587 2389 9264 2590 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20082 m0 *1 714.56,398.16
X$20082 9264 3650 2390 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $20084 m0 *1 601.44,650.16
X$20084 9263 2390 6614 9264 6585 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20086 r0 *1 577.36,630
X$20086 9263 2390 6472 9264 6433 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20088 r0 *1 596.96,680.4
X$20088 9263 2390 6855 9264 6909 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20090 m0 *1 670.88,690.48
X$20090 9264 9263 7035 6935 2390 6837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20092 r0 *1 638.4,630
X$20092 9263 2390 6369 9264 6437 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20094 m0 *1 626.08,690.48
X$20094 9263 2390 6934 9264 6970 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20112 m0 *1 670.88,650.16
X$20112 9264 9263 6542 6587 2390 6383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20114 r0 *1 715.68,267.12
X$20114 9263 2390 2498 9264 2441 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20144 m0 *1 215.04,347.76
X$20144 9264 3227 3167 3226 2398 3454 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $20150 r0 *1 607.04,267.12
X$20150 9263 2433 2399 9264 2653 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $20156 m0 *1 268.8,307.44
X$20156 9263 2677 2401 9264 2833 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20164 m0 *1 273.84,307.44
X$20164 9263 2729 2401 9264 2834 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20167 m0 *1 556.08,297.36
X$20167 9264 2764 2743 2402 2548 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $20169 r0 *1 564.48,277.2
X$20169 9264 9263 2402 2549 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20179 m0 *1 547.68,347.76
X$20179 9264 3288 9263 3241 3242 2402 3304 2743
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $20183 r0 *1 544.88,267.12
X$20183 9264 2431 2585 2403 2515 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $20194 m0 *1 456.4,267.12
X$20194 9264 9263 2450 2451 2430 2405 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20227 r0 *1 142.8,267.12
X$20227 9264 2506 2413 9263 2464 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $20243 m0 *1 193.2,277.2
X$20243 9264 2510 9263 2565 2416 2511 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20245 m0 *1 201.6,277.2
X$20245 9263 2533 2416 9264 2512 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20254 m0 *1 283.36,267.12
X$20254 2420 9264 2418 2419 9263 2452 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $20258 m0 *1 249.76,287.28
X$20258 9263 9264 2418 2568 2530 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $20261 m0 *1 259.28,287.28
X$20261 9264 9263 2621 2679 2418 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20269 r0 *1 253.12,287.28
X$20269 9263 2418 2621 2620 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $20271 m0 *1 285.04,277.2
X$20271 9263 9264 2419 2472 2452 2537 2469 2468
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $20277 r0 *1 302.96,307.44
X$20277 9263 2420 2778 9264 2837 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20279 m0 *1 273.28,327.6
X$20279 9264 9263 2420 2729 3229 2677 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $20283 m0 *1 327.04,287.28
X$20283 2627 2474 2420 2662 2663 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $20295 m0 *1 335.44,317.52
X$20295 9263 2420 3009 9264 2948 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $20298 r0 *1 336,297.36
X$20298 9263 2782 2880 2781 2420 2663 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $20302 r0 *1 291.76,267.12
X$20302 9264 9263 2516 2469 2422 2421 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20304 r0 *1 302.4,428.4
X$20304 3178 9263 2422 3909 9264 3960 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $20308 m0 *1 299.6,307.44
X$20308 9264 9263 2422 2836 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $20310 r0 *1 308.56,428.4
X$20310 3178 2422 4072 3909 9264 9263 3992 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $20319 m0 *1 312.48,357.84
X$20319 3178 9263 2422 3233 9264 3321 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $20321 m0 *1 315.84,337.68
X$20321 9264 3033 2422 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $20329 m0 *1 306.88,277.2
X$20329 9264 2624 2424 2423 2470 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $20331 r0 *1 305.76,267.12
X$20331 9264 2474 2424 2423 2470 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $20339 m0 *1 282.24,287.28
X$20339 2572 9263 2620 2423 9264 2537 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $20346 r0 *1 342.16,267.12
X$20346 9264 9263 2425 2519 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20360 r0 *1 411.04,277.2
X$20360 9264 9263 2427 2578 2543 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20362 m0 *1 422.8,287.28
X$20362 9263 2427 2579 9264 2666 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20365 m0 *1 416.64,287.28
X$20365 2427 9263 2543 2579 9264 2629 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $20372 r0 *1 413.28,297.36
X$20372 9264 9263 2428 2789 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20379 r0 *1 417.2,277.2
X$20379 9264 9263 2428 2453 2579 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $20382 m0 *1 407.12,297.36
X$20382 2907 9263 9264 2735 2428 2453 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $20384 r0 *1 412.72,287.28
X$20384 2428 9264 2578 2453 9263 2684 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $20386 r0 *1 448.56,267.12
X$20386 9264 9263 2429 2486 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20395 m0 *1 461.44,287.28
X$20395 9264 9263 2430 2632 2631 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20400 r0 *1 456.96,297.36
X$20400 9263 9264 2849 2430 2794 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $20410 m0 *1 624.96,287.28
X$20410 9263 2432 2508 9264 2652 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $20413 m0 *1 630.56,277.2
X$20413 9264 9263 2585 2551 2432 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20416 m0 *1 635.6,277.2
X$20416 9264 9263 2432 2494 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20436 r0 *1 632.8,277.2
X$20436 9264 2508 2434 2551 2593 2552 2585 9263 2923
+ gf180mcu_fd_sc_mcu9t5v0__oai33_2
* cell instance $20439 m0 *1 638.96,277.2
X$20439 2494 9263 2508 2434 9264 2552 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $20444 m0 *1 634.48,357.84
X$20444 3347 3195 2434 3354 9263 9264 3352 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $20446 m0 *1 644,337.68
X$20446 9264 2924 2434 9263 3196 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $20449 r0 *1 630,357.84
X$20449 9263 3056 9264 3444 3194 2434 3390 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $20451 r0 *1 630,307.44
X$20451 9264 2938 2924 2746 2434 2859 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $20459 r0 *1 651.28,317.52
X$20459 9263 2435 9264 2994 3001 2695 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20463 m0 *1 660.24,297.36
X$20463 9264 2651 9263 2804 2436 2754 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20468 r0 *1 678.72,317.52
X$20468 3139 9264 9263 2437 2553 2926 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $20470 r0 *1 694.4,317.52
X$20470 9264 9263 2995 2437 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $20473 m0 *1 715.68,327.6
X$20473 9263 2437 2997 9264 3050 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20483 m0 *1 631.68,418.32
X$20483 9264 9263 3807 2438 3556 3834 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $20488 r0 *1 693.28,267.12
X$20488 9264 2439 2500 9263 2438 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $20494 m0 *1 705.04,347.76
X$20494 9264 9263 2440 3248 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20502 m0 *1 704.48,307.44
X$20502 2440 9264 2867 9263 2932 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $20532 r0 *1 569.52,277.2
X$20532 9263 2447 9264 2549 3190 2584 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20552 m0 *1 414.96,297.36
X$20552 2683 9263 2733 2453 9264 3183 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $20566 m0 *1 406.56,317.52
X$20566 2978 2906 2454 2907 9264 9263 3016 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $20568 r0 *1 7.84,287.28
X$20568 9264 2700 2610 2455 2524 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $20581 r0 *1 62.72,287.28
X$20581 9263 2528 2458 9264 2611 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20594 r0 *1 66.08,277.2
X$20594 9264 9263 2527 2460 2595 2594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20598 m0 *1 109.2,307.44
X$20598 9264 9263 2462 2773 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20600 m0 *1 106.4,337.68
X$20600 9264 9263 2955 3205 2462 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20606 r0 *1 110.32,327.6
X$20606 9263 2462 2955 9264 3067 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20609 r0 *1 92.4,327.6
X$20609 9264 9263 3099 2462 3022 2889 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20613 m0 *1 142.8,277.2
X$20613 9263 2463 2464 9264 2600 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $20618 r0 *1 142.8,277.2
X$20618 9263 2463 2464 9264 2599 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20632 r0 *1 238.56,267.12
X$20632 9264 9263 2466 2513 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20638 r0 *1 252.56,277.2
X$20638 9264 9263 2530 2571 2467 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20640 m0 *1 272.72,277.2
X$20640 9264 9263 2467 2536 2538 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20656 r0 *1 321.44,277.2
X$20656 9264 2471 9263 2660 2626 2625 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20658 m0 *1 320.32,277.2
X$20658 9264 9263 2475 2471 2472 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20664 r0 *1 321.44,287.28
X$20664 9263 2627 2472 9264 2711 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20666 r0 *1 314.16,287.28
X$20666 2625 2626 2473 2472 9264 9263 2710 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $20672 m0 *1 316.4,287.28
X$20672 9264 2575 2624 2626 2625 9263 2473 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $20677 m0 *1 316.96,307.44
X$20677 9264 9263 2836 2838 2474 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20681 m0 *1 325.36,277.2
X$20681 9264 9263 2474 2540 2475 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20687 r0 *1 327.04,287.28
X$20687 2474 2711 2710 2660 9263 9264 2712 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $20694 m0 *1 319.2,297.36
X$20694 2626 2625 2627 2781 2475 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $20699 r0 *1 318.64,317.52
X$20699 9264 9263 3009 3008 3033 2476 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20701 m0 *1 322,347.76
X$20701 9263 3274 9264 3263 2476 2520 3179 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $20703 r0 *1 321.44,337.68
X$20703 9264 3179 3232 3234 2476 3033 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $20709 m0 *1 322.56,307.44
X$20709 9264 2836 2476 9263 2839 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $20718 m0 *1 359.52,277.2
X$20718 9263 2478 9264 2479 2542 2480 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20723 r0 *1 372.4,378
X$20723 2479 3579 3567 3549 9264 9263 3330 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $20726 r0 *1 366.24,297.36
X$20726 9264 2783 2479 2481 2731 2819 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $20731 r0 *1 360.64,347.76
X$20731 9264 2786 2479 3075 3326 3327 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $20742 m0 *1 366.24,367.92
X$20742 9263 3416 9264 2479 3375 3075 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20746 m0 *1 358.96,327.6
X$20746 9263 2819 9264 2479 2975 3075 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20749 r0 *1 360.64,327.6
X$20749 9263 2973 9264 2479 3106 2481 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20753 m0 *1 363.44,428.4
X$20753 9263 2479 3671 9264 3924 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20765 r0 *1 354.48,388.08
X$20765 9263 9264 3614 2480 3460 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $20767 m0 *1 349.44,418.32
X$20767 9264 3873 3855 3739 3776 2480 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $20776 r0 *1 369.6,388.08
X$20776 9264 2481 3672 9263 3373 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $20778 r0 *1 366.8,378
X$20778 9264 2481 3548 9263 3567 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $20780 r0 *1 357.28,378
X$20780 9263 9264 3614 2481 3460 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $20782 r0 *1 386.96,277.2
X$20782 9264 2484 2482 2483 2606 2578 9263 2788 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $20788 m0 *1 401.52,287.28
X$20788 9263 2578 9264 2683 2484 2483 2482 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $20790 r0 *1 393.68,438.48
X$20790 9264 3926 4080 3852 4006 2483 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $20801 m0 *1 389.76,357.84
X$20801 9263 3278 9264 3311 3328 2483 2735 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $20803 r0 *1 388.08,317.52
X$20803 9263 9264 3014 2483 2976 2732 3629 2905 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $20806 r0 *1 413.28,428.4
X$20806 9263 9264 3361 3927 2483 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $20809 m0 *1 405.44,418.32
X$20809 9263 3802 9264 3780 3827 2484 3803 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $20819 m0 *1 387.52,378
X$20819 9263 9264 3550 2484 3278 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $20821 r0 *1 406.56,408.24
X$20821 2484 3802 3827 3803 9263 9264 3740 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $20826 r0 *1 427.28,277.2
X$20826 9263 2579 2485 9264 2603 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $20829 r0 *1 445.76,287.28
X$20829 9264 2603 2633 2708 2486 2685 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $20831 m0 *1 446.88,287.28
X$20831 9264 2603 9263 2631 2630 2486 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20834 m0 *1 512.4,277.2
X$20834 2517 9263 2487 2488 9264 2547 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $20837 r0 *1 500.64,277.2
X$20837 9264 2688 2602 2488 2487 9263 2581 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $20839 m0 *1 489.44,277.2
X$20839 9264 2518 2634 2488 2487 9263 2546 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $20842 m0 *1 468.16,277.2
X$20842 9263 2544 2521 9264 2487 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $20852 m0 *1 536.48,317.52
X$20852 9264 2584 2989 2990 2489 2919 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $20857 m0 *1 528.64,317.52
X$20857 2919 2989 3041 2489 9263 9264 2743 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $20863 m0 *1 570.64,277.2
X$20863 9263 2490 9264 2549 2491 2584 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20866 r0 *1 575.12,317.52
X$20866 9264 2491 9263 3004 2799 2583 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20869 r0 *1 575.68,347.76
X$20869 3244 9264 2491 2550 9263 3384 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $20872 r0 *1 568.96,347.76
X$20872 3243 9264 3244 2491 9263 3343 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $20878 r0 *1 633.36,317.52
X$20878 9264 2808 3056 9263 3047 2493 2994 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $20885 m0 *1 637.28,287.28
X$20885 9263 2494 2508 9264 2924 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $20889 r0 *1 647.36,277.2
X$20889 9264 9263 2593 2494 2508 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $20895 r0 *1 715.68,327.6
X$20895 9264 9263 3142 3094 2998 2496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20897 r0 *1 714.56,337.68
X$20897 3198 9264 9263 2995 2496 9311 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $20900 r0 *1 679.28,267.12
X$20900 9264 9263 2496 2497 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20912 m0 *1 654.08,327.6
X$20912 2496 9264 2695 2994 9263 3048 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $20921 m0 *1 715.68,277.2
X$20921 9264 9263 2498 2647 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20927 r0 *1 716.8,317.52
X$20927 9264 9263 2499 2929 2997 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20929 m0 *1 714,458.64
X$20929 9264 9263 4176 4177 2499 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20932 m0 *1 714,418.32
X$20932 9264 9263 2499 3838 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20934 m0 *1 718.48,478.8
X$20934 9264 4222 9263 4426 4396 2499 4425 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $20961 m0 *1 621.04,327.6
X$20961 9264 3047 3046 2749 2504 3138 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $20965 m0 *1 544.32,327.6
X$20965 9263 3042 9264 3057 2505 3043 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20971 m0 *1 617.68,337.68
X$20971 9264 3082 2505 9263 3144 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $20973 r0 *1 614.88,307.44
X$20973 2505 9264 2922 9263 2748 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $20998 r0 *1 608.72,277.2
X$20998 9264 9263 2509 2596 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $21000 m0 *1 632.24,297.36
X$21000 9264 2751 2509 2695 2643 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $21003 r0 *1 637.28,297.36
X$21003 2751 2643 2509 2862 9264 9263 2803 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $21005 r0 *1 637.84,287.28
X$21005 2751 2643 2509 9264 9263 2752 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $21031 r0 *1 241.92,367.92
X$21031 3455 3500 3497 2514 9264 9263 3483 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $21034 r0 *1 243.6,357.84
X$21034 9264 9263 2514 3169 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $21044 r0 *1 251.44,357.84
X$21044 9263 9264 2946 2514 2899 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $21046 m0 *1 264.32,337.68
X$21046 2514 9264 3119 3149 9263 3211 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $21057 m0 *1 506.8,327.6
X$21057 9263 2517 3058 9264 3007 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21059 r0 *1 506.8,287.28
X$21059 9263 2517 9264 2689 2664 2635 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $21063 m0 *1 504.56,317.52
X$21063 9263 2517 2795 9264 2944 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21065 m0 *1 509.6,307.44
X$21065 2517 9263 2797 2854 9264 2874 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21070 r0 *1 490,277.2
X$21070 2518 2602 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $21078 r0 *1 322,367.92
X$21078 9264 9263 3178 3531 2520 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21080 r0 *1 328.16,378
X$21080 9263 3547 2520 9264 3507 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21083 m0 *1 325.92,398.16
X$21083 9264 3577 3510 3689 3733 2520 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $21093 m0 *1 330.4,337.68
X$21093 3033 9263 9264 2520 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $21103 m0 *1 12.32,297.36
X$21103 9263 2714 9264 2715 2759 2523 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $21111 m0 *1 15.12,317.52
X$21111 9264 2525 2820 2950 9263 3020 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $21116 m0 *1 70.56,287.28
X$21116 9264 9263 2612 2526 2595 2559 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21118 r0 *1 59.36,297.36
X$21118 9264 3252 2769 2527 2612 2720 2871 2670 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_4
* cell instance $21121 m0 *1 63.28,307.44
X$21121 9264 2769 9263 2527 2870 2612 2720 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $21130 r0 *1 57.12,307.44
X$21130 9264 9263 2885 2888 2528 2823 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $21132 r0 *1 32.48,287.28
X$21132 9264 9263 2528 2595 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $21137 m0 *1 84,307.44
X$21137 9264 9263 2884 2723 2528 2771 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $21139 m0 *1 128.24,287.28
X$21139 2529 9264 2561 9263 2614 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $21144 r0 *1 126.56,287.28
X$21144 9263 2529 2561 9264 2703 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21150 m0 *1 104.16,307.44
X$21150 9264 9263 2530 2770 2722 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21155 r0 *1 206.08,327.6
X$21155 9263 2530 3032 9264 3167 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $21157 r0 *1 194.88,317.52
X$21157 9263 2530 2895 9264 3031 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $21160 m0 *1 181.44,317.52
X$21160 9263 9264 2530 2961 2894 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $21163 r0 *1 196,337.68
X$21163 9263 2530 2829 9264 3166 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21176 r0 *1 151.2,327.6
X$21176 9264 3145 2530 9263 3069 2958 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $21179 m0 *1 179.2,347.76
X$21179 9264 3165 2530 3115 3224 3225 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $21181 r0 *1 173.6,277.2
X$21181 2531 9264 2563 9263 2532 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $21183 m0 *1 173.04,287.28
X$21183 9263 2531 2563 2657 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $21188 r0 *1 188.72,277.2
X$21188 2533 9264 2565 9263 2567 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $21190 m0 *1 185.92,287.28
X$21190 9263 2533 2564 9264 2566 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21198 r0 *1 192.64,307.44
X$21198 9264 2895 2828 2534 2875 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $21200 m0 *1 201.6,307.44
X$21200 2534 9264 2828 9263 3032 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $21202 r0 *1 209.44,307.44
X$21202 9263 2534 2828 9264 2896 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $21210 r0 *1 205.52,367.92
X$21210 9264 3272 3495 3497 3318 2535 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $21213 r0 *1 196,408.24
X$21213 3698 3731 3697 9264 9263 2535 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $21215 r0 *1 202.16,398.16
X$21215 9264 3668 3701 3699 2535 3573 3667 9263
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $21221 m0 *1 222.88,398.16
X$21221 9264 2535 3699 9263 3702 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $21226 r0 *1 264.32,287.28
X$21226 9264 9263 2622 2536 2677 2571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21228 m0 *1 273.84,287.28
X$21228 9264 9263 2570 2536 2729 2571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21232 r0 *1 290.08,277.2
X$21232 9263 2573 9264 2609 2537 2574 2607 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $21243 r0 *1 306.88,287.28
X$21243 9264 2539 9263 2658 2680 2623 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $21248 m0 *1 329.28,307.44
X$21248 2541 2626 2780 9264 9263 2782 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $21260 r0 *1 370.72,287.28
X$21260 9264 9263 2682 2576 2542 2577 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21270 m0 *1 470.96,297.36
X$21270 2686 9263 2544 2741 9264 2633 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $21272 r0 *1 463.12,287.28
X$21272 9264 9263 2544 2630 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $21276 m0 *1 482.16,287.28
X$21276 9264 9263 2635 2633 2544 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $21282 r0 *1 472.08,287.28
X$21282 2633 9264 2686 2544 9263 2687 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $21285 m0 *1 474.88,367.92
X$21285 9263 3333 2545 9264 3449 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21289 m0 *1 462,367.92
X$21289 9263 3379 3359 9264 2545 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21293 m0 *1 502.88,297.36
X$21293 9263 9264 2546 2797 2742 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $21297 m0 *1 511.84,297.36
X$21297 2546 2690 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $21300 r0 *1 523.04,287.28
X$21300 9264 2692 2581 2547 2706 2705 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $21321 m0 *1 589.68,367.92
X$21321 3426 3344 2550 3385 3345 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $21329 r0 *1 575.12,367.92
X$21329 9264 3555 3345 3524 3467 2550 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $21332 r0 *1 598.64,357.84
X$21332 9264 2550 3345 9263 3346 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $21334 r0 *1 604.24,367.92
X$21334 9263 3427 9264 3345 3469 2550 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $21337 m0 *1 571.76,337.68
X$21337 9264 3084 2992 2550 3083 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $21345 m0 *1 679.84,337.68
X$21345 9264 3200 3199 2553 3052 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $21352 r0 *1 709.52,277.2
X$21352 9264 9263 2697 2592 2554 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21356 r0 *1 523.6,277.2
X$21356 9264 2580 2555 9263 2601 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $21358 r0 *1 529.2,277.2
X$21358 2632 9263 2582 2581 9264 2555 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21363 r0 *1 197.12,287.28
X$21363 9264 9263 2556 2675 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $21372 r0 *1 222.32,277.2
X$21372 9264 2604 2557 9263 2618 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $21380 m0 *1 103.6,287.28
X$21380 9263 2560 2672 9264 2889 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $21383 r0 *1 106.4,287.28
X$21383 9263 2672 2560 2673 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $21385 m0 *1 111.44,297.36
X$21385 9264 2763 2672 2560 9263 gf180mcu_fd_sc_mcu9t5v0__xor2_4
* cell instance $21392 r0 *1 127.68,277.2
X$21392 9264 2598 2599 9263 2561 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $21402 r0 *1 185.36,277.2
X$21402 9264 9263 2565 2564 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $21412 m0 *1 190.4,297.36
X$21412 9264 2765 2566 9263 2828 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $21414 r0 *1 193.76,297.36
X$21414 9264 9263 2774 2567 2727 2675 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21418 m0 *1 243.6,317.52
X$21418 9264 9263 2965 2964 2568 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $21420 r0 *1 234.64,297.36
X$21420 9264 9263 2775 2678 2568 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $21427 r0 *1 235.2,307.44
X$21427 9264 2677 2568 9263 2897 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $21431 r0 *1 244.72,327.6
X$21431 9263 2729 2569 9264 3147 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21433 r0 *1 254.24,327.6
X$21433 9264 9263 2677 3210 2569 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21442 r0 *1 272.72,287.28
X$21442 9263 2679 2571 9264 2663 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21450 m0 *1 271.6,297.36
X$21450 9264 9263 2679 2778 2571 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21453 r0 *1 294,307.44
X$21453 2572 9263 2902 2903 9264 2878 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21457 r0 *1 305.76,297.36
X$21457 9263 2572 2663 9264 2779 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21462 r0 *1 310.24,307.44
X$21462 9263 9264 2837 2838 2779 2572 2840 2839 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $21470 r0 *1 287.28,327.6
X$21470 9264 9263 2573 3073 3150 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $21474 m0 *1 303.52,327.6
X$21474 9263 3074 9264 2573 2974 2836 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $21498 r0 *1 423.92,287.28
X$21498 9263 2579 2683 2709 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $21506 m0 *1 521.92,287.28
X$21506 9264 2580 9263 2766 2581 2632 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $21512 r0 *1 501.76,287.28
X$21512 9263 2688 2635 9264 2580 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21526 r0 *1 546.56,287.28
X$21526 9264 9263 2637 2659 2581 2693 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21530 r0 *1 565.6,297.36
X$21530 9264 9263 2582 2801 2744 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21539 m0 *1 558.32,357.84
X$21539 9264 3341 9263 3289 3290 2582 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $21541 m0 *1 517.44,357.84
X$21541 9264 9263 3287 2582 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $21545 r0 *1 586.32,297.36
X$21545 9264 2811 2744 2583 2746 2812 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $21548 r0 *1 571.2,357.84
X$21548 9264 9263 2583 3426 3290 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21551 m0 *1 560,287.28
X$21551 9264 2813 2583 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $21554 m0 *1 541.52,287.28
X$21554 9263 2632 2583 9264 2659 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21557 r0 *1 542.64,317.52
X$21557 2583 9263 2987 2986 9264 3057 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21573 r0 *1 590.24,287.28
X$21573 2639 9264 2585 2637 9263 2654 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $21575 m0 *1 575.12,287.28
X$21575 9264 2637 2642 2585 2596 2638 2586 9263
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $21583 m0 *1 592.48,297.36
X$21583 9264 2585 2637 9263 2746 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $21590 r0 *1 596.96,287.28
X$21590 9263 2640 9264 2694 2641 2586 2639 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $21592 m0 *1 600.32,297.36
X$21592 9264 9263 2762 2586 2641 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $21594 m0 *1 602,287.28
X$21594 2586 2641 2640 2639 9263 9264 2655 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $21606 m0 *1 700.56,357.84
X$21606 9263 3350 9264 3349 2589 3295 3248 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $21608 m0 *1 700,398.16
X$21608 9264 3556 2589 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $21612 m0 *1 674.24,579.6
X$21612 9264 9263 5775 3052 2589 5696 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21627 m0 *1 688.8,367.92
X$21627 9263 3440 9264 3433 2589 3434 3436 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $21629 m0 *1 702.24,367.92
X$21629 9264 9263 3435 3396 2589 2697 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21631 m0 *1 675.92,357.84
X$21631 9263 2589 9264 3350 3394 2804 3395 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $21633 r0 *1 677.04,357.84
X$21633 9263 2589 9264 3440 3394 2995 3395 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $21636 m0 *1 692.72,710.64
X$21636 9264 9263 7177 3247 2589 7178 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21641 r0 *1 688.8,569.52
X$21641 9264 9263 5743 3197 2589 5797 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21644 m0 *1 707.28,287.28
X$21644 9263 2592 2590 9264 2649 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $21647 m0 *1 62.72,418.32
X$21647 9264 9263 2591 3792 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $21649 r0 *1 62.16,408.24
X$21649 3216 9263 2591 3569 9264 3757 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21652 m0 *1 55.44,408.24
X$21652 9264 2591 9263 3747 3569 3216 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $21689 r0 *1 566.16,378
X$21689 9264 3190 3515 2597 3595 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $21692 m0 *1 568.96,357.84
X$21692 9264 3516 3343 2597 3301 3356 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $21714 m0 *1 529.2,287.28
X$21714 2686 9264 2601 9263 2639 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $21736 r0 *1 409.92,307.44
X$21736 9263 2845 2606 9264 2847 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21742 m0 *1 370.16,357.84
X$21742 3325 9263 3326 3327 9264 2606 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21760 m0 *1 30.24,357.84
X$21760 9264 9263 2610 3265 3312 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21774 r0 *1 31.36,357.84
X$21774 9263 2610 3312 9264 3438 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21790 r0 *1 116.48,287.28
X$21790 9264 2613 2703 9263 2672 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $21794 r0 *1 146.72,347.76
X$21794 3316 3317 3270 2615 9263 9264 3225 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $21796 m0 *1 149.52,297.36
X$21796 9264 9263 2615 2674 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $21799 r0 *1 161.84,297.36
X$21799 2726 9264 2616 9263 2816 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $21803 m0 *1 162.4,297.36
X$21803 9263 9264 2726 2827 2616 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $21806 m0 *1 161.28,287.28
X$21806 9264 2656 2657 9263 2616 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $21809 m0 *1 222.88,297.36
X$21809 9264 3072 2618 2617 2676 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $21811 r0 *1 224,287.28
X$21811 2617 9264 2618 9263 2678 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $21813 m0 *1 234.08,287.28
X$21813 9263 2617 2618 9264 2619 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $21828 r0 *1 271.6,337.68
X$21828 3169 9263 2619 3171 9264 3150 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21835 r0 *1 243.6,317.52
X$21835 9263 2620 2964 3006 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $21837 r0 *1 230.16,307.44
X$21837 9264 9263 2677 2943 2620 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21839 r0 *1 240.24,297.36
X$21839 9263 2620 2678 2818 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $21841 m0 *1 228.48,317.52
X$21841 9264 9263 2729 3005 2620 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21849 r0 *1 181.44,337.68
X$21849 9264 9263 3115 3164 2621 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21856 m0 *1 159.04,347.76
X$21856 2621 9263 3069 3027 9264 3221 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21858 r0 *1 187.04,317.52
X$21858 9263 2621 2894 9264 3030 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21861 m0 *1 144.48,347.76
X$21861 9263 2621 2704 9264 3255 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $21864 m0 *1 132.72,347.76
X$21864 9264 3159 9263 3302 3161 2621 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $21868 r0 *1 227.92,337.68
X$21868 9263 2621 3072 9264 3118 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $21884 r0 *1 124.88,327.6
X$21884 3486 9263 9264 3099 2621 2954 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $21888 r0 *1 311.36,297.36
X$21888 9264 9263 2623 2731 2680 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21890 m0 *1 308,317.52
X$21890 9263 2837 9264 2970 2623 2971 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $21895 m0 *1 297.36,347.76
X$21895 9264 2624 3232 3175 3174 2970 2971 9263
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $21897 r0 *1 314.16,337.68
X$21897 9263 3178 2624 9264 3213 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21904 r0 *1 307.44,347.76
X$21904 3307 9263 9264 3233 3178 2624 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $21906 r0 *1 308,317.52
X$21906 9263 2778 2624 9264 3008 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $21908 m0 *1 300.72,408.24
X$21908 9264 2625 3754 3753 3797 3503 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $21937 m0 *1 319.76,327.6
X$21937 9263 9264 2780 3033 2626 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $21939 r0 *1 302.4,317.52
X$21939 9263 2902 2903 9264 2626 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21953 r0 *1 409.92,317.52
X$21953 9264 3079 2979 3016 2629 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $21956 r0 *1 448,347.76
X$21956 9264 9263 3463 3281 2630 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21974 m0 *1 454.16,297.36
X$21974 2738 9263 2739 2632 9264 2742 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21980 r0 *1 454.16,337.68
X$21980 9264 3239 3184 2686 2633 3185 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $21982 r0 *1 468.72,337.68
X$21982 9264 3186 3185 2853 2686 2633 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $21993 m0 *1 488.32,327.6
X$21993 9264 9263 2634 2688 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $21995 m0 *1 479.92,347.76
X$21995 9264 2634 3285 3284 3186 3239 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $22008 m0 *1 565.04,307.44
X$22008 2764 2800 2636 2801 9264 9263 2802 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $22010 r0 *1 566.72,287.28
X$22010 9264 9263 2636 2693 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $22023 m0 *1 587.44,297.36
X$22023 9264 9263 2764 2638 2800 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22029 r0 *1 583.52,287.28
X$22029 9264 2693 2638 9263 2641 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $22032 m0 *1 605.92,297.36
X$22032 2639 9264 2762 9263 2921 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $22042 r0 *1 567.28,307.44
X$22042 9264 9263 2640 2856 2874 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $22057 m0 *1 637.28,367.92
X$22057 9264 3351 2642 3444 2923 9263 3472 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $22064 r0 *1 609.84,287.28
X$22064 9264 2654 9263 2643 2655 2694 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $22081 m0 *1 714.56,297.36
X$22081 9264 9263 2645 2699 2758 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22089 m0 *1 716.8,287.28
X$22089 9264 9263 2647 2648 2649 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22093 r0 *1 705.04,287.28
X$22093 9263 2648 2701 9264 2758 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $22106 m0 *1 625.52,307.44
X$22106 9264 2652 2811 2860 2861 3046 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $22111 r0 *1 621.6,297.36
X$22111 2747 2748 2761 2653 9264 9263 2750 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $22124 m0 *1 615.44,297.36
X$22124 9264 9263 2694 2747 2655 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22164 r0 *1 269.36,327.6
X$22164 9263 2677 2663 9264 3149 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $22167 m0 *1 272.72,337.68
X$22167 9263 2729 2663 9264 3261 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $22174 r0 *1 515.76,287.28
X$22174 9264 9263 2742 2706 2664 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22177 m0 *1 432.32,297.36
X$22177 2790 9263 2665 2912 9264 2708 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $22186 r0 *1 47.04,297.36
X$22186 9264 9263 2667 2810 2719 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22192 r0 *1 19.6,307.44
X$22192 9264 2952 2668 2716 2822 2866 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $22194 r0 *1 33.04,297.36
X$22194 2951 9263 9264 2716 2724 2668 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $22197 m0 *1 30.8,307.44
X$22197 9264 2760 2768 2668 2716 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $22204 r0 *1 37.52,307.44
X$22204 9263 2822 9264 2668 2882 2716 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $22208 m0 *1 83.44,347.76
X$22208 9264 9263 2669 3253 3218 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22210 r0 *1 71.12,347.76
X$22210 9264 3403 3298 2669 3266 3299 3218 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $22213 r0 *1 63.28,347.76
X$22213 9263 3155 2669 9264 3298 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22216 r0 *1 65.52,337.68
X$22216 9264 9263 3155 3217 2669 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22222 m0 *1 73.92,307.44
X$22222 9263 2870 9264 3299 2770 2671 2721 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $22228 m0 *1 121.52,327.6
X$22228 9264 2671 3025 2824 3022 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $22235 r0 *1 77.28,307.44
X$22235 9264 9263 2871 2671 2770 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $22237 r0 *1 116.48,317.52
X$22237 2671 9264 3022 2824 9263 3110 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $22247 m0 *1 99.68,297.36
X$22247 9264 9263 2673 2724 2722 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $22249 m0 *1 89.6,297.36
X$22249 9264 2673 2724 9263 2772 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $22263 r0 *1 253.68,307.44
X$22263 9263 2677 2728 9264 2898 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22268 m0 *1 241.92,327.6
X$22268 9264 9263 2964 2677 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22284 m0 *1 280.56,307.44
X$22284 2831 9264 2777 2677 9263 2730 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $22288 m0 *1 239.12,297.36
X$22288 9264 9263 2678 2729 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22303 m0 *1 307.44,307.44
X$22303 9264 2779 9263 2680 2878 2780 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $22309 m0 *1 346.64,317.52
X$22309 9264 2904 2681 9263 3010 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $22312 r0 *1 343.84,317.52
X$22312 9263 2681 9264 2904 3035 2972 3034 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $22314 m0 *1 373.52,317.52
X$22314 9264 9263 2682 2844 3011 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22316 r0 *1 377.44,307.44
X$22316 9264 2843 9263 2682 2736 2734 2949 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $22323 r0 *1 423.36,297.36
X$22323 2683 2737 2767 2790 9264 9263 2817 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $22331 m0 *1 413.84,327.6
X$22331 9264 3037 9263 3103 2684 2980 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $22334 r0 *1 453.04,347.76
X$22334 9263 3280 3184 2685 3283 3282 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $22340 m0 *1 442.96,418.32
X$22340 3778 9264 2685 3280 9263 3849 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $22342 r0 *1 441.28,398.16
X$22342 3377 9263 3378 3418 9264 2685 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $22348 m0 *1 524.16,297.36
X$22348 2686 9264 2766 9263 2691 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $22354 r0 *1 436.8,327.6
X$22354 9264 2739 2686 3448 3079 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $22366 m0 *1 466.48,418.32
X$22366 9263 3830 9264 3846 2687 3589 3805 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $22369 m0 *1 476.56,418.32
X$22369 9264 9263 3848 3589 2687 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $22372 r0 *1 474.32,388.08
X$22372 3589 3633 2687 3588 9263 9264 3552 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $22374 m0 *1 475.44,388.08
X$22374 9263 3633 9264 3590 2687 3589 3588 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $22382 r0 *1 478.24,398.16
X$22382 9264 3589 2687 9263 3419 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $22384 m0 *1 476.56,408.24
X$22384 3743 9264 3589 2687 9263 3712 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $22389 m0 *1 473.76,327.6
X$22389 9263 9264 3040 2918 2688 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $22391 r0 *1 460.32,317.52
X$22391 2688 2911 2982 3040 9264 9263 3017 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $22393 r0 *1 478.24,327.6
X$22393 3127 9263 2688 2741 9264 3129 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $22403 m0 *1 515.76,307.44
X$22403 9264 9263 2740 2689 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $22408 r0 *1 503.44,297.36
X$22408 9264 2740 2742 2690 2917 2815 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $22413 r0 *1 516.88,297.36
X$22413 9264 2798 2742 9263 2690 2740 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $22416 r0 *1 529.2,297.36
X$22416 9264 9263 2740 2744 2691 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22421 r0 *1 552.72,297.36
X$22421 9264 9263 2692 2799 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $22446 m0 *1 642.32,327.6
X$22446 9263 2938 9264 2994 3100 2695 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $22449 m0 *1 633.36,317.52
X$22449 9263 2994 3003 2695 2938 2801 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $22468 m0 *1 714,307.44
X$22468 2931 9264 9263 2806 2698 2865 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $22471 r0 *1 717.36,307.44
X$22471 9263 2699 2928 9264 2930 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $22476 r0 *1 72.8,337.68
X$22476 9264 3216 9263 3064 3156 2700 3107 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $22478 m0 *1 109.2,458.64
X$22478 9264 4163 2700 4124 4026 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $22480 r0 *1 121.52,448.56
X$22480 9263 2700 4124 9264 4145 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22483 r0 *1 95.2,418.32
X$22483 9264 9263 2700 3761 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $22485 r0 *1 120.96,438.48
X$22485 9263 4025 2700 9264 3993 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22487 m0 *1 122.64,458.64
X$22487 9264 9263 2700 4183 3810 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22499 m0 *1 104.16,448.56
X$22499 9263 3792 9264 2700 4095 3856 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $22502 r0 *1 111.44,438.48
X$22502 3912 3525 3856 4026 2700 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $22511 r0 *1 63.28,317.52
X$22511 2702 2885 2884 9264 9263 3155 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $22513 r0 *1 28,327.6
X$22513 2717 9263 3062 2702 9264 3063 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $22515 r0 *1 49.28,317.52
X$22515 9264 2884 2885 3021 2702 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $22518 m0 *1 51.52,317.52
X$22518 9264 2884 2885 2883 2702 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $22526 r0 *1 78.96,317.52
X$22526 9264 3218 2953 2702 2872 2884 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $22528 r0 *1 31.36,317.52
X$22528 9264 3250 2951 2886 2702 2717 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $22535 m0 *1 170.8,347.76
X$22535 9264 9263 3271 3027 3222 2704 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22550 r0 *1 178.64,317.52
X$22550 9264 9263 3028 2893 2704 2961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22553 m0 *1 537.04,297.36
X$22553 9264 9263 2855 2705 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $22560 m0 *1 201.6,458.64
X$22560 4203 9263 2707 4163 9264 4204 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $22566 m0 *1 190.96,458.64
X$22566 9263 3522 4202 9264 2707 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $22573 r0 *1 427.28,378
X$22573 3463 9263 2709 3376 9264 3581 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $22577 r0 *1 437.92,367.92
X$22577 3376 2709 3418 9264 9263 2794 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $22579 m0 *1 441.84,307.44
X$22579 9263 2709 2791 9264 2848 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22581 r0 *1 438.48,297.36
X$22581 9264 9263 2709 2738 2791 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22590 m0 *1 433.44,378
X$22590 9264 3582 3418 9263 2709 3376 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $22592 r0 *1 433.44,378
X$22592 9264 3584 3463 9263 2709 3376 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $22606 r0 *1 338.8,307.44
X$22606 9264 2904 2880 9263 2881 2713 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $22641 m0 *1 81.76,388.08
X$22641 9264 9263 2718 3570 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $22680 r0 *1 142.24,297.36
X$22680 9264 9263 2873 2814 2725 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $22683 m0 *1 151.76,307.44
X$22683 9264 9263 2725 2941 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $22690 m0 *1 204.96,347.76
X$22690 9264 9263 2727 3226 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $22692 r0 *1 203.28,337.68
X$22692 9264 9263 3119 2896 2727 3116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22694 r0 *1 183.12,378
X$22694 9264 3492 3695 3493 9263 2727 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $22703 r0 *1 257.6,297.36
X$22703 9263 2729 2728 9264 2776 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22735 m0 *1 370.72,307.44
X$22735 9264 2731 2819 9263 2784 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $22746 r0 *1 397.04,297.36
X$22746 9264 9263 2734 2737 2732 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22754 r0 *1 384.16,297.36
X$22754 9263 2783 2784 9264 2733 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22757 m0 *1 417.76,317.52
X$22757 9264 3061 9263 2910 2734 2906 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $22759 r0 *1 431.2,307.44
X$22759 9264 2734 9263 2909 2851 2847 2738 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $22761 m0 *1 425.6,307.44
X$22761 9264 9263 2734 2793 2846 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22772 r0 *1 375.76,388.08
X$22772 9264 3550 3627 3628 2735 3580 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $22777 r0 *1 348.32,398.16
X$22777 9264 3706 2735 3726 3756 3626 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $22788 m0 *1 386.4,317.52
X$22788 9264 2735 2905 9263 2976 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $22790 r0 *1 446.32,297.36
X$22790 9264 9263 2736 2792 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $22796 m0 *1 438.48,297.36
X$22796 9263 2738 2736 9264 2740 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $22799 r0 *1 442.4,307.44
X$22799 9264 2741 2877 2914 2848 2737 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $22801 m0 *1 438.48,307.44
X$22801 9264 9263 2737 2879 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $22836 r0 *1 479.36,297.36
X$22836 9263 2741 2740 9264 2854 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $22840 m0 *1 459.2,327.6
X$22840 9263 2981 2741 9264 3040 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22845 m0 *1 455.84,307.44
X$22845 9263 2793 2741 9264 2795 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22853 r0 *1 455.28,317.52
X$22853 9264 9263 2981 3018 2741 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22879 m0 *1 572.88,307.44
X$22879 9264 2745 2855 2860 2856 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $22897 m0 *1 653.52,307.44
X$22897 9263 2754 9264 2750 2808 2863 2809 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $22904 r0 *1 631.68,297.36
X$22904 9263 2861 2860 9264 2751 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22907 r0 *1 642.32,347.76
X$22907 2753 2752 3194 3292 3352 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $22910 m0 *1 642.32,347.76
X$22910 9263 2862 3251 2752 3293 3196 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $22913 m0 *1 648.48,307.44
X$22913 9264 9263 2752 2809 2862 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22923 r0 *1 651.28,297.36
X$22923 9263 2752 2753 9264 2754 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22925 r0 *1 651.84,347.76
X$22925 9263 3196 3398 3293 3294 2752 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $22927 m0 *1 642.32,357.84
X$22927 3347 9263 3429 2753 9264 3348 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $22943 m0 *1 682.08,317.52
X$22943 2756 2864 2868 2926 9264 9263 2933 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $22970 r0 *1 112.56,337.68
X$22970 9264 9263 2763 3203 3158 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22973 m0 *1 93.52,357.84
X$22973 9264 3066 3315 3219 3215 2763 3220 9263
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $22977 m0 *1 116.48,327.6
X$22977 9263 2763 2954 9264 3068 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22985 r0 *1 588.56,327.6
X$22985 2764 9263 3083 2992 9264 3085 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $22989 r0 *1 584.08,337.68
X$22989 2764 3084 3083 2992 9264 9263 3206 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $22998 r0 *1 587.44,347.76
X$22998 9264 9263 3291 3345 2764 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23010 m0 *1 48.16,398.16
X$23010 9264 3691 3450 3662 2768 2883 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $23012 r0 *1 31.36,388.08
X$23012 2768 9263 3020 3569 9264 2883 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $23017 m0 *1 39.76,357.84
X$23017 3021 9264 2768 3020 9263 3439 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $23022 r0 *1 49.28,398.16
X$23022 9263 3095 9264 3153 3693 2768 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $23029 r0 *1 94.64,307.44
X$23029 9264 9263 2769 2936 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $23045 r0 *1 101.92,307.44
X$23045 9263 2936 2770 9264 2824 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23055 m0 *1 95.2,337.68
X$23055 9264 9263 2773 3108 3158 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23058 m0 *1 112,317.52
X$23058 9263 2773 2954 9264 2956 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23069 r0 *1 241.36,327.6
X$23069 9264 9263 2774 2964 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $23076 m0 *1 238.56,307.44
X$23076 9264 2775 2818 2777 2831 9263 3230 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $23079 m0 *1 233.52,307.44
X$23079 9264 9263 2775 2830 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $23084 m0 *1 257.6,307.44
X$23084 9263 2776 9264 2775 2777 2832 2831 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $23093 r0 *1 219.52,428.4
X$23093 9263 3989 9264 3918 2777 3870 2831 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $23095 m0 *1 233.52,317.52
X$23095 2943 2897 2831 2963 2777 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $23097 r0 *1 274.96,388.08
X$23097 9264 3497 3576 2777 2831 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $23110 r0 *1 276.64,307.44
X$23110 9263 2834 9264 2947 2777 2835 2831 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $23113 r0 *1 236.88,408.24
X$23113 3701 9264 2777 3769 9263 3791 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $23115 m0 *1 230.16,428.4
X$23115 9263 3868 3907 2777 2900 3863 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $23117 r0 *1 238,438.48
X$23117 9264 2777 3769 9263 4065 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $23119 r0 *1 217.84,448.56
X$23119 9264 4031 3997 2777 4029 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $23139 m0 *1 313.6,428.4
X$23139 9264 9263 3875 3922 2780 4004 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $23142 m0 *1 297.36,418.32
X$23142 9264 2780 3754 3753 3797 3546 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $23156 m0 *1 346.64,307.44
X$23156 9264 2782 2781 9263 2842 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $23163 m0 *1 376.88,307.44
X$23163 9264 9263 2783 2843 2784 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23182 r0 *1 392.56,307.44
X$23182 9264 2844 2785 2786 2845 3078 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $23184 m0 *1 402.08,307.44
X$23184 9263 2844 2785 9264 2787 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23188 m0 *1 394.8,307.44
X$23188 9264 9263 2844 2846 2785 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23191 m0 *1 379.68,337.68
X$23191 2973 9263 2949 2786 9264 3123 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $23193 m0 *1 390.32,327.6
X$23193 9264 9263 2977 2980 2786 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23206 r0 *1 399.28,388.08
X$23206 9264 3378 2788 3673 3629 3707 3674 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $23215 m0 *1 422.24,367.92
X$23215 9264 9263 3331 3330 2790 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $23220 m0 *1 440.72,367.92
X$23220 9264 3418 2790 3378 3377 3379 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $23222 m0 *1 442.4,357.84
X$23222 9263 2790 2912 9264 3332 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23224 r0 *1 433.44,347.76
X$23224 9264 9263 2790 3280 2912 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23233 r0 *1 440.72,337.68
X$23233 2791 9263 3080 3124 9264 3185 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $23237 m0 *1 436.24,337.68
X$23237 9264 3127 2791 9263 3080 3124 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $23239 r0 *1 434,357.84
X$23239 9264 3418 3376 3378 3377 2791 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $23241 m0 *1 446.88,307.44
X$23241 9264 2879 9263 2792 2877 2793 2848 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $23250 r0 *1 451.36,388.08
X$23250 9263 3711 2794 9264 3631 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23252 m0 *1 448,347.76
X$23252 9264 3126 2849 2794 3212 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $23261 m0 *1 441.84,398.16
X$23261 9263 2817 3676 3675 2794 3711 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $23263 m0 *1 456.4,398.16
X$23263 2794 3687 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $23265 r0 *1 458.08,398.16
X$23265 2794 3661 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $23270 m0 *1 486.64,307.44
X$23270 2795 2945 2796 2815 2914 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $23277 r0 *1 500.64,307.44
X$23277 9264 9263 2915 2914 2796 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $23285 r0 *1 506.8,327.6
X$23285 2797 3256 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $23287 m0 *1 506.8,337.68
X$23287 9264 3131 2797 3132 9263 3133 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $23297 m0 *1 523.04,317.52
X$23297 9264 9263 2987 2798 2916 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $23312 m0 *1 601.44,307.44
X$23312 2800 9264 2858 9263 2859 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $23314 r0 *1 601.44,307.44
X$23314 9263 2800 2858 9264 2861 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $23325 r0 *1 634.48,327.6
X$23325 9263 3047 3137 2994 3101 2803 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $23328 m0 *1 666.4,307.44
X$23328 9264 9263 2804 2869 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $23354 r0 *1 59.36,378
X$23354 9263 2810 3155 9264 3535 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23357 r0 *1 58.8,367.92
X$23357 9264 9263 2810 3523 3155 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23370 m0 *1 586.88,317.52
X$23370 9263 2991 2920 9264 2812 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $23375 m0 *1 137.2,317.52
X$23375 9263 2814 3026 2891 3002 2826 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $23383 r0 *1 130.48,307.44
X$23383 9264 2814 2939 9263 2954 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $23393 r0 *1 159.6,347.76
X$23393 9263 2816 9264 3165 3317 3316 3270 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $23400 r0 *1 431.76,388.08
X$23400 9263 3581 9264 3742 3630 3675 2817 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $23416 r0 *1 322.56,307.44
X$23416 9264 9263 2839 2819 2838 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23420 r0 *1 14.56,317.52
X$23420 9264 9263 3313 2950 2820 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $23443 r0 *1 120.96,307.44
X$23443 9264 9263 2824 2890 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $23454 r0 *1 123.2,317.52
X$23454 3023 9264 2940 2825 9263 3024 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $23458 r0 *1 140.56,307.44
X$23458 9263 2873 9264 2826 2940 2827 2825 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $23462 r0 *1 150.64,307.44
X$23462 9263 9264 2827 2892 2941 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $23478 m0 *1 202.72,337.68
X$23478 9264 9263 3116 2829 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $23482 r0 *1 215.6,337.68
X$23482 9264 9263 3168 3032 3226 2829 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23492 r0 *1 230.72,317.52
X$23492 9264 3005 9263 2830 3117 2899 2900 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $23495 r0 *1 231.84,428.4
X$23495 9264 3869 2831 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $23507 m0 *1 246.96,438.48
X$23507 9264 9263 3998 2831 4067 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $23509 m0 *1 236.32,448.56
X$23509 9264 4067 2899 2831 4031 4066 9263 3923 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $23518 m0 *1 221.76,438.48
X$23518 9263 3995 9264 3915 3999 2831 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $23520 r0 *1 283.92,317.52
X$23520 9263 2832 2966 9264 2967 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23525 r0 *1 274.96,317.52
X$23525 9263 9264 2966 3173 2832 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $23529 m0 *1 267.12,317.52
X$23529 9263 2901 2968 2833 2946 2899 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $23534 m0 *1 284.48,317.52
X$23534 9264 9263 2835 2969 2968 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23536 m0 *1 289.52,317.52
X$23536 9263 2835 2968 9264 2902 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23541 m0 *1 289.52,327.6
X$23541 9264 3035 2967 2836 3151 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $23545 m0 *1 328.72,327.6
X$23545 9263 2836 3233 9264 3034 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23575 m0 *1 356.16,317.52
X$23575 9264 2973 9263 2840 3011 2974 2975 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $23603 r0 *1 400.4,317.52
X$23603 9264 9263 2977 2845 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $23605 r0 *1 425.04,307.44
X$23605 9264 9263 2846 2908 2847 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23629 r0 *1 451.36,357.84
X$23629 9263 3377 3378 9264 2849 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23634 r0 *1 467.6,317.52
X$23634 9264 2912 9263 2983 3017 2918 3012 2850
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $23636 r0 *1 464.24,307.44
X$23636 9263 2910 2982 9264 2850 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23639 r0 *1 478.24,307.44
X$23639 9263 2913 2851 9264 2876 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23646 m0 *1 474.88,337.68
X$23646 9264 9263 2852 3146 3128 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23650 m0 *1 464.8,337.68
X$23650 9264 3125 3126 9263 2852 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $23664 m0 *1 577.36,317.52
X$23664 9264 9263 2855 2920 2856 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23675 r0 *1 510.16,317.52
X$23675 9264 2916 2855 9263 2876 2918 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $23689 m0 *1 571.2,347.76
X$23689 9264 3243 3244 9263 2857 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $23703 r0 *1 622.16,367.92
X$23703 3517 3445 2859 3478 9263 9264 3521 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $23706 m0 *1 650.16,317.52
X$23706 9263 2860 3003 9264 3000 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $23721 r0 *1 623.28,337.68
X$23721 9264 9263 2862 3193 3192 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $23732 m0 *1 657.44,357.84
X$23732 9264 3393 3391 3351 2863 3297 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $23736 r0 *1 682.08,307.44
X$23736 9264 9263 2864 2934 2868 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23740 m0 *1 702.8,317.52
X$23740 9264 2927 3197 2865 2996 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $23760 m0 *1 687.12,327.6
X$23760 9263 3093 2868 9264 3049 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $23790 r0 *1 510.16,307.44
X$23790 9264 2918 2991 2876 2944 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $23839 r0 *1 52.08,307.44
X$23839 9263 2884 2885 9264 2886 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23872 r0 *1 63.84,367.92
X$23872 9263 2887 3153 9264 3114 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $23878 m0 *1 112,337.68
X$23878 9263 2889 2955 9264 3109 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23882 m0 *1 101.36,337.68
X$23882 9264 9263 2955 3204 2889 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23897 m0 *1 147.84,317.52
X$23897 9263 2891 2892 9264 2958 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $23899 r0 *1 139.44,317.52
X$23899 9263 2891 2892 2939 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $23902 r0 *1 148.96,317.52
X$23902 2891 9264 2892 9263 3027 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $23915 m0 *1 165.76,317.52
X$23915 9264 9263 2959 2961 2958 2893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23921 m0 *1 190.4,317.52
X$23921 9264 9263 2895 2894 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $23943 m0 *1 249.2,317.52
X$23943 9264 2966 2898 2965 2900 2899 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $23946 r0 *1 240.8,448.56
X$23946 9264 4003 4153 2899 4032 4127 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $23948 m0 *1 228.48,458.64
X$23948 9264 4231 2899 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $23952 r0 *1 258.72,408.24
X$23952 2899 2900 3772 3773 3771 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $23954 r0 *1 260.4,357.84
X$23954 2946 9263 2899 3368 9264 3410 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $23956 m0 *1 252.56,357.84
X$23956 9264 9263 2899 3229 2946 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23959 r0 *1 261.52,388.08
X$23959 9263 2899 2946 3231 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $23969 r0 *1 253.12,317.52
X$23969 9264 3122 3006 2965 2946 2899 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $23976 r0 *1 239.68,418.32
X$23976 9264 9263 3701 3685 2900 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $23988 m0 *1 245.84,428.4
X$23988 9263 3907 9264 3867 3948 2900 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $23999 m0 *1 297.92,317.52
X$23999 9263 9264 2903 2970 2902 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $24002 r0 *1 301.28,438.48
X$24002 4003 9263 4034 2903 9264 3923 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $24004 r0 *1 291.76,428.4
X$24004 9264 3821 9263 4002 2903 3959 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $24022 m0 *1 392,408.24
X$24022 9263 2906 3528 9264 3777 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24024 r0 *1 391.44,408.24
X$24024 9264 3778 2906 3528 3826 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $24026 r0 *1 376.32,337.68
X$24026 3237 2949 2973 9264 9263 2906 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $24029 m0 *1 392,317.52
X$24029 9264 9263 2978 3014 2906 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24043 m0 *1 421.12,327.6
X$24043 9264 9263 3038 2906 3076 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $24047 m0 *1 425.04,317.52
X$24047 9264 9263 2980 2909 2908 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24053 m0 *1 459.76,317.52
X$24053 9264 9263 2910 2911 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $24059 m0 *1 470.4,317.52
X$24059 9263 2912 2910 9264 3015 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $24062 m0 *1 463.12,317.52
X$24062 9264 2911 9263 3059 3018 2913 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $24071 m0 *1 447.44,357.84
X$24071 9263 2912 3360 9264 3359 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24082 m0 *1 441.84,327.6
X$24082 2982 9263 9264 3039 2912 3038 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $24100 m0 *1 499.52,317.52
X$24100 9264 9263 2985 3131 2915 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24107 r0 *1 541.52,357.84
X$24107 9263 2917 3244 3383 3340 3342 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $24109 m0 *1 549.92,357.84
X$24109 9263 3383 2917 9264 3288 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24111 m0 *1 542.08,347.76
X$24111 9264 9263 3242 3383 2917 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $24115 m0 *1 505.68,367.92
X$24115 9264 2917 3382 3383 3421 3422 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $24117 m0 *1 538.16,337.68
X$24117 9264 3042 3084 3241 3082 2917 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $24119 r0 *1 510.16,357.84
X$24119 9264 3382 9263 3401 2917 3383 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $24133 r0 *1 500.64,317.52
X$24133 9263 2918 3013 9264 2986 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $24145 r0 *1 516.32,327.6
X$24145 9264 3041 2919 3133 9263 3081 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $24151 r0 *1 528.64,317.52
X$24151 9263 2988 9264 3042 2989 2919 2990 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $24163 m0 *1 517.44,378
X$24163 2919 9264 3464 3514 9263 3424 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $24168 m0 *1 528.08,327.6
X$24168 9263 2987 9264 3044 2989 2919 3041 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $24170 r0 *1 609.28,337.68
X$24170 9264 2991 9263 3193 2920 2993 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $24173 r0 *1 603.12,337.68
X$24173 2991 9263 2993 2920 9264 3192 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $24184 m0 *1 633.92,347.76
X$24184 9264 9263 3297 2921 3100 3300 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24186 r0 *1 624.4,347.76
X$24186 9263 2921 9264 3300 3386 3388 3194 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $24191 r0 *1 611.52,317.52
X$24191 3045 9264 2991 2993 9263 2922 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $24200 m0 *1 486.08,388.08
X$24200 9264 3634 3591 3551 3611 9263 2925 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $24203 m0 *1 554.96,398.16
X$24203 9264 3515 3680 3641 3514 2925 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $24208 r0 *1 577.92,388.08
X$24208 9264 2925 3657 9263 3643 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $24211 m0 *1 686,357.84
X$24211 9263 3396 2926 3433 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $24215 r0 *1 701.68,307.44
X$24215 9264 2927 2931 2928 2932 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $24223 m0 *1 692.16,347.76
X$24223 9264 9263 2930 3247 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $24254 r0 *1 618.24,378
X$24254 9263 3606 3517 3597 3648 2937 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $24274 r0 *1 224,438.48
X$24274 4028 4030 2942 3227 9264 9263 3769 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $24281 m0 *1 224.56,448.56
X$24281 9264 4153 4028 9263 2942 3227 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $24298 m0 *1 245.84,398.16
X$24298 9264 9263 3701 3685 2946 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $24323 m0 *1 373.52,347.76
X$24323 9264 3237 3358 2973 3278 2949 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $24329 r0 *1 379.68,317.52
X$24329 9263 2973 2949 9264 2977 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24344 r0 *1 43.68,347.76
X$24344 9264 3097 3155 3153 2952 3053 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $24347 m0 *1 46.48,357.84
X$24347 9264 3097 2952 3053 9263 3216 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $24352 m0 *1 44.24,347.76
X$24352 9264 3220 2952 3097 3053 3021 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $24354 m0 *1 46.48,337.68
X$24354 9264 3021 3097 2952 9263 3215 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $24370 m0 *1 131.04,337.68
X$24370 9263 2957 2954 9264 3161 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $24385 r0 *1 116.48,327.6
X$24385 9264 9263 3111 2956 3022 3068 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24388 r0 *1 105.84,347.76
X$24388 9264 3314 3066 2957 3268 3159 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $24392 r0 *1 120.96,337.68
X$24392 9264 3481 3025 2957 3110 3159 3158 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $24401 r0 *1 83.44,337.68
X$24401 9263 3065 9264 2957 3160 3154 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $24403 r0 *1 173.6,317.52
X$24403 9263 2958 2961 9264 2962 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24424 m0 *1 166.88,337.68
X$24424 3113 2962 3208 3209 9263 9264 3163 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $24429 m0 *1 232.96,337.68
X$24429 9263 9264 2963 3117 3147 3168 3148 3118 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $24463 m0 *1 304.08,438.48
X$24463 9263 4004 9264 4024 3922 2969 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $24469 m0 *1 308,388.08
X$24469 9264 3577 2970 2971 3505 3508 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $24473 r0 *1 310.24,378
X$24473 9264 3458 2970 2971 3545 3547 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $24475 m0 *1 310.8,378
X$24475 9264 3414 2970 2971 3532 3509 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $24477 m0 *1 300.16,398.16
X$24477 9264 3798 2970 2971 3704 3660 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $24486 r0 *1 313.04,418.32
X$24486 3547 3921 3910 2970 9264 9263 3822 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $24502 r0 *1 285.6,408.24
X$24502 9264 2971 3797 3753 3546 3754 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $24504 r0 *1 317.52,428.4
X$24504 9264 9263 4023 2971 3922 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $24519 m0 *1 348.88,327.6
X$24519 9264 9263 3035 3034 2973 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $24545 m0 *1 403.2,357.84
X$24545 9264 2978 3331 3361 3181 2979 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $24554 r0 *1 387.52,357.84
X$24554 3375 9263 3358 3279 9264 2978 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $24556 m0 *1 400.96,448.56
X$24556 9264 3926 4006 3852 2979 4080 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $24570 r0 *1 394.8,327.6
X$24570 3036 9264 2980 3076 9263 3077 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $24572 r0 *1 416.08,327.6
X$24572 3105 2980 3079 3076 9264 9263 3104 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $24576 m0 *1 408.8,327.6
X$24576 9263 3036 2980 9264 3061 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24589 r0 *1 423.36,327.6
X$24589 9263 2981 9264 3104 3080 3103 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $24599 r0 *1 401.52,327.6
X$24599 9263 3077 9264 3037 2983 3123 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $24604 r0 *1 500.64,357.84
X$24604 2984 9264 3334 9263 3382 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $24608 r0 *1 467.6,357.84
X$24608 9264 9263 3380 2984 3283 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24614 m0 *1 560,327.6
X$24614 2986 9264 3044 9263 3045 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $24616 r0 *1 560,327.6
X$24616 9263 2986 3044 9264 3083 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $24633 r0 *1 543.2,388.08
X$24633 9263 3596 9264 3641 2989 3638 2990 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $24635 m0 *1 526.96,388.08
X$24635 9263 3594 9264 3639 2989 3607 2990 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $24638 m0 *1 540.4,398.16
X$24638 2989 9263 2990 3679 9264 3336 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $24640 m0 *1 523.04,337.68
X$24640 9264 3133 2989 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $24651 m0 *1 547.12,388.08
X$24651 3638 9264 2989 2990 9263 3599 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $24654 r0 *1 546.56,398.16
X$24654 3638 2989 2990 3596 9263 9264 3680 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $24658 r0 *1 534.8,357.84
X$24658 3400 9264 2990 3339 9263 3241 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $24660 r0 *1 528.08,367.92
X$24660 9264 3041 2990 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $24666 m0 *1 539.84,357.84
X$24666 9263 3288 9264 3340 2990 3400 3339 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $24677 m0 *1 610.4,327.6
X$24677 3045 9264 2991 2993 9263 3087 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $24690 r0 *1 609.28,327.6
X$24690 9263 3045 9264 2993 3086 2991 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $24703 r0 *1 576.8,337.68
X$24703 3084 9263 3083 2992 9264 3356 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $24717 r0 *1 644.56,357.84
X$24717 9264 3429 3347 3348 9263 2994 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $24731 m0 *1 720.72,327.6
X$24731 9264 9263 3051 3050 2998 2995 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24745 m0 *1 710.08,327.6
X$24745 9263 2999 2997 9264 3094 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24755 m0 *1 717.36,347.76
X$24755 9263 3198 2997 9264 3249 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24769 r0 *1 719.04,418.32
X$24769 3889 9263 3839 3890 9264 2998 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $24778 r0 *1 661.36,327.6
X$24778 9263 3098 3392 3096 3143 3000 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $24784 m0 *1 660.8,327.6
X$24784 9264 3054 9263 3098 3001 3048 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $24787 r0 *1 656.32,327.6
X$24787 9264 9263 3048 3090 3001 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24811 m0 *1 552.16,327.6
X$24811 9264 9263 3007 3043 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $24859 r0 *1 26.32,347.76
X$24859 9264 3063 3402 3265 3019 3264 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $24899 r0 *1 93.52,347.76
X$24899 3220 9263 9264 3022 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $24907 r0 *1 43.68,398.16
X$24907 9264 9263 3690 3022 3250 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $24909 r0 *1 71.68,378
X$24909 9264 3023 3216 3535 3477 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $24911 r0 *1 108.64,378
X$24911 3267 9263 3023 3353 9264 3536 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $24913 m0 *1 119.28,378
X$24913 9264 9263 3023 3487 3353 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24915 r0 *1 101.92,367.92
X$24915 9264 3364 3267 3023 3452 3157 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $24917 m0 *1 95.76,367.92
X$24917 9264 3364 3157 3023 3267 3664 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $24921 r0 *1 109.76,357.84
X$24921 9264 3315 3364 3353 3023 3270 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $24932 r0 *1 122.08,388.08
X$24932 9264 3616 3696 3538 3023 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $24934 m0 *1 123.76,367.92
X$24934 9264 9263 3480 3269 3405 3024 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24941 r0 *1 133.84,347.76
X$24941 9264 9263 3025 3269 3110 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24943 m0 *1 156.8,337.68
X$24943 3110 3025 3111 3208 3112 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $24945 r0 *1 159.04,337.68
X$24945 3025 3110 3111 3207 9264 9263 3209 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $24952 r0 *1 128.24,408.24
X$24952 3666 3026 3662 3763 9264 9263 3858 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $24958 m0 *1 126.56,408.24
X$24958 9264 3762 3666 9263 3026 3763 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $24970 m0 *1 187.6,327.6
X$24970 9264 9263 3028 3055 3029 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24975 r0 *1 178.08,327.6
X$24975 9263 3028 3029 9264 3071 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24982 r0 *1 165.76,327.6
X$24982 9264 3112 9263 3113 3114 3030 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $24987 r0 *1 210,347.76
X$24987 9264 9263 3226 3320 3031 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24990 r0 *1 200.48,347.76
X$24990 3271 9264 3031 9263 3272 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $25008 m0 *1 338.8,347.76
X$25008 3178 9263 3235 3034 9264 3262 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $25019 r0 *1 344.96,347.76
X$25019 9263 3178 9264 3324 3236 3034 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $25028 m0 *1 390.32,337.68
X$25028 9263 3036 3123 9264 3181 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $25031 r0 *1 409.36,327.6
X$25031 9264 9263 3036 3105 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $25034 m0 *1 403.76,327.6
X$25034 9264 9263 3036 3037 3076 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25041 m0 *1 354.48,347.76
X$25041 3180 9263 3277 3309 9264 3036 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $25053 m0 *1 449.68,327.6
X$25053 9264 9263 3060 3039 3038 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $25064 m0 *1 406,347.76
X$25064 9264 3039 3259 9263 3260 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $25081 r0 *1 513.52,367.92
X$25081 9264 3464 3514 9263 3041 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $25105 r0 *1 616.56,337.68
X$25105 3045 9264 3144 3191 9263 3245 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $25108 m0 *1 632.24,337.68
X$25108 9264 3046 3089 9263 3194 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $25121 m0 *1 695.52,347.76
X$25121 9263 3049 3396 3349 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $25163 r0 *1 617.68,398.16
X$25163 9263 3678 3718 9264 3056 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $25169 m0 *1 464.24,327.6
X$25169 9263 3060 3059 9264 3058 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $25183 r0 *1 57.12,398.16
X$25183 3062 9263 3313 3095 9264 3728 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $25186 m0 *1 57.68,418.32
X$25186 9263 3062 3662 9264 3841 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $25188 m0 *1 45.36,408.24
X$25188 9264 9263 3062 3727 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $25233 m0 *1 154,347.76
X$25233 9264 9263 3255 3254 3069 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25240 m0 *1 169.68,388.08
X$25240 9264 9263 3070 3572 3697 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $25242 r0 *1 175.84,388.08
X$25242 9264 9263 3572 3617 3070 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25249 r0 *1 165.76,388.08
X$25249 9264 3572 3070 9263 3818 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $25252 r0 *1 171.92,337.68
X$25252 9264 9263 3162 3163 3222 3071 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25257 m0 *1 191.52,337.68
X$25257 9264 9263 3072 3115 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $25269 m0 *1 284.48,337.68
X$25269 9264 3179 3073 3150 3174 3175 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $25274 r0 *1 294.56,337.68
X$25274 9264 9263 3074 3175 3174 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $25278 r0 *1 305.76,337.68
X$25278 9264 9263 3177 3176 3074 3213 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25285 r0 *1 332.64,367.92
X$25285 9264 3414 3457 3413 3458 3075 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $25315 m0 *1 374.08,367.92
X$25315 9263 3462 3417 9264 3076 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $25345 r0 *1 528.64,327.6
X$25345 3081 3134 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $25349 m0 *1 493.92,337.68
X$25349 9264 9263 3130 3082 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $25380 r0 *1 594.72,327.6
X$25380 9264 3084 3085 9263 3136 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $25389 m0 *1 600.32,337.68
X$25389 9264 3135 3136 3087 3086 3138 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $25393 r0 *1 621.04,327.6
X$25393 9264 3089 3088 9263 3086 3087 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $25401 m0 *1 623.28,337.68
X$25401 9264 9263 3144 3088 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $25404 r0 *1 631.12,327.6
X$25404 9264 9263 3089 3101 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $25411 r0 *1 670.88,327.6
X$25411 9264 9263 3090 3091 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $25417 r0 *1 664.16,367.92
X$25417 3090 9264 3432 3431 9263 3476 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $25425 m0 *1 676.48,337.68
X$25425 9264 9263 3139 3092 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $25436 r0 *1 45.92,388.08
X$25436 9264 3653 3153 3651 3095 3652 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $25479 r0 *1 243.6,347.76
X$25479 3229 3168 3102 3228 9264 9263 3409 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $25481 m0 *1 246.4,337.68
X$25481 9264 3119 9263 3120 3102 3229 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $25483 m0 *1 250.32,347.76
X$25483 9263 3119 3102 9264 3121 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $25512 r0 *1 92.4,337.68
X$25512 9264 9263 3157 3108 3220 3203 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25539 m0 *1 168,378
X$25539 9264 9263 3527 3481 3114 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $25548 m0 *1 144.48,378
X$25548 9264 3481 3114 9263 3540 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $25559 m0 *1 195.44,347.76
X$25559 9263 3225 3165 9264 3116 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $25564 m0 *1 245.28,347.76
X$25564 9264 9263 3118 3273 3228 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25567 r0 *1 239.68,337.68
X$25567 9263 3119 3118 9264 3171 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $25587 m0 *1 255.36,337.68
X$25587 9264 3120 9263 3151 3121 3169 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $25592 r0 *1 249.2,337.68
X$25592 9264 3175 3148 3169 3170 3120 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $25598 m0 *1 258.16,347.76
X$25598 3231 3230 3122 3210 9264 9263 3170 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $25600 r0 *1 283.92,357.84
X$25600 9263 3230 3122 9264 3371 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $25606 m0 *1 282.8,357.84
X$25606 9263 9264 3230 3546 3122 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $25608 r0 *1 274.96,357.84
X$25608 9263 9264 3230 3503 3122 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $25622 r0 *1 464.24,347.76
X$25622 9264 9263 3126 3125 3284 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $25626 m0 *1 461.44,347.76
X$25626 9264 3127 3589 3126 3125 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $25629 m0 *1 400.96,347.76
X$25629 9263 3311 3260 9264 3125 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $25645 r0 *1 474.32,357.84
X$25645 9263 3329 3128 9264 3420 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $25648 r0 *1 460.88,357.84
X$25648 9264 9263 3379 3128 3359 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25653 m0 *1 480.48,337.68
X$25653 9263 3146 3129 9264 3130 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $25659 r0 *1 507.92,337.68
X$25659 3132 9263 3131 3187 9264 3257 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $25665 m0 *1 510.72,357.84
X$25665 3336 9264 3132 3131 9263 3339 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $25672 m0 *1 505.12,357.84
X$25672 9264 9263 3334 3132 3335 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25684 r0 *1 525.28,357.84
X$25684 3134 3338 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $25693 r0 *1 632.8,337.68
X$25693 3195 9264 3137 9263 3143 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $25696 m0 *1 626.64,367.92
X$25696 3388 3389 3386 3137 9263 9264 3471 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $25702 m0 *1 630,378
X$25702 9264 9263 3554 3138 3521 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $25711 r0 *1 700,559.44
X$25711 9264 9263 5547 3141 3556 5548 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25727 r0 *1 124.88,367.92
X$25727 3525 3537 3452 3145 9264 9263 3441 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $25731 r0 *1 127.68,357.84
X$25731 9264 9263 3202 3365 3145 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25759 r0 *1 46.48,337.68
X$25759 9264 3154 3202 3152 3153 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $25803 r0 *1 76.16,367.92
X$25803 9264 3451 3403 3522 3402 3156 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $25807 m0 *1 76.16,367.92
X$25807 9264 3366 3402 3522 3403 3156 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $25809 m0 *1 110.32,378
X$25809 3267 9263 3364 3157 9264 3538 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $25819 r0 *1 101.92,357.84
X$25819 9264 9263 3364 3405 3157 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25841 r0 *1 114.8,378
X$25841 9264 3539 3536 3537 3525 9263 3160 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $25845 r0 *1 173.6,378
X$25845 3489 3541 3542 3162 9264 9263 3573 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $25849 r0 *1 167.44,378
X$25849 3489 9263 3541 3162 9264 3496 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $25866 r0 *1 194.88,398.16
X$25866 3697 3731 3698 3166 9264 9263 3454 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $25874 m0 *1 242.48,357.84
X$25874 9264 3168 9263 3408 3273 3169 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $25886 m0 *1 266.56,438.48
X$25886 9264 3960 9263 3999 4104 4069 3169 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $25904 m0 *1 268.24,367.92
X$25904 9263 3369 3171 9264 3411 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $25906 r0 *1 260.4,378
X$25906 3545 3228 3369 3171 9264 9263 3612 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $25913 r0 *1 267.68,378
X$25913 3228 9263 3369 3171 9264 3568 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $25918 m0 *1 273.28,347.76
X$25918 3231 9264 3171 3261 9263 3172 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $25920 r0 *1 277.76,337.68
X$25920 9264 3174 3211 3172 3173 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $25924 m0 *1 295.68,367.92
X$25924 9264 3412 3484 3413 3322 3173 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $25929 r0 *1 302.96,367.92
X$25929 9263 9264 3412 3173 3531 3446 3462 3507 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $25947 r0 *1 301.84,347.76
X$25947 9264 9263 3176 3178 3233 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $25952 r0 *1 315.28,347.76
X$25952 3177 3307 3321 3263 9263 9264 3308 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $25974 m0 *1 345.52,357.84
X$25974 9264 3277 3178 9263 3235 3324 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $25977 r0 *1 301.28,378
X$25977 9264 9263 3508 3178 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $25988 r0 *1 393.68,357.84
X$25988 3375 9263 3358 3181 9264 3362 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $26001 r0 *1 416.64,337.68
X$26001 3182 9264 3214 3183 9263 3212 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $26015 r0 *1 479.36,357.84
X$26015 3186 9263 3239 3381 9264 3285 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $26019 m0 *1 536.48,367.92
X$26019 9263 3187 3424 9264 3425 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26023 m0 *1 523.04,367.92
X$26023 9264 3342 3187 3424 3401 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $26026 r0 *1 517.44,357.84
X$26026 9263 3422 9264 3423 3290 3187 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $26029 m0 *1 530.32,347.76
X$26029 3240 3188 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $26032 r0 *1 543.76,337.68
X$26032 3188 3287 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $26034 m0 *1 563.92,347.76
X$26034 9263 3189 3290 9264 3243 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26039 m0 *1 575.12,378
X$26039 3190 9263 3595 3515 9264 3344 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $26041 r0 *1 649.6,378
X$26041 9263 3191 3561 9264 3432 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $26046 r0 *1 606.48,388.08
X$26046 9264 9263 3720 3191 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $26050 m0 *1 618.24,347.76
X$26050 3193 3192 3388 3245 9263 9264 3348 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $26072 r0 *1 621.04,357.84
X$26072 3389 3428 3195 3445 9263 9264 3390 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $26077 m0 *1 600.32,357.84
X$26077 9263 3355 9264 3346 3206 3195 3291 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $26102 m0 *1 682.08,650.16
X$26102 9264 9263 6589 3199 3556 6580 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26108 m0 *1 672.56,347.76
X$26108 9264 9263 3201 3246 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $26113 r0 *1 119.84,418.32
X$26113 9264 3917 3817 3452 3202 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $26123 r0 *1 101.92,337.68
X$26123 9264 9263 3364 3205 3220 3204 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $26134 r0 *1 605.92,347.76
X$26134 9264 9263 3387 3291 3206 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $26174 m0 *1 39.2,388.08
X$26174 9264 3215 3558 3603 3569 9263 3604 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $26184 m0 *1 65.52,347.76
X$26184 9264 3267 3217 3216 3252 3253 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $26187 m0 *1 72.8,388.08
X$26187 9264 9263 3216 3654 3535 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $26190 r0 *1 71.12,398.16
X$26190 9264 3758 3216 3533 3692 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $26192 m0 *1 49.84,408.24
X$26192 9264 9263 3216 3691 3250 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $26207 r0 *1 73.92,388.08
X$26207 9263 3216 3533 9264 3663 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26209 r0 *1 64.4,418.32
X$26209 9263 3216 3569 9264 3856 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26235 m0 *1 151.2,357.84
X$26235 9263 3221 9264 3443 3317 3316 3270 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $26237 m0 *1 122.64,398.16
X$26237 9264 3668 3222 3722 3665 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $26239 r0 *1 147.28,357.84
X$26239 9264 3367 3366 3270 9263 3222 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $26248 m0 *1 132.16,367.92
X$26248 9264 3443 3406 3441 3442 3254 3222 9263
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $26256 m0 *1 187.6,357.84
X$26256 9264 3224 3271 3223 9263 3453 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $26258 r0 *1 189.28,347.76
X$26258 9263 3271 9264 3224 3303 3223 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $26276 m0 *1 213.92,378
X$26276 9264 9263 3226 3544 3496 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $26284 r0 *1 208.88,357.84
X$26284 9264 9263 3357 3319 3226 3303 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26302 m0 *1 248.64,378
X$26302 3500 9264 3497 9263 3228 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $26313 m0 *1 273.28,367.92
X$26313 9264 3410 9263 3506 3411 3229 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $26331 r0 *1 266.56,357.84
X$26331 9264 9263 3370 3368 3231 3411 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26335 r0 *1 264.32,398.16
X$26335 9264 3545 3753 3752 3231 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $26345 m0 *1 320.32,357.84
X$26345 9263 3322 3233 9264 3323 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26351 m0 *1 325.36,357.84
X$26351 9264 9263 3275 3322 3233 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $26362 m0 *1 287.84,367.92
X$26362 9263 3370 3371 9264 3233 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26364 r0 *1 341.6,378
X$26364 9264 3234 3460 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $26367 r0 *1 342.72,357.84
X$26367 9264 9263 3234 3324 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $26371 r0 *1 340.48,388.08
X$26371 3614 9263 3234 3624 9264 3671 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $26383 m0 *1 347.2,347.76
X$26383 9264 3262 9263 3309 3236 3274 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $26392 m0 *1 402.08,408.24
X$26392 9264 3737 9263 3238 3707 3736 3735 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $26395 m0 *1 415.52,418.32
X$26395 9263 3238 3828 9264 3779 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26397 r0 *1 407.68,398.16
X$26397 9263 3238 3737 9264 3673 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26399 r0 *1 400.4,378
X$26399 9264 3566 3238 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $26412 m0 *1 489.44,378
X$26412 3239 9263 9264 3512 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $26423 m0 *1 483.84,378
X$26423 9264 3284 3239 9263 3562 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $26425 r0 *1 525.28,347.76
X$26425 3286 3240 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $26428 r0 *1 547.68,347.76
X$26428 9264 3291 3241 3288 3242 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $26449 r0 *1 576.24,357.84
X$26449 9264 9263 3386 3243 3384 3399 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26464 r0 *1 655.2,650.16
X$26464 9264 9263 6632 3246 3556 6625 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26485 m0 *1 35.84,367.92
X$26485 9264 3250 3437 3727 3438 3363 9263 3404 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $26491 r0 *1 658.56,357.84
X$26491 9263 3251 3398 9264 3391 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26510 m0 *1 520.8,347.76
X$26510 3256 3306 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $26514 m0 *1 511.28,347.76
X$26514 3258 3257 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $26519 r0 *1 511.28,347.76
X$26519 3306 3258 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $26522 r0 *1 372.96,357.84
X$26522 9263 3373 3374 9264 3259 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26555 r0 *1 70.56,408.24
X$26555 3266 9264 3792 3439 9263 3759 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $26557 m0 *1 68.88,418.32
X$26557 9264 3792 3760 3439 3266 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $26576 r0 *1 132.72,357.84
X$26576 9263 3365 9264 3442 3317 3316 3270 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $26593 m0 *1 211.68,357.84
X$26593 3271 9264 3320 9263 3669 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $26603 m0 *1 203.28,378
X$26603 3574 9263 9264 3318 3496 3272 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $26605 m0 *1 206.64,357.84
X$26605 9264 9263 3318 3319 3272 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $26608 r0 *1 203.84,378
X$26608 3496 9264 3318 3272 9263 3610 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $26612 m0 *1 332.08,367.92
X$26612 9263 3407 3274 9264 3457 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26614 m0 *1 287.28,378
X$26614 3370 3274 3371 3504 9264 9263 3505 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $26616 r0 *1 351.68,367.92
X$26616 9263 3274 3414 9264 3459 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26627 r0 *1 280.56,378
X$26627 9264 9263 3274 3576 3500 3497 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26636 m0 *1 355.6,408.24
X$26636 9263 3276 9264 3326 3774 3775 3734 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $26642 r0 *1 389.76,378
X$26642 9263 3550 3278 3566 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $26644 r0 *1 388.64,347.76
X$26644 9263 3328 3278 9264 3310 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26653 m0 *1 376.32,378
X$26653 9264 9263 3549 3548 3278 3530 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26655 m0 *1 375.2,388.08
X$26655 9264 3279 3628 3627 3580 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $26658 r0 *1 384.72,367.92
X$26658 3510 3375 3358 3279 9264 9263 3528 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $26660 r0 *1 393.68,347.76
X$26660 9264 3329 3279 3311 3310 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $26662 m0 *1 386.4,357.84
X$26662 9264 9263 3279 3328 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $26669 r0 *1 421.68,438.48
X$26669 9263 4118 3850 3280 4116 4073 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $26680 m0 *1 452.48,357.84
X$26680 9264 9263 3282 3329 3281 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $26687 m0 *1 468.16,367.92
X$26687 9263 3283 3333 9264 3587 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26703 m0 *1 476,378
X$26703 9263 3551 9264 3512 3513 3284 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $26706 r0 *1 469.84,378
X$26706 3284 9264 3512 3551 9263 3564 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $26708 m0 *1 435.12,388.08
X$26708 9264 3285 3582 3378 3583 3377 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $26721 m0 *1 525.28,357.84
X$26721 3337 3286 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $26737 r0 *1 561.12,347.76
X$26737 3342 3305 3304 3289 9264 9263 3301 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $26758 r0 *1 641.76,378
X$26758 9263 3601 9264 3292 3561 3555 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $26760 r0 *1 588.56,398.16
X$26760 9264 3721 3786 3293 3749 3516 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $26762 r0 *1 644.56,367.92
X$26762 9264 9263 3473 3429 3293 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $26772 m0 *1 646.24,367.92
X$26772 3294 9263 9264 3347 3348 3430 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $26799 m0 *1 137.2,378
X$26799 9264 3489 3488 9263 3539 3302 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $26804 r0 *1 138.32,378
X$26804 3488 9263 3539 3302 9264 3572 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $26854 r0 *1 112.56,388.08
X$26854 9263 3536 3314 9264 3615 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26856 m0 *1 110.32,398.16
X$26856 9264 3684 9263 3665 3314 3536 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $26861 m0 *1 113.12,367.92
X$26861 9264 9263 3364 3479 3315 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $26864 m0 *1 157.36,388.08
X$26864 9264 9263 3367 3316 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $26866 m0 *1 124.32,378
X$26866 9263 3486 9264 3488 3317 3316 3487 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $26883 r0 *1 145.04,367.92
X$26883 9263 3481 9264 3317 3491 3316 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $26887 m0 *1 129.92,388.08
X$26887 9263 3452 9264 3366 3616 3316 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $26890 r0 *1 128.24,378
X$26890 9263 3538 9264 3563 3317 3316 3571 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $26892 m0 *1 123.2,388.08
X$26892 3316 9264 3317 3479 9263 3666 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $26895 r0 *1 86.24,428.4
X$26895 9264 3366 3317 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $26897 m0 *1 94.08,428.4
X$26897 9264 3861 3317 3893 3452 3857 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $26938 r0 *1 311.36,398.16
X$26938 9263 3621 9264 3704 3546 3322 3622 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $26949 m0 *1 293.44,388.08
X$26949 9263 9264 3576 3322 3357 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $26951 m0 *1 318.08,398.16
X$26951 3689 9263 9264 3503 3322 3622 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $26953 r0 *1 309.68,388.08
X$26953 3322 3546 3621 3622 9263 9264 3660 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $26958 m0 *1 346.08,388.08
X$26958 9264 3580 3614 3324 3625 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $26963 m0 *1 355.04,367.92
X$26963 3407 9263 3459 3324 9264 3416 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $26968 m0 *1 352.8,357.84
X$26968 9263 3414 3324 9264 3327 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $26971 r0 *1 367.36,398.16
X$26971 9264 9263 3614 3325 3672 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $26977 r0 *1 364,438.48
X$26977 9264 3960 9263 4074 4041 3325 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $26998 m0 *1 470.4,357.84
X$26998 9264 9263 3329 3333 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $27006 m0 *1 490,367.92
X$27006 3329 9264 3419 3381 9263 3334 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $27022 m0 *1 450.24,428.4
X$27022 3804 3332 3586 3931 9264 9263 3908 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $27024 r0 *1 449.12,428.4
X$27024 9264 3586 9263 3952 3332 3804 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $27027 m0 *1 449.68,418.32
X$27027 9263 9264 3332 3380 3804 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $27029 r0 *1 442.96,428.4
X$27029 3804 9263 3332 3782 9264 3929 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $27044 m0 *1 534.8,357.84
X$27044 9263 3334 3335 9264 3383 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $27056 m0 *1 481.6,367.92
X$27056 9264 3449 9263 3335 3420 3419 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $27063 m0 *1 541.52,388.08
X$27063 9264 9263 3638 3400 3336 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $27071 r0 *1 534.8,347.76
X$27071 3338 3337 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $27084 m0 *1 482.16,418.32
X$27084 9264 3881 3846 3341 3381 3419 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $27087 r0 *1 557.76,357.84
X$27087 3341 9264 3447 9263 3389 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $27093 r0 *1 565.6,367.92
X$27093 3341 9264 3465 3422 9263 3645 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $27096 r0 *1 500.64,418.32
X$27096 3882 3341 3815 3883 9263 9264 3514 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $27099 m0 *1 579.6,367.92
X$27099 9264 9263 3426 3467 3342 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27109 m0 *1 590.8,357.84
X$27109 9264 9263 3354 3385 3342 3346 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27135 m0 *1 600.32,367.92
X$27135 9263 3482 3445 3346 3469 3426 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $27146 m0 *1 618.8,367.92
X$27146 3389 3428 3386 3470 9263 9264 3347 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $27189 r0 *1 295.12,378
X$27189 9263 3357 3576 9264 3508 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $27196 m0 *1 271.6,388.08
X$27196 9264 3754 3410 3568 3357 3576 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $27205 r0 *1 366.24,367.92
X$27205 9264 3415 9263 3358 3462 3461 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $27212 r0 *1 458.08,378
X$27212 9264 3688 9263 3565 3359 3379 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $27223 r0 *1 414.96,438.48
X$27223 9264 9263 3852 4116 3361 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27225 m0 *1 406,428.4
X$27225 9264 3708 3361 3953 3739 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $27227 r0 *1 414.96,418.32
X$27227 9264 3463 3828 3361 3778 3829 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $27230 m0 *1 402.64,378
X$27230 9264 9263 3566 3361 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $27272 m0 *1 62.72,408.24
X$27272 9264 3367 3757 3747 3758 3728 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $27301 r0 *1 364,357.84
X$27301 9264 9263 3415 3372 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $27303 r0 *1 367.36,357.84
X$27303 9264 3372 3416 9263 3374 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $27305 m0 *1 371.28,378
X$27305 9264 9263 3510 3530 3373 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27330 m0 *1 433.44,367.92
X$27330 3377 3378 3418 3376 9264 9263 3448 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $27338 m0 *1 424.48,408.24
X$27338 9264 3377 3780 3740 3708 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $27341 r0 *1 435.68,398.16
X$27341 9264 9263 3377 3675 3709 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27343 m0 *1 440.16,408.24
X$27343 9264 3377 3418 3804 3378 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $27346 r0 *1 451.92,378
X$27346 9264 9263 3377 3585 3378 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27389 m0 *1 457.52,428.4
X$27389 3930 3380 3950 3830 3908 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $27391 m0 *1 468.72,408.24
X$27391 9264 9263 3380 3743 3587 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27393 m0 *1 466.48,378
X$27393 9263 3380 3586 9264 3421 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $27397 m0 *1 466.48,388.08
X$27397 9264 3588 3586 3587 3380 9263 3565 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $27399 r0 *1 467.04,408.24
X$27399 9264 3805 3380 9263 3587 3586 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $27403 m0 *1 493.36,398.16
X$27403 9264 9263 3592 3712 3381 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $27405 r0 *1 483.28,418.32
X$27405 9264 3815 3881 9263 3879 3419 3381 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $27413 m0 *1 483.28,408.24
X$27413 9264 3636 3712 3381 3789 3788 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $27433 r0 *1 604.8,357.84
X$27433 3427 9264 3387 3385 9263 3388 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $27453 r0 *1 612.08,367.92
X$27453 9263 3389 3468 9264 3478 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $27472 m0 *1 668.64,367.92
X$27472 9264 3396 3431 3432 3392 3393 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $27474 r0 *1 666.96,357.84
X$27474 9264 3392 3393 9263 3394 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $27480 m0 *1 658.56,367.92
X$27480 9264 3520 3431 9263 3432 3392 3393 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $27491 r0 *1 671.44,367.92
X$27491 9263 9264 3394 3476 3556 3397 3560 3520
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $27500 m0 *1 683.2,367.92
X$27500 9264 3432 3431 9263 3395 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $27522 m0 *1 532.56,398.16
X$27522 9264 9263 3400 3637 3636 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $27524 r0 *1 554.4,398.16
X$27524 9264 9263 3400 3640 3679 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27538 m0 *1 530.88,378
X$27538 9264 3401 3425 9263 3427 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $27553 m0 *1 86.24,378
X$27553 9264 3490 3485 3451 3405 3403 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $27556 r0 *1 101.92,438.48
X$27556 9264 9263 3604 4075 3404 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27558 m0 *1 109.2,438.48
X$27558 9263 3604 3404 9264 3525 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $27561 r0 *1 135.52,438.48
X$27561 9264 9263 3912 3404 4027 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $27563 r0 *1 173.6,448.56
X$27563 9264 3522 9263 4149 4126 3404 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $27565 m0 *1 175.84,448.56
X$27565 3522 9263 3404 4126 9264 4148 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $27567 m0 *1 165.76,458.64
X$27567 9263 3404 3810 9264 4202 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $27582 m0 *1 138.32,418.32
X$27582 9264 3698 3406 3765 3794 3764 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $27584 r0 *1 151.2,418.32
X$27584 3847 9263 9264 3406 3764 3765 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $27587 m0 *1 141.12,438.48
X$27587 9264 4059 3406 3764 3994 3668 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $27593 m0 *1 151.2,408.24
X$27593 9264 3764 3406 9263 3730 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $27595 r0 *1 156.24,408.24
X$27595 3764 3406 3765 3794 9263 9264 3493 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $27597 m0 *1 150.08,428.4
X$27597 9264 3765 3668 3862 3406 3764 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $27599 m0 *1 142.8,448.56
X$27599 9264 9263 4096 4125 3406 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27606 m0 *1 244.72,367.92
X$27606 9263 3407 9264 3409 3412 3408 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $27609 r0 *1 238,378
X$27609 3544 9263 3498 3407 9264 3545 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $27611 m0 *1 234.08,378
X$27611 9263 3455 3543 9264 3407 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $27618 m0 *1 262.64,388.08
X$27618 9264 3410 9263 3622 3612 3575 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $27639 m0 *1 332.08,378
X$27639 9264 3414 3458 3413 3614 3457 9263 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $27643 m0 *1 342.16,367.92
X$27643 9264 9263 3458 3415 3413 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27674 r0 *1 374.08,367.92
X$27674 9264 9263 3417 3511 3461 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $27677 r0 *1 414.4,408.24
X$27677 3779 9263 3778 3418 9264 3803 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $27713 m0 *1 500.08,378
X$27713 9263 3592 3421 9264 3464 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $27718 r0 *1 550.48,367.92
X$27718 9264 9263 3447 3526 3422 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $27726 r0 *1 519.12,367.92
X$27726 9264 9263 3464 3423 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $27755 r0 *1 630,367.92
X$27755 9263 3428 3471 9264 3431 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $27764 m0 *1 613.2,398.16
X$27764 3682 9264 3516 9263 3428 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $27770 r0 *1 649.6,367.92
X$27770 9264 9263 3473 3430 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $27815 m0 *1 38.64,378
X$27815 9264 3475 3522 3518 3519 3439 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $27855 r0 *1 263.2,367.92
X$27855 9263 3499 3529 9264 3446 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $27872 r0 *1 90.16,418.32
X$27872 9264 9263 3451 3843 3485 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27874 m0 *1 86.24,418.32
X$27874 9264 3810 3451 3842 3664 3653 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $27881 m0 *1 112,428.4
X$27881 9263 3857 3452 9264 3912 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $27886 r0 *1 112.56,408.24
X$27886 9263 3758 3452 9264 3793 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $27889 m0 *1 104.16,408.24
X$27889 9264 3693 9263 3750 3452 3758 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $27903 r0 *1 184.8,367.92
X$27903 3492 3494 3493 3453 9263 9264 3495 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $27906 m0 *1 179.2,378
X$27906 9264 3608 3494 3493 3492 3453 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $27913 r0 *1 235.76,367.92
X$27913 9264 9263 3455 3499 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $27918 m0 *1 239.68,388.08
X$27918 3455 3542 3500 3497 9264 9263 3659 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $27924 m0 *1 150.08,378
X$27924 9263 3491 3480 9264 3455 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $27930 r0 *1 249.2,367.92
X$27930 9263 3456 3483 9264 3484 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $27932 r0 *1 243.6,388.08
X$27932 9264 3619 9263 3620 3659 3456 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $27934 r0 *1 232.96,378
X$27934 9263 3544 3498 9264 3456 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $27949 r0 *1 361.2,367.92
X$27949 9264 9263 3459 3461 3460 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $27956 r0 *1 363.44,388.08
X$27956 3614 9263 3460 3625 9264 3628 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $27959 m0 *1 347.76,398.16
X$27959 9264 3614 3624 3706 3460 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $27962 r0 *1 346.64,388.08
X$27962 3614 3460 3670 3625 9264 9263 3626 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $28004 r0 *1 556.08,367.92
X$28004 3465 3526 9263 9264 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $28008 m0 *1 565.6,378
X$28008 9263 3515 9264 3553 3524 3466 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $28021 r0 *1 609.84,388.08
X$28021 9264 3643 3647 9263 3470 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $28026 r0 *1 633.36,378
X$28026 3473 9263 3554 3605 9264 3472 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $28035 m0 *1 636.72,388.08
X$28035 9263 3600 3555 9264 3473 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $28067 r0 *1 148.4,378
X$28067 3491 3480 3540 3563 9264 9263 3541 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $28089 m0 *1 80.64,408.24
X$28089 9264 3485 3759 3760 3653 3571 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $28115 m0 *1 145.6,388.08
X$28115 9264 3542 3490 3571 9263 gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* cell instance $28119 m0 *1 221.76,378
X$28119 9263 3499 9264 3543 3490 3498 3527 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $28126 m0 *1 172.48,408.24
X$28126 9264 3494 3698 3492 3667 3573 9263 3732 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $28128 r0 *1 172.48,458.64
X$28128 9264 3818 3492 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $28134 r0 *1 187.04,458.64
X$28134 3492 3494 4127 4059 9263 9264 4271 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $28139 r0 *1 187.6,408.24
X$28139 3697 3731 3493 3767 9264 9263 3795 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $28148 r0 *1 187.04,418.32
X$28148 9263 3767 9264 3851 3494 3864 3698 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $28151 r0 *1 156.24,428.4
X$28151 3864 3494 3765 3862 9263 9264 3984 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $28157 m0 *1 165.76,408.24
X$28157 3730 9264 3494 3729 9263 3724 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $28160 m0 *1 159.04,438.48
X$28160 9263 9264 3494 3864 3862 3810 3996 4015 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $28162 m0 *1 151.76,448.56
X$28162 9263 3861 9264 4126 3494 3864 4059 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $28164 r0 *1 159.04,458.64
X$28164 9264 9263 3695 3494 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $28174 r0 *1 179.2,418.32
X$28174 3864 3494 3698 3767 9263 9264 3866 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $28185 r0 *1 180.88,388.08
X$28185 9264 3770 3495 3697 3610 3658 3724 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $28194 m0 *1 207.76,398.16
X$28194 9263 3696 3496 9264 3699 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $28200 m0 *1 225.12,418.32
X$28200 9264 3768 3813 3772 3497 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $28202 r0 *1 220.64,418.32
X$28202 9264 3905 3813 3497 3768 9263 3904 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $28205 m0 *1 274.96,378
X$28205 9264 9263 3500 3502 3497 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28220 r0 *1 274.4,378
X$28220 9264 3500 3497 9263 3501 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $28247 m0 *1 232.4,388.08
X$28247 9263 3543 3617 9264 3500 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28257 r0 *1 280.56,398.16
X$28257 9264 3503 3755 3623 3754 3703 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $28264 r0 *1 315.28,367.92
X$28264 3508 9264 3506 3503 9263 3509 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $28267 m0 *1 302.96,378
X$28267 9263 3508 9264 3503 3532 3506 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $28274 m0 *1 274.96,398.16
X$28274 9263 3702 3545 9264 3504 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28279 r0 *1 295.12,418.32
X$28279 9263 3505 3854 9264 3909 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28305 m0 *1 367.92,388.08
X$28305 9264 9263 3578 3579 3510 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28310 m0 *1 340.48,408.24
X$28310 9263 3798 3510 9264 3756 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28320 m0 *1 361.2,388.08
X$28320 9264 3578 3510 9263 3548 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $28322 m0 *1 381.92,458.64
X$28322 4033 4128 3511 4165 9263 9264 4042 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $28324 r0 *1 376.88,448.56
X$28324 9264 4165 4128 3926 3511 4033 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $28331 m0 *1 367.36,398.16
X$28331 9263 3614 3672 9264 3511 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28340 r0 *1 478.24,378
X$28340 9264 3564 3609 3552 3513 3590 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $28363 m0 *1 608.16,408.24
X$28363 9264 9263 3645 3748 3516 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28365 m0 *1 623.28,398.16
X$28365 9264 9263 3605 3606 3516 3656 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28375 m0 *1 600.32,408.24
X$28375 9263 3644 9264 3516 3785 3645 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $28410 m0 *1 185.36,468.72
X$28410 3522 9264 4202 4027 9263 4127 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $28414 m0 *1 169.68,468.72
X$28414 4201 9263 9264 4202 3522 4027 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $28424 m0 *1 120.4,418.32
X$28424 9263 3525 3537 9264 3817 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28426 m0 *1 114.24,438.48
X$28426 9264 3861 3993 3525 3792 3764 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $28430 r0 *1 128.24,438.48
X$28430 3792 3525 3861 3993 9264 9263 4096 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $28479 m0 *1 113.12,408.24
X$28479 3758 9263 3536 3694 9264 3763 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $28495 r0 *1 80.64,408.24
X$28495 9264 3537 3759 3760 3653 3761 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $28511 m0 *1 154,398.16
X$28511 9264 3667 3542 3695 3541 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $28515 m0 *1 185.92,388.08
X$28515 9264 9263 3541 3658 3617 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28517 r0 *1 211.12,388.08
X$28517 9263 3541 3617 9264 3618 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28519 r0 *1 188.72,398.16
X$28519 3667 9263 3541 3542 9264 3731 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $28521 m0 *1 156.8,408.24
X$28521 9264 3766 3542 3541 3667 9263 3668 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $28545 m0 *1 245.28,408.24
X$28545 9264 3751 3542 9263 3770 3791 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $28548 m0 *1 217.28,408.24
X$28548 9263 3543 3618 9264 3768 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28551 r0 *1 156.24,398.16
X$28551 9264 3729 3697 3543 3695 3730 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $28563 m0 *1 203.28,388.08
X$28563 9264 3685 3608 3574 3543 3618 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $28569 m0 *1 230.72,398.16
X$28569 9264 3696 9263 3700 3544 3685 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $28573 r0 *1 231.84,398.16
X$28573 3696 9263 3685 3544 9264 3725 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $28584 m0 *1 288.96,398.16
X$28584 9264 9263 3545 3703 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $28596 r0 *1 313.6,408.24
X$28596 9264 9263 3547 3754 3546 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $28609 m0 *1 289.52,418.32
X$28609 3754 9264 3546 3753 9263 3821 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $28633 m0 *1 453.04,388.08
X$28633 9264 3551 3585 3661 3613 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $28642 m0 *1 459.2,408.24
X$28642 9264 3788 3551 3633 3783 9263 3790 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $28644 r0 *1 483.84,398.16
X$28644 9264 9263 3633 3591 3551 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28647 m0 *1 487.76,398.16
X$28647 9264 9263 3552 3596 3686 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28655 r0 *1 567.84,388.08
X$28655 9264 9263 3642 3553 3639 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28669 m0 *1 705.6,388.08
X$28669 9264 3557 3556 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $28674 r0 *1 624.96,619.92
X$28674 9264 9263 6218 6302 3556 6153 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28698 r0 *1 482.16,650.16
X$28698 9264 9263 6628 6571 3556 6674 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28708 r0 *1 680.96,378
X$28708 9263 3559 3560 9264 3602 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28719 r0 *1 495.6,378
X$28719 9264 9263 3562 3611 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $28759 r0 *1 80.08,388.08
X$28759 9264 3663 9263 3655 3654 3570 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $28790 m0 *1 237.44,408.24
X$28790 3575 9263 9264 3725 3732 3700 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $28804 m0 *1 336,388.08
X$28804 9264 9263 3577 3578 3623 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28807 r0 *1 334.32,398.16
X$28807 9264 3670 3623 3776 3577 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $28810 r0 *1 327.04,398.16
X$28810 3621 3670 3577 3623 9264 9263 3624 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $28821 r0 *1 335.44,388.08
X$28821 9263 3577 3623 9264 3625 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28839 m0 *1 434,398.16
X$28839 9264 9263 3741 3632 3582 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28843 r0 *1 441.84,388.08
X$28843 9264 3710 9263 3583 3584 3630 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $28846 r0 *1 445.76,378
X$28846 9263 3630 3584 9264 3613 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28854 m0 *1 420.56,438.48
X$28854 9264 9263 3852 4118 3586 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28868 r0 *1 426.16,428.4
X$28868 9263 3927 3878 9264 3586 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28900 r0 *1 492.8,388.08
X$28900 9264 9263 3635 3591 3634 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $28905 m0 *1 516.32,388.08
X$28905 9263 3593 3635 9264 3594 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $28908 m0 *1 513.52,398.16
X$28908 9264 9263 3593 3715 3635 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28915 r0 *1 456.4,388.08
X$28915 9263 3632 3676 9264 3593 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28923 r0 *1 572.88,388.08
X$28923 9263 3642 3639 9264 3595 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28925 m0 *1 609.28,388.08
X$28925 9264 9263 3596 3598 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $28928 m0 *1 612.64,388.08
X$28928 9264 9263 3596 3656 3597 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28940 r0 *1 615.44,388.08
X$28940 9263 3682 3678 9264 3597 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28944 m0 *1 617.68,388.08
X$28944 9264 9263 3598 3606 3599 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28948 r0 *1 620.48,388.08
X$28948 9264 3598 3599 9263 3648 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $28955 r0 *1 639.52,388.08
X$28955 9264 9263 3600 3601 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $28959 m0 *1 585.2,398.16
X$28959 3643 9264 3681 3600 9263 3721 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $28961 r0 *1 555.52,388.08
X$28961 9264 9263 3639 3600 3640 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28976 r0 *1 175.84,438.48
X$28976 9264 4150 3732 4027 3916 3604 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $29049 r0 *1 136.64,388.08
X$29049 9264 3667 3655 3616 9263 gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* cell instance $29067 m0 *1 241.92,398.16
X$29067 9264 9263 3732 3619 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $29070 r0 *1 267.12,418.32
X$29070 9264 3854 3853 9263 3620 3771 3820 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $29073 r0 *1 321.44,398.16
X$29073 9264 9263 3670 3705 3620 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $29078 m0 *1 322,408.24
X$29078 9264 3705 3620 9263 3733 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $29080 r0 *1 268.24,408.24
X$29080 9264 3773 9263 3621 3771 3772 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $29111 m0 *1 345.52,408.24
X$29111 9263 3624 9264 3726 3774 3775 3734 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $29123 m0 *1 344.4,418.32
X$29123 9264 9263 3626 3823 3726 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $29134 m0 *1 368.48,408.24
X$29134 3775 3733 3774 3734 9263 9264 3627 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $29149 m0 *1 428.96,418.32
X$29149 3781 9264 3816 9263 3630 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $29151 r0 *1 448,398.16
X$29151 9264 9263 3716 3676 3709 3631 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29155 r0 *1 450.24,408.24
X$29155 3632 9263 3782 3676 9264 3790 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $29163 m0 *1 482.72,398.16
X$29163 9264 9263 3633 3686 3634 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $29174 r0 *1 434,408.24
X$29174 3781 9263 3850 3742 9264 3633 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $29184 r0 *1 494.48,398.16
X$29184 9263 3634 3713 9264 3678 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $29197 r0 *1 532.56,388.08
X$29197 9264 3637 3636 9263 3642 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $29202 r0 *1 518.56,398.16
X$29202 9263 3716 3714 9264 3637 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $29223 r0 *1 561.12,388.08
X$29223 9263 3641 3680 9264 3657 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $29240 r0 *1 608.16,398.16
X$29240 3644 9264 3645 9263 3682 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $29245 r0 *1 599.76,388.08
X$29245 9264 3644 3645 9263 3646 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $29247 r0 *1 508.48,418.32
X$29247 9264 3815 3883 9263 3644 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $29261 m0 *1 603.68,398.16
X$29261 3678 9264 3646 9263 3647 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $29276 r0 *1 714,418.32
X$29276 9264 9263 3650 3839 3838 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $29278 r0 *1 710.64,821.52
X$29278 9264 3650 8344 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $29280 r0 *1 707.28,448.56
X$29280 9264 3650 4176 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $29282 m0 *1 694.96,821.52
X$29282 9264 3650 8290 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $29284 r0 *1 609.28,700.56
X$29284 9264 3650 7118 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $29286 m0 *1 575.12,730.8
X$29286 9264 3650 7219 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $29288 m0 *1 636.72,730.8
X$29288 9264 3650 7325 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $29306 r0 *1 721.84,468.72
X$29306 9264 4264 3650 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $29355 r0 *1 137.76,428.4
X$29355 9263 3662 3762 9264 3863 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $29358 r0 *1 128.24,428.4
X$29358 3662 9264 3762 9263 3915 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $29366 r0 *1 137.2,418.32
X$29366 9264 3662 3859 9263 3860 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $29370 m0 *1 94.08,398.16
X$29370 9263 3694 9264 3722 3692 3663 3664 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $29381 m0 *1 113.12,418.32
X$29381 9264 3665 9263 3767 3793 3843 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $29408 r0 *1 150.08,438.48
X$29408 9263 9264 3668 3729 3994 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $29423 r0 *1 225.68,408.24
X$29423 3768 9263 3769 3669 9264 3868 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $29437 m0 *1 349.44,448.56
X$29437 9264 4037 9263 4114 3671 4039 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $29439 m0 *1 357.84,438.48
X$29439 4039 9263 4037 3671 9264 4041 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $29441 r0 *1 350.56,438.48
X$29441 4036 9263 4037 3671 9264 4038 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $29453 r0 *1 346.08,448.56
X$29453 9263 4039 3671 9264 4129 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $29455 r0 *1 347.2,418.32
X$29455 9263 3823 9264 3671 3826 3872 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29459 r0 *1 358.4,408.24
X$29459 9264 3672 3776 3774 3734 3775 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $29466 m0 *1 411.04,398.16
X$29466 9264 3707 9263 3709 3674 3673 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $29469 r0 *1 412.72,398.16
X$29469 9264 9263 3710 3674 3673 3738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29474 m0 *1 413.84,408.24
X$29474 9264 9263 3674 3739 3738 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $29493 r0 *1 511.28,398.16
X$29493 9264 3744 9263 3714 3677 3708 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $29495 m0 *1 514.64,408.24
X$29495 9263 3677 3715 9264 3745 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $29500 m0 *1 451.36,398.16
X$29500 9264 9263 3711 3677 3687 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $29506 m0 *1 594.16,398.16
X$29506 9264 9263 3682 3749 3678 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $29517 m0 *1 540.4,408.24
X$29517 9264 3787 9263 3786 3717 3679 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $29519 r0 *1 538.16,398.16
X$29519 9264 9263 3720 3723 3679 3717 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29528 r0 *1 584.64,398.16
X$29528 9264 9263 3717 3681 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $29537 m0 *1 668.64,791.28
X$29537 9264 3683 6914 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29541 m0 *1 902.16,861.84
X$29541 9264 3683 8019 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29544 m0 *1 739.76,952.56
X$29544 9264 3683 8741 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29547 m0 *1 804.16,912.24
X$29547 9264 3683 8374 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29550 r0 *1 921.76,750.96
X$29550 9264 3683 7127 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29553 m0 *1 690.48,468.72
X$29553 9264 3683 3974 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29555 m0 *1 945.28,549.36
X$29555 9264 3683 4563 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29557 m0 *1 934.08,660.24
X$29557 9264 3683 6315 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29561 r0 *1 804.72,680.4
X$29561 9264 3683 6313 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29564 r0 *1 715.68,559.44
X$29564 9264 3683 4653 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29568 r0 *1 739.2,670.32
X$29568 9264 6780 3683 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29571 r0 *1 842.24,539.28
X$29571 9264 3683 4626 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $29596 r0 *1 205.52,428.4
X$29596 9263 3988 9264 3989 3732 3685 3916 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $29612 m0 *1 220.08,428.4
X$29612 9263 3867 9264 3685 3918 3701 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29614 r0 *1 230.72,418.32
X$29614 9264 3701 3685 9263 3869 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $29622 m0 *1 450.24,438.48
X$29622 9264 3688 4044 9263 3930 3962 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $29632 r0 *1 43.12,408.24
X$29632 9263 3727 3690 9264 3913 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $29643 r0 *1 89.6,398.16
X$29643 9264 9263 3693 3694 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $29657 r0 *1 120.4,408.24
X$29657 9263 3762 9264 3793 3796 3694 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29661 r0 *1 164.08,428.4
X$29661 9264 3862 3863 3956 3695 3818 9263 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $29664 r0 *1 149.52,448.56
X$29664 9264 4164 3695 3729 4125 3818 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $29666 m0 *1 170.8,458.64
X$29666 3695 9263 4059 4205 9264 3818 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $29679 m0 *1 165.76,448.56
X$29679 3818 3695 3729 4125 9263 9264 3955 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $29682 m0 *1 157.92,458.64
X$29682 3818 9264 3695 3729 9263 4185 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $29695 m0 *1 219.52,418.32
X$29695 9264 9263 3813 3696 3732 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $29697 m0 *1 169.68,428.4
X$29697 3696 3794 3954 3915 9263 9264 3916 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $29730 r0 *1 238,398.16
X$29730 9264 3752 3771 3725 3700 3732 9263 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $29737 m0 *1 253.68,428.4
X$29737 9264 9263 3701 3919 3819 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $29754 m0 *1 254.8,408.24
X$29754 9263 3751 9264 3770 3755 3702 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29766 m0 *1 364,438.48
X$29766 9264 9263 3931 3924 4039 3706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29768 m0 *1 375.76,418.32
X$29768 3824 9263 9264 3706 3800 3799 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $29774 r0 *1 367.36,418.32
X$29774 9264 9263 3876 3774 3706 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $29782 m0 *1 360.64,458.64
X$29782 4036 9264 4035 3706 9263 4165 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $29784 m0 *1 375.76,428.4
X$29784 3800 3874 3706 3799 9263 9264 3736 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $29786 r0 *1 372.96,418.32
X$29786 9263 3874 9264 3706 3735 3800 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29792 r0 *1 506.24,398.16
X$29792 9263 3708 3710 9264 3744 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $29800 m0 *1 529.2,408.24
X$29800 9263 3708 9264 3745 3787 3710 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29802 r0 *1 524.72,398.16
X$29802 9263 3745 3723 3710 3717 3708 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $29827 m0 *1 454.16,408.24
X$29827 9264 9263 3741 3711 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $29839 r0 *1 492.24,408.24
X$29839 9264 3783 3815 9263 3713 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $29848 m0 *1 519.68,408.24
X$29848 9263 3715 3716 9264 3717 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $29856 m0 *1 504.56,408.24
X$29856 9264 3716 3744 9263 3789 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $29873 m0 *1 613.2,408.24
X$29873 9263 3785 3748 9264 3718 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $29876 m0 *1 489.44,640.08
X$29876 9264 9263 3719 6483 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $29879 r0 *1 518,640.08
X$29879 9263 3807 3719 9264 6536 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $29888 r0 *1 500.64,640.08
X$29888 9264 3807 3719 9263 6535 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $29928 r0 *1 75.04,418.32
X$29928 9263 3758 3728 9264 3857 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $29978 m0 *1 218.96,448.56
X$29978 9264 9263 4030 3732 3916 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $29981 m0 *1 369.04,418.32
X$29981 9264 9263 3799 3775 3733 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $29996 m0 *1 343.84,428.4
X$29996 3923 3872 3774 3734 9263 9264 3873 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $29998 r0 *1 342.16,428.4
X$29998 9263 9264 4005 3734 3875 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $30003 r0 *1 370.16,428.4
X$30003 9264 9263 3961 3734 3874 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $30005 m0 *1 370.16,428.4
X$30005 9264 3774 3734 9263 3800 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30009 r0 *1 395.36,418.32
X$30009 3739 9263 3735 3736 9264 4080 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $30011 m0 *1 392.56,418.32
X$30011 3825 3739 3735 3736 9264 9263 3827 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $30015 r0 *1 402.64,398.16
X$30015 9264 9263 3735 3738 3736 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30037 m0 *1 408.24,438.48
X$30037 4006 9263 3852 3926 9264 3737 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $30055 r0 *1 428.96,408.24
X$30055 9263 3780 3740 9264 3741 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30073 m0 *1 468.72,428.4
X$30073 9263 9264 3932 3743 3879 3965 3906 3931
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $30079 m0 *1 481.04,428.4
X$30079 9264 3743 3932 9263 3881 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30092 m0 *1 660.8,408.24
X$30092 9264 9263 3811 3746 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30127 r0 *1 304.64,418.32
X$30127 9264 9263 3910 3753 3797 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $30168 r0 *1 85.12,418.32
X$30168 9263 3760 3759 9264 3893 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30171 r0 *1 80.08,418.32
X$30171 9264 9263 3760 3842 3759 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30190 r0 *1 123.2,428.4
X$30190 9263 3762 3914 9264 4015 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30228 m0 *1 141.12,428.4
X$30228 9263 9264 3841 3765 3861 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $30233 r0 *1 159.04,418.32
X$30233 9264 3865 3766 3847 3863 3818 9263 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $30261 m0 *1 260.4,448.56
X$30261 9264 9263 3770 4032 4030 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30263 r0 *1 259.84,438.48
X$30263 9263 3770 4030 9264 4069 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30266 r0 *1 181.44,448.56
X$30266 9264 4078 4150 3770 4148 4149 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $30268 r0 *1 231.28,438.48
X$30268 3770 9263 4029 4030 9264 4066 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $30270 r0 *1 245.84,438.48
X$30270 9263 3770 4065 9264 3957 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30293 r0 *1 249.76,418.32
X$30293 9263 3820 9264 3771 3819 3772 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $30296 r0 *1 197.12,418.32
X$30296 9263 3851 3866 9264 3771 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30313 m0 *1 286.72,438.48
X$30313 9264 9263 3774 4022 4002 3797 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $30343 r0 *1 321.44,418.32
X$30343 9264 3775 3822 3871 3798 3951 9263 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $30348 r0 *1 380.8,418.32
X$30348 9263 3800 3877 3775 3876 3875 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $30362 r0 *1 401.52,418.32
X$30362 9264 3826 3777 9263 3878 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30384 m0 *1 427.84,428.4
X$30384 9264 3829 3927 9263 3781 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30388 r0 *1 437.36,428.4
X$30388 9264 9263 3782 3963 3928 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $30393 r0 *1 496.16,418.32
X$30393 9264 9263 3783 3882 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30400 r0 *1 439.6,438.48
X$30400 9264 3929 4043 3783 4071 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $30404 r0 *1 646.24,408.24
X$30404 9264 9263 3784 3844 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30438 r0 *1 128.8,448.56
X$30438 9263 3792 4145 9264 4182 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $30467 m0 *1 190.4,418.32
X$30467 3796 9264 3795 9263 3820 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $30483 m0 *1 282.24,428.4
X$30483 9263 9264 3920 3797 3870 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $30486 r0 *1 341.6,418.32
X$30486 9264 9263 3798 3872 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30513 r0 *1 390.32,418.32
X$30513 9264 9263 3801 3825 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30516 m0 *1 328.16,438.48
X$30516 9263 4023 4005 9264 3801 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $30519 m0 *1 383.6,418.32
X$30519 9264 3824 9263 3802 3877 3801 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30535 r0 *1 399.28,428.4
X$30535 9264 3875 3926 3803 3852 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $30550 m0 *1 655.76,549.36
X$30550 9264 3806 4706 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $30552 r0 *1 655.2,579.6
X$30552 9264 3806 5698 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $30578 r0 *1 525.84,912.24
X$30578 9264 9263 8780 8178 3806 8781 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30580 r0 *1 491.12,912.24
X$30580 9264 9263 8747 7994 3806 8778 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30582 r0 *1 408.24,468.72
X$30582 9264 3940 3806 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $30585 r0 *1 407.68,902.16
X$30585 9264 9263 8743 7282 3806 8775 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30587 r0 *1 417.2,892.08
X$30587 9264 9263 8708 8482 3806 8685 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30589 r0 *1 645.12,579.6
X$30589 9264 9263 5835 5771 3806 5491 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30592 r0 *1 442.4,912.24
X$30592 9264 9263 8804 7855 3806 8818 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30605 m0 *1 464.24,589.68
X$30605 9264 5824 3974 3807 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $30608 r0 *1 466.48,640.08
X$30608 9264 3807 6483 9263 6482 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30614 m0 *1 672,418.32
X$30614 9264 9263 3940 3808 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30616 m0 *1 675.36,418.32
X$30616 9264 9263 3808 3894 3888 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30619 m0 *1 646.24,418.32
X$30619 9264 3809 9263 3844 3812 3835 3808 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $30624 m0 *1 701.68,428.4
X$30624 9264 9263 3809 3888 3837 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30627 m0 *1 710.64,428.4
X$30627 9264 9263 3809 3941 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30634 r0 *1 701.12,438.48
X$30634 9264 9263 3809 4099 4014 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30641 m0 *1 708.4,448.56
X$30641 9264 3809 3890 9263 4098 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30682 m0 *1 389.2,428.4
X$30682 9263 3877 3925 9264 3816 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30686 r0 *1 150.08,458.64
X$30686 9264 9263 3818 3864 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $30710 m0 *1 269.36,428.4
X$30710 9264 4000 9263 3920 3905 3820 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30717 r0 *1 257.04,428.4
X$30717 9263 3919 9264 3957 4001 3820 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $30727 m0 *1 324.24,428.4
X$30727 9264 3871 3822 9263 3911 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30740 r0 *1 407.68,418.32
X$30740 9264 3828 3875 9263 3852 3827 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $30757 m0 *1 420.56,428.4
X$30757 9264 9263 3852 3829 3926 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30762 r0 *1 582.4,630
X$30762 9264 9263 6434 5908 5211 3831 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30765 m0 *1 588.56,670.32
X$30765 9264 3831 9263 6828 6745 6812 6487 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $30769 m0 *1 572.88,670.32
X$30769 9264 9263 6715 3831 5910 6301 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30773 m0 *1 563.92,640.08
X$30773 9264 9263 6431 6430 5440 3831 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30776 r0 *1 569.52,418.32
X$30776 9264 9263 3832 3900 3898 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30778 m0 *1 574,418.32
X$30778 9264 9263 3845 3832 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30781 m0 *1 600.32,428.4
X$30781 3833 9264 9263 4154 4242 3937 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $30783 r0 *1 593.6,418.32
X$30783 9264 3899 3896 3895 3887 3833 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $30799 m0 *1 714,428.4
X$30799 9263 3889 9264 3837 3976 3941 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $30809 r0 *1 725.2,418.32
X$30809 9264 9263 3839 3891 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30816 r0 *1 721.84,448.56
X$30816 3890 9263 4094 3840 9264 4221 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $30821 r0 *1 148.4,428.4
X$30821 9263 3861 3841 9264 3994 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30839 r0 *1 574.56,418.32
X$30839 3845 9264 9263 3901 3902 3886 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $30850 r0 *1 472.08,418.32
X$30850 9263 3933 3883 3848 3906 3880 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $30854 m0 *1 459.2,438.48
X$30854 9264 3931 9263 3964 3849 3927 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30856 m0 *1 468.16,438.48
X$30856 9263 3927 3849 9264 3965 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30867 m0 *1 191.52,428.4
X$30867 9264 3865 9263 3956 3904 3866 3851 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $30872 r0 *1 389.2,428.4
X$30872 3961 9263 3852 3926 9264 3953 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $30902 m0 *1 353.36,428.4
X$30902 9264 9263 3911 3855 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30906 r0 *1 106.96,438.48
X$30906 9264 9263 3856 4025 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30921 m0 *1 128.24,428.4
X$30921 9263 3861 9264 3858 3954 3913 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $30923 m0 *1 136.08,428.4
X$30923 9263 3861 3913 9264 3859 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30926 m0 *1 171.36,438.48
X$30926 3860 9263 3996 3984 9264 3988 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $30931 r0 *1 168,438.48
X$30931 9264 3995 3860 9263 3996 3984 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $30948 r0 *1 113.68,448.56
X$30948 9263 4025 9264 3861 4124 4075 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $30978 r0 *1 192.64,428.4
X$30978 9263 9264 3865 3867 3956 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $30982 m0 *1 178.08,438.48
X$30982 9264 3997 3917 3956 3955 3954 3865 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $30993 r0 *1 206.64,438.48
X$30993 9264 4060 3867 4029 4031 4067 9263 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $31007 r0 *1 285.04,428.4
X$31007 9263 3870 3920 9264 3959 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31016 r0 *1 273.84,428.4
X$31016 9264 3958 3998 9263 3871 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $31031 r0 *1 326.48,428.4
X$31031 9263 3951 3992 9264 3874 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $31035 m0 *1 346.08,438.48
X$31035 9263 3875 4005 9264 4006 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31048 m0 *1 383.6,428.4
X$31048 9264 3875 3876 9263 3925 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $31063 r0 *1 431.76,428.4
X$31063 9264 9263 3927 3928 3878 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31073 r0 *1 466.48,428.4
X$31073 9264 9263 3962 3879 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31076 r0 *1 475.44,428.4
X$31076 9264 9263 3962 3880 3964 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31089 m0 *1 525.28,428.4
X$31089 9264 3949 3903 3884 3935 3934 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31091 r0 *1 524.16,428.4
X$31091 9264 4063 3901 3991 3884 3967 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31093 m0 *1 543.2,428.4
X$31093 9264 9263 3885 3935 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31095 m0 *1 534.24,438.48
X$31095 9264 4007 4020 3885 4062 4048 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31100 m0 *1 581.84,428.4
X$31100 9263 3886 9264 3945 3898 3946 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $31104 r0 *1 598.64,428.4
X$31104 9264 4115 3985 3887 3972 3937 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31107 m0 *1 714,448.56
X$31107 3888 4177 4098 4094 9264 9263 4144 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $31119 r0 *1 722.4,438.48
X$31119 9264 9263 3975 3889 4055 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31122 m0 *1 726.88,458.64
X$31122 9264 9263 4012 3890 4427 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31135 m0 *1 745.36,428.4
X$31135 9264 3892 3940 9263 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $31144 m0 *1 589.68,428.4
X$31144 3946 9264 9263 3897 3895 3944 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31149 m0 *1 650.16,428.4
X$31149 3943 9264 9263 3896 3942 3938 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31156 m0 *1 563.36,428.4
X$31156 9264 3903 3897 3902 3936 3947 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31166 r0 *1 565.6,428.4
X$31166 9264 3969 3899 3936 3971 3970 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31169 r0 *1 551.6,428.4
X$31169 9264 3990 9263 4842 3900 3968 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $31221 m0 *1 119.84,428.4
X$31221 9264 9263 3913 3914 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31250 r0 *1 185.36,428.4
X$31250 9264 9263 3955 3958 3917 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31267 m0 *1 311.92,438.48
X$31267 3951 9263 4076 4004 9264 3921 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31283 m0 *1 297.36,438.48
X$31283 3923 9264 4003 4034 9263 4024 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $31298 r0 *1 388.64,438.48
X$31298 9264 9263 3926 4073 4042 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31306 m0 *1 439.6,438.48
X$31306 3927 9264 3931 9263 3930 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $31318 r0 *1 434,438.48
X$31318 9264 9263 4071 3927 3963 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $31324 m0 *1 445.2,428.4
X$31324 9263 3928 3930 9264 3950 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31350 r0 *1 459.2,428.4
X$31350 9264 3931 3952 9263 3932 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $31362 r0 *1 469.84,428.4
X$31362 9264 3962 3964 9263 3933 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $31365 m0 *1 524.72,438.48
X$31365 3967 9264 9263 4021 4123 3934 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31375 r0 *1 673.68,428.4
X$31375 4008 3977 3938 3973 9264 9263 3978 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $31379 r0 *1 654.64,428.4
X$31379 9264 3943 9263 3983 3980 3938 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $31382 r0 *1 664.16,428.4
X$31382 9264 9263 3939 3980 4009 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31386 m0 *1 661.36,428.4
X$31386 9264 9263 4017 3939 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31389 m0 *1 909.44,841.68
X$31389 9264 3940 8261 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $31394 m0 *1 520.8,670.32
X$31394 9264 3940 6770 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $31397 m0 *1 415.52,922.32
X$31397 9264 3940 8813 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $31400 m0 *1 400.96,922.32
X$31400 9264 3940 8863 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $31404 m0 *1 755.44,448.56
X$31404 9264 3940 4013 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $31425 r0 *1 628.32,428.4
X$31425 9264 3985 3981 3942 3986 3987 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31432 r0 *1 593.6,428.4
X$31432 9263 3944 3982 9264 3945 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31447 m0 *1 568.96,438.48
X$31447 3947 9264 9263 4135 4019 3970 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31450 r0 *1 280,438.48
X$31450 9264 9263 3948 4077 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31452 m0 *1 276.08,438.48
X$31452 4000 4001 3948 4033 9263 9264 4022 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $31459 r0 *1 520.8,428.4
X$31459 9264 9263 3966 3949 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31483 m0 *1 201.6,438.48
X$31483 9264 9263 3954 4060 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31511 m0 *1 279.44,448.56
X$31511 9264 9263 3958 4108 4076 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31531 r0 *1 315.84,438.48
X$31531 9264 3960 4070 9263 4035 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $31550 r0 *1 356.72,438.48
X$31550 9264 4038 9263 3963 4040 4039 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $31566 r0 *1 509.04,448.56
X$31566 9264 4463 3966 4159 4168 4131 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31574 r0 *1 542.08,428.4
X$31574 3990 9264 9263 4158 3991 3968 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31578 r0 *1 562.24,428.4
X$31578 9264 9263 4020 3969 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31583 m0 *1 578.48,438.48
X$31583 9264 9263 4087 3971 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31586 r0 *1 610.96,438.48
X$31586 9264 9263 4049 3972 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31588 m0 *1 675.36,438.48
X$31588 9263 3973 4057 9264 4016 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31591 r0 *1 666.4,438.48
X$31591 4053 9264 9263 4106 4107 3973 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31601 m0 *1 690.48,458.64
X$31601 9264 3974 9263 gf180mcu_fd_sc_mcu9t5v0__clkinv_20
* cell instance $31619 m0 *1 726.88,448.56
X$31619 9264 9263 3975 4012 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $31622 m0 *1 742,458.64
X$31622 9263 3975 4179 9264 4229 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31624 r0 *1 707.84,438.48
X$31624 9263 4100 4056 3975 4099 4097 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $31627 m0 *1 741.44,478.8
X$31627 3975 9263 4377 4428 9264 4444 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31629 r0 *1 711.76,488.88
X$31629 9264 9263 3975 4793 4487 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31640 r0 *1 744.24,478.8
X$31640 3975 9263 4377 4429 9264 4430 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31650 m0 *1 680.4,448.56
X$31650 4102 9264 9263 4146 4560 3977 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31653 m0 *1 680.4,438.48
X$31653 9263 4010 3979 4011 3978 4054 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $31657 r0 *1 649.6,428.4
X$31657 9264 9263 3979 3982 3983 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31666 m0 *1 656.88,438.48
X$31666 4017 9264 9263 3981 4052 4008 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31690 m0 *1 621.6,438.48
X$31690 9264 4113 4018 3986 4051 4050 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31698 r0 *1 624.4,438.48
X$31698 3987 9264 9263 4110 4152 4050 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31742 m0 *1 219.52,458.64
X$31742 4031 9263 4029 3997 9264 4231 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31757 m0 *1 269.92,448.56
X$31757 9263 4000 4104 9264 4128 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $31764 r0 *1 209.44,458.64
X$31764 4203 9264 4205 9263 4000 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $31768 r0 *1 290.64,438.48
X$31768 9263 4001 4002 9264 4036 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $31770 r0 *1 283.36,438.48
X$31770 9264 4077 9263 4070 4002 4001 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $31785 m0 *1 310.24,448.56
X$31785 4003 9264 4076 9263 4005 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $31795 m0 *1 297.36,448.56
X$31795 9264 9263 4004 4003 4078 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $31799 m0 *1 302.96,448.56
X$31799 4028 4079 4076 4004 9264 9263 4072 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $31824 m0 *1 530.32,478.8
X$31824 9264 4479 4007 4168 4404 4367 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31829 m0 *1 666.4,438.48
X$31829 9263 4008 9264 4016 4009 4053 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $31836 m0 *1 685.44,519.12
X$31836 9264 9263 4010 4973 4918 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $31843 r0 *1 686.56,498.96
X$31843 4011 9264 9263 4726 4794 4702 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31849 m0 *1 722.4,498.96
X$31849 9264 9263 4487 4012 4623 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $31856 r0 *1 715.68,498.96
X$31856 9264 4221 4858 4622 4012 9263 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $31860 r0 *1 682.08,942.48
X$31860 9264 9263 8945 7176 4013 8939 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31876 r0 *1 753.2,942.48
X$31876 9264 9263 8943 7862 4013 8971 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31879 r0 *1 759.36,650.16
X$31879 9264 9263 6638 6590 4013 6239 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31881 r0 *1 757.12,509.04
X$31881 9264 9263 4766 4862 4013 4505 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31883 r0 *1 738.64,942.48
X$31883 9264 9263 8944 8127 4013 8913 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31886 r0 *1 668.64,942.48
X$31886 9264 9263 8875 7860 4013 8891 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31889 m0 *1 677.6,942.48
X$31889 9264 9263 8889 8009 4013 8876 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31891 m0 *1 726.32,952.56
X$31891 9264 9263 8941 8336 4013 8972 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31894 m0 *1 709.52,952.56
X$31894 9264 9263 8978 8189 4013 8970 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31913 r0 *1 639.52,438.48
X$31913 9264 4018 4106 4052 4092 4091 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31921 m0 *1 537.6,458.64
X$31921 4019 9264 9263 4241 4199 4170 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31930 r0 *1 536.48,438.48
X$31930 9264 4088 4047 4021 4119 4085 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $31965 r0 *1 194.88,458.64
X$31965 9264 4202 4027 9263 4203 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $31974 m0 *1 209.44,458.64
X$31974 9263 4203 4205 9264 4028 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $31987 r0 *1 200.48,458.64
X$31987 9264 9263 4029 4204 4205 4230 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32008 r0 *1 253.68,438.48
X$32008 9264 9263 4068 4031 4066 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $32010 m0 *1 133.28,458.64
X$32010 9264 4270 4162 4185 4182 4164 9263 4031 gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $32021 r0 *1 303.52,448.56
X$32021 9264 9263 4033 4079 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32024 r0 *1 373.52,438.48
X$32024 9263 4033 4074 9264 4043 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $32039 m0 *1 288.96,448.56
X$32039 9264 4078 4108 9263 4034 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $32043 r0 *1 347.2,438.48
X$32043 9264 9263 4035 4037 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32054 m0 *1 355.04,458.64
X$32054 9264 9263 4036 4039 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $32095 r0 *1 455.28,438.48
X$32095 9264 9263 4043 4044 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32106 m0 *1 515.2,438.48
X$32106 9264 9263 4045 4046 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32108 m0 *1 505.12,448.56
X$32108 4123 9264 9263 4122 4243 4045 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32112 r0 *1 509.04,438.48
X$32112 9264 4160 4064 4084 4083 4046 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32115 r0 *1 533.12,438.48
X$32115 9264 9263 4047 4048 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32123 r0 *1 594.16,438.48
X$32123 9264 4299 4061 4049 4090 4089 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32128 r0 *1 633.92,438.48
X$32128 9264 9263 4111 4051 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32134 m0 *1 689.92,448.56
X$32134 9263 4102 4054 9264 4093 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $32138 r0 *1 678.72,438.48
X$32138 4058 9264 9263 4103 4101 4054 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32154 r0 *1 689.92,438.48
X$32154 9264 4058 4093 9263 4057 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $32176 r0 *1 617.68,438.48
X$32176 9264 9263 4061 4113 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32184 m0 *1 561.68,488.88
X$32184 9264 4527 4323 4579 4616 4062 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $32189 m0 *1 484.4,448.56
X$32189 9264 4256 4063 4161 4130 4082 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32191 r0 *1 529.76,438.48
X$32191 9264 9263 4064 4119 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32241 m0 *1 121.52,448.56
X$32241 9264 4075 9263 4162 4095 4183 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $32260 m0 *1 202.16,468.72
X$32260 9263 4163 4271 9264 4076 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $32279 r0 *1 477.68,448.56
X$32279 9264 4587 4158 4161 4081 4200 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $32281 r0 *1 483.84,438.48
X$32281 4081 9264 9263 4120 4198 4082 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32287 m0 *1 530.88,458.64
X$32287 9264 9263 4245 4083 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32293 m0 *1 514.64,448.56
X$32293 9264 4197 4131 4121 4132 4084 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32295 r0 *1 547.12,448.56
X$32295 4085 9264 9263 4170 4195 4193 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32298 r0 *1 590.8,438.48
X$32298 9264 9263 4086 4115 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32302 m0 *1 565.04,448.56
X$32302 9264 4323 4086 4087 4136 4117 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32309 m0 *1 586.32,448.56
X$32309 9264 9263 4171 4088 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32314 m0 *1 600.32,448.56
X$32314 9264 9263 4156 4089 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32316 r0 *1 609.84,448.56
X$32316 9264 9263 4173 4090 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32321 r0 *1 639.52,448.56
X$32321 4091 9264 9263 4175 4151 4140 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32324 m0 *1 638.4,448.56
X$32324 9264 4109 4105 4092 4141 4140 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32360 r0 *1 680.96,448.56
X$32360 9264 4187 4146 4101 4186 4143 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32368 m0 *1 655.2,448.56
X$32368 9264 4105 4103 4107 4142 4147 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32390 m0 *1 635.04,448.56
X$32390 9264 9263 4112 4109 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32395 r0 *1 619.92,448.56
X$32395 9264 4663 4137 4110 4188 4174 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32398 m0 *1 618.24,448.56
X$32398 9264 4421 4112 4111 4139 4138 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32422 m0 *1 561.68,448.56
X$32422 9264 9263 4133 4117 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32434 m0 *1 501.76,448.56
X$32434 9264 9263 4121 4120 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32443 m0 *1 422.24,458.64
X$32443 9264 4311 4122 4166 4196 4208 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32480 r0 *1 500.64,448.56
X$32480 9264 9263 4159 4130 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32489 m0 *1 466.48,458.64
X$32489 9264 4210 4132 4355 4213 4212 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32493 r0 *1 561.68,448.56
X$32493 9264 4157 4133 4135 4193 4134 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32497 r0 *1 578.48,448.56
X$32497 4134 9264 9263 4216 4192 4155 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32502 m0 *1 595.84,478.8
X$32502 9264 9263 4522 4136 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32507 r0 *1 616.56,448.56
X$32507 9264 9263 4137 4138 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32514 m0 *1 630,458.64
X$32514 9264 9263 4328 4139 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32519 r0 *1 636.16,478.8
X$32519 9264 4519 4283 4141 4483 4422 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32522 r0 *1 654.64,458.64
X$32522 9264 4283 4187 4142 4219 4263 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32528 r0 *1 678.72,458.64
X$32528 4143 9264 9263 4233 4236 9313 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32536 m0 *1 747.6,478.8
X$32536 9264 9263 4265 4444 4144 4336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32539 r0 *1 750.4,478.8
X$32539 9264 9263 4335 4430 4144 4337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32541 m0 *1 733.6,458.64
X$32541 9264 9263 4184 4229 4144 4178 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32553 m0 *1 658,468.72
X$32553 4147 9264 9263 4350 4284 4263 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32571 r0 *1 626.08,458.64
X$32571 4151 9264 9263 4217 4262 4238 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32576 r0 *1 609.28,458.64
X$32576 4152 9264 9263 4295 4239 4218 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32584 r0 *1 593.04,448.56
X$32584 9264 4190 4156 4154 4155 4172 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32596 r0 *1 589.12,458.64
X$32596 9264 9263 4244 4157 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32608 r0 *1 505.68,448.56
X$32608 9264 9263 4240 4160 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32625 m0 *1 185.36,458.64
X$32625 9263 4201 4163 9264 4230 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $32628 r0 *1 145.04,458.64
X$32628 9264 9263 4201 4270 4163 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $32641 m0 *1 439.04,458.64
X$32641 4198 9264 9263 4349 4166 4167 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32644 m0 *1 451.92,458.64
X$32644 9264 9263 4167 4212 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32651 r0 *1 539.84,448.56
X$32651 9264 9263 4169 4197 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32654 r0 *1 549.36,519.12
X$32654 9264 4998 4551 4169 4999 4912 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32660 m0 *1 575.12,509.04
X$32660 9264 4757 4616 4171 4760 4759 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32666 m0 *1 609.84,458.64
X$32666 4172 9264 9263 4218 4189 4188 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32670 r0 *1 595.28,488.88
X$32670 9264 4664 4521 4173 4555 4554 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32672 r0 *1 635.6,458.64
X$32672 4174 9264 9263 4327 4238 4353 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32676 m0 *1 645.12,468.72
X$32676 9264 9263 4329 4175 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32678 r0 *1 328.72,690.48
X$32678 9264 9263 6921 6979 4176 6974 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32680 r0 *1 313.6,781.2
X$32680 9264 9263 7881 7928 4176 7846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32685 m0 *1 706.72,478.8
X$32685 9264 9263 4176 4425 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $32701 r0 *1 318.08,801.36
X$32701 9264 9263 8049 8048 4176 7993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32703 r0 *1 416.08,811.44
X$32703 9264 9263 8276 8106 4176 8103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32706 m0 *1 342.72,811.44
X$32706 9264 9263 8166 8138 4176 8164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32708 r0 *1 311.92,821.52
X$32708 9264 9263 8308 8310 4176 8223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32710 m0 *1 313.04,720.72
X$32710 9264 9263 7254 7283 4176 6557 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32712 r0 *1 321.44,680.4
X$32712 9264 9263 6864 6919 4176 6558 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32717 r0 *1 731.36,478.8
X$32717 9264 9263 4178 4511 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32725 m0 *1 724.08,488.88
X$32725 9264 9263 4514 4178 4426 4485 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32727 r0 *1 734.72,458.64
X$32727 9264 4222 4179 4178 4223 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $32733 m0 *1 829.36,498.96
X$32733 9264 9263 4649 4708 4706 4180 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32740 r0 *1 957.6,448.56
X$32740 4180 9263 9264 4181 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32758 m0 *1 688.24,488.88
X$32758 9264 4517 4484 4186 4515 4424 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32775 m0 *1 580.16,458.64
X$32775 4191 9264 9263 4368 4332 4189 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32778 m0 *1 600.88,458.64
X$32778 9264 9263 4481 4190 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32783 m0 *1 570.08,458.64
X$32783 4194 9264 9263 4191 4246 4192 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32796 m0 *1 547.12,458.64
X$32796 4245 9264 9263 4194 4215 4195 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32805 m0 *1 418.88,458.64
X$32805 9264 9263 4207 4196 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32819 m0 *1 527.52,458.64
X$32819 9264 9263 4258 4199 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32823 m0 *1 483.28,589.68
X$32823 5867 9264 4200 9263 5869 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $32862 r0 *1 500.64,458.64
X$32862 9264 4362 4241 4243 4206 4294 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32864 r0 *1 402.08,458.64
X$32864 9264 9263 4235 4206 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32867 m0 *1 414.96,468.72
X$32867 9264 4252 4207 4313 4312 4251 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32870 r0 *1 426.72,458.64
X$32870 9264 9263 4237 4208 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32872 r0 *1 457.52,458.64
X$32872 9264 9263 4209 4253 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32874 r0 *1 460.88,458.64
X$32874 4209 9264 9263 4285 4352 4211 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32876 r0 *1 470.4,458.64
X$32876 9264 9263 4211 4210 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32885 r0 *1 486.64,458.64
X$32885 9264 9263 4214 4213 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32891 r0 *1 490,458.64
X$32891 4214 9264 9263 4247 4289 4240 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32894 r0 *1 538.16,458.64
X$32894 4247 9264 9263 4248 4259 4215 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32897 r0 *1 570.08,458.64
X$32897 4242 9264 9263 4298 4260 4216 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32901 r0 *1 592.48,458.64
X$32901 9264 4255 4217 4239 4297 4296 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32906 r0 *1 652.4,488.88
X$32906 9264 4575 4517 4219 4620 4559 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $32910 m0 *1 714.56,478.8
X$32910 9264 9263 4396 4220 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32913 r0 *1 717.36,509.04
X$32913 9263 4789 4221 5129 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $32918 m0 *1 715.12,509.04
X$32918 9263 9264 4793 5007 4221 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $32923 r0 *1 743.12,468.72
X$32923 9264 9263 4222 4377 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32931 r0 *1 748.16,458.64
X$32931 4223 9264 9263 4336 4337 9297 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32937 m0 *1 963.2,458.64
X$32937 4226 9263 9264 4224 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32940 m0 *1 954.8,458.64
X$32940 4228 9263 9264 4225 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32942 r0 *1 853.44,498.96
X$32942 9264 9263 4628 4710 4630 4226 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32950 m0 *1 790.16,519.12
X$32950 9264 9263 4864 4924 4769 4227 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32956 r0 *1 955.36,458.64
X$32956 4227 9263 9264 4339 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32959 r0 *1 872.48,498.96
X$32959 9264 9263 4629 4712 4630 4228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32979 r0 *1 311.92,458.64
X$32979 9264 4469 4278 4232 4281 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $32982 r0 *1 271.04,458.64
X$32982 9264 9263 4249 4232 4276 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $32987 r0 *1 700,458.64
X$32987 4233 9264 9263 4334 4234 9301 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32992 r0 *1 688.24,458.64
X$32992 4236 9264 9263 4333 4373 4234 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $32997 r0 *1 405.44,458.64
X$32997 9264 4318 4235 4237 4252 4251 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33035 r0 *1 588,519.12
X$33035 9264 5034 4964 4244 5002 5001 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33043 r0 *1 558.32,458.64
X$33043 4248 9264 9263 4327 4317 4246 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33055 r0 *1 272.72,468.72
X$33055 9264 9263 4303 4249 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33058 m0 *1 325.92,468.72
X$33058 9264 4391 4280 4346 4309 4250 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33060 r0 *1 325.36,458.64
X$33060 4250 9264 9263 4392 4472 4308 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33063 m0 *1 468.72,478.8
X$33063 9264 9263 4251 4322 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $33071 m0 *1 487.76,468.72
X$33071 9264 4319 4291 4257 4318 4251 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33073 m0 *1 390.88,589.68
X$33073 9263 9264 5897 4251 5468 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $33077 m0 *1 451.36,488.88
X$33077 9264 9263 4611 4252 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $33079 m0 *1 507.92,468.72
X$33079 9264 4252 4293 4258 4291 4321 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33086 m0 *1 411.04,488.88
X$33086 9264 4252 4518 4476 4312 4545 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33089 m0 *1 444.64,478.8
X$33089 9264 4402 4364 4612 4253 4458 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33092 r0 *1 462.56,579.6
X$33092 5867 9264 9263 4327 4254 5825 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33095 m0 *1 454.16,468.72
X$33095 4314 9264 9263 4254 4322 4315 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33098 r0 *1 599.2,468.72
X$33098 9264 9263 4254 4319 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $33100 r0 *1 390.88,599.76
X$33100 9263 6016 5468 4254 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $33103 m0 *1 534.8,468.72
X$33103 4290 9264 9263 4368 4254 4259 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33105 m0 *1 636.16,509.04
X$33105 4619 9264 9263 4254 4798 4797 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33113 r0 *1 467.6,478.8
X$33113 9264 9263 4318 4255 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $33115 m0 *1 464.24,468.72
X$33115 4316 9264 9263 4317 4255 4287 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33118 r0 *1 623.84,488.88
X$33118 4556 9264 9263 4255 4762 4557 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33125 r0 *1 460.32,488.88
X$33125 9264 4549 4363 4255 4611 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $33129 m0 *1 484.4,468.72
X$33129 9264 9263 4354 4256 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33131 m0 *1 504.56,468.72
X$33131 9264 9263 4257 4294 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33138 m0 *1 561.68,468.72
X$33138 9264 4322 4295 4260 4300 4325 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33141 m0 *1 626.64,468.72
X$33141 9264 9263 4261 4262 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33143 m0 *1 609.84,468.72
X$33143 9264 4319 4288 4261 4292 4348 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33150 m0 *1 727.44,478.8
X$33150 9264 9263 4264 4427 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $33155 r0 *1 963.76,458.64
X$33155 4272 9263 9264 4266 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33158 m0 *1 947.52,468.72
X$33158 4343 9263 9264 4267 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33162 m0 *1 939.12,468.72
X$33162 4338 9263 9264 4268 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33164 m0 *1 955.92,468.72
X$33164 4273 9263 9264 4269 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33175 m0 *1 801.92,498.96
X$33175 9264 9263 4650 4704 4630 4272 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33183 r0 *1 813.68,498.96
X$33183 9264 9263 4627 4705 4706 4273 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33193 m0 *1 270.48,468.72
X$33193 4303 9264 9263 4277 4304 4274 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33196 m0 *1 260.96,468.72
X$33196 9263 4274 9264 4275 4276 4302 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $33201 m0 *1 254.8,468.72
X$33201 9263 4344 4301 9264 4275 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $33210 m0 *1 291.2,468.72
X$33210 9264 4345 4277 4279 4307 4306 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33216 m0 *1 314.16,468.72
X$33216 4281 9264 9263 4280 4279 4278 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33230 m0 *1 664.72,478.8
X$33230 9264 4317 4373 4282 4423 4372 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33232 m0 *1 648.48,468.72
X$33232 4284 9264 9263 4286 4282 4331 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33246 m0 *1 474.88,468.72
X$33246 4285 9264 9263 4290 4287 4289 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33249 m0 *1 633.36,468.72
X$33249 9264 9263 4288 4286 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33274 m0 *1 604.24,468.72
X$33274 9264 9263 4326 4292 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33279 r0 *1 534.8,458.64
X$33279 9264 9263 4293 4298 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33294 r0 *1 603.68,468.72
X$33294 9264 4368 4326 4296 4327 4317 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33300 r0 *1 586.88,468.72
X$33300 9264 9263 4357 4297 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33306 m0 *1 592.48,478.8
X$33306 9264 9263 4524 4299 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33311 m0 *1 558.32,468.72
X$33311 9264 9263 4356 4300 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33319 r0 *1 211.68,478.8
X$33319 9264 4466 4467 9263 4301 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $33322 r0 *1 246.4,468.72
X$33322 4302 9264 9263 4385 4439 4344 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33329 r0 *1 255.92,468.72
X$33329 9264 4386 4385 4304 4359 4358 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33331 r0 *1 301.28,468.72
X$33331 4306 9264 9263 4388 5044 4305 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33334 r0 *1 283.36,468.72
X$33334 9264 4387 4386 4307 4389 4305 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33343 r0 *1 320.32,468.72
X$33343 9264 4447 4345 4309 4390 4308 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33348 m0 *1 341.04,478.8
X$33348 9264 4393 4391 4310 4450 4412 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33350 r0 *1 356.16,468.72
X$33350 9264 4346 4310 4394 4395 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $33353 r0 *1 535.36,488.88
X$33353 4615 9264 9263 4311 4692 4550 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33355 m0 *1 422.8,498.96
X$33355 9264 9263 4545 4311 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $33360 m0 *1 421.12,529.2
X$33360 9264 4992 4991 5050 4454 4311 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33362 r0 *1 420,488.88
X$33362 9264 4454 4727 4546 4362 4311 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33365 r0 *1 429.52,468.72
X$33365 9264 9263 4312 4362 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $33370 m0 *1 424.48,559.44
X$33370 9264 9263 5471 4312 5475 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $33374 m0 *1 431.2,478.8
X$33374 9264 9263 4313 4361 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33377 r0 *1 445.76,468.72
X$33377 4457 9264 9263 4363 4314 4351 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33382 r0 *1 456.96,468.72
X$33382 4456 9264 9263 4316 4315 4352 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33387 r0 *1 459.2,509.04
X$33387 4835 9264 9263 4332 4317 5096 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33391 r0 *1 557.2,478.8
X$33391 9264 9263 4320 4317 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $33394 r0 *1 661.36,509.04
X$33394 4764 9264 9263 4317 4882 4915 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33412 r0 *1 505.68,468.72
X$33412 9264 4319 4356 4321 4320 4318 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33416 r0 *1 394.24,579.6
X$33416 9263 9264 5895 4318 5471 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $33426 r0 *1 553.28,468.72
X$33426 9264 4420 4357 4324 4319 4320 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33437 m0 *1 400.96,579.6
X$33437 9263 9264 6291 4320 5471 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $33442 r0 *1 450.8,488.88
X$33442 4580 9264 9263 4362 4322 4548 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33446 m0 *1 604.24,488.88
X$33446 4555 9264 9263 4322 4847 4482 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33456 r0 *1 570.08,468.72
X$33456 9264 9263 4324 4325 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33464 r0 *1 452.48,589.68
X$33464 9263 6421 5468 4327 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $33468 r0 *1 676.48,478.8
X$33468 4423 9264 9263 4327 4332 4374 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33471 m0 *1 563.36,579.6
X$33471 9264 4327 4999 4804 5768 5802 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33474 r0 *1 677.04,539.28
X$33474 5243 9264 9263 4758 4327 5279 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33489 r0 *1 661.36,468.72
X$33489 9264 4368 4372 4347 4327 4332 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33493 m0 *1 613.76,488.88
X$33493 9264 4482 4519 4328 4556 4520 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33496 m0 *1 633.36,478.8
X$33496 9264 4558 4464 4329 4370 4369 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33498 r0 *1 647.36,468.72
X$33498 9264 9263 4330 4369 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33500 r0 *1 650.72,468.72
X$33500 4330 9264 9263 4332 4331 4371 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33508 r0 *1 458.64,619.92
X$33508 9263 6285 5822 4332 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $33510 r0 *1 580.72,559.44
X$33510 9264 4332 5056 4912 5535 5590 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33512 r0 *1 686.56,539.28
X$33512 9264 5329 9263 4918 4332 5374 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $33514 m0 *1 683.2,559.44
X$33514 9263 5513 4332 9264 5405 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $33529 r0 *1 694.4,468.72
X$33529 9264 9263 4333 4401 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33533 r0 *1 684.88,468.72
X$33533 4333 9264 9263 4368 4374 9293 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33536 r0 *1 700.56,468.72
X$33536 9264 9263 4334 4376 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33542 m0 *1 664.72,529.2
X$33542 9264 4334 4916 5063 5064 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $33547 r0 *1 758.8,478.8
X$33547 9264 9263 4336 4428 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33556 r0 *1 749.84,488.88
X$33556 9264 9263 4651 4336 4426 4625 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33559 m0 *1 746.48,488.88
X$33559 9264 9263 4337 4449 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33568 m0 *1 749.84,488.88
X$33568 9264 9263 4488 4337 4426 4489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33573 m0 *1 841.12,498.96
X$33573 9264 9263 4490 4709 4706 4338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33581 m0 *1 980.56,468.72
X$33581 4342 9263 9264 4340 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33583 r0 *1 956.48,468.72
X$33583 4378 9263 9264 4341 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33586 m0 *1 906.64,509.04
X$33586 9264 9263 4779 4770 4769 4342 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33594 m0 *1 830.48,509.04
X$33594 9264 9263 4707 4767 4706 4343 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33614 m0 *1 672.56,468.72
X$33614 9264 9263 4347 4348 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33626 m0 *1 414.4,478.8
X$33626 9264 4454 4349 4416 4400 4361 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33631 m0 *1 653.52,488.88
X$33631 4350 9264 9263 4574 4371 4559 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33633 r0 *1 445.76,478.8
X$33633 4477 9264 9263 4456 4351 4403 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33640 r0 *1 644,468.72
X$33640 9264 9263 4353 4370 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33646 r0 *1 477.12,478.8
X$33646 9264 4751 4354 4419 4462 4460 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33650 m0 *1 475.44,478.8
X$33650 9264 4366 4460 4365 4364 4355 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33663 m0 *1 262.08,488.88
X$33663 4358 9264 9263 4642 4599 4406 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33667 r0 *1 250.88,478.8
X$33667 9264 4441 4437 4359 4468 4406 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33671 r0 *1 384.72,478.8
X$33671 9263 4516 4453 9264 4360 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $33673 m0 *1 380.24,478.8
X$33673 9264 4397 4398 4399 4360 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $33682 r0 *1 545.44,488.88
X$33682 4530 9264 9263 4362 4584 4583 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33697 r0 *1 483.84,579.6
X$33697 9264 4363 5829 5828 5869 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $33703 m0 *1 492.24,478.8
X$33703 9264 9263 4365 4418 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33709 m0 *1 539.84,498.96
X$33709 9264 4695 4589 4662 4732 4366 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $33711 m0 *1 547.12,478.8
X$33711 9264 9263 4551 4367 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33718 r0 *1 552.16,478.8
X$33718 9264 9263 4420 4368 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $33723 r0 *1 557.76,509.04
X$33723 9264 4368 4886 4884 4913 4843 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33726 r0 *1 668.08,519.12
X$33726 4917 9264 9263 4368 5004 5099 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33747 r0 *1 670.88,488.88
X$33747 4661 9264 9263 4423 4372 4660 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33754 m0 *1 684.88,478.8
X$33754 9264 9263 4373 4375 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33762 r0 *1 688.8,519.12
X$33762 9264 9263 4374 5005 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33770 m0 *1 688.24,478.8
X$33770 9264 4401 4461 4459 4376 4375 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33778 r0 *1 861.84,498.96
X$33778 9264 9263 4562 4711 4630 4378 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33786 r0 *1 952,498.96
X$33786 9264 9263 4631 4771 4493 4379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33792 r0 *1 980.56,468.72
X$33792 4379 9263 9264 4381 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33795 r0 *1 946.4,478.8
X$33795 4491 9263 9264 4380 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33799 m0 *1 963.76,478.8
X$33799 4431 9263 9264 4382 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33802 r0 *1 972.16,468.72
X$33802 4384 9263 9264 4383 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33805 m0 *1 930.72,519.12
X$33805 9264 9263 4866 4927 4769 4384 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33824 m0 *1 295.68,478.8
X$33824 9264 4445 4387 4390 4410 4409 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33828 m0 *1 292.32,478.8
X$33828 9264 9263 4408 4388 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33836 r0 *1 267.68,478.8
X$33836 9264 4442 4441 4389 4443 4407 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33847 m0 *1 327.6,478.8
X$33847 9264 9263 4983 4392 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33851 m0 *1 357.84,478.8
X$33851 9264 4451 4393 4397 4414 4413 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33854 m0 *1 349.44,640.08
X$33854 9264 6514 5610 6566 4394 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $33859 r0 *1 472.08,609.84
X$33859 9264 6018 6141 6271 4395 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $33866 r0 *1 483.84,630
X$33866 6428 9264 6427 9263 4395 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $33876 r0 *1 358.96,599.76
X$33876 9264 6074 5363 6052 6075 4398 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $33881 m0 *1 400.96,488.88
X$33881 9263 4399 4577 9264 4830 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $33886 m0 *1 411.04,478.8
X$33886 9264 9263 4518 4400 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33895 r0 *1 442.4,468.72
X$33895 9264 9263 4403 4402 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33904 m0 *1 550.48,478.8
X$33904 9264 9263 4529 4404 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33909 m0 *1 243.6,488.88
X$33909 4405 9264 9263 4507 4506 4503 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33911 r0 *1 234.08,478.8
X$33911 9264 4437 4438 4439 4440 4405 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33917 m0 *1 274.4,488.88
X$33917 9264 9263 4677 4407 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33923 m0 *1 276.08,549.36
X$33923 9264 5357 4677 4408 5263 5358 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33926 r0 *1 301.84,478.8
X$33926 9264 9263 4602 4409 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33930 m0 *1 277.76,488.88
X$33930 9264 4600 4442 4410 4508 4509 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33935 m0 *1 333.76,488.88
X$33935 9264 9263 5024 4411 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33938 r0 *1 329.28,478.8
X$33938 9264 4448 4447 4450 4446 4411 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33942 m0 *1 346.08,549.36
X$33942 5610 9264 9263 5300 5360 4412 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33946 r0 *1 362.88,478.8
X$33946 9264 9263 4605 4413 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33951 r0 *1 346.08,478.8
X$33951 9264 4473 4448 4414 4475 4474 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33954 m0 *1 373.52,488.88
X$33954 9264 9263 4986 4415 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33957 r0 *1 367.92,478.8
X$33957 9264 4576 4451 4453 4452 4415 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $33960 r0 *1 428.4,478.8
X$33960 4455 9264 9263 4578 4416 4417 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33963 r0 *1 442.4,478.8
X$33963 9264 9263 4417 4458 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33966 m0 *1 474.88,488.88
X$33966 4523 9264 9263 4418 4455 4586 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $33971 r0 *1 493.92,478.8
X$33971 9264 9263 4419 4588 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33976 r0 *1 567.28,609.84
X$33976 9263 4420 6190 9264 6150 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $33983 m0 *1 475.44,619.92
X$33983 9263 9264 6426 4420 5824 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $33987 r0 *1 619.36,478.8
X$33987 9264 9263 4521 4421 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33989 r0 *1 632.8,478.8
X$33989 9264 9263 4464 4422 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33999 r0 *1 700,478.8
X$33999 9264 9263 4459 4424 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34004 m0 *1 618.24,609.84
X$34004 9263 4425 6300 9264 6152 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34007 r0 *1 747.04,549.36
X$34007 9263 4425 5409 9264 5368 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34009 m0 *1 761.04,559.44
X$34009 9263 4425 5485 9264 5410 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34011 m0 *1 762.16,539.28
X$34011 9263 4425 5281 9264 5071 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34013 r0 *1 703.36,549.36
X$34013 9263 4425 5584 9264 5208 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34015 r0 *1 720.72,549.36
X$34015 9263 4425 5331 9264 5330 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34017 m0 *1 642.88,609.84
X$34017 9263 4425 6084 9264 6125 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34020 m0 *1 667.52,609.84
X$34020 9263 4425 6224 9264 6123 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34030 r0 *1 666.4,630
X$34030 9263 4425 6305 9264 6373 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34043 m0 *1 755.44,519.12
X$34043 9263 4865 4427 5023 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $34045 m0 *1 727.44,650.16
X$34045 9263 9264 6593 4427 6594 5995 6595 6045
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $34048 m0 *1 639.52,680.4
X$34048 9263 9264 6781 4427 6831 6999 6912 6045
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $34060 m0 *1 666.96,589.68
X$34060 9263 4427 4774 9264 5908 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34062 r0 *1 734.72,478.8
X$34062 4486 9264 9263 4428 4449 4429 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34073 m0 *1 922.32,519.12
X$34073 9264 9263 4943 4926 4769 4431 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34080 m0 *1 953.68,488.88
X$34080 9264 9263 4492 4564 4493 4432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34086 m0 *1 972.16,478.8
X$34086 4432 9263 9264 4498 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $34089 r0 *1 962.08,478.8
X$34089 4436 9263 9264 4433 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $34092 m0 *1 980.56,478.8
X$34092 4435 9263 9264 4434 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $34094 m0 *1 971.6,488.88
X$34094 9264 9263 4495 4501 4493 4435 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34102 r0 *1 777.28,509.04
X$34102 9264 9263 4784 4863 4630 4436 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34114 m0 *1 210.56,488.88
X$34114 4466 9264 9263 4438 4571 4502 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34121 m0 *1 222.88,488.88
X$34121 9264 4504 4465 4440 4572 4503 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34134 m0 *1 251.44,509.04
X$34134 9264 4812 4676 4443 4740 4739 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34144 r0 *1 309.68,478.8
X$34144 9264 4603 4445 4446 4471 4470 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34172 m0 *1 349.44,488.88
X$34172 9264 4512 4473 4452 4540 4513 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34182 r0 *1 514.08,509.04
X$34182 4839 9264 9263 4840 4454 4888 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34193 r0 *1 440.16,559.44
X$34193 9263 5468 5684 9264 4454 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34203 r0 *1 443.52,488.88
X$34203 9264 9263 4457 4547 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34220 r0 *1 694.96,478.8
X$34220 9264 9263 4461 4573 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34228 r0 *1 514.08,488.88
X$34228 9264 4614 4463 4462 4591 4589 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34239 r0 *1 197.68,488.88
X$34239 9264 4465 4570 4571 4595 4535 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34245 m0 *1 203.28,488.88
X$34245 9263 4502 4500 9264 4467 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34249 r0 *1 236.88,488.88
X$34249 9264 4676 4504 4468 4539 4538 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34256 r0 *1 445.76,640.08
X$34256 9264 6533 4469 6571 6569 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $34260 r0 *1 330.4,488.88
X$34260 9264 9263 5470 4470 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34263 m0 *1 277.2,498.96
X$34263 9264 4643 4600 4471 4601 4644 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34269 r0 *1 332.64,529.2
X$34269 4472 9264 9263 5157 5158 5113 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34274 r0 *1 356.16,488.88
X$34274 9264 9263 4648 4474 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34276 m0 *1 316.96,498.96
X$34276 9264 4604 4603 4475 4646 4647 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34281 m0 *1 427.28,498.96
X$34281 9264 9263 4476 4608 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34284 m0 *1 443.52,488.88
X$34284 9264 9263 4477 4478 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34287 m0 *1 430.64,498.96
X$34287 9264 4688 4652 4609 4478 4689 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34291 m0 *1 530.32,488.88
X$34291 9264 9263 4531 4479 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34295 m0 *1 538.16,488.88
X$34295 9264 4550 4528 4529 4530 4480 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34297 m0 *1 550.48,529.2
X$34297 4998 9264 9263 5100 5102 4480 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34302 r0 *1 600.88,509.04
X$34302 9264 4846 4845 4481 4848 4849 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34306 r0 *1 633.36,488.88
X$34306 9264 4557 4575 4483 4619 4618 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34309 r0 *1 685.44,488.88
X$34309 4560 9264 9263 4484 4561 4726 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34312 m0 *1 742,519.12
X$34312 4921 9264 4485 4625 9263 5025 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $34315 m0 *1 735.28,519.12
X$34315 4489 9264 4485 4861 9263 4923 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $34318 r0 *1 721.28,519.12
X$34318 4921 9264 4485 4861 9263 5070 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $34320 r0 *1 726.88,509.04
X$34320 9264 9263 4485 4859 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34322 m0 *1 724.08,509.04
X$34322 9263 4623 9264 4789 4485 4489 4625 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $34330 m0 *1 734.16,509.04
X$34330 9264 9263 4489 4860 4485 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34332 m0 *1 732.48,488.88
X$34332 9263 4511 4486 9264 4487 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34349 m0 *1 722.4,519.12
X$34349 9264 9263 4489 4921 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34360 r0 *1 729.12,519.12
X$34360 4489 9264 4859 4861 9263 5166 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $34362 m0 *1 728.56,519.12
X$34362 4489 9264 4859 4625 9263 4960 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $34367 m0 *1 879.2,509.04
X$34367 9264 9263 4780 4768 4769 4491 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34378 r0 *1 954.24,811.44
X$34378 9264 8261 4493 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $34382 m0 *1 962.08,720.72
X$34382 9264 9263 7248 7253 4493 7249 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34390 r0 *1 971.6,498.96
X$34390 9264 9263 4717 4716 4493 4565 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34393 r0 *1 949.2,519.12
X$34393 9264 9263 4941 5010 4493 4496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34396 m0 *1 970.48,519.12
X$34396 9264 9263 4868 4928 4493 4714 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34400 m0 *1 950.88,680.4
X$34400 9264 9263 6840 6887 4493 6841 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34403 r0 *1 972.16,630
X$34403 9264 9263 6317 6498 4493 6250 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34405 m0 *1 948.64,750.96
X$34405 9264 9263 7535 7591 4493 7423 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34407 m0 *1 920.64,498.96
X$34407 9264 9263 4641 4624 4630 4494 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34411 r0 *1 970.48,478.8
X$34411 4494 9263 9264 4567 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $34423 r0 *1 978.88,478.8
X$34423 4496 9263 9264 4499 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $34425 m0 *1 980.56,488.88
X$34425 4565 9263 9264 4497 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $34433 r0 *1 166.88,488.88
X$34433 9263 4533 9264 4569 4500 4594 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $34437 m0 *1 850.08,589.68
X$34437 9264 9263 5859 5441 5843 4501 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34446 m0 *1 841.68,589.68
X$34446 9264 9263 5845 4501 5704 5923 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34452 m0 *1 703.36,599.76
X$34452 9264 9263 5975 4501 5974 5294 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34454 m0 *1 694.4,589.68
X$34454 9264 5911 5801 5291 4708 5868 4501 4710 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $34474 m0 *1 963.2,488.88
X$34474 4505 9263 9264 4566 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $34479 r0 *1 259.28,498.96
X$34479 4506 9264 9263 4722 4679 4640 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34482 m0 *1 225.12,498.96
X$34482 9264 4738 4536 4507 4639 4673 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34489 r0 *1 255.92,509.04
X$34489 9264 4877 4812 4508 4813 4876 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34491 m0 *1 299.04,488.88
X$34491 9264 9263 4510 4509 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34499 r0 *1 302.4,559.44
X$34499 5264 9264 9263 5652 5569 4510 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34504 m0 *1 370.72,498.96
X$34504 9264 4790 4512 4542 4687 4606 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34508 m0 *1 348.88,498.96
X$34508 9264 9263 4785 4513 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34517 m0 *1 692.72,498.96
X$34517 9264 4655 4621 4515 4703 4573 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34525 m0 *1 360.08,630
X$34525 9264 6210 6074 6404 6464 4516 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $34538 r0 *1 618.8,488.88
X$34538 9264 9263 4696 4520 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34547 m0 *1 580.72,488.88
X$34547 9264 4526 4524 4522 4553 4525 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34549 m0 *1 479.36,609.84
X$34549 9264 6119 4523 6186 6271 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $34561 r0 *1 585.76,498.96
X$34561 9264 9263 4964 4525 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34566 r0 *1 561.68,488.88
X$34566 9264 9263 4582 4526 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34568 m0 *1 558.32,488.88
X$34568 9264 9263 4528 4527 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34588 m0 *1 523.04,498.96
X$34588 9264 4754 4531 4659 4615 4658 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34590 m0 *1 163.52,498.96
X$34590 9264 9263 4593 4532 4592 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34592 r0 *1 159.6,488.88
X$34592 9264 4568 9263 4533 4532 4534 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $34597 r0 *1 163.52,498.96
X$34597 9264 4594 4734 4668 4534 9263 4733 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $34599 r0 *1 185.92,488.88
X$34599 4568 9264 9263 4570 4637 4534 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34604 r0 *1 207.76,498.96
X$34604 4535 9264 9263 4873 4719 4671 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34607 r0 *1 214.48,488.88
X$34607 9264 4596 4638 4572 4537 4536 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34613 m0 *1 221.76,498.96
X$34613 9264 9263 4809 4537 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34615 m0 *1 248.64,498.96
X$34615 9264 4675 4538 4642 4598 4597 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34620 r0 *1 222.88,519.12
X$34620 9264 4977 4596 4539 5017 4896 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34625 r0 *1 326.48,498.96
X$34625 9264 4724 4604 4540 4684 4683 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34628 m0 *1 367.36,498.96
X$34628 9264 9263 4685 4541 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34631 r0 *1 378.56,488.88
X$34631 9264 4607 4576 4543 4542 4541 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34636 r0 *1 395.36,488.88
X$34636 9264 5366 4543 4577 4544 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $34641 m0 *1 389.2,549.36
X$34641 5364 9264 5474 9263 4544 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $34645 r0 *1 419.44,569.52
X$34645 9264 9263 5468 4545 5683 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34648 r0 *1 436.24,509.04
X$34648 9264 9263 4546 4833 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34651 r0 *1 435.68,498.96
X$34651 9264 4729 4688 4834 4610 4547 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34654 m0 *1 451.92,498.96
X$34654 5164 9264 9263 4549 4548 4654 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34665 r0 *1 565.04,488.88
X$34665 9264 4581 4582 4579 4552 4617 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34667 m0 *1 575.12,498.96
X$34667 9264 9263 4665 4552 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34669 m0 *1 589.12,498.96
X$34669 4553 9264 9263 4844 4666 4664 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34672 m0 *1 601.44,509.04
X$34672 9264 9263 4845 4554 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34686 r0 *1 635.04,498.96
X$34686 9264 9263 4851 4558 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34693 m0 *1 675.92,498.96
X$34693 9264 4661 4728 4561 4621 4701 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34768 m0 *1 892.08,559.44
X$34768 9264 9263 5421 5415 5349 4564 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34770 m0 *1 888.72,539.28
X$34770 9264 9263 5079 5221 5067 4564 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34785 m0 *1 744.8,619.92
X$34785 9264 4564 6087 9263 6233 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34787 r0 *1 768.32,619.92
X$34787 9264 4564 6091 9263 6309 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34809 r0 *1 128.24,589.68
X$34809 9264 4569 5879 5806 6038 5805 9263 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $34829 r0 *1 651.84,509.04
X$34829 4574 9264 9263 4854 4855 4763 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34846 r0 *1 418.88,498.96
X$34846 9264 4831 4578 4796 4727 4608 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34852 m0 *1 482.16,498.96
X$34852 9264 4590 4580 4838 4613 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $34857 r0 *1 557.2,488.88
X$34857 9264 9263 4583 4581 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34873 r0 *1 534.24,509.04
X$34873 4887 9264 9263 4840 5003 4584 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34875 r0 *1 473.76,488.88
X$34875 9264 9263 4656 4585 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34877 r0 *1 480.48,488.88
X$34877 9264 4585 4587 4588 4586 4590 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $34897 r0 *1 530.88,488.88
X$34897 9264 9263 4659 4591 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34902 r0 *1 155.68,498.96
X$34902 9263 4668 9264 4775 4592 4667 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $34906 m0 *1 160.16,498.96
X$34906 9264 9263 4634 4593 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34912 m0 *1 203.84,498.96
X$34912 9264 4638 4636 4595 4672 4671 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34924 r0 *1 257.04,488.88
X$34924 4597 9264 9263 4640 4721 4639 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34926 r0 *1 267.12,539.28
X$34926 9264 9263 5312 4598 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34934 m0 *1 277.2,529.2
X$34934 4599 9264 9263 4902 4981 5089 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34938 m0 *1 272.72,519.12
X$34938 9264 5019 4877 4601 4942 4899 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34942 r0 *1 301.84,539.28
X$34942 9264 5264 4602 4983 5192 5265 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34950 r0 *1 355.6,549.36
X$34950 9264 5320 4605 5364 5363 5321 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34956 m0 *1 362.32,509.04
X$34956 9264 9263 4786 4606 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34958 m0 *1 383.04,519.12
X$34958 9264 4947 4607 4949 4948 4904 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34963 m0 *1 444.08,529.2
X$34963 9264 4609 5095 5196 4952 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $34967 m0 *1 448.56,498.96
X$34967 9264 9263 4654 4610 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34970 m0 *1 578.48,498.96
X$34970 4665 9264 9263 4758 4611 4666 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $34979 r0 *1 445.2,579.6
X$34979 9263 5822 5823 9264 4611 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34983 r0 *1 452.48,498.96
X$34983 9264 4730 4690 4731 4652 4612 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $34986 m0 *1 485.52,529.2
X$34986 5054 9264 5032 9263 4613 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $34990 m0 *1 511.84,498.96
X$34990 9264 9263 4657 4614 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34997 r0 *1 575.12,498.96
X$34997 9264 9263 4805 4617 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35000 r0 *1 636.72,509.04
X$35000 4851 9264 9263 4852 4853 4618 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35006 m0 *1 649.6,509.04
X$35006 9264 4797 4655 4620 4764 4763 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35016 r0 *1 741.44,519.12
X$35016 9264 5093 4623 5025 5007 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $35018 m0 *1 712.32,529.2
X$35018 9264 5006 4623 4857 5007 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $35021 m0 *1 725.76,529.2
X$35021 9264 5211 4623 5070 5007 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $35023 r0 *1 726.32,529.2
X$35023 9264 5167 4623 4960 5007 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $35028 m0 *1 739.2,529.2
X$35028 9264 4922 4623 4923 5007 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $35030 r0 *1 739.76,529.2
X$35030 9264 5130 4623 5166 5007 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $35033 m0 *1 582.4,660.24
X$35033 9263 4624 9264 6347 6630 6676 6698 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $35035 m0 *1 576.8,650.16
X$35035 9264 9263 4624 6584 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35039 r0 *1 637.28,599.76
X$35039 9264 9263 6083 5908 5129 4624 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35041 r0 *1 645.12,619.92
X$35041 9264 6370 9263 6223 6303 6091 4624 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $35055 r0 *1 742.56,509.04
X$35055 9264 9263 4625 4861 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35066 r0 *1 730.24,509.04
X$35066 9264 4625 4860 9263 4857 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $35094 m0 *1 842.24,539.28
X$35094 9264 9263 4626 9268 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $35137 r0 *1 924,821.52
X$35137 9264 8261 4630 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $35139 r0 *1 686,740.88
X$35139 9264 9263 7491 7353 4630 7452 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35142 r0 *1 927.36,801.36
X$35142 9264 9263 8085 8018 4630 8131 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35144 m0 *1 702.8,720.72
X$35144 9264 9263 7272 6936 4630 7238 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35166 m0 *1 710.08,831.6
X$35166 9264 9263 8348 7679 4630 8373 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35171 m0 *1 972.16,509.04
X$35171 4632 9263 9264 4774 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $35174 r0 *1 980.56,498.96
X$35174 4714 9263 9264 4633 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $35178 m0 *1 168.56,498.96
X$35178 4634 9264 9263 4635 4776 4668 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35183 m0 *1 178.64,498.96
X$35183 9264 4636 4635 4637 4670 4669 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35215 m0 *1 294,498.96
X$35215 9264 4723 4643 4646 4682 4645 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35220 r0 *1 278.32,498.96
X$35220 9264 9263 4878 4644 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35223 r0 *1 296.8,498.96
X$35223 9264 9263 4680 4645 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35231 m0 *1 295.68,509.04
X$35231 9264 4742 4680 4647 4781 4745 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35239 m0 *1 352.24,559.44
X$35239 5319 9264 9263 5437 5505 4648 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35274 m0 *1 682.64,579.6
X$35274 9264 5801 4653 5743 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $35277 m0 *1 693.84,569.52
X$35277 9264 5630 4653 5547 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $35281 m0 *1 715.68,559.44
X$35281 9264 4653 9270 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $35284 r0 *1 621.6,609.84
X$35284 9264 6153 4653 6218 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $35288 r0 *1 669.76,579.6
X$35288 9264 5836 4653 5775 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $35330 m0 *1 461.44,509.04
X$35330 9264 4953 4656 4891 4799 4690 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35335 m0 *1 501.2,509.04
X$35335 9264 4957 4657 4803 4753 4752 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35338 r0 *1 526.4,498.96
X$35338 9264 4755 4658 4694 4693 4691 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35349 r0 *1 671.44,509.04
X$35349 9264 4972 4881 4701 4856 4660 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35357 r0 *1 554.4,498.96
X$35357 9264 9263 4886 4662 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35363 m0 *1 629.44,498.96
X$35363 9264 9263 4699 4663 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35376 m0 *1 160.16,509.04
X$35376 4667 9264 9263 4937 4936 4734 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35384 r0 *1 190.4,498.96
X$35384 4669 9264 9263 4737 4718 4735 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35387 m0 *1 179.2,509.04
X$35387 9264 4870 4777 4670 4736 4735 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35395 r0 *1 185.36,509.04
X$35395 9264 4871 4870 4672 4807 4872 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35400 m0 *1 231.84,509.04
X$35400 4673 9264 9263 4674 4811 4874 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35405 r0 *1 229.04,498.96
X$35405 4719 9264 9263 4720 4681 4674 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35408 m0 *1 250.32,569.52
X$35408 9264 9263 5649 4675 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35416 r0 *1 272.16,498.96
X$35416 9264 9263 4678 4722 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35418 m0 *1 338.8,509.04
X$35418 9264 4678 4786 4748 4747 4787 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35422 r0 *1 334.88,509.04
X$35422 9264 4678 4824 4823 4822 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $35425 m0 *1 371.84,509.04
X$35425 9264 9263 4826 4679 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35431 m0 *1 383.04,509.04
X$35431 9264 4791 4790 4948 4792 4679 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35435 r0 *1 343.28,498.96
X$35435 9264 9263 4824 4681 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35440 r0 *1 365.12,498.96
X$35440 9264 4749 4724 4687 4686 4681 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35446 r0 *1 283.36,519.12
X$35446 9264 5021 5019 4682 4982 4976 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35448 r0 *1 321.44,498.96
X$35448 9264 9263 4883 4683 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35453 m0 *1 321.44,509.04
X$35453 9264 4783 4723 4684 4746 4741 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35457 r0 *1 356.16,509.04
X$35457 4885 9264 9263 4748 4817 4685 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35459 m0 *1 379.68,509.04
X$35459 9264 9263 4828 4686 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35466 m0 *1 435.12,509.04
X$35466 9264 9263 4750 4689 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35473 m0 *1 544.32,539.28
X$35473 9264 5273 5100 4691 5179 5240 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35479 m0 *1 530.32,509.04
X$35479 4755 9264 9263 4961 4887 4692 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35481 m0 *1 540.4,549.36
X$35481 9264 5326 4693 4996 5305 5327 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35484 r0 *1 543.2,498.96
X$35484 9264 9263 4694 4695 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35490 r0 *1 617.68,498.96
X$35490 9264 4697 4696 4699 4700 4698 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35493 r0 *1 614.32,498.96
X$35493 9264 9263 4761 4697 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35496 m0 *1 626.08,519.12
X$35496 9264 9263 4968 4698 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35501 m0 *1 630,539.28
X$35501 9264 9263 5249 4700 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35505 m0 *1 691.04,519.12
X$35505 9264 4973 4765 4702 4919 9263 4920 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $35508 m0 *1 665.28,519.12
X$35508 9264 4915 4972 4703 4917 4916 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35513 m0 *1 790.16,539.28
X$35513 9264 9263 5163 5214 5075 4704 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35516 m0 *1 799.68,559.44
X$35516 9264 9263 5412 5348 5444 4704 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35518 r0 *1 755.44,619.92
X$35518 9264 4704 9263 6412 6338 5636 6374 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $35531 r0 *1 763.84,579.6
X$35531 9264 5864 5839 5555 4705 5700 4716 4704 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35535 m0 *1 790.16,559.44
X$35535 9264 9263 5411 5348 5440 4705 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35537 r0 *1 783.44,539.28
X$35537 9264 9263 5238 5282 5212 4705 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35549 r0 *1 739.76,630
X$35549 9264 6466 9263 6413 6465 4705 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $35555 m0 *1 672,761.04
X$35555 9264 9263 7609 7412 4706 7578 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35579 m0 *1 936.32,569.52
X$35579 9264 9263 5553 5643 4706 5554 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35582 m0 *1 663.04,821.52
X$35582 9264 9263 8325 7119 4706 8291 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35584 m0 *1 687.12,831.6
X$35584 9264 9263 8349 7636 4706 8334 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35586 m0 *1 689.36,841.68
X$35586 9264 9263 8371 7863 4706 8372 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35588 r0 *1 935.2,670.32
X$35588 9264 9263 6793 6835 4706 6728 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35592 m0 *1 823.2,559.44
X$35592 9264 9263 5416 5441 5440 4708 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35595 m0 *1 815.92,539.28
X$35595 9264 9263 5161 5235 5212 4708 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35608 r0 *1 708.4,589.68
X$35608 9264 9263 5951 4708 5910 5847 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35612 m0 *1 831.6,559.44
X$35612 9264 9263 5417 5486 5440 4709 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35614 m0 *1 733.04,589.68
X$35614 9264 9263 5913 5707 5700 4709 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35617 m0 *1 819.84,529.2
X$35617 9264 9263 5073 5091 5212 4709 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35629 m0 *1 735.84,630
X$35629 9264 9263 6342 4709 6414 6026 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35632 m0 *1 842.8,569.52
X$35632 9264 9263 5487 5441 5444 4710 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35634 r0 *1 693.84,599.76
X$35634 9263 4710 5631 9264 6058 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $35636 m0 *1 837.76,529.2
X$35636 9264 9263 5008 5074 5075 4710 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35651 r0 *1 724.64,589.68
X$35651 9263 5910 4711 9264 5912 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $35653 r0 *1 719.6,589.68
X$35653 9264 9263 4711 5998 5914 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $35655 r0 *1 838.88,529.2
X$35655 9264 9263 4925 5131 5075 4711 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35666 r0 *1 843.92,559.44
X$35666 9264 9263 5418 5486 5444 4711 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35669 r0 *1 851.2,549.36
X$35669 9264 9263 5341 5415 5444 4712 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35671 m0 *1 744.8,640.08
X$35671 9264 4770 9263 6490 6441 6538 4712 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $35673 r0 *1 847.28,529.2
X$35673 9264 9263 5076 5156 5075 4712 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35685 r0 *1 763.84,599.76
X$35685 9264 6050 5839 5423 4767 5700 5705 4712 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35689 m0 *1 957.04,509.04
X$35689 4713 9263 9264 4865 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $35698 m0 *1 980.56,509.04
X$35698 4772 9263 9264 4715 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $35700 m0 *1 754.32,589.68
X$35700 9264 4927 9263 5552 5919 5949 4716 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $35708 m0 *1 786.8,579.6
X$35708 9264 9263 5703 4716 5704 5778 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35715 r0 *1 802.48,579.6
X$35715 9264 9263 5840 5348 5843 4716 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35722 m0 *1 217.84,509.04
X$35722 4718 9264 9263 4742 4741 4778 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35728 m0 *1 248.08,509.04
X$35728 9264 9263 4744 4720 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35736 m0 *1 257.6,599.76
X$35736 5937 9264 9263 6010 5957 4721 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35753 r0 *1 735.84,509.04
X$35753 9264 4861 4860 9263 4725 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $35763 m0 *1 686.56,509.04
X$35763 4794 9264 9263 4728 4880 4765 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35768 m0 *1 458.08,509.04
X$35768 9264 9263 4835 4729 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35776 r0 *1 482.72,509.04
X$35776 9264 4889 4801 4730 4890 4837 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35778 r0 *1 435.12,529.2
X$35778 9264 5050 4731 5237 5051 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $35786 r0 *1 578.48,498.96
X$35786 9264 9263 4804 4732 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35789 m0 *1 152.88,519.12
X$35789 4806 9264 9263 4935 5081 4733 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35792 m0 *1 155.12,509.04
X$35792 9263 4806 4734 9264 4775 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $35803 r0 *1 175.28,529.2
X$35803 9264 5106 5082 4736 5108 5107 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35806 m0 *1 183.68,529.2
X$35806 9264 5039 5107 4737 4939 5085 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35808 m0 *1 228.48,509.04
X$35808 9264 9263 4810 4738 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35811 m0 *1 268.24,509.04
X$35811 9264 9263 4980 4739 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35816 m0 *1 226.24,529.2
X$35816 9264 5088 4977 4740 5040 5018 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35823 m0 *1 316.4,509.04
X$35823 9264 9263 4818 4741 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35828 m0 *1 272.72,509.04
X$35828 9264 9263 4814 4742 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35835 m0 *1 292.32,509.04
X$35835 9264 9263 4743 4745 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35837 r0 *1 290.64,509.04
X$35837 4743 9264 9263 4816 4900 4879 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35843 r0 *1 311.36,509.04
X$35843 9264 4744 4883 4821 4820 4819 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35848 m0 *1 305.2,519.12
X$35848 9264 4744 4818 4822 4898 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $35854 m0 *1 322.56,529.2
X$35854 9264 5022 5021 4746 5046 5045 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35860 m0 *1 343.28,519.12
X$35860 4944 9264 9263 4898 4897 4747 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35864 m0 *1 368.48,509.04
X$35864 9264 9263 4946 4749 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35868 m0 *1 425.6,509.04
X$35868 4795 9264 9263 4832 4796 4750 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35871 m0 *1 478.8,509.04
X$35871 9264 4836 4751 4799 4802 4801 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35874 r0 *1 515.76,519.12
X$35874 9264 5036 4752 5035 4997 4996 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35877 m0 *1 518,509.04
X$35877 4753 9264 9263 4841 4888 4754 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35883 m0 *1 570.64,509.04
X$35883 9264 9263 4756 4757 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35885 m0 *1 571.2,519.12
X$35885 4756 9264 9263 4962 4963 4805 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35890 r0 *1 506.8,559.44
X$35890 9263 5401 5477 4758 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $35893 m0 *1 626.64,529.2
X$35893 5059 9264 9263 5003 4758 5004 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35896 m0 *1 626.64,509.04
X$35896 4800 9264 9263 4758 4969 4798 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35910 m0 *1 507.36,559.44
X$35910 9264 5121 5448 5585 5399 4758 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35912 r0 *1 619.36,519.12
X$35912 9264 4911 4882 5030 5003 4758 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35914 m0 *1 535.36,519.12
X$35914 9264 5121 4961 4959 4911 4758 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $35919 r0 *1 592.48,549.36
X$35919 9264 9263 5589 4759 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35921 m0 *1 580.72,519.12
X$35921 9264 9263 5056 4760 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35927 m0 *1 617.12,509.04
X$35927 4761 9264 9263 4850 4800 4762 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $35939 r0 *1 756,609.84
X$35939 9264 9263 6274 5705 6308 4767 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35941 m0 *1 814.8,559.44
X$35941 9264 9263 5414 5415 5440 4767 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35943 m0 *1 807.52,539.28
X$35943 9264 9263 5162 5215 5212 4767 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35957 r0 *1 861.84,559.44
X$35957 9264 9263 5504 5486 5488 4768 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35959 m0 *1 732.48,599.76
X$35959 9264 9263 5976 5707 5910 4768 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35965 m0 *1 868.56,549.36
X$35965 9264 9263 5078 5342 5219 4768 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35970 r0 *1 735.28,599.76
X$35970 9264 9263 6090 4768 5696 6026 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35972 r0 *1 926.8,841.68
X$35972 9264 8261 4769 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $35974 r0 *1 690.48,922.32
X$35974 9264 9263 8843 7806 4769 8844 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35992 r0 *1 932.4,539.28
X$35992 9264 9263 5133 5294 4769 5134 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35995 r0 *1 753.2,922.32
X$35995 9264 9263 8845 8078 4769 8846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35999 m0 *1 925.68,640.08
X$35999 9264 9263 6567 6495 4769 6505 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36001 m0 *1 706.72,932.4
X$36001 9264 9263 8887 8031 4769 8877 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36003 m0 *1 878.08,539.28
X$36003 9264 9263 5149 5220 5219 4770 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36005 m0 *1 873.6,569.52
X$36005 9264 9263 5568 5415 5488 4770 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36022 m0 *1 762.72,640.08
X$36022 9264 9263 6573 4770 5921 6249 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36025 r0 *1 904.96,559.44
X$36025 9264 9263 5500 5441 5349 4771 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36027 r0 *1 924,539.28
X$36027 9264 9263 5225 5230 5067 4771 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36039 r0 *1 692.16,619.92
X$36039 9264 4771 6347 9263 6346 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $36042 m0 *1 681.52,609.84
X$36042 9264 6085 6190 6057 6058 6087 4771 9263
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $36045 m0 *1 971.04,539.28
X$36045 9264 9263 5139 5128 5138 4772 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36053 m0 *1 980.56,519.12
X$36053 4929 9263 9264 4773 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $36061 m0 *1 164.08,519.12
X$36061 9264 4777 4937 4776 4894 4893 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36070 m0 *1 210,519.12
X$36070 4808 9264 9263 4778 5603 4939 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36083 m0 *1 313.04,509.04
X$36083 9264 9263 4782 4781 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36091 r0 *1 301.84,509.04
X$36091 4819 9264 9263 4897 4817 4782 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36093 m0 *1 358.96,509.04
X$36093 9264 9263 4788 4783 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36105 m0 *1 332.64,519.12
X$36105 4901 9264 9263 4821 4900 4785 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36114 m0 *1 316.96,519.12
X$36114 4787 9264 9263 5042 4816 4820 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36119 r0 *1 365.68,509.04
X$36119 9264 4825 4788 4828 4823 4827 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36131 m0 *1 400.96,529.2
X$36131 9264 5116 4791 5028 4990 5049 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36137 r0 *1 390.32,509.04
X$36137 9264 9263 4829 4792 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36145 r0 *1 441.28,509.04
X$36145 4891 9264 4795 9263 5051 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $36174 m0 *1 497.84,509.04
X$36174 9264 9263 4803 4802 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36193 m0 *1 197.12,519.12
X$36193 9264 9263 5109 4807 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36197 r0 *1 202.16,509.04
X$36197 9264 4895 4872 4873 4874 4808 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36200 r0 *1 205.52,539.28
X$36200 9264 5143 5186 4809 5259 5258 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36203 r0 *1 232.4,579.6
X$36203 4810 9264 9263 5856 5888 5258 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36205 m0 *1 225.68,609.84
X$36205 9264 6202 6111 4811 6070 6006 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36212 r0 *1 248.64,529.2
X$36212 9264 5144 5088 4813 5110 5041 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36216 r0 *1 273.84,519.12
X$36216 4814 9264 9263 5042 4898 5020 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36218 r0 *1 283.92,509.04
X$36218 9264 9263 4815 4899 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36220 r0 *1 274.4,509.04
X$36220 4878 9264 9263 4940 4879 4815 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36223 m0 *1 243.6,579.6
X$36223 9264 9263 5754 4816 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $36225 r0 *1 152.32,539.28
X$36225 5227 9264 9263 4816 4817 5598 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36227 m0 *1 246.96,529.2
X$36227 4978 9264 9263 4897 4816 5146 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36237 r0 *1 139.44,569.52
X$36237 9264 4816 5721 5722 5723 5597 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36242 r0 *1 192.08,589.68
X$36242 5885 9264 9263 4817 6200 5930 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36245 m0 *1 250.32,589.68
X$36245 9264 9263 5758 4817 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $36248 r0 *1 246.96,519.12
X$36248 4875 9264 9263 4817 4978 4979 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36258 m0 *1 151.76,589.68
X$36258 9264 5807 5881 4817 4900 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $36273 m0 *1 342.72,529.2
X$36273 5159 9264 9263 4822 5042 5090 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36282 m0 *1 339.36,529.2
X$36282 9264 9263 5046 4822 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $36285 r0 *1 283.36,529.2
X$36285 9264 4822 5111 5043 4898 5112 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36288 m0 *1 364.56,519.12
X$36288 4903 9264 9263 4825 4823 4826 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36291 r0 *1 327.6,519.12
X$36291 9264 9263 4823 5022 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36306 r0 *1 472.08,579.6
X$36306 9263 5824 5827 9264 4823 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $36309 m0 *1 425.04,589.68
X$36309 9263 5899 4823 9264 5900 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $36316 m0 *1 366.24,529.2
X$36316 5047 9264 9263 4987 4825 5048 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36322 r0 *1 374.08,519.12
X$36322 9264 4987 4946 4829 4825 4988 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36324 r0 *1 450.24,569.52
X$36324 9263 5468 5689 9264 4825 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $36328 r0 *1 373.52,579.6
X$36328 9264 9263 5760 4827 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36335 m0 *1 362.88,579.6
X$36335 9264 4988 5821 5759 4827 5681 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36343 r0 *1 410.48,609.84
X$36343 9264 4830 6140 6265 6264 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $36348 m0 *1 484.96,539.28
X$36348 5303 9264 9263 5197 4831 5117 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36350 r0 *1 424.48,529.2
X$36350 9264 9263 4992 4831 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36356 r0 *1 427.28,509.04
X$36356 9264 9263 4905 4832 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36358 r0 *1 425.04,519.12
X$36358 9264 4993 4905 4951 4833 4994 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36364 r0 *1 441.84,519.12
X$36364 9263 4834 4951 9264 4952 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $36369 r0 *1 480.48,519.12
X$36369 9264 5168 4836 4909 4958 4908 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36373 r0 *1 551.04,509.04
X$36373 9264 9263 4884 4837 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36376 m0 *1 492.8,589.68
X$36376 9264 4838 5826 5870 5828 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $36379 m0 *1 511.28,519.12
X$36379 9264 9263 4839 4956 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36384 r0 *1 485.52,539.28
X$36384 5450 9264 9263 4840 5121 5197 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36386 m0 *1 448.56,559.44
X$36386 5445 9264 9263 4840 5511 5476 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36392 r0 *1 533.12,539.28
X$36392 9264 9263 5272 4840 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36400 m0 *1 518.56,519.12
X$36400 5036 9264 9263 5037 4959 4841 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36403 m0 *1 553.28,630
X$36403 9264 6299 4842 6302 6340 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $36406 m0 *1 577.36,589.68
X$36406 9264 5876 5768 6000 5905 4843 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $36411 m0 *1 586.32,529.2
X$36411 5000 9264 9263 5105 5033 4844 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36416 r0 *1 597.52,509.04
X$36416 9264 9263 4914 4846 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36419 m0 *1 600.32,519.12
X$36419 4914 9264 9263 4965 4966 4847 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36422 m0 *1 614.32,549.36
X$36422 9264 9263 5377 4848 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36424 m0 *1 616,519.12
X$36424 9264 9263 5250 4849 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36430 r0 *1 609.28,519.12
X$36430 4966 9264 9263 5031 5004 4850 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36435 m0 *1 630,519.12
X$36435 4968 9264 9263 5203 4970 4852 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36438 r0 *1 645.68,519.12
X$36438 4853 9264 9263 5029 5062 4854 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36443 m0 *1 655.2,529.2
X$36443 4855 9264 9263 5176 5101 5063 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36447 r0 *1 685.44,519.12
X$36447 9264 9263 5065 4856 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36455 r0 *1 670.32,861.84
X$36455 9264 4858 8529 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $36458 m0 *1 644,861.84
X$36458 9264 4858 6862 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $36461 r0 *1 712.88,579.6
X$36461 9264 4858 5704 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $36464 m0 *1 655.76,630
X$36464 9264 9263 6371 6372 4858 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $36485 r0 *1 654.08,619.92
X$36485 9264 5842 4858 9263 6304 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $36487 m0 *1 642.32,640.08
X$36487 9264 9263 6541 6488 4858 5908 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36489 m0 *1 672.56,619.92
X$36489 9264 9263 6279 5643 4858 5023 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36509 m0 *1 685.44,619.92
X$36509 9264 9263 4862 6225 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36511 r0 *1 675.92,589.68
X$36511 9264 9263 5909 5023 5129 4862 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36513 r0 *1 661.92,609.84
X$36513 9264 6223 9263 5407 6278 6091 4862 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $36524 m0 *1 754.88,609.84
X$36524 9263 5977 9264 6091 6273 4862 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $36528 r0 *1 725.76,569.52
X$36528 9264 9263 5632 5408 5440 4863 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36530 m0 *1 728.56,549.36
X$36530 9264 9263 5302 5023 5211 4863 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36540 r0 *1 742,579.6
X$36540 9264 5916 5797 4924 4863 5696 5643 5128 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $36543 r0 *1 727.44,579.6
X$36543 9264 9263 5837 4863 5974 5367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36554 m0 *1 822.08,589.68
X$36554 9264 9263 5708 5940 5841 4867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36556 r0 *1 869.68,549.36
X$36556 9264 9263 5342 5419 5344 4867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36558 m0 *1 897.12,549.36
X$36558 9264 9263 5222 5346 5224 4867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36560 m0 *1 841.12,549.36
X$36560 9264 9263 5131 5339 5233 4867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36562 r0 *1 957.6,509.04
X$36562 9264 9263 4934 4867 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $36564 r0 *1 828.8,539.28
X$36564 9264 9263 5091 5287 5285 4867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36566 r0 *1 908.88,599.76
X$36566 9264 9263 5980 6043 5714 4867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36585 m0 *1 844.48,619.92
X$36585 9264 9263 6262 6260 6094 4867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36587 r0 *1 907.76,619.92
X$36587 9264 9263 6314 6324 6163 4867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36592 r0 *1 980.56,519.12
X$36592 5011 9263 9264 4869 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $36598 m0 *1 203.28,519.12
X$36598 9264 9263 5186 4871 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36615 r0 *1 252.56,509.04
X$36615 9264 9263 4875 4876 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36637 r0 *1 689.36,509.04
X$36637 4880 9264 9263 4881 4967 4920 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36655 m0 *1 365.12,640.08
X$36655 4885 9264 5896 9263 6515 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $36671 r0 *1 502.32,519.12
X$36671 9264 9263 5035 4889 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36673 m0 *1 462,519.12
X$36673 9264 9263 4906 4890 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36683 r0 *1 156.24,519.12
X$36683 9264 5013 4935 4936 4974 4892 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36686 r0 *1 227.92,549.36
X$36686 9263 5311 5430 9264 4892 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $36689 r0 *1 173.04,519.12
X$36689 4893 9264 9263 4975 5015 5038 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36691 m0 *1 162.96,529.2
X$36691 9264 5082 5013 4894 5083 5038 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36694 m0 *1 206.64,519.12
X$36694 9264 9263 4938 4895 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36697 m0 *1 241.92,539.28
X$36697 9264 9263 5431 4896 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36705 m0 *1 137.76,539.28
X$36705 5184 9264 9263 4897 5253 5185 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36707 m0 *1 262.08,519.12
X$36707 4940 9264 9263 5042 4897 9283 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36719 r0 *1 129.36,549.36
X$36719 9264 4897 5460 5427 5253 5307 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36722 r0 *1 234.64,549.36
X$36722 9264 9263 5466 4897 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $36725 m0 *1 243.04,559.44
X$36725 9264 5042 5502 5385 4897 5433 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36744 m0 *1 453.04,589.68
X$36744 9263 5695 5822 4898 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $36747 r0 *1 421.68,589.68
X$36747 9264 5754 4898 5901 5900 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $36749 m0 *1 259.28,549.36
X$36749 9264 5042 5298 5299 4898 5313 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36757 r0 *1 183.12,589.68
X$36757 9264 9263 5812 4900 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $36760 m0 *1 213.92,539.28
X$36760 5141 9264 9263 4900 5227 5231 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36763 r0 *1 152.32,609.84
X$36763 6130 9264 9263 4900 6282 6167 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36766 m0 *1 176.96,599.76
X$36766 5984 9264 9263 4900 6004 5983 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $36779 r0 *1 152.88,599.76
X$36779 9263 6107 4900 9264 6041 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $36781 r0 *1 371.84,539.28
X$36781 9264 4901 4986 5268 5267 5266 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36790 m0 *1 361.2,519.12
X$36790 9264 9263 4903 4902 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36792 r0 *1 352.24,519.12
X$36792 9264 4902 5026 4985 4984 4945 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36802 r0 *1 370.72,519.12
X$36802 9264 9263 5026 4904 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36807 r0 *1 459.76,529.2
X$36807 9264 5528 4906 5053 5123 5096 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36810 m0 *1 462.56,529.2
X$36810 9264 5165 4907 5095 4995 5052 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36812 r0 *1 463.68,519.12
X$36812 9264 5622 4953 5032 4909 4907 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36815 m0 *1 495.04,529.2
X$36815 9264 9263 5169 4908 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36825 m0 *1 494.48,519.12
X$36825 9264 4955 4954 4958 4956 4910 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $36827 m0 *1 510.72,529.2
X$36827 9264 9263 5097 4910 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36830 r0 *1 581.28,519.12
X$36830 9264 9263 5057 4911 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36841 m0 *1 571.2,609.84
X$36841 9264 6122 4913 6081 6124 5123 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $36856 r0 *1 692.16,519.12
X$36856 9264 9263 4971 4919 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36868 r0 *1 667.52,892.08
X$36868 9264 4922 8757 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $36870 r0 *1 590.24,831.6
X$36870 9264 4922 7319 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $36872 r0 *1 883.68,579.6
X$36872 9264 4922 5713 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $36875 r0 *1 603.12,670.32
X$36875 6435 9263 4922 6436 9264 6779 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $36878 m0 *1 608.72,680.4
X$36878 9263 4922 6370 9264 6878 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $36880 r0 *1 773.36,559.44
X$36880 9263 5407 4922 9264 5508 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $36903 r0 *1 767.2,559.44
X$36903 5549 9263 5577 4922 9264 5575 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $36906 m0 *1 763.28,529.2
X$36906 9264 9263 5094 5023 4922 4924 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36908 m0 *1 590.8,680.4
X$36908 9264 9263 6876 5908 4922 6827 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36915 m0 *1 770.56,569.52
X$36915 9264 9263 5633 5508 5712 4924 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36928 r0 *1 705.6,630
X$36928 9263 6489 9264 4924 6439 6438 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $36932 r0 *1 862.4,680.4
X$36932 9264 9263 6902 6892 5488 4926 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36934 r0 *1 869.68,670.32
X$36934 9264 9263 6790 6838 5219 4926 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36937 m0 *1 691.04,680.4
X$36937 9264 9263 6854 6882 5548 4926 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36949 m0 *1 705.6,700.56
X$36949 9264 7090 9263 5444 7091 5488 7089 4926
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $36955 r0 *1 870.8,559.44
X$36955 9264 9263 5503 5348 5488 4927 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36959 m0 *1 869.68,539.28
X$36959 9264 9263 5151 5218 5219 4927 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36975 r0 *1 764.4,589.68
X$36975 9264 9263 5947 4927 5921 5920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36980 r0 *1 899.92,559.44
X$36980 9264 9263 4928 5646 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $36982 m0 *1 897.12,539.28
X$36982 9264 9263 5148 5222 5067 4928 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36989 m0 *1 900.48,559.44
X$36989 9264 9263 5422 5486 5349 4928 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36993 r0 *1 974.4,539.28
X$36993 9264 9263 5080 5291 5138 4929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37001 r0 *1 965.44,519.12
X$37001 5014 9263 9264 4930 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $37003 r0 *1 957.6,519.12
X$37003 9264 9263 4931 5336 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $37006 r0 *1 945.28,509.04
X$37006 9264 9263 4932 5009 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $37011 r0 *1 960.96,529.2
X$37011 9264 9263 4933 5132 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $37029 r0 *1 210.56,579.6
X$37029 4938 9264 9263 5933 5932 5463 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37036 r0 *1 219.52,519.12
X$37036 9264 9263 4940 5016 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37048 m0 *1 263.2,539.28
X$37048 9264 5150 5144 4942 5191 5190 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37057 m0 *1 352.8,519.12
X$37057 9264 9263 4944 4945 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37071 r0 *1 395.92,519.12
X$37071 9264 5027 4947 4950 5028 4981 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37081 m0 *1 404.88,519.12
X$37081 9263 4950 4949 9264 4989 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $37096 r0 *1 502.32,509.04
X$37096 9264 9263 4954 4957 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37101 r0 *1 493.92,529.2
X$37101 9264 9263 5117 4955 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37129 r0 *1 563.36,529.2
X$37129 9264 5180 4962 5102 5182 5055 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37131 m0 *1 573.44,539.28
X$37131 9264 5124 5105 4963 5247 5246 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37142 m0 *1 591.92,519.12
X$37142 9264 9263 5058 4965 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37149 m0 *1 700,529.2
X$37149 9264 9263 5069 4967 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37161 r0 *1 623.84,529.2
X$37161 9264 9263 5181 4969 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37164 m0 *1 636.16,529.2
X$37164 9264 5030 5029 4970 5061 5060 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37172 m0 *1 683.2,529.2
X$37172 9264 5098 4971 5069 5068 5005 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37183 m0 *1 158.48,549.36
X$37183 9264 5254 5293 4974 5309 5353 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37189 m0 *1 168.56,539.28
X$37189 4975 9264 9263 5228 5140 5229 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37191 r0 *1 192.08,519.12
X$37191 5015 9264 9263 5016 4976 5086 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37194 m0 *1 286.72,529.2
X$37194 9264 9263 5020 4976 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37203 m0 *1 256.48,529.2
X$37203 9264 9263 4979 5041 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37208 m0 *1 273.84,569.52
X$37208 5357 9264 9263 5606 5605 4980 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37211 m0 *1 375.76,529.2
X$37211 9264 9263 5048 4981 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37218 m0 *1 296.8,529.2
X$37218 9264 9263 5043 4982 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37225 m0 *1 361.76,529.2
X$37225 9264 9263 5090 4984 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37230 m0 *1 373.52,609.84
X$37230 9264 6180 4985 6359 5114 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $37235 m0 *1 388.64,529.2
X$37235 9264 9263 4990 4987 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37237 r0 *1 364.56,529.2
X$37237 5160 9264 9263 5115 4987 5092 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37245 m0 *1 376.88,569.52
X$37245 9264 9263 5613 4988 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37255 r0 *1 400.96,589.68
X$37255 9264 5941 5794 6053 4989 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $37264 m0 *1 439.6,609.84
X$37264 9264 9263 5822 4990 5971 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $37267 r0 *1 416.08,630
X$37267 9264 6425 4990 6467 6516 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $37269 r0 *1 421.68,519.12
X$37269 9264 9263 4991 4993 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37272 r0 *1 421.12,549.36
X$37272 9264 9263 5471 4992 5393 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $37278 m0 *1 458.08,559.44
X$37278 9264 9263 4994 5446 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37281 m0 *1 433.44,559.44
X$37281 9264 9263 5471 4994 5620 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $37288 r0 *1 469.84,589.68
X$37288 9264 9263 5997 4995 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37294 m0 *1 533.68,569.52
X$37294 9264 5690 4997 5118 5625 5624 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37301 r0 *1 584.64,519.12
X$37301 9264 9263 5000 5034 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37304 m0 *1 603.12,549.36
X$37304 9264 9263 5378 5001 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37309 r0 *1 607.04,549.36
X$37309 9264 9263 5536 5002 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37314 m0 *1 595.84,539.28
X$37314 9264 9263 5003 5125 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37326 r0 *1 501.76,559.44
X$37326 9263 5477 5400 9264 5003 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37328 r0 *1 502.88,549.36
X$37328 9264 5003 5454 5455 5399 5324 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37341 m0 *1 680.96,750.96
X$37341 9264 5006 7677 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $37343 m0 *1 609.28,640.08
X$37343 6435 9263 5006 6436 9264 6526 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $37346 m0 *1 754.32,559.44
X$37346 9263 5407 5006 9264 5484 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37348 r0 *1 598.64,740.88
X$37348 9264 5006 7450 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $37351 m0 *1 740.32,569.52
X$37351 5549 9263 5577 5006 9264 5551 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $37353 r0 *1 861.28,529.2
X$37353 9264 5006 5219 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $37368 r0 *1 744.24,539.28
X$37368 9264 9263 5280 5023 5006 5213 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37371 m0 *1 615.44,640.08
X$37371 9263 5006 6370 9264 6540 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37374 m0 *1 600.88,640.08
X$37374 9264 9263 6486 5908 5006 6487 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37391 m0 *1 813.68,589.68
X$37391 9264 9263 5861 5922 5841 5009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37393 m0 *1 888.72,549.36
X$37393 9264 9263 5221 5345 5224 5009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37395 r0 *1 878.08,549.36
X$37395 9264 9263 5220 5420 5344 5009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37397 m0 *1 862.4,630
X$37397 9264 9263 6401 6382 6094 5009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37399 m0 *1 852.32,539.28
X$37399 9264 9263 5156 5217 5233 5009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37401 r0 *1 812,539.28
X$37401 9264 9263 5215 5284 5285 5009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37417 r0 *1 899.36,569.52
X$37417 9264 9263 5732 5733 5714 5009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37420 m0 *1 901.6,640.08
X$37420 9264 9263 6553 6510 6163 5009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37422 m0 *1 905.52,549.36
X$37422 9264 9263 5356 5348 5349 5010 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37424 m0 *1 915.04,539.28
X$37424 9264 9263 5145 5223 5067 5010 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37434 m0 *1 766.64,609.84
X$37434 9264 5010 6091 9263 6116 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $37438 m0 *1 747.04,609.84
X$37438 9264 5010 6087 9263 6183 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $37444 r0 *1 950.88,529.2
X$37444 9264 9263 5084 5135 5138 5011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37452 m0 *1 980.56,539.28
X$37452 5077 9263 9264 5012 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $37458 r0 *1 619.36,650.16
X$37458 9264 9263 6631 6487 6699 5014 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37474 m0 *1 222.88,529.2
X$37474 9264 9263 5087 5017 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37479 m0 *1 219.52,529.2
X$37479 9264 9263 5141 5018 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37501 r0 *1 728,640.08
X$37501 9264 9263 5023 6594 6045 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $37517 m0 *1 762.72,549.36
X$37517 9264 9263 5333 5023 5093 5367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37523 r0 *1 705.04,539.28
X$37523 9264 9263 5209 5023 5130 5128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37532 m0 *1 327.6,549.36
X$37532 9264 5316 5024 5300 5318 5317 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37540 m0 *1 400.96,539.28
X$37540 9264 9263 5194 5027 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37558 m0 *1 606.48,529.2
X$37558 9264 9263 5103 5031 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37566 m0 *1 602,529.2
X$37566 9264 9263 5104 5033 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37582 m0 *1 521.92,529.2
X$37582 9264 9263 5120 5037 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37588 m0 *1 186.48,539.28
X$37588 9264 9263 5257 5039 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37592 r0 *1 222.32,539.28
X$37592 9264 5296 5188 5040 5260 5189 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37596 r0 *1 276.08,559.44
X$37596 9263 5394 5468 5042 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $37600 r0 *1 248.64,549.36
X$37600 9264 9263 5042 5432 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37618 r0 *1 307.44,529.2
X$37618 5044 9264 9263 5155 5153 5154 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37620 m0 *1 335.44,579.6
X$37620 9264 9263 5681 5045 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37629 m0 *1 327.04,599.76
X$37629 9264 5045 5991 6049 5820 5890 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37631 m0 *1 336,589.68
X$37631 9264 5760 5894 5938 5045 5820 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37638 r0 *1 365.12,559.44
X$37638 9264 9263 5471 5046 5517 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $37641 r0 *1 342.16,529.2
X$37641 9264 9263 5047 5155 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37643 r0 *1 345.52,529.2
X$37643 5047 9264 5159 9263 5114 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $37651 r0 *1 406,569.52
X$37651 9264 9263 5616 5049 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37657 m0 *1 379.68,579.6
X$37657 9264 5049 5737 5794 5613 5760 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37664 r0 *1 476.56,529.2
X$37664 9264 9263 5053 5052 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37671 r0 *1 482.72,569.52
X$37671 9264 5583 5740 5054 5688 5741 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37675 r0 *1 566.72,579.6
X$37675 9264 5904 5055 5875 5832 5833 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37681 r0 *1 602.56,539.28
X$37681 9264 5057 5103 5276 5274 5199 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37692 r0 *1 529.76,619.92
X$37692 9263 9264 5530 5057 5830 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $37694 m0 *1 517.44,549.36
X$37694 9264 5057 5271 5371 5325 5274 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37696 m0 *1 563.92,619.92
X$37696 9264 5904 5057 6345 6150 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $37699 m0 *1 604.24,539.28
X$37699 9264 5057 5181 5251 5125 5199 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37701 r0 *1 581.84,539.28
X$37701 9264 5272 5245 5201 5057 5125 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37704 r0 *1 565.04,539.28
X$37704 9264 5275 5242 5244 5057 5199 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37708 r0 *1 589.68,529.2
X$37708 9264 5245 5058 5104 5127 5126 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37710 r0 *1 627.2,529.2
X$37710 9264 9263 5059 5127 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37716 m0 *1 645.68,559.44
X$37716 5060 9264 9263 5541 5515 5404 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37719 r0 *1 642.32,559.44
X$37719 5277 9264 9263 5540 5629 5061 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37722 r0 *1 651.84,529.2
X$37722 9264 9263 5177 5062 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37729 r0 *1 670.32,549.36
X$37729 5064 9264 9263 5457 5458 5206 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37733 r0 *1 675.36,529.2
X$37733 9264 5175 5098 5065 5173 5066 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37736 m0 *1 679.28,539.28
X$37736 9264 9263 5206 5066 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37741 m0 *1 916.16,821.52
X$37741 9264 9263 8265 8260 5067 7889 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37743 r0 *1 711.76,529.2
X$37743 9264 5129 5067 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $37776 m0 *1 675.36,720.72
X$37776 9264 9263 7301 7174 5067 7119 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37778 r0 *1 668.08,670.32
X$37778 9264 9263 6856 6806 5067 6718 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37780 m0 *1 921.2,730.8
X$37780 9264 9263 7366 7367 5067 7313 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37782 r0 *1 913.36,801.36
X$37782 9264 9263 8083 8084 5067 7821 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37784 m0 *1 913.92,680.4
X$37784 9264 9263 6845 6895 5067 6844 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37787 m0 *1 693.28,539.28
X$37787 9264 9263 5207 5068 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37796 m0 *1 757.68,529.2
X$37796 9264 5071 5094 9263 5072 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $37804 m0 *1 833.84,539.28
X$37804 9264 9263 5074 5216 5233 5132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37807 m0 *1 743.12,539.28
X$37807 9264 5130 5075 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $37809 m0 *1 854.56,700.56
X$37809 9264 9263 7138 7080 5075 7026 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37827 r0 *1 851.76,650.16
X$37827 9264 9263 6600 6657 5075 6599 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37831 m0 *1 748.16,720.72
X$37831 9264 9263 7303 7266 5075 7090 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37833 r0 *1 862.4,781.2
X$37833 9264 9263 7929 7924 5075 7812 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37835 m0 *1 847.28,781.2
X$37835 9264 9263 7868 7869 5075 7680 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37837 r0 *1 860.72,740.88
X$37837 9264 9263 7530 7465 5075 7517 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37841 m0 *1 564.48,670.32
X$37841 9264 9263 6675 6774 6699 5077 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37862 m0 *1 133.28,549.36
X$37862 9264 5293 5593 5081 5308 5292 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37873 r0 *1 165.76,539.28
X$37873 9264 5229 5254 5083 5295 5255 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $37880 r0 *1 192.08,529.2
X$37880 5085 9264 9263 5086 5381 5140 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37888 r0 *1 213.92,529.2
X$37888 5087 9264 9263 5142 5187 5143 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37895 r0 *1 277.76,539.28
X$37895 9264 9263 5089 5262 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37908 r0 *1 323.68,529.2
X$37908 9264 9263 5092 5153 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37915 m0 *1 696.64,882
X$37915 9264 5093 8562 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $37917 r0 *1 616.56,630
X$37917 6435 9263 5093 6436 9264 6366 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $37919 m0 *1 608.72,740.88
X$37919 9264 5093 6931 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $37922 m0 *1 780.08,569.52
X$37922 9263 5407 5093 9264 5634 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37924 m0 *1 756,569.52
X$37924 5549 9263 5577 5093 9264 5739 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $37926 r0 *1 883.68,619.92
X$37926 9264 5093 6031 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $37928 r0 *1 622.72,630
X$37928 9263 5093 6370 9264 6368 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37947 r0 *1 614.32,619.92
X$37947 9264 9263 6217 5908 5093 6301 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37963 r0 *1 508.48,529.2
X$37963 5170 9264 9263 5119 5172 5097 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37970 m0 *1 676.48,529.2
X$37970 9264 9263 5099 5175 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37980 r0 *1 660.8,549.36
X$37980 5101 9264 9263 5514 5459 5457 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $37998 m0 *1 179.2,539.28
X$37998 9264 9263 5380 5106 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38005 m0 *1 187.6,549.36
X$38005 9264 9263 5310 5108 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38008 m0 *1 183.68,559.44
X$38008 9264 5498 5380 5109 5464 5463 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38012 r0 *1 246.4,539.28
X$38012 9264 5297 5296 5110 5261 5147 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38014 r0 *1 280,529.2
X$38014 9264 9263 5111 5150 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38018 m0 *1 292.32,589.68
X$38018 9264 9263 5820 5112 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38020 m0 *1 290.64,599.76
X$38020 9264 5112 5960 5989 5313 5433 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38024 m0 *1 310.8,549.36
X$38024 9264 5607 5436 5317 5359 5113 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38031 m0 *1 372.4,539.28
X$38031 5234 9264 9263 5270 5115 5193 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $38033 r0 *1 404.88,529.2
X$38033 9264 9263 5116 5115 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38041 r0 *1 403.2,539.28
X$38041 9264 5269 5194 5236 5270 5115 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38046 r0 *1 420.56,579.6
X$38046 9264 9263 5471 5116 5761 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $38059 m0 *1 500.08,539.28
X$38059 9264 5170 5169 5171 5198 5118 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38062 r0 *1 514.08,539.28
X$38062 9264 9263 5271 5119 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38065 m0 *1 521.92,539.28
X$38065 9264 5125 5120 5174 5200 5199 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38069 m0 *1 561.68,549.36
X$38069 9264 9263 5121 5275 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38084 r0 *1 557.2,559.44
X$38084 9263 5532 5400 9264 5121 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38087 m0 *1 561.12,539.28
X$38087 9264 9263 5122 5179 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38089 r0 *1 547.68,539.28
X$38089 9264 5200 5241 5122 5274 5199 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38096 m0 *1 570.08,539.28
X$38096 9264 9263 5242 5124 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38106 r0 *1 597.52,559.44
X$38106 9264 5402 5126 5537 5274 5199 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38110 m0 *1 641.76,539.28
X$38110 9264 5127 5178 5177 5205 5204 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38117 m0 *1 711.2,579.6
X$38117 9263 5697 5128 9264 5800 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38128 m0 *1 707.28,559.44
X$38128 9264 9263 5483 5512 5444 5128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38131 m0 *1 647.92,750.96
X$38131 9264 5129 7610 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $38137 m0 *1 640.64,740.88
X$38137 9264 5129 7389 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $38140 r0 *1 649.6,630
X$38140 9263 6525 5129 9264 6223 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38153 m0 *1 650.72,619.92
X$38153 9264 9263 6220 6221 5129 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $38156 m0 *1 658.56,861.84
X$38156 9264 5130 8511 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $38159 m0 *1 614.88,730.8
X$38159 9264 5130 7151 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $38164 m0 *1 702.24,559.44
X$38164 9263 5407 5130 9264 5512 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38166 r0 *1 709.52,559.44
X$38166 5549 9263 5577 5130 9264 5550 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $38168 m0 *1 634.48,680.4
X$38168 9263 5130 6370 9264 6830 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38171 m0 *1 628.32,680.4
X$38171 6435 9263 5130 6436 9264 6879 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $38174 r0 *1 619.92,680.4
X$38174 9264 9263 6933 5908 5130 6829 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38190 r0 *1 914.48,539.28
X$38190 9264 9263 5230 5288 5224 5132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38192 r0 *1 844.48,599.76
X$38192 9264 9263 5923 6027 5841 5132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38194 r0 *1 871.92,609.84
X$38194 9264 9263 6029 6246 6094 5132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38197 m0 *1 910.56,589.68
X$38197 9264 9263 5935 5852 5714 5132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38199 m0 *1 871.92,589.68
X$38199 9264 9263 5846 5779 5344 5132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38201 m0 *1 919.52,609.84
X$38201 9264 9263 6030 6174 6163 5132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38203 r0 *1 820.4,539.28
X$38203 9264 9263 5235 5286 5285 5132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38232 m0 *1 980.56,549.36
X$38232 5134 9263 9264 5137 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $38237 m0 *1 919.52,599.76
X$38237 9264 9263 5985 5980 5713 5135 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38240 m0 *1 731.92,619.92
X$38240 9264 9263 6231 6155 5135 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $38242 r0 *1 903.84,589.68
X$38242 9264 9263 5986 5486 5712 5135 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38251 r0 *1 726.88,630
X$38251 9263 6440 9264 5135 6524 6374 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $38255 m0 *1 980.56,559.44
X$38255 5491 9263 9264 5136 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $38259 r0 *1 941.36,841.68
X$38259 9264 8261 5138 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $38263 r0 *1 967.68,821.52
X$38263 9264 9263 8306 8272 5138 8303 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38265 r0 *1 970.48,650.16
X$38265 9264 9263 6555 6603 5138 6386 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38283 r0 *1 950.88,559.44
X$38283 9264 9263 5499 5555 5138 5492 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38285 r0 *1 957.6,549.36
X$38285 9264 9263 5289 5423 5138 5290 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38288 r0 *1 904.4,851.76
X$38288 9264 9263 8458 7517 5138 8459 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38291 m0 *1 969.36,700.56
X$38291 9264 9263 7129 7128 5138 6901 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38293 m0 *1 960.96,710.64
X$38293 9264 9263 7194 7026 5138 7188 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38305 m0 *1 223.44,539.28
X$38305 9264 9263 5188 5142 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38320 m0 *1 252.56,539.28
X$38320 9264 9263 5146 5147 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38345 m0 *1 309.68,539.28
X$38345 9264 9263 5154 5152 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38349 m0 *1 292.88,549.36
X$38349 9264 5314 5263 5265 5315 5152 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38367 r0 *1 378.56,529.2
X$38367 9264 9263 5193 5157 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38374 r0 *1 355.04,529.2
X$38374 9264 9263 5160 5158 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38397 m0 *1 444.08,549.36
X$38397 9264 5164 5323 5395 5443 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $38402 m0 *1 469.84,539.28
X$38402 9264 9263 5171 5165 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38413 r0 *1 724.64,650.16
X$38413 9263 5407 5167 9264 6637 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38415 m0 *1 721.84,670.32
X$38415 9264 5167 6782 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $38420 m0 *1 481.6,539.28
X$38420 9264 9263 5239 5168 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38437 r0 *1 523.04,529.2
X$38437 9264 9263 5174 5172 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38440 m0 *1 682.64,539.28
X$38440 9264 9263 5243 5173 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38451 m0 *1 658.56,539.28
X$38451 9264 9263 5178 5176 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38466 r0 *1 558.88,529.2
X$38466 9264 9263 5241 5180 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38475 r0 *1 580.72,529.2
X$38475 9264 9263 5244 5182 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38480 r0 *1 16.8,539.28
X$38480 5226 9263 9264 5183 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $38483 r0 *1 130.48,539.28
X$38483 5292 9264 9263 5252 5184 9303 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $38486 r0 *1 140,539.28
X$38486 5252 9264 9263 5307 5185 9302 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $38492 r0 *1 217.28,549.36
X$38492 9264 9263 5384 5187 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38499 m0 *1 228.48,539.28
X$38499 9264 9263 5231 5189 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38501 m0 *1 259.84,539.28
X$38501 9264 9263 5232 5190 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38507 r0 *1 274.4,539.28
X$38507 9264 9263 5299 5191 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38509 r0 *1 310.8,549.36
X$38509 9264 9263 5436 5192 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38513 m0 *1 407.68,539.28
X$38513 5236 9264 5193 9263 5195 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $38521 m0 *1 402.08,599.76
X$38521 9264 6011 5965 6054 5195 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $38526 r0 *1 458.64,549.36
X$38526 9264 5395 5196 5447 5397 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $38533 r0 *1 511.84,579.6
X$38533 9264 5946 5198 5796 5871 5762 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38544 r0 *1 517.44,559.44
X$38544 9264 5531 5582 5586 5402 5199 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38546 m0 *1 553.84,569.52
X$38546 9263 9264 5467 5199 5767 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $38557 r0 *1 519.68,549.36
X$38557 9264 9263 5200 5399 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38565 m0 *1 524.16,559.44
X$38565 9264 9263 5516 5200 5530 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $38567 r0 *1 598.64,539.28
X$38567 9264 9263 5201 5247 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38570 r0 *1 621.6,539.28
X$38570 5250 9264 9263 5304 5202 5249 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $38573 r0 *1 631.12,539.28
X$38573 9264 5248 5203 5202 5278 5277 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38579 r0 *1 649.04,539.28
X$38579 9264 9263 5376 5204 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38582 r0 *1 653.52,549.36
X$38582 9264 9263 5404 5205 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38589 m0 *1 683.2,549.36
X$38589 5207 9264 9263 5375 5279 5406 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $38591 m0 *1 703.92,539.28
X$38591 9264 5208 5209 9263 5210 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $38598 m0 *1 554.4,801.36
X$38598 9264 5211 6865 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $38601 m0 *1 654.08,831.6
X$38601 9264 5211 8370 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $38603 r0 *1 568.96,640.08
X$38603 6435 9263 5211 6436 9264 6432 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $38605 r0 *1 563.92,630
X$38605 9263 5211 6370 9264 6430 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38609 m0 *1 731.36,569.52
X$38609 5549 9263 5577 5211 9264 5656 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $38611 r0 *1 727.44,539.28
X$38611 9264 5211 5212 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $38615 r0 *1 715.68,549.36
X$38615 9263 5407 5211 9264 5408 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38635 m0 *1 751.52,670.32
X$38635 9264 9263 6722 6799 5212 6590 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38660 r0 *1 840.56,730.8
X$38660 9264 9263 7428 7352 5212 7353 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38662 m0 *1 831.6,700.56
X$38662 9264 9263 7008 7124 5212 6936 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38665 m0 *1 721.84,710.64
X$38665 9264 9263 7212 7121 5212 7176 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38668 r0 *1 832.16,821.52
X$38668 9264 9263 8313 8197 5212 7679 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38670 m0 *1 820.4,831.6
X$38670 9264 9263 8343 8302 5212 7862 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38674 m0 *1 725.76,579.6
X$38674 9264 9263 5799 5643 5697 5213 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38685 r0 *1 980.56,579.6
X$38685 9264 9263 5718 5213 5848 5719 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38687 r0 *1 758.8,559.44
X$38687 9264 9263 5510 5484 5488 5213 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38691 r0 *1 734.16,569.52
X$38691 9264 9263 5699 5213 5700 5367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38695 r0 *1 792.96,539.28
X$38695 9264 9263 5214 5283 5233 5336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38701 m0 *1 841.68,559.44
X$38701 9264 9263 5216 5487 5340 5489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38704 m0 *1 850.64,549.36
X$38704 9264 9263 5217 5341 5340 5337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38708 m0 *1 876.96,549.36
X$38708 9264 9263 5218 5343 5344 5336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38712 m0 *1 873.6,650.16
X$38712 9264 9263 6552 6601 5219 6495 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38731 r0 *1 869.68,579.6
X$38731 9264 9263 5857 5846 5219 5294 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38738 r0 *1 875.28,781.2
X$38738 9264 9263 7925 7761 5219 7923 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38741 r0 *1 885.36,730.8
X$38741 9264 9263 7370 7420 5219 7312 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38743 r0 *1 882.56,690.48
X$38743 9264 9263 6946 7010 5219 6886 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38745 m0 *1 880.88,761.04
X$38745 9264 9263 7588 7685 5219 7520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38753 m0 *1 915.6,549.36
X$38753 9264 9263 5223 5355 5224 5336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38756 m0 *1 912.8,811.44
X$38756 9264 9263 8084 8134 5224 7686 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38758 m0 *1 896.56,831.6
X$38758 9264 8344 5224 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $38763 m0 *1 887.04,861.84
X$38763 9264 9263 8502 8501 5224 8498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38765 m0 *1 912.8,730.8
X$38765 9264 9263 7367 7368 5224 7311 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38779 m0 *1 884.8,851.76
X$38779 9264 9263 8375 8417 5224 8457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38781 r0 *1 907.2,821.52
X$38781 9264 9263 8260 8307 5224 7820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38783 r0 *1 915.6,690.48
X$38783 9264 9263 6895 7016 5224 6896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38791 r0 *1 238.56,660.24
X$38791 9264 9263 6617 6703 6664 5226 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38795 m0 *1 150.08,549.36
X$38795 9264 9263 5227 5253 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38802 m0 *1 175.28,549.36
X$38802 9264 9263 5811 5228 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38822 r0 *1 239.12,549.36
X$38822 5430 9264 9263 5432 5466 5232 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $38824 r0 *1 762.16,831.6
X$38824 9264 8290 5233 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $38850 r0 *1 781.2,912.24
X$38850 9264 9263 8791 8806 5233 8594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38855 r0 *1 843.36,650.16
X$38855 9264 9263 6657 6643 5233 6383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38858 r0 *1 853.44,690.48
X$38858 9264 9263 7080 7009 5233 6896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38860 r0 *1 800.8,922.32
X$38860 9264 9263 8849 8793 5233 8454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38862 r0 *1 755.44,710.64
X$38862 9264 9263 7266 7180 5233 6837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38864 m0 *1 787.36,922.32
X$38864 9264 9263 8823 8792 5233 8496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38866 r0 *1 364.56,539.28
X$38866 9264 9263 5234 5361 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38881 m0 *1 459.76,549.36
X$38881 9263 5396 5237 9264 5397 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $38891 m0 *1 474.88,549.36
X$38891 9264 5449 5239 5370 5303 5369 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38896 m0 *1 558.88,589.68
X$38896 9264 5832 5240 5876 5833 5903 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38916 m0 *1 576.24,559.44
X$38916 9264 9263 5534 5246 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38927 m0 *1 623.28,539.28
X$38927 9264 9263 5251 5248 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38952 r0 *1 176.96,559.44
X$38952 9264 9263 5519 5255 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38954 r0 *1 196.56,539.28
X$38954 9264 9263 5256 5295 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38956 m0 *1 190.96,549.36
X$38956 5310 9264 9263 5429 5354 5256 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $38961 r0 *1 198.8,549.36
X$38961 5257 9264 9263 5383 5382 5354 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $38969 r0 *1 193.2,559.44
X$38969 5259 9264 9263 5565 5520 5498 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $38972 m0 *1 217.84,569.52
X$38972 9264 5648 5647 5260 5604 5599 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38976 r0 *1 257.04,549.36
X$38976 9264 9263 5385 5261 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38978 r0 *1 268.24,549.36
X$38978 9264 5434 5312 5358 5386 5262 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38989 m0 *1 364,559.44
X$38989 9264 5390 5437 5266 5473 5472 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $38993 m0 *1 385.84,549.36
X$38993 9264 9263 5365 5267 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38995 r0 *1 384.72,619.92
X$38995 9264 5268 6336 6337 6334 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $39001 m0 *1 406.56,549.36
X$39001 9264 9263 5392 5269 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39004 m0 *1 373.52,599.76
X$39004 5962 9264 9263 5899 5270 5963 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39010 m0 *1 448,599.76
X$39010 9263 5468 5996 9264 5270 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39020 m0 *1 529.2,559.44
X$39020 9264 9263 5516 5272 5401 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39023 r0 *1 544.32,539.28
X$39023 9264 9263 5373 5273 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39025 r0 *1 528.64,569.52
X$39025 9264 9263 5765 5274 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $39036 r0 *1 544.32,549.36
X$39036 9264 5325 5373 5328 5402 5274 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39039 m0 *1 575.68,569.52
X$39039 9264 5402 5534 5744 5274 5533 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39046 r0 *1 619.92,549.36
X$39046 9264 9263 5276 5403 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39050 r0 *1 632.8,559.44
X$39050 5479 9264 9263 5539 5538 5278 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39057 m0 *1 752.64,549.36
X$39057 9264 5368 5280 9263 5301 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39061 m0 *1 762.16,569.52
X$39061 9264 9263 5281 5575 5838 5633 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39064 m0 *1 789.04,549.36
X$39064 9264 9263 5282 5334 5285 5336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39070 r0 *1 798.56,549.36
X$39070 9264 9263 5283 5412 5340 5413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39073 r0 *1 813.68,549.36
X$39073 9264 9263 5284 5414 5335 5337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39076 m0 *1 763.28,831.6
X$39076 9264 8290 5285 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $39101 m0 *1 768.32,871.92
X$39101 9264 9263 8568 8567 5285 8498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39105 r0 *1 835.52,700.56
X$39105 9264 9263 7124 7140 5285 6896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39107 r0 *1 839.44,720.72
X$39107 9264 9263 7352 7309 5285 7311 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39110 r0 *1 765.52,871.92
X$39110 9264 9263 8558 8595 5285 8457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39112 r0 *1 830.48,811.44
X$39112 9264 9263 8197 8206 5285 7686 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39114 r0 *1 822.64,821.52
X$39114 9264 9263 8302 8257 5285 7820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39117 r0 *1 822.08,549.36
X$39117 9264 9263 5286 5416 5335 5489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39119 r0 *1 830.48,549.36
X$39119 9264 9263 5287 5417 5335 5338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39125 m0 *1 908.88,559.44
X$39125 9264 9263 5288 5500 5347 5489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39133 r0 *1 978.32,559.44
X$39133 5290 9263 9264 5350 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $39136 m0 *1 901.04,589.68
X$39136 9264 9263 5853 5441 5712 5291 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39138 m0 *1 918.96,589.68
X$39138 9264 9263 5924 5935 5713 5291 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39153 m0 *1 711.76,599.76
X$39153 9264 6024 5291 9263 6025 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39165 m0 *1 873.04,579.6
X$39165 9264 9263 5709 5441 5488 5294 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39182 m0 *1 694.96,599.76
X$39182 9264 9263 5999 5294 5868 5847 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39193 m0 *1 248.08,549.36
X$39193 9264 9263 5298 5297 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39208 m0 *1 722.4,549.36
X$39208 9264 5330 5302 9263 5332 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39220 m0 *1 621.04,559.44
X$39220 9264 5403 5304 5456 5480 5479 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39225 m0 *1 558.32,549.36
X$39225 9264 9263 5328 5305 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39228 m0 *1 21.84,559.44
X$39228 5496 9263 9264 5306 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $39232 r0 *1 142.8,559.44
X$39232 9264 9263 5562 5307 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39234 m0 *1 128.24,559.44
X$39234 9264 5428 5426 5308 5461 5427 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39237 m0 *1 160.16,559.44
X$39237 9264 5563 5428 5309 5462 5497 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39245 m0 *1 230.72,559.44
X$39245 5311 9264 9263 5465 5501 5497 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39249 r0 *1 287.28,589.68
X$39249 9264 9263 5890 5313 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $39251 m0 *1 273.84,630
X$39251 9264 5313 6397 6327 5433 6352 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39253 m0 *1 305.2,640.08
X$39253 9264 6423 5896 5313 6424 6480 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $39264 r0 *1 296.8,549.36
X$39264 9264 9263 5387 5314 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39266 r0 *1 304.64,549.36
X$39266 9264 9263 5435 5315 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39270 r0 *1 325.92,549.36
X$39270 9264 9263 5469 5316 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39276 r0 *1 338.8,549.36
X$39276 9264 5388 5318 5321 5389 5362 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39279 m0 *1 355.6,549.36
X$39279 9264 9263 5319 5320 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39290 r0 *1 383.04,549.36
X$39290 9264 9263 5438 5322 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39293 r0 *1 389.2,549.36
X$39293 9264 5439 5365 5366 5391 5322 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39297 m0 *1 449.68,609.84
X$39297 5323 9264 9263 6267 6117 6118 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39299 r0 *1 529.76,549.36
X$39299 9264 9263 5325 5324 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39309 r0 *1 535.36,559.44
X$39309 9264 9263 5532 5325 5467 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39313 r0 *1 540.96,549.36
X$39313 9264 9263 5478 5326 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39316 r0 *1 549.36,599.76
X$39316 9264 5902 5327 6021 6020 6080 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39321 r0 *1 685.44,549.36
X$39321 5329 9264 9263 5406 5405 5374 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39326 m0 *1 722.96,569.52
X$39326 9264 9263 5331 5632 5335 5656 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39331 r0 *1 762.72,549.36
X$39331 9264 5410 5333 9263 5453 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39334 r0 *1 790.16,549.36
X$39334 9264 9263 5334 5411 5335 5413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39339 m0 *1 565.6,740.88
X$39339 9264 7493 5335 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $39362 m0 *1 751.52,680.4
X$39362 9264 9263 6783 6784 5335 6588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39364 m0 *1 840,700.56
X$39364 9264 9263 7140 7125 5335 7011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39366 m0 *1 840.56,720.72
X$39366 9264 9263 7309 7310 5335 7245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39372 r0 *1 568.96,630
X$39372 9264 9263 6472 6431 5335 6432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39374 m0 *1 722.4,720.72
X$39374 9264 9263 7179 7302 5335 6893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39378 m0 *1 921.2,579.6
X$39378 9264 9263 5715 5787 5714 5336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39383 m0 *1 862.96,609.84
X$39383 9264 9263 6162 6112 6094 5336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39387 r0 *1 907.76,609.84
X$39387 9264 9263 6173 6175 6163 5336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39398 r0 *1 794.08,579.6
X$39398 9264 9263 5778 5863 5841 5336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39401 r0 *1 889.84,549.36
X$39401 9264 9263 5345 5421 5347 5337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39405 r0 *1 889.84,569.52
X$39405 9264 9263 5733 5710 5711 5337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39407 r0 *1 879.2,559.44
X$39407 9264 9263 5420 5568 5490 5337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39409 r0 *1 862.96,630
X$39409 9264 9263 6382 6400 6161 5337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39412 m0 *1 893.2,640.08
X$39412 9264 9263 6510 6511 6097 5337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39424 r0 *1 815.92,589.68
X$39424 9264 9263 5922 5942 5842 5337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39426 m0 *1 813.68,650.16
X$39426 6446 9263 6612 6597 9264 5337 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $39428 m0 *1 830.48,589.68
X$39428 9264 9263 5940 5844 5842 5338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39430 m0 *1 869.68,559.44
X$39430 9264 9263 5419 5504 5490 5338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39432 r0 *1 899.36,549.36
X$39432 9264 9263 5346 5422 5347 5338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39434 r0 *1 848.96,609.84
X$39434 9264 9263 6260 6259 6161 5338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39437 r0 *1 842.24,549.36
X$39437 9264 9263 5339 5418 5340 5338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39440 r0 *1 899.36,619.92
X$39440 9264 9263 6324 6247 6097 5338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39455 m0 *1 903.84,599.76
X$39455 9264 9263 6043 5986 5711 5338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39457 r0 *1 823.2,630
X$39457 6448 9263 6446 6449 9264 5338 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $39461 r0 *1 660.24,801.36
X$39461 9264 8064 5340 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $39463 r0 *1 860.16,750.96
X$39463 9264 9263 7587 7598 5340 7245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39467 m0 *1 758.24,710.64
X$39467 9264 9263 7180 7210 5340 6893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39488 m0 *1 855.68,710.64
X$39488 9264 9263 7009 7203 5340 7011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39491 m0 *1 847.28,660.24
X$39491 9264 9263 6643 6695 5340 6588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39498 m0 *1 860.72,801.36
X$39498 9264 9263 8016 8017 5340 7871 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39500 m0 *1 855.68,781.2
X$39500 9264 9263 7870 7829 5340 7684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39507 m0 *1 878.08,559.44
X$39507 9264 9263 5343 5503 5490 5413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39529 r0 *1 827.68,882
X$39529 9264 9263 8646 8599 5344 8454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39533 r0 *1 837.76,871.92
X$39533 9264 9263 8561 8600 5344 8496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39536 m0 *1 856.8,882
X$39536 9264 9263 8602 8606 5344 8594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39538 r0 *1 864.64,831.6
X$39538 9264 8344 5344 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $39541 m0 *1 873.6,660.24
X$39541 9264 9263 6601 6644 5344 6383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39543 m0 *1 869.68,680.4
X$39543 9264 9263 6838 6894 5344 6837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39546 m0 *1 880.88,700.56
X$39546 9264 9263 7010 7126 5344 6896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39554 r0 *1 389.76,640.08
X$39554 9264 6087 5347 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $39556 r0 *1 907.2,690.48
X$39556 9264 9263 7016 7017 5347 7011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39559 m0 *1 673.68,710.64
X$39559 9264 9263 7175 7213 5347 6893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39577 r0 *1 907.76,549.36
X$39577 9264 9263 5355 5356 5347 5413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39584 r0 *1 465.92,761.04
X$39584 9264 7670 5347 9263 7707 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39586 m0 *1 673.68,670.32
X$39586 9264 9263 6804 6805 5347 6588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39588 r0 *1 384.72,761.04
X$39588 9264 7668 5347 9263 7704 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39590 r0 *1 903.28,720.72
X$39590 9264 9263 7368 7358 5347 7245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39592 r0 *1 822.64,609.84
X$39592 9264 9263 6241 6242 5348 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $39606 m0 *1 899.36,579.6
X$39606 9264 9263 5788 5348 5712 5555 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39608 r0 *1 889.84,599.76
X$39608 9264 9263 6096 5348 5702 5920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39612 r0 *1 857.36,609.84
X$39612 9264 9263 6160 5348 6245 5636 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39624 m0 *1 892.64,821.52
X$39624 9264 9263 8269 7922 5349 7889 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39626 m0 *1 671.44,781.2
X$39626 9264 7841 5349 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $39628 r0 *1 679.28,710.64
X$39628 9264 9263 7213 6892 5349 7119 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39630 m0 *1 904.4,690.48
X$39630 9264 9263 7017 6947 5349 6844 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39649 r0 *1 675.36,660.24
X$39649 9264 9263 6805 6634 5349 6718 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39651 m0 *1 904.4,730.8
X$39651 9264 9263 7358 7356 5349 7313 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39654 m0 *1 904.4,811.44
X$39654 9264 9263 8199 7683 5349 7821 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39660 m0 *1 955.36,569.52
X$39660 5641 9263 9264 5351 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $39664 r0 *1 980.56,589.68
X$39664 5425 9263 9264 5352 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $39667 r0 *1 240.24,559.44
X$39667 9264 9263 5471 5353 5567 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39695 r0 *1 301.28,599.76
X$39695 9264 6047 5387 5359 6071 6048 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39699 m0 *1 361.2,549.36
X$39699 5360 9264 9263 5612 5361 5362 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39727 r0 *1 772.8,569.52
X$39727 9264 9263 5738 5634 5702 5367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39741 m0 *1 972.72,569.52
X$39741 9264 9263 5424 5367 5637 5425 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39749 r0 *1 482.72,549.36
X$39749 9264 5450 5369 5451 5452 5372 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39753 r0 *1 479.36,549.36
X$39753 9264 9263 5370 5398 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39758 m0 *1 505.68,549.36
X$39758 9264 9263 5371 5372 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39776 m0 *1 673.68,559.44
X$39776 5458 9264 9263 5482 5545 5375 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39781 m0 *1 655.2,559.44
X$39781 5376 9264 9263 5662 5481 5459 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39785 r0 *1 610.4,549.36
X$39785 5378 9264 9263 5692 5456 5377 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39793 r0 *1 7.84,559.44
X$39793 5518 9263 9264 5379 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $39799 m0 *1 190.96,609.84
X$39799 5381 9264 9263 6109 6256 6171 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39803 m0 *1 203.84,559.44
X$39803 9264 9263 5931 5382 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39806 r0 *1 203.28,589.68
X$39806 9264 9263 6172 5383 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39809 r0 *1 203.28,559.44
X$39809 9264 5647 5602 5384 5566 5521 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39816 r0 *1 270.48,579.6
X$39816 9264 9263 5937 5386 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39821 r0 *1 341.04,599.76
X$39821 9264 6015 5388 6052 6051 6073 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39823 m0 *1 317.52,609.84
X$39823 9264 6014 5607 5389 6138 6178 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39828 m0 *1 411.04,559.44
X$39828 5506 9264 9263 5442 5576 5390 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $39833 m0 *1 404.32,559.44
X$39833 9264 9263 5506 5391 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39839 r0 *1 418.88,559.44
X$39839 9264 5392 5507 5659 5526 5525 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39844 r0 *1 413.84,559.44
X$39844 9263 5477 5393 9264 5392 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39847 m0 *1 413.84,579.6
X$39847 9264 9263 5687 5617 5393 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39850 r0 *1 434,640.08
X$39850 9263 5393 5621 9264 6532 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $39853 r0 *1 398.72,569.52
X$39853 9263 5618 5393 9264 5614 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39864 m0 *1 620.48,761.04
X$39864 9263 7663 7726 5393 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $39866 r0 *1 669.2,771.12
X$39866 9263 7840 7750 5394 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $39868 r0 *1 258.72,559.44
X$39868 9263 5468 5394 9264 5501 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39873 m0 *1 523.6,569.52
X$39873 9264 9263 5516 5531 5394 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39875 m0 *1 525.28,589.68
X$39875 9263 5830 5394 9264 5765 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39878 m0 *1 534.8,640.08
X$39878 9264 5394 5689 6484 6537 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $39880 r0 *1 651.84,559.44
X$39880 9263 5542 5394 9264 5515 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39882 m0 *1 641.2,569.52
X$39882 9263 5628 5394 9264 5540 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39894 r0 *1 246.4,559.44
X$39894 9264 9263 5567 5522 5394 5467 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39901 m0 *1 481.6,569.52
X$39901 9264 5581 5663 5396 5664 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $39907 r0 *1 465.92,569.52
X$39907 9264 5660 5622 5943 5398 5740 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39923 m0 *1 420,589.68
X$39923 9264 9263 5471 5758 5400 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39927 r0 *1 666.96,569.52
X$39927 9263 5619 5400 9264 5544 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39930 m0 *1 669.2,569.52
X$39930 9263 5542 5400 9264 5588 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39932 m0 *1 714,680.4
X$39932 9264 5400 6908 6348 6910 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $39945 r0 *1 537.04,640.08
X$39945 9263 5467 5400 9264 6537 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $39947 r0 *1 453.6,579.6
X$39947 9263 9264 5401 5812 5824 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $39949 m0 *1 482.72,630
X$39949 9264 9263 5401 6363 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39953 m0 *1 674.24,569.52
X$39953 9263 5619 5401 9264 5546 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39955 m0 *1 684.88,630
X$39955 9264 5401 6225 6348 6417 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $39967 r0 *1 567.84,589.68
X$39967 9264 9263 5402 5904 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39979 r0 *1 540.4,559.44
X$39979 9264 5531 5478 5587 5402 5533 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $39982 m0 *1 530.88,589.68
X$39982 9263 9264 5695 5402 5830 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $39995 m0 *1 803.6,670.32
X$39995 9264 9263 6159 6903 5407 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $40005 m0 *1 661.92,630
X$40005 9264 6371 9263 5407 6416 6372 5643 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $40032 r0 *1 750.4,559.44
X$40032 9264 9263 5409 5551 5552 5510 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40041 m0 *1 907.76,579.6
X$40041 9264 9263 5787 5788 5711 5413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40044 m0 *1 853.44,609.84
X$40044 9264 9263 6112 6160 6161 5413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40050 m0 *1 892.64,609.84
X$40050 9264 9263 6175 6096 6097 5413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40053 m0 *1 799.68,589.68
X$40053 9264 9263 5863 5840 5842 5413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40062 m0 *1 824.88,609.84
X$40062 9263 5577 6113 9264 5413 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40071 r0 *1 813.68,650.16
X$40071 9264 9263 6241 6641 5415 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $40089 m0 *1 890.96,579.6
X$40089 9264 9263 5710 5415 5712 5423 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40091 r0 *1 824.32,589.68
X$40091 9264 9263 5942 5415 5843 5705 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40095 r0 *1 889.84,630
X$40095 9264 9263 6511 5415 5702 6249 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40097 m0 *1 870.8,630
X$40097 9264 9263 6400 5415 6245 6410 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40114 r0 *1 907.76,569.52
X$40114 9264 9263 5728 5732 5713 5423 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40125 m0 *1 758.24,619.92
X$40125 9264 6229 5423 9263 6234 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $40143 m0 *1 117.6,579.6
X$40143 9264 5426 5745 5747 5669 5746 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $40156 m0 *1 190.96,569.52
X$40156 5464 9264 9263 5645 5644 5429 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40165 m0 *1 253.68,569.52
X$40165 5649 9264 9263 5672 5789 5431 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40171 m0 *1 261.52,630
X$40171 9264 9263 6137 5433 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $40173 r0 *1 327.6,630
X$40173 9264 5433 6513 6462 6290 6356 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $40190 r0 *1 287.28,559.44
X$40190 9264 9263 5523 5434 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40195 m0 *1 283.36,569.52
X$40195 5435 9264 9263 5988 5987 5523 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40206 r0 *1 376.88,569.52
X$40206 9264 5737 5438 5474 5686 5685 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $40208 m0 *1 407.68,559.44
X$40208 9264 9263 5865 5439 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40225 r0 *1 371.84,650.16
X$40225 9264 6581 9263 6610 5440 6622 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $40228 m0 *1 374.08,781.2
X$40228 9264 7882 5440 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $40231 m0 *1 525.84,781.2
X$40231 9264 7891 9263 7892 5440 8003 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $40247 m0 *1 759.92,670.32
X$40247 9264 9263 6784 6634 5440 6590 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40254 r0 *1 723.52,720.72
X$40254 9264 9263 7302 6892 5440 7176 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40273 r0 *1 807.52,599.76
X$40273 9263 9264 6114 5441 6157 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $40277 r0 *1 880.32,609.84
X$40277 9264 9263 6177 5441 6245 5928 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40279 m0 *1 902.72,609.84
X$40279 9264 9263 6110 5441 5702 5847 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40285 m0 *1 420.56,559.44
X$40285 9264 9263 5507 5442 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40290 m0 *1 439.04,559.44
X$40290 5445 9264 5509 9263 5443 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $40295 r0 *1 707.28,650.16
X$40295 9264 6599 9263 5444 6636 5488 6495 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $40320 r0 *1 845.04,660.24
X$40320 9264 9263 6695 6634 5444 6599 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40325 r0 *1 753.2,700.56
X$40325 9264 9263 7210 6892 5444 7090 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40327 m0 *1 632.24,690.48
X$40327 9264 9263 6880 6830 5444 6829 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40329 m0 *1 633.92,710.64
X$40329 9264 7172 5444 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $40337 m0 *1 469.28,559.44
X$40337 5580 9264 9263 5448 5446 5449 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40341 m0 *1 488.32,619.92
X$40341 9264 6186 5447 6341 6142 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $40354 r0 *1 487.76,559.44
X$40354 9264 9263 5451 5583 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40359 r0 *1 496.16,559.44
X$40359 9264 9263 5582 5452 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40368 m0 *1 465.92,559.44
X$40368 9264 9263 5454 5579 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40376 m0 *1 510.16,569.52
X$40376 9263 5762 5455 9264 5664 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $40390 r0 *1 127.68,559.44
X$40390 9264 9263 5460 5594 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40394 r0 *1 138.32,559.44
X$40394 9264 9263 5640 5461 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40397 r0 *1 170.24,559.44
X$40397 9264 9263 5600 5462 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40408 r0 *1 234.64,559.44
X$40408 9264 9263 5522 5465 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40410 m0 *1 226.8,579.6
X$40410 9264 5466 5785 5604 5754 5753 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $40418 m0 *1 244.16,569.52
X$40418 9264 9263 5471 5466 5467 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40421 r0 *1 709.52,750.96
X$40421 9264 5467 7638 6348 7634 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $40432 r0 *1 656.88,559.44
X$40432 9263 5542 5467 9264 5481 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40434 m0 *1 646.24,569.52
X$40434 9263 5628 5467 9264 5541 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40461 r0 *1 445.2,559.44
X$40461 9263 5468 5621 9264 5511 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40465 m0 *1 433.44,599.76
X$40465 9264 9263 5822 5468 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $40483 r0 *1 324.24,559.44
X$40483 5469 9264 9263 5570 5653 5470 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40493 r0 *1 429.52,579.6
X$40493 9264 5822 5471 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $40521 m0 *1 358.4,589.68
X$40521 9264 5821 5472 5939 5862 5896 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $40524 r0 *1 378.56,559.44
X$40524 5473 9264 9263 5574 5573 5571 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40530 r0 *1 390.32,771.12
X$40530 9264 5475 7737 6220 7883 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $40532 r0 *1 322,579.6
X$40532 9264 9263 5687 5678 5475 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40535 m0 *1 316.4,579.6
X$40535 9263 5618 5475 9264 5790 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40537 m0 *1 430.08,640.08
X$40537 9263 5532 5475 9264 6518 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40541 r0 *1 347.76,579.6
X$40541 9263 5477 5475 9264 5760 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40550 r0 *1 450.24,559.44
X$40550 5509 9264 9263 5579 5476 5578 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40554 r0 *1 376.88,589.68
X$40554 9263 5477 5897 9264 5820 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40557 r0 *1 371.84,569.52
X$40557 9263 5477 5683 9264 5613 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40559 r0 *1 509.6,609.84
X$40559 9263 5477 6146 9264 6147 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40562 m0 *1 517.44,609.84
X$40562 9263 5477 5996 9264 6148 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40580 m0 *1 425.6,609.84
X$40580 9264 9263 5830 5477 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $40582 r0 *1 336.56,589.68
X$40582 9263 5477 5895 9264 5890 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40584 r0 *1 338.8,609.84
X$40584 9263 5477 6016 9264 6137 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40591 m0 *1 626.08,579.6
X$40591 5693 9264 9263 5774 5773 5480 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40597 r0 *1 674.8,559.44
X$40597 5482 9264 9263 5546 5588 5513 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40599 m0 *1 710.64,569.52
X$40599 9264 9263 5584 5550 5631 5483 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40611 r0 *1 762.72,569.52
X$40611 9264 9263 5485 5739 5701 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40613 m0 *1 824.88,619.92
X$40613 9264 9263 6241 6243 5486 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $40628 m0 *1 852.88,619.92
X$40628 9264 9263 6259 5486 6245 6103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40632 r0 *1 831.6,579.6
X$40632 9264 9263 5844 5486 5843 5707 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40634 m0 *1 904.4,619.92
X$40634 9264 9263 6247 5486 5702 6026 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40647 m0 *1 619.36,710.64
X$40647 9264 7236 5488 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $40668 r0 *1 618.24,640.08
X$40668 9264 9263 6574 6540 5488 6487 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40671 r0 *1 865.2,650.16
X$40671 9264 9263 6655 6634 5488 6495 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40676 r0 *1 901.6,579.6
X$40676 9264 9263 5852 5853 5711 5489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40678 m0 *1 844.48,599.76
X$40678 9264 9263 6027 5859 5842 5489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40682 r0 *1 873.04,569.52
X$40682 9264 9263 5779 5709 5490 5489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40685 m0 *1 784.56,630
X$40685 9264 6153 5489 6445 6406 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $40704 m0 *1 786.8,609.84
X$40704 9264 5489 6270 6092 9263 gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* cell instance $40707 m0 *1 911.12,609.84
X$40707 9264 9263 6174 6110 6097 5489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40710 m0 *1 871.92,619.92
X$40710 9264 9263 6246 6177 6161 5489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40712 r0 *1 861.84,771.12
X$40712 9264 7803 5490 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $40715 r0 *1 883.12,700.56
X$40715 9264 9263 7126 7137 5490 7011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40733 m0 *1 879.2,781.2
X$40733 9264 9263 7819 7872 5490 7871 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40736 m0 *1 882,771.12
X$40736 9264 9263 7768 7767 5490 7684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40738 r0 *1 873.6,650.16
X$40738 9264 9263 6644 6655 5490 6588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40740 m0 *1 886.48,730.8
X$40740 9264 9263 7419 7357 5490 7245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40743 r0 *1 870.8,680.4
X$40743 9264 9263 6894 6902 5490 6893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40758 m0 *1 972.16,579.6
X$40758 5492 9263 9264 5494 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $40762 r0 *1 972.16,579.6
X$40762 5554 9263 9264 5493 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $40767 m0 *1 980.56,599.76
X$40767 5927 9263 9264 5495 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $40769 m0 *1 313.04,670.32
X$40769 9264 9263 6732 6752 6770 5496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40795 r0 *1 229.04,559.44
X$40795 9264 9263 5502 5648 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40810 r0 *1 333.76,559.44
X$40810 9264 5571 5570 5505 5524 5572 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $40842 r0 *1 665.28,559.44
X$40842 5514 9264 9263 5544 5543 5545 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40848 r0 *1 392,630
X$40848 9264 5532 5516 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $40850 r0 *1 295.12,630
X$40850 9264 9263 5516 6355 6421 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40853 r0 *1 306.32,630
X$40853 9264 9263 5516 6423 5897 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40856 r0 *1 301.28,630
X$40856 9264 9263 5516 6356 6426 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40859 m0 *1 296.24,640.08
X$40859 9264 9263 5516 6328 6285 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40861 r0 *1 312.48,630
X$40861 9264 9263 5516 6424 6016 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40864 m0 *1 338.24,630
X$40864 9264 9263 5516 6290 6291 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40869 r0 *1 524.72,619.92
X$40869 9264 9263 5516 6215 5827 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40878 r0 *1 685.44,791.28
X$40878 9264 5517 8008 6220 8033 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $40881 m0 *1 539.28,599.76
X$40881 9263 5532 5517 9264 5967 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40883 r0 *1 549.36,579.6
X$40883 9264 9263 5767 5533 5517 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40885 m0 *1 627.76,589.68
X$40885 9263 5628 5517 9264 5774 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40888 m0 *1 633.92,569.52
X$40888 9263 5542 5517 9264 5538 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40898 r0 *1 246.96,660.24
X$40898 9264 9263 6694 6665 6664 5518 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40906 m0 *1 181.44,569.52
X$40906 5519 9264 9263 5601 5670 5564 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40909 r0 *1 194.32,569.52
X$40909 5520 9264 9263 5727 5751 5645 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40911 m0 *1 150.64,569.52
X$40911 5596 9264 9263 5521 5599 5642 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40914 m0 *1 150.64,579.6
X$40914 9264 9263 5807 5521 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40922 r0 *1 166.88,609.84
X$40922 9264 5522 6042 6196 6132 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $40929 m0 *1 349.44,569.52
X$40929 5524 9264 9263 5654 5611 5651 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $40933 m0 *1 424.48,569.52
X$40933 9263 5618 5621 9264 5525 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40936 m0 *1 429.52,569.52
X$40936 9263 5619 5620 9264 5526 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40938 m0 *1 461.44,569.52
X$40938 9264 9263 5527 5660 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40940 r0 *1 459.76,559.44
X$40940 9264 5578 5527 5581 5580 5529 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $40943 r0 *1 460.88,599.76
X$40943 9264 6055 5528 6019 6056 5966 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $40945 m0 *1 470.96,569.52
X$40945 9264 9263 5661 5529 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40948 m0 *1 444.08,589.68
X$40948 9263 9264 5530 5754 5822 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $40950 m0 *1 708.4,730.8
X$40950 9264 5530 7345 6348 7384 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $40954 m0 *1 651.28,569.52
X$40954 9263 5628 5530 9264 5662 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40956 m0 *1 664.16,569.52
X$40956 9263 5542 5530 9264 5543 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40977 r0 *1 472.08,640.08
X$40977 9264 5532 6521 6483 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $40981 m0 *1 539.84,579.6
X$40981 9263 5532 5695 9264 5766 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40985 m0 *1 550.48,640.08
X$40985 9263 5532 6484 9264 6429 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40996 m0 *1 386.4,599.76
X$40996 9263 5532 5823 9264 5898 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40999 r0 *1 388.64,609.84
X$40999 9263 5532 5895 9264 5964 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41001 r0 *1 560,579.6
X$41001 9264 9263 5533 5832 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41006 m0 *1 540.96,589.68
X$41006 9264 5874 5872 5831 5533 5902 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41014 r0 *1 591.36,579.6
X$41014 9264 5875 5535 5802 5834 5769 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41017 m0 *1 600.32,569.52
X$41017 5589 9264 9263 5626 5665 5536 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41019 m0 *1 612.08,569.52
X$41019 9264 9263 5537 5627 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41025 r0 *1 634.48,569.52
X$41025 9263 5628 5695 9264 5539 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41031 r0 *1 445.2,599.76
X$41031 9264 9263 5542 5618 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $41034 r0 *1 598.08,599.76
X$41034 9264 9263 5542 5968 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $41037 m0 *1 659.68,609.84
X$41037 9264 9263 6085 5542 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $41044 m0 *1 619.92,579.6
X$41044 9263 5542 5689 9264 5772 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41047 r0 *1 627.2,579.6
X$41047 9263 5542 5827 9264 5773 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41050 r0 *1 641.2,569.52
X$41050 9263 5542 5695 9264 5629 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41074 m0 *1 464.24,791.28
X$41074 9264 9263 7791 7935 5548 7957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41076 m0 *1 392.56,791.28
X$41076 9264 8168 9263 7883 7946 5548 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $41078 m0 *1 350,660.24
X$41078 9264 6656 5548 6665 6622 6580 6623 6619 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41081 m0 *1 547.68,660.24
X$41081 9264 6414 5548 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $41083 m0 *1 693.28,650.16
X$41083 9264 6615 5548 6592 6590 6580 6591 6495 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41085 r0 *1 700.56,660.24
X$41085 9264 9263 6719 6599 5548 6551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41104 r0 *1 444.64,781.2
X$41104 9264 9263 7885 7904 5548 7886 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41106 m0 *1 652.4,771.12
X$41106 9264 7727 5548 9263 7803 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $41108 m0 *1 358.4,670.32
X$41108 9264 9263 6735 6752 5548 6754 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41116 m0 *1 819.28,690.48
X$41116 9264 9263 5549 6903 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41118 m0 *1 708.96,619.92
X$41118 9264 9263 5549 6222 5577 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41123 m0 *1 804.72,680.4
X$41123 9264 5549 6153 6904 6944 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $41125 r0 *1 717.92,670.32
X$41125 5549 6833 5577 6782 9264 9263 6800 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $41165 r0 *1 701.12,801.36
X$41165 9264 8032 9263 5552 8121 5949 8248 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $41167 r0 *1 635.04,771.12
X$41167 9264 7801 5552 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $41169 m0 *1 352.8,781.2
X$41169 9264 7729 9263 5552 7850 5949 7944 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $41172 r0 *1 718.48,730.8
X$41172 9264 7312 9263 5552 7486 5838 7411 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $41174 m0 *1 749.84,781.2
X$41174 9264 7923 9263 5552 7890 7804 7865 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $41176 r0 *1 418.32,791.28
X$41176 9264 7951 9263 5552 7953 5949 7954 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $41178 m0 *1 756.56,811.44
X$41178 9264 8296 9263 5552 8149 7456 8147 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $41180 m0 *1 379.68,811.44
X$41180 9264 8046 9263 5552 8148 5838 8104 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $41201 m0 *1 608.72,650.16
X$41201 9264 9263 6614 6526 5552 6574 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41214 r0 *1 920.08,569.52
X$41214 9264 9263 5716 5715 5713 5555 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41216 m0 *1 763.28,589.68
X$41216 9264 5920 9263 5701 5917 5838 5555 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $41230 m0 *1 963.76,569.52
X$41230 9264 9263 5556 5636 5637 5557 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41238 m0 *1 980.56,579.6
X$41238 5557 9263 9264 5560 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $41242 m0 *1 946.96,569.52
X$41242 5635 9263 9264 5558 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $41247 r0 *1 980.56,599.76
X$41247 5719 9263 9264 5559 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $41253 r0 *1 963.76,579.6
X$41253 5780 9263 9264 5561 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $41258 r0 *1 154.56,619.92
X$41258 5562 9264 9263 6320 6283 6131 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41260 r0 *1 183.12,559.44
X$41260 9264 9263 5564 5563 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41269 m0 *1 201.6,569.52
X$41269 9264 9263 5602 5565 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41274 m0 *1 204.4,579.6
X$41274 9264 5785 5784 5566 5786 5752 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41290 r0 *1 283.36,569.52
X$41290 9264 5729 5606 5569 5730 5675 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41300 m0 *1 332.08,579.6
X$41300 9264 9263 5791 5572 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41308 r0 *1 395.36,559.44
X$41308 9264 9263 5657 5573 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41313 m0 *1 403.2,569.52
X$41313 9264 5616 5574 5576 5617 5658 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41329 m0 *1 827.68,720.72
X$41329 9263 5577 7308 9264 7245 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41337 r0 *1 786.24,710.64
X$41337 9264 9263 6445 5577 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $41356 m0 *1 790.16,690.48
X$41356 9263 5577 6959 9264 6893 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41388 m0 *1 519.68,569.52
X$41388 9264 9263 5585 5623 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41396 r0 *1 509.04,569.52
X$41396 9264 5623 5661 5763 5742 5586 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41398 m0 *1 550.48,569.52
X$41398 9264 9263 5587 5625 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41411 m0 *1 600.32,579.6
X$41411 9264 5691 5626 5590 5770 5803 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41416 m0 *1 117.04,569.52
X$41416 9264 9263 5592 5591 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41418 r0 *1 113.68,569.52
X$41418 9264 5591 5666 5669 5668 5667 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41421 m0 *1 122.64,569.52
X$41421 9264 5639 5592 5640 5595 5594 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41424 r0 *1 128.24,579.6
X$41424 9264 5805 5806 5593 5747 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $41430 m0 *1 142.24,579.6
X$41430 9264 9263 5880 5595 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41435 m0 *1 147.28,569.52
X$41435 9264 9263 5596 5597 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41440 m0 *1 160.16,569.52
X$41440 9264 9263 5598 5599 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41442 r0 *1 148.4,579.6
X$41442 9264 5807 5850 9267 5809 5598 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41452 r0 *1 169.68,569.52
X$41452 5600 9264 9263 5725 6042 5639 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41455 r0 *1 182.56,569.52
X$41455 5644 9264 9263 5726 5671 5601 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41460 r0 *1 208.88,599.76
X$41460 5603 9264 9263 6044 6068 6134 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41467 r0 *1 260.4,569.52
X$41467 9264 5650 5672 5605 5674 5673 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41475 r0 *1 308.56,579.6
X$41475 9264 9263 5961 5608 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41477 m0 *1 307.44,569.52
X$41477 9264 5651 5652 5653 5609 5608 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41479 m0 *1 321.44,579.6
X$41479 5609 9264 9263 5680 5679 5729 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41485 r0 *1 354.48,569.52
X$41485 9264 9263 5734 5611 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41489 m0 *1 364,599.76
X$41489 6076 9264 9263 5994 6005 5612 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41498 m0 *1 380.24,569.52
X$41498 9264 5613 5655 5657 5615 5614 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41507 r0 *1 393.68,569.52
X$41507 9263 5619 5684 9264 5615 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41513 r0 *1 406.56,630
X$41513 9264 9263 5830 5616 5684 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41517 r0 *1 404.32,640.08
X$41517 9264 6568 5616 6516 6566 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $41522 m0 *1 253.68,640.08
X$41522 9264 9263 5618 6477 5895 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41526 m0 *1 221.2,640.08
X$41526 9264 9263 5618 6476 6426 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41528 m0 *1 226.8,640.08
X$41528 9264 9263 5618 6508 6291 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41530 r0 *1 409.36,569.52
X$41530 9264 9263 5618 5658 5620 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41533 r0 *1 434.56,619.92
X$41533 9264 9263 5618 6266 6295 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41535 r0 *1 341.04,569.52
X$41535 9264 9263 5618 5677 5683 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41537 m0 *1 356.16,579.6
X$41537 9263 5618 5684 9264 5793 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41558 m0 *1 440.16,579.6
X$41558 9264 9263 5619 5687 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $41561 m0 *1 277.2,599.76
X$41561 9263 5619 5897 9264 5893 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41563 r0 *1 349.44,569.52
X$41563 9263 5619 5683 9264 5792 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41566 r0 *1 301.28,579.6
X$41566 9263 5619 5823 9264 5756 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41568 r0 *1 271.04,630
X$41568 9263 5619 5895 9264 6459 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41572 m0 *1 468.72,630
X$41572 9264 9263 6362 5619 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $41576 r0 *1 646.24,589.68
X$41576 9264 9263 5619 5628 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $41594 m0 *1 434,650.16
X$41594 9264 6295 5620 6469 6532 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $41597 m0 *1 410.48,630
X$41597 9264 9263 5830 6360 5620 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41601 m0 *1 534.24,781.2
X$41601 9264 7842 5620 7857 6471 7858 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $41611 r0 *1 426.16,609.84
X$41611 9264 9263 5687 6212 5621 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41615 m0 *1 580.16,740.88
X$41615 9264 5621 7449 6348 7614 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $41632 r0 *1 540.4,609.84
X$41632 9264 6020 5624 6185 6080 6149 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41641 r0 *1 613.2,569.52
X$41641 9264 5627 5692 5665 5694 5693 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41644 r0 *1 612.64,579.6
X$41644 9263 5628 5827 9264 5873 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41646 m0 *1 600.32,599.76
X$41646 9263 5628 5971 9264 5972 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41648 m0 *1 590.24,609.84
X$41648 9263 5628 5761 9264 6082 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41650 r0 *1 587.44,609.84
X$41650 9263 5628 5996 9264 6191 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41653 r0 *1 607.6,589.68
X$41653 9263 5628 5689 9264 5906 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41675 r0 *1 708.96,569.52
X$41675 9264 5630 5697 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $41678 m0 *1 600.32,710.64
X$41678 9263 6412 6777 5631 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $41691 r0 *1 628.32,680.4
X$41691 9264 9263 6934 6879 5631 6880 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41693 m0 *1 422.24,781.2
X$41693 9264 7854 5631 7997 7952 7835 6833 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $41707 r0 *1 833.28,569.52
X$41707 9264 9263 5735 5707 5698 5635 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41716 m0 *1 863.52,619.92
X$41716 9264 9263 6095 6162 6045 5636 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41718 r0 *1 772.8,589.68
X$41718 9264 9263 5636 5992 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41732 m0 *1 960.96,821.52
X$41732 9264 8261 5637 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $41734 r0 *1 972.72,740.88
X$41734 9264 9263 7467 7409 5637 7361 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41748 r0 *1 962.64,609.84
X$41748 9264 9263 6098 6103 5637 6164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41750 r0 *1 969.36,589.68
X$41750 9264 9263 5929 5928 5637 5927 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41757 r0 *1 963.2,720.72
X$41757 9264 9263 7362 7313 5637 7360 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41760 m0 *1 975.52,821.52
X$41760 9264 9263 8264 8262 5637 8263 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41763 r0 *1 972.16,690.48
X$41763 9264 9263 6897 6938 5637 6950 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41765 r0 *1 971.04,791.28
X$41765 9264 9263 8021 7916 5637 7973 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41767 m0 *1 962.64,761.04
X$41767 9264 9263 7643 7580 5637 7592 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41770 r0 *1 960.96,569.52
X$41770 5717 9263 9264 5638 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $41779 r0 *1 618.24,670.32
X$41779 9264 9263 6811 6829 6770 5641 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41789 r0 *1 159.6,569.52
X$41789 5724 9264 9263 5810 5642 9307 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41825 m0 *1 728.56,630
X$41825 9264 6230 9263 6377 6376 5646 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $41833 r0 *1 713.44,630
X$41833 9264 6213 5646 6471 6470 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $41849 r0 *1 301.28,569.52
X$41849 5730 9264 9263 5731 5676 5650 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41864 m0 *1 363.44,569.52
X$41864 9264 9263 5655 5654 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41882 r0 *1 428.4,569.52
X$41882 9264 9263 5659 5866 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41901 r0 *1 528.64,579.6
X$41901 9264 5765 5764 5663 5766 5832 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41911 r0 *1 110.32,599.76
X$41911 9264 5666 6001 6035 6033 6002 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41914 r0 *1 130.48,569.52
X$41914 9264 9263 5721 5667 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41919 m0 *1 131.6,589.68
X$41919 9264 9263 5849 5668 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41927 r0 *1 176.96,599.76
X$41927 5811 9264 9263 6133 6108 5670 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41930 m0 *1 188.16,579.6
X$41930 9264 9263 5750 5671 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41934 r0 *1 266,579.6
X$41934 9264 9263 5958 5673 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41940 r0 *1 273.84,579.6
X$41940 5674 9264 9263 5819 5818 5858 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $41942 m0 *1 287.28,579.6
X$41942 9264 9263 5860 5675 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41948 m0 *1 307.44,579.6
X$41948 9264 9263 5757 5676 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41952 r0 *1 311.92,569.52
X$41952 9264 5681 5731 5679 5678 5677 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41960 r0 *1 337.68,569.52
X$41960 9264 9263 5682 5680 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41965 m0 *1 415.52,630
X$41965 9264 5681 6360 6294 6407 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $41975 m0 *1 408.24,619.92
X$41975 9264 9263 5830 5681 5823 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $41982 m0 *1 339.36,579.6
X$41982 9264 5760 5682 5734 5792 5793 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $41984 r0 *1 422.24,640.08
X$41984 9263 5683 6532 9264 6531 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $41988 r0 *1 422.8,781.2
X$41988 9264 7854 5683 6471 7953 7901 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $42006 r0 *1 628.88,781.2
X$42006 9264 5684 7912 6471 7989 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $42024 r0 *1 384.16,589.68
X$42024 9264 5898 5685 5941 5820 5964 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $42031 r0 *1 381.36,579.6
X$42031 9264 9263 5759 5686 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42033 r0 *1 205.52,640.08
X$42033 9263 5687 6285 9264 6561 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42035 r0 *1 245.84,640.08
X$42035 9264 9263 5687 6478 6016 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42037 r0 *1 200.48,640.08
X$42037 9264 9263 5687 6504 6421 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42042 r0 *1 220.08,640.08
X$42042 9264 9263 5687 6563 6426 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42044 m0 *1 231.84,640.08
X$42044 9264 9263 5687 6509 6291 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42071 m0 *1 448.56,619.92
X$42071 9263 5687 6213 9264 6267 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42073 r0 *1 450.24,609.84
X$42073 9263 5687 6146 9264 6182 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42075 m0 *1 495.04,609.84
X$42075 9264 9263 6079 5688 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42082 r0 *1 680.96,750.96
X$42082 9264 5689 7607 6348 7632 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $42086 r0 *1 557.76,609.84
X$42086 9263 9264 5689 6020 5767 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $42102 m0 *1 536.48,579.6
X$42102 9264 9263 5872 5690 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42105 r0 *1 596.96,569.52
X$42105 9264 9263 5744 5691 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42112 r0 *1 617.68,579.6
X$42112 5803 9264 9263 5873 5772 5694 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $42116 m0 *1 748.16,801.36
X$42116 9263 8076 8077 5695 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $42137 m0 *1 619.36,801.36
X$42137 9264 7991 8114 5696 8004 8006 8042 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42139 m0 *1 535.92,791.28
X$42139 9263 5696 7963 9264 7940 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42141 r0 *1 360.08,650.16
X$42141 9263 5696 6623 9264 6654 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42145 r0 *1 738.64,680.4
X$42145 9264 5797 9263 6907 7024 6888 5696 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42147 r0 *1 737.52,710.64
X$42147 9264 7085 5696 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $42150 r0 *1 700,690.48
X$42150 6121 7034 7092 7091 5696 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $42152 r0 *1 658.56,640.08
X$42152 9264 9263 5696 6372 6586 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42173 r0 *1 540.96,781.2
X$42173 9264 9263 7941 7942 5696 7909 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42180 m0 *1 641.76,771.12
X$42180 9264 9263 7727 5697 7801 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $42182 r0 *1 631.12,761.04
X$42182 9263 6489 5697 9264 7728 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42184 r0 *1 590.24,771.12
X$42184 9264 9263 7780 7843 5697 7859 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42186 m0 *1 600.32,609.84
X$42186 9264 5697 5974 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $42191 m0 *1 654.64,670.32
X$42191 9264 9263 5697 6438 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $42193 m0 *1 659.68,740.88
X$42193 9263 5697 7237 7435 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $42216 r0 *1 730.24,670.32
X$42216 9264 9263 6834 6835 5697 6886 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42218 r0 *1 717.92,761.04
X$42218 9264 9263 7678 7636 5697 7520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42222 m0 *1 668.08,922.32
X$42222 9264 9263 8829 7805 5698 8842 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42225 m0 *1 833.28,579.6
X$42225 9264 9263 5736 5705 5698 5720 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42245 m0 *1 772.8,972.72
X$42245 9264 9263 9099 8147 5698 9100 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42247 m0 *1 654.08,972.72
X$42247 9264 9263 9115 6591 5698 9095 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42249 r0 *1 664.72,962.64
X$42249 9264 9263 9072 6718 5698 9046 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42251 r0 *1 684.32,952.56
X$42251 9264 9263 8980 8248 5698 8969 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42253 m0 *1 696.64,952.56
X$42253 9264 9263 8940 8123 5698 9008 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42255 m0 *1 654.64,962.64
X$42255 9264 9263 8985 6882 5698 8968 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42258 r0 *1 722.96,962.64
X$42258 9264 9263 9067 8337 5698 9097 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42260 m0 *1 734.16,579.6
X$42260 9264 9263 5699 5777 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42271 m0 *1 662.48,801.36
X$42271 7178 9263 5700 8007 9264 8099 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $42273 r0 *1 360.64,640.08
X$42273 9264 5921 5700 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $42279 r0 *1 750.4,680.4
X$42279 9263 5700 6835 9264 6889 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42302 m0 *1 697.76,670.32
X$42302 9264 9263 6803 6591 5700 6590 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42304 r0 *1 526.4,791.28
X$42304 9264 9263 7908 8002 5700 7962 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42307 r0 *1 358.4,670.32
X$42307 9264 9263 6707 6752 5700 6753 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42309 r0 *1 347.2,660.24
X$42309 9264 9263 6734 6619 5700 6665 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42320 m0 *1 477.68,811.44
X$42320 9264 8111 9263 5701 8158 7804 8173 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42322 r0 *1 356.16,781.2
X$42322 9264 7896 9263 5701 7930 5838 7783 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42324 r0 *1 671.44,740.88
X$42324 9264 7492 5701 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $42327 r0 *1 360.64,710.64
X$42327 9264 6703 9263 5701 7260 5838 6953 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42330 r0 *1 761.6,811.44
X$42330 9264 8262 9263 5701 8209 7804 8192 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42333 m0 *1 642.32,811.44
X$42333 9264 8116 9263 5701 8039 5838 8118 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42336 m0 *1 715.68,811.44
X$42336 9264 8010 9263 5701 8124 5838 8072 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42338 m0 *1 689.36,811.44
X$42338 9264 8066 9263 5701 8159 5838 8120 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42359 m0 *1 617.68,630
X$42359 9264 9263 6300 6366 5701 6367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42361 m0 *1 621.6,791.28
X$42361 9264 7943 5702 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $42363 r0 *1 674.8,801.36
X$42363 9264 8099 9263 8034 5702 8066 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $42367 r0 *1 904.96,680.4
X$42367 9264 9263 6956 6947 5702 6938 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42387 m0 *1 626.08,630
X$42387 9264 9263 6367 6368 5702 6301 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42389 r0 *1 889.84,650.16
X$42389 9264 9263 6653 6634 5702 6592 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42391 m0 *1 902.72,680.4
X$42391 9264 9263 6846 6892 5702 6688 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42395 r0 *1 838.88,811.44
X$42395 9264 9263 8258 7636 5704 8198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42400 r0 *1 664.16,650.16
X$42400 9264 9263 6633 6591 5704 6542 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42416 m0 *1 826,680.4
X$42416 9264 9263 6836 6835 5704 6891 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42419 r0 *1 815.92,569.52
X$42419 9264 9263 5706 5707 5704 5708 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42421 r0 *1 805.84,569.52
X$42421 9264 9263 5795 5705 5704 5861 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42423 r0 *1 661.36,690.48
X$42423 9264 9263 7064 6882 5704 7035 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42425 r0 *1 834.96,750.96
X$42425 9264 9263 7585 7412 5704 7586 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42427 r0 *1 805.28,821.52
X$42427 9264 9263 8316 7863 5704 8314 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42464 m0 *1 907.2,781.2
X$42464 9264 9263 7879 7873 5711 7871 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42467 m0 *1 888.72,710.64
X$42467 9264 9263 7199 7186 5711 6893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42469 r0 *1 889.84,660.24
X$42469 9264 9263 6730 6684 5711 6588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42488 m0 *1 903.84,740.88
X$42488 9264 9263 7477 7466 5711 7245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42490 r0 *1 883.68,781.2
X$42490 9264 7864 5711 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $42492 r0 *1 907.76,700.56
X$42492 9264 9263 7135 7136 5711 7011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42494 r0 *1 903.28,771.12
X$42494 9264 9263 7827 7762 5711 7684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42498 m0 *1 892.08,660.24
X$42498 9264 9263 6684 6634 5712 6603 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42500 m0 *1 702.8,660.24
X$42500 9264 6603 9263 5712 6660 6678 6551 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42502 r0 *1 612.64,710.64
X$42502 9264 7235 5712 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $42533 r0 *1 608.72,680.4
X$42533 9264 9263 6877 6878 5712 6827 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42535 r0 *1 889.84,710.64
X$42535 9264 9263 7186 6892 5712 7128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42537 m0 *1 907.2,700.56
X$42537 9264 9263 7136 6947 5712 7066 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42539 m0 *1 924.56,781.2
X$42539 9264 9263 7874 7825 5713 7865 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42558 m0 *1 920.64,740.88
X$42558 9264 9263 7474 7473 5713 7411 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42560 r0 *1 927.36,700.56
X$42560 9264 9263 7133 7132 5713 7066 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42562 m0 *1 913.36,660.24
X$42562 9264 9263 6650 6686 5713 6603 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42565 m0 *1 905.52,710.64
X$42565 9264 9263 7247 7198 5713 7128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42567 r0 *1 919.52,761.04
X$42567 9264 9263 7687 7763 5713 7688 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42572 r0 *1 899.36,831.6
X$42572 9264 8344 5714 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $42577 r0 *1 825.44,902.16
X$42577 9264 9263 8731 8734 5714 8498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42600 r0 *1 805.84,912.24
X$42600 9264 9263 8803 8730 5714 8457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42603 m0 *1 912.24,740.88
X$42603 9264 9263 7473 7477 5714 7311 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42606 m0 *1 915.6,781.2
X$42606 9264 9263 7825 7879 5714 7820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42608 r0 *1 918.96,700.56
X$42608 9264 9263 7132 7135 5714 6896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42610 r0 *1 917.28,771.12
X$42610 9264 9263 7763 7827 5714 7686 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42618 m0 *1 946.4,589.68
X$42618 9264 9263 5925 5920 5926 5717 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42640 m0 *1 980.56,609.84
X$42640 5720 9263 9264 5782 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $42648 r0 *1 136.08,569.52
X$42648 9264 9263 5722 5746 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42651 r0 *1 156.24,569.52
X$42651 9264 9263 5724 5723 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42661 m0 *1 172.48,579.6
X$42661 9264 9263 5748 5725 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42663 m0 *1 184.8,579.6
X$42663 9264 9263 5749 5726 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42666 m0 *1 197.12,579.6
X$42666 9264 9263 5784 5727 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42717 m0 *1 510.72,579.6
X$42717 9264 9263 5796 5741 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42722 m0 *1 527.52,579.6
X$42722 9264 9263 5764 5742 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42735 m0 *1 114.24,599.76
X$42735 5952 9264 9263 5745 6035 5954 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $42745 r0 *1 173.6,579.6
X$42745 9264 5812 5748 5750 5814 5813 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $42748 m0 *1 183.68,589.68
X$42748 9264 5812 5749 5854 5855 5886 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $42753 r0 *1 198.8,579.6
X$42753 9264 9263 5854 5751 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42755 r0 *1 155.12,589.68
X$42755 9264 9263 5881 5752 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42758 r0 *1 131.6,599.76
X$42758 9263 5752 6003 9264 6002 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42764 m0 *1 242.48,609.84
X$42764 9264 5753 6070 6008 5889 6069 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $42766 r0 *1 248.08,619.92
X$42766 9264 9263 6352 5753 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42774 r0 *1 247.52,609.84
X$42774 9264 6137 6136 6176 5753 5889 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $42783 m0 *1 229.04,589.68
X$42783 9264 5754 5855 5786 5758 5889 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $42790 r0 *1 283.36,579.6
X$42790 9264 9263 5755 5819 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42794 m0 *1 290.64,579.6
X$42794 9264 5820 5755 5757 5756 5790 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $42823 m0 *1 594.16,599.76
X$42823 9263 5968 5761 9264 5970 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42826 m0 *1 680.4,690.48
X$42826 9264 7001 5761 6220 6881 7002 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $42836 m0 *1 540.96,609.84
X$42836 9264 9263 5767 6149 5761 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42843 r0 *1 514.64,609.84
X$42843 9264 6189 5762 6145 6148 6078 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $42846 r0 *1 520.8,589.68
X$42846 9263 6272 5763 9264 5945 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $42855 r0 *1 545.44,579.6
X$42855 9264 9263 5766 5874 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $42862 r0 *1 206.08,630
X$42862 9264 9263 5767 6200 6421 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42864 m0 *1 205.52,630
X$42864 9264 9263 5767 6004 6285 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42866 r0 *1 238,630
X$42866 9264 9263 5767 6354 6426 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42869 r0 *1 411.04,619.92
X$42869 9264 5830 5767 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $42872 m0 *1 546,609.84
X$42872 9264 9263 5767 6080 5971 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42874 m0 *1 546,599.76
X$42874 9264 9263 5767 5902 5827 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42893 m0 *1 265.44,640.08
X$42893 9263 9264 6291 6352 5767 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $42898 m0 *1 606.48,589.68
X$42898 5769 9264 9263 5906 5907 5770 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $42904 m0 *1 558.32,710.64
X$42904 9264 9263 7170 6996 7153 5771 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42906 m0 *1 570.08,710.64
X$42906 9264 9263 7214 7215 7151 5771 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42908 m0 *1 552.16,670.32
X$42908 9264 6378 9263 7059 6773 6538 5771 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42920 r0 *1 576.8,690.48
X$42920 9264 9263 7032 5771 5868 6932 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42933 m0 *1 701.12,630
X$42933 9264 6417 5837 6308 6344 6576 5776 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42935 m0 *1 716.8,579.6
X$42935 9264 9263 5776 5800 5798 5799 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42937 r0 *1 734.72,589.68
X$42937 9264 5797 9263 5777 5915 5914 5995 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42944 r0 *1 948.64,579.6
X$42944 9264 9263 5783 5847 5848 5780 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42952 m0 *1 972.16,599.76
X$42952 5981 9263 9264 5781 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $42981 r0 *1 241.92,579.6
X$42981 9264 5858 5856 5789 5816 5815 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $42990 r0 *1 324.24,599.76
X$42990 9264 5894 5791 6015 6049 6072 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $43017 r0 *1 430.64,761.04
X$43017 9264 7267 5797 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $43021 r0 *1 521.36,781.2
X$43021 9264 7891 5978 7941 7938 5797 7908 7940 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43023 r0 *1 355.6,660.24
X$43023 9264 6581 5978 6707 6736 5797 6734 6654 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43025 m0 *1 761.6,599.76
X$43025 9264 5797 9263 5948 5993 5914 5992 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $43028 r0 *1 762.16,630
X$43028 9264 5797 9263 6442 6380 5914 6463 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $43032 r0 *1 729.68,589.68
X$43032 9264 9263 5797 5950 5913 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $43035 r0 *1 733.6,609.84
X$43035 9264 5797 9263 6184 6155 6232 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $43056 m0 *1 630,761.04
X$43056 9263 7453 5798 7628 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $43059 m0 *1 663.04,771.12
X$43059 9263 7735 5798 7804 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $43062 r0 *1 589.68,640.08
X$43062 9263 5974 5798 6538 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $43064 r0 *1 598.64,720.72
X$43064 9264 5798 6777 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $43067 r0 *1 636.72,650.16
X$43067 9263 6438 5798 6466 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $43069 r0 *1 660.24,730.8
X$43069 9264 9263 7237 5798 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $43089 m0 *1 727.44,680.4
X$43089 9264 9263 6884 6885 5798 6834 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43091 m0 *1 734.72,771.12
X$43091 9263 5798 9264 7688 7712 6024 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $43093 m0 *1 588.56,761.04
X$43093 9263 5798 9264 7673 7516 6024 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $43108 m0 *1 594.16,619.92
X$43108 9263 6227 5801 9264 6216 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43110 m0 *1 568.4,690.48
X$43110 9264 5801 9263 7031 7030 6969 5868 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $43113 m0 *1 576.24,700.56
X$43113 9264 5801 7113 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $43116 r0 *1 686.56,609.84
X$43116 9264 5801 9263 6086 6226 6154 6188 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $43120 m0 *1 641.2,700.56
X$43120 9264 9263 5801 7062 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $43132 r0 *1 567.84,690.48
X$43132 9264 9263 6998 7095 5801 7032 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43142 m0 *1 27.44,589.68
X$43142 5808 9263 9264 5804 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $43149 r0 *1 138.32,599.76
X$43149 5806 6037 6104 6041 9264 9263 6038 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $43158 r0 *1 211.68,670.32
X$43158 9264 9263 6702 6749 6813 5808 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43167 r0 *1 142.8,609.84
X$43167 6105 9264 9263 5809 6194 6039 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43173 m0 *1 161.84,609.84
X$43173 9264 9263 5810 5809 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43178 r0 *1 159.04,630
X$43178 6349 9264 9263 6420 6419 5810 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43186 r0 *1 146.16,599.76
X$43186 9263 6039 5812 9264 6067 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43200 r0 *1 176.4,589.68
X$43200 9264 9263 5984 5813 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43202 r0 *1 188.72,589.68
X$43202 9264 9263 5930 5814 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43208 r0 *1 247.52,589.68
X$43208 9264 9263 5956 5815 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43210 r0 *1 256.48,589.68
X$43210 5816 9264 9263 5817 6009 5934 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43214 m0 *1 263.76,589.68
X$43214 9264 9263 5936 5817 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43217 m0 *1 279.44,589.68
X$43217 9264 9263 5892 5818 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43241 r0 *1 453.04,599.76
X$43241 9264 9263 5824 5822 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $43247 r0 *1 453.04,630
X$43247 9263 5822 6469 9264 6468 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43249 r0 *1 448.56,619.92
X$43249 9263 5822 6213 9264 6293 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43264 m0 *1 458.64,630
X$43264 9263 5822 6276 9264 6361 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43268 m0 *1 282.24,599.76
X$43268 9263 5968 5823 9264 5891 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43271 m0 *1 406,781.2
X$43271 9264 5823 7898 6471 8153 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $43288 m0 *1 453.6,619.92
X$43288 9263 5824 6146 9264 5899 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43294 m0 *1 459.76,599.76
X$43294 9264 6017 5997 6018 5966 5825 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $43297 r0 *1 483.84,589.68
X$43297 9264 5944 5943 5826 5945 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $43299 r0 *1 728.56,801.36
X$43299 9264 8074 5827 6471 8126 8075 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $43319 r0 *1 540.96,589.68
X$43319 9320 9264 9263 5967 5833 5829 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43321 r0 *1 492.8,609.84
X$43321 9263 5830 6297 9264 6142 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43330 r0 *1 519.68,650.16
X$43330 9264 5830 6521 6583 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $43344 m0 *1 426.72,650.16
X$43344 9263 5830 6531 9264 6425 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43347 r0 *1 554.4,579.6
X$43347 9264 9263 5831 5871 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43357 r0 *1 551.6,589.68
X$43357 9264 9263 5902 5833 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43367 r0 *1 596.4,589.68
X$43367 5905 9264 9263 5972 5970 5834 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43372 m0 *1 679.84,589.68
X$43372 9264 5836 5868 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $43382 r0 *1 758.8,771.12
X$43382 9264 7804 5838 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $43420 m0 *1 600.32,680.4
X$43420 9264 9263 6855 6779 5838 6877 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43427 r0 *1 654.64,811.44
X$43427 9264 7794 5839 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $43429 m0 *1 733.6,831.6
X$43429 9264 8293 5839 8214 8336 7085 8337 8294 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43431 m0 *1 361.76,781.2
X$43431 9263 9264 7851 7268 7831 5839 7769 7852
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $43433 r0 *1 359.52,720.72
X$43433 9264 5839 9263 7287 7262 5914 7373 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $43435 r0 *1 740.88,750.96
X$43435 9264 5839 9263 7606 7178 5914 7635 7604
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $43438 r0 *1 360.08,730.8
X$43438 9264 7321 5839 6953 7282 7085 6618 7392 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43440 r0 *1 733.6,821.52
X$43440 9264 5839 9263 8292 7178 5914 8281 8252
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $43444 m0 *1 749.28,700.56
X$43444 9264 9263 7004 6889 5839 7087 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43446 r0 *1 362.32,791.28
X$43446 9264 5839 9263 7979 7851 5914 7945 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $43478 m0 *1 840.56,841.68
X$43478 9264 8344 5841 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $43483 m0 *1 833.84,690.48
X$43483 9264 9263 6891 6958 5841 6896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43501 r0 *1 795.76,871.92
X$43501 9264 9263 8560 8612 5841 8498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43505 m0 *1 800.8,882
X$43505 9264 9263 8616 8613 5841 8457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43509 m0 *1 846.16,811.44
X$43509 9264 9263 8198 8137 5841 7686 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43511 r0 *1 843.36,750.96
X$43511 9264 9263 7586 7599 5841 7311 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43513 r0 *1 813.68,821.52
X$43513 9264 9263 8314 8300 5841 7820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43515 m0 *1 656.88,811.44
X$43515 9264 8065 5842 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $43517 m0 *1 842.24,690.48
X$43517 9264 9263 6958 6945 5842 7011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43550 r0 *1 673.12,650.16
X$43550 9264 9263 6587 6662 5842 6588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43552 r0 *1 678.16,690.48
X$43552 9264 9263 6935 7094 5842 6893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43554 m0 *1 840,750.96
X$43554 9264 9263 7599 7540 5842 7245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43556 r0 *1 845.04,801.36
X$43556 9264 9263 8137 8081 5842 7684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43560 m0 *1 848.4,750.96
X$43560 9264 9263 7540 7356 5843 7412 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43562 r0 *1 673.68,781.2
X$43562 9264 7792 5843 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $43566 m0 *1 697.76,690.48
X$43566 9264 6687 9263 6678 7033 5843 6882 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $43569 r0 *1 682.08,650.16
X$43569 9264 9263 6662 6634 5843 6591 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43588 r0 *1 842.8,680.4
X$43588 9264 9263 6945 6947 5843 6835 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43590 m0 *1 679.84,700.56
X$43590 9264 9263 7094 6892 5843 6882 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43592 m0 *1 844.48,801.36
X$43592 9264 9263 8081 7683 5843 7636 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43600 r0 *1 917.28,599.76
X$43600 9264 9263 6036 6030 6031 5847 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43615 r0 *1 960.96,831.6
X$43615 9264 8261 5848 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $43617 m0 *1 766.64,942.48
X$43617 9264 9263 8914 8296 5848 8915 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43620 r0 *1 971.6,781.2
X$43620 9264 9263 7876 7923 5848 7877 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43622 m0 *1 967.68,680.4
X$43622 9264 9263 6842 6886 5848 6843 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43639 m0 *1 739.76,942.48
X$43639 9264 9263 8885 8338 5848 8878 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43645 m0 *1 969.36,811.44
X$43645 9264 9263 8086 7889 5848 8132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43647 r0 *1 945.28,720.72
X$43647 9264 9263 7318 7312 5848 7314 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43649 m0 *1 952,761.04
X$43649 9264 9263 7593 7520 5848 7531 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43651 m0 *1 728.56,942.48
X$43651 9264 9263 8921 8032 5848 8912 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43656 m0 *1 134.96,589.68
X$43656 5849 9264 9263 5851 5850 6040 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43663 m0 *1 163.52,589.68
X$43663 9264 9263 5884 5851 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43701 r0 *1 283.36,599.76
X$43701 9264 5959 5860 6047 6012 6011 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $43707 m0 *1 355.04,589.68
X$43707 9264 9263 5938 5862 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43716 m0 *1 770.56,599.76
X$43716 9264 9263 5979 5993 5978 5864 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43723 m0 *1 410.48,589.68
X$43723 5965 9264 9263 6211 5866 5865 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43734 m0 *1 565.6,700.56
X$43734 9263 5868 7060 9264 7095 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43738 r0 *1 574.56,710.64
X$43738 9264 5868 7234 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $43742 r0 *1 651.84,690.48
X$43742 9263 5868 6227 6812 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $43745 r0 *1 623.84,700.56
X$43745 9263 7062 5868 9264 7149 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43758 m0 *1 608.72,700.56
X$43758 9264 9263 7115 6829 5868 6827 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43761 m0 *1 580.72,710.64
X$43761 9264 9263 5868 7061 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $43772 m0 *1 500.64,640.08
X$43772 9263 5870 6522 9264 6365 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $43801 r0 *1 11.76,589.68
X$43801 5878 9263 9264 5877 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $43804 m0 *1 223.44,660.24
X$43804 9264 9263 6649 6619 6813 5878 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43814 m0 *1 108.64,599.76
X$43814 9264 5952 5953 9263 5879 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $43820 r0 *1 158.48,589.68
X$43820 5880 9264 9263 5883 5882 5884 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43824 r0 *1 137.2,619.92
X$43824 6003 9264 9263 6193 5881 9304 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43826 m0 *1 136.64,619.92
X$43826 6251 9264 9263 6252 5881 6195 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43833 r0 *1 162.4,609.84
X$43833 9264 9263 6131 5882 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43838 m0 *1 173.6,599.76
X$43838 9264 9263 5983 5883 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43842 r0 *1 190.4,579.6
X$43842 9264 9263 5885 5886 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43851 r0 *1 224.56,589.68
X$43851 9264 5934 5933 5888 5955 5887 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $43853 m0 *1 229.6,599.76
X$43853 9264 9263 6111 5887 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43857 r0 *1 219.52,599.76
X$43857 9264 5889 6044 6006 6069 6005 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $43859 m0 *1 291.76,609.84
X$43859 9264 6208 6011 6046 5889 6179 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $43862 r0 *1 290.64,619.92
X$43862 9264 9263 6354 5889 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $43879 r0 *1 267.68,589.68
X$43879 9264 5890 5936 5892 5893 5891 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $43898 m0 *1 371.28,700.56
X$43898 9264 7049 5895 6220 7141 7043 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $43923 r0 *1 278.32,630
X$43923 9263 5968 5897 9264 6422 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43935 m0 *1 375.2,771.12
X$43935 9263 7704 7734 5897 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $43941 m0 *1 388.64,619.92
X$43941 6336 9264 9263 5899 6293 6335 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43953 r0 *1 431.76,630
X$43953 9264 6294 5901 6569 6467 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $43963 r0 *1 529.2,599.76
X$43963 9264 6062 6059 6061 5902 6020 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $43966 r0 *1 563.92,589.68
X$43966 9264 9263 6020 5903 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43982 m0 *1 608.16,599.76
X$43982 9263 5968 5971 9264 5907 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43984 r0 *1 638.4,680.4
X$43984 9264 9263 6045 6831 5908 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $44010 r0 *1 670.32,599.76
X$44010 9264 6123 5909 9263 6063 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $44019 r0 *1 613.2,670.32
X$44019 9263 5910 6829 9264 6809 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44021 r0 *1 549.92,660.24
X$44021 9264 5910 6414 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44023 r0 *1 684.32,589.68
X$44023 9264 5974 5910 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44055 r0 *1 725.2,821.52
X$44055 9264 9263 8249 8294 5910 8250 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44058 r0 *1 678.16,761.04
X$44058 9263 5910 9264 7719 7721 7631 6777 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $44060 r0 *1 539.84,811.44
X$44060 9263 5910 8178 9264 8217 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44062 m0 *1 534.24,821.52
X$44062 9264 9263 8240 8238 5910 8235 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44065 m0 *1 689.36,619.92
X$44065 9264 9263 6280 6226 6227 5911 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44069 r0 *1 726.88,599.76
X$44069 9264 9263 6120 5912 6022 5976 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44076 r0 *1 763.28,821.52
X$44076 9264 7267 9263 8318 8253 5914 8297 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44078 r0 *1 438.48,650.16
X$44078 9264 6154 5914 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44080 m0 *1 758.8,791.28
X$44080 9264 7267 9263 7917 7920 5914 7919 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44111 m0 *1 740.88,599.76
X$44111 9264 9263 5977 5915 5978 5916 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44115 r0 *1 755.44,589.68
X$44115 9263 5917 5919 9264 5918 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44120 m0 *1 746.48,630
X$44120 9263 9264 6413 6307 5918 6378 6275 6338
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $44131 r0 *1 919.52,609.84
X$44131 9264 9263 6253 6173 6031 5920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44148 m0 *1 764.4,781.2
X$44148 9264 7887 7267 7865 7862 5921 7863 7812 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $44150 r0 *1 382.48,791.28
X$44150 7794 9263 5921 8046 9264 7982 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $44153 m0 *1 600.32,730.8
X$44153 9264 7234 5921 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44175 m0 *1 356.16,791.28
X$44175 9264 9263 7979 7944 5921 7731 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44178 r0 *1 347.76,781.2
X$44178 9264 9263 7830 7729 5921 7896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44180 m0 *1 358.96,821.52
X$44180 9264 8169 7794 8228 8167 5921 8226 8227 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $44182 m0 *1 764.4,821.52
X$44182 9264 8277 7267 8192 8127 5921 8147 8208 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $44184 m0 *1 349.44,720.72
X$44184 9264 9263 7259 7217 5921 6703 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44196 m0 *1 924,841.68
X$44196 9264 8261 5926 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $44199 m0 *1 859.04,932.4
X$44199 9264 9263 8854 7716 5926 8880 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44201 m0 *1 970.48,650.16
X$44201 9264 9263 6559 6592 5926 6499 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44226 m0 *1 953.12,619.92
X$44226 9264 9263 6248 6249 5926 6316 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44229 m0 *1 846.16,942.48
X$44229 9264 9263 8918 8339 5926 8916 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44233 r0 *1 954.8,599.76
X$44233 9264 9263 6034 6026 5926 5981 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44235 m0 *1 873.6,942.48
X$44235 9264 9263 8881 8010 5926 8917 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44237 r0 *1 966,841.68
X$44237 9264 9263 8418 8066 5926 8377 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44239 r0 *1 969.92,660.24
X$44239 9264 9263 6690 6688 5926 6604 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44241 r0 *1 961.52,771.12
X$44241 9264 9263 7765 7821 5926 7692 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44250 m0 *1 869.68,599.76
X$44250 9264 9263 6028 6029 6045 5928 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44254 r0 *1 695.52,609.84
X$44254 9264 9263 5928 6188 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44257 r0 *1 705.04,609.84
X$44257 9263 6229 5928 9264 6088 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44277 r0 *1 190.4,609.84
X$44277 9264 6169 6170 5931 6199 6171 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44279 m0 *1 221.76,599.76
X$44279 9264 9263 6135 5932 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44308 m0 *1 364.56,609.84
X$44308 9264 9263 5939 6210 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44329 m0 *1 506.8,619.92
X$44329 9264 6145 6144 5944 6148 6147 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44336 r0 *1 522.48,599.76
X$44336 9264 9263 6059 5946 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44341 r0 *1 760.48,589.68
X$44341 9264 9263 5947 5948 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44360 r0 *1 638.4,801.36
X$44360 9264 8062 9263 6833 7968 5949 8117 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44365 r0 *1 718.48,801.36
X$44365 9264 7970 9263 6833 8122 5949 8123 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44368 r0 *1 383.6,801.36
X$44368 9264 8052 9263 6833 8151 5949 8053 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44373 m0 *1 744.8,750.96
X$44373 9264 7456 5949 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44375 m0 *1 359.52,730.8
X$44375 9264 7326 9263 6833 7374 5949 6618 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44378 m0 *1 635.6,630
X$44378 9263 5949 9264 6415 6219 6369 6304 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $44395 r0 *1 659.68,619.92
X$44395 9263 6222 9264 6304 6416 6305 5949 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $44399 m0 *1 725.2,599.76
X$44399 9264 5978 9263 6089 5950 5998 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $44405 r0 *1 702.8,599.76
X$44405 9264 6057 6023 5951 5975 6022 6088 6025 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $44411 r0 *1 105.28,599.76
X$44411 9263 5954 6065 9264 5953 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44415 m0 *1 124.88,609.84
X$44415 6100 6102 6167 5954 9264 9263 6104 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $44421 m0 *1 238.56,630
X$44421 5955 9264 9263 6394 6395 6286 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $44425 r0 *1 248.08,599.76
X$44425 9264 6136 5956 6010 6008 6007 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44428 r0 *1 264.88,599.76
X$44428 5957 9264 9263 6046 6005 6007 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $44431 r0 *1 264.32,609.84
X$44431 9264 6325 5958 5988 6176 6258 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44434 m0 *1 287.28,599.76
X$44434 9264 9263 5960 5959 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44439 m0 *1 308,599.76
X$44439 9264 5991 5961 6014 5990 6013 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44442 r0 *1 365.12,609.84
X$44442 9264 6261 6075 6263 6139 5962 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44444 m0 *1 383.04,599.76
X$44444 9264 9263 5963 5994 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44452 m0 *1 332.64,619.92
X$44452 9264 5964 6207 6357 6137 6208 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44459 r0 *1 546,599.76
X$44459 9264 9263 5967 6062 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44464 r0 *1 212.8,640.08
X$44464 9263 5968 6421 9264 6455 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44466 m0 *1 224,619.92
X$44466 9263 5968 6016 9264 6257 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44468 m0 *1 460.88,619.92
X$44468 9263 5968 6213 9264 6214 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44472 r0 *1 453.6,619.92
X$44472 9263 5968 6276 9264 6117 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44474 m0 *1 586.88,599.76
X$44474 9263 5968 5996 9264 5969 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44476 r0 *1 580.72,609.84
X$44476 9263 5968 6146 9264 6151 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44500 r0 *1 588.56,599.76
X$44500 6124 9264 9263 6082 5969 6000 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $44507 r0 *1 717.92,791.28
X$44507 9264 5971 7971 6471 8125 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $44523 m0 *1 637.28,609.84
X$44523 9264 6125 6083 9263 5973 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $44525 r0 *1 642.32,750.96
X$44525 9263 5974 7453 7518 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $44530 m0 *1 601.44,670.32
X$44530 9264 9263 6776 6488 5974 6487 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44556 m0 *1 728,761.04
X$44556 9264 9263 7653 7680 5974 7591 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44558 m0 *1 733.04,690.48
X$44558 9263 5974 7026 9264 6885 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44560 m0 *1 721.84,690.48
X$44560 9264 9263 6968 6936 5974 6938 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44562 r0 *1 580.16,750.96
X$44562 9264 9263 7615 7571 5974 7570 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44578 r0 *1 372.96,750.96
X$44578 9264 7268 5978 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44607 m0 *1 770,630
X$44607 9264 9263 6379 6380 5978 6050 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44610 m0 *1 368.48,720.72
X$44610 9264 9263 7263 7262 5978 7321 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44614 r0 *1 746.48,690.48
X$44614 9264 9263 7003 7024 5978 7004 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44617 r0 *1 710.08,660.24
X$44617 9263 6592 6679 6677 6231 5978 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $44619 m0 *1 724.08,619.92
X$44619 9263 5978 9264 6103 6232 6231 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $44621 m0 *1 772.24,609.84
X$44621 9263 5979 6116 9264 6156 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44635 r0 *1 980.56,609.84
X$44635 6250 9263 9264 5982 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $44654 m0 *1 282.24,609.84
X$44654 6048 9264 9263 6005 6203 5987 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $44660 r0 *1 314.72,589.68
X$44660 9264 9263 5989 5990 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44688 r0 *1 736.96,640.08
X$44688 9264 9263 6498 5995 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44701 m0 *1 683.2,660.24
X$44701 9264 6700 5996 6220 6661 6635 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $44719 r0 *1 687.68,599.76
X$44719 9264 9263 5999 6086 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44728 m0 *1 105.84,609.84
X$44728 6065 9264 9263 6001 6066 6100 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $44739 m0 *1 183.12,640.08
X$44739 9264 6004 6503 6530 6504 6476 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44741 r0 *1 203.84,599.76
X$44741 9264 9263 6004 6005 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $44750 m0 *1 201.6,619.92
X$44750 6256 9264 9263 6005 6257 6197 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $44752 m0 *1 210.56,609.84
X$44752 6068 9264 9263 6069 6005 6109 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $44777 r0 *1 262.64,619.92
X$44777 9264 9263 6458 6009 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44787 r0 *1 296.24,619.92
X$44787 9264 9263 6327 6012 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44793 m0 *1 313.6,630
X$44793 9264 6424 6013 6289 6356 6352 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44812 m0 *1 369.04,660.24
X$44812 9264 6667 6016 6220 6624 6621 9263 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $44815 m0 *1 459.2,609.84
X$44815 9264 6078 6017 6141 6118 6077 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44821 r0 *1 459.76,609.84
X$44821 6077 9264 9263 6182 6214 6019 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $44834 m0 *1 523.6,619.92
X$44834 9264 6215 6187 6272 6020 6080 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $44836 r0 *1 566.72,599.76
X$44836 9264 9263 6021 6122 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44847 m0 *1 609.84,750.96
X$44847 9264 6777 6022 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44849 r0 *1 531.44,811.44
X$44849 9264 9263 8176 8217 6022 8240 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44852 m0 *1 707.28,811.44
X$44852 9264 9263 8157 8069 6022 8190 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44856 r0 *1 650.16,700.56
X$44856 9264 6022 6765 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44885 m0 *1 641.76,801.36
X$44885 9264 9263 8041 8063 6022 8101 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44887 r0 *1 726.88,811.44
X$44887 9263 8249 8074 6440 8213 6022 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $44889 m0 *1 384.72,801.36
X$44889 9263 6022 9264 8028 8150 6544 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $44891 m0 *1 543.2,791.28
X$44891 9263 7964 7857 6755 7990 6022 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $44893 r0 *1 385.28,811.44
X$44893 9263 6414 9264 8211 8273 8168 6022 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $44902 m0 *1 731.36,781.2
X$44902 9263 9264 7807 6543 7808 6023 7750 7861
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $44904 r0 *1 427.84,771.12
X$44904 9264 6543 9263 7836 6023 6538 7835 7739
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $44906 m0 *1 744.24,811.44
X$44906 9263 9264 8212 6023 8146 6378 8077 8210
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $44909 m0 *1 516.32,801.36
X$44909 9264 8038 6414 7962 8003 6023 7963 8002 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $44911 r0 *1 599.76,619.92
X$44911 9264 6308 6023 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44913 r0 *1 547.68,640.08
X$44913 9264 6023 6307 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $44938 r0 *1 485.52,791.28
X$44938 9263 9264 7987 6023 8001 6378 7937 7959
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $44942 r0 *1 739.2,811.44
X$44942 6023 9264 6229 8214 9263 8213 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $44944 r0 *1 549.36,781.2
X$44944 6023 9264 6374 7909 9263 7990 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $44946 m0 *1 408.24,811.44
X$44946 9264 6023 8105 9263 8152 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $44951 m0 *1 622.72,771.12
X$44951 9264 6489 9263 7782 7724 7676 6024 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44953 m0 *1 736.96,761.04
X$44953 9264 9263 6024 7651 7580 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $44955 r0 *1 700,730.8
X$44955 9264 7353 9263 7435 7489 7409 6024 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44958 m0 *1 430.08,771.12
X$44958 9264 9263 7836 7740 6024 7741 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44960 m0 *1 582.96,750.96
X$44960 9264 9263 6024 7550 7515 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $44962 r0 *1 729.12,690.48
X$44962 9264 9263 6024 7028 6887 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $44964 r0 *1 652.4,660.24
X$44964 9264 6438 6024 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $44986 m0 *1 722.4,700.56
X$44986 9263 6489 9264 7066 7065 6024 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $44995 m0 *1 910.56,630
X$44995 9264 9263 6396 6314 6031 6026 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45029 r0 *1 921.2,730.8
X$45029 9264 9263 7421 7425 6031 7409 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45031 r0 *1 920.64,791.28
X$45031 9264 9263 8020 7975 6031 7916 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45033 m0 *1 906.64,670.32
X$45033 9264 9263 6727 6791 6031 6688 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45036 r0 *1 903.28,650.16
X$45036 9264 9263 6602 6645 6031 6592 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45040 r0 *1 901.6,640.08
X$45040 9264 9263 6450 6553 6031 6249 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45042 m0 *1 921.2,690.48
X$45042 9264 9263 7015 6954 6031 6938 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45044 r0 *1 912.24,750.96
X$45044 9264 9263 7644 7590 6031 7580 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45048 m0 *1 980.56,619.92
X$45048 6164 9263 9264 6032 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $45050 r0 *1 128.24,599.76
X$45050 9264 9263 6168 6033 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45066 r0 *1 148.96,619.92
X$45066 9264 9263 6037 6390 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45071 r0 *1 237.44,619.92
X$45071 9264 9263 6085 6037 6285 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45079 m0 *1 150.64,609.84
X$45079 6106 9264 9263 6039 6130 6107 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45088 r0 *1 121.52,609.84
X$45088 9264 6040 6128 6168 6129 6251 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $45106 m0 *1 841.68,670.32
X$45106 9264 9263 6796 6789 6045 6687 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45131 r0 *1 846.16,630
X$45131 9264 9263 6494 6401 6045 6410 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45134 m0 *1 834.4,650.16
X$45134 9264 9263 6550 6598 6045 6551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45136 m0 *1 836.08,619.92
X$45136 9264 9263 6244 6262 6045 6103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45140 r0 *1 653.52,670.32
X$45140 9264 6782 6045 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $45147 r0 *1 304.08,619.92
X$45147 9264 9263 6355 6046 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45165 m0 *1 349.44,619.92
X$45165 9264 9263 6209 6051 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45174 r0 *1 408.8,599.76
X$45174 9263 6053 6054 9264 6140 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $45183 r0 *1 487.76,609.84
X$45183 9264 9263 6185 6055 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45192 r0 *1 579.04,599.76
X$45192 6056 9264 9263 6191 6151 6081 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45209 r0 *1 525.84,599.76
X$45209 9264 9263 6061 6060 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45213 m0 *1 498.4,609.84
X$45213 9264 6143 6079 6119 6060 6144 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $45226 m0 *1 26.88,619.92
X$45226 6192 9263 9264 6064 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $45231 m0 *1 115.36,609.84
X$45231 6066 9264 9263 6128 6101 6102 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45234 m0 *1 143.36,609.84
X$45234 9264 6106 6067 9263 6101 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45238 m0 *1 211.12,619.92
X$45238 9264 9263 6200 6069 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $45247 m0 *1 272.72,619.92
X$45247 9264 6326 6258 6203 6202 6069 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $45250 m0 *1 298.48,619.92
X$45250 9264 6205 6204 6202 6069 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $45255 r0 *1 308.56,609.84
X$45255 6178 9264 9263 6204 6179 6071 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45260 r0 *1 331.52,609.84
X$45260 9264 9263 6207 6072 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45266 r0 *1 343.28,619.92
X$45266 9264 9263 6330 6073 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45272 m0 *1 370.16,609.84
X$45272 9264 9263 6076 6139 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45287 m0 *1 525.84,609.84
X$45287 9264 9263 6080 6189 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45308 m0 *1 640.64,619.92
X$45308 9263 6221 9264 6219 6303 6084 6220 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $45313 m0 *1 510.72,660.24
X$45313 9264 6085 6521 6582 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $45327 r0 *1 511.28,660.24
X$45327 9263 6087 6568 6743 6744 6085 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $45336 m0 *1 400.96,861.84
X$45336 9264 6087 7498 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $45338 m0 *1 673.12,861.84
X$45338 9264 6087 8268 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $45367 r0 *1 420.56,861.84
X$45367 9264 9263 8536 8481 6087 7787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45369 m0 *1 639.52,761.04
X$45369 9264 7630 6087 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $45372 r0 *1 385.84,861.84
X$45372 9264 9263 8519 8535 6087 7738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45375 r0 *1 747.04,801.36
X$45375 9264 8078 6087 9263 8076 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45380 r0 *1 724.08,609.84
X$45380 6090 6121 6184 6230 6089 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $45390 m0 *1 466.48,801.36
X$45390 9263 8109 9264 8035 6091 8000 7958 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $45392 r0 *1 526.96,660.24
X$45392 9264 6347 6091 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $45394 m0 *1 742.56,690.48
X$45394 9264 7003 7025 6091 6844 9263 6905 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $45422 m0 *1 384.72,771.12
X$45422 9264 7668 6091 9263 7736 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45425 r0 *1 767.2,801.36
X$45425 9264 8078 6091 9263 8096 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45427 m0 *1 767.76,791.28
X$45427 9264 7889 6091 9263 7984 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45429 m0 *1 800.24,609.84
X$45429 6092 9264 6115 9263 6157 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $45435 r0 *1 775.6,609.84
X$45435 9263 6153 6228 9264 6092 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $45438 m0 *1 813.68,640.08
X$45438 9264 6447 9263 6093 6517 6457 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $45440 m0 *1 814.24,609.84
X$45440 9263 6237 6093 9264 6113 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $45442 m0 *1 859.6,841.68
X$45442 9264 8344 6094 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $45458 r0 *1 834.96,851.76
X$45458 9264 9263 8499 8452 6094 8454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45461 r0 *1 843.36,851.76
X$45461 9264 9263 8455 8453 6094 8496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45464 r0 *1 834.96,650.16
X$45464 9264 9263 6598 6642 6094 6383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45466 r0 *1 842.24,670.32
X$45466 9264 9263 6789 6850 6094 6837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45472 r0 *1 863.52,851.76
X$45472 9264 9263 8462 8504 6094 8594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45476 r0 *1 866.32,710.64
X$45476 9264 9263 7246 7185 6094 6896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45487 m0 *1 900.48,750.96
X$45487 9264 9263 7538 7589 6097 7245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45491 m0 *1 894.32,680.4
X$45491 9264 9263 6847 6846 6097 6893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45493 m0 *1 900.48,660.24
X$45493 9264 9263 6685 6653 6097 6588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45511 m0 *1 906.08,791.28
X$45511 9264 9263 7976 7977 6097 7871 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45513 r0 *1 883.12,801.36
X$45513 9264 8073 6097 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $45516 m0 *1 912.8,690.48
X$45516 9264 9263 6955 6956 6097 7011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45519 r0 *1 901.6,761.04
X$45519 9264 9263 7700 7702 6097 7684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45524 m0 *1 971.6,619.92
X$45524 6239 9263 9264 6099 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $45539 m0 *1 723.52,630
X$45539 9264 9263 6374 6375 6103 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45558 m0 *1 136.64,609.84
X$45558 9264 9263 6105 6129 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45571 m0 *1 187.04,609.84
X$45571 9264 9263 6255 6108 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45597 m0 *1 810.32,609.84
X$45597 9264 9263 6158 6114 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45599 r0 *1 801.36,609.84
X$45599 9263 6268 9264 6238 6115 6237 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $45620 r0 *1 719.04,619.92
X$45620 9264 6470 6342 6307 6344 6343 6120 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $45627 m0 *1 711.2,791.28
X$45627 9264 8070 9263 7298 7986 6121 8031 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $45629 r0 *1 712.88,740.88
X$45629 9264 7517 9263 7298 7485 6121 7312 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $45631 m0 *1 695.52,781.2
X$45631 9264 7753 9263 7298 7839 6121 7806 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $45634 r0 *1 358.96,771.12
X$45634 9264 9263 6121 7831 7830 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45636 m0 *1 600.32,791.28
X$45636 9263 7061 6121 9264 7967 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45638 r0 *1 436.24,710.64
X$45638 9264 7155 9263 7298 7208 6121 7134 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $45641 r0 *1 595.84,609.84
X$45641 9264 6216 6121 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $45643 r0 *1 613.2,720.72
X$45643 9263 7117 6121 9264 7299 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45669 r0 *1 418.88,771.12
X$45669 9264 7178 9263 7770 7786 6121 7740 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $45686 r0 *1 3.92,609.84
X$45686 6166 9263 9264 6126 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $45689 r0 *1 25.2,619.92
X$45689 6287 9263 9264 6127 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $45700 m0 *1 167.44,630
X$45700 9264 9263 6350 6132 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45703 r0 *1 182.56,609.84
X$45703 9264 9263 6170 6133 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45706 r0 *1 207.2,609.84
X$45706 9264 6323 6172 6135 6201 6134 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $45717 r0 *1 254.24,630
X$45717 9264 6137 6353 6458 6459 6422 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $45724 r0 *1 325.92,609.84
X$45724 9264 9263 6206 6138 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45737 r0 *1 502.88,609.84
X$45737 9264 9263 6187 6143 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45742 r0 *1 534.24,609.84
X$45742 9264 9263 6149 6145 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45751 r0 *1 486.08,619.92
X$45751 6146 9264 6213 9263 6297 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $45766 r0 *1 747.04,619.92
X$45766 9263 6339 6233 9264 6146 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45788 r0 *1 613.76,609.84
X$45788 9264 6152 6217 9263 6277 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45792 m0 *1 813.68,791.28
X$45792 7972 9264 9263 6153 7811 9286 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45794 m0 *1 810.32,761.04
X$45794 7524 9264 9263 6153 7681 9280 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45796 r0 *1 792.96,781.2
X$45796 7921 9264 9263 6153 7810 9312 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45798 r0 *1 782.32,771.12
X$45798 7834 9264 9263 6153 7809 9292 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45800 m0 *1 777.28,750.96
X$45800 7521 9264 9263 6153 7519 9277 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45802 m0 *1 806.96,619.92
X$45802 6153 9263 6235 6331 9264 6158 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $45805 m0 *1 815.92,630
X$45805 6311 9264 9263 6153 6377 9279 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45807 r0 *1 785.12,609.84
X$45807 6181 9264 9263 6153 6156 9318 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45810 m0 *1 768.88,740.88
X$45810 7429 9264 9263 6153 7457 9291 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45812 r0 *1 797.44,730.8
X$45812 7378 9264 9263 6153 7413 9296 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45815 m0 *1 761.04,720.72
X$45815 7320 9264 9263 6153 7239 9290 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45818 r0 *1 804.16,690.48
X$45818 7021 9264 9263 6153 6273 9295 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45821 r0 *1 817.04,690.48
X$45821 7122 9264 9263 6153 7073 9306 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45824 r0 *1 786.8,640.08
X$45824 6546 9264 9263 6153 6443 9317 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45827 r0 *1 787.92,619.92
X$45827 9264 6153 6236 9263 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $45830 r0 *1 770.56,680.4
X$45830 6939 9264 9263 6153 6890 9294 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45833 r0 *1 791.28,660.24
X$45833 6786 9264 9263 6153 6444 9316 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $45864 m0 *1 655.76,791.28
X$45864 9263 6154 6227 7948 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $45866 m0 *1 470.4,781.2
X$45866 9264 7934 9263 6154 7888 7790 7794 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $45868 r0 *1 605.36,761.04
X$45868 9264 7113 9263 7674 7675 6154 7723 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $45872 m0 *1 402.08,821.52
X$45872 9264 7267 9263 8275 8230 6154 8231 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $45874 m0 *1 403.76,801.36
X$45874 9264 8051 9263 8004 7995 6154 7996 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $45876 r0 *1 500.64,811.44
X$45876 9264 7794 9263 8175 8215 6154 8236 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $45879 r0 *1 633.92,730.8
X$45879 9263 7344 6154 9264 7437 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45881 r0 *1 628.88,700.56
X$45881 9264 7149 6154 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $45916 m0 *1 786.8,619.92
X$45916 9264 6269 6237 6236 6156 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $45918 m0 *1 771.12,680.4
X$45918 9264 9263 6962 6156 6890 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $45920 r0 *1 811.44,609.84
X$45920 9263 6158 6157 6159 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $45930 m0 *1 801.92,841.68
X$45930 9264 9263 6159 6788 8414 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $45933 m0 *1 813.68,851.76
X$45933 9264 9263 6159 7582 8411 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $45936 r0 *1 801.36,841.68
X$45936 9264 9263 6159 7641 8413 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $45938 m0 *1 803.6,851.76
X$45938 9264 9263 6159 7602 8445 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $45942 r0 *1 806.4,670.32
X$45942 9264 6159 6241 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $45956 m0 *1 866.88,710.64
X$45956 9264 9263 7185 7202 6161 7011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45958 r0 *1 636.72,670.32
X$45958 9264 6807 9263 6781 6832 6161 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $45960 r0 *1 724.64,660.24
X$45960 9264 6800 9263 6593 6681 6161 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $45975 m0 *1 847.84,680.4
X$45975 9264 9263 6850 6848 6161 6893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45978 m0 *1 834.4,660.24
X$45978 9264 9263 6642 6683 6161 6588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45984 r0 *1 627.76,740.88
X$45984 9264 7800 6161 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $45987 r0 *1 870.24,720.72
X$45987 9264 9263 7372 7371 6161 7245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45991 r0 *1 883.68,831.6
X$45991 9264 8344 6163 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $45994 r0 *1 910.56,761.04
X$45994 9264 9263 7590 7700 6163 7686 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46008 r0 *1 885.92,882
X$46008 9264 9263 8674 8649 6163 8457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46013 m0 *1 889.28,871.92
X$46013 9264 9263 8563 8564 6163 8498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46015 m0 *1 914.48,791.28
X$46015 9264 9263 7975 7976 6163 7820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46020 r0 *1 916.16,680.4
X$46020 9264 9263 6954 6955 6163 6896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46022 m0 *1 912.8,750.96
X$46022 9264 9263 7425 7538 6163 7311 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46031 m0 *1 971.6,630
X$46031 6316 9263 9264 6165 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $46033 r0 *1 212.8,781.2
X$46033 9264 9263 7878 7886 6813 6166 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46052 m0 *1 210.56,630
X$46052 9264 9263 6392 6169 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46094 m0 *1 415.52,619.92
X$46094 9264 6360 6211 6180 6212 6266 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $46099 r0 *1 795.76,609.84
X$46099 9264 9263 6181 6268 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46108 m0 *1 750.4,619.92
X$46108 9263 6275 6183 9264 6276 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46151 r0 *1 211.12,710.64
X$46151 9264 9263 7193 7217 6813 6192 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46154 r0 *1 139.44,609.84
X$46154 9264 9263 6193 6252 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46157 m0 *1 146.16,630
X$46157 6193 9264 9263 6452 6390 6282 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $46161 m0 *1 147.28,619.92
X$46161 9264 9263 6195 6194 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46166 m0 *1 170.8,619.92
X$46166 9264 9263 6254 6196 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46168 m0 *1 177.52,619.92
X$46168 9264 6322 6254 6255 6198 6197 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $46174 r0 *1 188.72,630
X$46174 9264 9263 6529 6198 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46176 r0 *1 202.72,630
X$46176 9264 9263 6456 6199 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46187 m0 *1 203.84,640.08
X$46187 9264 6200 6562 6507 6563 6508 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $46190 m0 *1 220.64,619.92
X$46190 9264 9263 6284 6201 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46192 m0 *1 295.12,619.92
X$46192 9264 9263 6328 6202 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46204 r0 *1 355.04,619.92
X$46204 6402 9264 9263 6333 6204 6332 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $46210 m0 *1 321.44,619.92
X$46210 9264 9263 6205 6329 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46212 m0 *1 350.56,630
X$46212 6205 9264 6402 9263 6334 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $46220 r0 *1 320.32,619.92
X$46220 9264 6329 6206 6330 6289 6288 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $46225 r0 *1 339.36,619.92
X$46225 9264 9263 6290 6208 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46232 r0 *1 344.96,630
X$46232 9264 6357 6209 6464 6479 6292 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $46262 r0 *1 629.44,630
X$46262 9264 9263 6435 6219 6436 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46267 r0 *1 377.44,720.72
X$46267 9264 6291 7327 6220 7289 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $46302 r0 *1 413.84,650.16
X$46302 9264 6471 6220 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $46306 m0 *1 658,619.92
X$46306 9263 6221 9264 6222 6278 6224 6220 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $46341 r0 *1 622.72,750.96
X$46341 9264 9263 7344 6227 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $46344 r0 *1 557.76,781.2
X$46344 9263 7405 6227 7841 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $46346 m0 *1 483.84,761.04
X$46346 9263 9264 7405 6347 6227 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $46351 r0 *1 619.36,730.8
X$46351 9264 6227 7114 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $46368 m0 *1 479.36,781.2
X$46368 9264 9263 7708 7888 6227 7936 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46371 r0 *1 559.44,690.48
X$46371 9264 9263 7027 7030 6227 6998 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46375 r0 *1 778.4,619.92
X$46375 6235 9264 9263 6228 6491 6406 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $46381 r0 *1 776.16,630
X$46381 6377 6228 6443 6444 9263 9264 6461 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $46384 m0 *1 697.76,619.92
X$46384 9263 6280 6346 9264 6228 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46386 r0 *1 752.08,811.44
X$46386 9264 8208 9263 6412 8210 8279 6229 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $46389 m0 *1 487.2,801.36
X$46389 9264 8037 9263 7518 7959 8057 6229 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $46391 r0 *1 748.16,781.2
X$46391 9264 7862 9263 6465 7861 7916 6229 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $46393 r0 *1 405.44,801.36
X$46393 9264 8051 9263 6465 8105 8054 6229 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $46395 m0 *1 557.2,650.16
X$46395 9264 6229 6374 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $46397 r0 *1 578.48,670.32
X$46397 9264 9263 6229 6717 6775 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46401 m0 *1 655.2,650.16
X$46401 9264 6438 6229 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $46434 r0 *1 583.52,670.32
X$46434 9263 6440 9264 6827 6808 6229 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $46446 m0 *1 720.16,791.28
X$46446 9264 9263 7933 7969 6231 7986 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46448 r0 *1 365.12,781.2
X$46448 9264 7268 9263 7897 7852 7783 6231 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $46451 r0 *1 733.6,680.4
X$46451 9264 9263 6231 6907 6938 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46453 r0 *1 649.04,720.72
X$46453 9264 7056 6231 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $46485 r0 *1 722.96,740.88
X$46485 9264 9263 7482 7484 6231 7485 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46487 r0 *1 700,771.12
X$46487 9264 9263 7754 7837 6231 7839 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46489 r0 *1 515.76,781.2
X$46489 9264 6231 7907 9263 7938 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $46492 m0 *1 352.8,670.32
X$46492 9264 6231 6754 9263 6736 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $46500 m0 *1 759.92,630
X$46500 9264 6440 9263 6234 6411 6410 6374 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $46507 m0 *1 812.56,771.12
X$46507 7757 9264 9263 6236 7681 7682 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $46509 r0 *1 811.44,630
X$46509 9264 6447 6457 6236 6377 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46511 r0 *1 809.2,710.64
X$46511 7243 9264 9263 6236 7073 7244 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $46513 r0 *1 806.96,730.8
X$46513 9264 7416 7350 6236 7413 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46516 m0 *1 805.84,700.56
X$46516 9264 6236 7071 7073 7072 7307 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $46540 r0 *1 766.64,690.48
X$46540 9264 7068 7006 6236 6890 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46542 r0 *1 799.68,700.56
X$46542 9264 6236 7123 6905 7142 7306 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $46545 r0 *1 768.32,740.88
X$46545 9264 7460 7458 6236 7457 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46547 r0 *1 766.64,710.64
X$46547 9264 7181 7240 6236 7239 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46549 m0 *1 786.8,640.08
X$46549 9264 6519 6547 6236 6443 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46551 m0 *1 776.72,660.24
X$46551 9264 6658 6682 6236 6444 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46553 m0 *1 800.24,801.36
X$46553 9264 8013 8128 6236 7810 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46556 m0 *1 782.88,801.36
X$46556 9264 8012 7816 6236 7809 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46559 r0 *1 814.8,791.28
X$46559 9264 8015 7818 6236 7811 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46561 m0 *1 774.48,761.04
X$46561 9264 7581 7640 6236 7519 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $46564 m0 *1 799.68,619.92
X$46564 9264 6269 9263 6270 6310 6237 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $46568 m0 *1 813.12,619.92
X$46568 9263 6237 6240 9264 6242 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $46574 r0 *1 805.84,619.92
X$46574 9264 6311 9263 6238 6312 6381 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $46586 m0 *1 808.64,630
X$46586 9264 6311 9263 6240 6405 6381 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $46589 m0 *1 830.48,761.04
X$46589 9264 9263 6241 7584 7683 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $46591 r0 *1 827.12,781.2
X$46591 9264 9263 6241 7418 7922 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $46594 r0 *1 806.4,660.24
X$46594 9264 9263 6241 6726 6634 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $46600 m0 *1 805.28,710.64
X$46600 9264 9263 6241 7183 6892 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $46612 r0 *1 829.36,730.8
X$46612 9264 9263 6241 7351 7356 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $46615 r0 *1 825.44,700.56
X$46615 9264 9263 6241 7123 6947 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $46617 m0 *1 824.32,791.28
X$46617 9264 9263 6241 7601 8195 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $46624 r0 *1 822.64,619.92
X$46624 9264 6331 6242 9263 6243 6403 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $46627 r0 *1 813.12,619.92
X$46627 9263 6381 6312 9264 6243 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $46634 m0 *1 873.6,821.52
X$46634 9264 9263 8271 7922 6245 7918 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46636 r0 *1 846.16,791.28
X$46636 9264 7948 6245 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $46639 m0 *1 875.28,710.64
X$46639 9264 9263 7202 6947 6245 6887 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46659 m0 *1 865.2,892.08
X$46659 9264 9263 8671 8195 6245 8279 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46662 m0 *1 873.6,892.08
X$46662 9264 9263 8672 8411 6245 8187 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46667 m0 *1 864.08,811.44
X$46667 9264 9263 8204 7683 6245 7591 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46670 m0 *1 869.12,730.8
X$46670 9264 9263 7371 7356 6245 7253 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46682 m0 *1 753.76,640.08
X$46682 9264 6274 9263 6465 6523 6544 6249 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $46738 m0 *1 366.24,619.92
X$46738 9264 9263 6332 6261 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46746 r0 *1 371.28,630
X$46746 9264 6263 6462 6358 6515 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $46752 m0 *1 383.6,630
X$46752 9264 6358 6359 6264 6337 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $46754 m0 *1 432.32,630
X$46754 9264 6265 6293 6296 6408 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $46789 r0 *1 801.36,680.4
X$46789 9264 9263 6273 6904 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46797 m0 *1 772.8,690.48
X$46797 9264 6545 6940 6905 6273 9263 6962 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $46809 m0 *1 486.08,630
X$46809 9263 6362 6276 9264 6409 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46825 m0 *1 673.68,630
X$46825 9264 6373 6279 9263 6306 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $46833 r0 *1 24.64,630
X$46833 6451 9263 9264 6281 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $46838 m0 *1 158.48,630
X$46838 9264 9263 6349 6283 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46841 m0 *1 222.32,630
X$46841 6284 9264 9263 6393 6351 6392 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $46849 m0 *1 490.56,650.16
X$46849 9264 9263 6285 6534 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46851 r0 *1 574.56,650.16
X$46851 9264 6285 6584 6471 6629 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $46864 r0 *1 244.72,619.92
X$46864 9264 9263 6286 6323 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46867 m0 *1 324.24,660.24
X$46867 9264 9263 6620 6622 6866 6287 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46873 m0 *1 310.24,630
X$46873 9264 9263 6398 6288 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46904 m0 *1 346.64,630
X$46904 9264 9263 6399 6292 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46917 r0 *1 512.96,791.28
X$46917 9264 6295 7961 6471 8216 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $46920 m0 *1 463.68,630
X$46920 9263 6362 6295 9264 6408 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46926 m0 *1 437.36,640.08
X$46926 9264 6518 6570 6533 6296 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $46931 r0 *1 505.68,619.92
X$46931 9263 6341 6298 9264 6340 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $46933 m0 *1 495.04,630
X$46933 9264 6364 6409 6298 6365 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $46936 r0 *1 544.32,630
X$46936 9264 6345 6429 6299 6468 9263 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $46940 m0 *1 585.2,710.64
X$46940 9264 9263 7061 7171 6301 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46957 m0 *1 469.28,942.48
X$46957 9264 9263 8922 6301 6664 8902 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46981 r0 *1 388.64,650.16
X$46981 9264 6307 6580 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $46984 m0 *1 512.96,811.44
X$46984 9264 8216 8160 6307 6344 8161 8176 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $46986 m0 *1 364.56,811.44
X$46986 9263 6307 8226 9264 8143 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46989 r0 *1 571.76,660.24
X$46989 9264 6629 6715 6307 6344 6716 6810 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $47007 r0 *1 651.28,801.36
X$47007 9263 9264 6465 8065 6307 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $47010 m0 *1 705.6,710.64
X$47010 9264 9263 7145 7090 6307 7128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47014 r0 *1 408.8,811.44
X$47014 9264 6378 9263 8154 8231 6307 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47017 r0 *1 367.92,811.44
X$47017 9264 9263 8145 8227 6307 8228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47026 m0 *1 627.2,750.96
X$47026 9264 7453 6308 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $47028 r0 *1 678.72,771.12
X$47028 9263 6308 7805 9264 7751 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47030 r0 *1 711.2,680.4
X$47030 9264 6910 6968 6308 6344 6937 6884 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $47032 r0 *1 729.68,761.04
X$47032 9264 6308 9263 7714 7651 7712 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47034 m0 *1 588,750.96
X$47034 9264 6308 9263 7576 7550 7516 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47036 m0 *1 586.88,771.12
X$47036 9264 6308 9263 7780 7746 7735 7745 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47038 r0 *1 728.56,831.6
X$47038 9264 8251 6414 8339 8336 6308 8337 8338 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $47061 r0 *1 700.56,740.88
X$47061 9264 6308 7489 9263 7454 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $47063 r0 *1 771.12,630
X$47063 9263 6379 6309 9264 6443 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47067 r0 *1 803.04,630
X$47067 9264 9263 6460 6310 6448 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47082 m0 *1 799.68,650.16
X$47082 9263 6548 9264 6596 6312 6547 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $47126 m0 *1 804.72,690.48
X$47126 9264 6313 9263 gf180mcu_fd_sc_mcu9t5v0__inv_12
* cell instance $47140 m0 *1 929.6,660.24
X$47140 9264 9263 6315 9273 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $47199 r0 *1 963.76,630
X$47199 6385 9263 9264 6318 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $47202 m0 *1 980.56,630
X$47202 6386 9263 9264 6319 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $47206 r0 *1 165.76,619.92
X$47206 9264 9263 6321 6320 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47212 r0 *1 168.56,630
X$47212 6350 9264 9263 6453 6502 6321 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $47214 m0 *1 202.16,630
X$47214 9264 9263 6391 6322 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47227 m0 *1 266,630
X$47227 9264 9263 6397 6325 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47230 r0 *1 282.24,619.92
X$47230 9264 9263 6356 6326 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47244 m0 *1 293.44,630
X$47244 9264 6355 6398 6399 6354 6328 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $47261 r0 *1 381.36,619.92
X$47261 9264 9263 6335 6333 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47286 r0 *1 747.04,630
X$47286 9263 9264 6441 6440 6523 6378 6339 6411
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $47301 m0 *1 721.84,640.08
X$47301 9264 6378 9263 6343 6375 6524 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47314 r0 *1 535.92,670.32
X$47314 9264 9263 6344 6771 6853 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47317 r0 *1 687.68,700.56
X$47317 9264 7176 9263 6344 7120 7145 6765 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47319 m0 *1 631.68,700.56
X$47319 9263 6489 6543 6344 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $47371 r0 *1 475.44,761.04
X$47371 9263 7708 9264 6347 6873 7670 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $47373 r0 *1 534.24,690.48
X$47373 9263 7027 9264 7054 6347 6928 6743 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $47377 r0 *1 614.32,750.96
X$47377 9264 7629 6347 9263 7612 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $47385 m0 *1 600.32,750.96
X$47385 9263 6544 6777 6348 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $47388 r0 *1 594.72,630
X$47388 9264 6348 6471 9263 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $47409 r0 *1 226.8,630
X$47409 6351 9264 9263 6354 6509 6506 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $47411 m0 *1 236.88,640.08
X$47411 9264 6352 6393 6395 6478 6477 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $47422 r0 *1 302.4,640.08
X$47422 9264 6356 6479 6564 6352 6355 9263 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $47425 m0 *1 251.44,630
X$47425 9264 9263 6353 6394 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47465 r0 *1 458.64,630
X$47465 9263 6361 6520 9264 6407 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $47476 m0 *1 465.92,640.08
X$47476 9264 6362 6521 6482 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $47478 r0 *1 493.36,630
X$47478 9263 6428 6363 9264 6364 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47482 m0 *1 483.28,640.08
X$47482 9263 6427 6363 9264 6520 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47501 m0 *1 502.88,680.4
X$47501 9264 9263 6991 6874 6370 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $47506 m0 *1 646.24,630
X$47506 9264 6370 9263 6371 6415 6372 6488 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47518 m0 *1 643.44,670.32
X$47518 9263 6782 6370 9264 6857 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47546 m0 *1 529.2,821.52
X$47546 9264 9263 6374 8282 8239 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47551 m0 *1 537.6,680.4
X$47551 9264 6440 9263 6906 6772 6825 6374 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47555 r0 *1 632.8,720.72
X$47555 9264 6374 6720 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $47577 r0 *1 535.92,680.4
X$47577 9264 6374 6932 9263 6906 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $47580 m0 *1 535.36,811.44
X$47580 9263 6440 9264 8177 8162 6374 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $47587 m0 *1 728.56,791.28
X$47587 9264 7933 9263 7914 7239 6376 7971 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47589 r0 *1 379.12,650.16
X$47589 9264 6610 9263 6611 6376 6621 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47591 m0 *1 380.24,730.8
X$47591 9264 9263 7327 7222 6376 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47593 r0 *1 731.92,720.72
X$47593 9264 6525 6376 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $47596 m0 *1 689.92,801.36
X$47596 9264 8068 9263 8034 7809 6376 8008 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47598 m0 *1 740.32,801.36
X$47598 9264 8191 9263 7519 6376 8075 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47601 r0 *1 528.64,771.12
X$47601 9264 7892 9263 6925 6376 7842 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47604 m0 *1 719.04,660.24
X$47604 9264 6680 9263 6444 6376 6635 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47633 m0 *1 701.12,761.04
X$47633 9264 7754 9263 7776 7457 6376 7607 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47635 r0 *1 709.52,690.48
X$47635 9264 7089 9263 7033 6890 6376 7002 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47651 m0 *1 422.24,660.24
X$47651 9264 6378 6625 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $47654 m0 *1 456.96,660.24
X$47654 9264 6543 6378 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $47659 r0 *1 527.52,801.36
X$47659 9264 6378 9263 8161 8282 8162 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47661 m0 *1 730.8,811.44
X$47661 9264 9263 6378 8126 8251 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47696 m0 *1 825.44,630
X$47696 9264 9263 6457 6381 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47711 m0 *1 938.56,630
X$47711 9264 9263 6389 6383 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $47714 r0 *1 899.36,660.24
X$47714 9264 9263 6645 6685 6839 6383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47720 m0 *1 743.12,670.32
X$47720 9264 9263 6799 6783 7067 6383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47724 r0 *1 676.48,670.32
X$47724 9264 9263 6806 6804 6913 6383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47740 m0 *1 897.12,670.32
X$47740 9264 9263 6686 6730 7187 6383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47743 r0 *1 948.08,630
X$47743 9264 9263 6384 6410 6554 6385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47759 r0 *1 980.56,630
X$47759 6499 9263 9264 6387 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $47762 r0 *1 959.84,640.08
X$47762 6497 9263 9264 6388 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $47771 r0 *1 211.12,630
X$47771 6456 9264 9263 6506 6507 6391 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $47820 m0 *1 813.68,670.32
X$47820 6788 6797 6641 6726 9264 9263 6403 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $47825 m0 *1 328.16,640.08
X$47825 9264 6512 6404 6481 6565 6514 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $47827 r0 *1 801.36,640.08
X$47827 9263 6548 9264 6549 6405 6547 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $47849 m0 *1 771.12,640.08
X$47849 9264 9263 6410 6463 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47874 r0 *1 647.36,811.44
X$47874 9264 6544 9263 8063 6412 8185 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47876 r0 *1 710.08,801.36
X$47876 9264 6544 9263 8069 6412 8070 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47879 m0 *1 651.28,801.36
X$47879 9263 9264 6412 8064 6765 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $47881 r0 *1 648.48,791.28
X$47881 9264 7518 6412 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $47883 r0 *1 680.4,811.44
X$47883 9264 8247 9263 6412 8186 8187 6720 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47885 m0 *1 393.68,801.36
X$47885 9263 7996 6412 9264 8028 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47888 m0 *1 378.56,750.96
X$47888 9264 6544 9263 7544 6412 7392 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47891 m0 *1 369.6,791.28
X$47891 9264 7945 9263 6412 7980 7899 6720 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47928 m0 *1 554.4,700.56
X$47928 9264 9263 7059 7060 6414 7055 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47956 r0 *1 504,821.52
X$47956 9264 9263 8160 8237 6414 8287 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47959 m0 *1 685.44,761.04
X$47959 9264 7631 9263 7632 7633 6414 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47961 r0 *1 540.96,670.32
X$47961 9264 9263 6853 6824 6414 6774 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47964 r0 *1 545.44,791.28
X$47964 9264 9263 7964 7942 6414 7907 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47980 r0 *1 2.24,640.08
X$47980 6556 9263 9264 6418 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $47982 r0 *1 155.68,630
X$47982 9264 9263 6419 6452 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47987 r0 *1 192.08,630
X$47987 6528 9264 9263 6455 6561 6419 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $47991 m0 *1 163.52,640.08
X$47991 9264 9263 6501 6420 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47996 r0 *1 456.4,761.04
X$47996 9263 7707 7669 6421 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $48026 r0 *1 487.2,781.2
X$48026 9263 7906 7937 6426 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $48036 m0 *1 493.92,640.08
X$48036 9263 6427 6534 9264 6522 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48043 m0 *1 496.16,650.16
X$48043 9264 6427 6521 6535 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $48045 r0 *1 491.68,640.08
X$48045 9264 9263 6428 6570 6534 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48052 m0 *1 518,640.08
X$48052 9264 6428 6521 6536 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $48066 r0 *1 576.8,640.08
X$48066 9264 6433 6434 9263 6572 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $48077 m0 *1 499.52,680.4
X$48077 9264 9263 6435 6874 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48079 m0 *1 484.96,670.32
X$48079 9264 6435 6674 6822 6742 9263 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $48082 r0 *1 629.44,670.32
X$48082 6435 6833 6782 6436 9264 9263 6807 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $48103 m0 *1 454.72,690.48
X$48103 9263 6964 6436 7022 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $48105 m0 *1 465.92,710.64
X$48105 9264 9263 7160 6436 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48111 r0 *1 518,740.88
X$48111 9263 6436 7488 9264 7447 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48141 r0 *1 600.32,750.96
X$48141 9263 6436 7608 9264 7664 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48144 r0 *1 640.08,640.08
X$48144 9264 6437 6541 9263 6575 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $48146 r0 *1 668.08,761.04
X$48146 9263 6438 7453 7667 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $48148 r0 *1 700,750.96
X$48148 9263 7628 6438 6833 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $48151 r0 *1 710.08,640.08
X$48151 9264 9263 6438 6577 6498 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48155 r0 *1 672,640.08
X$48155 9263 6543 6438 9264 6490 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48161 r0 *1 663.6,720.72
X$48161 9263 6489 6438 9264 7300 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48177 m0 *1 631.68,771.12
X$48177 9264 6438 7749 9263 7782 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $48181 m0 *1 707.84,640.08
X$48181 9264 6543 9263 6576 6577 6439 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48184 r0 *1 618.24,761.04
X$48184 9263 9264 7724 6543 7725 6440 7726 7781
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $48190 r0 *1 641.76,710.64
X$48190 9264 6440 6755 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $48192 m0 *1 650.72,640.08
X$48192 9264 6489 6440 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $48213 r0 *1 688.24,761.04
X$48213 9263 6777 9264 7717 7752 7719 6440 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $48222 r0 *1 760.48,640.08
X$48222 9264 9263 6573 6442 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48239 m0 *1 778.96,730.8
X$48239 7346 6445 7382 9264 9263 7379 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $48242 r0 *1 786.8,630
X$48242 9264 9263 6445 6446 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $48245 r0 *1 789.04,821.52
X$48245 8254 9263 6446 8255 9264 8317 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $48247 m0 *1 832.72,801.36
X$48247 9263 6446 8027 9264 7871 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48249 r0 *1 798,821.52
X$48249 9263 6446 8298 9264 8299 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48251 m0 *1 810.32,821.52
X$48251 8193 9263 6446 8194 9264 8256 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $48256 m0 *1 826.56,700.56
X$48256 9263 7084 6446 9264 7011 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48259 r0 *1 783.44,670.32
X$48259 6798 9263 6446 6785 9264 6588 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $48274 m0 *1 789.6,831.6
X$48274 9263 6446 7813 9264 8340 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48276 r0 *1 834.4,761.04
X$48276 9263 6446 7703 9264 7684 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48279 r0 *1 808.08,630
X$48279 9264 9263 6447 6460 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48287 r0 *1 816.48,640.08
X$48287 9264 9263 6457 6448 6493 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48291 m0 *1 820.96,640.08
X$48291 9264 6457 6493 9263 6449 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $48295 r0 *1 288.4,650.16
X$48295 9264 9263 6651 6618 6666 6451 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $48310 r0 *1 179.76,630
X$48310 9264 9263 6454 6453 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48316 r0 *1 189.84,640.08
X$48316 6529 9264 9263 6562 6530 6454 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $48351 m0 *1 778.96,640.08
X$48351 9264 6461 6545 9263 6491 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $48369 r0 *1 642.32,740.88
X$48369 9264 7435 6465 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $48371 m0 *1 683.2,801.36
X$48371 9263 8009 6465 9264 8067 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48374 m0 *1 362.32,771.12
X$48374 9264 6466 9263 7733 6465 7731 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48378 m0 *1 736.96,811.44
X$48378 9264 6466 9263 8212 6465 8127 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48380 r0 *1 367.36,700.56
X$48380 9264 6465 9263 7086 7141 6833 7101 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $48382 r0 *1 366.24,740.88
X$48382 9263 9264 6465 7493 6755 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $48422 m0 *1 491.68,791.28
X$48422 9264 6466 9263 7987 7435 7994 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48431 r0 *1 682.08,801.36
X$48431 9263 6755 9264 8067 8098 6466 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $48496 r0 *1 30.24,640.08
X$48496 9264 9263 6473 6558 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48499 r0 *1 10.64,640.08
X$48499 9264 9263 6474 6557 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48502 m0 *1 170.24,640.08
X$48502 9264 9263 6475 6502 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48504 m0 *1 173.6,640.08
X$48504 6475 9264 9263 6503 6560 6501 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $48520 m0 *1 324.8,640.08
X$48520 9264 9263 6480 6512 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48524 r0 *1 339.92,640.08
X$48524 9264 9263 6513 6481 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48549 r0 *1 557.76,710.64
X$48549 9264 6485 9263 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $48583 m0 *1 557.76,720.72
X$48583 9264 6757 6485 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $48586 r0 *1 600.88,650.16
X$48586 9264 6585 6486 9263 6539 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $48603 r0 *1 607.6,710.64
X$48603 9263 7234 6488 9264 7116 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48615 r0 *1 613.76,972.72
X$48615 9264 9263 9137 6488 6666 9040 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $48626 r0 *1 700,761.04
X$48626 9263 6489 7716 9264 7717 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48647 r0 *1 660.8,740.88
X$48647 9264 9263 7453 6489 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $48655 r0 *1 434,700.56
X$48655 9264 7134 9263 6490 7143 6538 7155 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $48663 m0 *1 613.76,771.12
X$48663 9264 7797 9263 6490 7781 6538 7748 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $48671 m0 *1 807.52,650.16
X$48671 9264 9263 6492 6493 6613 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48673 r0 *1 811.44,640.08
X$48673 9264 9263 6492 6517 6597 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48678 m0 *1 801.92,640.08
X$48678 9264 9263 6519 6492 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48704 r0 *1 947.52,640.08
X$48704 9264 9263 6496 6551 6554 6497 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $48712 m0 *1 726.88,660.24
X$48712 9264 9263 6681 6637 6678 6498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $48733 m0 *1 962.08,650.16
X$48733 6505 9263 9264 6500 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $48825 m0 *1 380.8,670.32
X$48825 9264 6521 9263 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $48828 m0 *1 479.36,660.24
X$48828 9264 6674 6521 6628 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $48868 r0 *1 380.8,660.24
X$48868 9264 6757 6521 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $48883 r0 *1 659.12,781.2
X$48883 9264 7841 6525 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $48886 m0 *1 389.76,710.64
X$48886 9264 7205 9263 7204 7088 6525 7043 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $48889 m0 *1 433.44,791.28
X$48889 9264 7956 9263 7955 7397 6525 7901 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $48891 m0 *1 750.96,761.04
X$48891 9264 7710 9263 7681 6525 7638 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48893 r0 *1 614.88,781.2
X$48893 9264 7399 7912 6525 7991 9263 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $48895 r0 *1 402.64,781.2
X$48895 9264 7950 9263 7396 6525 7898 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48897 m0 *1 394.8,781.2
X$48897 9264 9263 7737 7853 6525 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48899 r0 *1 575.12,740.88
X$48899 9264 7573 9263 7398 6525 7449 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48901 r0 *1 742,730.8
X$48901 9264 7482 9263 7430 7413 6525 7345 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $48929 m0 *1 10.64,650.16
X$48929 6609 9263 9264 6527 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $48931 r0 *1 185.92,640.08
X$48931 9264 9263 6528 6560 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48951 m0 *1 512.96,650.16
X$48951 9264 9263 6535 6582 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48959 m0 *1 519.68,650.16
X$48959 9264 6582 6536 9263 6583 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $49006 m0 *1 581.28,670.32
X$49006 9264 6543 9263 6716 6717 6808 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $49011 m0 *1 652.96,730.8
X$49011 9264 7237 6543 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $49014 r0 *1 720.16,690.48
X$49014 9264 6543 9263 6937 7028 7065 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $49049 m0 *1 678.72,771.12
X$49049 9264 9263 7633 7751 6543 7778 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49051 r0 *1 669.2,811.44
X$49051 9263 9264 6544 8073 6625 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $49054 m0 *1 662.48,750.96
X$49054 9264 7300 6544 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $49057 r0 *1 730.24,771.12
X$49057 9264 6544 9263 7807 7518 7812 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $49059 m0 *1 604.8,771.12
X$49059 9264 7911 9263 7435 7725 6544 7799 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $49095 r0 *1 710.64,730.8
X$49095 9263 6777 9264 7410 7433 6544 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $49100 r0 *1 783.44,640.08
X$49100 9264 9263 6546 6548 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $49103 m0 *1 805.84,660.24
X$49103 9263 6547 6549 9264 6641 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $49105 r0 *1 803.04,650.16
X$49105 9264 9263 6547 6597 6640 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49114 r0 *1 808.08,650.16
X$49114 9264 6547 6640 9263 6612 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $49120 r0 *1 792.4,650.16
X$49120 9263 6547 9264 6639 6613 6658 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $49128 r0 *1 789.6,670.32
X$49128 9264 6786 9263 6549 6943 6725 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $49138 r0 *1 834.96,660.24
X$49138 9264 9263 6683 6634 6678 6551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49158 m0 *1 858.48,972.72
X$49158 9264 9263 9105 8187 6554 9104 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49160 m0 *1 943.04,831.6
X$49160 9264 8261 6554 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $49163 r0 *1 948.08,680.4
X$49163 9264 9263 6948 6844 6554 6949 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49169 r0 *1 842.24,962.64
X$49169 9264 9263 9062 7970 6554 9103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49172 r0 *1 850.64,962.64
X$49172 9264 9263 9063 8279 6554 9167 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49175 r0 *1 823.76,962.64
X$49175 9264 9263 9061 7752 6554 9102 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49177 m0 *1 823.2,962.64
X$49177 9264 9263 9011 8250 6554 9012 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49181 r0 *1 948.08,660.24
X$49181 9264 9263 6689 6687 6554 6648 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49183 m0 *1 948.08,801.36
X$49183 9264 9263 8090 7918 6554 8022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49187 m0 *1 285.6,660.24
X$49187 9264 9263 6652 6623 6666 6556 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49197 m0 *1 287.28,690.48
X$49197 9264 9263 6861 6978 6913 6557 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49199 m0 *1 250.32,720.72
X$49199 9264 9263 7276 7277 7325 6557 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49202 m0 *1 257.04,710.64
X$49202 9264 9263 7196 7197 7037 6557 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49205 m0 *1 327.04,761.04
X$49205 9264 9263 7617 7646 7542 6557 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49207 m0 *1 320.88,740.88
X$49207 9264 9263 7391 7478 7219 6557 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49209 r0 *1 301.28,750.96
X$49209 9264 9263 7557 7556 7496 6557 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49226 r0 *1 249.76,761.04
X$49226 9264 9263 7696 7697 7555 6557 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49230 r0 *1 319.76,710.64
X$49230 9264 9263 7201 7256 7219 6558 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49232 r0 *1 254.8,690.48
X$49232 9264 9263 6975 7014 7037 6558 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49234 m0 *1 278.32,740.88
X$49234 9264 9263 7388 7475 7496 6558 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49236 m0 *1 248.08,730.8
X$49236 9264 9263 7364 7365 7325 6558 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49238 r0 *1 301.28,680.4
X$49238 9264 9263 6863 6917 6913 6558 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49241 m0 *1 343.84,750.96
X$49241 9264 9263 7501 7541 7542 6558 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49256 m0 *1 246.96,750.96
X$49256 9264 9263 7534 7536 7555 6558 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49277 r0 *1 328.72,640.08
X$49277 9264 9263 6564 6565 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $49330 m0 *1 2.24,650.16
X$49330 6579 9263 9264 6578 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $49333 m0 *1 220.64,690.48
X$49333 9264 9263 6952 6953 6859 6579 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49347 r0 *1 364,771.12
X$49347 9263 9264 7733 6580 7832 6625 7734 7980
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $49350 r0 *1 452.48,771.12
X$49350 9263 9264 7788 6765 7838 6580 7669 7789
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $49352 m0 *1 451.36,781.2
X$49352 9264 6580 9263 7885 7788 7735 7855 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $49372 r0 *1 689.92,660.24
X$49372 6580 9264 6720 6603 9263 6721 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $49375 m0 *1 683.76,680.4
X$49375 9264 6881 6625 9263 6580 6854 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $49377 r0 *1 350,690.48
X$49377 9264 9263 7086 6750 6580 6706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49379 r0 *1 366.8,670.32
X$49379 6580 9264 6720 6753 9263 6756 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $49402 r0 *1 716.8,781.2
X$49402 9264 6586 9263 8011 7914 6678 7970 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $49404 m0 *1 650.72,791.28
X$49404 9263 7117 6586 9264 7913 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $49407 r0 *1 632.8,750.96
X$49407 9263 7113 7344 6586 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $49411 r0 *1 733.04,730.8
X$49411 9264 6586 9263 7431 7430 6678 7253 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $49413 m0 *1 687.12,771.12
X$49413 9264 6586 9263 7779 7776 6678 7752 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $49415 r0 *1 594.16,781.2
X$49415 9263 7061 6586 9264 7939 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $49417 r0 *1 380.8,700.56
X$49417 9264 6586 9263 7139 7204 6678 7101 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $49421 r0 *1 702.24,650.16
X$49421 9264 9263 6586 6659 6803 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49465 r0 *1 682.08,730.8
X$49465 9264 7490 6914 6589 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $49519 m0 *1 791.28,670.32
X$49519 9264 6786 9263 6596 6787 6725 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $49547 r0 *1 934.64,650.16
X$49547 9264 9263 6646 6599 6794 6647 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49576 m0 *1 980.56,650.16
X$49576 6604 9263 9264 6607 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $49579 r0 *1 980.56,660.24
X$49579 6647 9263 9264 6605 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $49582 r0 *1 978.88,650.16
X$49582 6648 9263 9264 6606 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $49586 m0 *1 946.4,650.16
X$49586 9264 9263 6608 6837 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $49589 r0 *1 328.72,660.24
X$49589 9264 9263 6733 6706 6866 6609 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49601 r0 *1 415.52,660.24
X$49601 6671 9264 9263 6674 6611 9314 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $49610 m0 *1 468.72,690.48
X$49610 6926 6925 6611 6965 9263 9264 6966 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $49612 r0 *1 386.96,670.32
X$49612 9264 6817 6763 6759 6611 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $49626 r0 *1 691.6,650.16
X$49626 9264 9263 6625 6661 6615 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49632 m0 *1 14.56,660.24
X$49632 6693 9263 9264 6616 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $49638 m0 *1 292.32,710.64
X$49638 9264 9263 7098 7100 7040 6618 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49650 r0 *1 284.48,680.4
X$49650 9264 9263 6814 6618 6862 6861 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49652 r0 *1 245.28,740.88
X$49652 9264 9263 7471 7534 7450 6619 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49654 r0 *1 263.2,740.88
X$49654 9264 9263 7537 6918 7448 6619 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49676 r0 *1 304.64,660.24
X$49676 9264 9263 6749 6621 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $49683 m0 *1 321.44,680.4
X$49683 9264 9263 6815 6864 6865 6622 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49693 m0 *1 329.84,690.48
X$49693 9264 9263 6957 6918 7019 6622 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49698 m0 *1 306.32,690.48
X$49698 9264 9263 7018 6918 7040 6623 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49710 m0 *1 295.12,680.4
X$49710 9264 9263 6751 6623 6862 6863 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49718 r0 *1 366.8,650.16
X$49718 9264 9263 6625 6624 6656 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49731 m0 *1 535.36,801.36
X$49731 9264 9263 6625 7858 8038 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49734 m0 *1 539.84,670.32
X$49734 9263 9264 6772 6625 6771 6755 6744 6773
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $49758 m0 *1 682.08,821.52
X$49758 9264 6625 8186 9263 8283 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $49760 m0 *1 369.6,811.44
X$49760 9264 9263 7946 8143 6625 8145 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49763 m0 *1 409.92,670.32
X$49763 9263 6626 9264 6710 6818 6763 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $49765 r0 *1 409.36,670.32
X$49765 9263 6626 9264 6819 6963 6763 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $49767 m0 *1 411.6,660.24
X$49767 9264 9263 6671 6626 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $49771 m0 *1 471.52,660.24
X$49771 9264 9263 6673 6627 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $49773 m0 *1 460.88,670.32
X$49773 9264 6740 9263 6801 6742 6627 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $49780 m0 *1 590.8,700.56
X$49780 9264 9263 6630 7112 7114 7063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49785 m0 *1 653.52,720.72
X$49785 9264 7237 6914 6632 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $49817 r0 *1 683.76,660.24
X$49817 9264 9263 6718 6635 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $49820 m0 *1 711.76,660.24
X$49820 6660 6636 6659 6679 9264 9263 6680 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $49828 m0 *1 788.48,660.24
X$49828 9263 6682 6724 9264 6639 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $49832 r0 *1 779.52,660.24
X$49832 9263 6723 9264 6738 6640 6725 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $49904 r0 *1 776.16,660.24
X$49904 9264 9263 6658 6723 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $49933 r0 *1 243.6,720.72
X$49933 9264 6757 6663 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $49982 r0 *1 246.4,710.64
X$49982 9264 9263 6663 9274 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $49989 m0 *1 292.88,942.48
X$49989 9264 8863 6664 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $49991 r0 *1 271.04,942.48
X$49991 9264 9263 8925 7896 6664 8926 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49993 m0 *1 439.04,912.24
X$49993 9264 9263 8802 7903 6664 8746 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50007 m0 *1 268.8,932.4
X$50007 9264 9263 8856 8111 6664 8832 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50009 r0 *1 291.76,922.32
X$50009 9264 9263 8834 8054 6664 8809 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50013 m0 *1 242.48,670.32
X$50013 9264 9263 6795 6748 6664 6704 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50016 r0 *1 458.08,932.4
X$50016 9264 9263 8888 6825 6664 8867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50019 r0 *1 456.4,902.16
X$50019 9264 9263 8769 8239 6664 8776 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50021 m0 *1 252,690.48
X$50021 9264 9263 6860 6975 6931 6665 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50028 m0 *1 263.2,690.48
X$50028 9264 9263 6976 6918 6916 6665 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50036 m0 *1 278.88,982.8
X$50036 9264 9263 9143 8174 6666 9121 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50038 r0 *1 278.88,962.64
X$50038 9264 9263 9024 7944 6666 9079 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50040 m0 *1 313.04,962.64
X$50040 9264 8863 6666 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $50042 m0 *1 473.2,902.16
X$50042 9264 9263 8717 7904 6666 8718 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50058 m0 *1 527.52,982.8
X$50058 9264 9263 9158 6824 6666 9132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50064 m0 *1 272.16,670.32
X$50064 9264 9263 6731 6750 6666 6705 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50066 r0 *1 479.36,942.48
X$50066 9264 9263 8952 8237 6666 8932 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50069 m0 *1 638.96,962.64
X$50069 9264 9263 9007 8040 6666 9138 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50071 m0 *1 366.8,670.32
X$50071 9263 6735 6667 6755 6756 6765 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $50074 r0 *1 377.44,660.24
X$50074 9264 9263 6668 6708 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50079 r0 *1 379.12,670.32
X$50079 9263 6763 9264 6670 6758 6668 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50081 m0 *1 389.2,660.24
X$50081 6668 9264 9263 6759 6711 6669 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50083 m0 *1 400.96,660.24
X$50083 9263 6669 6709 9264 6670 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $50085 m0 *1 396.48,670.32
X$50085 9264 9263 6669 6760 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $50095 r0 *1 473.76,660.24
X$50095 9263 6673 6697 9264 6672 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $50098 r0 *1 455.84,660.24
X$50098 9263 6713 9264 6672 6696 6739 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50102 r0 *1 463.68,660.24
X$50102 6739 9264 9263 6759 6714 6673 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50104 r0 *1 474.32,700.56
X$50104 7161 9264 9263 6674 6925 9308 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50107 r0 *1 479.36,690.48
X$50107 9264 6674 6993 7160 6990 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $50109 r0 *1 486.08,680.4
X$50109 6967 9264 9263 6674 6927 9299 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50112 r0 *1 427.28,720.72
X$50112 7291 9264 9263 6674 7157 9310 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50115 r0 *1 406,710.64
X$50115 7265 9264 9263 6674 7156 9315 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50117 r0 *1 407.12,720.72
X$50117 7329 9264 9263 6674 7396 9298 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50120 m0 *1 470.96,670.32
X$50120 6740 9264 9263 6674 6714 9281 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50122 r0 *1 445.2,670.32
X$50122 6851 9264 9263 6674 6769 9309 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50124 r0 *1 487.76,660.24
X$50124 6741 9264 9263 6674 6676 9300 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50128 m0 *1 417.76,670.32
X$50128 6764 9264 9263 6674 6711 9284 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50131 m0 *1 405.44,700.56
X$50131 6985 9264 9263 6674 7088 9278 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50133 m0 *1 440.72,730.8
X$50133 7335 9264 9263 6674 7397 9288 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50136 m0 *1 453.04,730.8
X$50136 7336 9264 9263 6674 7399 9282 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50139 m0 *1 473.2,720.72
X$50139 7228 9264 9263 6674 7231 9276 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50141 m0 *1 495.04,730.8
X$50141 7163 9264 9263 6674 7398 9289 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $50143 m0 *1 496.16,690.48
X$50143 9263 6674 6928 9264 6992 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $50145 m0 *1 490.56,700.56
X$50145 9264 6674 7211 6994 6989 9263 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $50147 r0 *1 500.64,670.32
X$50147 9264 6674 6759 9263 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $50175 r0 *1 490,670.32
X$50175 9264 9263 6676 6822 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50182 m0 *1 716.8,801.36
X$50182 9264 7268 9263 8071 7969 8072 6677 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $50185 r0 *1 708.96,771.12
X$50185 9264 7268 9263 7775 7837 7774 6677 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $50187 m0 *1 710.08,740.88
X$50187 9264 7114 9263 7455 7484 7411 6677 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $50189 r0 *1 690.48,801.36
X$50189 9264 9263 8068 8119 6677 8097 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50192 m0 *1 439.04,710.64
X$50192 9264 7114 9263 7051 7207 7096 6677 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $50195 r0 *1 656.32,710.64
X$50195 9264 7062 6677 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $50225 m0 *1 476.56,801.36
X$50225 9264 9263 8035 6677 8036 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $50227 m0 *1 592.48,660.24
X$50227 9264 9263 6698 6677 6745 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $50229 m0 *1 715.68,690.48
X$50229 9264 9263 7025 6677 7029 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $50231 m0 *1 711.2,801.36
X$50231 9264 6677 8010 9263 8071 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $50238 m0 *1 636.16,791.28
X$50238 9264 7948 6678 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $50240 m0 *1 839.44,680.4
X$50240 9264 9263 6848 6892 6678 6687 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50268 r0 *1 644,670.32
X$50268 9264 9263 6832 6857 6678 6775 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50279 r0 *1 787.36,660.24
X$50279 9264 9263 6682 6725 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50281 m0 *1 776.16,670.32
X$50281 9264 9263 6682 6798 6724 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $50286 m0 *1 781.2,670.32
X$50286 9264 6682 6724 9263 6785 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $50302 r0 *1 687.68,680.4
X$50302 9263 6765 9264 6911 6687 6883 6755 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $50321 r0 *1 700,680.4
X$50321 9263 6755 6688 9264 6911 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $50323 r0 *1 705.04,680.4
X$50323 9264 9263 6688 7034 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50339 m0 *1 980.56,680.4
X$50339 6901 9263 9264 6691 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $50341 r0 *1 961.52,660.24
X$50341 6728 9263 9264 6692 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $50344 r0 *1 220.08,670.32
X$50344 9264 9263 6747 6753 6859 6693 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50360 r0 *1 446.88,660.24
X$50360 9264 9263 6712 6709 6696 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $50364 r0 *1 482.16,660.24
X$50364 9264 9263 6741 6697 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50366 r0 *1 461.44,670.32
X$50366 9264 6759 6852 6714 6697 6821 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $50381 r0 *1 395.92,932.4
X$50381 9264 8863 6699 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $50383 m0 *1 482.16,922.32
X$50383 9264 9263 8819 8287 6699 8830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50404 m0 *1 610.4,942.48
X$50404 9264 9263 8910 7799 6699 8911 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50406 m0 *1 512.4,932.4
X$50406 9264 9263 8892 7962 6699 8870 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50409 m0 *1 400.96,902.16
X$50409 9264 9263 8715 8155 6699 8716 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50411 m0 *1 390.32,922.32
X$50411 9264 9263 8816 7441 6699 8837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50413 r0 *1 423.36,902.16
X$50413 9264 9263 8744 7900 6699 8745 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50416 m0 *1 479.36,932.4
X$50416 9264 9263 8890 7515 6699 8868 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50418 m0 *1 628.32,932.4
X$50418 9264 9263 8873 8116 6699 8874 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50421 m0 *1 688.24,670.32
X$50421 9263 6719 6700 6755 6721 6765 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $50425 m0 *1 2.24,670.32
X$50425 6705 9263 9264 6701 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $50430 m0 *1 266.56,710.64
X$50430 9264 9263 7097 7100 6916 6703 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50432 m0 *1 248.64,710.64
X$50432 9264 9263 7195 7196 6931 6703 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50450 m0 *1 19.04,670.32
X$50450 6704 9263 9264 6746 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $50458 m0 *1 339.92,700.56
X$50458 9264 9263 7042 7099 7019 6706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50461 m0 *1 348.32,700.56
X$50461 9264 9263 7139 6750 7085 6706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50464 r0 *1 329.84,680.4
X$50464 9264 9263 6816 6921 6865 6706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50480 m0 *1 400.96,670.32
X$50480 9263 6708 9264 6737 6761 6760 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50489 r0 *1 399.28,670.32
X$50489 9263 6760 6709 9264 6762 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $50491 m0 *1 415.52,680.4
X$50491 9264 6764 9263 6710 6766 6760 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $50506 m0 *1 380.8,720.72
X$50506 9263 7263 7222 9264 6711 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $50509 m0 *1 448,710.64
X$50509 6711 7206 7209 7159 9263 9264 6965 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $50512 m0 *1 445.2,670.32
X$50512 9264 9263 6768 6712 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50514 m0 *1 442.4,680.4
X$50514 9264 6768 9263 6737 6821 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $50516 m0 *1 449.68,680.4
X$50516 6713 9264 6821 9263 6964 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $50519 r0 *1 439.04,680.4
X$50519 9263 6713 6820 9264 6869 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $50527 m0 *1 449.12,670.32
X$50527 9264 6768 6713 6759 6769 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50530 m0 *1 436.8,670.32
X$50530 9263 6767 9264 6801 6766 6713 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50532 r0 *1 437.36,670.32
X$50532 9263 6767 9264 6820 6802 6713 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50535 m0 *1 481.04,700.56
X$50535 6822 6714 6927 7231 9263 9264 7144 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $50537 r0 *1 477.68,680.4
X$50537 9264 9263 6873 6714 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50575 r0 *1 453.04,781.2
X$50575 9264 6765 9263 7902 7789 7903 6720 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $50580 r0 *1 426.16,690.48
X$50580 9264 6765 9263 7050 6988 6748 6720 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $50605 m0 *1 450.24,791.28
X$50605 9264 6720 7905 9263 7902 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $50608 r0 *1 623.84,771.12
X$50608 9263 9264 7628 7800 6720 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $50612 r0 *1 686.56,690.48
X$50612 9264 9263 7001 6883 6720 7120 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50614 r0 *1 425.04,700.56
X$50614 9264 6720 7096 9263 7050 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $50632 r0 *1 780.08,680.4
X$50632 9264 9263 6941 6724 6942 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $50635 r0 *1 796.88,670.32
X$50635 9263 6725 6787 9264 6726 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $50661 m0 *1 980.56,690.48
X$50661 6843 9263 9264 6729 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $50693 m0 *1 774.48,700.56
X$50693 9264 7068 9263 6738 7069 7006 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $50712 m0 *1 465.92,680.4
X$50712 9264 9263 6742 6872 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50718 m0 *1 525.28,750.96
X$50718 9264 9263 7404 6996 7440 6743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50720 r0 *1 529.2,730.8
X$50720 9264 9263 7341 7403 7389 6743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50738 m0 *1 478.24,982.8
X$50738 9264 9263 9154 6743 8992 9088 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50752 r0 *1 244.16,690.48
X$50752 9264 9263 7013 7077 6931 6748 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50754 m0 *1 265.44,700.56
X$50754 9264 9263 7079 7099 6916 6748 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50763 m0 *1 435.12,700.56
X$50763 9264 7062 6748 9263 7051 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $50769 r0 *1 280,730.8
X$50769 9264 9263 7280 7388 7389 6749 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50772 r0 *1 288.4,730.8
X$50772 9264 9263 7476 6918 7440 6749 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50780 m0 *1 308.56,700.56
X$50780 9264 9263 7083 7099 7040 6750 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50790 m0 *1 278.32,690.48
X$50790 9264 9263 6977 6750 6862 7081 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50798 m0 *1 314.72,710.64
X$50798 9264 9263 7200 7201 7151 6752 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50801 m0 *1 328.16,710.64
X$50801 9264 9263 7152 6918 7153 6752 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50811 r0 *1 264.88,730.8
X$50811 9264 9263 7427 6918 7279 6753 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50813 r0 *1 235.2,720.72
X$50813 9264 9263 7317 7364 7319 6753 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50828 m0 *1 350,761.04
X$50828 9264 9263 7647 7501 7618 6754 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50830 r0 *1 357.84,740.88
X$50830 9264 9263 7543 6918 7443 6754 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50840 r0 *1 349.44,962.64
X$50840 9264 9263 9028 6754 8992 9029 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50879 m0 *1 426.16,700.56
X$50879 9264 9263 7049 6988 6755 7143 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50885 m0 *1 400.96,811.44
X$50885 9264 8154 9263 8211 8155 6755 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $50891 r0 *1 519.12,952.56
X$50891 9264 6757 8777 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $50893 m0 *1 642.88,942.48
X$50893 9264 6757 8527 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $50899 r0 *1 548.24,882
X$50899 9264 6757 8058 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $50903 m0 *1 523.04,740.88
X$50903 9264 6757 9263 gf180mcu_fd_sc_mcu9t5v0__clkinv_20
* cell instance $50906 r0 *1 523.04,740.88
X$50906 9264 6780 6757 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $50913 r0 *1 372.96,902.16
X$50913 9264 6757 8436 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $50915 r0 *1 306.88,942.48
X$50915 9264 6757 8707 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $50918 r0 *1 438.48,922.32
X$50918 9264 6757 8470 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $50920 m0 *1 292.88,821.52
X$50920 9264 6757 7442 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $50935 m0 *1 380.8,680.4
X$50935 9264 9263 6849 6867 6758 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $50941 r0 *1 386.96,690.48
X$50941 9264 6983 6922 6759 7088 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50944 r0 *1 482.16,750.96
X$50944 9264 7565 7564 6759 7231 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50963 r0 *1 484.4,740.88
X$50963 9264 7511 7230 6759 6925 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50965 r0 *1 451.36,680.4
X$50965 9264 6759 6924 6873 6872 6820 9263 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $50967 r0 *1 393.12,720.72
X$50967 9264 7328 7102 6759 7156 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50970 m0 *1 459.76,750.96
X$50970 9264 7509 7295 6759 7399 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50973 m0 *1 413.84,750.96
X$50973 9264 7561 7290 6759 7157 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50976 m0 *1 402.08,750.96
X$50976 9264 7503 7505 6759 7396 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50979 r0 *1 442.96,750.96
X$50979 9264 7621 7507 6759 7397 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50981 m0 *1 504,740.88
X$50981 9264 7401 7446 6759 7398 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50983 m0 *1 507.36,700.56
X$50983 9264 7147 7107 6759 6927 9263 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $50990 m0 *1 426.16,680.4
X$50990 9263 6760 6766 9264 6870 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $50993 r0 *1 417.76,670.32
X$50993 9264 6764 9263 6819 6802 6760 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $51004 m0 *1 391.44,680.4
X$51004 9264 6817 9263 7045 6761 6763 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $51007 r0 *1 386.96,680.4
X$51007 6763 9264 6761 9263 6960 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $51013 m0 *1 401.52,690.48
X$51013 9263 6923 6762 9264 6961 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $51016 m0 *1 406,680.4
X$51016 9263 6763 6819 9264 6868 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $51067 r0 *1 375.2,740.88
X$51067 9264 9263 7288 7544 6765 7444 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51070 r0 *1 688.24,781.2
X$51070 9263 9264 7735 7864 6765 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $51081 m0 *1 439.04,680.4
X$51081 9264 9263 6851 6767 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51096 r0 *1 445.76,700.56
X$51096 7157 9264 6769 7144 9263 7209 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $51098 r0 *1 459.76,791.28
X$51098 9264 9263 8000 6769 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51103 m0 *1 523.04,942.48
X$51103 9264 9263 8903 6932 6770 8904 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51107 m0 *1 328.16,942.48
X$51107 9264 9263 8895 7392 6770 8920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51121 m0 *1 560,942.48
X$51121 9264 9263 8924 7673 6770 8906 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51123 r0 *1 537.04,932.4
X$51123 9264 9263 8871 7909 6770 8905 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51125 r0 *1 500.64,942.48
X$51125 9264 9263 8933 8177 6770 8934 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51128 r0 *1 417.2,932.4
X$51128 9264 9263 8886 7935 6770 8866 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51130 r0 *1 313.6,962.64
X$51130 9264 9263 8957 7978 6770 8975 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51133 r0 *1 341.6,942.48
X$51133 9264 9263 8927 8037 6770 8958 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51144 r0 *1 545.44,690.48
X$51144 9264 9263 7057 6996 6916 6774 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51146 m0 *1 549.92,690.48
X$51146 9264 9263 6826 6997 6931 6774 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51149 m0 *1 570.64,700.56
X$51149 9264 9263 7061 7031 6774 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51162 r0 *1 615.44,690.48
X$51162 9264 9263 6775 6999 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51177 m0 *1 579.04,972.72
X$51177 9264 9263 9092 6775 8992 9093 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51181 r0 *1 594.72,670.32
X$51181 9264 9263 6810 6809 6777 6776 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51183 r0 *1 651.84,750.96
X$51183 9263 9264 7300 7630 6777 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $51205 m0 *1 710.08,761.04
X$51205 9264 9263 7656 6777 7715 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $51211 r0 *1 591.36,761.04
X$51211 9264 9263 7722 6777 7746 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $51214 r0 *1 594.16,660.24
X$51214 9264 6778 6780 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $51238 m0 *1 369.04,851.76
X$51238 9264 9263 8507 8425 6782 8052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51240 m0 *1 668.64,851.76
X$51240 9264 6782 7355 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $51242 m0 *1 371.84,761.04
X$51242 9264 6782 7618 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $51269 m0 *1 400.96,851.76
X$51269 9264 9263 8508 8397 6782 7997 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51271 r0 *1 383.04,841.68
X$51271 9264 9263 8395 8396 6782 8328 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51273 m0 *1 354.48,851.76
X$51273 9264 9263 8465 8424 6782 7899 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51288 r0 *1 780.08,690.48
X$51288 9263 7005 9264 7070 6787 7006 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $51300 r0 *1 787.92,720.72
X$51300 9263 7241 7347 9264 6788 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $51308 r0 *1 899.36,670.32
X$51308 9264 9263 6791 6847 6839 6837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51313 m0 *1 972.16,690.48
X$51313 6841 9263 9264 6792 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $51319 r0 *1 918.96,831.6
X$51319 9264 8261 6794 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $51322 m0 *1 759.92,982.8
X$51322 9264 9263 9147 8208 6794 9065 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51324 r0 *1 934.08,771.12
X$51324 9264 9263 7689 7812 6794 7690 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51347 m0 *1 754.88,962.64
X$51347 9264 9263 9010 8427 6794 9054 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51349 r0 *1 740.32,972.72
X$51349 9264 9263 9140 8294 6794 9098 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51351 r0 *1 708.4,962.64
X$51351 9264 9263 9049 7090 6794 9050 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51353 m0 *1 711.2,962.64
X$51353 9264 9263 9009 8070 6794 9051 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51356 r0 *1 687.12,962.64
X$51356 9264 9263 9047 8247 6794 9048 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51358 m0 *1 689.92,972.72
X$51358 9264 9263 9112 7753 6794 9096 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51360 r0 *1 731.36,962.64
X$51360 9264 9263 9052 7680 6794 9053 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51370 r0 *1 804.72,750.96
X$51370 7600 7602 7641 7183 9264 9263 6797 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $51430 m0 *1 702.24,801.36
X$51430 9264 8009 9263 6828 8097 6812 8032 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $51432 m0 *1 496.16,801.36
X$51432 9264 7994 9263 6828 8036 6812 7999 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $51434 m0 *1 537.04,700.56
X$51434 9264 6824 9263 6828 7093 6812 7055 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $51438 m0 *1 706.72,690.48
X$51438 9264 6936 9263 6828 7029 6812 6886 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $51448 m0 *1 286.72,922.32
X$51448 9264 8863 6813 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $51450 r0 *1 262.08,902.16
X$51450 9264 9263 8733 8046 6813 8713 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51463 r0 *1 212.8,700.56
X$51463 9264 9263 7131 7134 6813 7036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51468 m0 *1 213.92,771.12
X$51468 9264 9263 7666 7729 6813 7252 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51471 m0 *1 255.36,892.08
X$51471 9264 9263 8655 7999 6813 8656 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51474 m0 *1 260.4,932.4
X$51474 9264 9263 8855 7951 6813 8831 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51476 m0 *1 277.2,932.4
X$51476 9264 9263 8857 8165 6813 8833 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51485 m0 *1 385.84,680.4
X$51485 9264 9263 6817 6849 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51488 r0 *1 402.64,690.48
X$51488 9264 6985 9263 7224 6818 6986 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $51491 r0 *1 409.92,690.48
X$51491 9263 6986 6818 9264 7047 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $51516 r0 *1 523.6,680.4
X$51516 9264 9263 6823 6930 6865 6824 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51520 r0 *1 524.72,690.48
X$51520 9264 9263 7053 6996 7019 6824 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51535 m0 *1 531.44,761.04
X$51535 9264 9263 7672 7626 7618 6825 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51537 r0 *1 525.28,750.96
X$51537 9264 9263 7625 6996 7662 6825 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51539 m0 *1 562.8,690.48
X$51539 9264 9263 6825 6969 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51573 m0 *1 584.64,942.48
X$51573 9264 9263 8908 6827 7766 8909 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51582 m0 *1 589.68,730.8
X$51582 9263 7061 7344 6828 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $51632 r0 *1 739.2,781.2
X$51632 9264 7918 9263 6833 7915 7456 7863 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $51634 m0 *1 730.8,740.88
X$51634 9264 7253 9263 6833 7483 7456 7412 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $51696 m0 *1 897.12,710.64
X$51696 9264 9263 7198 7199 7187 6837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51702 r0 *1 670.88,710.64
X$51702 9264 9263 7174 7175 6913 6837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51704 r0 *1 720.72,700.56
X$51704 9264 9263 7121 7179 7067 6837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51724 r0 *1 882,811.44
X$51724 9264 9263 8130 8202 6839 7686 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51726 m0 *1 865.2,912.24
X$51726 9264 9263 8764 8766 6839 8457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51736 m0 *1 846.16,922.32
X$51736 9264 9263 8826 8797 6839 8594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51739 m0 *1 837.76,922.32
X$51739 9264 9263 8825 8796 6839 8496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51742 m0 *1 829.36,922.32
X$51742 9264 9263 8824 8794 6839 8454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51745 r0 *1 861.28,902.16
X$51745 9264 9263 8765 8732 6839 8498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51748 r0 *1 861.28,720.72
X$51748 9264 9263 7354 7372 6839 7311 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51751 m0 *1 882,831.6
X$51751 9264 8344 6839 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $51753 r0 *1 862.4,821.52
X$51753 9264 9263 8312 8259 6839 7820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51774 m0 *1 740.88,680.4
X$51774 9264 9263 6844 6908 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51820 m0 *1 459.76,680.4
X$51820 9264 9263 6852 6871 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51846 m0 *1 19.6,690.48
X$51846 6951 9263 9264 6858 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $51850 r0 *1 228.48,771.12
X$51850 9264 9263 7730 7783 6859 7316 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51853 m0 *1 295.12,952.56
X$51853 9264 8863 6859 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $51856 m0 *1 318.08,932.4
X$51856 9264 9263 8882 7749 6859 8861 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51867 m0 *1 223.44,700.56
X$51867 9264 9263 7076 7096 6859 6951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51871 r0 *1 280.56,952.56
X$51871 9264 9263 8955 7668 6859 8956 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51874 r0 *1 305.2,962.64
X$51874 9264 9263 9025 8434 6859 9026 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51876 m0 *1 315.84,952.56
X$51876 9264 9263 8894 8118 6859 8919 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51879 r0 *1 291.76,962.64
X$51879 9264 9263 9064 8228 6859 8988 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51881 m0 *1 257.6,962.64
X$51881 9264 9263 8953 8104 6859 8954 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51892 r0 *1 420.56,841.68
X$51892 9264 9263 8426 7954 6862 8399 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51894 m0 *1 276.64,892.08
X$51894 9264 9263 8675 8174 6862 8650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51921 r0 *1 309.12,902.16
X$51921 9264 9263 8742 8226 6862 8683 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51923 m0 *1 302.4,912.24
X$51923 9264 9263 8767 8053 6862 8682 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51925 m0 *1 279.44,902.16
X$51925 9264 9263 8714 7944 6862 8657 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51928 r0 *1 528.64,710.64
X$51928 9264 9263 7169 7060 6862 7273 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51936 m0 *1 464.8,892.08
X$51936 9264 9263 8663 7904 6862 8638 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51948 m0 *1 311.92,781.2
X$51948 9264 9263 7828 7881 6865 7731 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51970 r0 *1 442.96,821.52
X$51970 9264 9263 8285 8286 6865 7855 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51973 m0 *1 417.2,821.52
X$51973 9264 9263 8315 8276 6865 8156 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51976 r0 *1 341.6,811.44
X$51976 9264 9263 8225 8166 6865 8167 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51978 r0 *1 320.32,811.44
X$51978 9264 9263 8136 8049 6865 7994 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51981 r0 *1 303.52,821.52
X$51981 9264 9263 8309 8308 6865 8051 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51983 m0 *1 304.64,720.72
X$51983 9264 9263 7281 7254 6865 7282 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51986 m0 *1 374.08,912.24
X$51986 9264 9263 8801 8167 6866 8774 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51988 r0 *1 337.12,932.4
X$51988 9264 8863 6866 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $52004 m0 *1 338.24,922.32
X$52004 9264 9263 8810 8051 6866 8811 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52006 m0 *1 612.08,932.4
X$52006 9264 9263 8841 8184 6866 8872 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52008 r0 *1 595.28,922.32
X$52008 9264 9263 8860 7796 6866 8840 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52010 m0 *1 504,932.4
X$52010 9264 9263 8838 8003 6866 8869 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52012 r0 *1 411.04,922.32
X$52012 9264 9263 8859 8156 6866 8865 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52014 r0 *1 328.72,932.4
X$52014 9264 9263 8883 7731 6866 8862 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52016 r0 *1 458.08,912.24
X$52016 9264 9263 8805 7745 6866 8817 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52020 m0 *1 388.64,690.48
X$52020 9263 6922 6867 9264 6984 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52025 m0 *1 377.44,690.48
X$52025 9264 6922 6867 9263 6982 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $52028 r0 *1 374.64,690.48
X$52028 9264 9263 6922 6981 6867 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $52030 m0 *1 367.36,690.48
X$52030 9264 9263 6980 6868 6918 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $52032 m0 *1 431.2,690.48
X$52032 6924 6874 6869 6868 9264 9263 6987 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $52038 r0 *1 358.4,690.48
X$52038 9264 9263 6980 6869 7020 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $52045 r0 *1 357.28,700.56
X$52045 9264 9263 6980 6870 7100 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $52048 m0 *1 418.88,700.56
X$52048 7105 7047 6870 6987 9264 9263 7048 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $52054 m0 *1 460.88,700.56
X$52054 9263 6871 6923 9264 7052 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52073 r0 *1 502.88,680.4
X$52073 6992 9264 6875 9263 6929 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $52075 r0 *1 500.64,700.56
X$52075 9263 7023 9264 7106 6875 7107 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $52078 r0 *1 591.36,680.4
X$52078 9264 6909 6876 9263 6971 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $52123 m0 *1 889.28,700.56
X$52123 9264 9263 7137 6947 7436 6886 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52142 m0 *1 864.08,720.72
X$52142 9264 9263 7255 7246 7355 6887 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52144 m0 *1 744.24,680.4
X$52144 9264 9263 6887 6888 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52245 r0 *1 959.28,680.4
X$52245 9264 9263 6898 6896 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $52253 m0 *1 980.56,700.56
X$52253 6949 9263 9264 6899 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $52256 r0 *1 980.56,690.48
X$52256 6950 9263 9264 6900 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $52270 r0 *1 819.84,730.8
X$52270 7123 6903 7351 7418 9264 9263 7417 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $52284 m0 *1 801.92,710.64
X$52284 9264 9263 6905 7073 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52315 m0 *1 669.2,841.68
X$52315 9264 8344 6913 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $52317 r0 *1 313.04,892.08
X$52317 9264 9263 8683 8578 6913 8164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52340 m0 *1 285.04,892.08
X$52340 9264 9263 8657 8575 6913 7846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52342 r0 *1 285.04,882
X$52342 9264 9263 8650 8574 6913 7993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52345 r0 *1 303.52,892.08
X$52345 9264 9263 8682 8577 6913 8223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52349 m0 *1 425.6,841.68
X$52349 9264 9263 8399 8360 6913 8103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52352 m0 *1 291.76,700.56
X$52352 9264 9263 7081 7082 6913 6974 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52364 r0 *1 668.64,791.28
X$52364 9264 6914 9263 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $52382 m0 *1 630.56,720.72
X$52382 9264 7344 6914 7177 9263 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $52413 r0 *1 10.64,690.48
X$52413 7075 9263 9264 6915 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $52419 m0 *1 335.44,791.28
X$52419 9264 7943 6916 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $52423 m0 *1 501.76,882
X$52423 9264 9263 8639 7400 6916 8287 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52425 m0 *1 455.84,871.92
X$52425 9264 9263 8548 7158 6916 7903 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52441 r0 *1 263.2,871.92
X$52441 9264 9263 8517 7020 6916 8111 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52443 m0 *1 515.76,871.92
X$52443 9264 9263 8549 7661 6916 7515 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52445 m0 *1 528.64,882
X$52445 9264 9263 8587 7385 6916 7962 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52447 r0 *1 264.88,811.44
X$52447 9264 9263 8201 7286 6916 7896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52454 r0 *1 304.64,690.48
X$52454 9264 9263 6917 7018 7039 6920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52478 m0 *1 321.44,690.48
X$52478 9264 9263 6919 6957 7041 6920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52483 m0 *1 321.44,720.72
X$52483 9264 9263 7256 7152 7221 6920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52485 r0 *1 263.2,690.48
X$52485 9264 9263 7014 6976 7058 6920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52488 m0 *1 352.24,750.96
X$52488 9264 9263 7541 7543 7619 6920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52490 m0 *1 286.72,740.88
X$52490 9264 9263 7475 7476 7498 6920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52492 m0 *1 255.36,750.96
X$52492 9264 9263 7536 7537 7494 6920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52502 m0 *1 383.04,690.48
X$52502 9263 6923 6960 9264 6920 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52504 r0 *1 256.48,730.8
X$52504 9264 9263 7365 7427 7342 6920 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52509 r0 *1 398.72,690.48
X$52509 9264 9263 6922 6986 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52522 r0 *1 383.6,740.88
X$52522 9263 7394 6923 7546 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $52524 r0 *1 488.32,761.04
X$52524 7709 6923 7711 9264 9263 7627 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $52527 r0 *1 397.6,761.04
X$52527 9263 6923 7649 9264 7738 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52529 m0 *1 502.88,761.04
X$52529 7566 7659 6923 9264 9263 7660 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $52531 r0 *1 513.52,750.96
X$52531 7514 9263 6923 7567 9264 7671 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $52538 r0 *1 470.96,710.64
X$52538 9264 9263 7160 6923 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $52541 r0 *1 380.24,690.48
X$52541 6981 9263 6923 6982 9264 7038 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $52544 m0 *1 388.64,761.04
X$52544 7603 6923 7560 9264 9263 7706 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $52560 r0 *1 446.88,690.48
X$52560 9264 9263 6980 6924 7158 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $52579 m0 *1 476.56,690.48
X$52579 6989 9264 9263 6926 6966 6990 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $52582 m0 *1 489.44,690.48
X$52582 9264 9263 6928 6926 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52591 r0 *1 506.24,791.28
X$52591 9263 7960 7988 9264 6927 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52601 m0 *1 517.44,690.48
X$52601 9264 9263 6929 6995 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52606 r0 *1 504,690.48
X$52606 9264 9263 6994 6929 6991 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $52609 r0 *1 523.6,700.56
X$52609 9264 9263 6930 7109 7118 7110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52646 m0 *1 300.72,892.08
X$52646 9264 9263 8658 8629 6931 8054 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52648 m0 *1 246.4,821.52
X$52648 9264 9263 8221 8222 6931 7896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52651 r0 *1 252.56,861.84
X$52651 9264 9263 8515 8516 6931 8111 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52655 m0 *1 385.84,902.16
X$52655 9264 9263 8684 8635 6931 8155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52657 r0 *1 405.44,882
X$52657 9264 9263 8678 8636 6931 7900 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52660 m0 *1 444.64,892.08
X$52660 9264 9263 8637 8584 6931 7903 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52662 r0 *1 548.24,720.72
X$52662 9264 9263 7386 6996 7279 6932 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52665 m0 *1 560.56,730.8
X$52665 9264 9263 7387 7343 7319 6932 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52679 m0 *1 620.48,690.48
X$52679 9264 6970 6933 9263 7000 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $52689 m0 *1 840,710.64
X$52689 9264 9263 7125 6947 7464 6936 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52721 m0 *1 769.44,690.48
X$52721 9264 9263 6939 7005 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52724 m0 *1 768.32,750.96
X$52724 9264 9263 6940 7545 7771 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $52729 m0 *1 781.76,690.48
X$52729 9264 9263 7068 6941 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52733 m0 *1 774.48,710.64
X$52733 9263 7006 9264 7182 6942 7181 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $52737 r0 *1 787.92,690.48
X$52737 9263 7005 9264 7007 6943 7006 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $52741 r0 *1 822.08,700.56
X$52741 9264 9263 6944 7142 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52743 m0 *1 815.36,710.64
X$52743 9264 7122 9263 7261 6944 7184 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $52764 r0 *1 864.08,700.56
X$52764 9264 9263 7203 6947 7173 7026 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52800 m0 *1 265.44,730.8
X$52800 9264 9263 7369 7100 7279 6953 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52815 r0 *1 239.68,730.8
X$52815 9264 9263 7218 7276 7319 6953 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52840 m0 *1 781.76,700.56
X$52840 7006 9264 7069 9263 6959 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $52846 r0 *1 320.32,720.72
X$52846 9264 9263 7283 7284 7041 6961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52848 m0 *1 257.04,730.8
X$52848 9264 9263 7277 7369 7342 6961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52850 r0 *1 263.2,700.56
X$52850 9264 9263 7197 7097 7058 6961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52852 r0 *1 290.08,700.56
X$52852 9264 9263 6978 7098 7039 6961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52854 m0 *1 329.28,740.88
X$52854 9264 9263 7478 7393 7221 6961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52857 m0 *1 301.84,750.96
X$52857 9264 9263 7556 7499 7498 6961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52874 m0 *1 258.72,761.04
X$52874 9264 9263 7697 7616 7494 6961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52876 m0 *1 335.44,761.04
X$52876 9264 9263 7646 7559 7619 6961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52883 m0 *1 408.8,690.48
X$52883 9264 6985 9263 7104 6963 6986 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $52895 m0 *1 492.8,690.48
X$52895 9264 9263 6967 7023 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52917 m0 *1 17.36,700.56
X$52917 7036 9263 9264 6972 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $52919 r0 *1 2.8,690.48
X$52919 9264 9263 6973 6974 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $52926 r0 *1 248.08,730.8
X$52926 9264 9263 7324 7426 7325 6974 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52928 m0 *1 248.64,700.56
X$52928 9264 9263 7077 7078 7037 6974 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52930 r0 *1 322.56,750.96
X$52930 9264 9263 7558 7597 7542 6974 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52933 m0 *1 280,750.96
X$52933 9264 9263 7495 7539 7496 6974 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52936 r0 *1 246.4,750.96
X$52936 9264 9263 7554 7595 7555 6974 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52950 r0 *1 328.16,710.64
X$52950 9264 9263 7257 7220 7219 6974 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52962 m0 *1 331.52,700.56
X$52962 9264 9263 6979 7042 7041 7038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52965 m0 *1 356.72,700.56
X$52965 9264 9263 6980 7047 7099 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $52968 m0 *1 465.92,700.56
X$52968 9264 6991 6980 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $52974 r0 *1 481.04,730.8
X$52974 9264 9263 6980 7339 7402 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $52977 m0 *1 484.4,730.8
X$52977 9264 9263 6980 7340 7385 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $52980 r0 *1 461.44,730.8
X$52980 9264 9263 6980 7294 7407 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $52983 r0 *1 500.64,720.72
X$52983 9264 9263 6980 7165 7400 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $52985 r0 *1 503.44,710.64
X$52985 9264 9263 6980 7166 7661 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $53004 m0 *1 388.64,700.56
X$53004 9264 9263 6983 7044 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $53006 r0 *1 389.76,700.56
X$53006 9263 7102 9264 6984 7103 6983 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $53025 m0 *1 392,700.56
X$53025 9263 7044 9264 7045 7046 6986 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $53041 m0 *1 415.52,730.8
X$53041 9264 9263 6991 7334 7380 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $53043 m0 *1 434.56,740.88
X$53043 9264 9263 6991 7292 7508 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $53053 m0 *1 414.4,740.88
X$53053 9264 9263 6991 7333 7481 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $53056 m0 *1 414.96,710.64
X$53056 9264 9263 6991 7105 7286 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $53059 m0 *1 505.68,690.48
X$53059 9264 6993 7146 6992 9263 gf180mcu_fd_sc_mcu9t5v0__xor2_4
* cell instance $53068 m0 *1 554.4,750.96
X$53068 9264 9263 7613 7553 7494 6993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53070 r0 *1 537.6,730.8
X$53070 9264 9263 7438 7404 7498 6993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53073 m0 *1 520.24,700.56
X$53073 9264 9263 7109 7053 7041 6993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53075 m0 *1 546,700.56
X$53075 9264 9263 7111 7057 7058 6993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53078 m0 *1 552.16,730.8
X$53078 9264 9263 7439 7386 7342 6993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53097 m0 *1 523.04,761.04
X$53097 9264 9263 7611 7625 7619 6993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53099 r0 *1 514.64,710.64
X$53099 9264 9263 7233 7168 7039 6993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53101 r0 *1 549.36,710.64
X$53101 9264 9263 7275 7170 7221 6993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53105 r0 *1 514.64,690.48
X$53105 9263 9264 6994 6996 6995 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $53122 m0 *1 517.44,710.64
X$53122 9264 9263 7168 6996 7040 7060 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53131 r0 *1 557.76,740.88
X$53131 9264 9263 7553 6996 7448 7055 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53136 r0 *1 549.36,700.56
X$53136 9264 9263 6997 7111 7148 7110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53146 r0 *1 590.24,700.56
X$53146 9264 7113 9263 7171 7112 6999 7117 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53153 m0 *1 691.6,700.56
X$53153 9264 9263 7119 7002 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $53175 m0 *1 784.56,710.64
X$53175 9263 7006 7007 9264 7183 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $53188 m0 *1 784.56,720.72
X$53188 9264 7320 9263 7007 7348 7241 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $53221 r0 *1 963.76,690.48
X$53221 7074 9263 9264 7012 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $53246 r0 *1 329.84,791.28
X$53246 9264 7882 7019 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $53265 m0 *1 590.8,841.68
X$53265 9264 9263 8364 7402 7019 7796 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53267 r0 *1 500.64,841.68
X$53267 9264 9263 8430 7400 7019 8237 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53270 m0 *1 535.36,841.68
X$53270 9264 9263 8403 7385 7019 8003 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53272 r0 *1 518,841.68
X$53272 9264 9263 8401 7661 7019 7745 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53275 m0 *1 327.04,801.36
X$53275 9264 9263 8026 7020 7019 7994 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53277 r0 *1 451.92,831.6
X$53277 9264 9263 8386 7158 7019 7855 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53281 r0 *1 328.72,720.72
X$53281 9264 9263 7284 7100 7019 7282 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53302 r0 *1 290.08,871.92
X$53302 9264 9263 8604 7020 7040 8174 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53306 m0 *1 329.28,871.92
X$53306 9264 9263 8605 7020 7153 8037 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53308 m0 *1 263.2,841.68
X$53308 9264 9263 8353 7020 7279 8173 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53311 r0 *1 262.08,801.36
X$53311 9264 9263 8044 7020 7448 7999 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53313 r0 *1 289.52,861.84
X$53313 9264 9263 8480 7020 7440 7958 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53315 m0 *1 338.24,831.6
X$53315 9264 9263 8327 7020 7443 8057 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53318 r0 *1 813.68,690.48
X$53318 9264 9263 7021 7072 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $53329 m0 *1 318.64,801.36
X$53329 9264 9263 8048 8026 7041 7022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53331 m0 *1 285.04,861.84
X$53331 9264 9263 8479 8480 7498 7022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53334 r0 *1 327.6,871.92
X$53334 9264 9263 8580 8605 7221 7022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53337 r0 *1 259.84,831.6
X$53337 9264 9263 8352 8353 7342 7022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53340 m0 *1 260.96,801.36
X$53340 9264 9263 8025 8044 7494 7022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53342 r0 *1 260.96,861.84
X$53342 9264 9263 8532 8517 7058 7022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53359 r0 *1 281.68,871.92
X$53359 9264 9263 8574 8604 7039 7022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53361 r0 *1 341.04,831.6
X$53361 9264 9263 8357 8327 7619 7022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53386 m0 *1 740.88,700.56
X$53386 9264 9263 7087 7026 7085 7066 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53431 m0 *1 600.32,811.44
X$53431 9264 9263 8060 8183 7037 8113 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53433 m0 *1 602.56,831.6
X$53433 9264 8290 7037 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $53453 r0 *1 254.8,871.92
X$53453 9264 9263 8516 8532 7037 7993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53455 r0 *1 305.2,882
X$53455 9264 9263 8629 8576 7037 8223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53457 r0 *1 250.32,811.44
X$53457 9264 9263 8222 8200 7037 7846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53459 r0 *1 618.8,841.68
X$53459 9264 9263 8410 8433 7037 8432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53464 r0 *1 386.96,882
X$53464 9264 9263 8635 8583 7037 8164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53466 m0 *1 407.68,882
X$53466 9264 9263 8636 8610 7037 8103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53468 m0 *1 259.84,740.88
X$53468 9264 9263 7426 7278 7342 7038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53470 m0 *1 300.16,700.56
X$53470 9264 9263 7082 7083 7039 7038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53472 r0 *1 254.8,750.96
X$53472 9264 9263 7595 7596 7494 7038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53475 m0 *1 288.4,750.96
X$53475 9264 9263 7539 7497 7498 7038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53488 r0 *1 330.96,750.96
X$53488 9264 9263 7597 7500 7619 7038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53490 m0 *1 257.04,700.56
X$53490 9264 9263 7078 7079 7058 7038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53492 m0 *1 332.64,720.72
X$53492 9264 9263 7220 7258 7221 7038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53496 m0 *1 465.36,831.6
X$53496 9264 8065 7039 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $53499 r0 *1 509.04,882
X$53499 9264 9263 8640 8641 7039 7447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53502 m0 *1 313.04,882
X$53502 9264 9263 8578 8579 7039 7738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53505 m0 *1 468.72,882
X$53505 9264 9263 8586 8617 7039 7052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53522 m0 *1 287.84,882
X$53522 9264 9263 8575 8538 7039 7546 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53524 m0 *1 304.64,882
X$53524 9264 9263 8577 8539 7039 7706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53529 r0 *1 447.44,811.44
X$53529 9264 7792 7040 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $53531 m0 *1 289.52,871.92
X$53531 9264 9263 8538 7286 7040 7944 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53534 r0 *1 464.24,871.92
X$53534 9264 9263 8617 7158 7040 7904 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53553 r0 *1 315.84,871.92
X$53553 9264 9263 8579 7380 7040 8226 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53555 m0 *1 306.32,871.92
X$53555 9264 9263 8539 7481 7040 8053 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53557 m0 *1 510.16,882
X$53557 9264 9263 8641 7400 7040 8238 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53566 m0 *1 364,750.96
X$53566 9264 7493 7041 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $53584 m0 *1 502.88,851.76
X$53584 9264 9263 8438 8430 7041 7447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53587 m0 *1 515.2,851.76
X$53587 9264 9263 8439 8401 7041 7671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53590 m0 *1 319.2,791.28
X$53590 9264 9263 7928 7895 7041 7546 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53593 m0 *1 450.24,841.68
X$53593 9264 9263 8385 8386 7041 7052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53596 r0 *1 320.32,821.52
X$53596 9264 9263 8310 8224 7041 7706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53603 m0 *1 323.12,710.64
X$53603 9264 9263 7285 7043 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $53619 r0 *1 393.12,730.8
X$53619 9264 7328 9263 7480 7046 7102 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $53621 m0 *1 387.52,740.88
X$53621 7102 9264 7046 9263 7394 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $53633 m0 *1 426.16,730.8
X$53633 7294 7048 7334 7333 9264 9263 7381 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $53645 m0 *1 469.28,841.68
X$53645 9264 9263 8330 8362 7619 7052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53647 m0 *1 445.76,811.44
X$53647 9264 9263 8108 7998 7494 7052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53651 r0 *1 454.72,871.92
X$53651 9264 9263 8614 8548 7058 7052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53654 r0 *1 446.32,871.92
X$53654 9264 9263 8615 8547 7221 7052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53665 m0 *1 449.68,851.76
X$53665 9264 9263 8429 8437 7342 7052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53667 m0 *1 469.28,861.84
X$53667 9264 9263 8485 8484 7498 7052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53671 m0 *1 531.44,700.56
X$53671 9264 9263 7054 7062 7093 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $53675 m0 *1 546,750.96
X$53675 9264 9263 7552 7568 7450 7055 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53698 r0 *1 541.52,962.64
X$53698 9264 9263 9035 7055 7766 9036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53701 m0 *1 617.12,811.44
X$53701 9264 9263 7056 8163 8118 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53703 m0 *1 466.48,821.52
X$53703 9264 9263 7056 8233 8111 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53705 m0 *1 419.44,791.28
X$53705 9264 7956 7786 7952 7172 7236 7056 7951 9263
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $53707 m0 *1 430.64,710.64
X$53707 9264 9263 7205 7207 7056 7208 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53709 r0 *1 689.92,811.44
X$53709 9264 7268 9263 8188 8119 8120 7056 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53712 r0 *1 589.12,710.64
X$53712 9264 7061 7056 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $53742 r0 *1 611.52,801.36
X$53742 9263 7114 9264 8062 8102 7056 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $53744 r0 *1 374.08,781.2
X$53744 9264 7056 7899 9263 7897 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $53746 m0 *1 687.68,821.52
X$53746 9264 7056 8187 9263 8188 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $53748 m0 *1 575.68,761.04
X$53748 9263 7744 7665 7114 7551 7056 9264 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $53754 m0 *1 667.52,871.92
X$53754 9264 8073 7058 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $53770 r0 *1 305.76,871.92
X$53770 9264 9263 8576 8540 7058 7706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53772 m0 *1 258.72,811.44
X$53772 9264 9263 8200 8201 7058 7546 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53781 r0 *1 390.88,871.92
X$53781 9264 9263 8583 8544 7058 7738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53783 m0 *1 416.08,882
X$53783 9264 9263 8610 8546 7058 7787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53802 r0 *1 509.04,982.8
X$53802 9264 9263 9157 7060 8930 9090 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53811 r0 *1 594.16,791.28
X$53811 9263 7113 7061 9264 8004 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $53814 r0 *1 585.76,730.8
X$53814 9263 7062 7061 9264 7405 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $53835 m0 *1 421.68,771.12
X$53835 9264 9263 7770 7739 7062 7741 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53838 r0 *1 582.4,740.88
X$53838 7344 9264 7062 7515 9263 7551 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $53840 m0 *1 602,720.72
X$53840 9263 7062 7344 7298 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $53863 r0 *1 706.72,740.88
X$53863 9264 7062 7409 9263 7455 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $53866 m0 *1 704.48,771.12
X$53866 9264 7062 7716 9263 7775 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $53872 r0 *1 600.88,700.56
X$53872 9264 9263 7063 7116 7113 7115 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53889 r0 *1 949.2,700.56
X$53889 9264 9263 7130 7066 7422 7074 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53893 r0 *1 774.48,902.16
X$53893 9264 9263 8737 8728 7067 8498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53895 m0 *1 712.32,841.68
X$53895 9264 8290 7067 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $53918 r0 *1 766.08,902.16
X$53918 9264 9263 8768 8727 7067 8457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53922 m0 *1 859.6,750.96
X$53922 9264 9263 7465 7587 7067 7311 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53924 r0 *1 860.72,791.28
X$53924 9264 9263 7924 8016 7067 7820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53926 m0 *1 851.76,791.28
X$53926 9264 9263 7869 7870 7067 7686 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53928 r0 *1 701.68,892.08
X$53928 9264 9263 8710 8670 7067 8454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53930 r0 *1 733.6,892.08
X$53930 9264 9263 8698 8699 7067 8496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53933 m0 *1 712.32,902.16
X$53933 9264 9263 8740 8696 7067 8594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53944 r0 *1 778.4,710.64
X$53944 9263 7264 9264 7242 7069 7241 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $53946 r0 *1 780.64,720.72
X$53946 9264 7320 9263 7070 7347 7241 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $53949 m0 *1 802.48,700.56
X$53949 9264 9263 7071 7084 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $53956 m0 *1 812,720.72
X$53956 9263 7244 7072 9264 7305 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $53971 r0 *1 286.16,761.04
X$53971 9264 9263 7698 7285 7766 7075 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54022 r0 *1 467.6,811.44
X$54022 9264 7267 9263 8233 8170 8171 7085 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $54026 r0 *1 742.56,761.04
X$54026 9264 7637 7267 7688 7679 7085 7636 7680 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $54030 m0 *1 682.08,730.8
X$54030 9264 7117 7085 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $54053 m0 *1 739.76,740.88
X$54053 9264 9263 7431 7412 7085 7353 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54055 r0 *1 716.8,811.44
X$54055 9264 9263 8011 8123 7085 8189 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54059 r0 *1 686,771.12
X$54059 9264 9263 7779 7805 7085 7860 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54080 m0 *1 406,710.64
X$54080 9264 7156 7088 9263 7206 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $54111 r0 *1 707.84,710.64
X$54111 9264 9263 7092 7268 7269 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $54125 m0 *1 264.88,720.72
X$54125 9264 9263 7278 7099 7279 7096 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54127 m0 *1 236.32,730.8
X$54127 9264 9263 7363 7324 7319 7096 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54160 m0 *1 263.76,750.96
X$54160 9264 9263 7596 7099 7448 7134 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54162 m0 *1 335.44,750.96
X$54162 9264 9263 7500 7099 7443 7101 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54166 r0 *1 291.76,740.88
X$54166 9264 9263 7497 7099 7440 7285 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54171 m0 *1 341.04,720.72
X$54171 9264 9263 7258 7099 7153 7155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54182 r0 *1 263.2,750.96
X$54182 9264 9263 7616 7100 7448 7217 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54184 r0 *1 339.36,750.96
X$54184 9264 9263 7559 7100 7443 7326 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54188 r0 *1 302.96,740.88
X$54188 9264 9263 7499 7100 7440 7441 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54192 r0 *1 329.28,730.8
X$54192 9264 9263 7393 7100 7153 7392 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54196 m0 *1 318.64,761.04
X$54196 9264 9263 7701 7558 7618 7101 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54213 m0 *1 337.12,962.64
X$54213 9264 9263 9015 7101 8989 9027 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54218 r0 *1 411.6,700.56
X$54218 9263 7102 7104 9264 7105 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $54227 m0 *1 411.04,720.72
X$54227 9263 7223 9264 7104 7331 7102 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $54229 m0 *1 401.52,720.72
X$54229 9263 7223 9264 7224 7395 7102 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $54231 r0 *1 388.08,730.8
X$54231 9264 9263 7377 7502 7103 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54240 r0 *1 492.24,720.72
X$54240 9264 7163 9263 7106 7232 7297 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $54245 m0 *1 501.2,720.72
X$54245 9263 7107 7164 9264 7165 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $54247 r0 *1 515.76,730.8
X$54247 9263 7107 7487 9264 7488 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $54255 r0 *1 508.48,700.56
X$54255 9264 7147 9263 7146 7108 7107 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $54261 r0 *1 509.6,730.8
X$54261 9264 9263 7434 7108 7514 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54265 r0 *1 523.04,962.64
X$54265 9264 9263 9078 7110 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $54267 r0 *1 533.68,750.96
X$54267 9264 9263 7626 7611 7542 7110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54270 m0 *1 533.68,750.96
X$54270 9264 9263 7403 7438 7569 7110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54272 r0 *1 548.8,750.96
X$54272 9264 9263 7568 7613 7555 7110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54275 m0 *1 526.4,720.72
X$54275 9264 9263 7273 7233 7274 7110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54279 r0 *1 558.32,730.8
X$54279 9264 9263 7343 7439 7408 7110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54281 r0 *1 566.16,720.72
X$54281 9264 9263 7215 7275 7219 7110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54303 r0 *1 465.92,781.2
X$54303 9264 7936 7113 7905 7855 7234 7904 7935 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $54305 m0 *1 635.6,781.2
X$54305 9264 7113 7794 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $54312 r0 *1 604.8,771.12
X$54312 9264 7747 7113 7749 7796 7234 7798 7748 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $54315 m0 *1 507.36,821.52
X$54315 9264 8280 7113 8177 8237 7234 8238 8178 9263
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $54317 m0 *1 633.92,811.44
X$54317 9264 9263 8061 8117 7113 8185 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54343 r0 *1 618.24,720.72
X$54343 9264 7114 7268 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $54363 m0 *1 466.48,811.44
X$54363 9264 9263 8109 8170 7114 8110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54366 r0 *1 630,801.36
X$54366 9264 9263 8042 8115 7114 8061 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54371 m0 *1 504.56,811.44
X$54371 9264 9263 7960 8215 7114 8280 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54374 m0 *1 606.48,761.04
X$54374 9264 9263 7577 7675 7114 7747 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54390 m0 *1 461.44,821.52
X$54390 9263 7117 8174 9264 8278 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $54392 m0 *1 509.6,781.2
X$54392 9264 7234 7117 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $54426 r0 *1 732.48,750.96
X$54426 9264 9263 7579 7520 7117 7580 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54428 r0 *1 395.36,821.52
X$54428 9264 9263 8229 8165 7117 8155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54431 m0 *1 750.4,791.28
X$54431 9264 9263 7932 7923 7117 7916 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54433 m0 *1 754.88,831.6
X$54433 9264 9263 8295 8296 7117 8262 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54435 r0 *1 747.6,831.6
X$54435 9264 9263 8380 8338 7117 8339 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54458 r0 *1 596.96,851.76
X$54458 9264 9263 8477 8442 7118 8113 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54461 r0 *1 500.64,851.76
X$54461 9264 9263 8473 8438 7118 8400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54463 r0 *1 512.4,851.76
X$54463 9264 9263 8488 8439 7118 7743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54465 m0 *1 527.52,851.76
X$54465 9264 9263 8363 8402 7118 8182 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54467 r0 *1 617.68,861.84
X$54467 9264 9263 8525 8492 7118 8432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54469 r0 *1 443.52,831.6
X$54469 9264 9263 8286 8385 7118 8232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54472 r0 *1 351.12,882
X$54472 9264 9263 8632 8582 7118 8223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54475 r0 *1 342.72,882
X$54475 9264 9263 8631 8651 7118 8164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54478 r0 *1 364.56,882
X$54478 9264 9263 8633 8634 7118 8103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54528 m0 *1 932.96,761.04
X$54528 9264 9263 7127 9325 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $54585 m0 *1 711.2,720.72
X$54585 9264 9263 7269 7176 7267 7128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54614 m0 *1 234.64,750.96
X$54614 9264 9263 7594 7554 7450 7134 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54677 m0 *1 619.36,831.6
X$54677 9264 8290 7148 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $54679 m0 *1 445.76,882
X$54679 9264 9263 8584 8614 7148 8232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54701 m0 *1 610.4,892.08
X$54701 9264 9263 8644 8590 7148 8113 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54704 m0 *1 520.24,892.08
X$54704 9264 9263 8665 8642 7148 8182 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54707 m0 *1 495.04,892.08
X$54707 9264 9263 8664 8680 7148 8400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54709 r0 *1 502.32,871.92
X$54709 9264 9263 8619 8620 7148 7743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54711 r0 *1 404.32,841.68
X$54711 9264 9263 8397 8398 7148 8103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54713 m0 *1 383.04,841.68
X$54713 9264 9263 8396 8383 7148 8164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54715 r0 *1 367.92,841.68
X$54715 9264 9263 8425 8394 7148 8223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54718 r0 *1 628.32,892.08
X$54718 9264 9263 8711 8668 7148 8432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54725 m0 *1 17.92,720.72
X$54725 7252 9263 9264 7150 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $54743 m0 *1 323.68,892.08
X$54743 9264 9263 8659 8676 7151 8037 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54746 m0 *1 332.08,892.08
X$54746 9264 9263 8660 8630 7151 7945 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54749 m0 *1 349.44,902.16
X$54749 9264 9263 8735 8632 7151 7996 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54751 m0 *1 341.6,892.08
X$54751 9264 9263 8677 8631 7151 8227 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54755 r0 *1 336.56,710.64
X$54755 9264 9263 7154 7257 7151 7155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54757 r0 *1 364.56,892.08
X$54757 9264 9263 8661 8633 7151 7952 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54759 r0 *1 318.08,730.8
X$54759 9264 9263 7390 7391 7151 7392 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54763 m0 *1 454.16,892.08
X$54763 9264 9263 8662 8585 7151 7935 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54771 r0 *1 369.6,710.64
X$54771 9264 7172 7153 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $54775 m0 *1 447.44,871.92
X$54775 9264 9263 8547 7158 7153 7935 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54795 r0 *1 570.64,861.84
X$54795 9264 9263 8523 7661 7153 7571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54798 m0 *1 578.48,871.92
X$54798 9264 9263 8573 7402 7153 7748 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54800 r0 *1 538.16,851.76
X$54800 9264 9263 8440 7385 7153 7942 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54802 r0 *1 538.72,871.92
X$54802 9264 9263 8621 7400 7153 8178 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54825 m0 *1 427.84,942.48
X$54825 9264 9263 8900 7155 8813 8901 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54834 m0 *1 390.32,771.12
X$54834 9263 7736 7769 9264 7156 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $54847 m0 *1 400.96,781.2
X$54847 9263 7785 7853 9264 7157 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $54861 m0 *1 448.56,801.36
X$54861 9264 9263 7998 7158 7448 7886 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54864 r0 *1 451.92,851.76
X$54864 9264 9263 8437 7158 7279 7905 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54866 r0 *1 470.4,831.6
X$54866 9264 9263 8362 7158 7662 7957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54869 r0 *1 469.28,861.84
X$54869 9264 9263 8484 7158 7440 7670 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54876 r0 *1 444.64,730.8
X$54876 7398 7399 7397 7396 9263 9264 7159 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $54880 m0 *1 437.92,750.96
X$54880 7605 7160 7547 9264 9263 7787 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $54889 m0 *1 474.88,710.64
X$54889 9264 9263 7161 7162 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $54892 r0 *1 478.8,710.64
X$54892 9263 7162 9264 7229 7271 7230 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $54897 m0 *1 482.72,720.72
X$54897 9263 7162 9264 7270 7232 7230 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $54900 r0 *1 492.24,710.64
X$54900 9264 7163 9263 7164 7271 7297 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $54913 m0 *1 494.48,710.64
X$54913 9264 7211 7165 9263 7166 7167 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $54918 m0 *1 491.68,720.72
X$54918 9263 7297 7232 9264 7166 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $54923 m0 *1 475.44,730.8
X$54923 7292 7340 7339 7381 9264 9263 7167 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $54940 r0 *1 564.48,750.96
X$54940 9264 7570 9263 7443 7574 7172 7571 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $54943 m0 *1 366.8,871.92
X$54943 9264 9263 8542 7508 7172 7952 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54945 r0 *1 638.96,730.8
X$54945 9264 7437 7172 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $54949 m0 *1 648.48,710.64
X$54949 9264 7172 7173 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $54980 r0 *1 351.12,861.84
X$54980 9264 9263 8518 7380 7172 8227 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54982 m0 *1 352.24,871.92
X$54982 9264 9263 8608 7481 7172 7996 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54984 m0 *1 341.6,871.92
X$54984 9264 9263 8541 7286 7172 7945 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55006 r0 *1 780.08,892.08
X$55006 9264 9263 8702 8195 7173 8208 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55009 r0 *1 771.68,892.08
X$55009 9264 9263 8701 8411 7173 8247 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55012 r0 *1 742,892.08
X$55012 9264 9263 8700 8413 7173 8294 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55015 r0 *1 869.12,791.28
X$55015 9264 9263 8017 7922 7173 7812 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55018 r0 *1 852.32,771.12
X$55018 9264 9263 7829 7683 7173 7680 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55021 m0 *1 689.92,892.08
X$55021 9264 9263 8679 8445 7173 7753 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55023 m0 *1 715.12,892.08
X$55023 9264 9263 8709 8414 7173 8070 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55026 r0 *1 651.28,871.92
X$55026 9264 9263 8627 7407 7173 8185 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55028 r0 *1 868.56,750.96
X$55028 9264 9263 7598 7356 7173 7517 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55069 r0 *1 407.12,791.28
X$55069 9263 8030 9264 7985 7405 7178 7982 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $55071 m0 *1 412.72,801.36
X$55071 9264 9263 7178 8030 7995 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55074 m0 *1 743.68,761.04
X$55074 9264 7635 9263 7710 7637 7178 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $55078 m0 *1 623.28,740.88
X$55078 9264 7344 7178 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $55093 m0 *1 736.96,821.52
X$55093 9264 8281 9263 8191 8293 7178 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $55095 m0 *1 624.96,811.44
X$55095 9264 9263 8114 8184 7178 8116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55102 m0 *1 771.12,710.64
X$55102 9264 9263 7181 7264 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $55111 m0 *1 772.8,720.72
X$55111 9263 7240 7304 9264 7182 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $55121 r0 *1 820.4,710.64
X$55121 9264 9263 7244 7184 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $55127 r0 *1 880.32,761.04
X$55127 9264 9263 7685 7768 7187 7686 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55143 m0 *1 718.48,861.84
X$55143 9264 9263 8510 8509 7187 8594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55145 m0 *1 704.48,851.76
X$55145 9264 9263 8474 8446 7187 8454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55148 m0 *1 888.72,841.68
X$55148 9264 8344 7187 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $55151 m0 *1 738.08,851.76
X$55151 9264 9263 8447 8471 7187 8496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55154 m0 *1 777.84,861.84
X$55154 9264 9263 8450 8497 7187 8498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55156 r0 *1 768.88,851.76
X$55156 9264 9263 8468 8467 7187 8457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55158 m0 *1 886.48,740.88
X$55158 9264 9263 7420 7419 7187 7311 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55162 r0 *1 876.4,771.12
X$55162 9264 9263 7761 7819 7187 7820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55168 m0 *1 980.56,730.8
X$55168 7188 9263 9264 7251 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $55171 r0 *1 936.88,710.64
X$55171 9264 9263 7189 7311 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $55175 r0 *1 980.56,720.72
X$55175 7361 9263 9264 7190 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $55178 r0 *1 972.16,720.72
X$55178 7359 9263 9264 7191 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $55181 m0 *1 972.16,720.72
X$55181 7314 9263 9264 7192 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $55274 r0 *1 5.6,720.72
X$55274 7316 9263 9264 7216 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $55276 r0 *1 240.24,761.04
X$55276 9264 9263 7695 7696 7450 7217 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55278 r0 *1 375.2,761.04
X$55278 9264 7217 9263 7667 7444 7735 7282 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55311 m0 *1 569.52,882
X$55311 9264 9263 8552 8553 7219 7743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55313 r0 *1 325.36,882
X$55313 9264 9263 8676 8580 7219 7993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55316 r0 *1 534.8,882
X$55316 9264 9263 8643 8588 7219 8400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55318 m0 *1 535.36,871.92
X$55318 9264 9263 8489 8490 7219 8182 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55320 r0 *1 334.32,882
X$55320 9264 9263 8630 8581 7219 7846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55326 m0 *1 454.16,882
X$55326 9264 9263 8585 8615 7219 8232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55336 m0 *1 646.8,851.76
X$55336 9264 8064 7221 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $55354 m0 *1 338.8,882
X$55354 9264 9263 8581 8541 7221 7546 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55356 r0 *1 350.56,871.92
X$55356 9264 9263 8582 8608 7221 7706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55358 m0 *1 349.44,882
X$55358 9264 9263 8651 8518 7221 7738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55361 m0 *1 365.68,882
X$55361 9264 9263 8634 8542 7221 7787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55372 r0 *1 402.08,710.64
X$55372 9264 9263 7265 7223 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $55376 m0 *1 426.72,720.72
X$55376 9264 9263 7291 7225 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $55379 r0 *1 418.88,720.72
X$55379 9263 7225 9264 7332 7323 7290 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55381 m0 *1 418.88,720.72
X$55381 9263 7225 9264 7322 7226 7290 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55386 m0 *1 433.44,730.8
X$55386 9264 7335 9263 7383 7226 7227 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $55390 m0 *1 433.44,720.72
X$55390 9263 7227 7226 9264 7292 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $55392 r0 *1 435.12,740.88
X$55392 9264 9263 7507 7227 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $55401 r0 *1 436.8,720.72
X$55401 9264 7335 9263 7293 7323 7227 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $55403 m0 *1 437.92,761.04
X$55403 9263 7652 9264 7620 7622 7227 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55405 r0 *1 469.28,720.72
X$55405 9264 7228 9263 7270 7296 7338 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $55408 r0 *1 473.2,730.8
X$55408 9264 7228 9263 7229 7432 7338 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $55416 r0 *1 476.56,720.72
X$55416 9263 7230 7229 9264 7340 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $55418 r0 *1 493.92,750.96
X$55418 9264 9263 7230 7566 7624 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55431 m0 *1 481.04,750.96
X$55431 9263 7230 9264 7510 7548 7565 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55433 m0 *1 496.72,761.04
X$55433 9264 7230 7624 9263 7659 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $55445 r0 *1 608.16,750.96
X$55445 9263 7577 7612 9264 7231 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $55479 m0 *1 495.6,821.52
X$55479 9264 9263 8234 8235 7234 8287 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55481 m0 *1 455.84,791.28
X$55481 9264 9263 7856 7886 7234 7903 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55484 r0 *1 477.68,811.44
X$55484 9264 9263 8172 8037 7234 8173 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55486 m0 *1 602.56,781.2
X$55486 9264 9263 7795 7797 7234 7799 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55494 r0 *1 303.52,730.8
X$55494 9264 7235 7279 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $55497 r0 *1 390.32,791.28
X$55497 9264 8104 9263 7235 8029 7948 8052 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55501 r0 *1 613.2,740.88
X$55501 9264 7235 7451 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $55504 r0 *1 593.6,730.8
X$55504 9264 7406 7235 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $55521 m0 *1 309.68,841.68
X$55521 9264 9263 8392 7380 7235 8228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55524 m0 *1 339.92,851.76
X$55524 9264 9263 8464 7508 7235 8434 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55526 r0 *1 290.64,841.68
X$55526 9264 9263 8421 7481 7235 8104 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55532 m0 *1 573.44,781.2
X$55532 9264 7859 9263 7236 7572 7792 7843 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55534 m0 *1 291.2,791.28
X$55534 9264 7236 7448 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $55538 m0 *1 614.32,720.72
X$55538 9264 7299 7236 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $55543 r0 *1 627.2,710.64
X$55543 9264 7236 7436 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $55558 r0 *1 291.76,801.36
X$55558 9264 9263 8091 7481 7236 8046 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55560 r0 *1 338.24,801.36
X$55560 9264 9263 8050 7508 7236 7951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55562 r0 *1 309.68,801.36
X$55562 9264 9263 8047 7380 7236 8165 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55564 m0 *1 271.6,781.2
X$55564 9264 9263 7848 7286 7236 7729 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55567 r0 *1 651.84,761.04
X$55567 9264 9263 7237 7727 7453 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55569 r0 *1 666.4,740.88
X$55569 9263 7237 7300 9264 7492 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $55589 r0 *1 708.4,982.8
X$55589 7238 9263 9264 9246 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $55599 m0 *1 759.36,750.96
X$55599 7239 7457 7519 7413 9263 9264 7545 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $55601 m0 *1 778.96,720.72
X$55601 9264 9263 7240 7241 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $55603 r0 *1 768.32,720.72
X$55603 9264 9263 7240 7382 7304 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55610 r0 *1 775.04,720.72
X$55610 9264 7240 7304 9263 7346 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $55625 r0 *1 780.08,740.88
X$55625 9264 7460 9263 7242 7461 7458 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $55628 r0 *1 810.88,720.72
X$55628 9263 7350 9264 7305 7376 7243 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55667 r0 *1 978.32,710.64
X$55667 7249 9263 9264 7250 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $55686 m0 *1 856.24,730.8
X$55686 9264 9263 7375 7354 7355 7253 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55719 m0 *1 357.84,720.72
X$55719 9264 9263 7259 7287 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $55724 r0 *1 371.28,720.72
X$55724 7374 9263 7260 7288 9264 7289 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $55732 m0 *1 809.76,730.8
X$55732 9263 7349 9264 7261 7529 7350 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55762 r0 *1 619.36,801.36
X$55762 9264 7267 9263 8006 8163 8102 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $55769 m0 *1 671.44,811.44
X$55769 9264 7794 7267 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $55826 r0 *1 400.4,811.44
X$55826 9264 9263 7785 8230 7268 8169 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55828 r0 *1 772.24,811.44
X$55828 9264 9263 8079 8253 7268 8277 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55830 r0 *1 767.76,781.2
X$55830 9264 9263 7931 7920 7268 7887 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55852 m0 *1 726.88,841.68
X$55852 9264 8344 7274 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $55870 r0 *1 577.36,902.16
X$55870 9264 9263 8751 8722 7274 8182 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55872 m0 *1 571.76,902.16
X$55872 9264 9263 8721 8691 7274 7743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55875 m0 *1 605.36,912.24
X$55875 9264 9263 8752 8753 7274 8113 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55877 r0 *1 509.04,902.16
X$55877 9264 9263 8748 8640 7274 8400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55881 r0 *1 647.36,912.24
X$55881 9264 9263 8788 8756 7274 8432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55884 r0 *1 731.92,912.24
X$55884 9264 9263 8790 8761 7274 8496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55887 r0 *1 714.56,912.24
X$55887 9264 9263 8789 8760 7274 8594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55890 m0 *1 682.08,912.24
X$55890 9264 9263 8770 8758 7274 8454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55892 r0 *1 470.4,882
X$55892 9264 9263 8638 8586 7274 8232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55928 m0 *1 561.12,892.08
X$55928 9264 9263 8667 7661 7279 7673 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55930 m0 *1 551.04,892.08
X$55930 9264 9263 8681 7385 7279 7909 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55932 r0 *1 549.36,871.92
X$55932 9264 9263 8550 7400 7279 8177 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55936 m0 *1 262.64,781.2
X$55936 9264 9263 7847 7286 7279 7783 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55977 r0 *1 283.92,750.96
X$55977 9264 9263 7645 7495 7389 7285 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55999 r0 *1 291.76,771.12
X$55999 9264 9263 7784 7286 7440 7668 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56001 r0 *1 322,781.2
X$56001 9264 9263 7895 7286 7882 7731 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56008 r0 *1 357.28,831.6
X$56008 9264 9263 8381 7286 7443 7899 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56019 r0 *1 414.4,750.96
X$56019 9264 7561 9263 7620 7445 7290 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $56021 r0 *1 414.96,730.8
X$56021 9263 7290 7332 9264 7334 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $56023 r0 *1 403.2,750.96
X$56023 7290 9264 7445 9263 7649 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $56034 m0 *1 405.44,761.04
X$56034 9263 7290 9264 7648 7650 7503 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56050 r0 *1 452.48,730.8
X$56050 9263 7337 9264 7293 7432 7295 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56052 r0 *1 444.64,720.72
X$56052 9263 7295 7293 9264 7294 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $56063 r0 *1 460.88,750.96
X$56063 7295 9264 7622 9263 7608 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $56065 m0 *1 457.52,761.04
X$56065 9264 7509 9263 7657 7622 7295 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $56079 r0 *1 454.16,720.72
X$56079 9263 7337 9264 7383 7296 7295 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56083 m0 *1 445.76,761.04
X$56083 9263 7295 9264 7654 7655 7621 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56090 m0 *1 465.92,730.8
X$56090 9263 7338 7296 9264 7339 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $56093 r0 *1 502.32,730.8
X$56093 9264 9263 7446 7297 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56135 r0 *1 775.04,730.8
X$56135 9264 9263 7414 7304 7459 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56141 m0 *1 812,740.88
X$56141 9263 7349 9264 7306 7526 7350 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56143 m0 *1 817.6,730.8
X$56143 9263 7350 7306 9264 7351 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $56146 r0 *1 822.08,720.72
X$56146 7350 9264 7307 9263 7308 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $56148 m0 *1 819.84,740.88
X$56148 9264 7416 9263 7583 7307 7350 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $56156 m0 *1 839.44,740.88
X$56156 9264 9263 7310 7356 7464 7353 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56193 r0 *1 886.48,740.88
X$56193 9264 9263 7357 7356 7436 7312 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56199 m0 *1 900.48,730.8
X$56199 9264 9263 7313 7345 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $56216 r0 *1 980.56,730.8
X$56216 7360 9263 9264 7315 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $56260 r0 *1 241.92,841.68
X$56260 9264 9263 8419 8420 7319 8173 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56262 m0 *1 267.68,851.76
X$56262 9264 9263 8460 8461 7319 8104 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56264 r0 *1 443.52,851.76
X$56264 9264 9263 8483 8469 7319 7905 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56266 m0 *1 241.92,791.28
X$56266 9264 9263 7893 7844 7319 7783 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56268 r0 *1 318.64,851.76
X$56268 9264 9263 8505 8463 7319 8434 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56272 r0 *1 301.28,841.68
X$56272 9264 9263 8391 8390 7319 8228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56284 m0 *1 407.12,740.88
X$56284 9264 7329 9263 7322 7395 7330 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $56298 m0 *1 645.68,882
X$56298 9264 9263 8653 8626 7325 8432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56316 m0 *1 588,871.92
X$56316 9264 9263 8537 8554 7325 8113 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56318 r0 *1 255.36,841.68
X$56318 9264 9263 8420 8352 7325 7993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56320 m0 *1 253.68,781.2
X$56320 9264 9263 7844 7845 7325 7846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56322 r0 *1 327.04,851.76
X$56322 9264 9263 8463 8435 7325 8103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56325 m0 *1 301.28,841.68
X$56325 9264 9263 8390 8354 7325 8164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56327 m0 *1 280,851.76
X$56327 9264 9263 8461 8389 7325 8223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56332 m0 *1 331.52,771.12
X$56332 9264 9263 7732 7617 7618 7326 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56338 m0 *1 356.16,730.8
X$56338 9264 9263 7326 7373 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56347 m0 *1 355.04,962.64
X$56347 9264 9263 8990 7326 8992 8991 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56351 r0 *1 379.12,730.8
X$56351 9264 9263 7441 7327 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56357 m0 *1 391.44,730.8
X$56357 9264 9263 7328 7377 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56363 m0 *1 408.24,730.8
X$56363 9264 7329 9263 7332 7331 7330 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $56366 r0 *1 405.44,730.8
X$56366 9263 7330 7395 9264 7333 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $56374 r0 *1 410.48,740.88
X$56374 9264 9263 7505 7330 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56377 r0 *1 402.64,740.88
X$56377 9263 7504 9264 7480 7445 7330 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56408 m0 *1 450.8,740.88
X$56408 9264 9263 7336 7337 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56424 r0 *1 473.76,750.96
X$56424 9264 9263 7564 7338 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56426 m0 *1 465.92,761.04
X$56426 9263 7658 9264 7657 7624 7338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56446 r0 *1 664.72,841.68
X$56446 9264 7864 7342 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $56472 r0 *1 258.16,781.2
X$56472 9264 9263 7845 7847 7342 7546 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56474 r0 *1 309.68,841.68
X$56474 9264 9263 8354 8392 7342 7738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56478 r0 *1 282.24,841.68
X$56478 9264 9263 8389 8421 7342 7706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56480 m0 *1 328.16,851.76
X$56480 9264 9263 8435 8464 7342 7787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56493 m0 *1 593.6,740.88
X$56493 9263 7344 7405 9264 7406 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $56519 r0 *1 787.36,740.88
X$56519 9263 7415 9264 7462 7347 7458 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56525 m0 *1 789.6,740.88
X$56525 9263 7415 9264 7463 7348 7458 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56527 m0 *1 806.4,730.8
X$56527 9264 9263 7378 7349 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56568 m0 *1 859.04,922.32
X$56568 9264 9263 8827 8764 7355 8187 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56587 r0 *1 843.36,922.32
X$56587 9264 9263 8853 8826 7355 7970 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56590 r0 *1 834.96,922.32
X$56590 9264 9263 8852 8825 7355 8250 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56593 m0 *1 873.6,912.24
X$56593 9264 9263 8799 8765 7355 8279 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56596 m0 *1 822.08,932.4
X$56596 9264 9263 8851 8824 7355 7752 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56598 r0 *1 651.28,861.84
X$56598 9264 9263 8528 8534 7355 8062 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56600 r0 *1 874.72,801.36
X$56600 9264 9263 8082 8130 7355 7591 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56603 r0 *1 870.8,821.52
X$56603 9264 9263 8311 8312 7355 7918 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56619 r0 *1 902.72,740.88
X$56619 9264 9263 7466 7356 7451 7411 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56627 r0 *1 903.84,750.96
X$56627 9264 9263 7589 7356 7642 7409 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56633 r0 *1 946.4,730.8
X$56633 9264 9263 7472 7411 7422 7359 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56707 r0 *1 810.88,740.88
X$56707 9264 9263 7479 7525 7376 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56719 m0 *1 845.6,882
X$56719 9264 9263 8606 8607 8591 7379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56721 r0 *1 850.08,912.24
X$56721 9264 9263 8797 8798 8220 7379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56723 r0 *1 720.16,902.16
X$56723 9264 9263 8760 8726 8342 7379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56725 m0 *1 854,861.84
X$56725 9264 9263 8504 8500 8268 7379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56727 r0 *1 722.4,871.92
X$56727 9264 9263 8624 8571 8196 7379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56730 m0 *1 787.92,912.24
X$56730 9264 9263 8806 8763 8689 7379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56732 r0 *1 713.44,892.08
X$56732 9264 9263 8696 8709 8491 7379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56748 r0 *1 724.64,851.76
X$56748 9264 9263 8509 8472 8112 7379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56769 m0 *1 387.52,861.84
X$56769 9264 9263 8535 7380 7440 7947 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56775 r0 *1 351.12,811.44
X$56775 9264 9263 8207 7380 7882 8167 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56777 r0 *1 390.32,831.6
X$56777 9264 9263 8358 7380 7443 8328 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56780 m0 *1 391.44,871.92
X$56780 9264 9263 8544 7380 7943 8155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56797 m0 *1 720.16,740.88
X$56797 7454 7433 7486 7483 9264 9263 7384 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $56813 r0 *1 582.96,882
X$56813 9264 9263 8654 7385 8301 7963 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56819 r0 *1 563.36,811.44
X$56819 9264 9263 8179 7385 7448 8002 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56821 m0 *1 577.92,811.44
X$56821 9264 9263 8219 7385 7662 7907 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56824 r0 *1 581.84,841.68
X$56824 9264 9263 8409 7385 7802 8406 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56858 r0 *1 281.68,831.6
X$56858 9264 9263 8284 8379 7389 7978 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56860 r0 *1 301.28,761.04
X$56860 9264 9263 7699 7557 7389 7441 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56862 m0 *1 279.44,791.28
X$56862 9264 9263 7927 7849 7389 7668 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56866 m0 *1 276.64,861.84
X$56866 9264 9263 8503 8478 7389 7958 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56869 r0 *1 379.68,871.92
X$56869 9264 9263 8609 8543 7389 7947 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56871 m0 *1 409.92,871.92
X$56871 9264 9263 8545 8520 7389 8482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56873 r0 *1 477.68,871.92
X$56873 9264 9263 8572 8521 7389 7670 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56955 m0 *1 554.4,841.68
X$56955 9264 9263 8405 7400 7802 8333 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56957 m0 *1 512.96,831.6
X$56957 9264 9263 8319 7400 7662 8239 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56967 m0 *1 548.8,821.52
X$56967 9264 9263 8241 7400 7448 8235 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56969 r0 *1 505.68,740.88
X$56969 9264 7401 9263 7487 7549 7446 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $56971 r0 *1 506.24,730.8
X$56971 9264 9263 7401 7434 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56993 m0 *1 590.8,821.52
X$56993 9264 9263 8243 7402 7662 7676 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56995 m0 *1 608.72,811.44
X$56995 9264 9263 8218 7402 7448 7797 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56998 m0 *1 605.92,902.16
X$56998 9264 9263 8723 7402 8301 7798 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57001 r0 *1 620.48,831.6
X$57001 9264 9263 8384 7402 7802 7629 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57003 m0 *1 625.52,882
X$57003 9264 9263 8625 7402 7642 7799 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57005 m0 *1 617.12,902.16
X$57005 9264 9263 8724 7402 7451 7749 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57050 r0 *1 631.12,831.6
X$57050 9264 9263 8366 7407 7436 8246 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57052 r0 *1 640.08,851.76
X$57052 9264 9263 8513 7407 7662 8062 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57056 m0 *1 624.4,861.84
X$57056 9264 9263 8514 7407 7464 8184 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57058 r0 *1 650.72,841.68
X$57058 9264 9263 8368 7407 7802 8040 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57060 m0 *1 649.04,902.16
X$57060 9264 9263 8725 7407 7451 8118 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57062 r0 *1 633.36,882
X$57062 9264 9263 8645 7407 7642 8116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57065 r0 *1 650.16,892.08
X$57065 9264 9263 8693 7407 8301 8117 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57068 m0 *1 640.64,912.24
X$57068 9264 9263 8808 8772 7408 8432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57071 m0 *1 634.48,831.6
X$57071 9264 8290 7408 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $57073 m0 *1 543.76,902.16
X$57073 9264 9263 8720 8739 7408 8182 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57092 r0 *1 560.56,902.16
X$57092 9264 9263 8750 8690 7408 7743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57094 r0 *1 549.36,902.16
X$57094 9264 9263 8749 8688 7408 8400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57097 m0 *1 281.68,821.52
X$57097 9264 9263 8267 8045 7408 8223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57100 r0 *1 291.76,811.44
X$57100 9264 9263 8203 8205 7408 8164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57102 m0 *1 441.28,851.76
X$57102 9264 9263 8469 8429 7408 8232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57106 m0 *1 328.72,811.44
X$57106 9264 9263 8135 8094 7408 8103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57108 m0 *1 613.76,912.24
X$57108 9264 9263 8754 8755 7408 8113 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57127 m0 *1 712.88,750.96
X$57127 9263 7517 7518 9264 7410 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $57166 m0 *1 778.96,740.88
X$57166 9264 9263 7460 7414 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $57168 r0 *1 780.08,730.8
X$57168 9264 9263 7429 7415 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $57175 m0 *1 808.64,740.88
X$57175 9264 9263 7416 7479 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $57181 r0 *1 813.12,750.96
X$57181 7582 7601 7584 7417 9264 9263 7600 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $57187 m0 *1 819.28,781.2
X$57187 9263 7818 7528 9264 7418 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $57198 m0 *1 951.44,771.12
X$57198 9264 9263 7764 7688 7422 7691 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57207 m0 *1 786.24,952.56
X$57207 9264 9263 8973 8072 7422 8942 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57209 r0 *1 810.88,962.64
X$57209 9264 9263 9060 8192 7422 9141 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57212 r0 *1 802.48,962.64
X$57212 9264 9263 9058 8120 7422 9059 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57215 m0 *1 786.8,962.64
X$57215 9264 9263 9056 7774 7422 9057 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57217 m0 *1 785.68,972.72
X$57217 9264 9263 9107 8214 7422 9101 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57219 m0 *1 943.6,841.68
X$57219 9264 8261 7422 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $57224 r0 *1 933.52,831.6
X$57224 9264 9263 8346 8376 7422 8345 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57226 m0 *1 952.56,781.2
X$57226 9264 9263 7875 7865 7422 7926 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57233 r0 *1 963.76,730.8
X$57233 7423 9263 9264 7424 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $57280 m0 *1 660.8,761.04
X$57280 9263 7435 7453 7456 9264 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $57300 m0 *1 715.68,851.76
X$57300 9264 9263 8472 8414 7436 8031 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57302 r0 *1 888.72,761.04
X$57302 9264 9263 7767 7683 7436 7520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57318 m0 *1 696.08,851.76
X$57318 9264 9263 8444 8445 7436 7806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57320 m0 *1 885.36,791.28
X$57320 9264 9263 7872 7922 7436 7923 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57322 m0 *1 790.16,851.76
X$57322 9264 9263 8466 8195 7436 8296 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57324 m0 *1 747.6,851.76
X$57324 9264 9263 8448 8413 7436 8338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57326 m0 *1 773.92,841.68
X$57326 9264 9263 8412 8411 7436 8032 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57342 m0 *1 419.44,861.84
X$57342 9264 9263 8481 7508 7440 8482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57361 r0 *1 301.28,831.6
X$57361 9264 9263 8347 7481 7440 7978 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57367 m0 *1 521.36,791.28
X$57367 9264 7841 7440 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $57418 m0 *1 292.88,811.44
X$57418 9264 7442 9271 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $57456 m0 *1 404.88,791.28
X$57456 9264 7948 7443 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $57460 r0 *1 427.28,791.28
X$57460 9264 7997 9263 7443 7955 7792 7954 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $57476 r0 *1 406,831.6
X$57476 9264 9263 8359 7508 7443 7997 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57479 r0 *1 371.28,831.6
X$57479 9264 9263 8382 7481 7443 8052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57493 m0 *1 508.48,750.96
X$57493 9264 9263 7446 7514 7513 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $57501 m0 *1 513.52,750.96
X$57501 9264 7446 7513 9263 7567 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $57506 r0 *1 550.48,892.08
X$57506 9264 9263 8688 8550 8689 7447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57508 m0 *1 537.04,882
X$57508 9264 9263 8588 8621 8491 7447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57510 r0 *1 551.04,821.52
X$57510 9264 9263 8289 8241 8112 7447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57513 m0 *1 504.56,831.6
X$57513 9264 9263 8331 8319 7619 7447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57526 r0 *1 551.6,841.68
X$57526 9264 9263 8404 8405 7498 7447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57528 r0 *1 500.64,882
X$57528 9264 9263 8680 8639 8591 7447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57563 m0 *1 577.36,791.28
X$57563 9264 9263 7966 7661 7448 7859 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57569 m0 *1 577.92,750.96
X$57569 9264 9263 7575 7449 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $57602 m0 *1 440.16,801.36
X$57602 9264 9263 8055 8056 7450 7886 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57604 r0 *1 283.36,811.44
X$57604 9264 9263 8270 8203 7450 8165 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57606 r0 *1 273.28,811.44
X$57606 9264 9263 8266 8267 7450 8046 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57608 m0 *1 284.48,811.44
X$57608 9264 9263 8092 8135 7450 7951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57611 r0 *1 250.32,771.12
X$57611 9264 9263 7824 7826 7450 7729 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57613 m0 *1 244.16,801.36
X$57613 9264 9263 8043 8024 7450 7999 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57620 m0 *1 799.68,902.16
X$57620 9264 9263 8736 8445 7451 7774 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57634 m0 *1 790.16,902.16
X$57634 9264 9263 8729 8413 7451 8214 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57636 r0 *1 788.48,902.16
X$57636 9264 9263 8763 8414 7451 8072 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57638 r0 *1 813.68,892.08
X$57638 9264 9263 8704 8195 7451 8192 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57641 r0 *1 822.08,892.08
X$57641 9264 9263 8703 8411 7451 8120 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57645 r0 *1 903.84,781.2
X$57645 9264 9263 7873 7922 7451 7865 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57650 m0 *1 904.4,771.12
X$57650 9264 9263 7762 7683 7451 7688 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57663 r0 *1 650.72,982.8
X$57663 7452 9263 9264 9237 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $57671 m0 *1 694.4,740.88
X$57671 9264 7490 7453 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $57673 r0 *1 708.96,761.04
X$57673 9264 7453 9263 7678 7715 7735 7679 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $57691 m0 *1 696.08,771.12
X$57691 9264 9263 7778 7753 7453 7774 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57693 m0 *1 605.36,791.28
X$57693 9264 9263 7911 7798 7453 7796 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57709 r0 *1 490.56,801.36
X$57709 9264 7999 9263 7801 8100 7456 8174 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $57727 r0 *1 794.08,750.96
X$57727 9263 7458 7463 9264 7602 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $57729 r0 *1 784,750.96
X$57729 7458 9264 7461 9263 7813 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $57741 r0 *1 773.92,750.96
X$57741 9263 7458 9264 7639 7459 7581 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $57752 m0 *1 783.44,771.12
X$57752 9263 7755 9264 7756 7461 7522 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $57756 m0 *1 786.8,750.96
X$57756 9264 7521 9263 7462 7523 7522 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $57759 r0 *1 789.6,761.04
X$57759 9264 7521 9263 7463 7833 7522 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $57765 m0 *1 716.24,871.92
X$57765 9264 9263 8571 8414 7464 8189 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57782 r0 *1 773.92,871.92
X$57782 9264 9263 8596 8411 7464 8009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57786 r0 *1 782.32,871.92
X$57786 9264 9263 8559 8195 7464 8127 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57789 m0 *1 738.64,871.92
X$57789 9264 9263 8556 8413 7464 8336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57792 m0 *1 614.88,781.2
X$57792 9264 7882 7464 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $57796 m0 *1 829.36,811.44
X$57796 9264 9263 8139 7683 7464 7679 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57798 r0 *1 822.08,811.44
X$57798 9264 9263 8274 7922 7464 7862 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57800 r0 *1 689.36,871.92
X$57800 9264 9263 8593 8445 7464 7860 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57808 r0 *1 981.68,740.88
X$57808 7468 9263 9264 7686 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $57812 r0 *1 979.44,750.96
X$57812 7592 9263 9264 7469 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $57814 r0 *1 964.32,740.88
X$57814 7531 9263 9264 7470 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $57874 m0 *1 316.96,871.92
X$57874 9264 9263 8540 7481 7943 8054 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57883 r0 *1 328.72,811.44
X$57883 9264 9263 8224 7481 7882 8051 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57928 m0 *1 545.44,811.44
X$57928 9264 7493 8196 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $57948 m0 *1 351.12,811.44
X$57948 9264 9263 8138 8207 7493 7738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57951 m0 *1 423.36,811.44
X$57951 9264 9263 8106 8107 7493 7787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57959 r0 *1 644.56,781.2
X$57959 9264 7803 7494 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $57980 r0 *1 283.36,801.36
X$57980 9264 9263 8045 8091 7494 7706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57986 r0 *1 327.6,801.36
X$57986 9264 9263 8094 8050 7494 7787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57990 r0 *1 266.56,781.2
X$57990 9264 9263 7894 7848 7494 7546 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57993 r0 *1 308,811.44
X$57993 9264 9263 8205 8047 7494 7738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57999 m0 *1 624.4,841.68
X$57999 9264 8290 7496 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $58017 m0 *1 281.12,871.92
X$58017 9264 9263 8478 8479 7496 7993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58019 r0 *1 588,821.52
X$58019 9264 9263 8323 8324 7496 8113 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58021 r0 *1 412.16,861.84
X$58021 9264 9263 8520 8536 7496 8103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58024 r0 *1 632.8,861.84
X$58024 9264 9263 8534 8493 7496 8432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58027 m0 *1 280.56,781.2
X$58027 9264 9263 7849 7880 7496 7846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58029 m0 *1 283.36,841.68
X$58029 9264 9263 8379 8326 7496 8223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58032 m0 *1 383.04,871.92
X$58032 9264 9263 8543 8519 7496 8164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58060 r0 *1 291.76,831.6
X$58060 9264 9263 8326 8347 7498 7706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58064 m0 *1 288.96,781.2
X$58064 9264 9263 7880 7784 7498 7546 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58073 r0 *1 553.84,771.12
X$58073 9264 9263 7777 7793 7498 7671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58087 r0 *1 388.64,750.96
X$58087 9264 9263 7505 7560 7502 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58089 r0 *1 395.92,750.96
X$58089 9263 7505 7502 9264 7648 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58093 m0 *1 390.32,750.96
X$58093 9264 7505 7502 9263 7603 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $58095 m0 *1 402.08,761.04
X$58095 9264 9263 7503 7504 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $58112 m0 *1 420,761.04
X$58112 9264 9263 7562 7506 7650 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58114 r0 *1 437.36,750.96
X$58114 9263 7507 7506 9264 7654 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58118 r0 *1 431.76,750.96
X$58118 9264 7507 7506 9263 7605 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $58121 m0 *1 432.88,750.96
X$58121 9264 9263 7507 7547 7506 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58162 m0 *1 428.96,831.6
X$58162 9264 9263 8329 7508 7792 7954 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58167 r0 *1 424.48,811.44
X$58167 9264 9263 8107 7508 7882 8156 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58169 m0 *1 418.32,871.92
X$58169 9264 9263 8546 7508 7943 7900 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58172 m0 *1 455.84,750.96
X$58172 9264 9263 7509 7563 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $58179 r0 *1 477.12,750.96
X$58179 9263 7564 7623 9264 7510 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58182 m0 *1 490,750.96
X$58182 9264 9263 7511 7512 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $58187 r0 *1 502.32,750.96
X$58187 9264 9263 7512 7549 7566 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58189 m0 *1 502.32,750.96
X$58189 9264 9263 7512 7513 7548 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58204 r0 *1 491.12,871.92
X$58204 9264 9263 8618 8619 8562 7515 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58284 m0 *1 789.04,761.04
X$58284 9263 7522 7523 9264 7641 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $58287 r0 *1 785.68,761.04
X$58287 9264 9263 7640 7522 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $58292 m0 *1 790.72,781.2
X$58292 9263 7814 9264 7884 7523 7816 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $58299 m0 *1 814.24,750.96
X$58299 9264 7524 9263 7528 7526 7527 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $58301 r0 *1 814.24,761.04
X$58301 9264 7524 9263 7758 7529 7527 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $58304 m0 *1 822.08,771.12
X$58304 9263 7682 7525 9264 7759 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58309 m0 *1 820.4,761.04
X$58309 9263 7527 7525 9264 7703 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $58315 r0 *1 825.44,750.96
X$58315 9263 7527 7529 9264 7584 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $58323 r0 *1 821.52,750.96
X$58323 9264 9263 7682 7527 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $58325 r0 *1 824.32,761.04
X$58325 9263 7705 9264 7583 7760 7527 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $58330 r0 *1 813.68,781.2
X$58330 9263 7817 9264 7528 7983 7818 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $58347 r0 *1 972.16,761.04
X$58347 7690 9263 9264 7532 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $58350 m0 *1 980.56,761.04
X$58350 7692 9263 9264 7533 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $58404 r0 *1 500.64,831.6
X$58404 9264 9263 8350 8331 7542 8400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58406 r0 *1 572.32,811.44
X$58406 9264 9263 8180 8181 7542 8182 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58408 m0 *1 572.88,841.68
X$58408 9264 8290 7542 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $58411 r0 *1 462,831.6
X$58411 9264 9263 8361 8330 7542 8232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58417 r0 *1 352.8,841.68
X$58417 9264 9263 8424 8393 7542 7846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58419 m0 *1 336.56,841.68
X$58419 9264 9263 8356 8357 7542 7993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58421 m0 *1 512.4,771.12
X$58421 9264 9263 7772 7773 7542 7743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58440 m0 *1 355.6,841.68
X$58440 9264 9263 8393 8381 7619 7546 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58496 r0 *1 560.56,821.52
X$58496 9264 9263 8321 8242 7555 8182 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58521 m0 *1 574,821.52
X$58521 9264 8290 7555 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $58527 m0 *1 252.56,801.36
X$58527 9264 9263 8024 8025 7555 7993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58529 m0 *1 445.2,821.52
X$58529 9264 9263 8056 8108 7555 8232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58531 m0 *1 260.4,791.28
X$58531 9264 9263 7826 7894 7555 7846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58534 r0 *1 567.84,791.28
X$58534 9264 9263 7965 7992 7555 7743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58536 r0 *1 547.68,831.6
X$58536 9264 9263 8288 8289 7555 8400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58548 r0 *1 421.68,750.96
X$58548 9264 9263 7561 7562 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $58556 r0 *1 455.28,750.96
X$58556 9264 9263 7563 7623 7655 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58560 r0 *1 483.28,761.04
X$58560 9264 9263 7564 7711 7623 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58566 m0 *1 476,761.04
X$58566 9264 7564 7623 9263 7709 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $58570 r0 *1 470.4,750.96
X$58570 9264 9263 7565 7658 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $58589 m0 *1 554.4,771.12
X$58589 9264 9263 7718 7777 7569 7743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58611 m0 *1 551.6,851.76
X$58611 9264 9263 8441 8404 7569 8400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58613 r0 *1 576.24,851.76
X$58613 9264 9263 8408 8476 7569 8182 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58615 r0 *1 612.08,831.6
X$58615 9264 9263 8245 8365 7569 8113 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58618 m0 *1 658,841.68
X$58618 9264 9263 8369 8335 7569 8432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58620 r0 *1 477.68,861.84
X$58620 9264 9263 8521 8485 7569 8232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58623 m0 *1 697.76,841.68
X$58623 9264 8290 7569 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $58627 r0 *1 688.8,882
X$58627 9264 9263 8628 8652 7569 8454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58630 m0 *1 711.76,882
X$58630 9264 9263 8555 8624 7569 8594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58632 r0 *1 731.92,871.92
X$58632 9264 9263 8569 8623 7569 8496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58634 m0 *1 504,771.12
X$58634 9264 9263 7742 7772 7618 7570 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58636 r0 *1 518.56,761.04
X$58636 9264 9263 7713 7661 7662 7570 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58654 r0 *1 411.04,962.64
X$58654 9264 9263 9032 7570 8989 9128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58670 m0 *1 561.68,871.92
X$58670 9264 9263 8551 8552 8511 7571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58674 m0 *1 553.84,932.4
X$58674 9264 9263 8893 7571 8813 8839 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58678 r0 *1 574,750.96
X$58678 7572 9263 7574 7665 9264 7573 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $58689 m0 *1 558.32,781.2
X$58689 9264 9263 7793 7661 7802 7575 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58692 r0 *1 556.64,761.04
X$58692 9264 9263 7720 7718 7610 7575 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58703 m0 *1 571.76,982.8
X$58703 9264 9263 9160 7575 8992 9135 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58706 r0 *1 589.12,750.96
X$58706 7615 7628 7576 7614 7722 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $58719 r0 *1 667.52,982.8
X$58719 7578 9263 9264 9183 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $58723 m0 *1 733.04,750.96
X$58723 9264 9263 7579 7606 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $58728 m0 *1 903.28,761.04
X$58728 9264 9263 7702 7683 7642 7580 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58740 r0 *1 782.32,761.04
X$58740 9264 9263 7581 7755 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $58751 r0 *1 802.48,781.2
X$58751 9263 7816 7815 9264 7582 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $58781 r0 *1 752.64,750.96
X$58781 9264 9263 7591 7604 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $58838 m0 *1 806.96,781.2
X$58838 9263 7866 7867 9264 7601 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $58874 r0 *1 706.16,841.68
X$58874 9264 9263 8427 7607 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $58889 r0 *1 573.44,841.68
X$58889 9264 9263 8407 8408 7610 8406 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58891 r0 *1 873.6,861.84
X$58891 9264 9263 8531 8502 7610 8078 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58915 r0 *1 845.04,841.68
X$58915 9264 9263 8416 8455 7610 8272 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58917 m0 *1 824.32,861.84
X$58917 9264 9263 8506 8499 7610 8427 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58919 m0 *1 554.4,861.84
X$58919 9264 9263 8512 8441 7610 8333 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58922 m0 *1 612.08,821.52
X$58922 9264 9263 8244 8245 7610 7629 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58924 r0 *1 641.2,841.68
X$58924 9264 9263 8367 8369 7610 8040 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58927 m0 *1 865.76,851.76
X$58927 9264 9263 8423 8462 7610 8018 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58929 m0 *1 874.16,841.68
X$58929 9264 9263 8378 8375 7610 8376 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58979 m0 *1 491.12,831.6
X$58979 9264 9263 8351 8350 7618 8239 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58981 r0 *1 570.64,821.52
X$58981 9264 9263 8322 8323 7618 7676 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58983 m0 *1 569.52,811.44
X$58983 9264 9263 8059 8180 7618 7907 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58987 m0 *1 460.88,841.68
X$58987 9264 9263 8387 8361 7618 7957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58991 r0 *1 332.64,831.6
X$58991 9264 9263 8355 8356 7618 8057 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59015 m0 *1 373.52,841.68
X$59015 9264 9263 8394 8382 7619 7706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59022 r0 *1 510.16,761.04
X$59022 9264 9263 7773 7713 7619 7671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59024 r0 *1 415.52,831.6
X$59024 9264 7800 7619 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $59034 m0 *1 434.56,761.04
X$59034 9264 9263 7621 7652 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $59066 m0 *1 617.12,882
X$59066 9264 9263 8590 8625 8591 7627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59068 m0 *1 613.2,841.68
X$59068 9264 9263 8365 8384 8268 7627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59070 m0 *1 589.68,831.6
X$59070 9264 9263 8324 8243 8220 7627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59072 r0 *1 601.44,811.44
X$59072 9264 9263 8183 8218 8112 7627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59074 r0 *1 579.6,871.92
X$59074 9264 9263 8554 8573 8491 7627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59077 r0 *1 616,902.16
X$59077 9264 9263 8755 8724 8689 7627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59080 r0 *1 606.48,902.16
X$59080 9264 9263 8753 8723 8342 7627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59083 m0 *1 590.8,851.76
X$59083 9264 9263 8442 8364 8196 7627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59105 m0 *1 716.8,761.04
X$59105 7653 7628 7714 7634 7656 9263 9264 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $59107 r0 *1 464.8,771.12
X$59107 9264 9263 7628 7838 7791 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $59127 m0 *1 614.88,761.04
X$59127 9264 7629 7630 9263 7663 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $59130 r0 *1 624.4,962.64
X$59130 9264 9263 9006 7629 8930 9045 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59139 m0 *1 486.08,791.28
X$59139 9264 7958 7630 9263 7906 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $59141 m0 *1 665.28,781.2
X$59141 9264 7889 7630 9263 7840 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $59178 m0 *1 898.24,771.12
X$59178 9264 9263 7821 7638 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $59187 m0 *1 783.44,811.44
X$59187 9263 7640 8144 9264 7639 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $59192 r0 *1 786.24,811.44
X$59192 9264 9263 7640 8254 8144 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $59197 m0 *1 786.8,821.52
X$59197 9264 7640 8144 9263 8255 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $59206 r0 *1 621.6,791.28
X$59206 9264 7943 7642 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $59208 m0 *1 828.8,882
X$59208 9264 9263 8611 8445 7642 7716 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59218 m0 *1 876.96,882
X$59218 9264 9263 8648 8195 7642 8262 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59220 r0 *1 876.96,871.92
X$59220 9264 9263 8565 8411 7642 8066 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59223 r0 *1 847.28,871.92
X$59223 9264 9263 8607 8414 7642 8010 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59226 r0 *1 838.32,882
X$59226 9264 9263 8647 8413 7642 8339 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59228 r0 *1 903.28,791.28
X$59228 9264 9263 7977 7922 7642 7916 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59302 r0 *1 534.8,841.68
X$59302 9264 9263 8402 8403 8196 7660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59304 m0 *1 542.08,861.84
X$59304 9264 9263 8490 8440 8491 7660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59306 m0 *1 559.44,821.52
X$59306 9264 9263 8242 8179 8112 7660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59309 r0 *1 580.72,811.44
X$59309 9264 9263 8181 8219 8220 7660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59312 r0 *1 526.4,882
X$59312 9264 9263 8642 8587 8591 7660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59314 m0 *1 580.16,902.16
X$59314 9264 9263 8722 8654 8342 7660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59317 m0 *1 552.16,902.16
X$59317 9264 9263 8739 8681 8689 7660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59320 r0 *1 584.64,851.76
X$59320 9264 9263 8476 8409 8268 7660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59364 m0 *1 580.16,892.08
X$59364 9264 9263 8712 7661 8301 7843 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59373 r0 *1 831.6,791.28
X$59373 9264 7948 7662 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $59399 m0 *1 847.28,912.24
X$59399 9264 9263 8798 8414 7662 7970 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59402 m0 *1 838.88,912.24
X$59402 9264 9263 8795 8413 7662 8250 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59405 r0 *1 824.88,912.24
X$59405 9264 9263 8800 8445 7662 7752 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59416 m0 *1 631.12,892.08
X$59416 9264 9263 8668 8645 8591 7664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59419 m0 *1 649.04,912.24
X$59419 9264 9263 8756 8693 8342 7664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59421 r0 *1 642.88,871.92
X$59421 9264 9263 8626 8627 8491 7664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59423 r0 *1 647.92,831.6
X$59423 9264 9263 8335 8368 8268 7664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59425 m0 *1 635.6,861.84
X$59425 9264 9263 8493 8513 8220 7664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59427 r0 *1 627.2,841.68
X$59427 9264 9263 8433 8366 8112 7664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59429 m0 *1 616,861.84
X$59429 9264 9263 8492 8514 8196 7664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59447 r0 *1 646.8,902.16
X$59447 9264 9263 8772 8725 8689 7664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59462 m0 *1 686,781.2
X$59462 9264 7806 9263 7667 7721 7735 7860 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59467 r0 *1 636.72,811.44
X$59467 9264 8246 9263 7667 8101 7735 8184 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59469 r0 *1 376.32,811.44
X$59469 9264 8165 9263 7667 8273 7735 8167 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59471 r0 *1 706.16,811.44
X$59471 9264 8031 9263 7667 8190 7735 8189 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59508 m0 *1 451.36,982.8
X$59508 9264 9263 9129 7670 8992 9130 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59516 m0 *1 570.08,871.92
X$59516 9264 9263 8553 8523 8491 7671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59519 r0 *1 562.24,892.08
X$59519 9264 9263 8690 8667 8689 7671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59522 r0 *1 576.24,791.28
X$59522 9264 9263 7992 7966 8112 7671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59524 r0 *1 510.72,871.92
X$59524 9264 9263 8620 8549 8591 7671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59527 r0 *1 578.48,892.08
X$59527 9264 9263 8691 8712 8342 7671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59552 m0 *1 578.48,771.12
X$59552 9264 9263 7744 7745 7794 7673 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59565 r0 *1 560.56,912.24
X$59565 9264 9263 8783 8750 8757 7673 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59573 r0 *1 602,761.04
X$59573 9264 9263 7795 7674 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $59580 r0 *1 614.32,761.04
X$59580 9264 9263 7676 7723 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $59593 r0 *1 431.2,962.64
X$59593 9264 9263 9071 7676 8989 9084 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59598 r0 *1 539.28,821.52
X$59598 9264 9263 8320 8288 7677 8235 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59618 m0 *1 558.88,831.6
X$59618 9264 9263 8332 8321 7677 8002 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59620 m0 *1 617.68,851.76
X$59620 9264 9263 8443 8410 7677 8246 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59623 r0 *1 600.32,801.36
X$59623 9264 9263 8005 8060 7677 7797 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59626 m0 *1 687.68,851.76
X$59626 9264 9263 8475 8474 7677 7806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59628 r0 *1 736.4,851.76
X$59628 9264 9263 8495 8447 7677 8338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59630 m0 *1 710.08,861.84
X$59630 9264 9263 8494 8510 7677 8031 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59632 m0 *1 567.84,791.28
X$59632 9264 9263 7910 7965 7677 7859 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59634 r0 *1 760.48,851.76
X$59634 9264 9263 8449 8468 7677 8032 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59636 m0 *1 773.36,851.76
X$59636 9264 9263 8428 8450 7677 8296 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59675 r0 *1 773.36,771.12
X$59675 7809 7810 7811 7681 9263 9264 7771 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $59701 r0 *1 870.24,811.44
X$59701 9264 9263 8202 8204 8220 7684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59703 m0 *1 820.96,811.44
X$59703 9264 9263 8206 8139 8196 7684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59705 r0 *1 903.28,811.44
X$59705 9264 9263 8134 8199 8268 7684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59783 m0 *1 978.88,771.12
X$59783 7691 9263 9264 7694 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $59793 m0 *1 939.12,771.12
X$59793 7693 9263 9264 7820 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $59839 r0 *1 810.88,761.04
X$59839 9264 9263 7757 7705 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $59919 r0 *1 832.16,892.08
X$59919 9264 9263 8705 8646 8562 7716 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59966 r0 *1 637.28,761.04
X$59966 9264 7728 7735 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $60038 r0 *1 392.56,781.2
X$60038 9264 9263 7947 7737 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60062 m0 *1 391.44,841.68
X$60062 9264 9263 8383 8358 7800 7738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60070 r0 *1 413.84,841.68
X$60070 9264 9263 8434 7739 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60078 r0 *1 419.44,781.2
X$60078 9264 9263 7900 7740 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60085 m0 *1 433.44,811.44
X$60085 9264 9263 8156 7741 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60100 m0 *1 540.96,962.64
X$60100 9264 9263 9002 7743 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $60120 m0 *1 509.6,861.84
X$60120 9264 9263 8487 8488 8370 7745 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60144 r0 *1 589.68,861.84
X$60144 9264 9263 8524 8537 8511 7748 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60161 m0 *1 576.24,942.48
X$60161 9264 9263 8923 7748 8813 8907 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60164 r0 *1 618.24,912.24
X$60164 9264 9263 8786 8754 8757 7749 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60207 r0 *1 690.48,892.08
X$60207 9264 9263 8695 8710 8511 7753 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60216 r0 *1 787.92,801.36
X$60216 9264 8012 9263 7756 8080 7816 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $60221 r0 *1 818.72,771.12
X$60221 9263 7818 9264 7759 7981 7757 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60227 r0 *1 810.88,771.12
X$60227 9263 7817 9264 7758 7867 7818 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60231 m0 *1 815.36,801.36
X$60231 9264 8015 9263 8093 7760 7818 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $60235 m0 *1 823.2,801.36
X$60235 7818 9264 7760 9263 8027 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $60252 r0 *1 285.6,942.48
X$60252 9264 8863 7766 9263 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $60274 r0 *1 488.32,952.56
X$60274 9264 9263 8986 8235 7766 8999 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60278 m0 *1 509.6,962.64
X$60278 9264 9263 9022 8002 7766 9000 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60280 r0 *1 603.12,962.64
X$60280 9264 9263 9041 7797 7766 9042 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60282 m0 *1 565.6,952.56
X$60282 9264 9263 8987 7859 7766 8936 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60284 m0 *1 457.52,962.64
X$60284 9264 9263 8998 7905 7766 9034 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60286 m0 *1 307.44,982.8
X$60286 9264 9263 9123 8173 7766 9124 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60288 m0 *1 618.24,952.56
X$60288 9264 9263 8966 8246 7766 8967 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60316 m0 *1 800.24,932.4
X$60316 9264 9263 8848 8849 8757 7774 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60393 m0 *1 403.76,841.68
X$60393 9264 9263 8398 8359 7800 7787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60395 r0 *1 430.08,831.6
X$60395 9264 9263 8360 8329 8065 7787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60430 m0 *1 460.88,781.2
X$60430 9264 9263 7856 7790 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60435 m0 *1 650.16,781.2
X$60435 9264 7913 7792 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $60442 r0 *1 396.48,801.36
X$60442 9264 8054 9263 7943 7949 7792 8053 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $60445 m0 *1 672.56,831.6
X$60445 9264 7792 8301 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $60471 m0 *1 671.44,821.52
X$60471 9264 9263 8007 8248 7794 8247 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60481 r0 *1 630,811.44
X$60481 9263 7794 8246 9264 8115 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60511 m0 *1 472.08,821.52
X$60511 9264 9263 8110 8278 7794 8172 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60522 m0 *1 600.32,851.76
X$60522 9264 9263 8431 8477 8370 7796 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60553 m0 *1 600.88,962.64
X$60553 9264 9263 9004 7798 8930 9005 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60556 m0 *1 602.56,922.32
X$60556 9264 9263 8785 7798 8529 8752 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60566 m0 *1 608.72,882
X$60566 9264 9263 8589 8644 8562 7799 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60582 r0 *1 628.88,821.52
X$60582 9264 7800 8220 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $60621 r0 *1 855.12,851.76
X$60621 9264 9263 8500 8414 7802 8018 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60623 r0 *1 836.64,841.68
X$60623 9264 9263 8415 8413 7802 8272 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60625 r0 *1 826.56,851.76
X$60625 9264 9263 8451 8445 7802 8427 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60628 r0 *1 652.96,771.12
X$60628 9264 7841 7802 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $60634 m0 *1 875.84,851.76
X$60634 9264 9263 8456 8195 7802 8078 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60636 r0 *1 876.4,841.68
X$60636 9264 9263 8422 8411 7802 8376 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60639 m0 *1 668.64,801.36
X$60639 9264 7803 8112 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $60672 m0 *1 671.44,912.24
X$60672 9264 9263 8771 7805 8529 8770 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60675 r0 *1 682.08,892.08
X$60675 9264 9263 8694 8445 8301 7805 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60697 m0 *1 743.68,781.2
X$60697 9263 7890 7915 9264 7808 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60716 r0 *1 772.8,801.36
X$60716 9263 8079 8096 9264 7810 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60722 m0 *1 773.36,791.28
X$60722 9263 7931 7984 9264 7811 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60742 m0 *1 786.8,781.2
X$60742 9264 9263 7834 7814 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60747 r0 *1 791.84,771.12
X$60747 9263 7814 9264 7815 7833 7816 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60749 m0 *1 799.68,791.28
X$60749 9264 7921 9263 7815 7983 7866 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $60756 r0 *1 792.96,811.44
X$60756 7816 9264 8080 9263 8298 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $60762 m0 *1 799.68,811.44
X$60762 9263 7816 9264 8140 8141 8013 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60769 m0 *1 810.32,791.28
X$60769 9264 9263 7972 7817 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60825 r0 *1 980.56,781.2
X$60825 7877 9263 9264 7822 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $60828 m0 *1 972.16,791.28
X$60828 7926 9263 9264 7823 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $60863 m0 *1 364.56,791.28
X$60863 9263 7930 7850 9264 7832 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60900 m0 *1 516.32,791.28
X$60900 9264 9263 7961 7988 7841 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60917 r0 *1 544.32,801.36
X$60917 9264 9263 8406 7842 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60928 r0 *1 568.96,902.16
X$60928 9264 9263 8773 7843 8529 8721 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60932 r0 *1 574,952.56
X$60932 9264 9263 8964 7843 8930 9003 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60950 r0 *1 361.76,942.48
X$60950 9264 9263 8977 7846 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $61039 m0 *1 673.68,882
X$61039 9264 9263 8592 8628 8370 7860 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61079 m0 *1 812,831.6
X$61079 9264 9263 8341 7922 8301 7863 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61096 r0 *1 673.68,882
X$61096 9264 7864 8689 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $61122 r0 *1 809.2,801.36
X$61122 9264 9263 8128 7866 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61128 r0 *1 799.68,801.36
X$61128 9263 8095 9264 8093 8080 7866 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61131 m0 *1 799.68,781.2
X$61131 9264 7921 9263 7884 7867 7866 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $61149 m0 *1 865.2,821.52
X$61149 9264 9263 8259 8271 8220 7871 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61153 m0 *1 824.88,821.52
X$61153 9264 9263 8257 8274 8196 7871 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61167 m0 *1 905.52,821.52
X$61167 9264 9263 8307 8269 8268 7871 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61170 r0 *1 813.12,831.6
X$61170 9264 9263 8300 8341 8342 7871 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61228 r0 *1 599.76,781.2
X$61228 9264 7939 7882 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $61327 r0 *1 330.4,781.2
X$61327 9264 9263 7978 7898 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61346 m0 *1 364.56,962.64
X$61346 9264 9263 8976 7899 8989 8959 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61364 r0 *1 426.72,851.76
X$61364 9264 9263 8482 7901 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61423 r0 *1 445.76,952.56
X$61423 9264 9263 8931 7907 8989 8951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61441 r0 *1 540.96,902.16
X$61441 9264 9263 8719 8720 8757 7909 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61455 r0 *1 636.16,791.28
X$61455 9264 9263 8040 7912 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $61479 r0 *1 757.12,781.2
X$61479 9264 9263 7932 7917 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61485 r0 *1 762.16,781.2
X$61485 9264 9263 7918 7919 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61592 m0 *1 472.64,791.28
X$61592 9264 9263 7957 7934 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61641 m0 *1 533.68,861.84
X$61641 9264 9263 8522 8489 8511 7942 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61652 r0 *1 540.4,942.48
X$61652 9264 9263 8950 7942 8813 8935 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61669 r0 *1 599.2,791.28
X$61669 9264 7967 7943 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $61709 m0 *1 360.64,922.32
X$61709 9264 9263 8814 7945 8813 8836 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61729 r0 *1 383.6,932.4
X$61729 9264 9263 8884 7947 8813 8864 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61750 r0 *1 399.28,791.28
X$61750 7949 9263 8029 7985 9264 7950 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $61790 r0 *1 376.88,922.32
X$61790 9264 9263 8858 7952 8813 8815 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61814 m0 *1 421.12,952.56
X$61814 9264 9263 8979 7954 8930 8963 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61831 m0 *1 460.88,982.8
X$61831 9264 9263 9086 7957 8992 9021 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61847 m0 *1 333.2,972.72
X$61847 9264 9263 9080 7958 8989 9081 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61853 m0 *1 532,831.6
X$61853 9264 9263 8333 7961 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61861 r0 *1 520.24,892.08
X$61861 9264 9263 8687 8665 8562 7962 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61885 m0 *1 507.36,982.8
X$61885 9264 9263 9131 7963 8930 9089 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61888 r0 *1 572.88,912.24
X$61888 9264 9263 8784 7963 8529 8751 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61901 r0 *1 642.32,791.28
X$61901 7968 9263 8039 8041 9264 7989 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $61925 m0 *1 857.36,801.36
X$61925 9264 9263 8018 7971 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $61934 m0 *1 980.56,791.28
X$61934 7973 9263 9264 7974 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $61975 r0 *1 814.8,801.36
X$61975 9264 9263 8014 8129 7981 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $62044 m0 *1 351.68,942.48
X$62044 9264 9263 8896 7993 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $62072 m0 *1 352.24,922.32
X$62072 9264 9263 8812 7996 8813 8835 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62091 m0 *1 401.52,962.64
X$62091 9264 9263 8995 7997 8989 8996 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62117 r0 *1 485.52,801.36
X$62117 9263 8158 8100 9264 8001 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $62136 m0 *1 526.96,841.68
X$62136 9264 9263 8388 8363 8370 8003 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62173 r0 *1 859.6,831.6
X$62173 9264 9263 8376 8008 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $62184 r0 *1 755.44,871.92
X$62184 9264 9263 8622 8558 8370 8009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62204 r0 *1 855.68,871.92
X$62204 9264 9263 8601 8602 8562 8010 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62220 r0 *1 784,801.36
X$62220 9264 9263 8012 8142 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62224 r0 *1 795.76,801.36
X$62224 9264 9263 8013 8095 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62233 m0 *1 812,801.36
X$62233 9264 9263 8015 8014 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62269 m0 *1 897.68,861.84
X$62269 9264 9263 8019 9272 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $62332 r0 *1 980.56,791.28
X$62332 8022 9263 9264 8089 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $62335 m0 *1 980.56,811.44
X$62335 8132 9263 9264 8023 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $62408 m0 *1 698.32,811.44
X$62408 8283 8098 8159 8121 9264 9263 8033 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $62533 m0 *1 374.64,962.64
X$62533 9264 9263 8993 8052 8989 8994 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62551 m0 *1 402.08,952.56
X$62551 9264 9263 8948 8053 8930 8899 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62574 r0 *1 473.2,801.36
X$62574 9264 9263 8057 8171 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62590 r0 *1 401.52,962.64
X$62590 9264 9263 9068 8057 8992 9031 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62611 m0 *1 548.24,882
X$62611 9264 8058 9321 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $62677 r0 *1 440.72,962.64
X$62677 9264 9263 9033 8062 8989 9085 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62686 r0 *1 653.52,851.76
X$62686 9264 8064 8491 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $62697 r0 *1 659.12,831.6
X$62697 9264 8065 8342 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $62709 m0 *1 889.84,892.08
X$62709 9264 9263 8673 8674 8562 8066 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62746 r0 *1 708.96,902.16
X$62746 9264 9263 8759 8740 8511 8070 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62754 r0 *1 779.52,922.32
X$62754 9264 9263 8847 8791 8757 8072 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62769 m0 *1 692.72,871.92
X$62769 9264 8073 8591 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $62786 r0 *1 748.72,811.44
X$62786 9264 9263 8272 8075 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62833 m0 *1 949.2,811.44
X$62833 8131 9263 9264 8087 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $62836 m0 *1 980.56,831.6
X$62836 8303 9263 9264 8088 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $62913 m0 *1 432.32,962.64
X$62913 9264 9263 9020 8103 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $62962 m0 *1 699.44,861.84
X$62962 9264 9263 8446 8444 8112 8340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62983 r0 *1 746.48,851.76
X$62983 9264 9263 8471 8448 8112 8317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62985 m0 *1 781.76,851.76
X$62985 9264 9263 8467 8412 8112 8299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62987 r0 *1 781.2,851.76
X$62987 9264 9263 8497 8466 8112 8256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62990 r0 *1 586.88,962.64
X$62990 9264 9263 9076 8113 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $63026 r0 *1 636.72,892.08
X$63026 9264 9263 8692 8711 8562 8116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63042 m0 *1 642.88,922.32
X$63042 9264 9263 8820 8117 8529 8788 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63045 r0 *1 632.8,962.64
X$63045 9264 9263 9044 8117 8930 9073 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63062 r0 *1 638.96,912.24
X$63062 9264 9263 8787 8808 8757 8118 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63068 m0 *1 801.92,922.32
X$63068 9264 9263 8828 8803 8757 8120 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63095 m0 *1 724.64,811.44
X$63095 8122 9263 8124 8157 9264 8125 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $63098 m0 *1 720.72,902.16
X$63098 9264 9263 8726 8414 8301 8123 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63108 m0 *1 708.4,922.32
X$63108 9264 9263 8821 8123 8529 8789 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63121 m0 *1 757.68,871.92
X$63121 9264 9263 8557 8568 8370 8127 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63142 r0 *1 804.72,811.44
X$63142 9264 9263 8128 8193 8129 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $63146 r0 *1 809.76,811.44
X$63146 9264 8128 8129 9263 8194 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $63149 m0 *1 808.64,811.44
X$63149 9263 8128 8129 9264 8140 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63178 r0 *1 980.56,821.52
X$63178 8263 9263 9264 8133 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $63211 m0 *1 789.6,811.44
X$63211 9264 9263 8142 8144 8141 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $63239 m0 *1 765.52,811.44
X$63239 9263 8209 8149 9264 8146 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63242 m0 *1 810.88,871.92
X$63242 9264 9263 8566 8195 8301 8147 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63254 m0 *1 790.16,871.92
X$63254 9264 9263 8533 8147 8529 8560 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63260 m0 *1 388.64,811.44
X$63260 8152 8150 8148 8151 9264 9263 8153 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $63365 r0 *1 392.56,952.56
X$63365 9264 9263 9148 8164 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $63449 r0 *1 496.16,811.44
X$63449 9264 9263 8234 8175 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $63455 r0 *1 545.44,912.24
X$63455 9264 9263 8782 8749 8757 8177 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63474 m0 *1 531.44,892.08
X$63474 9264 9263 8666 8643 8511 8178 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63520 m0 *1 533.12,962.64
X$63520 9001 9263 9264 8182 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $63524 r0 *1 617.68,871.92
X$63524 9264 9263 8526 8525 8370 8184 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63543 r0 *1 647.92,882
X$63543 9264 9263 8669 8653 8511 8185 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63556 r0 *1 638.96,942.48
X$63556 9264 9263 8937 8185 8813 8938 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63582 m0 *1 707.84,871.92
X$63582 9264 9263 8530 8555 8370 8189 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63607 r0 *1 809.2,922.32
X$63607 9264 9263 8850 8731 8757 8192 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63639 m0 *1 776.72,871.92
X$63639 9264 9263 8567 8559 8196 8256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63641 m0 *1 688.24,882
X$63641 9264 9263 8652 8593 8196 8340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63661 m0 *1 771.12,882
X$63661 9264 9263 8595 8596 8196 8299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63663 r0 *1 740.32,871.92
X$63663 9264 9263 8623 8556 8196 8317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63714 r0 *1 757.68,902.16
X$63714 9264 9263 8762 8737 8511 8208 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63756 m0 *1 785.12,942.48
X$63756 9264 9263 8879 8823 8757 8214 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63802 m0 *1 862.96,902.16
X$63802 9264 9263 8732 8671 8220 8256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63804 r0 *1 873.04,902.16
X$63804 9264 9263 8766 8672 8220 8299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63806 r0 *1 833.28,912.24
X$63806 9264 9263 8794 8800 8220 8340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63809 r0 *1 841.68,912.24
X$63809 9264 9263 8796 8795 8220 8317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63843 m0 *1 370.16,952.56
X$63843 9264 9263 8946 8223 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $63866 m0 *1 378,952.56
X$63866 9264 9263 8897 8226 8930 8898 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63880 r0 *1 351.68,942.48
X$63880 9264 9263 8928 8227 8813 8929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63900 m0 *1 396.48,821.52
X$63900 9264 9263 8229 8275 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $63905 r0 *1 403.76,821.52
X$63905 9264 9263 8328 8231 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $63932 m0 *1 442.96,982.8
X$63932 9264 9263 9218 8232 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $63951 m0 *1 504,821.52
X$63951 9264 9263 8239 8236 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $63953 r0 *1 491.12,851.76
X$63953 9264 9263 8486 8473 8370 8237 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63978 r0 *1 506.24,912.24
X$63978 9264 9263 8779 8238 8529 8748 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63982 m0 *1 487.76,982.8
X$63982 9264 9263 9156 8238 8930 9087 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64040 m0 *1 759.92,912.24
X$64040 9264 9263 8807 8768 8511 8247 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64054 r0 *1 809.2,882
X$64054 9264 9263 8598 8411 8301 8248 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64069 m0 *1 790.16,882
X$64069 9264 9263 8597 8248 8529 8616 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64080 r0 *1 745.36,821.52
X$64080 9264 9263 8250 8252 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $64105 m0 *1 816.48,902.16
X$64105 9264 9263 8734 8704 8689 8256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64110 r0 *1 804.16,871.92
X$64110 9264 9263 8612 8566 8342 8256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64121 m0 *1 778.96,902.16
X$64121 9264 9263 8728 8702 8491 8256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64123 r0 *1 874.72,882
X$64123 9264 9263 8564 8648 8591 8256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64125 r0 *1 875.84,851.76
X$64125 9264 9263 8501 8456 8268 8256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64156 r0 *1 889.84,871.92
X$64156 9264 9263 8603 8563 8562 8262 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64214 m0 *1 836.64,851.76
X$64214 9264 9263 8453 8415 8268 8317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64221 r0 *1 885.36,841.68
X$64221 9264 9263 8417 8422 8268 8299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64225 m0 *1 827.12,851.76
X$64225 9264 9263 8452 8451 8268 8340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64275 r0 *1 772.24,821.52
X$64275 9264 9263 8279 8297 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $64318 r0 *1 491.12,892.08
X$64318 9264 9263 8686 8664 8562 8287 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64371 m0 *1 626.64,962.64
X$64371 8291 9263 9264 9074 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64373 m0 *1 742.56,841.68
X$64373 9264 9263 8380 8292 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $64380 m0 *1 732.48,902.16
X$64380 9264 9263 8697 8698 8511 8294 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64393 r0 *1 756,821.52
X$64393 9264 9263 8295 8318 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $64420 m0 *1 809.2,882
X$64420 9264 9263 8613 8598 8342 8299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64422 m0 *1 808.08,902.16
X$64422 9264 9263 8730 8703 8689 8299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64424 m0 *1 770.56,902.16
X$64424 9264 9263 8727 8701 8491 8299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64437 m0 *1 885.36,882
X$64437 9264 9263 8649 8565 8591 8299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64456 r0 *1 738.64,902.16
X$64456 9264 9263 8738 8413 8301 8337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64479 r0 *1 980.56,831.6
X$64479 8345 9263 9264 8304 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64482 m0 *1 980.56,841.68
X$64482 8377 9263 9264 8305 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64532 r0 *1 728.56,902.16
X$64532 9264 9263 8761 8738 8342 8317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64534 m0 *1 837.2,882
X$64534 9264 9263 8600 8647 8591 8317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64537 m0 *1 740.88,902.16
X$64537 9264 9263 8699 8700 8491 8317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64556 r0 *1 789.6,912.24
X$64556 9264 9263 8792 8729 8689 8317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64607 r0 *1 383.6,952.56
X$64607 9264 9263 8961 8328 8989 8962 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64630 r0 *1 561.68,962.64
X$64630 9264 9263 9037 8333 8992 9091 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64637 m0 *1 618.24,962.64
X$64637 8334 9263 9264 9018 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64647 m0 *1 730.24,871.92
X$64647 9264 9263 8570 8569 8370 8336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64670 m0 *1 728,922.32
X$64670 9264 9263 8822 8337 8529 8790 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64689 r0 *1 840.56,892.08
X$64689 9264 9263 8706 8561 8562 8339 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64707 r0 *1 814.24,912.24
X$64707 9264 9263 8793 8736 8689 8340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64711 m0 *1 698.32,892.08
X$64711 9264 9263 8670 8679 8491 8340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64729 r0 *1 829.36,871.92
X$64729 9264 9263 8599 8611 8591 8340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64732 r0 *1 686,902.16
X$64732 9264 9263 8758 8694 8342 8340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64902 r0 *1 684.32,982.8
X$64902 8372 9263 9264 9244 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64909 r0 *1 637.84,952.56
X$64909 8373 9263 9264 9117 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64927 r0 *1 804.16,902.16
X$64927 9264 8374 9322 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $65078 m0 *1 527.52,972.72
X$65078 9194 9263 9264 8400 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $65104 r0 *1 544.32,972.72
X$65104 9264 9263 9159 8406 8992 9133 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65278 m0 *1 626.64,952.56
X$65278 9264 9263 8947 8432 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $65323 r0 *1 372.96,892.08
X$65323 9264 8436 9265 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $65463 m0 *1 763.28,962.64
X$65463 9264 9263 9013 8454 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $65491 r0 *1 768.88,962.64
X$65491 9264 9263 9253 8457 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $65501 r0 *1 675.92,982.8
X$65501 8459 9263 9264 9241 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $65564 m0 *1 438.48,932.4
X$65564 9264 9263 8470 9324 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $65746 r0 *1 762.72,952.56
X$65746 8974 9263 9264 8496 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $65769 m0 *1 771.12,962.64
X$65769 9254 9263 9264 8498 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $66232 r0 *1 763.28,962.64
X$66232 9055 9263 9264 8594 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $66428 m0 *1 262.08,982.8
X$66428 8656 9263 9264 9197 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66509 m0 *1 391.44,982.8
X$66509 8685 9263 9264 9126 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66596 r0 *1 301.84,932.4
X$66596 9264 9263 8707 9326 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $66680 m0 *1 262.64,972.72
X$66680 8713 9263 9264 9106 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66693 m0 *1 415.52,962.64
X$66693 8716 9263 9264 9151 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66698 r0 *1 474.32,982.8
X$66698 8718 9263 9264 9222 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66775 m0 *1 735.28,952.56
X$66775 9264 9263 8741 9323 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $66839 r0 *1 399.28,972.72
X$66839 8745 9263 9264 9214 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66845 r0 *1 415.52,982.8
X$66845 8746 9263 9264 9213 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66960 m0 *1 366.24,982.8
X$66960 8774 9263 9264 9179 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66967 r0 *1 420.56,962.64
X$66967 8775 9263 9264 9083 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66973 r0 *1 455.28,952.56
X$66973 8776 9263 9264 8983 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66995 m0 *1 519.12,952.56
X$66995 9264 9263 8777 9269 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $67045 r0 *1 553.28,962.64
X$67045 8778 9263 9264 9077 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67055 r0 *1 535.36,982.8
X$67055 8781 9263 9264 9230 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67138 m0 *1 287.28,982.8
X$67138 8809 9263 9264 9122 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67148 r0 *1 341.04,982.8
X$67148 8811 9263 9264 9206 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67186 r0 *1 375.2,952.56
X$67186 8815 9263 9264 8960 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67196 r0 *1 432.32,982.8
X$67196 8817 9263 9264 9217 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67203 r0 *1 423.92,982.8
X$67203 8818 9263 9264 9215 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67242 r0 *1 457.52,982.8
X$67242 8830 9263 9264 9220 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67250 r0 *1 256.48,972.72
X$67250 8831 9263 9264 9142 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67253 m0 *1 270.48,982.8
X$67253 8832 9263 9264 9171 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67260 r0 *1 264.88,972.72
X$67260 8833 9263 9264 9120 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67269 r0 *1 372.4,962.64
X$67269 8835 9263 9264 9109 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67278 m0 *1 374.64,982.8
X$67278 8836 9263 9264 9146 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67285 m0 *1 423.92,962.64
X$67285 8837 9263 9264 8997 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67294 r0 *1 560.56,982.8
X$67294 8839 9263 9264 9191 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67300 r0 *1 608.72,982.8
X$67300 8840 9263 9264 9189 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67310 m0 *1 663.04,962.64
X$67310 8842 9263 9264 9016 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67319 m0 *1 696.08,982.8
X$67319 8844 9263 9264 9165 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67325 m0 *1 768.32,982.8
X$67325 8846 9263 9264 9252 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67375 r0 *1 324.24,982.8
X$67375 8861 9263 9264 9204 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67381 r0 *1 332.64,982.8
X$67381 8862 9263 9264 9205 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67391 r0 *1 401.52,952.56
X$67391 9264 8863 8930 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $67396 r0 *1 357.84,962.64
X$67396 9264 8863 8992 9263 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $67398 r0 *1 341.04,962.64
X$67398 9264 9263 8863 8989 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $67421 r0 *1 357.84,982.8
X$67421 8864 9263 9264 9208 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67428 r0 *1 414.96,942.48
X$67428 8865 9263 9264 8949 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67436 r0 *1 391.44,982.8
X$67436 8866 9263 9264 9212 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67439 r0 *1 464.8,952.56
X$67439 8867 9263 9264 8984 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67447 m0 *1 469.84,982.8
X$67447 8868 9263 9264 9163 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67452 r0 *1 500.64,982.8
X$67452 8869 9263 9264 9224 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67459 r0 *1 517.44,982.8
X$67459 8870 9263 9264 9226 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67467 r0 *1 625.52,982.8
X$67467 8872 9263 9264 9236 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67479 m0 *1 608.72,952.56
X$67479 8874 9263 9264 9136 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67490 r0 *1 678.72,962.64
X$67490 8876 9263 9264 9070 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67496 m0 *1 673.12,972.72
X$67496 8877 9263 9264 9114 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67505 m0 *1 746.48,962.64
X$67505 8878 9263 9264 9014 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67512 m0 *1 863.52,982.8
X$67512 8880 9263 9264 9169 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67556 m0 *1 671.44,962.64
X$67556 8891 9263 9264 9069 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67582 r0 *1 366.24,982.8
X$67582 8898 9263 9264 9210 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67588 r0 *1 383.04,982.8
X$67588 8899 9263 9264 9211 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67596 m0 *1 440.72,962.64
X$67596 8901 9263 9264 8982 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67601 m0 *1 465.92,962.64
X$67601 8902 9263 9264 9023 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67608 r0 *1 526.96,982.8
X$67608 8904 9263 9264 9227 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67615 r0 *1 543.76,982.8
X$67615 8905 9263 9264 9229 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67625 m0 *1 560,962.64
X$67625 8906 9263 9264 9038 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67632 r0 *1 578.48,962.64
X$67632 8907 9263 9264 9039 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67640 m0 *1 588.56,982.8
X$67640 8909 9263 9264 9161 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67648 r0 *1 617.12,982.8
X$67648 8911 9263 9264 9238 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67655 r0 *1 716.8,982.8
X$67655 8912 9263 9264 9245 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67661 m0 *1 738.64,972.72
X$67661 8913 9263 9264 9108 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67669 m0 *1 776.72,982.8
X$67669 8915 9263 9264 9145 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67674 r0 *1 862.4,972.72
X$67674 8916 9263 9264 9170 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67681 r0 *1 875.84,982.8
X$67681 8917 9263 9264 9262 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67692 m0 *1 315.84,982.8
X$67692 8919 9263 9264 9175 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67702 m0 *1 412.16,952.56
X$67702 8920 9263 9264 9113 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67727 r0 *1 274.96,982.8
X$67727 8926 9263 9264 9199 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67740 r0 *1 349.44,982.8
X$67740 8929 9263 9264 9207 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67782 m0 *1 434.56,982.8
X$67782 8932 9263 9264 9188 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67791 m0 *1 496.16,982.8
X$67791 8934 9263 9264 9192 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67797 m0 *1 544.32,982.8
X$67797 8935 9263 9264 9228 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67804 m0 *1 580.16,982.8
X$67804 8936 9263 9264 9134 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67813 m0 *1 657.44,982.8
X$67813 8938 9263 9264 9185 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67819 r0 *1 605.36,952.56
X$67819 8939 9263 9264 8965 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67832 m0 *1 790.16,982.8
X$67832 8942 9263 9264 9255 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67872 r0 *1 407.12,982.8
X$67872 8951 9263 9264 9184 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67886 r0 *1 258.16,982.8
X$67886 8954 9263 9264 9196 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67892 m0 *1 253.68,982.8
X$67892 8956 9263 9264 9168 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67901 m0 *1 346.64,962.64
X$67901 8958 9263 9264 9017 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67908 m0 *1 349.44,982.8
X$67908 8959 9263 9264 9162 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67918 m0 *1 391.44,962.64
X$67918 8962 9263 9264 9030 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67926 r0 *1 436.24,952.56
X$67926 8963 9263 9264 8981 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67942 m0 *1 628.88,982.8
X$67942 8967 9263 9264 9187 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67948 m0 *1 609.84,962.64
X$67948 8968 9263 9264 9094 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67957 r0 *1 700,982.8
X$67957 8969 9263 9264 9166 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67962 r0 *1 700,962.64
X$67962 8970 9263 9264 9110 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67970 m0 *1 721.28,982.8
X$67970 8971 9263 9264 9180 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67976 m0 *1 732.48,982.8
X$67976 8972 9263 9264 9139 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67989 m0 *1 299.04,982.8
X$67989 8975 9263 9264 9173 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68043 r0 *1 291.76,982.8
X$68043 8988 9263 9264 9201 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68072 m0 *1 383.04,962.64
X$68072 8991 9263 9264 9082 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68111 m0 *1 341.04,982.8
X$68111 8994 9263 9264 9125 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68122 r0 *1 374.64,982.8
X$68122 8996 9263 9264 9209 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68134 r0 *1 491.12,982.8
X$68134 8999 9263 9264 9225 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68136 m0 *1 516.32,982.8
X$68136 9000 9263 9264 9195 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68150 r0 *1 600.32,982.8
X$68150 9003 9263 9264 9233 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68159 m0 *1 590.8,962.64
X$68159 9005 9263 9264 9019 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68172 m0 *1 704.48,982.8
X$68172 9008 9263 9264 9153 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68184 r0 *1 827.68,982.8
X$68184 9012 9263 9264 9174 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68221 m0 *1 449.12,962.64
X$68221 9021 9263 9264 9118 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68241 r0 *1 315.84,982.8
X$68241 9026 9263 9264 9203 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68249 m0 *1 324.24,982.8
X$68249 9027 9263 9264 9144 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68256 m0 *1 357.84,982.8
X$68256 9029 9263 9264 9127 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68268 m0 *1 400.96,982.8
X$68268 9031 9263 9264 9182 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68280 m0 *1 417.76,982.8
X$68280 9034 9263 9264 9152 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68287 r0 *1 552.16,982.8
X$68287 9036 9263 9264 9231 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68302 r0 *1 594.72,962.64
X$68302 9040 9263 9264 9075 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68314 m0 *1 587.44,972.72
X$68314 9042 9263 9264 9119 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68317 r0 *1 611.52,962.64
X$68317 9046 9263 9264 9043 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68327 r0 *1 633.92,982.8
X$68327 9045 9263 9264 9239 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68345 m0 *1 681.52,972.72
X$68345 9048 9263 9264 9111 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68354 m0 *1 712.88,982.8
X$68354 9050 9263 9264 9181 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68361 m0 *1 664.72,972.72
X$68361 9051 9263 9264 9164 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68370 r0 *1 733.6,982.8
X$68370 9053 9263 9264 9247 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68377 r0 *1 753.76,962.64
X$68377 9054 9263 9264 9066 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68387 r0 *1 799.68,982.8
X$68387 9057 9263 9264 9256 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68396 r0 *1 808.08,982.8
X$68396 9059 9263 9264 9257 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68419 r0 *1 743.12,962.64
X$68419 9065 9263 9264 9251 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68450 m0 *1 641.2,972.72
X$68450 9073 9263 9264 9116 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68471 r0 *1 266.56,982.8
X$68471 9079 9263 9264 9198 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68480 m0 *1 332.64,982.8
X$68480 9081 9263 9264 9177 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68494 m0 *1 426.16,982.8
X$68494 9084 9263 9264 9186 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68501 m0 *1 383.04,982.8
X$68501 9085 9263 9264 9149 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68512 r0 *1 440.72,982.8
X$68512 9087 9263 9264 9216 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68519 r0 *1 465.92,982.8
X$68519 9088 9263 9264 9221 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68525 r0 *1 467.04,972.72
X$68525 9089 9263 9264 9155 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68532 r0 *1 482.72,982.8
X$68532 9090 9263 9264 9223 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68537 r0 *1 577.36,982.8
X$68537 9091 9263 9264 9234 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68547 m0 *1 600.32,982.8
X$68547 9093 9263 9264 9190 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68554 r0 *1 659.12,982.8
X$68554 9095 9263 9264 9242 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68560 r0 *1 671.44,972.72
X$68560 9096 9263 9264 9243 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68568 r0 *1 725.2,982.8
X$68568 9097 9263 9264 9248 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68577 r0 *1 742,982.8
X$68577 9098 9263 9264 9250 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68584 r0 *1 750.4,982.8
X$68584 9100 9263 9264 9249 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68593 m0 *1 799.68,982.8
X$68593 9101 9263 9264 9176 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68598 m0 *1 831.6,982.8
X$68598 9102 9263 9264 9172 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68604 r0 *1 841.68,982.8
X$68604 9103 9263 9264 9259 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68609 r0 *1 864.08,982.8
X$68609 9104 9263 9264 9261 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68666 r0 *1 283.36,982.8
X$68666 9121 9263 9264 9200 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68681 r0 *1 307.44,982.8
X$68681 9124 9263 9264 9202 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68696 m0 *1 409.36,982.8
X$68696 9128 9263 9264 9150 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68705 r0 *1 449.12,982.8
X$68705 9130 9263 9264 9219 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68716 m0 *1 535.92,982.8
X$68716 9132 9263 9264 9193 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68720 r0 *1 568.96,982.8
X$68720 9133 9263 9264 9232 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68733 r0 *1 585.76,982.8
X$68733 9135 9263 9264 9235 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68744 r0 *1 642.32,982.8
X$68744 9138 9263 9264 9240 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68757 r0 *1 816.48,982.8
X$68757 9141 9263 9264 9258 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68842 r0 *1 855.68,982.8
X$68842 9167 9263 9264 9260 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS parameterized_fft

* cell gf180mcu_fd_sc_mcu9t5v0__tieh
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__tieh 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 4 Z
* device instance $1 r0 *1 0.875,3.315 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=0.9U AS=0.396P AD=0.396P PS=2.68U PD=2.68U
* device instance $2 r0 *1 0.925,1.335 nmos_5p0
M$2 3 3 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.2904P PS=2.2U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__tieh

* cell gf180mcu_fd_sc_mcu9t5v0__inv_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_16 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=29.28U AS=9.3147P AD=9.3147P PS=41.29U PD=41.29U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 3 2 1 1 nmos_5p0 L=0.6U W=21.12U AS=5.7288P AD=5.7288P PS=31.12U PD=31.12U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_16

* cell gf180mcu_fd_sc_mcu9t5v0__oai33_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A1
* pin ZN
* pin A3
* pin B2
* pin B3
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai33_4 1 2 3 5 6 7 8 9 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B1
* net 3 A1
* net 5 ZN
* net 6 A3
* net 7 B2
* net 8 B3
* net 9 A2
* net 11 NWELL,VDD
* device instance $1 r0 *1 14.93,3.78 pmos_5p0
M$1 5 3 12 11 pmos_5p0 L=0.5U W=5.49U AS=1.89405P AD=1.65615P PS=9.39U PD=7.3U
* device instance $4 r0 *1 18.24,3.78 pmos_5p0
M$4 18 3 5 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 19.36,3.78 pmos_5p0
M$5 20 9 18 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 20.48,3.78 pmos_5p0
M$6 11 6 20 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.61305P PS=2.45U PD=2.5U
* device instance $7 r0 *1 21.65,3.78 pmos_5p0
M$7 19 6 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $8 r0 *1 22.72,3.78 pmos_5p0
M$8 12 9 19 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 23.84,3.78 pmos_5p0
M$9 21 9 12 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 24.96,3.78 pmos_5p0
M$10 11 6 21 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 26.08,3.78 pmos_5p0
M$11 22 6 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $12 r0 *1 27.15,3.78 pmos_5p0
M$12 12 9 22 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $13 r0 *1 0.92,3.78 pmos_5p0
M$13 13 7 10 11 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $14 r0 *1 1.99,3.78 pmos_5p0
M$14 11 8 13 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $15 r0 *1 3.16,3.78 pmos_5p0
M$15 15 8 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.5673P PS=2.5U PD=2.45U
* device instance $16 r0 *1 4.28,3.78 pmos_5p0
M$16 10 7 15 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $17 r0 *1 5.4,3.78 pmos_5p0
M$17 14 7 10 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $18 r0 *1 6.47,3.78 pmos_5p0
M$18 11 8 14 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $19 r0 *1 7.64,3.78 pmos_5p0
M$19 16 8 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.5673P PS=2.5U PD=2.45U
* device instance $20 r0 *1 8.76,3.78 pmos_5p0
M$20 17 7 16 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $21 r0 *1 9.88,3.78 pmos_5p0
M$21 5 2 17 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $22 r0 *1 10.95,3.78 pmos_5p0
M$22 10 2 5 11 pmos_5p0 L=0.5U W=5.49U AS=1.65615P AD=1.9398P PS=7.3U PD=9.44U
* device instance $25 r0 *1 0.92,1.005 nmos_5p0
M$25 1 7 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $26 r0 *1 2.04,1.005 nmos_5p0
M$26 4 8 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $33 r0 *1 9.88,1.005 nmos_5p0
M$33 1 2 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.716P PS=7.36U PD=7.88U
* device instance $37 r0 *1 14.88,1.005 nmos_5p0
M$37 5 3 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.716P AD=1.3728P PS=7.88U PD=7.36U
* device instance $41 r0 *1 19.36,1.005 nmos_5p0
M$41 5 9 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
* device instance $42 r0 *1 20.48,1.005 nmos_5p0
M$42 4 6 5 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai33_4

* cell gf180mcu_fd_sc_mcu9t5v0__dffsnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin SETN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffsnq_4 1 10 11 12 13 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 10 Q
* net 11 CLK
* net 12 D
* net 13 SETN
* net 17 NWELL,VDD
* device instance $1 r0 *1 14.415,3.365 pmos_5p0
M$1 8 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $2 r0 *1 15.435,3.365 pmos_5p0
M$2 17 9 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.536P PS=1.52U PD=2.57U
* device instance $3 r0 *1 16.675,3.78 pmos_5p0
M$3 9 2 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.0118P AD=0.9516P PS=4.92U PD=4.7U
* device instance $5 r0 *1 18.715,3.78 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=2.2326P PS=9.4U PD=11.59U
* device instance $9 r0 *1 11.335,3.365 pmos_5p0
M$9 2 3 7 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.42P PS=2.88U PD=1.84U
* device instance $10 r0 *1 12.675,3.365 pmos_5p0
M$10 8 4 2 17 pmos_5p0 L=0.5U W=1U AS=0.42P AD=0.44P PS=1.84U PD=2.88U
* device instance $11 r0 *1 0.97,3.555 pmos_5p0
M$11 17 11 3 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $12 r0 *1 1.99,3.555 pmos_5p0
M$12 4 3 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $13 r0 *1 3.93,3.465 pmos_5p0
M$13 5 12 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.3825P PS=2.88U PD=1.765U
* device instance $14 r0 *1 5.195,3.465 pmos_5p0
M$14 6 4 5 17 pmos_5p0 L=0.5U W=1U AS=0.3825P AD=0.26P PS=1.765U PD=1.52U
* device instance $15 r0 *1 6.215,3.465 pmos_5p0
M$15 18 3 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2P PS=1.52U PD=1.4U
* device instance $16 r0 *1 7.115,3.465 pmos_5p0
M$16 17 7 18 17 pmos_5p0 L=0.5U W=1U AS=0.2P AD=0.26P PS=1.4U PD=1.52U
* device instance $17 r0 *1 8.135,3.465 pmos_5p0
M$17 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $18 r0 *1 9.155,3.465 pmos_5p0
M$18 17 13 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.7374P PS=1.52U PD=3.75U
* device instance $19 r0 *1 14.545,1.37 nmos_5p0
M$19 16 13 8 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.0708P PS=2.06U PD=0.83U
* device instance $20 r0 *1 15.385,1.37 nmos_5p0
M$20 16 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.3789P AD=0.0708P PS=2.06U PD=0.83U
* device instance $21 r0 *1 16.725,1.005 nmos_5p0
M$21 9 2 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7221P AD=0.6864P PS=3.9U PD=3.68U
* device instance $23 r0 *1 18.965,1.005 nmos_5p0
M$23 10 9 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
* device instance $27 r0 *1 0.92,1.27 nmos_5p0
M$27 1 11 3 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $28 r0 *1 2.04,1.27 nmos_5p0
M$28 4 3 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $29 r0 *1 3.88,1.37 nmos_5p0
M$29 5 12 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $30 r0 *1 5,1.37 nmos_5p0
M$30 6 3 5 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 6.12,1.37 nmos_5p0
M$31 14 4 6 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.101775P PS=1.11U PD=0.935U
* device instance $32 r0 *1 7.065,1.37 nmos_5p0
M$32 1 7 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.101775P AD=0.1534P PS=0.935U PD=1.11U
* device instance $33 r0 *1 8.185,1.37 nmos_5p0
M$33 15 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0944P PS=1.11U PD=0.91U
* device instance $34 r0 *1 9.105,1.37 nmos_5p0
M$34 7 13 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0944P AD=0.1652P PS=0.91U PD=1.15U
* device instance $35 r0 *1 10.265,1.37 nmos_5p0
M$35 2 4 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1652P AD=0.1534P PS=1.15U PD=1.11U
* device instance $36 r0 *1 11.385,1.37 nmos_5p0
M$36 8 3 2 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.2596P PS=1.11U PD=2.06U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffsnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai33_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B3
* pin B2
* pin B1
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai33_2 1 3 4 5 6 7 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B3
* net 4 B2
* net 5 B1
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 3 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 11 4 12 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 10 5 11 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 14 5 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 13 4 14 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 9 3 13 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.61305P PS=2.45U PD=2.5U
* device instance $7 r0 *1 7.69,3.78 pmos_5p0
M$7 15 6 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 16 7 15 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.88,3.78 pmos_5p0
M$9 10 8 16 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 11,3.78 pmos_5p0
M$10 17 8 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 12.12,3.78 pmos_5p0
M$11 18 7 17 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $12 r0 *1 13.19,3.78 pmos_5p0
M$12 9 6 18 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 1 3 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $14 r0 *1 2.04,1.005 nmos_5p0
M$14 2 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $15 r0 *1 3.16,1.005 nmos_5p0
M$15 1 5 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $19 r0 *1 7.64,1.005 nmos_5p0
M$19 10 6 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $20 r0 *1 8.76,1.005 nmos_5p0
M$20 2 7 10 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $21 r0 *1 9.88,1.005 nmos_5p0
M$21 10 8 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai33_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi222_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin C1
* pin C2
* pin B1
* pin B2
* pin A1
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi222_4 1 2 3 4 5 6 7 8 22
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 C1
* net 4 C2
* net 5 B1
* net 6 B2
* net 7 A1
* net 8 A2
* net 22 NWELL,VDD
* device instance $1 r0 *1 9.75,3.78 pmos_5p0
M$1 21 5 23 22 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=1.9032P PS=11.59U PD=9.4U
* device instance $2 r0 *1 10.77,3.78 pmos_5p0
M$2 23 6 21 22 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 17.91,3.78 pmos_5p0
M$9 2 7 23 22 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=2.2326P PS=9.4U PD=11.59U
* device instance $10 r0 *1 18.93,3.78 pmos_5p0
M$10 23 8 2 22 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $17 r0 *1 0.87,3.78 pmos_5p0
M$17 21 3 22 22 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U
+ PD=11.59U
* device instance $18 r0 *1 1.89,3.78 pmos_5p0
M$18 22 4 21 22 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $25 r0 *1 0.92,1.005 nmos_5p0
M$25 11 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $26 r0 *1 1.84,1.005 nmos_5p0
M$26 1 4 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $27 r0 *1 2.96,1.005 nmos_5p0
M$27 9 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 3.88,1.005 nmos_5p0
M$28 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 5,1.005 nmos_5p0
M$29 13 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 5.92,1.005 nmos_5p0
M$30 1 4 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 7.04,1.005 nmos_5p0
M$31 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 7.96,1.005 nmos_5p0
M$32 2 3 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.7854P PS=1.64U PD=2.51U
* device instance $33 r0 *1 9.75,1.005 nmos_5p0
M$33 18 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.7854P AD=0.2442P PS=2.51U PD=1.69U
* device instance $34 r0 *1 10.72,1.005 nmos_5p0
M$34 1 6 18 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $35 r0 *1 11.84,1.005 nmos_5p0
M$35 16 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $36 r0 *1 12.76,1.005 nmos_5p0
M$36 2 5 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $37 r0 *1 13.88,1.005 nmos_5p0
M$37 19 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $38 r0 *1 14.8,1.005 nmos_5p0
M$38 1 6 19 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $39 r0 *1 15.92,1.005 nmos_5p0
M$39 20 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $40 r0 *1 16.84,1.005 nmos_5p0
M$40 2 5 20 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $41 r0 *1 17.96,1.005 nmos_5p0
M$41 17 7 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $42 r0 *1 18.88,1.005 nmos_5p0
M$42 1 8 17 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $43 r0 *1 20,1.005 nmos_5p0
M$43 14 8 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $44 r0 *1 20.92,1.005 nmos_5p0
M$44 2 7 14 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $45 r0 *1 22.04,1.005 nmos_5p0
M$45 15 7 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $46 r0 *1 22.96,1.005 nmos_5p0
M$46 1 8 15 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $47 r0 *1 24.08,1.005 nmos_5p0
M$47 10 8 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $48 r0 *1 25,1.005 nmos_5p0
M$48 2 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi222_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai32_2
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
* pin B2
* pin ZN
* pin B1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai32_2 1 2 3 4 5 7 8 9
* net 1 NWELL,VDD
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 A1
* net 5 A3
* net 7 B2
* net 8 ZN
* net 9 B1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 15 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 14 3 15 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 14 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 13 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 11 3 13 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 5 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.6588P PS=2.45U PD=2.55U
* device instance $7 r0 *1 7.69,3.78 pmos_5p0
M$7 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 8 9 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.88,3.78 pmos_5p0
M$9 10 9 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $10 r0 *1 10.95,3.78 pmos_5p0
M$10 1 7 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $11 r0 *1 0.92,1.005 nmos_5p0
M$11 2 5 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $12 r0 *1 2.04,1.005 nmos_5p0
M$12 6 3 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 3.16,1.005 nmos_5p0
M$13 2 4 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 7.64,1.005 nmos_5p0
M$17 8 7 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2408P PS=3.68U PD=5.84U
* device instance $18 r0 *1 8.76,1.005 nmos_5p0
M$18 6 9 8 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai32_2

* cell gf180mcu_fd_sc_mcu9t5v0__or4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_4 1 3 4 5 6 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 Z
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 4 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 5 11 8 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 6 10 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 7 9 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 12 7 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 13 6 12 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 14 5 13 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 8 4 14 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.77775P PS=2.45U PD=2.68U
* device instance $9 r0 *1 10.11,3.78 pmos_5p0
M$9 3 2 8 8 pmos_5p0 L=0.5U W=7.32U AS=2.38815P AD=2.4156P PS=9.93U PD=11.79U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 2 4 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.5879P PS=3.77U PD=3.33U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 1 5 2 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $15 r0 *1 3.16,0.74 nmos_5p0
M$15 2 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $16 r0 *1 4.28,0.74 nmos_5p0
M$16 1 7 2 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $21 r0 *1 10.06,1.005 nmos_5p0
M$21 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4121P AD=1.6104P PS=7.54U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A4
* pin NWELL,VDD
* pin A3
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A4
* net 4 NWELL,VDD
* net 5 A3
* net 6 A1
* net 7 A2
* device instance $1 r0 *1 0.975,3.78 pmos_5p0
M$1 13 5 8 4 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.045,3.78 pmos_5p0
M$2 4 3 13 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.165,3.78 pmos_5p0
M$3 12 3 4 4 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.465,3.78 pmos_5p0
M$4 11 5 12 4 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.77775P PS=2.63U PD=2.68U
* device instance $5 r0 *1 5.815,3.78 pmos_5p0
M$5 10 7 11 4 pmos_5p0 L=0.5U W=1.83U AS=0.77775P AD=0.52155P PS=2.68U PD=2.4U
* device instance $6 r0 *1 6.885,3.78 pmos_5p0
M$6 2 6 10 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 8.055,3.78 pmos_5p0
M$7 9 6 2 4 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $8 r0 *1 9.075,3.78 pmos_5p0
M$8 8 7 9 4 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 4.465,0.695 nmos_5p0
M$9 1 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.52165P AD=0.40285P PS=3.565U PD=2.545U
* device instance $11 r0 *1 2.045,0.7 nmos_5p0
M$11 1 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.40285P AD=0.3432P PS=2.545U PD=2.36U
* device instance $13 r0 *1 5.765,0.7 nmos_5p0
M$13 2 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.40285P AD=0.462P PS=2.545U PD=3.38U
* device instance $14 r0 *1 6.885,0.7 nmos_5p0
M$14 1 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=2.36U PD=2.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor4_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_2
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_2 1 2 3 4 5 6
* net 1 ZN
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A1
* net 6 A3
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 6 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 9 4 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 1 5 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 8 5 1 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 4 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 6 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 3 6 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.553P PS=3.77U PD=3.77U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 1 4 3 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 3 5 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_4
* pin A2
* pin NWELL,VDD
* pin A3
* pin ZN
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_4 1 2 3 4 5 6
* net 1 A2
* net 2 NWELL,VDD
* net 3 A3
* net 4 ZN
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 12 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 2 3 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 11 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 7 1 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 9 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 3 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.59,3.78 pmos_5p0
M$7 8 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 10 1 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 9.83,3.78 pmos_5p0
M$9 4 6 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 10.95,3.78 pmos_5p0
M$10 7 6 4 2 pmos_5p0 L=0.5U W=5.49U AS=1.7019P AD=1.9398P PS=7.35U PD=9.44U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 4 1 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.9638P AD=0.8216P PS=6.39U PD=5.24U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 5 3 4 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.8216P PS=5.24U PD=5.24U
* device instance $21 r0 *1 9.88,0.74 nmos_5p0
M$21 4 6 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.9638P PS=5.24U PD=6.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A4
* pin A2
* pin A1
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_4 1 3 4 5 6 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 A3
* net 4 A4
* net 5 A2
* net 6 A1
* net 16 ZN
* net 17 NWELL,VDD
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 16 3 17 17 pmos_5p0 L=0.5U W=5.12U AS=1.5616P AD=1.3312P PS=8.84U PD=7.2U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 17 4 16 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.3312P PS=7.2U PD=7.2U
* device instance $9 r0 *1 9.03,4.055 pmos_5p0
M$9 16 5 17 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.5616P PS=7.2U PD=8.84U
* device instance $10 r0 *1 10.05,4.055 pmos_5p0
M$10 17 6 16 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.3312P PS=7.2U PD=7.2U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 7 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $18 r0 *1 1.84,1.005 nmos_5p0
M$18 1 4 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $19 r0 *1 2.96,1.005 nmos_5p0
M$19 9 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 3.88,1.005 nmos_5p0
M$20 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $21 r0 *1 5,1.005 nmos_5p0
M$21 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 5.92,1.005 nmos_5p0
M$22 1 4 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 7.04,1.005 nmos_5p0
M$23 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $24 r0 *1 8.01,1.005 nmos_5p0
M$24 11 3 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $25 r0 *1 9.03,1.005 nmos_5p0
M$25 14 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $26 r0 *1 10,1.005 nmos_5p0
M$26 16 6 14 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $27 r0 *1 11.12,1.005 nmos_5p0
M$27 15 6 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.04,1.005 nmos_5p0
M$28 2 5 15 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 13.16,1.005 nmos_5p0
M$29 10 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.08,1.005 nmos_5p0
M$30 16 6 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 15.2,1.005 nmos_5p0
M$31 13 6 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 16.12,1.005 nmos_5p0
M$32 2 5 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_4

* cell gf180mcu_fd_sc_mcu9t5v0__and4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A1
* pin A2
* pin Z
* pin A4
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_4 1 2 3 5 6 13 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 3 A1
* net 5 A2
* net 6 Z
* net 13 A4
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.885,3.505 pmos_5p0
M$1 4 13 14 14 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.8908P PS=5.24U PD=4.33U
* device instance $2 r0 *1 1.905,3.505 pmos_5p0
M$2 14 2 4 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.925,3.505 pmos_5p0
M$3 4 5 14 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.945,3.505 pmos_5p0
M$4 14 3 4 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 9.225,3.78 pmos_5p0
M$9 6 4 14 14 pmos_5p0 L=0.5U W=7.32U AS=1.9854P AD=2.2326P PS=9.58U PD=11.59U
* device instance $13 r0 *1 0.935,1.005 nmos_5p0
M$13 7 13 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $14 r0 *1 1.855,1.005 nmos_5p0
M$14 8 2 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $15 r0 *1 2.875,1.005 nmos_5p0
M$15 10 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $16 r0 *1 3.895,1.005 nmos_5p0
M$16 4 3 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $17 r0 *1 5.015,1.005 nmos_5p0
M$17 9 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 5.935,1.005 nmos_5p0
M$18 12 5 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $19 r0 *1 6.955,1.005 nmos_5p0
M$19 11 2 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $20 r0 *1 7.975,1.005 nmos_5p0
M$20 1 13 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $21 r0 *1 9.095,1.005 nmos_5p0
M$21 6 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_4

* cell gf180mcu_fd_sc_mcu9t5v0__tiel
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__tiel 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.97,3.315 pmos_5p0
M$1 3 3 2 2 pmos_5p0 L=0.5U W=0.9U AS=0.396P AD=0.396P PS=2.68U PD=2.68U
* device instance $2 r0 *1 0.92,1.335 nmos_5p0
M$2 4 3 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.2904P PS=2.2U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__tiel

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_4 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.975,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.46135P AD=2.31495P PS=11.84U PD=9.85U
* device instance $5 r0 *1 5.505,3.78 pmos_5p0
M$5 12 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $6 r0 *1 6.785,3.78 pmos_5p0
M$6 6 8 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $7 r0 *1 7.805,3.78 pmos_5p0
M$7 11 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $8 r0 *1 8.545,3.78 pmos_5p0
M$8 2 7 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $9 r0 *1 9.565,3.78 pmos_5p0
M$9 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 0.975,1.005 nmos_5p0
M$10 3 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 5.455,1.005 nmos_5p0
M$14 9 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $15 r0 *1 6.295,1.005 nmos_5p0
M$15 6 5 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $16 r0 *1 7.415,1.005 nmos_5p0
M$16 10 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $17 r0 *1 8.495,1.005 nmos_5p0
M$17 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $18 r0 *1 9.615,1.005 nmos_5p0
M$18 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai32_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin A1
* pin B2
* pin B1
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai32_4 1 3 4 5 6 7 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 A3
* net 5 A1
* net 6 B2
* net 7 B1
* net 9 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 15.135,3.78 pmos_5p0
M$1 16 6 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 16.205,3.78 pmos_5p0
M$2 10 7 16 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 17.325,3.78 pmos_5p0
M$3 18 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 18.445,3.78 pmos_5p0
M$4 9 6 18 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 19.565,3.78 pmos_5p0
M$5 17 6 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 20.685,3.78 pmos_5p0
M$6 10 7 17 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 21.805,3.78 pmos_5p0
M$7 19 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 22.875,3.78 pmos_5p0
M$8 9 6 19 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8235P PS=2.4U PD=4.56U
* device instance $9 r0 *1 1.125,3.78 pmos_5p0
M$9 11 3 8 9 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $10 r0 *1 2.195,3.78 pmos_5p0
M$10 9 4 11 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $11 r0 *1 3.415,3.78 pmos_5p0
M$11 13 4 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $12 r0 *1 4.485,3.78 pmos_5p0
M$12 8 3 13 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $13 r0 *1 5.605,3.78 pmos_5p0
M$13 12 3 8 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $14 r0 *1 6.675,3.78 pmos_5p0
M$14 9 4 12 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $15 r0 *1 7.845,3.78 pmos_5p0
M$15 14 4 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.5673P PS=2.5U PD=2.45U
* device instance $16 r0 *1 8.965,3.78 pmos_5p0
M$16 15 3 14 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $17 r0 *1 10.035,3.78 pmos_5p0
M$17 10 5 15 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $18 r0 *1 11.155,3.78 pmos_5p0
M$18 8 5 10 9 pmos_5p0 L=0.5U W=5.49U AS=1.7019P AD=1.9398P PS=7.35U PD=9.44U
* device instance $21 r0 *1 1.125,1.005 nmos_5p0
M$21 1 3 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $22 r0 *1 2.245,1.005 nmos_5p0
M$22 2 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $29 r0 *1 10.085,1.005 nmos_5p0
M$29 1 5 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.716P PS=7.36U PD=7.88U
* device instance $33 r0 *1 15.085,1.005 nmos_5p0
M$33 10 6 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.716P AD=1.6104P PS=7.88U PD=9.04U
* device instance $34 r0 *1 16.205,1.005 nmos_5p0
M$34 2 7 10 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai32_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_4 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.3 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.8906P AD=0.8906P PS=6.09U PD=6.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_4 1 2 3 4 5 6 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A2
* net 4 A1
* net 5 B
* net 6 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 1.54,3.78 pmos_5p0
M$1 2 3 11 12 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1411P PS=11.59U PD=9.66U
* device instance $2 r0 *1 2.56,3.78 pmos_5p0
M$2 11 4 2 12 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.96,3.78 pmos_5p0
M$9 13 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.5673P PS=2.61U PD=2.45U
* device instance $10 r0 *1 11.08,3.78 pmos_5p0
M$10 12 6 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $11 r0 *1 12.62,3.78 pmos_5p0
M$11 14 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $12 r0 *1 13.74,3.78 pmos_5p0
M$12 11 5 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $13 r0 *1 15.28,3.78 pmos_5p0
M$13 16 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $14 r0 *1 16.4,3.78 pmos_5p0
M$14 12 6 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $15 r0 *1 17.94,3.78 pmos_5p0
M$15 15 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $16 r0 *1 19.06,3.78 pmos_5p0
M$16 11 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $17 r0 *1 9.96,1.08 nmos_5p0
M$17 2 5 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.33065P AD=0.9638P PS=6.745U PD=6.39U
* device instance $18 r0 *1 11.08,1.08 nmos_5p0
M$18 2 6 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.5056P AD=0.8216P PS=7.04U PD=5.24U
* device instance $25 r0 *1 1.54,0.937 nmos_5p0
M$25 7 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.74655P AD=0.219225P PS=3.63U
+ PD=1.555U
* device instance $26 r0 *1 2.51,0.937 nmos_5p0
M$26 2 4 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.63,0.937 nmos_5p0
M$27 9 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 4.55,0.937 nmos_5p0
M$28 1 3 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.67,0.937 nmos_5p0
M$29 8 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 6.59,0.937 nmos_5p0
M$30 2 4 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.71,0.937 nmos_5p0
M$31 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $32 r0 *1 8.63,0.937 nmos_5p0
M$32 1 3 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.37245P PS=1.505U
+ PD=1.915U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin C2
* pin B2
* pin B1
* pin A2
* pin C1
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi222_2 1 2 3 4 5 6 13 14 15
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 C2
* net 4 B2
* net 5 B1
* net 6 A2
* net 13 C1
* net 14 A1
* net 15 NWELL,VDD
* device instance $1 r0 *1 0.905,3.78 pmos_5p0
M$1 16 13 15 15 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $2 r0 *1 1.925,3.78 pmos_5p0
M$2 15 3 16 15 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.705,3.78 pmos_5p0
M$5 16 5 17 15 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.965325P PS=6.89U PD=4.715U
* device instance $6 r0 *1 6.725,3.78 pmos_5p0
M$6 17 4 16 15 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 9.8,3.78 pmos_5p0
M$9 2 14 17 15 pmos_5p0 L=0.5U W=3.66U AS=0.965325P AD=1.281P PS=4.715U PD=6.89U
* device instance $10 r0 *1 10.82,3.78 pmos_5p0
M$10 17 6 2 15 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $13 r0 *1 0.955,1.005 nmos_5p0
M$13 7 13 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $14 r0 *1 1.875,1.005 nmos_5p0
M$14 1 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 2.995,1.005 nmos_5p0
M$15 9 3 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 3.915,1.005 nmos_5p0
M$16 2 13 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.7524P PS=1.64U PD=2.46U
* device instance $17 r0 *1 5.655,1.005 nmos_5p0
M$17 10 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.7524P AD=0.2772P PS=2.46U PD=1.74U
* device instance $18 r0 *1 6.675,1.005 nmos_5p0
M$18 1 4 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $19 r0 *1 7.795,1.005 nmos_5p0
M$19 11 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 8.715,1.005 nmos_5p0
M$20 2 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3531P PS=1.64U PD=1.855U
* device instance $21 r0 *1 9.85,1.005 nmos_5p0
M$21 12 14 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3531P AD=0.2112P PS=1.855U PD=1.64U
* device instance $22 r0 *1 10.77,1.005 nmos_5p0
M$22 1 6 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 11.89,1.005 nmos_5p0
M$23 8 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $24 r0 *1 12.81,1.005 nmos_5p0
M$24 2 14 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi222_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_2 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1346P AD=1.3725P PS=4.9U PD=6.99U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 3 1 4 3 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $5 r0 *1 2.04,1.005 nmos_5p0
M$5 5 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_2 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.732P PS=4.54U PD=2.63U
* device instance $2 r0 *1 2.17,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.2993P AD=1.3725P PS=5.08U PD=6.99U
* device instance $4 r0 *1 0.92,1.23 nmos_5p0
M$4 3 1 4 3 nmos_5p0 L=0.6U W=0.73U AS=0.3212P AD=0.2695P PS=2.34U PD=1.5U
* device instance $5 r0 *1 2.22,1.265 nmos_5p0
M$5 5 4 3 3 nmos_5p0 L=0.6U W=1.6U AS=0.4775P AD=0.56P PS=2.82U PD=3.8U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_12 1 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 I
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 3 4 4 pmos_5p0 L=0.5U W=21.96U AS=7.0455P AD=7.0455P PS=31.49U PD=31.49U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 2 3 1 1 nmos_5p0 L=0.6U W=15.84U AS=4.356P AD=4.356P PS=23.76U PD=23.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_12

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 A3
* device instance $1 r0 *1 0.92,3.872 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.93765P PS=6.72U PD=4.43U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 11 5 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 4 6 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 6 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 9 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 7 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $11 r0 *1 3.16,1.005 nmos_5p0
M$11 4 7 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2342P PS=3.68U PD=5.83U
* device instance $12 r0 *1 4.28,1.005 nmos_5p0
M$12 8 5 4 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 4 6 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin A4
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 A4
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 6 7 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.896P PS=5.24U PD=5.24U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 2 3 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.91,4.055 pmos_5p0
M$3 6 4 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.93,4.055 pmos_5p0
M$4 2 5 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 13 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2442P PS=3.52U PD=1.69U
* device instance $10 r0 *1 1.89,1.005 nmos_5p0
M$10 12 3 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2442P PS=1.69U PD=1.69U
* device instance $11 r0 *1 2.86,1.005 nmos_5p0
M$11 11 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 2 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 9 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $14 r0 *1 5.97,1.005 nmos_5p0
M$14 8 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $15 r0 *1 6.99,1.005 nmos_5p0
M$15 10 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.5808P PS=1.69U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai221_4
* pin PWELL,VSS,gf180mcu_gnd
* pin C
* pin ZN
* pin B1
* pin B2
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai221_4 1 2 5 6 7 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 C
* net 5 ZN
* net 6 B1
* net 7 B2
* net 8 A2
* net 9 A1
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 6 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 7 11 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 12 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 12 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 14 6 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 7 14 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 13 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 5 6 13 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=1.0157P PS=2.45U PD=3.12U
* device instance $9 r0 *1 10.55,3.965 pmos_5p0
M$9 10 2 5 10 pmos_5p0 L=0.5U W=5.84U AS=2.5205P AD=1.8104P PS=9.83U PD=8.32U
* device instance $13 r0 *1 15.13,3.78 pmos_5p0
M$13 16 9 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.5996P AD=0.52155P PS=2.55U PD=2.4U
* device instance $14 r0 *1 16.2,3.78 pmos_5p0
M$14 10 8 16 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $15 r0 *1 17.37,3.78 pmos_5p0
M$15 15 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $16 r0 *1 18.44,3.78 pmos_5p0
M$16 5 9 15 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $17 r0 *1 19.56,3.78 pmos_5p0
M$17 17 9 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $18 r0 *1 20.68,3.78 pmos_5p0
M$18 10 8 17 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $19 r0 *1 21.8,3.78 pmos_5p0
M$19 18 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $20 r0 *1 22.87,3.78 pmos_5p0
M$20 5 9 18 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $21 r0 *1 10.6,1.005 nmos_5p0
M$21 3 2 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $25 r0 *1 15.08,1.005 nmos_5p0
M$25 5 9 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
* device instance $26 r0 *1 16.2,1.005 nmos_5p0
M$26 4 8 5 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $33 r0 *1 0.92,1.005 nmos_5p0
M$33 3 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $34 r0 *1 2.04,1.005 nmos_5p0
M$34 1 7 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai221_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.4038P PS=16.79U PD=14.7U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.8076P AD=7.0455P PS=29.4U PD=31.49U
* device instance $19 r0 *1 0.97,1.005 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=7.92U AS=2.2968P AD=2.0592P PS=12.72U PD=11.04U
* device instance $25 r0 *1 7.69,1.005 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=15.84U AS=4.1184P AD=4.356P PS=22.08U PD=23.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_12

* cell gf180mcu_fd_sc_mcu9t5v0__inv_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_8 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7763P PS=21.69U PD=21.69U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.9832P AD=2.9832P PS=16.4U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_8

* cell gf180mcu_fd_sc_mcu9t5v0__xor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xor2_4 2 5 7 8 9
* net 2 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* net 7 A2
* net 8 A1
* net 9 NWELL,VDD
* device instance $1 r0 *1 7.27,3.78 pmos_5p0
M$1 5 4 9 9 pmos_5p0 L=0.5U W=7.32U AS=2.4156P AD=2.4156P PS=11.79U PD=11.79U
* device instance $5 r0 *1 0.87,3.962 pmos_5p0
M$5 3 7 9 9 pmos_5p0 L=0.5U W=0.495U AS=0.2178P AD=0.1287P PS=1.87U PD=1.015U
* device instance $6 r0 *1 1.89,3.962 pmos_5p0
M$6 3 8 9 9 pmos_5p0 L=0.5U W=0.495U AS=0.465P AD=0.1287P PS=2.63U PD=1.015U
* device instance $7 r0 *1 3.19,3.78 pmos_5p0
M$7 4 3 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.465P AD=0.52155P PS=2.63U PD=2.4U
* device instance $8 r0 *1 4.26,3.78 pmos_5p0
M$8 10 8 4 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.52155P PS=2.4U PD=2.4U
* device instance $9 r0 *1 5.33,3.78 pmos_5p0
M$9 9 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $10 r0 *1 7.22,1.005 nmos_5p0
M$10 5 4 2 2 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $14 r0 *1 0.92,1.48 nmos_5p0
M$14 6 7 3 2 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0576P PS=1.6U PD=0.68U
* device instance $15 r0 *1 1.84,1.48 nmos_5p0
M$15 6 8 2 2 nmos_5p0 L=0.6U W=0.36U AS=0.318P AD=0.0576P PS=2.02U PD=0.68U
* device instance $16 r0 *1 3.14,1 nmos_5p0
M$16 1 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.318P AD=0.3432P PS=2.02U PD=1.84U
* device instance $17 r0 *1 4.26,1 nmos_5p0
M$17 4 8 1 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $18 r0 *1 5.38,1 nmos_5p0
M$18 1 7 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_20 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=36.6U AS=11.5839P AD=11.5839P PS=51.09U PD=51.09U
* device instance $21 r0 *1 0.92,1.3 nmos_5p0
M$21 3 2 1 1 nmos_5p0 L=0.6U W=14.6U AS=3.9274P AD=3.9274P PS=26.09U PD=26.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_20

* cell gf180mcu_fd_sc_mcu9t5v0__dffq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffq_2 1 5 6 7 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 5 Q
* net 6 CLK
* net 7 D
* net 14 NWELL,VDD
* device instance $1 r0 *1 14.6,3.78 pmos_5p0
M$1 5 4 14 14 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 4.24,3.41 pmos_5p0
M$3 15 2 14 14 pmos_5p0 L=0.5U W=1U AS=0.9462P AD=0.12P PS=4.91U PD=1.24U
* device instance $4 r0 *1 4.98,3.41 pmos_5p0
M$4 8 7 15 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.31P PS=1.24U PD=1.62U
* device instance $5 r0 *1 6.1,3.41 pmos_5p0
M$5 16 3 8 14 pmos_5p0 L=0.5U W=1U AS=0.31P AD=0.12P PS=1.62U PD=1.24U
* device instance $6 r0 *1 6.84,3.41 pmos_5p0
M$6 14 9 16 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.35P PS=1.24U PD=1.7U
* device instance $7 r0 *1 8.04,3.41 pmos_5p0
M$7 9 8 14 14 pmos_5p0 L=0.5U W=1U AS=0.35P AD=0.46P PS=1.7U PD=1.92U
* device instance $8 r0 *1 9.46,3.41 pmos_5p0
M$8 10 3 9 14 pmos_5p0 L=0.5U W=1U AS=0.46P AD=0.4P PS=1.92U PD=1.8U
* device instance $9 r0 *1 10.76,3.41 pmos_5p0
M$9 17 2 10 14 pmos_5p0 L=0.5U W=1U AS=0.4P AD=0.13P PS=1.8U PD=1.26U
* device instance $10 r0 *1 11.52,3.41 pmos_5p0
M$10 17 4 14 14 pmos_5p0 L=0.5U W=1U AS=0.6017P AD=0.13P PS=2.67U PD=1.26U
* device instance $11 r0 *1 12.86,3.78 pmos_5p0
M$11 4 10 14 14 pmos_5p0 L=0.5U W=1.83U AS=0.6017P AD=0.8052P PS=2.67U PD=4.54U
* device instance $12 r0 *1 0.87,3.555 pmos_5p0
M$12 14 6 3 14 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.4278P PS=3.64U PD=2U
* device instance $13 r0 *1 1.99,3.555 pmos_5p0
M$13 2 3 14 14 pmos_5p0 L=0.5U W=1.38U AS=0.4278P AD=0.6072P PS=2U PD=3.64U
* device instance $14 r0 *1 14.65,1.005 nmos_5p0
M$14 5 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $16 r0 *1 0.92,1.125 nmos_5p0
M$16 1 6 3 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.125 nmos_5p0
M$17 2 3 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 4.09,1.365 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.6463P AD=0.0696P PS=4U PD=0.82U
* device instance $19 r0 *1 4.93,1.365 nmos_5p0
M$19 8 7 11 1 nmos_5p0 L=0.6U W=0.58U AS=0.0696P AD=0.1508P PS=0.82U PD=1.1U
* device instance $20 r0 *1 6.05,1.365 nmos_5p0
M$20 12 2 8 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $21 r0 *1 6.89,1.365 nmos_5p0
M$21 12 9 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.40405P AD=0.0696P PS=2.425U PD=0.82U
* device instance $22 r0 *1 8.39,1.37 nmos_5p0
M$22 9 8 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.40405P AD=0.1508P PS=2.425U PD=1.1U
* device instance $23 r0 *1 9.51,1.37 nmos_5p0
M$23 10 2 9 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.1508P PS=1.1U PD=1.1U
* device instance $24 r0 *1 10.63,1.37 nmos_5p0
M$24 13 3 10 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $25 r0 *1 11.47,1.37 nmos_5p0
M$25 13 4 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3774P AD=0.0696P PS=2.06U PD=0.82U
* device instance $26 r0 *1 12.81,1 nmos_5p0
M$26 4 10 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3774P AD=0.5808P PS=2.06U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffq_2

* cell gf180mcu_fd_sc_mcu9t5v0__or2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 2 4 4 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 6 3 8 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 7 3 6 4 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 4 2 7 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.7869P PS=2.4U PD=2.69U
* device instance $5 r0 *1 5.59,3.78 pmos_5p0
M$5 5 6 4 4 pmos_5p0 L=0.5U W=7.32U AS=2.3973P AD=2.4156P PS=9.94U PD=11.79U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 6 2 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7788P PS=5.36U PD=3.82U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 1 3 6 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.54,1.005 nmos_5p0
M$13 5 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4652P AD=1.6104P PS=7.5U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_8 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7763P PS=21.69U PD=21.69U
* device instance $9 r0 *1 0.92,1.3 nmos_5p0
M$9 4 3 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.6498P AD=1.6498P PS=11.09U PD=11.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_8

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_2
* pin NWELL,VDD
* pin B2
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B2
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.4758P PS=4.54U PD=2.35U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 6 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $5 r0 *1 5.45,3.78 pmos_5p0
M$5 11 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 6 7 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 10 7 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 6 5 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $14 r0 *1 6.52,1.005 nmos_5p0
M$14 8 7 6 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_4 1 2 3 4 5
* net 1 NWELL,VDD
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 ZN
* net 5 A1
* device instance $1 r0 *1 0.87,3.687 pmos_5p0
M$1 4 3 1 1 pmos_5p0 L=0.5U W=6.58U AS=2.0069P AD=2.0069P PS=10.665U PD=10.665U
* device instance $2 r0 *1 1.89,3.687 pmos_5p0
M$2 1 5 4 1 pmos_5p0 L=0.5U W=6.58U AS=1.7108P AD=1.7108P PS=8.66U PD=8.66U
* device instance $9 r0 *1 1,1.005 nmos_5p0
M$9 9 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 5 9 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3729P PS=1.56U PD=1.885U
* device instance $11 r0 *1 3.005,1.005 nmos_5p0
M$11 8 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3729P AD=0.1584P PS=1.885U PD=1.56U
* device instance $12 r0 *1 3.845,1.005 nmos_5p0
M$12 2 3 8 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3663P PS=1.56U PD=1.875U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 7 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.2112P PS=1.875U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 4 5 7 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 6 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 2 3 6 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_12 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=21.96U AS=7.0455P AD=7.0455P PS=31.49U PD=31.49U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=8.76U AS=2.409P AD=2.409P PS=16.09U PD=16.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_12

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_3 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.552 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=2.75U AS=1.03125P AD=0.97625P PS=5.625U PD=4.17U
* device instance $3 r0 *1 3.29,3.552 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=5.5U AS=1.82875P AD=1.88375P PS=8.16U PD=9.615U
* device instance $7 r0 *1 0.92,1.34 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.1U AS=0.385P AD=0.3455P PS=3.05U PD=2.37U
* device instance $9 r0 *1 3.34,1.365 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=2.4U AS=0.6705P AD=0.732P PS=4.66U PD=5.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_4 1 3 4 5 6 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 RN
* net 4 Q
* net 5 CLK
* net 6 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 16.975,3.78 pmos_5p0
M$1 4 13 17 17 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U PD=11.59U
* device instance $5 r0 *1 9.55,3.71 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.285P PS=2.88U PD=1.57U
* device instance $6 r0 *1 10.62,3.71 pmos_5p0
M$6 11 2 10 17 pmos_5p0 L=0.5U W=1U AS=0.285P AD=0.26P PS=1.57U PD=1.52U
* device instance $7 r0 *1 11.64,3.71 pmos_5p0
M$7 12 8 11 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2875P PS=1.52U PD=1.575U
* device instance $8 r0 *1 12.715,3.71 pmos_5p0
M$8 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.5457P AD=0.2875P PS=2.57U PD=1.575U
* device instance $9 r0 *1 13.955,3.78 pmos_5p0
M$9 13 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5457P AD=0.4758P PS=2.57U PD=2.35U
* device instance $10 r0 *1 14.975,3.78 pmos_5p0
M$10 17 11 13 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $11 r0 *1 3.73,3.41 pmos_5p0
M$11 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $12 r0 *1 4.75,3.41 pmos_5p0
M$12 9 8 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 5.77,3.41 pmos_5p0
M$13 18 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $14 r0 *1 6.79,3.41 pmos_5p0
M$14 17 10 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $15 r0 *1 7.81,3.41 pmos_5p0
M$15 18 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $16 r0 *1 0.97,3.555 pmos_5p0
M$16 17 5 2 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $17 r0 *1 1.99,3.555 pmos_5p0
M$17 8 2 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $18 r0 *1 16.925,1.005 nmos_5p0
M$18 4 13 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $22 r0 *1 3.9,1.315 nmos_5p0
M$22 7 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $23 r0 *1 5.02,1.315 nmos_5p0
M$23 9 2 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $24 r0 *1 6.14,1.315 nmos_5p0
M$24 15 8 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0708P PS=1.11U PD=0.83U
* device instance $25 r0 *1 6.98,1.315 nmos_5p0
M$25 14 10 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.0826P PS=0.83U PD=0.87U
* device instance $26 r0 *1 7.86,1.315 nmos_5p0
M$26 1 3 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.0826P AD=0.2124P PS=0.87U PD=1.31U
* device instance $27 r0 *1 9.18,1.315 nmos_5p0
M$27 10 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2124P AD=0.190275P PS=1.31U PD=1.235U
* device instance $28 r0 *1 10.425,1.315 nmos_5p0
M$28 11 8 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.190275P AD=0.1534P PS=1.235U
+ PD=1.11U
* device instance $29 r0 *1 11.545,1.315 nmos_5p0
M$29 12 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $30 r0 *1 12.665,1.315 nmos_5p0
M$30 1 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 13.785,1.315 nmos_5p0
M$31 1 3 16 1 nmos_5p0 L=0.6U W=0.59U AS=0.3525P AD=0.1534P PS=2.02U PD=1.11U
* device instance $32 r0 *1 15.085,1.005 nmos_5p0
M$32 13 11 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3525P AD=0.5808P PS=2.02U PD=3.52U
* device instance $33 r0 *1 0.92,1.27 nmos_5p0
M$33 1 5 2 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $34 r0 *1 2.04,1.27 nmos_5p0
M$34 8 2 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin B1
* pin A1
* pin B2
* pin C
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_4 1 2 3 4 13 14 15 16
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 B1
* net 4 A1
* net 13 B2
* net 14 C
* net 15 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 9.8,3.78 pmos_5p0
M$1 17 14 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.27835P AD=2.20515P PS=11.64U
+ PD=9.73U
* device instance $5 r0 *1 14.21,3.78 pmos_5p0
M$5 2 4 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $6 r0 *1 15.23,3.78 pmos_5p0
M$6 18 15 2 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $13 r0 *1 0.92,3.78 pmos_5p0
M$13 17 3 16 16 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U
+ PD=11.59U
* device instance $14 r0 *1 1.94,3.78 pmos_5p0
M$14 16 13 17 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $21 r0 *1 9.6,0.74 nmos_5p0
M$21 1 14 2 1 nmos_5p0 L=0.6U W=3.16U AS=1.04675P AD=0.9717P PS=6.005U PD=5.815U
* device instance $25 r0 *1 0.92,0.937 nmos_5p0
M$25 5 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.219225P PS=3.25U PD=1.555U
* device instance $26 r0 *1 1.89,0.937 nmos_5p0
M$26 1 13 5 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.01,0.937 nmos_5p0
M$27 7 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 3.93,0.937 nmos_5p0
M$28 2 3 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.05,0.937 nmos_5p0
M$29 9 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 5.97,0.937 nmos_5p0
M$30 1 13 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.09,0.937 nmos_5p0
M$31 8 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.24885P PS=1.705U
+ PD=1.605U
* device instance $32 r0 *1 8.11,0.937 nmos_5p0
M$32 2 3 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.24885P AD=0.43055P PS=1.605U
+ PD=2.075U
* device instance $33 r0 *1 14.26,0.937 nmos_5p0
M$33 12 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1896P PS=1.885U PD=1.505U
* device instance $34 r0 *1 15.18,0.937 nmos_5p0
M$34 1 15 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $35 r0 *1 16.3,0.937 nmos_5p0
M$35 11 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U
+ PD=1.505U
* device instance $36 r0 *1 17.22,0.937 nmos_5p0
M$36 2 4 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $37 r0 *1 18.34,0.937 nmos_5p0
M$37 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $38 r0 *1 19.26,0.937 nmos_5p0
M$38 1 15 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $39 r0 *1 20.38,0.937 nmos_5p0
M$39 6 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $40 r0 *1 21.3,0.937 nmos_5p0
M$40 2 4 6 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.5214P PS=1.505U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_4

* cell gf180mcu_fd_sc_mcu9t5v0__inv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=3.96U AS=1.2672P AD=1.2672P PS=7.2U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_3

* cell gf180mcu_fd_sc_mcu9t5v0__inv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.7385P PS=7.02U PD=7.39U
* device instance $3 r0 *1 0.92,1.005 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.9438P AD=0.9438P PS=5.39U PD=5.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_2

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__and4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_2 1 2 3 4 5 6 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.925,4.055 pmos_5p0
M$1 7 1 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3328P PS=3.44U PD=1.8U
* device instance $2 r0 *1 1.945,4.055 pmos_5p0
M$2 6 2 7 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $3 r0 *1 2.965,4.055 pmos_5p0
M$3 7 3 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $4 r0 *1 3.985,4.055 pmos_5p0
M$4 7 4 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.558P AD=0.3328P PS=2.53U PD=1.8U
* device instance $5 r0 *1 5.185,3.78 pmos_5p0
M$5 8 7 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.0338P AD=1.281P PS=4.88U PD=6.89U
* device instance $7 r0 *1 0.975,1.005 nmos_5p0
M$7 11 1 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $8 r0 *1 1.895,1.005 nmos_5p0
M$8 10 2 11 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $9 r0 *1 2.915,1.005 nmos_5p0
M$9 9 3 10 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $10 r0 *1 3.935,1.005 nmos_5p0
M$10 5 4 9 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $11 r0 *1 5.055,1.005 nmos_5p0
M$11 8 7 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.673P PS=26.59U PD=24.5U
* device instance $11 r0 *1 12.07,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.346P AD=11.5839P PS=49U PD=51.09U
* device instance $31 r0 *1 0.92,1.005 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=13.2U AS=3.6696P AD=3.432P PS=20.08U PD=18.4U
* device instance $41 r0 *1 12.12,1.005 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=26.4U AS=6.864P AD=7.1016P PS=36.8U PD=38.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_20

* cell gf180mcu_fd_sc_mcu9t5v0__buf_3
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_3 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.74115P PS=4.54U PD=2.64U
* device instance $2 r0 *1 2.18,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.87575P AD=1.9398P PS=7.54U PD=9.44U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 1 4 3 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.4686P PS=3.52U PD=2.03U
* device instance $6 r0 *1 2.23,1.005 nmos_5p0
M$6 5 4 3 3 nmos_5p0 L=0.6U W=3.96U AS=1.155P AD=1.2672P PS=5.71U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_3

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.8377P PS=26.59U PD=24.68U
* device instance $11 r0 *1 12.25,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.5107P AD=11.5839P PS=49.18U PD=51.09U
* device instance $31 r0 *1 0.92,1.3 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=7.3U AS=2.1091P AD=1.898P PS=13.84U PD=12.5U
* device instance $41 r0 *1 12.3,1.265 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=16U AS=4.2215P AD=4.304P PS=26.58U PD=27.56U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20

* cell gf180mcu_fd_sc_mcu9t5v0__mux4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin S1
* pin I0
* pin I2
* pin S0
* pin I3
* pin I1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux4_2 1 6 7 11 12 13 14 16 18
* net 1 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* net 7 S1
* net 11 I0
* net 12 I2
* net 13 S0
* net 14 I3
* net 16 I1
* net 18 NWELL,VDD
* device instance $1 r0 *1 0.97,3.62 pmos_5p0
M$1 3 12 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.6848P AD=0.5504P PS=3.63U PD=2.14U
* device instance $2 r0 *1 2.33,3.62 pmos_5p0
M$2 4 13 3 18 pmos_5p0 L=0.5U W=1.28U AS=0.5504P AD=0.4544P PS=2.14U PD=1.99U
* device instance $3 r0 *1 3.54,3.62 pmos_5p0
M$3 5 17 4 18 pmos_5p0 L=0.5U W=1.28U AS=0.4544P AD=0.4032P PS=1.99U PD=1.91U
* device instance $4 r0 *1 4.67,3.62 pmos_5p0
M$4 18 14 5 18 pmos_5p0 L=0.5U W=1.28U AS=0.4032P AD=0.6432P PS=1.91U PD=2.4U
* device instance $5 r0 *1 6.13,3.62 pmos_5p0
M$5 6 2 18 18 pmos_5p0 L=0.5U W=2.56U AS=0.976P AD=0.896P PS=4.2U PD=5.24U
* device instance $7 r0 *1 9.555,3.62 pmos_5p0
M$7 2 15 4 18 pmos_5p0 L=0.5U W=1.28U AS=0.7616P AD=0.4672P PS=3.75U PD=2.01U
* device instance $8 r0 *1 10.785,3.62 pmos_5p0
M$8 8 7 2 18 pmos_5p0 L=0.5U W=1.28U AS=0.4672P AD=0.5632P PS=2.01U PD=3.44U
* device instance $9 r0 *1 12.605,3.62 pmos_5p0
M$9 18 7 15 18 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3712P PS=3.44U PD=1.86U
* device instance $10 r0 *1 13.685,3.62 pmos_5p0
M$10 9 16 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.3712P AD=0.3776P PS=1.86U PD=1.87U
* device instance $11 r0 *1 14.775,3.62 pmos_5p0
M$11 8 17 9 18 pmos_5p0 L=0.5U W=1.28U AS=0.3776P AD=0.3328P PS=1.87U PD=1.8U
* device instance $12 r0 *1 15.795,3.62 pmos_5p0
M$12 10 13 8 18 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.416P PS=1.8U PD=1.93U
* device instance $13 r0 *1 16.945,3.62 pmos_5p0
M$13 18 11 10 18 pmos_5p0 L=0.5U W=1.28U AS=0.416P AD=0.3968P PS=1.93U PD=1.9U
* device instance $14 r0 *1 18.065,3.62 pmos_5p0
M$14 17 13 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.3968P AD=0.5632P PS=1.9U PD=3.44U
* device instance $15 r0 *1 12.515,1.18 nmos_5p0
M$15 1 7 15 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.208P PS=2.48U PD=1.32U
* device instance $16 r0 *1 13.635,1.18 nmos_5p0
M$16 9 16 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $17 r0 *1 14.755,1.18 nmos_5p0
M$17 8 13 9 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $18 r0 *1 15.875,1.18 nmos_5p0
M$18 10 17 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $19 r0 *1 16.995,1.18 nmos_5p0
M$19 1 11 10 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $20 r0 *1 18.115,1.18 nmos_5p0
M$20 17 13 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
* device instance $21 r0 *1 0.92,1.18 nmos_5p0
M$21 3 12 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.48P PS=2.48U PD=2U
* device instance $22 r0 *1 2.72,1.18 nmos_5p0
M$22 4 17 3 1 nmos_5p0 L=0.6U W=0.8U AS=0.48P AD=0.208P PS=2U PD=1.32U
* device instance $23 r0 *1 3.84,1.18 nmos_5p0
M$23 5 13 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $24 r0 *1 4.96,1.18 nmos_5p0
M$24 1 14 5 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $25 r0 *1 6.08,1.18 nmos_5p0
M$25 6 2 1 1 nmos_5p0 L=0.6U W=1.6U AS=0.416P AD=0.56P PS=2.64U PD=3.8U
* device instance $27 r0 *1 9.555,1.18 nmos_5p0
M$27 2 7 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.544P AD=0.208P PS=2.96U PD=1.32U
* device instance $28 r0 *1 10.675,1.18 nmos_5p0
M$28 8 15 2 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux4_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin C
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_2 1 3 4 5 6 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 NWELL,VDD
* net 5 B1
* net 6 C
* net 8 A2
* net 9 ZN
* net 10 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 2 6 7 4 pmos_5p0 L=0.5U W=3.66U AS=1.4457P AD=0.983625P PS=7.07U PD=4.735U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.1163P PS=4.7U PD=4.88U
* device instance $3 r0 *1 3.01,3.78 pmos_5p0
M$3 2 5 4 4 pmos_5p0 L=0.5U W=3.66U AS=0.9699P AD=0.9699P PS=4.72U PD=4.72U
* device instance $7 r0 *1 7.325,3.78 pmos_5p0
M$7 9 10 7 4 pmos_5p0 L=0.5U W=3.66U AS=0.983625P AD=1.281P PS=4.735U PD=6.89U
* device instance $8 r0 *1 8.345,3.78 pmos_5p0
M$8 7 8 9 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $11 r0 *1 6.32,0.875 nmos_5p0
M$11 9 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.711P AD=0.709025P PS=3.77U PD=4.36U
* device instance $13 r0 *1 2.22,1.072 nmos_5p0
M$13 14 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1422P PS=1.885U PD=1.425U
* device instance $14 r0 *1 3.06,1.072 nmos_5p0
M$14 9 5 14 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 4.18,1.072 nmos_5p0
M$15 12 5 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 5.02,1.072 nmos_5p0
M$16 1 3 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
* device instance $17 r0 *1 7.635,1.072 nmos_5p0
M$17 13 10 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.361425P AD=0.1422P PS=1.9U
+ PD=1.425U
* device instance $18 r0 *1 8.475,1.072 nmos_5p0
M$18 1 8 13 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $19 r0 *1 9.595,1.072 nmos_5p0
M$19 11 8 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $20 r0 *1 10.435,1.072 nmos_5p0
M$20 9 10 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.5214P PS=1.425U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_4 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__buf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.2692P PS=11.89U PD=9.8U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.5384P AD=4.7763P PS=19.6U PD=21.69U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $17 r0 *1 5.4,1.005 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.7456P AD=2.9832P PS=14.72U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_8

* cell gf180mcu_fd_sc_mcu9t5v0__dlya_4
* pin I
* pin Z
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlya_4 1 5 6 7
* net 1 I
* net 5 Z
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 3.885,3.61 pmos_5p0
M$1 4 3 6 6 pmos_5p0 L=0.5U W=0.36U AS=0.429P AD=0.1584P PS=2.58U PD=1.6U
* device instance $2 r0 *1 5.135,3.78 pmos_5p0
M$2 5 4 6 6 pmos_5p0 L=0.5U W=7.32U AS=2.1309P AD=2.5071P PS=9.93U PD=11.89U
* device instance $6 r0 *1 0.875,3.61 pmos_5p0
M$6 6 1 2 6 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1116P PS=1.6U PD=0.98U
* device instance $7 r0 *1 1.995,3.61 pmos_5p0
M$7 3 2 6 6 pmos_5p0 L=0.5U W=0.36U AS=0.1116P AD=0.1584P PS=0.98U PD=1.6U
* device instance $8 r0 *1 3.885,0.94 nmos_5p0
M$8 4 3 7 7 nmos_5p0 L=0.6U W=0.36U AS=0.318P AD=0.1584P PS=2.02U PD=1.6U
* device instance $9 r0 *1 5.185,1.005 nmos_5p0
M$9 5 4 7 7 nmos_5p0 L=0.6U W=5.28U AS=1.3476P AD=1.6104P PS=7.54U PD=9.04U
* device instance $13 r0 *1 0.925,0.94 nmos_5p0
M$13 7 1 2 7 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0936P PS=1.6U PD=0.88U
* device instance $14 r0 *1 2.045,0.94 nmos_5p0
M$14 3 2 7 7 nmos_5p0 L=0.6U W=0.36U AS=0.0936P AD=0.1584P PS=0.88U PD=1.6U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlya_4

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 10 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 10 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 11 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 11 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 8 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 8 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffq_4 1 8 9 10 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 8 Q
* net 9 CLK
* net 10 D
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.97,3.555 pmos_5p0
M$1 14 9 3 14 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $2 r0 *1 1.99,3.555 pmos_5p0
M$2 2 3 14 14 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $3 r0 *1 4.03,3.365 pmos_5p0
M$3 15 2 14 14 pmos_5p0 L=0.5U W=1U AS=0.9696P AD=0.12P PS=5.04U PD=1.24U
* device instance $4 r0 *1 4.77,3.365 pmos_5p0
M$4 4 10 15 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.36P PS=1.24U PD=1.72U
* device instance $5 r0 *1 5.99,3.365 pmos_5p0
M$5 16 3 4 14 pmos_5p0 L=0.5U W=1U AS=0.36P AD=0.12P PS=1.72U PD=1.24U
* device instance $6 r0 *1 6.73,3.365 pmos_5p0
M$6 14 5 16 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.45P PS=1.24U PD=1.9U
* device instance $7 r0 *1 8.13,3.365 pmos_5p0
M$7 5 4 14 14 pmos_5p0 L=0.5U W=1U AS=0.45P AD=0.3075P PS=1.9U PD=1.615U
* device instance $8 r0 *1 9.245,3.365 pmos_5p0
M$8 6 3 5 14 pmos_5p0 L=0.5U W=1U AS=0.3075P AD=0.4625P PS=1.615U PD=1.925U
* device instance $9 r0 *1 10.67,3.365 pmos_5p0
M$9 17 2 6 14 pmos_5p0 L=0.5U W=1U AS=0.4625P AD=0.14P PS=1.925U PD=1.28U
* device instance $10 r0 *1 11.45,3.365 pmos_5p0
M$10 14 7 17 14 pmos_5p0 L=0.5U W=1U AS=0.14P AD=0.5526P PS=1.28U PD=2.57U
* device instance $11 r0 *1 12.69,3.78 pmos_5p0
M$11 7 6 14 14 pmos_5p0 L=0.5U W=3.66U AS=1.0284P AD=0.9516P PS=4.92U PD=4.7U
* device instance $13 r0 *1 14.73,3.78 pmos_5p0
M$13 8 7 14 14 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=2.2326P PS=9.4U PD=11.59U
* device instance $17 r0 *1 0.92,1.27 nmos_5p0
M$17 1 9 3 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $18 r0 *1 2.04,1.27 nmos_5p0
M$18 2 3 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $19 r0 *1 3.88,1.375 nmos_5p0
M$19 11 3 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.2552P AD=0.0696P PS=2.04U PD=0.82U
* device instance $20 r0 *1 4.72,1.375 nmos_5p0
M$20 4 10 11 1 nmos_5p0 L=0.6U W=0.58U AS=0.0696P AD=0.1508P PS=0.82U PD=1.1U
* device instance $21 r0 *1 5.84,1.375 nmos_5p0
M$21 12 2 4 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $22 r0 *1 6.68,1.375 nmos_5p0
M$22 12 5 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3932P AD=0.0696P PS=2.35U PD=0.82U
* device instance $23 r0 *1 8.18,1.375 nmos_5p0
M$23 5 4 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3932P AD=0.1508P PS=2.35U PD=1.1U
* device instance $24 r0 *1 9.3,1.375 nmos_5p0
M$24 6 2 5 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.1508P PS=1.1U PD=1.1U
* device instance $25 r0 *1 10.42,1.375 nmos_5p0
M$25 13 3 6 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $26 r0 *1 11.26,1.375 nmos_5p0
M$26 13 7 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3774P AD=0.0696P PS=2.06U PD=0.82U
* device instance $27 r0 *1 12.6,1.005 nmos_5p0
M$27 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7206P AD=0.6864P PS=3.9U PD=3.68U
* device instance $29 r0 *1 14.84,1.005 nmos_5p0
M$29 8 7 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffq_4

* cell gf180mcu_fd_sc_mcu9t5v0__addh_1
* pin CO
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A
* pin B
* pin S
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_1 1 2 3 4 5 9
* net 1 CO
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 NWELL,VDD
* net 4 A
* net 5 B
* net 9 S
* device instance $1 r0 *1 5.01,3.912 pmos_5p0
M$1 11 5 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 6.03,3.912 pmos_5p0
M$2 8 4 11 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.3294P PS=1.435U PD=1.635U
* device instance $3 r0 *1 7.25,3.912 pmos_5p0
M$3 8 6 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.50325P AD=0.3294P PS=2.53U PD=1.635U
* device instance $4 r0 *1 8.45,3.78 pmos_5p0
M$4 9 8 3 3 pmos_5p0 L=0.5U W=1.83U AS=0.50325P AD=0.8052P PS=2.53U PD=4.54U
* device instance $5 r0 *1 2.23,3.912 pmos_5p0
M$5 6 4 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.5307P AD=0.2379P PS=2.59U PD=1.435U
* device instance $6 r0 *1 3.25,3.912 pmos_5p0
M$6 3 5 6 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.4026P PS=1.435U PD=2.71U
* device instance $7 r0 *1 0.97,3.78 pmos_5p0
M$7 3 6 1 3 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5307P PS=4.54U PD=2.59U
* device instance $8 r0 *1 4.96,1.335 nmos_5p0
M$8 8 5 7 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $9 r0 *1 6.08,1.335 nmos_5p0
M$9 7 4 8 2 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.1716P PS=1.18U PD=1.18U
* device instance $10 r0 *1 7.2,1.335 nmos_5p0
M$10 7 6 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1716P PS=2.02U PD=1.18U
* device instance $11 r0 *1 8.5,1.005 nmos_5p0
M$11 9 8 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.5808P PS=2.02U PD=3.52U
* device instance $12 r0 *1 0.92,1.005 nmos_5p0
M$12 2 6 1 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3828P PS=3.52U PD=2.08U
* device instance $13 r0 *1 2.28,1.335 nmos_5p0
M$13 10 4 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.3828P AD=0.0792P PS=2.08U PD=0.9U
* device instance $14 r0 *1 3.12,1.335 nmos_5p0
M$14 6 5 10 2 nmos_5p0 L=0.6U W=0.66U AS=0.0792P AD=0.2904P PS=0.9U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_1

* cell gf180mcu_fd_sc_mcu9t5v0__addh_4
* pin PWELL,VSS,gf180mcu_gnd
* pin S
* pin A
* pin B
* pin CO
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_4 1 4 5 6 8 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 4 S
* net 5 A
* net 6 B
* net 8 CO
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 2 5 11 11 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.16205P PS=6.89U PD=4.93U
* device instance $2 r0 *1 1.94,3.78 pmos_5p0
M$2 11 6 2 11 pmos_5p0 L=0.5U W=3.66U AS=0.99735P AD=0.99735P PS=4.75U PD=4.75U
* device instance $5 r0 *1 5.28,3.78 pmos_5p0
M$5 7 2 11 11 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.25355P PS=5.03U PD=5.03U
* device instance $6 r0 *1 6.35,3.78 pmos_5p0
M$6 12 5 7 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 7.52,3.78 pmos_5p0
M$7 11 6 12 11 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.5673P PS=2.5U PD=2.45U
* device instance $8 r0 *1 8.64,3.78 pmos_5p0
M$8 13 6 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 9.76,3.78 pmos_5p0
M$9 7 5 13 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 12.18,3.78 pmos_5p0
M$11 8 2 11 11 pmos_5p0 L=0.5U W=7.32U AS=2.38815P AD=2.22345P PS=9.93U PD=9.75U
* device instance $15 r0 *1 16.61,3.78 pmos_5p0
M$15 4 7 11 11 pmos_5p0 L=0.5U W=7.32U AS=2.24175P AD=2.47965P PS=9.77U
+ PD=11.86U
* device instance $19 r0 *1 0.92,1 nmos_5p0
M$19 9 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2772P PS=3.52U PD=1.74U
* device instance $20 r0 *1 1.94,1 nmos_5p0
M$20 2 6 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $21 r0 *1 3.06,1 nmos_5p0
M$21 10 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 3.98,1 nmos_5p0
M$22 1 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.396P PS=1.64U PD=2.02U
* device instance $23 r0 *1 5.28,1.22 nmos_5p0
M$23 3 2 1 1 nmos_5p0 L=0.6U W=1.76U AS=0.792P AD=0.4576P PS=4.04U PD=2.8U
* device instance $24 r0 *1 6.4,1.22 nmos_5p0
M$24 7 5 3 1 nmos_5p0 L=0.6U W=1.76U AS=0.4576P AD=0.4576P PS=2.8U PD=2.8U
* device instance $25 r0 *1 7.52,1.22 nmos_5p0
M$25 3 6 7 1 nmos_5p0 L=0.6U W=1.76U AS=0.4576P AD=0.4576P PS=2.8U PD=2.8U
* device instance $29 r0 *1 12.18,1 nmos_5p0
M$29 8 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4256P AD=1.3728P PS=7.54U PD=7.36U
* device instance $33 r0 *1 16.66,1 nmos_5p0
M$33 4 7 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_4

* cell gf180mcu_fd_sc_mcu9t5v0__addh_2
* pin PWELL,VSS,gf180mcu_gnd
* pin CO
* pin S
* pin A
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_2 1 2 6 7 8 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 CO
* net 6 S
* net 7 A
* net 8 B
* net 10 NWELL,VDD
* device instance $1 r0 *1 5.99,3.78 pmos_5p0
M$1 11 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 7.06,3.78 pmos_5p0
M$2 5 7 11 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.52155P PS=2.4U PD=2.4U
* device instance $3 r0 *1 8.13,3.78 pmos_5p0
M$3 10 3 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8784P PS=2.4U PD=2.79U
* device instance $4 r0 *1 9.59,3.78 pmos_5p0
M$4 6 5 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.32675P PS=5.19U PD=6.94U
* device instance $6 r0 *1 0.94,3.78 pmos_5p0
M$6 2 3 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.08885P PS=6.99U PD=4.85U
* device instance $8 r0 *1 3.13,3.78 pmos_5p0
M$8 3 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.4758P PS=2.4U PD=2.35U
* device instance $9 r0 *1 4.15,3.78 pmos_5p0
M$9 10 8 3 10 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 5.94,1.005 nmos_5p0
M$10 5 8 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $11 r0 *1 7.06,1.005 nmos_5p0
M$11 4 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $12 r0 *1 8.18,1.005 nmos_5p0
M$12 1 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5016P PS=1.84U PD=2.08U
* device instance $13 r0 *1 9.54,1.005 nmos_5p0
M$13 6 5 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.8448P AD=0.924P PS=3.92U PD=5.36U
* device instance $15 r0 *1 0.94,1.005 nmos_5p0
M$15 2 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $17 r0 *1 3.18,1.005 nmos_5p0
M$17 9 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 4.1,1.005 nmos_5p0
M$18 3 8 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_2

* cell gf180mcu_fd_sc_mcu9t5v0__addf_1
* pin PWELL,VSS,gf180mcu_gnd
* pin A
* pin S
* pin CO
* pin B
* pin CI
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addf_1 1 2 3 4 12 13 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A
* net 3 S
* net 4 CO
* net 12 B
* net 13 CI
* net 14 NWELL,VDD
* device instance $1 r0 *1 2.31,3.465 pmos_5p0
M$1 18 2 14 14 pmos_5p0 L=0.5U W=0.99U AS=0.5985P AD=0.1683P PS=2.67U PD=1.33U
* device instance $2 r0 *1 3.15,3.465 pmos_5p0
M$2 17 12 18 14 pmos_5p0 L=0.5U W=0.99U AS=0.1683P AD=0.1683P PS=1.33U PD=1.33U
* device instance $3 r0 *1 3.99,3.465 pmos_5p0
M$3 5 13 17 14 pmos_5p0 L=0.5U W=0.99U AS=0.1683P AD=0.3069P PS=1.33U PD=1.61U
* device instance $4 r0 *1 5.11,3.465 pmos_5p0
M$4 15 8 5 14 pmos_5p0 L=0.5U W=0.99U AS=0.3069P AD=0.3069P PS=1.61U PD=1.61U
* device instance $5 r0 *1 6.23,3.465 pmos_5p0
M$5 14 2 15 14 pmos_5p0 L=0.5U W=0.99U AS=0.3069P AD=0.2574P PS=1.61U PD=1.51U
* device instance $6 r0 *1 7.25,3.465 pmos_5p0
M$6 15 12 14 14 pmos_5p0 L=0.5U W=0.99U AS=0.2574P AD=0.2574P PS=1.51U PD=1.51U
* device instance $7 r0 *1 8.27,3.465 pmos_5p0
M$7 14 13 15 14 pmos_5p0 L=0.5U W=0.99U AS=0.2574P AD=0.4356P PS=1.51U PD=2.86U
* device instance $8 r0 *1 0.97,3.78 pmos_5p0
M$8 14 5 3 14 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5985P PS=4.54U PD=2.67U
* device instance $9 r0 *1 10.31,3.36 pmos_5p0
M$9 14 12 16 14 pmos_5p0 L=0.5U W=0.99U AS=0.4356P AD=0.2574P PS=2.86U PD=1.51U
* device instance $10 r0 *1 11.33,3.36 pmos_5p0
M$10 16 2 14 14 pmos_5p0 L=0.5U W=0.99U AS=0.2574P AD=0.3069P PS=1.51U PD=1.61U
* device instance $11 r0 *1 12.45,3.36 pmos_5p0
M$11 8 13 16 14 pmos_5p0 L=0.5U W=0.99U AS=0.3069P AD=0.3069P PS=1.61U PD=1.61U
* device instance $12 r0 *1 13.57,3.36 pmos_5p0
M$12 19 12 8 14 pmos_5p0 L=0.5U W=0.99U AS=0.3069P AD=0.1683P PS=1.61U PD=1.33U
* device instance $13 r0 *1 14.41,3.36 pmos_5p0
M$13 14 2 19 14 pmos_5p0 L=0.5U W=0.99U AS=0.1683P AD=0.6006P PS=1.33U PD=2.67U
* device instance $14 r0 *1 15.75,3.78 pmos_5p0
M$14 4 8 14 14 pmos_5p0 L=0.5U W=1.83U AS=0.6006P AD=0.8052P PS=2.67U PD=4.54U
* device instance $15 r0 *1 10.26,1.37 nmos_5p0
M$15 1 12 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $16 r0 *1 11.38,1.37 nmos_5p0
M$16 7 2 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $17 r0 *1 12.5,1.37 nmos_5p0
M$17 8 13 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $18 r0 *1 13.62,1.37 nmos_5p0
M$18 11 12 8 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0708P PS=1.11U PD=0.83U
* device instance $19 r0 *1 14.46,1.37 nmos_5p0
M$19 11 2 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.3789P AD=0.0708P PS=2.06U PD=0.83U
* device instance $20 r0 *1 15.8,1.005 nmos_5p0
M$20 4 8 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3789P AD=0.5808P PS=2.06U PD=3.52U
* device instance $21 r0 *1 0.92,1.075 nmos_5p0
M$21 1 5 3 1 nmos_5p0 L=0.6U W=1.18U AS=0.5192P AD=0.3481P PS=3.24U PD=1.92U
* device instance $22 r0 *1 2.26,1.37 nmos_5p0
M$22 9 2 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.3481P AD=0.0708P PS=1.92U PD=0.83U
* device instance $23 r0 *1 3.1,1.37 nmos_5p0
M$23 10 12 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.0708P PS=0.83U PD=0.83U
* device instance $24 r0 *1 3.94,1.37 nmos_5p0
M$24 5 13 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.1534P PS=0.83U PD=1.11U
* device instance $25 r0 *1 5.06,1.37 nmos_5p0
M$25 6 8 5 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $26 r0 *1 6.18,1.37 nmos_5p0
M$26 1 2 6 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $27 r0 *1 7.3,1.37 nmos_5p0
M$27 6 12 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $28 r0 *1 8.42,1.37 nmos_5p0
M$28 1 13 6 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.2596P PS=1.11U PD=2.06U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addf_1

* cell gf180mcu_fd_sc_mcu9t5v0__addf_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A
* pin S
* pin B
* pin CI
* pin CO
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addf_2 1 2 3 5 6 10 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A
* net 3 S
* net 5 B
* net 6 CI
* net 10 CO
* net 14 NWELL,VDD
* device instance $1 r0 *1 11.37,3.56 pmos_5p0
M$1 14 5 16 14 pmos_5p0 L=0.5U W=1.39U AS=0.6116P AD=0.4309P PS=3.66U PD=2.01U
* device instance $2 r0 *1 12.49,3.56 pmos_5p0
M$2 16 2 14 14 pmos_5p0 L=0.5U W=1.39U AS=0.4309P AD=0.5004P PS=2.01U PD=2.11U
* device instance $3 r0 *1 13.71,3.56 pmos_5p0
M$3 9 6 16 14 pmos_5p0 L=0.5U W=1.39U AS=0.5004P AD=0.4309P PS=2.11U PD=2.01U
* device instance $4 r0 *1 14.83,3.56 pmos_5p0
M$4 19 5 9 14 pmos_5p0 L=0.5U W=1.39U AS=0.4309P AD=0.1668P PS=2.01U PD=1.63U
* device instance $5 r0 *1 15.57,3.56 pmos_5p0
M$5 14 2 19 14 pmos_5p0 L=0.5U W=1.39U AS=0.1668P AD=0.5685P PS=1.63U PD=2.5U
* device instance $6 r0 *1 16.77,3.765 pmos_5p0
M$6 10 9 14 14 pmos_5p0 L=0.5U W=3.6U AS=1.0365P AD=1.26P PS=4.82U PD=6.8U
* device instance $8 r0 *1 3.57,3.56 pmos_5p0
M$8 18 2 14 14 pmos_5p0 L=0.5U W=1.39U AS=0.6601P AD=0.1668P PS=2.62U PD=1.63U
* device instance $9 r0 *1 4.31,3.56 pmos_5p0
M$9 17 5 18 14 pmos_5p0 L=0.5U W=1.39U AS=0.1668P AD=0.2363P PS=1.63U PD=1.73U
* device instance $10 r0 *1 5.15,3.56 pmos_5p0
M$10 4 6 17 14 pmos_5p0 L=0.5U W=1.39U AS=0.2363P AD=0.3614P PS=1.73U PD=1.91U
* device instance $11 r0 *1 6.17,3.56 pmos_5p0
M$11 15 9 4 14 pmos_5p0 L=0.5U W=1.39U AS=0.3614P AD=0.5004P PS=1.91U PD=2.11U
* device instance $12 r0 *1 7.39,3.56 pmos_5p0
M$12 14 2 15 14 pmos_5p0 L=0.5U W=1.39U AS=0.5004P AD=0.3614P PS=2.11U PD=1.91U
* device instance $13 r0 *1 8.41,3.56 pmos_5p0
M$13 15 5 14 14 pmos_5p0 L=0.5U W=1.39U AS=0.3614P AD=0.5004P PS=1.91U PD=2.11U
* device instance $14 r0 *1 9.63,3.56 pmos_5p0
M$14 14 6 15 14 pmos_5p0 L=0.5U W=1.39U AS=0.5004P AD=0.6116P PS=2.11U PD=3.66U
* device instance $15 r0 *1 1.23,3.765 pmos_5p0
M$15 3 4 14 14 pmos_5p0 L=0.5U W=3.6U AS=1.26P AD=1.1281P PS=6.8U PD=4.94U
* device instance $17 r0 *1 11.42,1.265 nmos_5p0
M$17 1 5 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.208P PS=2.48U PD=1.32U
* device instance $18 r0 *1 12.54,1.265 nmos_5p0
M$18 8 2 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $19 r0 *1 13.66,1.265 nmos_5p0
M$19 9 6 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $20 r0 *1 14.78,1.265 nmos_5p0
M$20 13 5 9 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.096P PS=1.32U PD=1.04U
* device instance $21 r0 *1 15.62,1.265 nmos_5p0
M$21 13 2 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.3972P AD=0.096P PS=2.04U PD=1.04U
* device instance $22 r0 *1 16.94,1.005 nmos_5p0
M$22 10 9 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7404P AD=0.924P PS=3.88U PD=5.36U
* device instance $24 r0 *1 0.96,1.005 nmos_5p0
M$24 3 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7536P PS=5.36U PD=3.9U
* device instance $26 r0 *1 3.42,1.265 nmos_5p0
M$26 11 2 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.4104P AD=0.096P PS=2.06U PD=1.04U
* device instance $27 r0 *1 4.26,1.265 nmos_5p0
M$27 12 5 11 1 nmos_5p0 L=0.6U W=0.8U AS=0.096P AD=0.096P PS=1.04U PD=1.04U
* device instance $28 r0 *1 5.1,1.265 nmos_5p0
M$28 4 6 12 1 nmos_5p0 L=0.6U W=0.8U AS=0.096P AD=0.208P PS=1.04U PD=1.32U
* device instance $29 r0 *1 6.22,1.265 nmos_5p0
M$29 7 9 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $30 r0 *1 7.34,1.265 nmos_5p0
M$30 1 2 7 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $31 r0 *1 8.46,1.265 nmos_5p0
M$31 7 5 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $32 r0 *1 9.58,1.265 nmos_5p0
M$32 1 6 7 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addf_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_16 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7031P PS=21.69U PD=19.78U
* device instance $9 r0 *1 10.01,3.78 pmos_5p0
M$9 4 3 5 5 pmos_5p0 L=0.5U W=29.28U AS=9.2415P AD=9.3147P PS=39.38U PD=41.29U
* device instance $25 r0 *1 0.92,1.3 nmos_5p0
M$25 3 2 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.7295P AD=1.5184P PS=11.34U PD=10U
* device instance $33 r0 *1 10.06,1.265 nmos_5p0
M$33 4 3 1 1 nmos_5p0 L=0.6U W=12.8U AS=3.3895P AD=3.472P PS=21.3U PD=22.28U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16

* cell gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin ZN
* pin A3
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor3_2 1 3 4 8 11 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 A1
* net 8 ZN
* net 11 A3
* net 12 NWELL,VDD
* device instance $1 r0 *1 13.64,3.78 pmos_5p0
M$1 12 7 8 12 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 1.09,3.772 pmos_5p0
M$3 15 3 2 12 pmos_5p0 L=0.5U W=0.495U AS=0.2178P AD=0.15345P PS=1.87U PD=1.115U
* device instance $4 r0 *1 2.21,3.772 pmos_5p0
M$4 15 4 12 12 pmos_5p0 L=0.5U W=0.495U AS=0.282P AD=0.15345P PS=1.715U
+ PD=1.115U
* device instance $5 r0 *1 3.51,3.967 pmos_5p0
M$5 13 2 12 12 pmos_5p0 L=0.5U W=0.915U AS=0.282P AD=0.2379P PS=1.715U PD=1.435U
* device instance $6 r0 *1 4.53,3.967 pmos_5p0
M$6 5 4 13 12 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.2379P PS=1.435U PD=1.435U
* device instance $7 r0 *1 5.55,3.967 pmos_5p0
M$7 13 3 5 12 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.4026P PS=1.435U PD=2.71U
* device instance $8 r0 *1 7.39,3.977 pmos_5p0
M$8 16 5 6 12 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $9 r0 *1 8.41,3.977 pmos_5p0
M$9 16 11 12 12 pmos_5p0 L=0.5U W=0.915U AS=0.571875P AD=0.2379P PS=2.68U
+ PD=1.435U
* device instance $10 r0 *1 9.76,3.78 pmos_5p0
M$10 14 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.571875P AD=0.52155P PS=2.68U
+ PD=2.4U
* device instance $11 r0 *1 10.83,3.78 pmos_5p0
M$11 7 11 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.4758P PS=2.4U PD=2.35U
* device instance $12 r0 *1 11.85,3.78 pmos_5p0
M$12 14 5 7 12 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $13 r0 *1 1.04,1.015 nmos_5p0
M$13 2 3 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0936P PS=1.6U PD=0.88U
* device instance $14 r0 *1 2.16,1.015 nmos_5p0
M$14 1 4 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.0936P AD=0.186P PS=0.88U PD=1.36U
* device instance $15 r0 *1 3.46,1.165 nmos_5p0
M$15 5 2 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.186P AD=0.1716P PS=1.36U PD=1.18U
* device instance $16 r0 *1 4.58,1.165 nmos_5p0
M$16 9 4 5 1 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.1056P PS=1.18U PD=0.98U
* device instance $17 r0 *1 5.5,1.165 nmos_5p0
M$17 1 3 9 1 nmos_5p0 L=0.6U W=0.66U AS=0.1056P AD=0.2904P PS=0.98U PD=2.2U
* device instance $18 r0 *1 13.64,1.005 nmos_5p0
M$18 1 7 8 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $20 r0 *1 7.34,1.165 nmos_5p0
M$20 6 5 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $21 r0 *1 8.46,1.165 nmos_5p0
M$21 6 11 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1716P PS=2.02U PD=1.18U
* device instance $22 r0 *1 9.76,1 nmos_5p0
M$22 7 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $23 r0 *1 10.88,1 nmos_5p0
M$23 10 11 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $24 r0 *1 11.8,1 nmos_5p0
M$24 1 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai221_2
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin B2
* pin C
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai221_2 1 3 4 5 6 8 9 10
* net 1 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 B2
* net 6 C
* net 8 A1
* net 9 ZN
* net 10 A2
* device instance $1 r0 *1 0.92,3.965 pmos_5p0
M$1 9 6 1 1 pmos_5p0 L=0.5U W=2.92U AS=1.17P AD=1.2274P PS=5.06U PD=6.33U
* device instance $2 r0 *1 2.12,3.78 pmos_5p0
M$2 14 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.4758P PS=2.53U PD=2.35U
* device instance $3 r0 *1 3.14,3.78 pmos_5p0
M$3 9 4 14 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $4 r0 *1 4.31,3.78 pmos_5p0
M$4 13 4 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $5 r0 *1 5.38,3.78 pmos_5p0
M$5 1 5 13 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $7 r0 *1 7.78,3.78 pmos_5p0
M$7 12 8 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.52155P PS=2.53U PD=2.4U
* device instance $8 r0 *1 8.85,3.78 pmos_5p0
M$8 1 10 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.97,3.78 pmos_5p0
M$9 11 10 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $10 r0 *1 11.04,3.78 pmos_5p0
M$10 9 8 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $11 r0 *1 0.92,1.005 nmos_5p0
M$11 2 6 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7458P PS=5.36U PD=3.77U
* device instance $12 r0 *1 2.07,1.005 nmos_5p0
M$12 3 5 2 3 nmos_5p0 L=0.6U W=2.64U AS=0.7062P AD=0.6864P PS=3.71U PD=3.68U
* device instance $13 r0 *1 3.19,1.005 nmos_5p0
M$13 2 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 7.73,1.005 nmos_5p0
M$17 9 8 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.726P AD=0.924P PS=3.74U PD=5.36U
* device instance $18 r0 *1 8.85,1.005 nmos_5p0
M$18 7 10 9 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai221_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_2 1 2 3 4 5 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 NWELL,VDD
* net 4 B1
* net 5 ZN
* net 7 A2
* net 8 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 6 3 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.9516P PS=6.89U PD=4.7U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 6 4 3 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 4.95,3.78 pmos_5p0
M$5 5 7 6 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.281P PS=4.7U PD=6.89U
* device instance $6 r0 *1 5.97,3.78 pmos_5p0
M$6 6 8 5 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 12 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 5 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 11 4 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 1 2 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 10 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 5 8 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 9 8 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_2

* cell gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor2_4 1 4 5 6 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 7.27,3.78 pmos_5p0
M$1 4 3 8 8 pmos_5p0 L=0.5U W=7.32U AS=2.4156P AD=2.4156P PS=11.79U PD=11.79U
* device instance $5 r0 *1 0.92,3.112 pmos_5p0
M$5 10 5 2 8 pmos_5p0 L=0.5U W=0.495U AS=0.2178P AD=0.15345P PS=1.87U PD=1.115U
* device instance $6 r0 *1 2.04,3.112 pmos_5p0
M$6 8 6 10 8 pmos_5p0 L=0.5U W=0.495U AS=0.15345P AD=0.479325P PS=1.115U
+ PD=2.58U
* device instance $7 r0 *1 3.29,3.78 pmos_5p0
M$7 9 2 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.479325P AD=0.5673P PS=2.58U PD=2.45U
* device instance $8 r0 *1 4.41,3.78 pmos_5p0
M$8 3 6 9 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.4758P PS=2.45U PD=2.35U
* device instance $9 r0 *1 5.43,3.78 pmos_5p0
M$9 9 5 3 8 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 7.22,1.005 nmos_5p0
M$10 4 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $14 r0 *1 0.92,0.85 nmos_5p0
M$14 2 5 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0936P PS=1.6U PD=0.88U
* device instance $15 r0 *1 2.04,0.85 nmos_5p0
M$15 2 6 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.318P AD=0.0936P PS=2.02U PD=0.88U
* device instance $16 r0 *1 3.34,1.005 nmos_5p0
M$16 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.318P AD=0.3432P PS=2.02U PD=1.84U
* device instance $17 r0 *1 4.46,1.005 nmos_5p0
M$17 7 6 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 5.38,1.005 nmos_5p0
M$18 1 5 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* pin A2
* pin A1
* pin B
* pin ZN
* pin C
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_2 1 2 4 5 6 7 8
* net 1 A2
* net 2 A1
* net 4 B
* net 5 ZN
* net 6 C
* net 7 NWELL,VDD
* net 8 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 5 1 3 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.3359P PS=6.89U PD=5.12U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 3 2 5 7 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.37,3.78 pmos_5p0
M$5 12 4 3 7 pmos_5p0 L=0.5U W=1.83U AS=0.8601P AD=0.2196P PS=2.77U PD=2.07U
* device instance $6 r0 *1 6.11,3.78 pmos_5p0
M$6 7 6 12 7 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.549P PS=2.07U PD=2.43U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 11 6 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.549P AD=0.4392P PS=2.43U PD=2.31U
* device instance $8 r0 *1 8.19,3.78 pmos_5p0
M$8 3 4 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.4392P AD=0.8052P PS=2.31U PD=4.54U
* device instance $9 r0 *1 5.02,0.745 nmos_5p0
M$9 5 4 8 8 nmos_5p0 L=0.6U W=1.58U AS=0.5609P AD=0.553P PS=3.195U PD=3.77U
* device instance $10 r0 *1 6.14,0.745 nmos_5p0
M$10 8 6 5 8 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $13 r0 *1 0.92,0.942 nmos_5p0
M$13 10 1 8 8 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.1422P PS=3.25U PD=1.425U
* device instance $14 r0 *1 1.76,0.942 nmos_5p0
M$14 5 2 10 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 2.88,0.942 nmos_5p0
M$15 9 2 5 8 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 3.72,0.942 nmos_5p0
M$16 8 1 9 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_2

* cell gf180mcu_fd_sc_mcu9t5v0__xor2_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xor2_2 1 2 6 7 8
* net 1 A1
* net 2 PWELL,VSS,gf180mcu_gnd
* net 6 A2
* net 7 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.87,3.947 pmos_5p0
M$1 3 6 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 1.89,3.947 pmos_5p0
M$2 3 1 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.526125P AD=0.2379P PS=2.58U PD=1.435U
* device instance $3 r0 *1 3.14,3.785 pmos_5p0
M$3 5 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.526125P AD=0.61305P PS=2.58U PD=2.5U
* device instance $4 r0 *1 4.31,3.785 pmos_5p0
M$4 10 1 5 7 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $5 r0 *1 5.33,3.785 pmos_5p0
M$5 7 6 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.27,3.78 pmos_5p0
M$6 8 5 7 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 5 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,1.16 nmos_5p0
M$10 9 6 3 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1056P PS=2.2U PD=0.98U
* device instance $11 r0 *1 1.84,1.16 nmos_5p0
M$11 9 1 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1056P PS=2.02U PD=0.98U
* device instance $12 r0 *1 3.14,1.005 nmos_5p0
M$12 4 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.26,1.005 nmos_5p0
M$13 5 1 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 4 6 5 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_2 1 2 3 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 NWELL,VDD
* net 5 A2
* net 6 A3
* device instance $1 r0 *1 0.87,3.85 pmos_5p0
M$1 2 6 4 4 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.022P PS=5.78U PD=5.78U
* device instance $2 r0 *1 1.89,3.85 pmos_5p0
M$2 4 5 2 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.85 pmos_5p0
M$3 2 3 4 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 1.06,1 nmos_5p0
M$7 10 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1848P PS=3.52U PD=1.6U
* device instance $8 r0 *1 1.94,1 nmos_5p0
M$8 9 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1848P AD=0.2112P PS=1.6U PD=1.64U
* device instance $9 r0 *1 2.86,1 nmos_5p0
M$9 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $10 r0 *1 3.98,1 nmos_5p0
M$10 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $11 r0 *1 4.9,1 nmos_5p0
M$11 7 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $12 r0 *1 5.92,1 nmos_5p0
M$12 1 6 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.5808P PS=1.74U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_2
* pin NWELL,VDD
* pin A2
* pin ZN
* pin A1
* pin B
* pin C
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 A2
* net 3 ZN
* net 4 A1
* net 5 B
* net 6 C
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 11 4 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $5 r0 *1 5.43,3.965 pmos_5p0
M$5 3 5 1 1 pmos_5p0 L=0.5U W=2.92U AS=0.9646P AD=1.022P PS=4.51U PD=5.78U
* device instance $6 r0 *1 6.45,3.965 pmos_5p0
M$6 1 6 3 1 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7062P PS=5.36U PD=3.71U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 7 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.43,1.005 nmos_5p0
M$13 9 5 8 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $14 r0 *1 6.4,1.005 nmos_5p0
M$14 7 6 9 7 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $15 r0 *1 7.52,1.005 nmos_5p0
M$15 10 6 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 8.44,1.005 nmos_5p0
M$16 8 5 10 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_2

* cell gf180mcu_fd_sc_mcu9t5v0__or3_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 2 6 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 4 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 3 5 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 9 5 3 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 6 2 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8235P PS=2.4U PD=2.73U
* device instance $7 r0 *1 7.87,3.78 pmos_5p0
M$7 7 3 6 6 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.4156P PS=9.98U PD=11.79U
* device instance $11 r0 *1 0.92,0.87 nmos_5p0
M$11 3 2 1 1 nmos_5p0 L=0.6U W=2.1U AS=0.735P AD=0.6945P PS=4.55U PD=3.59U
* device instance $12 r0 *1 2.04,0.87 nmos_5p0
M$12 1 4 3 1 nmos_5p0 L=0.6U W=2.1U AS=0.546P AD=0.546P PS=3.14U PD=3.14U
* device instance $13 r0 *1 3.16,0.87 nmos_5p0
M$13 3 5 1 1 nmos_5p0 L=0.6U W=2.1U AS=0.546P AD=0.546P PS=3.14U PD=3.14U
* device instance $17 r0 *1 7.82,1.005 nmos_5p0
M$17 7 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4511P AD=1.6104P PS=7.54U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin B1
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_4 1 3 4 5 6 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 B1
* net 5 A2
* net 6 A1
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 8 4 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 11 4 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 7 3 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 10 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 8 4 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 12 4 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 7 3 12 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $9 r0 *1 9.93,3.78 pmos_5p0
M$9 13 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $10 r0 *1 11,3.78 pmos_5p0
M$10 8 6 13 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $11 r0 *1 12.12,3.78 pmos_5p0
M$11 15 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $12 r0 *1 13.24,3.78 pmos_5p0
M$12 7 5 15 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $13 r0 *1 14.36,3.78 pmos_5p0
M$13 14 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $14 r0 *1 15.48,3.78 pmos_5p0
M$14 8 6 14 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $15 r0 *1 16.6,3.78 pmos_5p0
M$15 16 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $16 r0 *1 17.67,3.78 pmos_5p0
M$16 7 5 16 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 1 3 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $18 r0 *1 2.04,1.005 nmos_5p0
M$18 2 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $25 r0 *1 9.88,1.005 nmos_5p0
M$25 8 5 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.9272P PS=7.36U PD=9.52U
* device instance $26 r0 *1 11,1.005 nmos_5p0
M$26 2 6 8 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A3
* pin ZN
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_4 1 2 4 5 11 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A3
* net 5 ZN
* net 11 A2
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.87,3.965 pmos_5p0
M$1 5 11 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.8542P AD=1.5914P PS=9.84U PD=8.02U
* device instance $2 r0 *1 1.89,3.965 pmos_5p0
M$2 12 4 5 12 pmos_5p0 L=0.5U W=5.84U AS=1.6644P AD=1.6644P PS=8.12U PD=8.12U
* device instance $9 r0 *1 9.33,3.965 pmos_5p0
M$9 5 2 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.7374P AD=2.0002P PS=8.22U PD=10.04U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 6 11 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2772P PS=3.52U PD=1.74U
* device instance $14 r0 *1 1.94,1.005 nmos_5p0
M$14 1 4 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $15 r0 *1 3.06,1.005 nmos_5p0
M$15 7 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2772P PS=1.84U PD=1.74U
* device instance $16 r0 *1 4.08,1.005 nmos_5p0
M$16 3 11 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $17 r0 *1 5.2,1.005 nmos_5p0
M$17 9 11 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2772P PS=1.84U PD=1.74U
* device instance $18 r0 *1 6.22,1.005 nmos_5p0
M$18 1 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $19 r0 *1 7.34,1.005 nmos_5p0
M$19 8 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2772P PS=1.84U PD=1.74U
* device instance $20 r0 *1 8.36,1.005 nmos_5p0
M$20 10 11 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $21 r0 *1 9.38,1.005 nmos_5p0
M$21 5 2 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $22 r0 *1 10.5,1.005 nmos_5p0
M$22 3 2 5 1 nmos_5p0 L=0.6U W=3.96U AS=1.0296P AD=1.2672P PS=5.52U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,0.995 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=2.19U AS=0.7008P AD=0.7008P PS=4.84U PD=4.84U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_3

* cell gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor2_2 1 5 6 7 8
* net 1 NWELL,VDD
* net 5 A1
* net 6 A2
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 ZN
* device instance $1 r0 *1 0.97,3.327 pmos_5p0
M$1 10 6 2 1 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.260775P PS=2.71U PD=1.485U
* device instance $2 r0 *1 2.04,3.327 pmos_5p0
M$2 1 5 10 1 pmos_5p0 L=0.5U W=0.915U AS=0.260775P AD=0.571875P PS=1.485U
+ PD=2.68U
* device instance $3 r0 *1 3.39,3.785 pmos_5p0
M$3 4 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.571875P AD=0.4758P PS=2.68U PD=2.35U
* device instance $4 r0 *1 4.41,3.785 pmos_5p0
M$4 3 5 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.4758P PS=2.35U PD=2.35U
* device instance $5 r0 *1 5.43,3.785 pmos_5p0
M$5 4 6 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.17,3.78 pmos_5p0
M$6 8 3 1 1 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 3 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,0.675 nmos_5p0
M$10 2 6 7 7 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $11 r0 *1 2.04,0.675 nmos_5p0
M$11 7 5 2 7 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.363P PS=1.18U PD=2.02U
* device instance $12 r0 *1 3.34,1.005 nmos_5p0
M$12 3 2 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.46,1.005 nmos_5p0
M$13 9 5 3 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 7 6 9 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_4 1 2 3 5 6 7 9
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 3 B
* net 5 ZN
* net 6 A2
* net 7 A1
* net 9 NWELL,VDD
* device instance $1 r0 *1 14.93,3.872 pmos_5p0
M$1 5 3 9 9 pmos_5p0 L=0.5U W=6.58U AS=2.212525P AD=2.212525P PS=10.915U
+ PD=10.915U
* device instance $5 r0 *1 0.97,3.78 pmos_5p0
M$5 9 2 8 9 pmos_5p0 L=0.5U W=5.49U AS=1.89405P AD=1.65615P PS=9.39U PD=7.3U
* device instance $8 r0 *1 4.28,3.78 pmos_5p0
M$8 11 2 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 5.4,3.78 pmos_5p0
M$9 10 6 11 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 6.52,3.78 pmos_5p0
M$10 5 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 7.64,3.78 pmos_5p0
M$11 13 7 5 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.61305P PS=2.45U PD=2.5U
* device instance $12 r0 *1 8.81,3.78 pmos_5p0
M$12 8 6 13 9 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $13 r0 *1 9.88,3.78 pmos_5p0
M$13 12 6 8 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $14 r0 *1 11,3.78 pmos_5p0
M$14 5 7 12 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $15 r0 *1 12.12,3.78 pmos_5p0
M$15 14 7 5 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $16 r0 *1 13.19,3.78 pmos_5p0
M$16 8 6 14 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 5 2 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $21 r0 *1 5.4,1.005 nmos_5p0
M$21 5 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.716P PS=7.36U PD=7.88U
* device instance $22 r0 *1 6.52,1.005 nmos_5p0
M$22 4 7 5 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $29 r0 *1 14.88,1.005 nmos_5p0
M$29 1 3 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.716P AD=1.6104P PS=7.88U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_4

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 11 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 10 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 9 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A2
* pin A1
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A2
* net 4 A1
* net 5 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.61305P PS=4.54U PD=2.5U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 5 4 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 3 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 5 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 6 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 2 3 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $9 r0 *1 0.92,1.04 nmos_5p0
M$9 5 3 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1224P AD=1.1224P PS=7.04U PD=7.04U
* device instance $10 r0 *1 2.04,1.04 nmos_5p0
M$10 1 4 5 1 nmos_5p0 L=0.6U W=3.68U AS=0.9568P AD=0.9568P PS=5.76U PD=5.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_4 1 3 4 5 6 7 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 ZN
* net 4 A2
* net 5 A1
* net 6 B
* net 7 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 13 4 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 3 5 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 14 5 3 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 12 4 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 15 4 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 3 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 16 5 3 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 12 4 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $9 r0 *1 9.91,3.965 pmos_5p0
M$9 3 6 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.7238P AD=1.7812P PS=8.47U PD=9.74U
* device instance $10 r0 *1 10.93,3.965 pmos_5p0
M$10 12 7 3 12 pmos_5p0 L=0.5U W=5.84U AS=1.5184P AD=1.5184P PS=7.92U PD=7.92U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 3 4 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3926P PS=9.04U PD=7.39U
* device instance $18 r0 *1 2.04,1.005 nmos_5p0
M$18 2 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $25 r0 *1 9.91,1.005 nmos_5p0
M$25 10 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $26 r0 *1 10.88,1.005 nmos_5p0
M$26 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $27 r0 *1 12,1.005 nmos_5p0
M$27 11 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.92,1.005 nmos_5p0
M$28 2 6 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 14.04,1.005 nmos_5p0
M$29 9 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.96,1.005 nmos_5p0
M$30 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 16.08,1.005 nmos_5p0
M$31 8 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 17,1.005 nmos_5p0
M$32 2 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_4

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin ZN
* pin A2
* pin B1
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_4 1 2 3 4 13 14 16
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 ZN
* net 4 A2
* net 13 B1
* net 14 A1
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 16 2 15 16 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1228P PS=11.59U PD=9.64U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 15 13 16 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.27,3.78 pmos_5p0
M$9 3 4 15 16 pmos_5p0 L=0.5U W=7.32U AS=2.1228P AD=2.2326P PS=9.64U PD=11.59U
* device instance $10 r0 *1 10.29,3.78 pmos_5p0
M$10 15 14 3 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 5 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $18 r0 *1 1.84,1.005 nmos_5p0
M$18 3 13 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $19 r0 *1 2.96,1.005 nmos_5p0
M$19 7 13 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 3.88,1.005 nmos_5p0
M$20 1 2 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $21 r0 *1 5,1.005 nmos_5p0
M$21 6 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 5.92,1.005 nmos_5p0
M$22 3 13 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 7.04,1.005 nmos_5p0
M$23 9 13 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $24 r0 *1 7.96,1.005 nmos_5p0
M$24 1 2 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5016P PS=1.64U PD=2.08U
* device instance $25 r0 *1 9.32,1.005 nmos_5p0
M$25 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5016P AD=0.2112P PS=2.08U PD=1.64U
* device instance $26 r0 *1 10.24,1.005 nmos_5p0
M$26 3 14 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $27 r0 *1 11.36,1.005 nmos_5p0
M$27 11 14 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.28,1.005 nmos_5p0
M$28 1 4 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 13.4,1.005 nmos_5p0
M$29 10 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.32,1.005 nmos_5p0
M$30 3 14 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 15.44,1.005 nmos_5p0
M$31 8 14 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 16.36,1.005 nmos_5p0
M$32 1 4 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_4

* cell gf180mcu_fd_sc_mcu9t5v0__and3_4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_4 1 2 3 4 5 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS,gf180mcu_gnd
* net 5 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.87,3.595 pmos_5p0
M$1 6 1 5 5 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.0012P PS=5.78U PD=4.55U
* device instance $2 r0 *1 1.89,3.595 pmos_5p0
M$2 5 2 6 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.595 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 7 6 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.049P AD=2.2326P PS=9.62U PD=11.59U
* device instance $11 r0 *1 1,1.005 nmos_5p0
M$11 11 1 4 4 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $12 r0 *1 1.84,1.005 nmos_5p0
M$12 10 2 11 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.2772P PS=1.56U PD=1.74U
* device instance $13 r0 *1 2.86,1.005 nmos_5p0
M$13 6 3 10 4 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $14 r0 *1 3.98,1.005 nmos_5p0
M$14 9 3 6 4 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $15 r0 *1 4.9,1.005 nmos_5p0
M$15 8 2 9 4 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.1584P PS=1.64U PD=1.56U
* device instance $16 r0 *1 5.74,1.005 nmos_5p0
M$16 4 1 8 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 6.86,1.005 nmos_5p0
M$17 7 6 4 4 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A3
* pin A4
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor4_4 1 2 3 4 5 6 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 1.285,3.78 pmos_5p0
M$1 9 4 7 8 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.355,3.78 pmos_5p0
M$2 8 5 9 8 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.475,3.78 pmos_5p0
M$3 10 5 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.775,3.78 pmos_5p0
M$4 7 4 10 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $5 r0 *1 6.075,3.78 pmos_5p0
M$5 11 4 7 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.5673P PS=2.63U PD=2.45U
* device instance $6 r0 *1 7.195,3.78 pmos_5p0
M$6 8 5 11 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 8.315,3.78 pmos_5p0
M$7 14 5 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $8 r0 *1 9.615,3.78 pmos_5p0
M$8 13 4 14 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $9 r0 *1 10.915,3.78 pmos_5p0
M$9 12 3 13 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $10 r0 *1 12.215,3.78 pmos_5p0
M$10 2 6 12 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $11 r0 *1 13.515,3.78 pmos_5p0
M$11 15 6 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $12 r0 *1 14.815,3.78 pmos_5p0
M$12 7 3 15 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $13 r0 *1 16.115,3.78 pmos_5p0
M$13 16 3 7 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $14 r0 *1 17.415,3.78 pmos_5p0
M$14 2 6 16 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $15 r0 *1 18.715,3.78 pmos_5p0
M$15 17 6 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.68625P PS=2.63U PD=2.58U
* device instance $16 r0 *1 19.965,3.78 pmos_5p0
M$16 7 3 17 8 pmos_5p0 L=0.5U W=1.83U AS=0.68625P AD=0.8052P PS=2.58U PD=4.54U
* device instance $17 r0 *1 4.775,0.695 nmos_5p0
M$17 1 4 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.98415P AD=0.8057P PS=6.295U PD=5.09U
* device instance $19 r0 *1 12.215,0.695 nmos_5p0
M$19 1 6 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.925P AD=0.925P PS=5.46U PD=5.46U
* device instance $20 r0 *1 14.815,0.695 nmos_5p0
M$20 1 3 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.925P AD=0.98415P PS=5.46U PD=6.295U
* device instance $24 r0 *1 2.355,0.7 nmos_5p0
M$24 1 5 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.8057P AD=0.6864P PS=5.09U PD=4.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor4_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 4 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 10 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 7 5 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 9 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 4 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 11 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 7 5 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6292P PS=2.4U PD=2.55U
* device instance $9 r0 *1 9.93,3.872 pmos_5p0
M$9 4 2 7 7 pmos_5p0 L=0.5U W=6.58U AS=2.117925P AD=2.212525P PS=9.295U
+ PD=10.915U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 4 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 2.04,1.005 nmos_5p0
M$14 3 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $21 r0 *1 9.88,1.005 nmos_5p0
M$21 1 2 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin A2
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_4 1 2 3 4 5 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 A2
* net 5 B
* net 11 NWELL,VDD
* device instance $1 r0 *1 1.07,3.785 pmos_5p0
M$1 2 4 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1594P PS=11.59U PD=9.68U
* device instance $2 r0 *1 2.09,3.785 pmos_5p0
M$2 10 3 2 11 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.51,3.785 pmos_5p0
M$9 11 5 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $13 r0 *1 1.14,1 nmos_5p0
M$13 7 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $14 r0 *1 1.98,1 nmos_5p0
M$14 2 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $15 r0 *1 3.1,1 nmos_5p0
M$15 6 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $16 r0 *1 3.94,1 nmos_5p0
M$16 1 4 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 5.06,1 nmos_5p0
M$17 8 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $18 r0 *1 5.9,1 nmos_5p0
M$18 2 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $19 r0 *1 7.02,1 nmos_5p0
M$19 9 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $20 r0 *1 7.86,1 nmos_5p0
M$20 1 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.402P PS=1.56U PD=2.02U
* device instance $21 r0 *1 9.16,1.2 nmos_5p0
M$21 2 5 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1196P AD=1.1224P PS=6.34U PD=7.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_4

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.2993P PS=6.99U PD=5.08U
* device instance $3 r0 *1 3.29,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.5071P PS=9.98U PD=11.89U
* device instance $7 r0 *1 0.92,1.23 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.4593P PS=3.59U PD=2.75U
* device instance $9 r0 *1 3.34,1.265 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=3.2U AS=0.8935P AD=0.976P PS=5.46U PD=6.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_4
* pin NWELL,VDD
* pin A2
* pin A1
* pin Z
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_4 1 2 3 5 6
* net 1 NWELL,VDD
* net 2 A2
* net 3 A1
* net 5 Z
* net 6 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.875 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.28U AS=1.3336P AD=0.8528P PS=6.69U PD=4.32U
* device instance $2 r0 *1 1.89,3.875 pmos_5p0
M$2 1 3 4 1 pmos_5p0 L=0.5U W=3.28U AS=0.8528P AD=0.8528P PS=4.32U PD=4.32U
* device instance $5 r0 *1 5.13,3.78 pmos_5p0
M$5 5 4 1 1 pmos_5p0 L=0.5U W=7.32U AS=2.0394P AD=2.2326P PS=9.58U PD=11.59U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 8 2 6 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 3 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 7 3 4 6 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 6 2 7 6 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 5 4 6 6 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
