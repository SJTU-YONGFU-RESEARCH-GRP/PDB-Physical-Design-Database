* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT performance_counter all_counts[0] all_counts[100]
+ all_counts[101] all_counts[102] all_counts[103] all_counts[104]
+ all_counts[105] all_counts[106] all_counts[107] all_counts[108]
+ all_counts[109] all_counts[10] all_counts[110] all_counts[111]
+ all_counts[112] all_counts[113] all_counts[114] all_counts[115]
+ all_counts[116] all_counts[117] all_counts[118] all_counts[119]
+ all_counts[11] all_counts[120] all_counts[121] all_counts[122]
+ all_counts[123] all_counts[124] all_counts[125] all_counts[126]
+ all_counts[127] all_counts[128] all_counts[129] all_counts[12]
+ all_counts[130] all_counts[131] all_counts[132] all_counts[133]
+ all_counts[134] all_counts[135] all_counts[136] all_counts[137]
+ all_counts[138] all_counts[139] all_counts[13] all_counts[140]
+ all_counts[141] all_counts[142] all_counts[143] all_counts[144]
+ all_counts[145] all_counts[146] all_counts[147] all_counts[148]
+ all_counts[149] all_counts[14] all_counts[150] all_counts[151]
+ all_counts[152] all_counts[153] all_counts[154] all_counts[155]
+ all_counts[156] all_counts[157] all_counts[158] all_counts[159]
+ all_counts[15] all_counts[160] all_counts[161] all_counts[162]
+ all_counts[163] all_counts[164] all_counts[165] all_counts[166]
+ all_counts[167] all_counts[168] all_counts[169] all_counts[16]
+ all_counts[170] all_counts[171] all_counts[172] all_counts[173]
+ all_counts[174] all_counts[175] all_counts[176] all_counts[177]
+ all_counts[178] all_counts[179] all_counts[17] all_counts[180]
+ all_counts[181] all_counts[182] all_counts[183] all_counts[184]
+ all_counts[185] all_counts[186] all_counts[187] all_counts[188]
+ all_counts[189] all_counts[18] all_counts[190] all_counts[191]
+ all_counts[192] all_counts[193] all_counts[194] all_counts[195]
+ all_counts[196] all_counts[197] all_counts[198] all_counts[199]
+ all_counts[19] all_counts[1] all_counts[200] all_counts[201]
+ all_counts[202] all_counts[203] all_counts[204] all_counts[205]
+ all_counts[206] all_counts[207] all_counts[208] all_counts[209]
+ all_counts[20] all_counts[210] all_counts[211] all_counts[212]
+ all_counts[213] all_counts[214] all_counts[215] all_counts[216]
+ all_counts[217] all_counts[218] all_counts[219] all_counts[21]
+ all_counts[220] all_counts[221] all_counts[222] all_counts[223]
+ all_counts[224] all_counts[225] all_counts[226] all_counts[227]
+ all_counts[228] all_counts[229] all_counts[22] all_counts[230]
+ all_counts[231] all_counts[232] all_counts[233] all_counts[234]
+ all_counts[235] all_counts[236] all_counts[237] all_counts[238]
+ all_counts[239] all_counts[23] all_counts[240] all_counts[241]
+ all_counts[242] all_counts[243] all_counts[244] all_counts[245]
+ all_counts[246] all_counts[247] all_counts[248] all_counts[249]
+ all_counts[24] all_counts[250] all_counts[251] all_counts[252]
+ all_counts[253] all_counts[254] all_counts[255] all_counts[25]
+ all_counts[26] all_counts[27] all_counts[28] all_counts[29]
+ all_counts[2] all_counts[30] all_counts[31] all_counts[32]
+ all_counts[33] all_counts[34] all_counts[35] all_counts[36]
+ all_counts[37] all_counts[38] all_counts[39] all_counts[3]
+ all_counts[40] all_counts[41] all_counts[42] all_counts[43]
+ all_counts[44] all_counts[45] all_counts[46] all_counts[47]
+ all_counts[48] all_counts[49] all_counts[4] all_counts[50]
+ all_counts[51] all_counts[52] all_counts[53] all_counts[54]
+ all_counts[55] all_counts[56] all_counts[57] all_counts[58]
+ all_counts[59] all_counts[5] all_counts[60] all_counts[61]
+ all_counts[62] all_counts[63] all_counts[64] all_counts[65]
+ all_counts[66] all_counts[67] all_counts[68] all_counts[69]
+ all_counts[6] all_counts[70] all_counts[71] all_counts[72]
+ all_counts[73] all_counts[74] all_counts[75] all_counts[76]
+ all_counts[77] all_counts[78] all_counts[79] all_counts[7]
+ all_counts[80] all_counts[81] all_counts[82] all_counts[83]
+ all_counts[84] all_counts[85] all_counts[86] all_counts[87]
+ all_counts[88] all_counts[89] all_counts[8] all_counts[90]
+ all_counts[91] all_counts[92] all_counts[93] all_counts[94]
+ all_counts[95] all_counts[96] all_counts[97] all_counts[98]
+ all_counts[99] all_counts[9] clear clk count_value[0] count_value[10]
+ count_value[11] count_value[12] count_value[13] count_value[14]
+ count_value[15] count_value[16] count_value[17] count_value[18]
+ count_value[19] count_value[1] count_value[20] count_value[21]
+ count_value[22] count_value[23] count_value[24] count_value[25]
+ count_value[26] count_value[27] count_value[28] count_value[29]
+ count_value[2] count_value[30] count_value[31] count_value[3]
+ count_value[4] count_value[5] count_value[6] count_value[7]
+ count_value[8] count_value[9] counter_sel[0] counter_sel[1]
+ counter_sel[2] counter_sel[3] counter_sel[4] counter_sel[5]
+ counter_sel[6] counter_sel[7] enable event_inc[0] event_inc[1]
+ event_inc[2] event_inc[3] event_inc[4] event_inc[5] event_inc[6]
+ event_inc[7] rst_n
X_1554_ clear VSS VSS VDD VDD _1215_ sky130_fd_sc_hd__clkbuf_2
X_1555_ _1215_ VSS VSS VDD VDD _1216_ sky130_fd_sc_hd__buf_6
X_1556_ _1216_ VSS VSS VDD VDD _1217_ sky130_fd_sc_hd__buf_4
X_1557_ _1217_ VSS VSS VDD VDD _1218_ sky130_fd_sc_hd__clkbuf_4
X_1558_ net4 VSS VSS VDD VDD _1219_ sky130_fd_sc_hd__buf_4
X_1559_ _1219_ VSS VSS VDD VDD _1220_ sky130_fd_sc_hd__clkbuf_8
X_1560_ prev_event_inc\[0\] net5 _1220_ VSS VSS VDD VDD _1221_
+ sky130_fd_sc_hd__and3b_1
X_1561_ net14 _1221_ VSS VSS VDD VDD _1222_ sky130_fd_sc_hd__xnor2_1
X_1562_ _1218_ _1222_ VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__nor2_1
X_1563_ prev_event_inc\[3\] net267 _1219_ net8 VSS VSS VDD
+ VDD _1223_ sky130_fd_sc_hd__and4b_2
X_1564_ net268 _1550_ VSS VSS VDD VDD _1224_ sky130_fd_sc_hd__and2_0
X_1565_ _1224_ VSS VSS VDD VDD _1225_ sky130_fd_sc_hd__clkbuf_2
X_1566_ _1223_ _1225_ VSS VSS VDD VDD _1226_ sky130_fd_sc_hd__nand2_2
X_1567_ net15 _1226_ VSS VSS VDD VDD _1227_ sky130_fd_sc_hd__xor2_1
X_1568_ _1218_ _1227_ VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__nor2_1
X_1569_ _1223_ VSS VSS VDD VDD _1228_ sky130_fd_sc_hd__buf_2
X_1570_ net265 net266 net268 VSS VSS VDD VDD _1229_ sky130_fd_sc_hd__and3_1
X_1571_ _1229_ VSS VSS VDD VDD _1230_ sky130_fd_sc_hd__clkbuf_2
X_1572_ net15 _1228_ _1230_ VSS VSS VDD VDD _1231_ sky130_fd_sc_hd__nand3_1
X_1573_ net16 _1231_ VSS VSS VDD VDD _1232_ sky130_fd_sc_hd__xor2_1
X_1574_ _1218_ _1232_ VSS VSS VDD VDD _0002_ sky130_fd_sc_hd__nor2_1
X_1575_ net15 net16 _1228_ _1225_ VSS VSS VDD VDD _1233_ sky130_fd_sc_hd__nand4_1
X_1576_ net17 _1233_ VSS VSS VDD VDD _1234_ sky130_fd_sc_hd__xor2_1
X_1577_ _1218_ _1234_ VSS VSS VDD VDD _0003_ sky130_fd_sc_hd__nor2_1
X_1578_ net15 net16 net17 VSS VSS VDD VDD _1235_ sky130_fd_sc_hd__and3_1
X_1579_ _1235_ VSS VSS VDD VDD _1236_ sky130_fd_sc_hd__dlymetal6s2s_1
X_1580_ _1228_ _1230_ _1236_ VSS VSS VDD VDD _1237_ sky130_fd_sc_hd__nand3_1
X_1581_ net18 _1237_ VSS VSS VDD VDD _1238_ sky130_fd_sc_hd__xor2_1
X_1582_ _1218_ _1238_ VSS VSS VDD VDD _0004_ sky130_fd_sc_hd__nor2_1
X_1583_ net18 _1228_ _1225_ _1236_ VSS VSS VDD VDD _1239_
+ sky130_fd_sc_hd__nand4_1
X_1584_ net19 _1239_ VSS VSS VDD VDD _1240_ sky130_fd_sc_hd__xor2_1
X_1585_ _1218_ _1240_ VSS VSS VDD VDD _0005_ sky130_fd_sc_hd__nor2_1
X_1586_ net18 net19 VSS VSS VDD VDD _1241_ sky130_fd_sc_hd__and2_0
X_1587_ _1228_ _1230_ _1236_ _1241_ VSS VSS VDD VDD _1242_
+ sky130_fd_sc_hd__and4_1
X_1588_ net20 _1242_ VSS VSS VDD VDD _1243_ sky130_fd_sc_hd__xnor2_1
X_1589_ _1218_ _1243_ VSS VSS VDD VDD _0006_ sky130_fd_sc_hd__nor2_1
X_1590_ net18 net19 net20 VSS VSS VDD VDD _1244_ sky130_fd_sc_hd__and3_1
X_1591_ _1228_ _1225_ _1236_ _1244_ VSS VSS VDD VDD _1245_
+ sky130_fd_sc_hd__nand4_1
X_1592_ net21 _1245_ VSS VSS VDD VDD _1246_ sky130_fd_sc_hd__xor2_1
X_1593_ _1218_ _1246_ VSS VSS VDD VDD _0007_ sky130_fd_sc_hd__nor2_1
X_1594_ net18 net19 net20 net21 VSS VSS VDD VDD _1247_ sky130_fd_sc_hd__and4_2
X_1595_ _1228_ _1230_ _1236_ _1247_ VSS VSS VDD VDD _1248_
+ sky130_fd_sc_hd__nand4_1
X_1596_ net22 _1248_ VSS VSS VDD VDD _1249_ sky130_fd_sc_hd__xor2_1
X_1597_ _1218_ _1249_ VSS VSS VDD VDD _0008_ sky130_fd_sc_hd__nor2_1
X_1598_ _1228_ _1225_ _1236_ VSS VSS VDD VDD _1250_ sky130_fd_sc_hd__nand3_1
X_1599_ net22 _1247_ VSS VSS VDD VDD _1251_ sky130_fd_sc_hd__nand2_1
X_1600_ _1250_ _1251_ net23 VSS VSS VDD VDD _1252_ sky130_fd_sc_hd__o21ai_0
X_1601_ net23 _1250_ _1251_ VSS VSS VDD VDD _1253_ sky130_fd_sc_hd__or3_1
X_1602_ _1215_ VSS VSS VDD VDD _1254_ sky130_fd_sc_hd__buf_4
X_1603_ _1254_ VSS VSS VDD VDD _1255_ sky130_fd_sc_hd__clkbuf_4
X_1604_ _1252_ _1253_ _1255_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__a21oi_1
X_1605_ net22 net23 VSS VSS VDD VDD _1256_ sky130_fd_sc_hd__and2_1
X_1606_ _1247_ _1256_ VSS VSS VDD VDD _1257_ sky130_fd_sc_hd__nand2_2
X_1607_ _1237_ _1257_ net24 VSS VSS VDD VDD _1258_ sky130_fd_sc_hd__o21ai_0
X_1608_ net24 _1237_ _1257_ VSS VSS VDD VDD _1259_ sky130_fd_sc_hd__or3_1
X_1609_ _1258_ _1259_ _1255_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__a21oi_1
X_1610_ net269 VSS VSS VDD VDD _1260_ sky130_fd_sc_hd__inv_1
X_1611_ _1540_ VSS VSS VDD VDD _1261_ sky130_fd_sc_hd__inv_1
X_1612_ prev_event_inc\[0\] net192 net4 net5 VSS VSS VDD VDD
+ _1262_ sky130_fd_sc_hd__nand4b_2
X_1613_ net203 net214 net225 net236 VSS VSS VDD VDD _1263_
+ sky130_fd_sc_hd__nand4_2
X_1614_ net247 net258 VSS VSS VDD VDD _1264_ sky130_fd_sc_hd__nand2_1
X_1615_ _1261_ _1262_ _1263_ _1264_ VSS VSS VDD VDD _1265_
+ sky130_fd_sc_hd__or4_1
X_1616_ _1265_ VSS VSS VDD VDD _1266_ sky130_fd_sc_hd__clkbuf_4
X_1617_ _1260_ _1266_ net25 VSS VSS VDD VDD _1267_ sky130_fd_sc_hd__o21ai_0
X_1618_ _1260_ net25 _1266_ VSS VSS VDD VDD _1268_ sky130_fd_sc_hd__or3_1
X_1619_ _1267_ _1268_ _1255_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__a21oi_1
X_1620_ net24 VSS VSS VDD VDD _1269_ sky130_fd_sc_hd__inv_1
X_1621_ _1269_ _1250_ _1257_ net26 VSS VSS VDD VDD _1270_
+ sky130_fd_sc_hd__o31ai_1
X_1622_ _1269_ net26 _1250_ _1257_ VSS VSS VDD VDD _1271_
+ sky130_fd_sc_hd__or4_1
X_1623_ _1270_ _1271_ _1255_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__a21oi_1
X_1624_ _1228_ _1230_ VSS VSS VDD VDD _1272_ sky130_fd_sc_hd__nand2_1
X_1625_ net15 net16 net17 net26 VSS VSS VDD VDD _1273_ sky130_fd_sc_hd__and4_2
X_1626_ net24 _1247_ _1256_ _1273_ VSS VSS VDD VDD _1274_
+ sky130_fd_sc_hd__nand4_4
X_1627_ _1272_ _1274_ net27 VSS VSS VDD VDD _1275_ sky130_fd_sc_hd__o21ai_0
X_1628_ net27 _1272_ _1274_ VSS VSS VDD VDD _1276_ sky130_fd_sc_hd__or3_1
X_1629_ _1275_ _1276_ _1255_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__a21oi_1
X_1630_ net27 VSS VSS VDD VDD _1277_ sky130_fd_sc_hd__inv_1
X_1631_ net24 _1223_ _1225_ _1273_ VSS VSS VDD VDD _1278_
+ sky130_fd_sc_hd__nand4_2
X_1632_ _1278_ VSS VSS VDD VDD _1279_ sky130_fd_sc_hd__buf_2
X_1633_ _1277_ _1257_ _1279_ net28 VSS VSS VDD VDD _1280_
+ sky130_fd_sc_hd__o31ai_1
X_1634_ _1277_ net28 _1257_ _1279_ VSS VSS VDD VDD _1281_
+ sky130_fd_sc_hd__or4_1
X_1635_ _1280_ _1281_ _1255_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__a21oi_1
X_1636_ net24 _1223_ _1230_ _1273_ VSS VSS VDD VDD _1282_
+ sky130_fd_sc_hd__nand4_4
X_1637_ _1282_ VSS VSS VDD VDD _1283_ sky130_fd_sc_hd__buf_2
X_1638_ net27 net28 VSS VSS VDD VDD _1284_ sky130_fd_sc_hd__nand2_1
X_1639_ _1257_ _1283_ _1284_ net29 VSS VSS VDD VDD _1285_
+ sky130_fd_sc_hd__o31ai_1
X_1640_ net29 _1257_ _1283_ _1284_ VSS VSS VDD VDD _1286_
+ sky130_fd_sc_hd__or4_1
X_1641_ _1216_ VSS VSS VDD VDD _1287_ sky130_fd_sc_hd__clkbuf_4
X_1642_ _1287_ VSS VSS VDD VDD _1288_ sky130_fd_sc_hd__buf_4
X_1643_ _1285_ _1286_ _1288_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__a21oi_1
X_1644_ net27 net28 net29 VSS VSS VDD VDD _1289_ sky130_fd_sc_hd__nand3_1
X_1645_ _1226_ _1274_ _1289_ net30 VSS VSS VDD VDD _1290_
+ sky130_fd_sc_hd__o31ai_1
X_1646_ net30 _1226_ _1274_ _1289_ VSS VSS VDD VDD _1291_
+ sky130_fd_sc_hd__or4_1
X_1647_ _1290_ _1291_ _1288_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__a21oi_1
X_1648_ net27 net28 net29 net30 VSS VSS VDD VDD _1292_ sky130_fd_sc_hd__nand4_1
X_1649_ _1272_ _1274_ _1292_ net31 VSS VSS VDD VDD _1293_
+ sky130_fd_sc_hd__o31ai_1
X_1650_ net31 _1272_ _1274_ _1292_ VSS VSS VDD VDD _1294_
+ sky130_fd_sc_hd__or4_1
X_1651_ _1293_ _1294_ _1288_ VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__a21oi_1
X_1652_ net27 net28 net29 net30 VSS VSS VDD VDD _1295_ sky130_fd_sc_hd__and4_1
X_1653_ net31 _1295_ VSS VSS VDD VDD _1296_ sky130_fd_sc_hd__nand2_1
X_1654_ _1226_ _1274_ _1296_ net32 VSS VSS VDD VDD _1297_
+ sky130_fd_sc_hd__o31ai_1
X_1655_ net32 _1226_ _1274_ _1296_ VSS VSS VDD VDD _1298_
+ sky130_fd_sc_hd__or4_1
X_1656_ _1297_ _1298_ _1288_ VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__a21oi_1
X_1657_ net31 net32 VSS VSS VDD VDD _1299_ sky130_fd_sc_hd__and2_0
X_1658_ _1247_ _1256_ _1295_ _1299_ VSS VSS VDD VDD _1300_
+ sky130_fd_sc_hd__nand4_2
X_1659_ _1300_ VSS VSS VDD VDD _1301_ sky130_fd_sc_hd__clkbuf_2
X_1660_ _1301_ VSS VSS VDD VDD _1302_ sky130_fd_sc_hd__buf_2
X_1661_ _1283_ _1302_ net33 VSS VSS VDD VDD _1303_ sky130_fd_sc_hd__o21ai_0
X_1662_ net33 _1283_ _1301_ VSS VSS VDD VDD _1304_ sky130_fd_sc_hd__or3_1
X_1663_ _1303_ _1304_ _1288_ VSS VSS VDD VDD _0019_ sky130_fd_sc_hd__a21oi_1
X_1664_ net33 VSS VSS VDD VDD _1305_ sky130_fd_sc_hd__inv_1
X_1665_ _1305_ _1279_ _1302_ net34 VSS VSS VDD VDD _1306_
+ sky130_fd_sc_hd__o31ai_1
X_1666_ _1305_ net34 _1279_ _1301_ VSS VSS VDD VDD _1307_
+ sky130_fd_sc_hd__or4_1
X_1667_ _1306_ _1307_ _1288_ VSS VSS VDD VDD _0020_ sky130_fd_sc_hd__a21oi_1
X_1668_ net33 net34 VSS VSS VDD VDD _1308_ sky130_fd_sc_hd__nand2_1
X_1669_ _1283_ _1302_ _1308_ net35 VSS VSS VDD VDD _1309_
+ sky130_fd_sc_hd__o31ai_1
X_1670_ net35 _1283_ _1301_ _1308_ VSS VSS VDD VDD _1310_
+ sky130_fd_sc_hd__or4_1
X_1671_ _1309_ _1310_ _1288_ VSS VSS VDD VDD _0021_ sky130_fd_sc_hd__a21oi_1
X_1672_ net203 net214 net225 net236 VSS VSS VDD VDD _1311_
+ sky130_fd_sc_hd__and4_1
X_1673_ net247 net258 _1311_ VSS VSS VDD VDD _1312_ sky130_fd_sc_hd__nand3_1
X_1674_ net269 net25 VSS VSS VDD VDD _1313_ sky130_fd_sc_hd__nand2_1
X_1675_ prev_event_inc\[0\] net192 _1219_ net5 VSS VSS VDD
+ VDD _1314_ sky130_fd_sc_hd__and4b_1
X_1676_ net14 net125 _1314_ VSS VSS VDD VDD _1315_ sky130_fd_sc_hd__nand3_1
X_1677_ _1312_ _1313_ _1315_ net36 VSS VSS VDD VDD _1316_
+ sky130_fd_sc_hd__o31ai_1
X_1678_ net36 _1312_ _1313_ _1315_ VSS VSS VDD VDD _1317_
+ sky130_fd_sc_hd__or4_1
X_1679_ _1316_ _1317_ _1288_ VSS VSS VDD VDD _0022_ sky130_fd_sc_hd__a21oi_1
X_1680_ net33 net34 net35 VSS VSS VDD VDD _1318_ sky130_fd_sc_hd__nand3_1
X_1681_ _1279_ _1302_ _1318_ net37 VSS VSS VDD VDD _1319_
+ sky130_fd_sc_hd__o31ai_1
X_1682_ net37 _1279_ _1301_ _1318_ VSS VSS VDD VDD _1320_
+ sky130_fd_sc_hd__or4_1
X_1683_ _1319_ _1320_ _1288_ VSS VSS VDD VDD _0023_ sky130_fd_sc_hd__a21oi_1
X_1684_ net33 net34 net35 net37 VSS VSS VDD VDD _1321_ sky130_fd_sc_hd__nand4_1
X_1685_ _1283_ _1302_ _1321_ net38 VSS VSS VDD VDD _1322_
+ sky130_fd_sc_hd__o31ai_1
X_1686_ net38 _1282_ _1301_ _1321_ VSS VSS VDD VDD _1323_
+ sky130_fd_sc_hd__or4_1
X_1687_ _1322_ _1323_ _1288_ VSS VSS VDD VDD _0024_ sky130_fd_sc_hd__a21oi_1
X_1688_ net33 net34 net35 net37 VSS VSS VDD VDD _1324_ sky130_fd_sc_hd__and4_1
X_1689_ _1324_ VSS VSS VDD VDD _1325_ sky130_fd_sc_hd__dlymetal6s2s_1
X_1690_ net38 _1325_ VSS VSS VDD VDD _1326_ sky130_fd_sc_hd__nand2_1
X_1691_ _1279_ _1302_ _1326_ net39 VSS VSS VDD VDD _1327_
+ sky130_fd_sc_hd__o31ai_1
X_1692_ net39 _1279_ _1301_ _1326_ VSS VSS VDD VDD _1328_
+ sky130_fd_sc_hd__or4_1
X_1693_ _1287_ VSS VSS VDD VDD _1329_ sky130_fd_sc_hd__clkbuf_4
X_1694_ _1327_ _1328_ _1329_ VSS VSS VDD VDD _0025_ sky130_fd_sc_hd__a21oi_1
X_1695_ net38 net39 _1325_ VSS VSS VDD VDD _1330_ sky130_fd_sc_hd__nand3_1
X_1696_ _1283_ _1302_ _1330_ net40 VSS VSS VDD VDD _1331_
+ sky130_fd_sc_hd__o31ai_1
X_1697_ net40 _1282_ _1301_ _1330_ VSS VSS VDD VDD _1332_
+ sky130_fd_sc_hd__or4_1
X_1698_ _1331_ _1332_ _1329_ VSS VSS VDD VDD _0026_ sky130_fd_sc_hd__a21oi_1
X_1699_ net38 net39 net40 _1325_ VSS VSS VDD VDD _1333_ sky130_fd_sc_hd__nand4_1
X_1700_ _1279_ _1302_ _1333_ net41 VSS VSS VDD VDD _1334_
+ sky130_fd_sc_hd__o31ai_1
X_1701_ net41 _1278_ _1301_ _1333_ VSS VSS VDD VDD _1335_
+ sky130_fd_sc_hd__or4_1
X_1702_ _1334_ _1335_ _1329_ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__a21oi_1
X_1703_ net38 net39 net40 net41 VSS VSS VDD VDD _1336_ sky130_fd_sc_hd__and4_1
X_1704_ _1325_ _1336_ VSS VSS VDD VDD _1337_ sky130_fd_sc_hd__nand2_1
X_1705_ _1283_ _1302_ _1337_ net42 VSS VSS VDD VDD _1338_
+ sky130_fd_sc_hd__o31ai_1
X_1706_ net42 _1282_ _1300_ _1337_ VSS VSS VDD VDD _1339_
+ sky130_fd_sc_hd__or4_1
X_1707_ _1338_ _1339_ _1329_ VSS VSS VDD VDD _0028_ sky130_fd_sc_hd__a21oi_1
X_1708_ net42 _1325_ _1336_ VSS VSS VDD VDD _1340_ sky130_fd_sc_hd__nand3_1
X_1709_ _1279_ _1302_ _1340_ net43 VSS VSS VDD VDD _1341_
+ sky130_fd_sc_hd__o31ai_1
X_1710_ net43 _1278_ _1300_ _1340_ VSS VSS VDD VDD _1342_
+ sky130_fd_sc_hd__or4_1
X_1711_ _1341_ _1342_ _1329_ VSS VSS VDD VDD _0029_ sky130_fd_sc_hd__a21oi_1
X_1712_ net42 net43 _1325_ _1336_ VSS VSS VDD VDD _1343_ sky130_fd_sc_hd__nand4_1
X_1713_ _1283_ _1301_ _1343_ net44 VSS VSS VDD VDD _1344_
+ sky130_fd_sc_hd__o31ai_1
X_1714_ net44 _1282_ _1300_ _1343_ VSS VSS VDD VDD _1345_
+ sky130_fd_sc_hd__or4_1
X_1715_ _1344_ _1345_ _1329_ VSS VSS VDD VDD _0030_ sky130_fd_sc_hd__a21oi_1
X_1716_ net45 VSS VSS VDD VDD _1346_ sky130_fd_sc_hd__inv_1
X_1717_ prev_event_inc\[4\] net9 _1220_ VSS VSS VDD VDD _1347_
+ sky130_fd_sc_hd__nand3b_1
X_1718_ _1346_ _1347_ VSS VSS VDD VDD _1348_ sky130_fd_sc_hd__xnor2_1
X_1719_ _1218_ _1348_ VSS VSS VDD VDD _0031_ sky130_fd_sc_hd__nor2_1
X_1720_ _1217_ VSS VSS VDD VDD _1349_ sky130_fd_sc_hd__clkbuf_4
X_1721_ _1549_ net46 _1347_ VSS VSS VDD VDD _1350_ sky130_fd_sc_hd__mux2i_1
X_1722_ _1349_ _1350_ VSS VSS VDD VDD _0032_ sky130_fd_sc_hd__nor2_1
X_1723_ net269 net25 net36 VSS VSS VDD VDD _1351_ sky130_fd_sc_hd__nand3_4
X_1724_ _1351_ VSS VSS VDD VDD _1352_ sky130_fd_sc_hd__clkbuf_4
X_1725_ _1266_ _1352_ net47 VSS VSS VDD VDD _1353_ sky130_fd_sc_hd__o21ai_0
X_1726_ _1265_ VSS VSS VDD VDD _1354_ sky130_fd_sc_hd__clkbuf_4
X_1727_ net47 _1354_ _1352_ VSS VSS VDD VDD _1355_ sky130_fd_sc_hd__or3_1
X_1728_ _1353_ _1355_ _1329_ VSS VSS VDD VDD _0033_ sky130_fd_sc_hd__a21oi_1
X_1729_ net48 VSS VSS VDD VDD _1356_ sky130_fd_sc_hd__inv_1
X_1730_ prev_event_inc\[4\] _1548_ _1220_ net9 VSS VSS VDD
+ VDD _1357_ sky130_fd_sc_hd__nand4b_1
X_1731_ _1356_ _1357_ VSS VSS VDD VDD _1358_ sky130_fd_sc_hd__xnor2_1
X_1732_ _1349_ _1358_ VSS VSS VDD VDD _0034_ sky130_fd_sc_hd__nor2_1
X_1733_ net45 net46 VSS VSS VDD VDD _1359_ sky130_fd_sc_hd__nand2_1
X_1734_ prev_event_inc\[4\] net48 _1220_ net9 VSS VSS VDD
+ VDD _1360_ sky130_fd_sc_hd__nand4b_1
X_1735_ _1359_ _1360_ net49 VSS VSS VDD VDD _1361_ sky130_fd_sc_hd__o21ai_0
X_1736_ net49 VSS VSS VDD VDD _1362_ sky130_fd_sc_hd__inv_1
X_1737_ net45 net46 VSS VSS VDD VDD _1363_ sky130_fd_sc_hd__and2_1
X_1738_ prev_event_inc\[4\] net48 net4 net9 VSS VSS VDD VDD
+ _1364_ sky130_fd_sc_hd__and4b_1
X_1739_ _1364_ VSS VSS VDD VDD _1365_ sky130_fd_sc_hd__clkbuf_4
X_1740_ _1362_ _1363_ _1365_ VSS VSS VDD VDD _1366_ sky130_fd_sc_hd__nand3_1
X_1741_ _1361_ _1366_ _1329_ VSS VSS VDD VDD _0035_ sky130_fd_sc_hd__a21oi_1
X_1742_ net50 VSS VSS VDD VDD _1367_ sky130_fd_sc_hd__inv_1
X_1743_ net49 _1548_ _1365_ VSS VSS VDD VDD _1368_ sky130_fd_sc_hd__nand3_1
X_1744_ _1367_ _1368_ VSS VSS VDD VDD _1369_ sky130_fd_sc_hd__xnor2_1
X_1745_ _1349_ _1369_ VSS VSS VDD VDD _0036_ sky130_fd_sc_hd__nor2_1
X_1746_ net51 VSS VSS VDD VDD _1370_ sky130_fd_sc_hd__inv_1
X_1747_ net49 net50 _1363_ _1365_ VSS VSS VDD VDD _1371_ sky130_fd_sc_hd__nand4_1
X_1748_ _1370_ _1371_ VSS VSS VDD VDD _1372_ sky130_fd_sc_hd__xnor2_1
X_1749_ _1349_ _1372_ VSS VSS VDD VDD _0037_ sky130_fd_sc_hd__nor2_1
X_1750_ net52 VSS VSS VDD VDD _1373_ sky130_fd_sc_hd__inv_1
X_1751_ net49 net50 net51 VSS VSS VDD VDD _1374_ sky130_fd_sc_hd__and3_2
X_1752_ _1548_ _1365_ _1374_ VSS VSS VDD VDD _1375_ sky130_fd_sc_hd__nand3_1
X_1753_ _1373_ _1375_ VSS VSS VDD VDD _1376_ sky130_fd_sc_hd__xnor2_1
X_1754_ _1349_ _1376_ VSS VSS VDD VDD _0038_ sky130_fd_sc_hd__nor2_1
X_1755_ net49 net50 net51 net52 VSS VSS VDD VDD _1377_ sky130_fd_sc_hd__nand4_2
X_1756_ _1359_ _1360_ _1377_ VSS VSS VDD VDD _1378_ sky130_fd_sc_hd__nor3_1
X_1757_ net53 _1378_ VSS VSS VDD VDD _1379_ sky130_fd_sc_hd__xnor2_1
X_1758_ _1349_ _1379_ VSS VSS VDD VDD _0039_ sky130_fd_sc_hd__nor2_1
X_1759_ net54 VSS VSS VDD VDD _1380_ sky130_fd_sc_hd__inv_1
X_1760_ net49 net50 net51 net52 VSS VSS VDD VDD _1381_ sky130_fd_sc_hd__and4_1
X_1761_ net53 _1548_ _1365_ _1381_ VSS VSS VDD VDD _1382_
+ sky130_fd_sc_hd__nand4_1
X_1762_ _1380_ _1382_ VSS VSS VDD VDD _1383_ sky130_fd_sc_hd__xnor2_1
X_1763_ _1349_ _1383_ VSS VSS VDD VDD _0040_ sky130_fd_sc_hd__nor2_1
X_1764_ net53 net54 VSS VSS VDD VDD _1384_ sky130_fd_sc_hd__nand2_1
X_1765_ _1359_ _1360_ _1377_ _1384_ VSS VSS VDD VDD _1385_
+ sky130_fd_sc_hd__nor4_1
X_1766_ net55 _1385_ VSS VSS VDD VDD _1386_ sky130_fd_sc_hd__xnor2_1
X_1767_ _1349_ _1386_ VSS VSS VDD VDD _0041_ sky130_fd_sc_hd__nor2_1
X_1768_ net56 VSS VSS VDD VDD _1387_ sky130_fd_sc_hd__inv_1
X_1769_ net53 net54 net55 VSS VSS VDD VDD _1388_ sky130_fd_sc_hd__and3_1
X_1770_ _1548_ _1365_ _1381_ _1388_ VSS VSS VDD VDD _1389_
+ sky130_fd_sc_hd__nand4_1
X_1771_ _1387_ _1389_ VSS VSS VDD VDD _1390_ sky130_fd_sc_hd__xnor2_1
X_1772_ _1349_ _1390_ VSS VSS VDD VDD _0042_ sky130_fd_sc_hd__nor2_1
X_1773_ net57 VSS VSS VDD VDD _1391_ sky130_fd_sc_hd__inv_1
X_1774_ net53 net54 net55 net56 VSS VSS VDD VDD _1392_ sky130_fd_sc_hd__and4_2
X_1775_ _1363_ _1365_ _1381_ _1392_ VSS VSS VDD VDD _1393_
+ sky130_fd_sc_hd__nand4_4
X_1776_ _1391_ _1393_ VSS VSS VDD VDD _1394_ sky130_fd_sc_hd__xnor2_1
X_1777_ _1349_ _1394_ VSS VSS VDD VDD _0043_ sky130_fd_sc_hd__nor2_1
X_1778_ net47 VSS VSS VDD VDD _1395_ sky130_fd_sc_hd__inv_1
X_1779_ net14 net125 net247 net258 VSS VSS VDD VDD _1396_
+ sky130_fd_sc_hd__nand4_1
X_1780_ _1262_ _1263_ _1351_ _1396_ VSS VSS VDD VDD _1397_
+ sky130_fd_sc_hd__or4_1
X_1781_ _1397_ VSS VSS VDD VDD _1398_ sky130_fd_sc_hd__buf_2
X_1782_ _1398_ VSS VSS VDD VDD _1399_ sky130_fd_sc_hd__buf_2
X_1783_ _1395_ _1399_ net58 VSS VSS VDD VDD _1400_ sky130_fd_sc_hd__o21ai_0
X_1784_ _1395_ net58 _1399_ VSS VSS VDD VDD _1401_ sky130_fd_sc_hd__or3_1
X_1785_ _1400_ _1401_ _1329_ VSS VSS VDD VDD _0044_ sky130_fd_sc_hd__a21oi_1
X_1786_ _1548_ _1365_ VSS VSS VDD VDD _1402_ sky130_fd_sc_hd__nand2_2
X_1787_ net57 _1392_ VSS VSS VDD VDD _1403_ sky130_fd_sc_hd__nand2_1
X_1788_ _1402_ _1377_ _1403_ net59 VSS VSS VDD VDD _1404_
+ sky130_fd_sc_hd__o31ai_1
X_1789_ net59 _1402_ _1377_ _1403_ VSS VSS VDD VDD _1405_
+ sky130_fd_sc_hd__or4_1
X_1790_ _1404_ _1405_ _1329_ VSS VSS VDD VDD _0045_ sky130_fd_sc_hd__a21oi_1
X_1791_ net57 net59 VSS VSS VDD VDD _1406_ sky130_fd_sc_hd__nand2_1
X_1792_ _1393_ _1406_ net60 VSS VSS VDD VDD _1407_ sky130_fd_sc_hd__o21ai_0
X_1793_ net60 _1393_ _1406_ VSS VSS VDD VDD _1408_ sky130_fd_sc_hd__or3_1
X_1794_ _1287_ VSS VSS VDD VDD _1409_ sky130_fd_sc_hd__clkbuf_4
X_1795_ _1407_ _1408_ _1409_ VSS VSS VDD VDD _0046_ sky130_fd_sc_hd__a21oi_1
X_1796_ net52 net57 net59 net60 VSS VSS VDD VDD _1410_ sky130_fd_sc_hd__and4_1
X_1797_ _1374_ _1392_ _1410_ VSS VSS VDD VDD _1411_ sky130_fd_sc_hd__nand3_2
X_1798_ _1402_ _1411_ net61 VSS VSS VDD VDD _1412_ sky130_fd_sc_hd__o21ai_0
X_1799_ net61 _1402_ _1411_ VSS VSS VDD VDD _1413_ sky130_fd_sc_hd__or3_1
X_1800_ _1412_ _1413_ _1409_ VSS VSS VDD VDD _0047_ sky130_fd_sc_hd__a21oi_1
X_1801_ net61 VSS VSS VDD VDD _1414_ sky130_fd_sc_hd__inv_1
X_1802_ net57 net59 net60 VSS VSS VDD VDD _1415_ sky130_fd_sc_hd__and3_1
X_1803_ _1415_ VSS VSS VDD VDD _1416_ sky130_fd_sc_hd__inv_1
X_1804_ _1414_ _1393_ _1416_ net62 VSS VSS VDD VDD _1417_
+ sky130_fd_sc_hd__o31ai_1
X_1805_ _1414_ net62 _1393_ _1416_ VSS VSS VDD VDD _1418_
+ sky130_fd_sc_hd__or4_1
X_1806_ _1417_ _1418_ _1409_ VSS VSS VDD VDD _0048_ sky130_fd_sc_hd__a21oi_1
X_1807_ net61 net62 VSS VSS VDD VDD _1419_ sky130_fd_sc_hd__nand2_1
X_1808_ _1402_ _1411_ _1419_ net63 VSS VSS VDD VDD _1420_
+ sky130_fd_sc_hd__o31ai_1
X_1809_ net63 _1402_ _1411_ _1419_ VSS VSS VDD VDD _1421_
+ sky130_fd_sc_hd__or4_1
X_1810_ _1420_ _1421_ _1409_ VSS VSS VDD VDD _0049_ sky130_fd_sc_hd__a21oi_1
X_1811_ net61 net62 net63 VSS VSS VDD VDD _1422_ sky130_fd_sc_hd__nand3_1
X_1812_ _1393_ _1416_ _1422_ net64 VSS VSS VDD VDD _1423_
+ sky130_fd_sc_hd__o31ai_1
X_1813_ net64 _1393_ _1416_ _1422_ VSS VSS VDD VDD _1424_
+ sky130_fd_sc_hd__or4_1
X_1814_ _1423_ _1424_ _1409_ VSS VSS VDD VDD _0050_ sky130_fd_sc_hd__a21oi_1
X_1815_ net61 net62 net63 net64 VSS VSS VDD VDD _1425_ sky130_fd_sc_hd__nand4_1
X_1816_ _1402_ _1411_ _1425_ net65 VSS VSS VDD VDD _1426_
+ sky130_fd_sc_hd__o31ai_1
X_1817_ net65 _1402_ _1411_ _1425_ VSS VSS VDD VDD _1427_
+ sky130_fd_sc_hd__or4_1
X_1818_ _1426_ _1427_ _1409_ VSS VSS VDD VDD _0051_ sky130_fd_sc_hd__a21oi_1
X_1819_ net61 net62 net63 net64 VSS VSS VDD VDD _1428_ sky130_fd_sc_hd__and4_1
X_1820_ net65 _1415_ _1428_ VSS VSS VDD VDD _1429_ sky130_fd_sc_hd__nand3_1
X_1821_ _1393_ _1429_ net66 VSS VSS VDD VDD _1430_ sky130_fd_sc_hd__o21ai_0
X_1822_ net66 _1393_ _1429_ VSS VSS VDD VDD _1431_ sky130_fd_sc_hd__or3_1
X_1823_ _1430_ _1431_ _1409_ VSS VSS VDD VDD _0052_ sky130_fd_sc_hd__a21oi_1
X_1824_ net65 _1548_ _1365_ _1428_ VSS VSS VDD VDD _1432_
+ sky130_fd_sc_hd__nand4_2
X_1825_ _1432_ VSS VSS VDD VDD _1433_ sky130_fd_sc_hd__clkbuf_2
X_1826_ net66 _1374_ _1392_ _1410_ VSS VSS VDD VDD _1434_
+ sky130_fd_sc_hd__nand4_2
X_1827_ _1433_ _1434_ net67 VSS VSS VDD VDD _1435_ sky130_fd_sc_hd__o21ai_0
X_1828_ net67 _1433_ _1434_ VSS VSS VDD VDD _1436_ sky130_fd_sc_hd__or3_1
X_1829_ _1435_ _1436_ _1409_ VSS VSS VDD VDD _0053_ sky130_fd_sc_hd__a21oi_1
X_1830_ net67 VSS VSS VDD VDD _1437_ sky130_fd_sc_hd__inv_1
X_1831_ net65 _1363_ _1365_ _1428_ VSS VSS VDD VDD _1438_
+ sky130_fd_sc_hd__nand4_1
X_1832_ _1438_ VSS VSS VDD VDD _1439_ sky130_fd_sc_hd__buf_2
X_1833_ _1437_ _1434_ _1439_ net68 VSS VSS VDD VDD _1440_
+ sky130_fd_sc_hd__o31ai_1
X_1834_ _1437_ net68 _1434_ _1439_ VSS VSS VDD VDD _1441_
+ sky130_fd_sc_hd__or4_1
X_1835_ _1440_ _1441_ _1409_ VSS VSS VDD VDD _0054_ sky130_fd_sc_hd__a21oi_1
X_1836_ net47 net58 VSS VSS VDD VDD _1442_ sky130_fd_sc_hd__nand2_1
X_1837_ _1266_ _1352_ _1442_ net69 VSS VSS VDD VDD _1443_
+ sky130_fd_sc_hd__o31ai_1
X_1838_ net69 _1354_ _1351_ _1442_ VSS VSS VDD VDD _1444_
+ sky130_fd_sc_hd__or4_1
X_1839_ _1443_ _1444_ _1409_ VSS VSS VDD VDD _0055_ sky130_fd_sc_hd__a21oi_1
X_1840_ net67 net68 VSS VSS VDD VDD _1445_ sky130_fd_sc_hd__nand2_1
X_1841_ _1433_ _1434_ _1445_ net70 VSS VSS VDD VDD _1446_
+ sky130_fd_sc_hd__o31ai_1
X_1842_ net70 _1433_ _1434_ _1445_ VSS VSS VDD VDD _1447_
+ sky130_fd_sc_hd__or4_1
X_1843_ _1287_ VSS VSS VDD VDD _1448_ sky130_fd_sc_hd__clkbuf_4
X_1844_ _1446_ _1447_ _1448_ VSS VSS VDD VDD _0056_ sky130_fd_sc_hd__a21oi_1
X_1845_ net66 net67 net68 net70 VSS VSS VDD VDD _1449_ sky130_fd_sc_hd__and4_1
X_1846_ _1374_ _1392_ _1410_ _1449_ VSS VSS VDD VDD _1450_
+ sky130_fd_sc_hd__nand4_4
X_1847_ _1450_ VSS VSS VDD VDD _1451_ sky130_fd_sc_hd__buf_2
X_1848_ _1439_ _1451_ net71 VSS VSS VDD VDD _1452_ sky130_fd_sc_hd__o21ai_0
X_1849_ net71 _1439_ _1451_ VSS VSS VDD VDD _1453_ sky130_fd_sc_hd__or3_1
X_1850_ _1452_ _1453_ _1448_ VSS VSS VDD VDD _0057_ sky130_fd_sc_hd__a21oi_1
X_1851_ net71 VSS VSS VDD VDD _1454_ sky130_fd_sc_hd__inv_1
X_1852_ _1454_ _1433_ _1451_ net72 VSS VSS VDD VDD _1455_
+ sky130_fd_sc_hd__o31ai_1
X_1853_ _1454_ net72 _1433_ _1450_ VSS VSS VDD VDD _1456_
+ sky130_fd_sc_hd__or4_1
X_1854_ _1455_ _1456_ _1448_ VSS VSS VDD VDD _0058_ sky130_fd_sc_hd__a21oi_1
X_1855_ net71 net72 VSS VSS VDD VDD _1457_ sky130_fd_sc_hd__nand2_1
X_1856_ _1439_ _1451_ _1457_ net73 VSS VSS VDD VDD _1458_
+ sky130_fd_sc_hd__o31ai_1
X_1857_ net73 _1439_ _1450_ _1457_ VSS VSS VDD VDD _1459_
+ sky130_fd_sc_hd__or4_1
X_1858_ _1458_ _1459_ _1448_ VSS VSS VDD VDD _0059_ sky130_fd_sc_hd__a21oi_1
X_1859_ net71 net72 net73 VSS VSS VDD VDD _1460_ sky130_fd_sc_hd__nand3_1
X_1860_ _1433_ _1451_ _1460_ net74 VSS VSS VDD VDD _1461_
+ sky130_fd_sc_hd__o31ai_1
X_1861_ net74 _1433_ _1450_ _1460_ VSS VSS VDD VDD _1462_
+ sky130_fd_sc_hd__or4_1
X_1862_ _1461_ _1462_ _1448_ VSS VSS VDD VDD _0060_ sky130_fd_sc_hd__a21oi_1
X_1863_ net71 net72 net73 net74 VSS VSS VDD VDD _1463_ sky130_fd_sc_hd__nand4_1
X_1864_ _1439_ _1451_ _1463_ net75 VSS VSS VDD VDD _1464_
+ sky130_fd_sc_hd__o31ai_1
X_1865_ net75 _1439_ _1450_ _1463_ VSS VSS VDD VDD _1465_
+ sky130_fd_sc_hd__or4_1
X_1866_ _1464_ _1465_ _1448_ VSS VSS VDD VDD _0061_ sky130_fd_sc_hd__a21oi_1
X_1867_ net71 net72 net73 net74 VSS VSS VDD VDD _1466_ sky130_fd_sc_hd__and4_1
X_1868_ net75 _1466_ VSS VSS VDD VDD _1467_ sky130_fd_sc_hd__nand2_1
X_1869_ _1433_ _1451_ _1467_ net76 VSS VSS VDD VDD _1468_
+ sky130_fd_sc_hd__o31ai_1
X_1870_ net76 _1432_ _1450_ _1467_ VSS VSS VDD VDD _1469_
+ sky130_fd_sc_hd__or4_1
X_1871_ _1468_ _1469_ _1448_ VSS VSS VDD VDD _0062_ sky130_fd_sc_hd__a21oi_1
X_1872_ net75 net76 _1466_ VSS VSS VDD VDD _1470_ sky130_fd_sc_hd__nand3_1
X_1873_ _1439_ _1451_ _1470_ net77 VSS VSS VDD VDD _1471_
+ sky130_fd_sc_hd__o31ai_1
X_1874_ net77 _1438_ _1450_ _1470_ VSS VSS VDD VDD _1472_
+ sky130_fd_sc_hd__or4_1
X_1875_ _1471_ _1472_ _1448_ VSS VSS VDD VDD _0063_ sky130_fd_sc_hd__a21oi_1
X_1876_ net75 net76 net77 _1466_ VSS VSS VDD VDD _1473_ sky130_fd_sc_hd__nand4_1
X_1877_ _1433_ _1451_ _1473_ net78 VSS VSS VDD VDD _1474_
+ sky130_fd_sc_hd__o31ai_1
X_1878_ net78 _1432_ _1450_ _1473_ VSS VSS VDD VDD _1475_
+ sky130_fd_sc_hd__or4_1
X_1879_ _1474_ _1475_ _1448_ VSS VSS VDD VDD _0064_ sky130_fd_sc_hd__a21oi_1
X_1880_ net79 VSS VSS VDD VDD _1476_ sky130_fd_sc_hd__inv_1
X_1881_ _1254_ _1476_ VSS VSS VDD VDD _1477_ sky130_fd_sc_hd__nor2_1
X_1882_ _1215_ VSS VSS VDD VDD _1478_ sky130_fd_sc_hd__buf_4
X_1883_ _1478_ net79 VSS VSS VDD VDD _1479_ sky130_fd_sc_hd__nor2_1
X_1884_ net78 VSS VSS VDD VDD _1480_ sky130_fd_sc_hd__inv_1
X_1885_ _1480_ _1439_ _1451_ _1473_ VSS VSS VDD VDD _1481_
+ sky130_fd_sc_hd__nor4_1
X_1886_ _1477_ _1479_ _1481_ VSS VSS VDD VDD _0065_ sky130_fd_sc_hd__mux2_1
X_1887_ net47 net58 net69 VSS VSS VDD VDD _1482_ sky130_fd_sc_hd__nand3_1
X_1888_ _1399_ _1482_ net80 VSS VSS VDD VDD _1483_ sky130_fd_sc_hd__o21ai_0
X_1889_ net80 _1399_ _1482_ VSS VSS VDD VDD _1484_ sky130_fd_sc_hd__or3_1
X_1890_ _1483_ _1484_ _1448_ VSS VSS VDD VDD _0066_ sky130_fd_sc_hd__a21oi_1
X_1891_ _1217_ VSS VSS VDD VDD _1485_ sky130_fd_sc_hd__buf_2
X_1892_ prev_event_inc\[5\] net10 _1220_ VSS VSS VDD VDD _1486_
+ sky130_fd_sc_hd__and3b_1
X_1893_ net81 _1486_ VSS VSS VDD VDD _1487_ sky130_fd_sc_hd__xnor2_1
X_1894_ _1485_ _1487_ VSS VSS VDD VDD _0067_ sky130_fd_sc_hd__nor2_1
X_1895_ net82 _1547_ _1486_ VSS VSS VDD VDD _1488_ sky130_fd_sc_hd__mux2i_1
X_1896_ _1485_ _1488_ VSS VSS VDD VDD _0068_ sky130_fd_sc_hd__nor2_1
X_1897_ _1546_ VSS VSS VDD VDD _1489_ sky130_fd_sc_hd__clkbuf_4
X_1898_ _1489_ _1486_ VSS VSS VDD VDD _1490_ sky130_fd_sc_hd__nand2_1
X_1899_ net83 _1490_ VSS VSS VDD VDD _1491_ sky130_fd_sc_hd__xor2_1
X_1900_ _1485_ _1491_ VSS VSS VDD VDD _0069_ sky130_fd_sc_hd__nor2_1
X_1901_ prev_event_inc\[5\] net83 net4 net10 VSS VSS VDD VDD
+ _1492_ sky130_fd_sc_hd__nand4b_4
X_1902_ net81 net82 VSS VSS VDD VDD _1493_ sky130_fd_sc_hd__nand2_2
X_1903_ _1492_ _1493_ net84 VSS VSS VDD VDD _1494_ sky130_fd_sc_hd__o21ai_0
X_1904_ net84 _1492_ _1493_ VSS VSS VDD VDD _1495_ sky130_fd_sc_hd__or3_1
X_1905_ _1287_ VSS VSS VDD VDD _1496_ sky130_fd_sc_hd__clkbuf_4
X_1906_ _1494_ _1495_ _1496_ VSS VSS VDD VDD _0070_ sky130_fd_sc_hd__a21oi_1
X_1907_ prev_event_inc\[5\] net83 _1219_ net10 VSS VSS VDD
+ VDD _1497_ sky130_fd_sc_hd__and4b_1
X_1908_ _1497_ VSS VSS VDD VDD _1498_ sky130_fd_sc_hd__buf_2
X_1909_ net84 _1489_ _1498_ VSS VSS VDD VDD _1499_ sky130_fd_sc_hd__nand3_1
X_1910_ net85 _1499_ VSS VSS VDD VDD _1500_ sky130_fd_sc_hd__xor2_1
X_1911_ _1485_ _1500_ VSS VSS VDD VDD _0071_ sky130_fd_sc_hd__nor2_1
X_1912_ net84 net85 VSS VSS VDD VDD _1501_ sky130_fd_sc_hd__nand2_1
X_1913_ _1492_ _1493_ _1501_ VSS VSS VDD VDD _1502_ sky130_fd_sc_hd__nor3_1
X_1914_ net86 _1502_ VSS VSS VDD VDD _1503_ sky130_fd_sc_hd__xnor2_1
X_1915_ _1485_ _1503_ VSS VSS VDD VDD _0072_ sky130_fd_sc_hd__nor2_1
X_1916_ net84 net85 net86 VSS VSS VDD VDD _1504_ sky130_fd_sc_hd__and3_1
X_1917_ _1489_ _1498_ _1504_ VSS VSS VDD VDD _1505_ sky130_fd_sc_hd__nand3_1
X_1918_ net87 _1505_ VSS VSS VDD VDD _1506_ sky130_fd_sc_hd__xor2_1
X_1919_ _1485_ _1506_ VSS VSS VDD VDD _0073_ sky130_fd_sc_hd__nor2_1
X_1920_ net84 net85 net86 net87 VSS VSS VDD VDD _1507_ sky130_fd_sc_hd__nand4_2
X_1921_ _1492_ _1493_ _1507_ VSS VSS VDD VDD _1508_ sky130_fd_sc_hd__nor3_1
X_1922_ net88 _1508_ VSS VSS VDD VDD _1509_ sky130_fd_sc_hd__xnor2_1
X_1923_ _1485_ _1509_ VSS VSS VDD VDD _0074_ sky130_fd_sc_hd__nor2_1
X_1924_ net84 net85 net86 net87 VSS VSS VDD VDD _1510_ sky130_fd_sc_hd__and4_1
X_1925_ net88 _1489_ _1498_ _1510_ VSS VSS VDD VDD _1511_
+ sky130_fd_sc_hd__nand4_1
X_1926_ net89 _1511_ VSS VSS VDD VDD _1512_ sky130_fd_sc_hd__xor2_1
X_1927_ _1485_ _1512_ VSS VSS VDD VDD _0075_ sky130_fd_sc_hd__nor2_1
X_1928_ net88 net89 VSS VSS VDD VDD _1513_ sky130_fd_sc_hd__nand2_1
X_1929_ _1492_ _1493_ _1507_ _1513_ VSS VSS VDD VDD _1514_
+ sky130_fd_sc_hd__nor4_1
X_1930_ net90 _1514_ VSS VSS VDD VDD _1515_ sky130_fd_sc_hd__xnor2_1
X_1931_ _1485_ _1515_ VSS VSS VDD VDD _0076_ sky130_fd_sc_hd__nor2_1
X_1932_ net47 net58 net69 net80 VSS VSS VDD VDD _1516_ sky130_fd_sc_hd__nand4_1
X_1933_ _1266_ _1352_ _1516_ net91 VSS VSS VDD VDD _1517_
+ sky130_fd_sc_hd__o31ai_1
X_1934_ net91 _1354_ _1351_ _1516_ VSS VSS VDD VDD _1518_
+ sky130_fd_sc_hd__or4_1
X_1935_ _1517_ _1518_ _1496_ VSS VSS VDD VDD _0077_ sky130_fd_sc_hd__a21oi_1
X_1936_ _1489_ VSS VSS VDD VDD _1519_ sky130_fd_sc_hd__inv_1
X_1937_ net88 net89 net90 VSS VSS VDD VDD _1520_ sky130_fd_sc_hd__nand3_1
X_1938_ _1519_ _1492_ _1507_ _1520_ VSS VSS VDD VDD _1521_
+ sky130_fd_sc_hd__nor4_1
X_1939_ net92 _1521_ VSS VSS VDD VDD _1522_ sky130_fd_sc_hd__xnor2_1
X_1940_ _1485_ _1522_ VSS VSS VDD VDD _0078_ sky130_fd_sc_hd__nor2_1
X_1941_ _1217_ VSS VSS VDD VDD _1523_ sky130_fd_sc_hd__buf_4
X_1942_ net88 net89 net90 net92 VSS VSS VDD VDD _1524_ sky130_fd_sc_hd__and4_2
X_1943_ _1492_ _1493_ _1507_ _1524_ VSS VSS VDD VDD _1525_
+ sky130_fd_sc_hd__or4b_1
X_1944_ _1525_ VSS VSS VDD VDD _1526_ sky130_fd_sc_hd__clkbuf_2
X_1945_ net93 _1526_ VSS VSS VDD VDD _1527_ sky130_fd_sc_hd__xor2_1
X_1946_ _1523_ _1527_ VSS VSS VDD VDD _0079_ sky130_fd_sc_hd__nor2_1
X_1947_ _1489_ _1498_ _1510_ VSS VSS VDD VDD _1528_ sky130_fd_sc_hd__nand3_1
X_1948_ net93 _1524_ VSS VSS VDD VDD _1529_ sky130_fd_sc_hd__nand2_1
X_1949_ _1528_ _1529_ net94 VSS VSS VDD VDD _1530_ sky130_fd_sc_hd__o21ai_0
X_1950_ net94 _1528_ _1529_ VSS VSS VDD VDD _1531_ sky130_fd_sc_hd__or3_1
X_1951_ _1530_ _1531_ _1496_ VSS VSS VDD VDD _0080_ sky130_fd_sc_hd__a21oi_1
X_1952_ net93 net94 VSS VSS VDD VDD _1532_ sky130_fd_sc_hd__nand2_1
X_1953_ _1526_ _1532_ net95 VSS VSS VDD VDD _1533_ sky130_fd_sc_hd__o21ai_0
X_1954_ net95 _1526_ _1532_ VSS VSS VDD VDD _1534_ sky130_fd_sc_hd__or3_1
X_1955_ _1533_ _1534_ _1496_ VSS VSS VDD VDD _0081_ sky130_fd_sc_hd__a21oi_1
X_1956_ _1489_ _1498_ VSS VSS VDD VDD _1535_ sky130_fd_sc_hd__nand2_1
X_1957_ net93 net94 net95 VSS VSS VDD VDD _1536_ sky130_fd_sc_hd__and3_2
X_1958_ net87 _1504_ _1524_ _1536_ VSS VSS VDD VDD _1537_
+ sky130_fd_sc_hd__nand4_2
X_1959_ _1535_ _1537_ net96 VSS VSS VDD VDD _0264_ sky130_fd_sc_hd__o21ai_0
X_1960_ net96 _1535_ _1537_ VSS VSS VDD VDD _0265_ sky130_fd_sc_hd__or3_1
X_1961_ _0264_ _0265_ _1496_ VSS VSS VDD VDD _0082_ sky130_fd_sc_hd__a21oi_1
X_1962_ net96 _1536_ VSS VSS VDD VDD _0266_ sky130_fd_sc_hd__nand2_1
X_1963_ _1526_ _0266_ net97 VSS VSS VDD VDD _0267_ sky130_fd_sc_hd__o21ai_0
X_1964_ net97 _1526_ _0266_ VSS VSS VDD VDD _0268_ sky130_fd_sc_hd__or3_1
X_1965_ _0267_ _0268_ _1496_ VSS VSS VDD VDD _0083_ sky130_fd_sc_hd__a21oi_1
X_1966_ net96 net97 VSS VSS VDD VDD _0269_ sky130_fd_sc_hd__nand2_1
X_1967_ _1535_ _1537_ _0269_ net98 VSS VSS VDD VDD _0270_
+ sky130_fd_sc_hd__o31ai_1
X_1968_ net98 _1535_ _1537_ _0269_ VSS VSS VDD VDD _0271_
+ sky130_fd_sc_hd__or4_1
X_1969_ _0270_ _0271_ _1496_ VSS VSS VDD VDD _0084_ sky130_fd_sc_hd__a21oi_1
X_1970_ net96 net97 net98 _1536_ VSS VSS VDD VDD _0272_ sky130_fd_sc_hd__nand4_1
X_1971_ _1526_ _0272_ net99 VSS VSS VDD VDD _0273_ sky130_fd_sc_hd__o21ai_0
X_1972_ net99 _1526_ _0272_ VSS VSS VDD VDD _0274_ sky130_fd_sc_hd__or3_1
X_1973_ _0273_ _0274_ _1496_ VSS VSS VDD VDD _0085_ sky130_fd_sc_hd__a21oi_1
X_1974_ net96 net97 net98 net99 VSS VSS VDD VDD _0275_ sky130_fd_sc_hd__nand4_1
X_1975_ _1535_ _1537_ _0275_ net100 VSS VSS VDD VDD _0276_
+ sky130_fd_sc_hd__o31ai_1
X_1976_ net100 _1535_ _1537_ _0275_ VSS VSS VDD VDD _0277_
+ sky130_fd_sc_hd__or4_1
X_1977_ _0276_ _0277_ _1496_ VSS VSS VDD VDD _0086_ sky130_fd_sc_hd__a21oi_1
X_1978_ net96 net97 net98 net99 VSS VSS VDD VDD _0278_ sky130_fd_sc_hd__and4_1
X_1979_ net100 _1536_ _0278_ VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__nand3_1
X_1980_ _1526_ _0279_ net101 VSS VSS VDD VDD _0280_ sky130_fd_sc_hd__o21ai_0
X_1981_ net101 _1526_ _0279_ VSS VSS VDD VDD _0281_ sky130_fd_sc_hd__or3_1
X_1982_ _0280_ _0281_ _1496_ VSS VSS VDD VDD _0087_ sky130_fd_sc_hd__a21oi_1
X_1983_ net47 net58 net69 net80 VSS VSS VDD VDD _0282_ sky130_fd_sc_hd__and4_1
X_1984_ _0282_ VSS VSS VDD VDD _0283_ sky130_fd_sc_hd__buf_2
X_1985_ net91 _0283_ VSS VSS VDD VDD _0284_ sky130_fd_sc_hd__nand2_1
X_1986_ _1399_ _0284_ net102 VSS VSS VDD VDD _0285_ sky130_fd_sc_hd__o21ai_0
X_1987_ net102 _1398_ _0284_ VSS VSS VDD VDD _0286_ sky130_fd_sc_hd__or3_1
X_1988_ _1287_ VSS VSS VDD VDD _0287_ sky130_fd_sc_hd__buf_2
X_1989_ _0285_ _0286_ _0287_ VSS VSS VDD VDD _0088_ sky130_fd_sc_hd__a21oi_1
X_1990_ net87 net101 VSS VSS VDD VDD _0288_ sky130_fd_sc_hd__and2_0
X_1991_ _1504_ _1524_ _1536_ _0288_ VSS VSS VDD VDD _0289_
+ sky130_fd_sc_hd__nand4_4
X_1992_ _0289_ VSS VSS VDD VDD _0290_ sky130_fd_sc_hd__buf_2
X_1993_ _0290_ VSS VSS VDD VDD _0291_ sky130_fd_sc_hd__buf_2
X_1994_ net100 _1498_ _0278_ VSS VSS VDD VDD _0292_ sky130_fd_sc_hd__nand3_2
X_1995_ _1519_ _0291_ _0292_ net103 VSS VSS VDD VDD _0293_
+ sky130_fd_sc_hd__o31ai_1
X_1996_ net103 _1519_ _0290_ _0292_ VSS VSS VDD VDD _0294_
+ sky130_fd_sc_hd__or4_1
X_1997_ _0293_ _0294_ _0287_ VSS VSS VDD VDD _0089_ sky130_fd_sc_hd__a21oi_1
X_1998_ net81 net82 net103 VSS VSS VDD VDD _0295_ sky130_fd_sc_hd__nand3_1
X_1999_ _0291_ _0292_ _0295_ net104 VSS VSS VDD VDD _0296_
+ sky130_fd_sc_hd__o31ai_1
X_2000_ net104 _0290_ _0292_ _0295_ VSS VSS VDD VDD _0297_
+ sky130_fd_sc_hd__or4_1
X_2001_ _0296_ _0297_ _0287_ VSS VSS VDD VDD _0090_ sky130_fd_sc_hd__a21oi_1
X_2002_ net103 net104 _1489_ VSS VSS VDD VDD _0298_ sky130_fd_sc_hd__nand3_1
X_2003_ _0291_ _0292_ _0298_ net105 VSS VSS VDD VDD _0299_
+ sky130_fd_sc_hd__o31ai_1
X_2004_ net105 _0290_ _0292_ _0298_ VSS VSS VDD VDD _0300_
+ sky130_fd_sc_hd__or4_1
X_2005_ _0299_ _0300_ _0287_ VSS VSS VDD VDD _0091_ sky130_fd_sc_hd__a21oi_1
X_2006_ net100 net103 net104 net105 VSS VSS VDD VDD _0301_
+ sky130_fd_sc_hd__and4_1
X_2007_ _1492_ _1493_ _0275_ _0301_ VSS VSS VDD VDD _0302_
+ sky130_fd_sc_hd__or4b_1
X_2008_ _0302_ VSS VSS VDD VDD _0303_ sky130_fd_sc_hd__buf_2
X_2009_ _0291_ _0303_ net106 VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__o21ai_0
X_2010_ net106 _0290_ _0303_ VSS VSS VDD VDD _0305_ sky130_fd_sc_hd__or3_1
X_2011_ _0304_ _0305_ _0287_ VSS VSS VDD VDD _0092_ sky130_fd_sc_hd__a21oi_1
X_2012_ net106 VSS VSS VDD VDD _0306_ sky130_fd_sc_hd__inv_1
X_2013_ _1489_ _1498_ _0278_ _0301_ VSS VSS VDD VDD _0307_
+ sky130_fd_sc_hd__nand4_4
X_2014_ _0306_ _0291_ _0307_ net107 VSS VSS VDD VDD _0308_
+ sky130_fd_sc_hd__o31ai_1
X_2015_ _0306_ net107 _0290_ _0307_ VSS VSS VDD VDD _0309_
+ sky130_fd_sc_hd__or4_1
X_2016_ _0308_ _0309_ _0287_ VSS VSS VDD VDD _0093_ sky130_fd_sc_hd__a21oi_1
X_2017_ net106 net107 VSS VSS VDD VDD _0310_ sky130_fd_sc_hd__nand2_1
X_2018_ _0291_ _0303_ _0310_ net108 VSS VSS VDD VDD _0311_
+ sky130_fd_sc_hd__o31ai_1
X_2019_ net108 _0290_ _0303_ _0310_ VSS VSS VDD VDD _0312_
+ sky130_fd_sc_hd__or4_1
X_2020_ _0311_ _0312_ _0287_ VSS VSS VDD VDD _0094_ sky130_fd_sc_hd__a21oi_1
X_2021_ net106 net107 net108 VSS VSS VDD VDD _0313_ sky130_fd_sc_hd__nand3_1
X_2022_ _0291_ _0307_ _0313_ net109 VSS VSS VDD VDD _0314_
+ sky130_fd_sc_hd__o31ai_1
X_2023_ net109 _0290_ _0307_ _0313_ VSS VSS VDD VDD _0315_
+ sky130_fd_sc_hd__or4_1
X_2024_ _0314_ _0315_ _0287_ VSS VSS VDD VDD _0095_ sky130_fd_sc_hd__a21oi_1
X_2025_ net106 net107 net108 net109 VSS VSS VDD VDD _0316_
+ sky130_fd_sc_hd__nand4_1
X_2026_ _0291_ _0303_ _0316_ net110 VSS VSS VDD VDD _0317_
+ sky130_fd_sc_hd__o31ai_1
X_2027_ net110 _0289_ _0303_ _0316_ VSS VSS VDD VDD _0318_
+ sky130_fd_sc_hd__or4_1
X_2028_ _0317_ _0318_ _0287_ VSS VSS VDD VDD _0096_ sky130_fd_sc_hd__a21oi_1
X_2029_ net106 net107 net108 net109 VSS VSS VDD VDD _0319_
+ sky130_fd_sc_hd__and4_1
X_2030_ net110 _0319_ VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__nand2_1
X_2031_ _0291_ _0307_ _0320_ net111 VSS VSS VDD VDD _0321_
+ sky130_fd_sc_hd__o31ai_1
X_2032_ net111 _0289_ _0307_ _0320_ VSS VSS VDD VDD _0322_
+ sky130_fd_sc_hd__or4_1
X_2033_ _0321_ _0322_ _0287_ VSS VSS VDD VDD _0097_ sky130_fd_sc_hd__a21oi_1
X_2034_ net110 net111 _0319_ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__nand3_1
X_2035_ _0291_ _0303_ _0323_ net112 VSS VSS VDD VDD _0324_
+ sky130_fd_sc_hd__o31ai_1
X_2036_ net112 _0289_ _0303_ _0323_ VSS VSS VDD VDD _0325_
+ sky130_fd_sc_hd__or4_1
X_2037_ _1287_ VSS VSS VDD VDD _0326_ sky130_fd_sc_hd__clkbuf_4
X_2038_ _0324_ _0325_ _0326_ VSS VSS VDD VDD _0098_ sky130_fd_sc_hd__a21oi_1
X_2039_ net91 net102 _0283_ VSS VSS VDD VDD _0327_ sky130_fd_sc_hd__nand3_1
X_2040_ _1266_ _1352_ _0327_ net113 VSS VSS VDD VDD _0328_
+ sky130_fd_sc_hd__o31ai_1
X_2041_ net113 _1354_ _1351_ _0327_ VSS VSS VDD VDD _0329_
+ sky130_fd_sc_hd__or4_1
X_2042_ _0328_ _0329_ _0326_ VSS VSS VDD VDD _0099_ sky130_fd_sc_hd__a21oi_1
X_2043_ net110 net111 net112 VSS VSS VDD VDD _0330_ sky130_fd_sc_hd__and3_1
X_2044_ _0319_ _0330_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__nand2_1
X_2045_ _0290_ _0307_ _0331_ net114 VSS VSS VDD VDD _0332_
+ sky130_fd_sc_hd__o31ai_1
X_2046_ net114 _0289_ _0307_ _0331_ VSS VSS VDD VDD _0333_
+ sky130_fd_sc_hd__or4_1
X_2047_ _0332_ _0333_ _0326_ VSS VSS VDD VDD _0100_ sky130_fd_sc_hd__a21oi_1
X_2048_ net114 _0319_ _0330_ VSS VSS VDD VDD _0334_ sky130_fd_sc_hd__nand3_1
X_2049_ _0290_ _0303_ _0334_ net115 VSS VSS VDD VDD _0335_
+ sky130_fd_sc_hd__o31ai_1
X_2050_ net115 _0289_ _0303_ _0334_ VSS VSS VDD VDD _0336_
+ sky130_fd_sc_hd__or4_1
X_2051_ _0335_ _0336_ _0326_ VSS VSS VDD VDD _0101_ sky130_fd_sc_hd__a21oi_1
X_2052_ prev_event_inc\[6\] net11 _1220_ VSS VSS VDD VDD _0337_
+ sky130_fd_sc_hd__nand3b_1
X_2053_ net116 _0337_ VSS VSS VDD VDD _0338_ sky130_fd_sc_hd__xor2_1
X_2054_ _1523_ _0338_ VSS VSS VDD VDD _0102_ sky130_fd_sc_hd__nor2_1
X_2055_ _1545_ net117 _0337_ VSS VSS VDD VDD _0339_ sky130_fd_sc_hd__mux2i_1
X_2056_ _1523_ _0339_ VSS VSS VDD VDD _0103_ sky130_fd_sc_hd__nor2_1
X_2057_ prev_event_inc\[6\] _1544_ _1220_ net11 VSS VSS VDD
+ VDD _0340_ sky130_fd_sc_hd__nand4b_1
X_2058_ net118 _0340_ VSS VSS VDD VDD _0341_ sky130_fd_sc_hd__xor2_1
X_2059_ _1523_ _0341_ VSS VSS VDD VDD _0104_ sky130_fd_sc_hd__nor2_1
X_2060_ net116 net117 VSS VSS VDD VDD _0342_ sky130_fd_sc_hd__nand2_1
X_2061_ prev_event_inc\[6\] net118 _1219_ net11 VSS VSS VDD
+ VDD _0343_ sky130_fd_sc_hd__nand4b_1
X_2062_ _0342_ _0343_ net119 VSS VSS VDD VDD _0344_ sky130_fd_sc_hd__o21ai_0
X_2063_ net119 _0342_ _0343_ VSS VSS VDD VDD _0345_ sky130_fd_sc_hd__or3_1
X_2064_ _0344_ _0345_ _0326_ VSS VSS VDD VDD _0105_ sky130_fd_sc_hd__a21oi_1
X_2065_ prev_event_inc\[6\] net118 net4 net11 VSS VSS VDD
+ VDD _0346_ sky130_fd_sc_hd__and4b_1
X_2066_ _0346_ VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__buf_2
X_2067_ net119 _1544_ _0347_ VSS VSS VDD VDD _0348_ sky130_fd_sc_hd__nand3_1
X_2068_ net120 _0348_ VSS VSS VDD VDD _0349_ sky130_fd_sc_hd__xor2_1
X_2069_ _1523_ _0349_ VSS VSS VDD VDD _0106_ sky130_fd_sc_hd__nor2_1
X_2070_ net116 net117 VSS VSS VDD VDD _0350_ sky130_fd_sc_hd__and2_1
X_2071_ net119 net120 _0350_ _0347_ VSS VSS VDD VDD _0351_
+ sky130_fd_sc_hd__nand4_1
X_2072_ net121 _0351_ VSS VSS VDD VDD _0352_ sky130_fd_sc_hd__xor2_1
X_2073_ _1523_ _0352_ VSS VSS VDD VDD _0107_ sky130_fd_sc_hd__nor2_1
X_2074_ net119 net120 net121 VSS VSS VDD VDD _0353_ sky130_fd_sc_hd__and3_2
X_2075_ _1544_ _0347_ _0353_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__nand3_2
X_2076_ net122 _0354_ VSS VSS VDD VDD _0355_ sky130_fd_sc_hd__xor2_1
X_2077_ _1523_ _0355_ VSS VSS VDD VDD _0108_ sky130_fd_sc_hd__nor2_1
X_2078_ net119 net120 net121 net122 VSS VSS VDD VDD _0356_
+ sky130_fd_sc_hd__nand4_1
X_2079_ _0342_ _0343_ _0356_ VSS VSS VDD VDD _0357_ sky130_fd_sc_hd__nor3_1
X_2080_ net123 _0357_ VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__xnor2_1
X_2081_ _1523_ _0358_ VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__nor2_1
X_2082_ net113 VSS VSS VDD VDD _0359_ sky130_fd_sc_hd__inv_1
X_2083_ _0359_ _1399_ _0327_ net124 VSS VSS VDD VDD _0360_
+ sky130_fd_sc_hd__o31ai_1
X_2084_ _0359_ net124 _1398_ _0327_ VSS VSS VDD VDD _0361_
+ sky130_fd_sc_hd__or4_1
X_2085_ _0360_ _0361_ _0326_ VSS VSS VDD VDD _0110_ sky130_fd_sc_hd__a21oi_1
X_2086_ net125 _1541_ _1221_ VSS VSS VDD VDD _0362_ sky130_fd_sc_hd__mux2i_1
X_2087_ _1523_ _0362_ VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__nor2_1
X_2088_ net119 net120 net121 net122 VSS VSS VDD VDD _0363_
+ sky130_fd_sc_hd__and4_2
X_2089_ net123 _1544_ _0347_ _0363_ VSS VSS VDD VDD _0364_
+ sky130_fd_sc_hd__nand4_1
X_2090_ net126 _0364_ VSS VSS VDD VDD _0365_ sky130_fd_sc_hd__xor2_1
X_2091_ _1523_ _0365_ VSS VSS VDD VDD _0112_ sky130_fd_sc_hd__nor2_1
X_2092_ _1217_ VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__clkbuf_4
X_2093_ net123 net126 VSS VSS VDD VDD _0367_ sky130_fd_sc_hd__nand2_1
X_2094_ _0342_ _0343_ _0356_ _0367_ VSS VSS VDD VDD _0368_
+ sky130_fd_sc_hd__nor4_1
X_2095_ net127 _0368_ VSS VSS VDD VDD _0369_ sky130_fd_sc_hd__xnor2_1
X_2096_ _0366_ _0369_ VSS VSS VDD VDD _0113_ sky130_fd_sc_hd__nor2_1
X_2097_ net123 net126 net127 VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__and3_1
X_2098_ _1544_ _0347_ _0363_ _0370_ VSS VSS VDD VDD _0371_
+ sky130_fd_sc_hd__nand4_1
X_2099_ net128 _0371_ VSS VSS VDD VDD _0372_ sky130_fd_sc_hd__xor2_1
X_2100_ _0366_ _0372_ VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__nor2_1
X_2101_ net123 net126 net127 net128 VSS VSS VDD VDD _0373_
+ sky130_fd_sc_hd__and4_2
X_2102_ _0350_ _0347_ _0363_ _0373_ VSS VSS VDD VDD _0374_
+ sky130_fd_sc_hd__nand4_4
X_2103_ net129 _0374_ VSS VSS VDD VDD _0375_ sky130_fd_sc_hd__xor2_1
X_2104_ _0366_ _0375_ VSS VSS VDD VDD _0115_ sky130_fd_sc_hd__nor2_1
X_2105_ _1544_ _0347_ _0363_ VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__nand3_1
X_2106_ net129 _0373_ VSS VSS VDD VDD _0377_ sky130_fd_sc_hd__nand2_1
X_2107_ _0376_ _0377_ net130 VSS VSS VDD VDD _0378_ sky130_fd_sc_hd__o21ai_0
X_2108_ net130 _0376_ _0377_ VSS VSS VDD VDD _0379_ sky130_fd_sc_hd__or3_1
X_2109_ _0378_ _0379_ _0326_ VSS VSS VDD VDD _0116_ sky130_fd_sc_hd__a21oi_1
X_2110_ net129 net130 VSS VSS VDD VDD _0380_ sky130_fd_sc_hd__nand2_1
X_2111_ _0374_ _0380_ net131 VSS VSS VDD VDD _0381_ sky130_fd_sc_hd__o21ai_0
X_2112_ net131 _0374_ _0380_ VSS VSS VDD VDD _0382_ sky130_fd_sc_hd__or3_1
X_2113_ _0381_ _0382_ _0326_ VSS VSS VDD VDD _0117_ sky130_fd_sc_hd__a21oi_1
X_2114_ net122 net129 net130 net131 VSS VSS VDD VDD _0383_
+ sky130_fd_sc_hd__and4_1
X_2115_ _0373_ _0383_ VSS VSS VDD VDD _0384_ sky130_fd_sc_hd__nand2_1
X_2116_ _0354_ _0384_ net132 VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__o21ai_0
X_2117_ net132 _0354_ _0384_ VSS VSS VDD VDD _0386_ sky130_fd_sc_hd__or3_1
X_2118_ _0385_ _0386_ _0326_ VSS VSS VDD VDD _0118_ sky130_fd_sc_hd__a21oi_1
X_2119_ net129 net130 net131 VSS VSS VDD VDD _0387_ sky130_fd_sc_hd__and3_1
X_2120_ net132 _0387_ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__nand2_1
X_2121_ _0374_ _0388_ net133 VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__o21ai_0
X_2122_ net133 _0374_ _0388_ VSS VSS VDD VDD _0390_ sky130_fd_sc_hd__or3_1
X_2123_ _0389_ _0390_ _0326_ VSS VSS VDD VDD _0119_ sky130_fd_sc_hd__a21oi_1
X_2124_ net132 net133 VSS VSS VDD VDD _0391_ sky130_fd_sc_hd__nand2_1
X_2125_ _0354_ _0384_ _0391_ net134 VSS VSS VDD VDD _0392_
+ sky130_fd_sc_hd__o31ai_1
X_2126_ net134 _0354_ _0384_ _0391_ VSS VSS VDD VDD _0393_
+ sky130_fd_sc_hd__or4_1
X_2127_ _1254_ VSS VSS VDD VDD _0394_ sky130_fd_sc_hd__buf_4
X_2128_ _0392_ _0393_ _0394_ VSS VSS VDD VDD _0120_ sky130_fd_sc_hd__a21oi_1
X_2129_ net132 net133 net134 _0387_ VSS VSS VDD VDD _0395_
+ sky130_fd_sc_hd__nand4_1
X_2130_ _0374_ _0395_ net135 VSS VSS VDD VDD _0396_ sky130_fd_sc_hd__o21ai_0
X_2131_ net135 _0374_ _0395_ VSS VSS VDD VDD _0397_ sky130_fd_sc_hd__or3_1
X_2132_ _0396_ _0397_ _0394_ VSS VSS VDD VDD _0121_ sky130_fd_sc_hd__a21oi_1
X_2133_ net91 net102 net113 net124 VSS VSS VDD VDD _0398_
+ sky130_fd_sc_hd__and4_1
X_2134_ _0283_ _0398_ VSS VSS VDD VDD _0399_ sky130_fd_sc_hd__nand2_1
X_2135_ _1266_ _1352_ _0399_ net136 VSS VSS VDD VDD _0400_
+ sky130_fd_sc_hd__o31ai_1
X_2136_ net136 _1354_ _1351_ _0399_ VSS VSS VDD VDD _0401_
+ sky130_fd_sc_hd__or4_1
X_2137_ _0400_ _0401_ _0394_ VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__a21oi_1
X_2138_ _1216_ net137 VSS VSS VDD VDD _0402_ sky130_fd_sc_hd__nor2b_1
X_2139_ _1478_ net137 VSS VSS VDD VDD _0403_ sky130_fd_sc_hd__nor2_1
X_2140_ net132 net133 net134 net135 VSS VSS VDD VDD _0404_
+ sky130_fd_sc_hd__and4_1
X_2141_ _0354_ _0384_ _0404_ VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__nor3b_1
X_2142_ _0402_ _0403_ _0405_ VSS VSS VDD VDD _0123_ sky130_fd_sc_hd__mux2_1
X_2143_ net137 _0387_ _0404_ VSS VSS VDD VDD _0406_ sky130_fd_sc_hd__nand3_1
X_2144_ _0374_ _0406_ net138 VSS VSS VDD VDD _0407_ sky130_fd_sc_hd__o21ai_0
X_2145_ net138 _0374_ _0406_ VSS VSS VDD VDD _0408_ sky130_fd_sc_hd__or3_1
X_2146_ _0407_ _0408_ _0394_ VSS VSS VDD VDD _0124_ sky130_fd_sc_hd__a21oi_1
X_2147_ net138 _0353_ _0373_ _0383_ VSS VSS VDD VDD _0409_
+ sky130_fd_sc_hd__nand4_2
X_2148_ net137 _1544_ _0347_ _0404_ VSS VSS VDD VDD _0410_
+ sky130_fd_sc_hd__nand4_1
X_2149_ _0410_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__buf_2
X_2150_ _0409_ _0411_ net139 VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__o21ai_0
X_2151_ net139 _0409_ _0411_ VSS VSS VDD VDD _0413_ sky130_fd_sc_hd__or3_1
X_2152_ _0412_ _0413_ _0394_ VSS VSS VDD VDD _0125_ sky130_fd_sc_hd__a21oi_1
X_2153_ net139 VSS VSS VDD VDD _0414_ sky130_fd_sc_hd__inv_1
X_2154_ net137 _0350_ _0347_ _0404_ VSS VSS VDD VDD _0415_
+ sky130_fd_sc_hd__nand4_1
X_2155_ _0415_ VSS VSS VDD VDD _0416_ sky130_fd_sc_hd__clkbuf_2
X_2156_ _0414_ _0409_ _0416_ net140 VSS VSS VDD VDD _0417_
+ sky130_fd_sc_hd__o31ai_1
X_2157_ _0414_ net140 _0409_ _0416_ VSS VSS VDD VDD _0418_
+ sky130_fd_sc_hd__or4_1
X_2158_ _0417_ _0418_ _0394_ VSS VSS VDD VDD _0126_ sky130_fd_sc_hd__a21oi_1
X_2159_ net139 net140 VSS VSS VDD VDD _0419_ sky130_fd_sc_hd__nand2_1
X_2160_ _0409_ _0411_ _0419_ net141 VSS VSS VDD VDD _0420_
+ sky130_fd_sc_hd__o31ai_1
X_2161_ net141 _0409_ _0411_ _0419_ VSS VSS VDD VDD _0421_
+ sky130_fd_sc_hd__or4_1
X_2162_ _0420_ _0421_ _0394_ VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__a21oi_1
X_2163_ net138 net139 net140 net141 VSS VSS VDD VDD _0422_
+ sky130_fd_sc_hd__and4_1
X_2164_ _0353_ _0373_ _0383_ _0422_ VSS VSS VDD VDD _0423_
+ sky130_fd_sc_hd__nand4_4
X_2165_ _0423_ VSS VSS VDD VDD _0424_ sky130_fd_sc_hd__buf_2
X_2166_ _0416_ _0424_ net142 VSS VSS VDD VDD _0425_ sky130_fd_sc_hd__o21ai_0
X_2167_ net142 _0416_ _0424_ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__or3_1
X_2168_ _0425_ _0426_ _0394_ VSS VSS VDD VDD _0128_ sky130_fd_sc_hd__a21oi_1
X_2169_ net142 VSS VSS VDD VDD _0427_ sky130_fd_sc_hd__inv_1
X_2170_ _0427_ _0411_ _0424_ net143 VSS VSS VDD VDD _0428_
+ sky130_fd_sc_hd__o31ai_1
X_2171_ _0427_ net143 _0411_ _0423_ VSS VSS VDD VDD _0429_
+ sky130_fd_sc_hd__or4_1
X_2172_ _0428_ _0429_ _0394_ VSS VSS VDD VDD _0129_ sky130_fd_sc_hd__a21oi_1
X_2173_ net142 net143 VSS VSS VDD VDD _0430_ sky130_fd_sc_hd__nand2_1
X_2174_ _0416_ _0424_ _0430_ net144 VSS VSS VDD VDD _0431_
+ sky130_fd_sc_hd__o31ai_1
X_2175_ net144 _0416_ _0423_ _0430_ VSS VSS VDD VDD _0432_
+ sky130_fd_sc_hd__or4_1
X_2176_ _0431_ _0432_ _0394_ VSS VSS VDD VDD _0130_ sky130_fd_sc_hd__a21oi_1
X_2177_ net142 net143 net144 VSS VSS VDD VDD _0433_ sky130_fd_sc_hd__nand3_1
X_2178_ _0411_ _0424_ _0433_ net145 VSS VSS VDD VDD _0434_
+ sky130_fd_sc_hd__o31ai_1
X_2179_ net145 _0411_ _0423_ _0433_ VSS VSS VDD VDD _0435_
+ sky130_fd_sc_hd__or4_1
X_2180_ _1254_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__clkbuf_4
X_2181_ _0434_ _0435_ _0436_ VSS VSS VDD VDD _0131_ sky130_fd_sc_hd__a21oi_1
X_2182_ net142 net143 net144 net145 VSS VSS VDD VDD _0437_
+ sky130_fd_sc_hd__nand4_1
X_2183_ _0416_ _0424_ _0437_ net146 VSS VSS VDD VDD _0438_
+ sky130_fd_sc_hd__o31ai_1
X_2184_ net146 _0416_ _0423_ _0437_ VSS VSS VDD VDD _0439_
+ sky130_fd_sc_hd__or4_1
X_2185_ _0438_ _0439_ _0436_ VSS VSS VDD VDD _0132_ sky130_fd_sc_hd__a21oi_1
X_2186_ net136 _0283_ _0398_ VSS VSS VDD VDD _0440_ sky130_fd_sc_hd__nand3_1
X_2187_ _1399_ _0440_ net147 VSS VSS VDD VDD _0441_ sky130_fd_sc_hd__o21ai_0
X_2188_ net147 _1398_ _0440_ VSS VSS VDD VDD _0442_ sky130_fd_sc_hd__or3_1
X_2189_ _0441_ _0442_ _0436_ VSS VSS VDD VDD _0133_ sky130_fd_sc_hd__a21oi_1
X_2190_ net142 net143 net144 net145 VSS VSS VDD VDD _0443_
+ sky130_fd_sc_hd__and4_1
X_2191_ net146 _0443_ VSS VSS VDD VDD _0444_ sky130_fd_sc_hd__nand2_1
X_2192_ _0411_ _0424_ _0444_ net148 VSS VSS VDD VDD _0445_
+ sky130_fd_sc_hd__o31ai_1
X_2193_ net148 _0410_ _0423_ _0444_ VSS VSS VDD VDD _0446_
+ sky130_fd_sc_hd__or4_1
X_2194_ _0445_ _0446_ _0436_ VSS VSS VDD VDD _0134_ sky130_fd_sc_hd__a21oi_1
X_2195_ net146 net148 _0443_ VSS VSS VDD VDD _0447_ sky130_fd_sc_hd__nand3_1
X_2196_ _0416_ _0424_ _0447_ net149 VSS VSS VDD VDD _0448_
+ sky130_fd_sc_hd__o31ai_1
X_2197_ net149 _0415_ _0423_ _0447_ VSS VSS VDD VDD _0449_
+ sky130_fd_sc_hd__or4_1
X_2198_ _0448_ _0449_ _0436_ VSS VSS VDD VDD _0135_ sky130_fd_sc_hd__a21oi_1
X_2199_ net146 net148 net149 _0443_ VSS VSS VDD VDD _0450_
+ sky130_fd_sc_hd__nand4_1
X_2200_ _0411_ _0424_ _0450_ net150 VSS VSS VDD VDD _0451_
+ sky130_fd_sc_hd__o31ai_1
X_2201_ net150 _0410_ _0423_ _0450_ VSS VSS VDD VDD _0452_
+ sky130_fd_sc_hd__or4_1
X_2202_ _0451_ _0452_ _0436_ VSS VSS VDD VDD _0136_ sky130_fd_sc_hd__a21oi_1
X_2203_ _1216_ net151 VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__nor2b_1
X_2204_ _1478_ net151 VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__nor2_1
X_2205_ net150 VSS VSS VDD VDD _0455_ sky130_fd_sc_hd__inv_1
X_2206_ _0455_ _0416_ _0424_ _0450_ VSS VSS VDD VDD _0456_
+ sky130_fd_sc_hd__nor4_1
X_2207_ _0453_ _0454_ _0456_ VSS VSS VDD VDD _0137_ sky130_fd_sc_hd__mux2_1
X_2208_ prev_event_inc\[7\] net12 net4 VSS VSS VDD VDD _0457_
+ sky130_fd_sc_hd__nand3b_4
X_2209_ net152 _0457_ VSS VSS VDD VDD _0458_ sky130_fd_sc_hd__xor2_1
X_2210_ _0366_ _0458_ VSS VSS VDD VDD _0138_ sky130_fd_sc_hd__nor2_1
X_2211_ _1543_ net153 _0457_ VSS VSS VDD VDD _0459_ sky130_fd_sc_hd__mux2i_1
X_2212_ _0366_ _0459_ VSS VSS VDD VDD _0139_ sky130_fd_sc_hd__nor2_1
X_2213_ prev_event_inc\[7\] _1542_ net4 net12 VSS VSS VDD
+ VDD _0460_ sky130_fd_sc_hd__and4b_1
X_2214_ _0460_ VSS VSS VDD VDD _0461_ sky130_fd_sc_hd__clkbuf_4
X_2215_ net154 _0461_ VSS VSS VDD VDD _0462_ sky130_fd_sc_hd__xnor2_1
X_2216_ _0366_ _0462_ VSS VSS VDD VDD _0140_ sky130_fd_sc_hd__nor2_1
X_2217_ net154 VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__inv_1
X_2218_ net152 net153 VSS VSS VDD VDD _0464_ sky130_fd_sc_hd__nand2_2
X_2219_ _0463_ _0457_ _0464_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__nor3_1
X_2220_ net155 _0465_ VSS VSS VDD VDD _0466_ sky130_fd_sc_hd__xnor2_1
X_2221_ _0366_ _0466_ VSS VSS VDD VDD _0141_ sky130_fd_sc_hd__nor2_1
X_2222_ net154 net155 _0461_ VSS VSS VDD VDD _0467_ sky130_fd_sc_hd__nand3_1
X_2223_ net156 _0467_ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__xor2_1
X_2224_ _0366_ _0468_ VSS VSS VDD VDD _0142_ sky130_fd_sc_hd__nor2_1
X_2225_ net154 net155 net156 VSS VSS VDD VDD _0469_ sky130_fd_sc_hd__nand3_2
X_2226_ _0457_ _0464_ _0469_ VSS VSS VDD VDD _0470_ sky130_fd_sc_hd__nor3_1
X_2227_ net157 _0470_ VSS VSS VDD VDD _0471_ sky130_fd_sc_hd__xnor2_1
X_2228_ _0366_ _0471_ VSS VSS VDD VDD _0143_ sky130_fd_sc_hd__nor2_1
X_2229_ net136 net147 _0283_ _0398_ VSS VSS VDD VDD _0472_
+ sky130_fd_sc_hd__nand4_1
X_2230_ _1266_ _1352_ _0472_ net158 VSS VSS VDD VDD _0473_
+ sky130_fd_sc_hd__o31ai_1
X_2231_ net158 _1354_ _1351_ _0472_ VSS VSS VDD VDD _0474_
+ sky130_fd_sc_hd__or4_1
X_2232_ _0473_ _0474_ _0436_ VSS VSS VDD VDD _0144_ sky130_fd_sc_hd__a21oi_1
X_2233_ net154 net155 net156 VSS VSS VDD VDD _0475_ sky130_fd_sc_hd__and3_1
X_2234_ _0475_ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__clkbuf_2
X_2235_ net157 _0461_ _0476_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__nand3_1
X_2236_ net159 _0477_ VSS VSS VDD VDD _0478_ sky130_fd_sc_hd__xor2_1
X_2237_ _0366_ _0478_ VSS VSS VDD VDD _0145_ sky130_fd_sc_hd__nor2_1
X_2238_ _1287_ VSS VSS VDD VDD _0479_ sky130_fd_sc_hd__buf_4
X_2239_ net157 net159 VSS VSS VDD VDD _0480_ sky130_fd_sc_hd__nand2_1
X_2240_ _0457_ _0464_ _0469_ _0480_ VSS VSS VDD VDD _0481_
+ sky130_fd_sc_hd__nor4_1
X_2241_ net160 _0481_ VSS VSS VDD VDD _0482_ sky130_fd_sc_hd__xnor2_1
X_2242_ _0479_ _0482_ VSS VSS VDD VDD _0146_ sky130_fd_sc_hd__nor2_1
X_2243_ net157 net159 net160 VSS VSS VDD VDD _0483_ sky130_fd_sc_hd__and3_1
X_2244_ _0461_ _0476_ _0483_ VSS VSS VDD VDD _0484_ sky130_fd_sc_hd__nand3_1
X_2245_ net161 _0484_ VSS VSS VDD VDD _0485_ sky130_fd_sc_hd__xor2_1
X_2246_ _0479_ _0485_ VSS VSS VDD VDD _0147_ sky130_fd_sc_hd__nor2_1
X_2247_ net157 net159 net160 net161 VSS VSS VDD VDD _0486_
+ sky130_fd_sc_hd__nand4_1
X_2248_ _0457_ _0464_ _0469_ _0486_ VSS VSS VDD VDD _0487_
+ sky130_fd_sc_hd__nor4_1
X_2249_ net162 _0487_ VSS VSS VDD VDD _0488_ sky130_fd_sc_hd__xnor2_1
X_2250_ _0479_ _0488_ VSS VSS VDD VDD _0148_ sky130_fd_sc_hd__nor2_1
X_2251_ net157 net159 net160 net161 VSS VSS VDD VDD _0489_
+ sky130_fd_sc_hd__and4_1
X_2252_ net162 _0461_ _0476_ _0489_ VSS VSS VDD VDD _0490_
+ sky130_fd_sc_hd__nand4_1
X_2253_ net163 _0490_ VSS VSS VDD VDD _0491_ sky130_fd_sc_hd__xor2_1
X_2254_ _0479_ _0491_ VSS VSS VDD VDD _0149_ sky130_fd_sc_hd__nor2_1
X_2255_ _0457_ _0464_ VSS VSS VDD VDD _0492_ sky130_fd_sc_hd__or2_1
X_2256_ net162 net163 _0489_ VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__nand3_2
X_2257_ _0492_ _0469_ _0493_ net164 VSS VSS VDD VDD _0494_
+ sky130_fd_sc_hd__o31ai_1
X_2258_ net164 _0492_ _0469_ _0493_ VSS VSS VDD VDD _0495_
+ sky130_fd_sc_hd__or4_1
X_2259_ _0494_ _0495_ _0436_ VSS VSS VDD VDD _0150_ sky130_fd_sc_hd__a21oi_1
X_2260_ net164 _0461_ _0476_ VSS VSS VDD VDD _0496_ sky130_fd_sc_hd__nand3_1
X_2261_ _0493_ _0496_ net165 VSS VSS VDD VDD _0497_ sky130_fd_sc_hd__o21ai_0
X_2262_ net165 _0493_ _0496_ VSS VSS VDD VDD _0498_ sky130_fd_sc_hd__or3_1
X_2263_ _0497_ _0498_ _0436_ VSS VSS VDD VDD _0151_ sky130_fd_sc_hd__a21oi_1
X_2264_ net164 net165 VSS VSS VDD VDD _0499_ sky130_fd_sc_hd__and2_0
X_2265_ _0476_ _0499_ VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__nand2_1
X_2266_ _0492_ _0493_ _0500_ net166 VSS VSS VDD VDD _0501_
+ sky130_fd_sc_hd__o31ai_1
X_2267_ net166 _0492_ _0493_ _0500_ VSS VSS VDD VDD _0502_
+ sky130_fd_sc_hd__or4_1
X_2268_ _0501_ _0502_ _0436_ VSS VSS VDD VDD _0152_ sky130_fd_sc_hd__a21oi_1
X_2269_ net166 _0461_ VSS VSS VDD VDD _0503_ sky130_fd_sc_hd__nand2_1
X_2270_ _0493_ _0500_ _0503_ net167 VSS VSS VDD VDD _0504_
+ sky130_fd_sc_hd__o31ai_1
X_2271_ net167 _0493_ _0500_ _0503_ VSS VSS VDD VDD _0505_
+ sky130_fd_sc_hd__or4_1
X_2272_ _1254_ VSS VSS VDD VDD _0506_ sky130_fd_sc_hd__buf_2
X_2273_ _0504_ _0505_ _0506_ VSS VSS VDD VDD _0153_ sky130_fd_sc_hd__a21oi_1
X_2274_ net162 _0476_ _0489_ _0499_ VSS VSS VDD VDD _0507_
+ sky130_fd_sc_hd__nand4_1
X_2275_ _0507_ VSS VSS VDD VDD _0508_ sky130_fd_sc_hd__clkbuf_2
X_2276_ net163 net166 net167 VSS VSS VDD VDD _0509_ sky130_fd_sc_hd__nand3_1
X_2277_ _0492_ _0508_ _0509_ net168 VSS VSS VDD VDD _0510_
+ sky130_fd_sc_hd__o31ai_1
X_2278_ net168 _0492_ _0508_ _0509_ VSS VSS VDD VDD _0511_
+ sky130_fd_sc_hd__or4_1
X_2279_ _0510_ _0511_ _0506_ VSS VSS VDD VDD _0154_ sky130_fd_sc_hd__a21oi_1
X_2280_ _1216_ net169 VSS VSS VDD VDD _0512_ sky130_fd_sc_hd__nor2b_1
X_2281_ _1478_ net169 VSS VSS VDD VDD _0513_ sky130_fd_sc_hd__nor2_1
X_2282_ net158 VSS VSS VDD VDD _0514_ sky130_fd_sc_hd__inv_1
X_2283_ _0514_ _1398_ _0472_ VSS VSS VDD VDD _0515_ sky130_fd_sc_hd__nor3_1
X_2284_ _0512_ _0513_ _0515_ VSS VSS VDD VDD _0155_ sky130_fd_sc_hd__mux2_1
X_2285_ net163 net166 net167 VSS VSS VDD VDD _0516_ sky130_fd_sc_hd__and3_1
X_2286_ net168 _0461_ _0516_ VSS VSS VDD VDD _0517_ sky130_fd_sc_hd__nand3_4
X_2287_ _0517_ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__buf_2
X_2288_ _0508_ _0518_ net170 VSS VSS VDD VDD _0519_ sky130_fd_sc_hd__o21ai_0
X_2289_ net170 _0508_ _0518_ VSS VSS VDD VDD _0520_ sky130_fd_sc_hd__or3_1
X_2290_ _0519_ _0520_ _0506_ VSS VSS VDD VDD _0156_ sky130_fd_sc_hd__a21oi_1
X_2291_ net170 VSS VSS VDD VDD _0521_ sky130_fd_sc_hd__inv_1
X_2292_ net168 VSS VSS VDD VDD _0522_ sky130_fd_sc_hd__inv_1
X_2293_ _0522_ _0457_ _0464_ _0509_ VSS VSS VDD VDD _0523_
+ sky130_fd_sc_hd__or4_4
X_2294_ _0523_ VSS VSS VDD VDD _0524_ sky130_fd_sc_hd__buf_2
X_2295_ _0521_ _0508_ _0524_ net171 VSS VSS VDD VDD _0525_
+ sky130_fd_sc_hd__o31ai_1
X_2296_ _0521_ net171 _0508_ _0524_ VSS VSS VDD VDD _0526_
+ sky130_fd_sc_hd__or4_1
X_2297_ _0525_ _0526_ _0506_ VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__a21oi_1
X_2298_ net170 net171 VSS VSS VDD VDD _0527_ sky130_fd_sc_hd__nand2_1
X_2299_ _0508_ _0518_ _0527_ net172 VSS VSS VDD VDD _0528_
+ sky130_fd_sc_hd__o31ai_1
X_2300_ net172 _0508_ _0518_ _0527_ VSS VSS VDD VDD _0529_
+ sky130_fd_sc_hd__or4_1
X_2301_ _0528_ _0529_ _0506_ VSS VSS VDD VDD _0158_ sky130_fd_sc_hd__a21oi_1
X_2302_ net170 net171 net172 VSS VSS VDD VDD _0530_ sky130_fd_sc_hd__nand3_1
X_2303_ _0508_ _0524_ _0530_ net173 VSS VSS VDD VDD _0531_
+ sky130_fd_sc_hd__o31ai_1
X_2304_ net173 _0507_ _0523_ _0530_ VSS VSS VDD VDD _0532_
+ sky130_fd_sc_hd__or4_1
X_2305_ _0531_ _0532_ _0506_ VSS VSS VDD VDD _0159_ sky130_fd_sc_hd__a21oi_1
X_2306_ net170 net171 net172 net173 VSS VSS VDD VDD _0533_
+ sky130_fd_sc_hd__nand4_1
X_2307_ _0508_ _0518_ _0533_ net174 VSS VSS VDD VDD _0534_
+ sky130_fd_sc_hd__o31ai_1
X_2308_ net174 _0507_ _0517_ _0533_ VSS VSS VDD VDD _0535_
+ sky130_fd_sc_hd__or4_1
X_2309_ _0534_ _0535_ _0506_ VSS VSS VDD VDD _0160_ sky130_fd_sc_hd__a21oi_1
X_2310_ net162 net164 net165 net174 VSS VSS VDD VDD _0536_
+ sky130_fd_sc_hd__nand4_1
X_2311_ _0469_ _0486_ _0533_ _0536_ VSS VSS VDD VDD _0537_
+ sky130_fd_sc_hd__or4_1
X_2312_ _0537_ VSS VSS VDD VDD _0538_ sky130_fd_sc_hd__clkbuf_2
X_2313_ _0538_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__buf_2
X_2314_ _0524_ _0539_ net175 VSS VSS VDD VDD _0540_ sky130_fd_sc_hd__o21ai_0
X_2315_ net175 _0524_ _0538_ VSS VSS VDD VDD _0541_ sky130_fd_sc_hd__or3_1
X_2316_ _0540_ _0541_ _0506_ VSS VSS VDD VDD _0161_ sky130_fd_sc_hd__a21oi_1
X_2317_ net175 VSS VSS VDD VDD _0542_ sky130_fd_sc_hd__inv_1
X_2318_ _0542_ _0518_ _0539_ net176 VSS VSS VDD VDD _0543_
+ sky130_fd_sc_hd__o31ai_1
X_2319_ _0542_ net176 _0517_ _0538_ VSS VSS VDD VDD _0544_
+ sky130_fd_sc_hd__or4_1
X_2320_ _0543_ _0544_ _0506_ VSS VSS VDD VDD _0162_ sky130_fd_sc_hd__a21oi_1
X_2321_ net175 net176 VSS VSS VDD VDD _0545_ sky130_fd_sc_hd__nand2_1
X_2322_ _0524_ _0539_ _0545_ net177 VSS VSS VDD VDD _0546_
+ sky130_fd_sc_hd__o31ai_1
X_2323_ net177 _0523_ _0538_ _0545_ VSS VSS VDD VDD _0547_
+ sky130_fd_sc_hd__or4_1
X_2324_ _0546_ _0547_ _0506_ VSS VSS VDD VDD _0163_ sky130_fd_sc_hd__a21oi_1
X_2325_ net175 net176 net177 VSS VSS VDD VDD _0548_ sky130_fd_sc_hd__nand3_1
X_2326_ _0518_ _0539_ _0548_ net178 VSS VSS VDD VDD _0549_
+ sky130_fd_sc_hd__o31ai_1
X_2327_ net178 _0517_ _0538_ _0548_ VSS VSS VDD VDD _0550_
+ sky130_fd_sc_hd__or4_1
X_2328_ _1254_ VSS VSS VDD VDD _0551_ sky130_fd_sc_hd__clkbuf_4
X_2329_ _0549_ _0550_ _0551_ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__a21oi_1
X_2330_ _1216_ net179 VSS VSS VDD VDD _0552_ sky130_fd_sc_hd__nor2b_1
X_2331_ _1478_ net179 VSS VSS VDD VDD _0553_ sky130_fd_sc_hd__nor2_1
X_2332_ net175 net176 net177 net178 VSS VSS VDD VDD _0554_
+ sky130_fd_sc_hd__and4_1
X_2333_ _0554_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__clkbuf_2
X_2334_ _0524_ _0538_ _0555_ VSS VSS VDD VDD _0556_ sky130_fd_sc_hd__nor3b_1
X_2335_ _0552_ _0553_ _0556_ VSS VSS VDD VDD _0165_ sky130_fd_sc_hd__mux2_1
X_2336_ net136 net147 net158 net169 VSS VSS VDD VDD _0557_
+ sky130_fd_sc_hd__and4_1
X_2337_ _0283_ _0398_ _0557_ VSS VSS VDD VDD _0558_ sky130_fd_sc_hd__nand3_1
X_2338_ _1266_ _1352_ _0558_ net180 VSS VSS VDD VDD _0559_
+ sky130_fd_sc_hd__o31ai_1
X_2339_ net180 _1354_ _1351_ _0558_ VSS VSS VDD VDD _0560_
+ sky130_fd_sc_hd__or4_1
X_2340_ _0559_ _0560_ _0551_ VSS VSS VDD VDD _0166_ sky130_fd_sc_hd__a21oi_1
X_2341_ net179 _0555_ VSS VSS VDD VDD _0561_ sky130_fd_sc_hd__nand2_1
X_2342_ _0518_ _0539_ _0561_ net181 VSS VSS VDD VDD _0562_
+ sky130_fd_sc_hd__o31ai_1
X_2343_ net181 _0517_ _0538_ _0561_ VSS VSS VDD VDD _0563_
+ sky130_fd_sc_hd__or4_1
X_2344_ _0562_ _0563_ _0551_ VSS VSS VDD VDD _0167_ sky130_fd_sc_hd__a21oi_1
X_2345_ net179 net181 _0555_ VSS VSS VDD VDD _0564_ sky130_fd_sc_hd__nand3_1
X_2346_ _0524_ _0539_ _0564_ net182 VSS VSS VDD VDD _0565_
+ sky130_fd_sc_hd__o31ai_1
X_2347_ net182 _0523_ _0538_ _0564_ VSS VSS VDD VDD _0566_
+ sky130_fd_sc_hd__or4_1
X_2348_ _0565_ _0566_ _0551_ VSS VSS VDD VDD _0168_ sky130_fd_sc_hd__a21oi_1
X_2349_ net179 net181 net182 _0555_ VSS VSS VDD VDD _0567_
+ sky130_fd_sc_hd__nand4_1
X_2350_ _0518_ _0539_ _0567_ net183 VSS VSS VDD VDD _0568_
+ sky130_fd_sc_hd__o31ai_1
X_2351_ net183 _0517_ _0538_ _0567_ VSS VSS VDD VDD _0569_
+ sky130_fd_sc_hd__or4_1
X_2352_ _0568_ _0569_ _0551_ VSS VSS VDD VDD _0169_ sky130_fd_sc_hd__a21oi_1
X_2353_ net179 net181 net182 net183 VSS VSS VDD VDD _0570_
+ sky130_fd_sc_hd__and4_1
X_2354_ _0555_ _0570_ VSS VSS VDD VDD _0571_ sky130_fd_sc_hd__nand2_1
X_2355_ _0524_ _0539_ _0571_ net184 VSS VSS VDD VDD _0572_
+ sky130_fd_sc_hd__o31ai_1
X_2356_ net184 _0523_ _0538_ _0571_ VSS VSS VDD VDD _0573_
+ sky130_fd_sc_hd__or4_1
X_2357_ _0572_ _0573_ _0551_ VSS VSS VDD VDD _0170_ sky130_fd_sc_hd__a21oi_1
X_2358_ net184 _0555_ _0570_ VSS VSS VDD VDD _0574_ sky130_fd_sc_hd__nand3_1
X_2359_ _0518_ _0539_ _0574_ net185 VSS VSS VDD VDD _0575_
+ sky130_fd_sc_hd__o31ai_1
X_2360_ net185 _0517_ _0537_ _0574_ VSS VSS VDD VDD _0576_
+ sky130_fd_sc_hd__or4_1
X_2361_ _0575_ _0576_ _0551_ VSS VSS VDD VDD _0171_ sky130_fd_sc_hd__a21oi_1
X_2362_ net184 net185 _0555_ _0570_ VSS VSS VDD VDD _0577_
+ sky130_fd_sc_hd__nand4_1
X_2363_ _0524_ _0539_ _0577_ net186 VSS VSS VDD VDD _0578_
+ sky130_fd_sc_hd__o31ai_1
X_2364_ net186 _0523_ _0537_ _0577_ VSS VSS VDD VDD _0579_
+ sky130_fd_sc_hd__or4_1
X_2365_ _0578_ _0579_ _0551_ VSS VSS VDD VDD _0172_ sky130_fd_sc_hd__a21oi_1
X_2366_ net180 VSS VSS VDD VDD _0580_ sky130_fd_sc_hd__inv_1
X_2367_ _0580_ _1399_ _0558_ net187 VSS VSS VDD VDD _0581_
+ sky130_fd_sc_hd__o31ai_1
X_2368_ _0580_ net187 _1398_ _0558_ VSS VSS VDD VDD _0582_
+ sky130_fd_sc_hd__or4_1
X_2369_ _0581_ _0582_ _0551_ VSS VSS VDD VDD _0173_ sky130_fd_sc_hd__a21oi_1
X_2370_ net180 net187 VSS VSS VDD VDD _0583_ sky130_fd_sc_hd__and2_0
X_2371_ _0283_ _0398_ _0557_ _0583_ VSS VSS VDD VDD _0584_
+ sky130_fd_sc_hd__nand4_4
X_2372_ _1266_ _1352_ _0584_ net188 VSS VSS VDD VDD _0585_
+ sky130_fd_sc_hd__o31ai_1
X_2373_ net188 _1354_ _1351_ _0584_ VSS VSS VDD VDD _0586_
+ sky130_fd_sc_hd__or4_1
X_2374_ _0585_ _0586_ _0551_ VSS VSS VDD VDD _0174_ sky130_fd_sc_hd__a21oi_1
X_2375_ net188 VSS VSS VDD VDD _0587_ sky130_fd_sc_hd__inv_1
X_2376_ _0587_ _1399_ _0584_ net189 VSS VSS VDD VDD _0588_
+ sky130_fd_sc_hd__o31ai_1
X_2377_ _0587_ net189 _1398_ _0584_ VSS VSS VDD VDD _0589_
+ sky130_fd_sc_hd__or4_1
X_2378_ _1254_ VSS VSS VDD VDD _0590_ sky130_fd_sc_hd__buf_2
X_2379_ _0588_ _0589_ _0590_ VSS VSS VDD VDD _0175_ sky130_fd_sc_hd__a21oi_1
X_2380_ _1216_ net190 VSS VSS VDD VDD _0591_ sky130_fd_sc_hd__nor2b_1
X_2381_ _1478_ net190 VSS VSS VDD VDD _0592_ sky130_fd_sc_hd__nor2_1
X_2382_ net188 net189 VSS VSS VDD VDD _0593_ sky130_fd_sc_hd__nand2_1
X_2383_ _1354_ _1352_ _0584_ _0593_ VSS VSS VDD VDD _0594_
+ sky130_fd_sc_hd__nor4_1
X_2384_ _0591_ _0592_ _0594_ VSS VSS VDD VDD _0176_ sky130_fd_sc_hd__mux2_1
X_2385_ net188 net189 net190 VSS VSS VDD VDD _0595_ sky130_fd_sc_hd__nand3_1
X_2386_ _1399_ _0584_ _0595_ net191 VSS VSS VDD VDD _0596_
+ sky130_fd_sc_hd__o31ai_1
X_2387_ net191 _1398_ _0584_ _0595_ VSS VSS VDD VDD _0597_
+ sky130_fd_sc_hd__or4_1
X_2388_ _0596_ _0597_ _0590_ VSS VSS VDD VDD _0177_ sky130_fd_sc_hd__a21oi_1
X_2389_ _1540_ _1221_ VSS VSS VDD VDD _0598_ sky130_fd_sc_hd__nand2_1
X_2390_ net192 _0598_ VSS VSS VDD VDD _0599_ sky130_fd_sc_hd__xor2_1
X_2391_ _0479_ _0599_ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__nor2_1
X_2392_ net193 VSS VSS VDD VDD _0600_ sky130_fd_sc_hd__inv_1
X_2393_ _1478_ _0600_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__nor2_1
X_2394_ _1478_ net193 VSS VSS VDD VDD _0602_ sky130_fd_sc_hd__nor2_1
X_2395_ net188 net189 net190 net191 VSS VSS VDD VDD _0603_
+ sky130_fd_sc_hd__nand4_1
X_2396_ _1354_ _1351_ _0584_ _0603_ VSS VSS VDD VDD _0604_
+ sky130_fd_sc_hd__nor4_1
X_2397_ _0601_ _0602_ _0604_ VSS VSS VDD VDD _0179_ sky130_fd_sc_hd__mux2_1
X_2398_ _1216_ net194 VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__nor2b_1
X_2399_ _1478_ net194 VSS VSS VDD VDD _0606_ sky130_fd_sc_hd__nor2_1
X_2400_ _0600_ _1398_ _0584_ _0603_ VSS VSS VDD VDD _0607_
+ sky130_fd_sc_hd__nor4_1
X_2401_ _0605_ _0606_ _0607_ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__mux2_1
X_2402_ prev_event_inc\[1\] net6 _1220_ VSS VSS VDD VDD _0608_
+ sky130_fd_sc_hd__and3b_1
X_2403_ net195 _0608_ VSS VSS VDD VDD _0609_ sky130_fd_sc_hd__xnor2_1
X_2404_ _0479_ _0609_ VSS VSS VDD VDD _0181_ sky130_fd_sc_hd__nor2_1
X_2405_ net196 _1539_ _0608_ VSS VSS VDD VDD _0610_ sky130_fd_sc_hd__mux2i_1
X_2406_ _0479_ _0610_ VSS VSS VDD VDD _0182_ sky130_fd_sc_hd__nor2_1
X_2407_ _1538_ _0608_ VSS VSS VDD VDD _0611_ sky130_fd_sc_hd__nand2_1
X_2408_ net197 _0611_ VSS VSS VDD VDD _0612_ sky130_fd_sc_hd__xor2_1
X_2409_ _0479_ _0612_ VSS VSS VDD VDD _0183_ sky130_fd_sc_hd__nor2_1
X_2410_ prev_event_inc\[1\] net197 _1219_ net6 VSS VSS VDD
+ VDD _0613_ sky130_fd_sc_hd__and4b_1
X_2411_ _0613_ VSS VSS VDD VDD _0614_ sky130_fd_sc_hd__clkbuf_4
X_2412_ net195 net196 _0614_ VSS VSS VDD VDD _0615_ sky130_fd_sc_hd__nand3_1
X_2413_ net198 _0615_ VSS VSS VDD VDD _0616_ sky130_fd_sc_hd__xor2_1
X_2414_ _0479_ _0616_ VSS VSS VDD VDD _0184_ sky130_fd_sc_hd__nor2_1
X_2415_ _1538_ net198 _0614_ VSS VSS VDD VDD _0617_ sky130_fd_sc_hd__nand3_1
X_2416_ net199 _0617_ VSS VSS VDD VDD _0618_ sky130_fd_sc_hd__xor2_1
X_2417_ _0479_ _0618_ VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__nor2_1
X_2418_ _1287_ VSS VSS VDD VDD _0619_ sky130_fd_sc_hd__buf_4
X_2419_ net195 net196 net199 VSS VSS VDD VDD _0620_ sky130_fd_sc_hd__and3_1
X_2420_ net198 _0614_ _0620_ VSS VSS VDD VDD _0621_ sky130_fd_sc_hd__nand3_1
X_2421_ net200 _0621_ VSS VSS VDD VDD _0622_ sky130_fd_sc_hd__xor2_1
X_2422_ _0619_ _0622_ VSS VSS VDD VDD _0186_ sky130_fd_sc_hd__nor2_1
X_2423_ _1538_ net198 net199 VSS VSS VDD VDD _0623_ sky130_fd_sc_hd__and3_1
X_2424_ _0623_ VSS VSS VDD VDD _0624_ sky130_fd_sc_hd__clkbuf_2
X_2425_ net200 _0614_ _0624_ VSS VSS VDD VDD _0625_ sky130_fd_sc_hd__nand3_1
X_2426_ net201 _0625_ VSS VSS VDD VDD _0626_ sky130_fd_sc_hd__xor2_1
X_2427_ _0619_ _0626_ VSS VSS VDD VDD _0187_ sky130_fd_sc_hd__nor2_1
X_2428_ net195 net196 net198 net199 VSS VSS VDD VDD _0627_
+ sky130_fd_sc_hd__and4_1
X_2429_ net200 net201 _0614_ _0627_ VSS VSS VDD VDD _0628_
+ sky130_fd_sc_hd__nand4_1
X_2430_ net202 _0628_ VSS VSS VDD VDD _0629_ sky130_fd_sc_hd__xor2_1
X_2431_ _0619_ _0629_ VSS VSS VDD VDD _0188_ sky130_fd_sc_hd__nor2_1
X_2432_ net203 _1315_ VSS VSS VDD VDD _0630_ sky130_fd_sc_hd__xor2_1
X_2433_ _0619_ _0630_ VSS VSS VDD VDD _0189_ sky130_fd_sc_hd__nor2_1
X_2434_ net200 net201 net202 VSS VSS VDD VDD _0631_ sky130_fd_sc_hd__and3_1
X_2435_ _0614_ _0624_ _0631_ VSS VSS VDD VDD _0632_ sky130_fd_sc_hd__nand3_1
X_2436_ net204 _0632_ VSS VSS VDD VDD _0633_ sky130_fd_sc_hd__xor2_1
X_2437_ _0619_ _0633_ VSS VSS VDD VDD _0190_ sky130_fd_sc_hd__nor2_1
X_2438_ prev_event_inc\[1\] net199 _1219_ net6 VSS VSS VDD
+ VDD _0634_ sky130_fd_sc_hd__and4b_1
X_2439_ net195 net197 net196 net198 VSS VSS VDD VDD _0635_
+ sky130_fd_sc_hd__and4_1
X_2440_ net200 net201 net202 net204 VSS VSS VDD VDD _0636_
+ sky130_fd_sc_hd__and4_2
X_2441_ _0634_ _0635_ _0636_ VSS VSS VDD VDD _0637_ sky130_fd_sc_hd__nand3_1
X_2442_ net205 _0637_ VSS VSS VDD VDD _0638_ sky130_fd_sc_hd__xnor2_1
X_2443_ _1217_ _0638_ VSS VSS VDD VDD _0191_ sky130_fd_sc_hd__nor2b_1
X_2444_ net205 _0614_ _0624_ _0636_ VSS VSS VDD VDD _0639_
+ sky130_fd_sc_hd__nand4_1
X_2445_ net206 _0639_ VSS VSS VDD VDD _0640_ sky130_fd_sc_hd__xor2_1
X_2446_ _0619_ _0640_ VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__nor2_1
X_2447_ net207 VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__inv_1
X_2448_ net205 net206 VSS VSS VDD VDD _0642_ sky130_fd_sc_hd__and2_1
X_2449_ _0614_ _0627_ _0636_ _0642_ VSS VSS VDD VDD _0643_
+ sky130_fd_sc_hd__nand4_4
X_2450_ _0641_ _0643_ VSS VSS VDD VDD _0644_ sky130_fd_sc_hd__xnor2_1
X_2451_ _0619_ _0644_ VSS VSS VDD VDD _0193_ sky130_fd_sc_hd__nor2_1
X_2452_ _0614_ _0624_ VSS VSS VDD VDD _0645_ sky130_fd_sc_hd__nand2_2
X_2453_ _0636_ _0642_ VSS VSS VDD VDD _0646_ sky130_fd_sc_hd__nand2_1
X_2454_ _0641_ _0645_ _0646_ net208 VSS VSS VDD VDD _0647_
+ sky130_fd_sc_hd__o31ai_1
X_2455_ _0641_ net208 _0645_ _0646_ VSS VSS VDD VDD _0648_
+ sky130_fd_sc_hd__or4_1
X_2456_ _0647_ _0648_ _0590_ VSS VSS VDD VDD _0194_ sky130_fd_sc_hd__a21oi_1
X_2457_ net207 net208 VSS VSS VDD VDD _0649_ sky130_fd_sc_hd__nand2_1
X_2458_ _0643_ _0649_ net209 VSS VSS VDD VDD _0650_ sky130_fd_sc_hd__o21ai_0
X_2459_ net209 _0643_ _0649_ VSS VSS VDD VDD _0651_ sky130_fd_sc_hd__or3_1
X_2460_ _0650_ _0651_ _0590_ VSS VSS VDD VDD _0195_ sky130_fd_sc_hd__a21oi_1
X_2461_ net207 net208 net209 VSS VSS VDD VDD _0652_ sky130_fd_sc_hd__nand3_1
X_2462_ _0645_ _0646_ _0652_ net210 VSS VSS VDD VDD _0653_
+ sky130_fd_sc_hd__o31ai_1
X_2463_ net210 _0645_ _0646_ _0652_ VSS VSS VDD VDD _0654_
+ sky130_fd_sc_hd__or4_1
X_2464_ _0653_ _0654_ _0590_ VSS VSS VDD VDD _0196_ sky130_fd_sc_hd__a21oi_1
X_2465_ net207 net208 net209 net210 VSS VSS VDD VDD _0655_
+ sky130_fd_sc_hd__nand4_1
X_2466_ _0643_ _0655_ net211 VSS VSS VDD VDD _0656_ sky130_fd_sc_hd__o21ai_0
X_2467_ net211 _0643_ _0655_ VSS VSS VDD VDD _0657_ sky130_fd_sc_hd__or3_1
X_2468_ _0656_ _0657_ _0590_ VSS VSS VDD VDD _0197_ sky130_fd_sc_hd__a21oi_1
X_2469_ net207 net208 net209 net210 VSS VSS VDD VDD _0658_
+ sky130_fd_sc_hd__and4_1
X_2470_ net211 _0658_ VSS VSS VDD VDD _0659_ sky130_fd_sc_hd__nand2_1
X_2471_ _0645_ _0646_ _0659_ net212 VSS VSS VDD VDD _0660_
+ sky130_fd_sc_hd__o31ai_1
X_2472_ net212 _0645_ _0646_ _0659_ VSS VSS VDD VDD _0661_
+ sky130_fd_sc_hd__or4_1
X_2473_ _0660_ _0661_ _0590_ VSS VSS VDD VDD _0198_ sky130_fd_sc_hd__a21oi_1
X_2474_ net211 net212 VSS VSS VDD VDD _0662_ sky130_fd_sc_hd__and2_0
X_2475_ _0658_ _0662_ VSS VSS VDD VDD _0663_ sky130_fd_sc_hd__nand2_1
X_2476_ _0643_ _0663_ net213 VSS VSS VDD VDD _0664_ sky130_fd_sc_hd__o21ai_0
X_2477_ net213 _0643_ _0663_ VSS VSS VDD VDD _0665_ sky130_fd_sc_hd__or3_1
X_2478_ _0664_ _0665_ _0590_ VSS VSS VDD VDD _0199_ sky130_fd_sc_hd__a21oi_1
X_2479_ _1540_ net203 _1314_ VSS VSS VDD VDD _0666_ sky130_fd_sc_hd__nand3_1
X_2480_ net214 _0666_ VSS VSS VDD VDD _0667_ sky130_fd_sc_hd__xor2_1
X_2481_ _0619_ _0667_ VSS VSS VDD VDD _0200_ sky130_fd_sc_hd__nor2_1
X_2482_ net213 VSS VSS VDD VDD _0668_ sky130_fd_sc_hd__inv_1
X_2483_ _0636_ _0642_ _0658_ _0662_ VSS VSS VDD VDD _0669_
+ sky130_fd_sc_hd__nand4_4
X_2484_ _0669_ VSS VSS VDD VDD _0670_ sky130_fd_sc_hd__buf_2
X_2485_ _0670_ VSS VSS VDD VDD _0671_ sky130_fd_sc_hd__buf_2
X_2486_ _0668_ _0645_ _0671_ net215 VSS VSS VDD VDD _0672_
+ sky130_fd_sc_hd__o31ai_1
X_2487_ _0668_ net215 _0645_ _0670_ VSS VSS VDD VDD _0673_
+ sky130_fd_sc_hd__or4_1
X_2488_ _0672_ _0673_ _0590_ VSS VSS VDD VDD _0201_ sky130_fd_sc_hd__a21oi_1
X_2489_ net213 net215 VSS VSS VDD VDD _0674_ sky130_fd_sc_hd__nand2_1
X_2490_ _0643_ _0663_ _0674_ net216 VSS VSS VDD VDD _0675_
+ sky130_fd_sc_hd__o31ai_1
X_2491_ net216 _0643_ _0663_ _0674_ VSS VSS VDD VDD _0676_
+ sky130_fd_sc_hd__or4_1
X_2492_ _0675_ _0676_ _0590_ VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__a21oi_1
X_2493_ net213 net215 net216 VSS VSS VDD VDD _0677_ sky130_fd_sc_hd__nand3_1
X_2494_ _0645_ _0671_ _0677_ net217 VSS VSS VDD VDD _0678_
+ sky130_fd_sc_hd__o31ai_1
X_2495_ net217 _0645_ _0670_ _0677_ VSS VSS VDD VDD _0679_
+ sky130_fd_sc_hd__or4_1
X_2496_ _1254_ VSS VSS VDD VDD _0680_ sky130_fd_sc_hd__buf_2
X_2497_ _0678_ _0679_ _0680_ VSS VSS VDD VDD _0203_ sky130_fd_sc_hd__a21oi_1
X_2498_ net213 net215 net216 net217 VSS VSS VDD VDD _0681_
+ sky130_fd_sc_hd__and4_2
X_2499_ _0634_ _0635_ _0681_ VSS VSS VDD VDD _0682_ sky130_fd_sc_hd__nand3_4
X_2500_ _0671_ _0682_ net218 VSS VSS VDD VDD _0683_ sky130_fd_sc_hd__o21ai_0
X_2501_ net218 _0670_ _0682_ VSS VSS VDD VDD _0684_ sky130_fd_sc_hd__or3_1
X_2502_ _0683_ _0684_ _0680_ VSS VSS VDD VDD _0204_ sky130_fd_sc_hd__a21oi_1
X_2503_ net218 VSS VSS VDD VDD _0685_ sky130_fd_sc_hd__inv_1
X_2504_ _0614_ _0624_ _0681_ VSS VSS VDD VDD _0686_ sky130_fd_sc_hd__nand3_4
X_2505_ _0685_ _0671_ _0686_ net219 VSS VSS VDD VDD _0687_
+ sky130_fd_sc_hd__o31ai_1
X_2506_ _0685_ net219 _0670_ _0686_ VSS VSS VDD VDD _0688_
+ sky130_fd_sc_hd__or4_1
X_2507_ _0687_ _0688_ _0680_ VSS VSS VDD VDD _0205_ sky130_fd_sc_hd__a21oi_1
X_2508_ net218 net219 VSS VSS VDD VDD _0689_ sky130_fd_sc_hd__nand2_1
X_2509_ _0671_ _0682_ _0689_ net220 VSS VSS VDD VDD _0690_
+ sky130_fd_sc_hd__o31ai_1
X_2510_ net220 _0670_ _0682_ _0689_ VSS VSS VDD VDD _0691_
+ sky130_fd_sc_hd__or4_1
X_2511_ _0690_ _0691_ _0680_ VSS VSS VDD VDD _0206_ sky130_fd_sc_hd__a21oi_1
X_2512_ net218 net219 net220 VSS VSS VDD VDD _0692_ sky130_fd_sc_hd__nand3_1
X_2513_ _0671_ _0686_ _0692_ net221 VSS VSS VDD VDD _0693_
+ sky130_fd_sc_hd__o31ai_1
X_2514_ net221 _0670_ _0686_ _0692_ VSS VSS VDD VDD _0694_
+ sky130_fd_sc_hd__or4_1
X_2515_ _0693_ _0694_ _0680_ VSS VSS VDD VDD _0207_ sky130_fd_sc_hd__a21oi_1
X_2516_ net222 VSS VSS VDD VDD _0695_ sky130_fd_sc_hd__buf_2
X_2517_ _1216_ _0695_ VSS VSS VDD VDD _0696_ sky130_fd_sc_hd__nor2b_1
X_2518_ _1215_ VSS VSS VDD VDD _0697_ sky130_fd_sc_hd__buf_6
X_2519_ _0697_ _0695_ VSS VSS VDD VDD _0698_ sky130_fd_sc_hd__nor2_1
X_2520_ net218 net219 net220 net221 VSS VSS VDD VDD _0699_
+ sky130_fd_sc_hd__and4_1
X_2521_ _0699_ VSS VSS VDD VDD _0700_ sky130_fd_sc_hd__clkbuf_2
X_2522_ _0670_ _0682_ _0700_ VSS VSS VDD VDD _0701_ sky130_fd_sc_hd__nor3b_1
X_2523_ _0696_ _0698_ _0701_ VSS VSS VDD VDD _0208_ sky130_fd_sc_hd__mux2_1
X_2524_ _0695_ _0700_ VSS VSS VDD VDD _0702_ sky130_fd_sc_hd__nand2_1
X_2525_ _0671_ _0686_ _0702_ net223 VSS VSS VDD VDD _0703_
+ sky130_fd_sc_hd__o31ai_1
X_2526_ net223 _0669_ _0686_ _0702_ VSS VSS VDD VDD _0704_
+ sky130_fd_sc_hd__or4_1
X_2527_ _0703_ _0704_ _0680_ VSS VSS VDD VDD _0209_ sky130_fd_sc_hd__a21oi_1
X_2528_ _0695_ net223 _0700_ VSS VSS VDD VDD _0705_ sky130_fd_sc_hd__nand3_1
X_2529_ _0671_ _0682_ _0705_ net224 VSS VSS VDD VDD _0706_
+ sky130_fd_sc_hd__o31ai_1
X_2530_ net224 _0669_ _0682_ _0705_ VSS VSS VDD VDD _0707_
+ sky130_fd_sc_hd__or4_1
X_2531_ _0706_ _0707_ _0680_ VSS VSS VDD VDD _0210_ sky130_fd_sc_hd__a21oi_1
X_2532_ net203 net214 VSS VSS VDD VDD _0708_ sky130_fd_sc_hd__nand2_1
X_2533_ net14 net125 VSS VSS VDD VDD _0709_ sky130_fd_sc_hd__nand2_1
X_2534_ _1262_ _0708_ _0709_ VSS VSS VDD VDD _0710_ sky130_fd_sc_hd__nor3_1
X_2535_ net225 _0710_ VSS VSS VDD VDD _0711_ sky130_fd_sc_hd__xnor2_1
X_2536_ _0619_ _0711_ VSS VSS VDD VDD _0211_ sky130_fd_sc_hd__nor2_1
X_2537_ _0695_ net223 net224 _0700_ VSS VSS VDD VDD _0712_
+ sky130_fd_sc_hd__nand4_1
X_2538_ _0671_ _0686_ _0712_ net226 VSS VSS VDD VDD _0713_
+ sky130_fd_sc_hd__o31ai_1
X_2539_ net226 _0669_ _0686_ _0712_ VSS VSS VDD VDD _0714_
+ sky130_fd_sc_hd__or4_1
X_2540_ _0713_ _0714_ _0680_ VSS VSS VDD VDD _0212_ sky130_fd_sc_hd__a21oi_1
X_2541_ net224 net226 VSS VSS VDD VDD _0715_ sky130_fd_sc_hd__and2_0
X_2542_ _0695_ net223 _0700_ _0715_ VSS VSS VDD VDD _0716_
+ sky130_fd_sc_hd__nand4_1
X_2543_ _0671_ _0682_ _0716_ net227 VSS VSS VDD VDD _0717_
+ sky130_fd_sc_hd__o31ai_1
X_2544_ net227 _0669_ _0682_ _0716_ VSS VSS VDD VDD _0718_
+ sky130_fd_sc_hd__or4_1
X_2545_ _0717_ _0718_ _0680_ VSS VSS VDD VDD _0213_ sky130_fd_sc_hd__a21oi_1
X_2546_ net223 net224 net226 VSS VSS VDD VDD _0719_ sky130_fd_sc_hd__and3_1
X_2547_ _0695_ net227 _0700_ _0719_ VSS VSS VDD VDD _0720_
+ sky130_fd_sc_hd__nand4_1
X_2548_ _0670_ _0686_ _0720_ net228 VSS VSS VDD VDD _0721_
+ sky130_fd_sc_hd__o31ai_1
X_2549_ net228 _0669_ _0686_ _0720_ VSS VSS VDD VDD _0722_
+ sky130_fd_sc_hd__or4_1
X_2550_ _0721_ _0722_ _0680_ VSS VSS VDD VDD _0214_ sky130_fd_sc_hd__a21oi_1
X_2551_ _1215_ net229 VSS VSS VDD VDD _0723_ sky130_fd_sc_hd__nor2b_1
X_2552_ _0697_ net229 VSS VSS VDD VDD _0724_ sky130_fd_sc_hd__nor2_1
X_2553_ net228 VSS VSS VDD VDD _0725_ sky130_fd_sc_hd__inv_1
X_2554_ _0725_ _0670_ _0682_ _0720_ VSS VSS VDD VDD _0726_
+ sky130_fd_sc_hd__nor4_1
X_2555_ _0723_ _0724_ _0726_ VSS VSS VDD VDD _0215_ sky130_fd_sc_hd__mux2_1
X_2556_ prev_event_inc\[2\] _1219_ net7 VSS VSS VDD VDD _0727_
+ sky130_fd_sc_hd__nand3b_1
X_2557_ _0727_ VSS VSS VDD VDD _0728_ sky130_fd_sc_hd__buf_2
X_2558_ net230 _0728_ VSS VSS VDD VDD _0729_ sky130_fd_sc_hd__nand2_1
X_2559_ net230 VSS VSS VDD VDD _0730_ sky130_fd_sc_hd__inv_1
X_2560_ prev_event_inc\[2\] _1219_ net7 VSS VSS VDD VDD _0731_
+ sky130_fd_sc_hd__and3b_1
X_2561_ _0730_ _0731_ VSS VSS VDD VDD _0732_ sky130_fd_sc_hd__nand2_1
X_2562_ _1254_ VSS VSS VDD VDD _0733_ sky130_fd_sc_hd__clkbuf_4
X_2563_ _0729_ _0732_ _0733_ VSS VSS VDD VDD _0216_ sky130_fd_sc_hd__a21oi_1
X_2564_ _1553_ _0731_ VSS VSS VDD VDD _0734_ sky130_fd_sc_hd__nand2_1
X_2565_ net231 _0728_ VSS VSS VDD VDD _0735_ sky130_fd_sc_hd__nand2_1
X_2566_ _0734_ _0735_ _0733_ VSS VSS VDD VDD _0217_ sky130_fd_sc_hd__a21oi_1
X_2567_ prev_event_inc\[2\] _1219_ _1552_ net7 VSS VSS VDD
+ VDD _0736_ sky130_fd_sc_hd__and4b_2
X_2568_ net232 _0736_ VSS VSS VDD VDD _0737_ sky130_fd_sc_hd__xnor2_1
X_2569_ _0619_ _0737_ VSS VSS VDD VDD _0218_ sky130_fd_sc_hd__nor2_1
X_2570_ _1287_ VSS VSS VDD VDD _0738_ sky130_fd_sc_hd__buf_4
X_2571_ net233 VSS VSS VDD VDD _0739_ sky130_fd_sc_hd__inv_1
X_2572_ net232 VSS VSS VDD VDD _0740_ sky130_fd_sc_hd__inv_1
X_2573_ net231 net230 VSS VSS VDD VDD _0741_ sky130_fd_sc_hd__nand2_1
X_2574_ _0740_ _0728_ _0741_ VSS VSS VDD VDD _0742_ sky130_fd_sc_hd__or3_1
X_2575_ _0739_ _0742_ VSS VSS VDD VDD _0743_ sky130_fd_sc_hd__xnor2_1
X_2576_ _0738_ _0743_ VSS VSS VDD VDD _0219_ sky130_fd_sc_hd__nor2_1
X_2577_ net233 net232 _1552_ VSS VSS VDD VDD _0744_ sky130_fd_sc_hd__nand3_2
X_2578_ _0728_ _0744_ net234 VSS VSS VDD VDD _0745_ sky130_fd_sc_hd__o21ai_0
X_2579_ net234 _0728_ _0744_ VSS VSS VDD VDD _0746_ sky130_fd_sc_hd__or3_1
X_2580_ _0745_ _0746_ _0733_ VSS VSS VDD VDD _0220_ sky130_fd_sc_hd__a21oi_1
X_2581_ net234 VSS VSS VDD VDD _0747_ sky130_fd_sc_hd__inv_1
X_2582_ net233 net232 net231 net230 VSS VSS VDD VDD _0748_
+ sky130_fd_sc_hd__nand4_2
X_2583_ _0747_ _0728_ _0748_ VSS VSS VDD VDD _0749_ sky130_fd_sc_hd__nor3_1
X_2584_ net235 _0749_ VSS VSS VDD VDD _0750_ sky130_fd_sc_hd__xnor2_1
X_2585_ _0738_ _0750_ VSS VSS VDD VDD _0221_ sky130_fd_sc_hd__nor2_1
X_2586_ net203 net214 net225 VSS VSS VDD VDD _0751_ sky130_fd_sc_hd__and3_1
X_2587_ _1540_ _1314_ _0751_ VSS VSS VDD VDD _0752_ sky130_fd_sc_hd__nand3_1
X_2588_ net236 _0752_ VSS VSS VDD VDD _0753_ sky130_fd_sc_hd__xor2_1
X_2589_ _0738_ _0753_ VSS VSS VDD VDD _0222_ sky130_fd_sc_hd__nor2_1
X_2590_ net235 VSS VSS VDD VDD _0754_ sky130_fd_sc_hd__inv_1
X_2591_ _0754_ _0747_ _0728_ _0744_ VSS VSS VDD VDD _0755_
+ sky130_fd_sc_hd__nor4_1
X_2592_ net237 _0755_ VSS VSS VDD VDD _0756_ sky130_fd_sc_hd__xnor2_1
X_2593_ _0738_ _0756_ VSS VSS VDD VDD _0223_ sky130_fd_sc_hd__nor2_1
X_2594_ net237 net235 net234 VSS VSS VDD VDD _0757_ sky130_fd_sc_hd__nand3_1
X_2595_ _0728_ _0748_ _0757_ VSS VSS VDD VDD _0758_ sky130_fd_sc_hd__nor3_1
X_2596_ net238 _0758_ VSS VSS VDD VDD _0759_ sky130_fd_sc_hd__xnor2_1
X_2597_ _0738_ _0759_ VSS VSS VDD VDD _0224_ sky130_fd_sc_hd__nor2_1
X_2598_ net238 VSS VSS VDD VDD _0760_ sky130_fd_sc_hd__inv_1
X_2599_ _0760_ _0728_ _0744_ _0757_ VSS VSS VDD VDD _0761_
+ sky130_fd_sc_hd__nor4_1
X_2600_ net239 _0761_ VSS VSS VDD VDD _0762_ sky130_fd_sc_hd__xnor2_1
X_2601_ _0738_ _0762_ VSS VSS VDD VDD _0225_ sky130_fd_sc_hd__nor2_1
X_2602_ net240 VSS VSS VDD VDD _0763_ sky130_fd_sc_hd__inv_1
X_2603_ net239 VSS VSS VDD VDD _0764_ sky130_fd_sc_hd__inv_1
X_2604_ net238 net237 net235 net234 VSS VSS VDD VDD _0765_
+ sky130_fd_sc_hd__and4_1
X_2605_ _0764_ _0727_ _0748_ _0765_ VSS VSS VDD VDD _0766_
+ sky130_fd_sc_hd__or4b_1
X_2606_ _0766_ VSS VSS VDD VDD _0767_ sky130_fd_sc_hd__clkbuf_2
X_2607_ _0763_ _0767_ VSS VSS VDD VDD _0768_ sky130_fd_sc_hd__xnor2_1
X_2608_ _0738_ _0768_ VSS VSS VDD VDD _0226_ sky130_fd_sc_hd__nor2_1
X_2609_ _0764_ _0728_ _0744_ _0765_ VSS VSS VDD VDD _0769_
+ sky130_fd_sc_hd__or4b_2
X_2610_ _0763_ _0769_ net241 VSS VSS VDD VDD _0770_ sky130_fd_sc_hd__o21ai_0
X_2611_ net241 _0763_ _0769_ VSS VSS VDD VDD _0771_ sky130_fd_sc_hd__or3_1
X_2612_ _0770_ _0771_ _0733_ VSS VSS VDD VDD _0227_ sky130_fd_sc_hd__a21oi_1
X_2613_ net241 net240 VSS VSS VDD VDD _0772_ sky130_fd_sc_hd__nand2_1
X_2614_ _0767_ _0772_ net242 VSS VSS VDD VDD _0773_ sky130_fd_sc_hd__o21ai_0
X_2615_ net242 _0767_ _0772_ VSS VSS VDD VDD _0774_ sky130_fd_sc_hd__or3_1
X_2616_ _0773_ _0774_ _0733_ VSS VSS VDD VDD _0228_ sky130_fd_sc_hd__a21oi_1
X_2617_ net242 net241 net240 VSS VSS VDD VDD _0775_ sky130_fd_sc_hd__nand3_1
X_2618_ _0769_ _0775_ net243 VSS VSS VDD VDD _0776_ sky130_fd_sc_hd__o21ai_0
X_2619_ net243 _0769_ _0775_ VSS VSS VDD VDD _0777_ sky130_fd_sc_hd__or3_1
X_2620_ _0776_ _0777_ _0733_ VSS VSS VDD VDD _0229_ sky130_fd_sc_hd__a21oi_1
X_2621_ net243 net242 net241 net240 VSS VSS VDD VDD _0778_
+ sky130_fd_sc_hd__nand4_1
X_2622_ _0767_ _0778_ net244 VSS VSS VDD VDD _0779_ sky130_fd_sc_hd__o21ai_0
X_2623_ net244 _0767_ _0778_ VSS VSS VDD VDD _0780_ sky130_fd_sc_hd__or3_1
X_2624_ _0779_ _0780_ _0733_ VSS VSS VDD VDD _0230_ sky130_fd_sc_hd__a21oi_1
X_2625_ net243 net242 net241 net240 VSS VSS VDD VDD _0781_
+ sky130_fd_sc_hd__and4_1
X_2626_ net244 _0781_ VSS VSS VDD VDD _0782_ sky130_fd_sc_hd__nand2_1
X_2627_ _0769_ _0782_ net245 VSS VSS VDD VDD _0783_ sky130_fd_sc_hd__o21ai_0
X_2628_ net245 _0769_ _0782_ VSS VSS VDD VDD _0784_ sky130_fd_sc_hd__or3_1
X_2629_ _0783_ _0784_ _0733_ VSS VSS VDD VDD _0231_ sky130_fd_sc_hd__a21oi_1
X_2630_ net245 net244 VSS VSS VDD VDD _0785_ sky130_fd_sc_hd__and2_0
X_2631_ _0781_ _0785_ VSS VSS VDD VDD _0786_ sky130_fd_sc_hd__nand2_1
X_2632_ _0767_ _0786_ net246 VSS VSS VDD VDD _0787_ sky130_fd_sc_hd__o21ai_0
X_2633_ net246 _0767_ _0786_ VSS VSS VDD VDD _0788_ sky130_fd_sc_hd__or3_1
X_2634_ _0787_ _0788_ _0733_ VSS VSS VDD VDD _0232_ sky130_fd_sc_hd__a21oi_1
X_2635_ _1262_ _1263_ _0709_ VSS VSS VDD VDD _0789_ sky130_fd_sc_hd__nor3_1
X_2636_ net247 _0789_ VSS VSS VDD VDD _0790_ sky130_fd_sc_hd__xnor2_1
X_2637_ _0738_ _0790_ VSS VSS VDD VDD _0233_ sky130_fd_sc_hd__nor2_1
X_2638_ net246 net233 net232 VSS VSS VDD VDD _0791_ sky130_fd_sc_hd__and3_1
X_2639_ _0736_ _0791_ VSS VSS VDD VDD _0792_ sky130_fd_sc_hd__nand2_1
X_2640_ net239 _0765_ _0781_ _0785_ VSS VSS VDD VDD _0793_
+ sky130_fd_sc_hd__nand4_2
X_2641_ _0793_ VSS VSS VDD VDD _0794_ sky130_fd_sc_hd__buf_2
X_2642_ _0794_ VSS VSS VDD VDD _0795_ sky130_fd_sc_hd__buf_2
X_2643_ _0792_ _0795_ net248 VSS VSS VDD VDD _0796_ sky130_fd_sc_hd__o21ai_0
X_2644_ net248 _0792_ _0794_ VSS VSS VDD VDD _0797_ sky130_fd_sc_hd__or3_1
X_2645_ _0796_ _0797_ _0733_ VSS VSS VDD VDD _0234_ sky130_fd_sc_hd__a21oi_1
X_2646_ net248 VSS VSS VDD VDD _0798_ sky130_fd_sc_hd__inv_1
X_2647_ net231 net230 _0731_ _0791_ VSS VSS VDD VDD _0799_
+ sky130_fd_sc_hd__nand4_2
X_2648_ _0798_ _0795_ _0799_ net249 VSS VSS VDD VDD _0800_
+ sky130_fd_sc_hd__o31ai_1
X_2649_ net249 _0798_ _0794_ _0799_ VSS VSS VDD VDD _0801_
+ sky130_fd_sc_hd__or4_1
X_2650_ _1254_ VSS VSS VDD VDD _0802_ sky130_fd_sc_hd__buf_2
X_2651_ _0800_ _0801_ _0802_ VSS VSS VDD VDD _0235_ sky130_fd_sc_hd__a21oi_1
X_2652_ net249 net248 VSS VSS VDD VDD _0803_ sky130_fd_sc_hd__nand2_1
X_2653_ _0792_ _0795_ _0803_ net250 VSS VSS VDD VDD _0804_
+ sky130_fd_sc_hd__o31ai_1
X_2654_ _0793_ VSS VSS VDD VDD _0805_ sky130_fd_sc_hd__buf_2
X_2655_ net250 _0792_ _0805_ _0803_ VSS VSS VDD VDD _0806_
+ sky130_fd_sc_hd__or4_1
X_2656_ _0804_ _0806_ _0802_ VSS VSS VDD VDD _0236_ sky130_fd_sc_hd__a21oi_1
X_2657_ net250 net249 net248 VSS VSS VDD VDD _0807_ sky130_fd_sc_hd__nand3_1
X_2658_ _0795_ _0799_ _0807_ net251 VSS VSS VDD VDD _0808_
+ sky130_fd_sc_hd__o31ai_1
X_2659_ net251 _0805_ _0799_ _0807_ VSS VSS VDD VDD _0809_
+ sky130_fd_sc_hd__or4_1
X_2660_ _0808_ _0809_ _0802_ VSS VSS VDD VDD _0237_ sky130_fd_sc_hd__a21oi_1
X_2661_ net251 net250 net249 net248 VSS VSS VDD VDD _0810_
+ sky130_fd_sc_hd__nand4_1
X_2662_ _0792_ _0795_ _0810_ net252 VSS VSS VDD VDD _0811_
+ sky130_fd_sc_hd__o31ai_1
X_2663_ net252 _0792_ _0805_ _0810_ VSS VSS VDD VDD _0812_
+ sky130_fd_sc_hd__or4_1
X_2664_ _0811_ _0812_ _0802_ VSS VSS VDD VDD _0238_ sky130_fd_sc_hd__a21oi_1
X_2665_ net252 net246 VSS VSS VDD VDD _0813_ sky130_fd_sc_hd__nand2_1
X_2666_ _0727_ _0748_ _0810_ _0813_ VSS VSS VDD VDD _0814_
+ sky130_fd_sc_hd__or4_2
X_2667_ _0795_ _0814_ net253 VSS VSS VDD VDD _0815_ sky130_fd_sc_hd__o21ai_0
X_2668_ net253 _0794_ _0814_ VSS VSS VDD VDD _0816_ sky130_fd_sc_hd__or3_1
X_2669_ _0815_ _0816_ _0802_ VSS VSS VDD VDD _0239_ sky130_fd_sc_hd__a21oi_1
X_2670_ net253 VSS VSS VDD VDD _0817_ sky130_fd_sc_hd__inv_1
X_2671_ net251 net250 net249 net248 VSS VSS VDD VDD _0818_
+ sky130_fd_sc_hd__and4_1
X_2672_ net252 _0736_ _0791_ _0818_ VSS VSS VDD VDD _0819_
+ sky130_fd_sc_hd__nand4_4
X_2673_ _0817_ _0795_ _0819_ net254 VSS VSS VDD VDD _0820_
+ sky130_fd_sc_hd__o31ai_1
X_2674_ net254 _0817_ _0805_ _0819_ VSS VSS VDD VDD _0821_
+ sky130_fd_sc_hd__or4_1
X_2675_ _0820_ _0821_ _0802_ VSS VSS VDD VDD _0240_ sky130_fd_sc_hd__a21oi_1
X_2676_ net252 net246 net233 net232 VSS VSS VDD VDD _0822_
+ sky130_fd_sc_hd__nand4_1
X_2677_ _0727_ _0741_ _0810_ _0822_ VSS VSS VDD VDD _0823_
+ sky130_fd_sc_hd__or4_4
X_2678_ net254 net253 VSS VSS VDD VDD _0824_ sky130_fd_sc_hd__nand2_1
X_2679_ _0795_ _0823_ _0824_ net255 VSS VSS VDD VDD _0825_
+ sky130_fd_sc_hd__o31ai_1
X_2680_ net255 _0805_ _0823_ _0824_ VSS VSS VDD VDD _0826_
+ sky130_fd_sc_hd__or4_1
X_2681_ _0825_ _0826_ _0802_ VSS VSS VDD VDD _0241_ sky130_fd_sc_hd__a21oi_1
X_2682_ net255 net254 net253 VSS VSS VDD VDD _0827_ sky130_fd_sc_hd__nand3_1
X_2683_ _0795_ _0819_ _0827_ net256 VSS VSS VDD VDD _0828_
+ sky130_fd_sc_hd__o31ai_1
X_2684_ net256 _0805_ _0819_ _0827_ VSS VSS VDD VDD _0829_
+ sky130_fd_sc_hd__or4_1
X_2685_ _0828_ _0829_ _0802_ VSS VSS VDD VDD _0242_ sky130_fd_sc_hd__a21oi_1
X_2686_ net257 VSS VSS VDD VDD _0830_ sky130_fd_sc_hd__clkbuf_2
X_2687_ _0830_ VSS VSS VDD VDD _0831_ sky130_fd_sc_hd__inv_1
X_2688_ _1478_ _0831_ VSS VSS VDD VDD _0832_ sky130_fd_sc_hd__nor2_1
X_2689_ _0697_ _0830_ VSS VSS VDD VDD _0833_ sky130_fd_sc_hd__nor2_1
X_2690_ net256 VSS VSS VDD VDD _0834_ sky130_fd_sc_hd__inv_1
X_2691_ _0834_ _0794_ _0814_ _0827_ VSS VSS VDD VDD _0835_
+ sky130_fd_sc_hd__nor4_1
X_2692_ _0832_ _0833_ _0835_ VSS VSS VDD VDD _0243_ sky130_fd_sc_hd__mux2_1
X_2693_ _1540_ net247 _1314_ _1311_ VSS VSS VDD VDD _0836_
+ sky130_fd_sc_hd__nand4_1
X_2694_ net258 _0836_ VSS VSS VDD VDD _0837_ sky130_fd_sc_hd__xor2_1
X_2695_ _0738_ _0837_ VSS VSS VDD VDD _0244_ sky130_fd_sc_hd__nor2_1
X_2696_ net255 net254 net253 net256 VSS VSS VDD VDD _0838_
+ sky130_fd_sc_hd__and4_1
X_2697_ _0838_ VSS VSS VDD VDD _0839_ sky130_fd_sc_hd__clkbuf_2
X_2698_ _0830_ _0839_ VSS VSS VDD VDD _0840_ sky130_fd_sc_hd__nand2_1
X_2699_ _0795_ _0819_ _0840_ net259 VSS VSS VDD VDD _0841_
+ sky130_fd_sc_hd__o31ai_1
X_2700_ net259 _0805_ _0819_ _0840_ VSS VSS VDD VDD _0842_
+ sky130_fd_sc_hd__or4_1
X_2701_ _0841_ _0842_ _0802_ VSS VSS VDD VDD _0245_ sky130_fd_sc_hd__a21oi_1
X_2702_ _0830_ net259 _0839_ VSS VSS VDD VDD _0843_ sky130_fd_sc_hd__nand3_1
X_2703_ _0794_ _0823_ _0843_ net260 VSS VSS VDD VDD _0844_
+ sky130_fd_sc_hd__o31ai_1
X_2704_ net260 _0805_ _0823_ _0843_ VSS VSS VDD VDD _0845_
+ sky130_fd_sc_hd__or4_1
X_2705_ _0844_ _0845_ _0802_ VSS VSS VDD VDD _0246_ sky130_fd_sc_hd__a21oi_1
X_2706_ _0830_ net259 net260 _0839_ VSS VSS VDD VDD _0846_
+ sky130_fd_sc_hd__nand4_1
X_2707_ _0794_ _0819_ _0846_ net261 VSS VSS VDD VDD _0847_
+ sky130_fd_sc_hd__o31ai_1
X_2708_ net261 _0805_ _0819_ _0846_ VSS VSS VDD VDD _0848_
+ sky130_fd_sc_hd__or4_1
X_2709_ _0847_ _0848_ _1217_ VSS VSS VDD VDD _0247_ sky130_fd_sc_hd__a21oi_1
X_2710_ _0830_ net259 net260 net261 VSS VSS VDD VDD _0849_
+ sky130_fd_sc_hd__and4_1
X_2711_ _0839_ _0849_ VSS VSS VDD VDD _0850_ sky130_fd_sc_hd__nand2_1
X_2712_ _0794_ _0823_ _0850_ net262 VSS VSS VDD VDD _0851_
+ sky130_fd_sc_hd__o31ai_1
X_2713_ net262 _0805_ _0823_ _0850_ VSS VSS VDD VDD _0852_
+ sky130_fd_sc_hd__or4_1
X_2714_ _0851_ _0852_ _1217_ VSS VSS VDD VDD _0248_ sky130_fd_sc_hd__a21oi_1
X_2715_ net259 net260 net261 net262 VSS VSS VDD VDD _0853_
+ sky130_fd_sc_hd__and4_1
X_2716_ _0830_ _0839_ _0853_ VSS VSS VDD VDD _0854_ sky130_fd_sc_hd__nand3_1
X_2717_ _0794_ _0819_ _0854_ net263 VSS VSS VDD VDD _0855_
+ sky130_fd_sc_hd__o31ai_1
X_2718_ net263 _0793_ _0819_ _0854_ VSS VSS VDD VDD _0856_
+ sky130_fd_sc_hd__or4_1
X_2719_ _0855_ _0856_ _1217_ VSS VSS VDD VDD _0249_ sky130_fd_sc_hd__a21oi_1
X_2720_ _0830_ net263 _0839_ _0853_ VSS VSS VDD VDD _0857_
+ sky130_fd_sc_hd__nand4_1
X_2721_ _0794_ _0814_ _0857_ net264 VSS VSS VDD VDD _0858_
+ sky130_fd_sc_hd__o31ai_1
X_2722_ net264 _0793_ _0814_ _0857_ VSS VSS VDD VDD _0859_
+ sky130_fd_sc_hd__or4_1
X_2723_ _0858_ _0859_ _1217_ VSS VSS VDD VDD _0250_ sky130_fd_sc_hd__a21oi_1
X_2724_ prev_event_inc\[3\] net8 _1220_ VSS VSS VDD VDD _0860_
+ sky130_fd_sc_hd__nand3b_1
X_2725_ net265 _0860_ VSS VSS VDD VDD _0861_ sky130_fd_sc_hd__xor2_1
X_2726_ _0738_ _0861_ VSS VSS VDD VDD _0251_ sky130_fd_sc_hd__nor2_1
X_2727_ _1551_ net266 _0860_ VSS VSS VDD VDD _0862_ sky130_fd_sc_hd__mux2i_1
X_2728_ _1255_ _0862_ VSS VSS VDD VDD _0252_ sky130_fd_sc_hd__nor2_1
X_2729_ prev_event_inc\[3\] _1550_ _1220_ net8 VSS VSS VDD
+ VDD _0863_ sky130_fd_sc_hd__nand4b_1
X_2730_ net267 _0863_ VSS VSS VDD VDD _0864_ sky130_fd_sc_hd__xor2_1
X_2731_ _1255_ _0864_ VSS VSS VDD VDD _0253_ sky130_fd_sc_hd__nor2_1
X_2732_ net265 net266 _1228_ VSS VSS VDD VDD _0865_ sky130_fd_sc_hd__nand3_1
X_2733_ net268 _0865_ VSS VSS VDD VDD _0866_ sky130_fd_sc_hd__xor2_1
X_2734_ _1255_ _0866_ VSS VSS VDD VDD _0254_ sky130_fd_sc_hd__nor2_1
X_2735_ _1262_ _1263_ _1264_ _0709_ VSS VSS VDD VDD _0867_
+ sky130_fd_sc_hd__nor4_1
X_2736_ net269 _0867_ VSS VSS VDD VDD _0868_ sky130_fd_sc_hd__xnor2_1
X_2737_ _1255_ _0868_ VSS VSS VDD VDD _0255_ sky130_fd_sc_hd__nor2_1
X_2738_ net5 prev_event_inc\[0\] _0697_ VSS VSS VDD VDD _0256_
+ sky130_fd_sc_hd__mux2_1
X_2739_ net6 prev_event_inc\[1\] _0697_ VSS VSS VDD VDD _0257_
+ sky130_fd_sc_hd__mux2_1
X_2740_ net7 prev_event_inc\[2\] _0697_ VSS VSS VDD VDD _0258_
+ sky130_fd_sc_hd__mux2_1
X_2741_ net8 prev_event_inc\[3\] _0697_ VSS VSS VDD VDD _0259_
+ sky130_fd_sc_hd__mux2_1
X_2742_ net9 prev_event_inc\[4\] _0697_ VSS VSS VDD VDD _0260_
+ sky130_fd_sc_hd__mux2_1
X_2743_ net10 prev_event_inc\[5\] _0697_ VSS VSS VDD VDD _0261_
+ sky130_fd_sc_hd__mux2_1
X_2744_ net11 prev_event_inc\[6\] _0697_ VSS VSS VDD VDD _0262_
+ sky130_fd_sc_hd__mux2_1
X_2745_ net12 prev_event_inc\[7\] _1216_ VSS VSS VDD VDD _0263_
+ sky130_fd_sc_hd__mux2_1
X_2746_ counter_sel[4] VSS VSS VDD VDD _0869_ sky130_fd_sc_hd__buf_2
X_2747_ _0869_ VSS VSS VDD VDD _0870_ sky130_fd_sc_hd__clkbuf_4
X_2748_ counter_sel[2] VSS VSS VDD VDD _0871_ sky130_fd_sc_hd__buf_2
X_2749_ _0871_ VSS VSS VDD VDD _0872_ sky130_fd_sc_hd__buf_2
X_2750_ counter_sel[1] VSS VSS VDD VDD _0873_ sky130_fd_sc_hd__buf_2
X_2751_ _0873_ VSS VSS VDD VDD _0874_ sky130_fd_sc_hd__clkbuf_2
X_2752_ net1 VSS VSS VDD VDD _0875_ sky130_fd_sc_hd__buf_2
X_2753_ _0874_ _0875_ net14 VSS VSS VDD VDD _0876_ sky130_fd_sc_hd__nand3b_1
X_2754_ _0871_ VSS VSS VDD VDD _0877_ sky130_fd_sc_hd__buf_2
X_2755_ net195 _0874_ _0877_ VSS VSS VDD VDD _0878_ sky130_fd_sc_hd__a21oi_1
X_2756_ counter_sel[3] VSS VSS VDD VDD _0879_ sky130_fd_sc_hd__clkbuf_4
X_2757_ _0879_ VSS VSS VDD VDD _0880_ sky130_fd_sc_hd__buf_2
X_2758_ _0730_ _0872_ _0876_ _0878_ _0880_ VSS VSS VDD VDD
+ _0881_ sky130_fd_sc_hd__a221o_1
X_2759_ _0879_ VSS VSS VDD VDD _0882_ sky130_fd_sc_hd__buf_2
X_2760_ _0869_ VSS VSS VDD VDD _0883_ sky130_fd_sc_hd__buf_2
X_2761_ net265 _0882_ _0883_ VSS VSS VDD VDD _0884_ sky130_fd_sc_hd__a21oi_1
X_2762_ counter_sel[5] VSS VSS VDD VDD _0885_ sky130_fd_sc_hd__clkbuf_4
X_2763_ _0885_ VSS VSS VDD VDD _0886_ sky130_fd_sc_hd__clkbuf_4
X_2764_ _1346_ _0870_ _0881_ _0884_ _0886_ VSS VSS VDD VDD
+ _0887_ sky130_fd_sc_hd__a221o_1
X_2765_ _0885_ VSS VSS VDD VDD _0888_ sky130_fd_sc_hd__buf_2
X_2766_ net81 _0888_ VSS VSS VDD VDD _0889_ sky130_fd_sc_hd__nand2_1
X_2767_ net2 net3 VSS VSS VDD VDD _0890_ sky130_fd_sc_hd__nor2_1
X_2768_ _0890_ VSS VSS VDD VDD _0891_ sky130_fd_sc_hd__clkbuf_4
X_2769_ net2 VSS VSS VDD VDD _0892_ sky130_fd_sc_hd__buf_2
X_2770_ net116 _0892_ VSS VSS VDD VDD _0893_ sky130_fd_sc_hd__nand2b_1
X_2771_ net3 VSS VSS VDD VDD _0894_ sky130_fd_sc_hd__buf_2
X_2772_ _0894_ VSS VSS VDD VDD _0895_ sky130_fd_sc_hd__buf_4
X_2773_ _0893_ net152 _0895_ VSS VSS VDD VDD _0896_ sky130_fd_sc_hd__mux2i_1
X_2774_ _0887_ _0889_ _0891_ _0896_ VSS VSS VDD VDD net270
+ sky130_fd_sc_hd__a31oi_1
X_2775_ _0890_ VSS VSS VDD VDD _0897_ sky130_fd_sc_hd__buf_2
X_2776_ net241 VSS VSS VDD VDD _0898_ sky130_fd_sc_hd__inv_1
X_2777_ _0873_ VSS VSS VDD VDD _0899_ sky130_fd_sc_hd__clkbuf_2
X_2778_ _0899_ _0875_ net25 VSS VSS VDD VDD _0900_ sky130_fd_sc_hd__nand3b_1
X_2779_ net206 _0874_ _0877_ VSS VSS VDD VDD _0901_ sky130_fd_sc_hd__a21oi_1
X_2780_ _0898_ _0872_ _0900_ _0901_ _0880_ VSS VSS VDD VDD
+ _0902_ sky130_fd_sc_hd__a221o_1
X_2781_ _0882_ net21 _0883_ VSS VSS VDD VDD _0903_ sky130_fd_sc_hd__a21oi_1
X_2782_ _0870_ _1387_ _0902_ _0903_ _0886_ VSS VSS VDD VDD
+ _0904_ sky130_fd_sc_hd__a221o_1
X_2783_ _0885_ VSS VSS VDD VDD _0905_ sky130_fd_sc_hd__clkbuf_2
X_2784_ _0905_ net92 VSS VSS VDD VDD _0906_ sky130_fd_sc_hd__nand2_1
X_2785_ net128 _0892_ VSS VSS VDD VDD _0907_ sky130_fd_sc_hd__nand2b_1
X_2786_ _0907_ net163 _0895_ VSS VSS VDD VDD _0908_ sky130_fd_sc_hd__mux2i_1
X_2787_ _0897_ _0904_ _0906_ _0908_ VSS VSS VDD VDD net271
+ sky130_fd_sc_hd__a31oi_1
X_2788_ net242 VSS VSS VDD VDD _0909_ sky130_fd_sc_hd__inv_1
X_2789_ _0899_ _0875_ net36 VSS VSS VDD VDD _0910_ sky130_fd_sc_hd__nand3b_1
X_2790_ net207 _0874_ _0877_ VSS VSS VDD VDD _0911_ sky130_fd_sc_hd__a21oi_1
X_2791_ _0909_ _0872_ _0910_ _0911_ _0880_ VSS VSS VDD VDD
+ _0912_ sky130_fd_sc_hd__a221o_1
X_2792_ _0882_ net22 _0883_ VSS VSS VDD VDD _0913_ sky130_fd_sc_hd__a21oi_1
X_2793_ _0870_ _1391_ _0912_ _0913_ _0886_ VSS VSS VDD VDD
+ _0914_ sky130_fd_sc_hd__a221o_1
X_2794_ _0905_ net93 VSS VSS VDD VDD _0915_ sky130_fd_sc_hd__nand2_1
X_2795_ net2 VSS VSS VDD VDD _0916_ sky130_fd_sc_hd__buf_2
X_2796_ net129 _0916_ VSS VSS VDD VDD _0917_ sky130_fd_sc_hd__nand2b_1
X_2797_ _0917_ net164 _0895_ VSS VSS VDD VDD _0918_ sky130_fd_sc_hd__mux2i_1
X_2798_ _0897_ _0914_ _0915_ _0918_ VSS VSS VDD VDD net272
+ sky130_fd_sc_hd__a31oi_1
X_2799_ net59 VSS VSS VDD VDD _0919_ sky130_fd_sc_hd__inv_1
X_2800_ net243 VSS VSS VDD VDD _0920_ sky130_fd_sc_hd__inv_1
X_2801_ _0899_ _0875_ net47 VSS VSS VDD VDD _0921_ sky130_fd_sc_hd__nand3b_1
X_2802_ net208 _0874_ _0877_ VSS VSS VDD VDD _0922_ sky130_fd_sc_hd__a21oi_1
X_2803_ _0920_ _0872_ _0921_ _0922_ _0880_ VSS VSS VDD VDD
+ _0923_ sky130_fd_sc_hd__a221o_1
X_2804_ _0882_ net23 _0883_ VSS VSS VDD VDD _0924_ sky130_fd_sc_hd__a21oi_1
X_2805_ _0870_ _0919_ _0923_ _0924_ _0886_ VSS VSS VDD VDD
+ _0925_ sky130_fd_sc_hd__a221o_1
X_2806_ _0905_ net94 VSS VSS VDD VDD _0926_ sky130_fd_sc_hd__nand2_1
X_2807_ net130 _0916_ VSS VSS VDD VDD _0927_ sky130_fd_sc_hd__nand2b_1
X_2808_ _0927_ net165 _0895_ VSS VSS VDD VDD _0928_ sky130_fd_sc_hd__mux2i_1
X_2809_ _0897_ _0925_ _0926_ _0928_ VSS VSS VDD VDD net273
+ sky130_fd_sc_hd__a31oi_1
X_2810_ net60 VSS VSS VDD VDD _0929_ sky130_fd_sc_hd__inv_1
X_2811_ net244 VSS VSS VDD VDD _0930_ sky130_fd_sc_hd__inv_1
X_2812_ _0899_ _0875_ net58 VSS VSS VDD VDD _0931_ sky130_fd_sc_hd__nand3b_1
X_2813_ net209 _0874_ _0877_ VSS VSS VDD VDD _0932_ sky130_fd_sc_hd__a21oi_1
X_2814_ _0930_ _0872_ _0931_ _0932_ _0880_ VSS VSS VDD VDD
+ _0933_ sky130_fd_sc_hd__a221o_1
X_2815_ _0882_ net24 _0883_ VSS VSS VDD VDD _0934_ sky130_fd_sc_hd__a21oi_1
X_2816_ _0870_ _0929_ _0933_ _0934_ _0886_ VSS VSS VDD VDD
+ _0935_ sky130_fd_sc_hd__a221o_1
X_2817_ _0905_ net95 VSS VSS VDD VDD _0936_ sky130_fd_sc_hd__nand2_1
X_2818_ net131 _0916_ VSS VSS VDD VDD _0937_ sky130_fd_sc_hd__nand2b_1
X_2819_ _0937_ net166 _0895_ VSS VSS VDD VDD _0938_ sky130_fd_sc_hd__mux2i_1
X_2820_ _0897_ _0935_ _0936_ _0938_ VSS VSS VDD VDD net274
+ sky130_fd_sc_hd__a31oi_1
X_2821_ net245 VSS VSS VDD VDD _0939_ sky130_fd_sc_hd__inv_1
X_2822_ _0899_ _0875_ net69 VSS VSS VDD VDD _0940_ sky130_fd_sc_hd__nand3b_1
X_2823_ _0873_ VSS VSS VDD VDD _0941_ sky130_fd_sc_hd__clkbuf_2
X_2824_ net210 _0941_ _0877_ VSS VSS VDD VDD _0942_ sky130_fd_sc_hd__a21oi_1
X_2825_ _0939_ _0872_ _0940_ _0942_ _0880_ VSS VSS VDD VDD
+ _0943_ sky130_fd_sc_hd__a221o_1
X_2826_ _0882_ net26 _0883_ VSS VSS VDD VDD _0944_ sky130_fd_sc_hd__a21oi_1
X_2827_ _0870_ _1414_ _0943_ _0944_ _0886_ VSS VSS VDD VDD
+ _0945_ sky130_fd_sc_hd__a221o_1
X_2828_ _0905_ net96 VSS VSS VDD VDD _0946_ sky130_fd_sc_hd__nand2_1
X_2829_ net132 _0916_ VSS VSS VDD VDD _0947_ sky130_fd_sc_hd__nand2b_1
X_2830_ _0947_ net167 _0895_ VSS VSS VDD VDD _0948_ sky130_fd_sc_hd__mux2i_1
X_2831_ _0897_ _0945_ _0946_ _0948_ VSS VSS VDD VDD net275
+ sky130_fd_sc_hd__a31oi_1
X_2832_ net62 VSS VSS VDD VDD _0949_ sky130_fd_sc_hd__inv_1
X_2833_ net246 VSS VSS VDD VDD _0950_ sky130_fd_sc_hd__inv_1
X_2834_ _0874_ _0875_ net80 VSS VSS VDD VDD _0951_ sky130_fd_sc_hd__nand3b_1
X_2835_ net211 _0874_ _0872_ VSS VSS VDD VDD _0952_ sky130_fd_sc_hd__a21oi_1
X_2836_ _0950_ _0872_ _0951_ _0952_ _0880_ VSS VSS VDD VDD
+ _0953_ sky130_fd_sc_hd__a221o_1
X_2837_ _0882_ net27 _0883_ VSS VSS VDD VDD _0954_ sky130_fd_sc_hd__a21oi_1
X_2838_ _0870_ _0949_ _0953_ _0954_ _0886_ VSS VSS VDD VDD
+ _0955_ sky130_fd_sc_hd__a221oi_2
X_2839_ _0886_ net97 VSS VSS VDD VDD _0956_ sky130_fd_sc_hd__nand2_1
X_2840_ _0890_ _0956_ VSS VSS VDD VDD _0957_ sky130_fd_sc_hd__nand2_1
X_2841_ net133 _0894_ _0892_ VSS VSS VDD VDD _0958_ sky130_fd_sc_hd__nor3b_1
X_2842_ _0522_ _0895_ _0958_ VSS VSS VDD VDD _0959_ sky130_fd_sc_hd__a21oi_1
X_2843_ _0955_ _0957_ _0959_ VSS VSS VDD VDD net276 sky130_fd_sc_hd__o21a_1
X_2844_ net63 VSS VSS VDD VDD _0960_ sky130_fd_sc_hd__inv_1
X_2845_ _0871_ VSS VSS VDD VDD _0961_ sky130_fd_sc_hd__buf_2
X_2846_ _0873_ VSS VSS VDD VDD _0962_ sky130_fd_sc_hd__clkbuf_2
X_2847_ _0962_ _0875_ net91 VSS VSS VDD VDD _0963_ sky130_fd_sc_hd__nand3b_1
X_2848_ _0871_ VSS VSS VDD VDD _0964_ sky130_fd_sc_hd__clkbuf_2
X_2849_ net212 _0941_ _0964_ VSS VSS VDD VDD _0965_ sky130_fd_sc_hd__a21oi_1
X_2850_ _0879_ VSS VSS VDD VDD _0966_ sky130_fd_sc_hd__buf_2
X_2851_ _0798_ _0961_ _0963_ _0965_ _0966_ VSS VSS VDD VDD
+ _0967_ sky130_fd_sc_hd__a221o_1
X_2852_ _0869_ VSS VSS VDD VDD _0968_ sky130_fd_sc_hd__buf_2
X_2853_ _0882_ net28 _0968_ VSS VSS VDD VDD _0969_ sky130_fd_sc_hd__a21oi_1
X_2854_ _0885_ VSS VSS VDD VDD _0970_ sky130_fd_sc_hd__buf_2
X_2855_ _0870_ _0960_ _0967_ _0969_ _0970_ VSS VSS VDD VDD
+ _0971_ sky130_fd_sc_hd__a221o_1
X_2856_ _0905_ net98 VSS VSS VDD VDD _0972_ sky130_fd_sc_hd__nand2_1
X_2857_ _0894_ VSS VSS VDD VDD _0973_ sky130_fd_sc_hd__buf_4
X_2858_ net134 _0894_ _0892_ VSS VSS VDD VDD _0974_ sky130_fd_sc_hd__nor3b_1
X_2859_ _0521_ _0973_ _0974_ VSS VSS VDD VDD _0975_ sky130_fd_sc_hd__a21o_1
X_2860_ _0897_ _0971_ _0972_ _0975_ VSS VSS VDD VDD net277
+ sky130_fd_sc_hd__a31oi_1
X_2861_ net64 VSS VSS VDD VDD _0976_ sky130_fd_sc_hd__inv_1
X_2862_ net249 VSS VSS VDD VDD _0977_ sky130_fd_sc_hd__inv_1
X_2863_ _0962_ _0875_ net102 VSS VSS VDD VDD _0978_ sky130_fd_sc_hd__nand3b_1
X_2864_ net213 _0941_ _0964_ VSS VSS VDD VDD _0979_ sky130_fd_sc_hd__a21oi_1
X_2865_ _0977_ _0961_ _0978_ _0979_ _0966_ VSS VSS VDD VDD
+ _0980_ sky130_fd_sc_hd__a221o_1
X_2866_ _0882_ net29 _0968_ VSS VSS VDD VDD _0981_ sky130_fd_sc_hd__a21oi_1
X_2867_ _0870_ _0976_ _0980_ _0981_ _0970_ VSS VSS VDD VDD
+ _0982_ sky130_fd_sc_hd__a221o_1
X_2868_ _0905_ net99 VSS VSS VDD VDD _0983_ sky130_fd_sc_hd__nand2_1
X_2869_ net135 _0916_ VSS VSS VDD VDD _0984_ sky130_fd_sc_hd__nand2b_1
X_2870_ _0984_ net171 _0895_ VSS VSS VDD VDD _0985_ sky130_fd_sc_hd__mux2i_1
X_2871_ _0897_ _0982_ _0983_ _0985_ VSS VSS VDD VDD net278
+ sky130_fd_sc_hd__a31oi_1
X_2872_ _0869_ VSS VSS VDD VDD _0986_ sky130_fd_sc_hd__buf_2
X_2873_ net65 VSS VSS VDD VDD _0987_ sky130_fd_sc_hd__inv_1
X_2874_ net250 VSS VSS VDD VDD _0988_ sky130_fd_sc_hd__inv_1
X_2875_ net1 VSS VSS VDD VDD _0989_ sky130_fd_sc_hd__buf_2
X_2876_ _0962_ _0989_ net113 VSS VSS VDD VDD _0990_ sky130_fd_sc_hd__nand3b_1
X_2877_ net215 _0941_ _0964_ VSS VSS VDD VDD _0991_ sky130_fd_sc_hd__a21oi_1
X_2878_ _0988_ _0961_ _0990_ _0991_ _0966_ VSS VSS VDD VDD
+ _0992_ sky130_fd_sc_hd__a221o_1
X_2879_ _0879_ VSS VSS VDD VDD _0993_ sky130_fd_sc_hd__buf_2
X_2880_ _0993_ net30 _0968_ VSS VSS VDD VDD _0994_ sky130_fd_sc_hd__a21oi_1
X_2881_ _0986_ _0987_ _0992_ _0994_ _0970_ VSS VSS VDD VDD
+ _0995_ sky130_fd_sc_hd__a221o_1
X_2882_ _0905_ net100 VSS VSS VDD VDD _0996_ sky130_fd_sc_hd__nand2_1
X_2883_ net137 _0916_ VSS VSS VDD VDD _0997_ sky130_fd_sc_hd__nand2b_1
X_2884_ _0997_ net172 _0895_ VSS VSS VDD VDD _0998_ sky130_fd_sc_hd__mux2i_1
X_2885_ _0897_ _0995_ _0996_ _0998_ VSS VSS VDD VDD net279
+ sky130_fd_sc_hd__a31oi_1
X_2886_ net66 VSS VSS VDD VDD _0999_ sky130_fd_sc_hd__inv_1
X_2887_ net251 VSS VSS VDD VDD _1000_ sky130_fd_sc_hd__inv_1
X_2888_ _0962_ _0989_ net124 VSS VSS VDD VDD _1001_ sky130_fd_sc_hd__nand3b_1
X_2889_ net216 _0941_ _0964_ VSS VSS VDD VDD _1002_ sky130_fd_sc_hd__a21oi_1
X_2890_ _1000_ _0961_ _1001_ _1002_ _0966_ VSS VSS VDD VDD
+ _1003_ sky130_fd_sc_hd__a221o_1
X_2891_ _0993_ net31 _0968_ VSS VSS VDD VDD _1004_ sky130_fd_sc_hd__a21oi_1
X_2892_ _0986_ _0999_ _1003_ _1004_ _0970_ VSS VSS VDD VDD
+ _1005_ sky130_fd_sc_hd__a221o_1
X_2893_ _0905_ net101 VSS VSS VDD VDD _1006_ sky130_fd_sc_hd__nand2_1
X_2894_ net138 _0916_ VSS VSS VDD VDD _1007_ sky130_fd_sc_hd__nand2b_1
X_2895_ _0894_ VSS VSS VDD VDD _1008_ sky130_fd_sc_hd__buf_4
X_2896_ _1007_ net173 _1008_ VSS VSS VDD VDD _1009_ sky130_fd_sc_hd__mux2i_1
X_2897_ _0897_ _1005_ _1006_ _1009_ VSS VSS VDD VDD net280
+ sky130_fd_sc_hd__a31oi_1
X_2898_ net46 VSS VSS VDD VDD _1010_ sky130_fd_sc_hd__inv_1
X_2899_ net231 VSS VSS VDD VDD _1011_ sky130_fd_sc_hd__inv_1
X_2900_ _0962_ _0989_ net125 VSS VSS VDD VDD _1012_ sky130_fd_sc_hd__nand3b_1
X_2901_ net196 _0941_ _0964_ VSS VSS VDD VDD _1013_ sky130_fd_sc_hd__a21oi_1
X_2902_ _1011_ _0961_ _1012_ _1013_ _0966_ VSS VSS VDD VDD
+ _1014_ sky130_fd_sc_hd__a221o_1
X_2903_ _0993_ net266 _0968_ VSS VSS VDD VDD _1015_ sky130_fd_sc_hd__a21oi_1
X_2904_ _0986_ _1010_ _1014_ _1015_ _0970_ VSS VSS VDD VDD
+ _1016_ sky130_fd_sc_hd__a221o_1
X_2905_ _0905_ net82 VSS VSS VDD VDD _1017_ sky130_fd_sc_hd__nand2_1
X_2906_ net117 _0916_ VSS VSS VDD VDD _1018_ sky130_fd_sc_hd__nand2b_1
X_2907_ _1018_ net153 _1008_ VSS VSS VDD VDD _1019_ sky130_fd_sc_hd__mux2i_1
X_2908_ _0897_ _1016_ _1017_ _1019_ VSS VSS VDD VDD net281
+ sky130_fd_sc_hd__a31oi_1
X_2909_ _0890_ VSS VSS VDD VDD _1020_ sky130_fd_sc_hd__buf_2
X_2910_ net252 VSS VSS VDD VDD _1021_ sky130_fd_sc_hd__inv_1
X_2911_ _0962_ _0989_ net136 VSS VSS VDD VDD _1022_ sky130_fd_sc_hd__nand3b_1
X_2912_ net217 _0941_ _0964_ VSS VSS VDD VDD _1023_ sky130_fd_sc_hd__a21oi_1
X_2913_ _1021_ _0961_ _1022_ _1023_ _0966_ VSS VSS VDD VDD
+ _1024_ sky130_fd_sc_hd__a221o_1
X_2914_ _0993_ net32 _0968_ VSS VSS VDD VDD _1025_ sky130_fd_sc_hd__a21oi_1
X_2915_ _0986_ _1437_ _1024_ _1025_ _0970_ VSS VSS VDD VDD
+ _1026_ sky130_fd_sc_hd__a221o_1
X_2916_ _0885_ VSS VSS VDD VDD _1027_ sky130_fd_sc_hd__clkbuf_2
X_2917_ _1027_ net103 VSS VSS VDD VDD _1028_ sky130_fd_sc_hd__nand2_1
X_2918_ _0892_ _0414_ VSS VSS VDD VDD _1029_ sky130_fd_sc_hd__nand2_1
X_2919_ _1029_ net174 _1008_ VSS VSS VDD VDD _1030_ sky130_fd_sc_hd__mux2i_1
X_2920_ _1020_ _1026_ _1028_ _1030_ VSS VSS VDD VDD net282
+ sky130_fd_sc_hd__a31oi_1
X_2921_ net68 VSS VSS VDD VDD _1031_ sky130_fd_sc_hd__inv_1
X_2922_ _0962_ _0989_ net147 VSS VSS VDD VDD _1032_ sky130_fd_sc_hd__nand3b_1
X_2923_ net218 _0941_ _0964_ VSS VSS VDD VDD _1033_ sky130_fd_sc_hd__a21oi_1
X_2924_ _0817_ _0961_ _1032_ _1033_ _0966_ VSS VSS VDD VDD
+ _1034_ sky130_fd_sc_hd__a221o_1
X_2925_ _0993_ net33 _0968_ VSS VSS VDD VDD _1035_ sky130_fd_sc_hd__a21oi_1
X_2926_ _0986_ _1031_ _1034_ _1035_ _0970_ VSS VSS VDD VDD
+ _1036_ sky130_fd_sc_hd__a221o_1
X_2927_ _1027_ net104 VSS VSS VDD VDD _1037_ sky130_fd_sc_hd__nand2_1
X_2928_ net140 _0894_ _0892_ VSS VSS VDD VDD _1038_ sky130_fd_sc_hd__nor3b_1
X_2929_ _0542_ _0894_ _1038_ VSS VSS VDD VDD _1039_ sky130_fd_sc_hd__a21o_1
X_2930_ _1020_ _1036_ _1037_ _1039_ VSS VSS VDD VDD net283
+ sky130_fd_sc_hd__a31oi_1
X_2931_ net70 VSS VSS VDD VDD _1040_ sky130_fd_sc_hd__inv_1
X_2932_ net254 VSS VSS VDD VDD _1041_ sky130_fd_sc_hd__inv_1
X_2933_ _0962_ _0989_ net158 VSS VSS VDD VDD _1042_ sky130_fd_sc_hd__nand3b_1
X_2934_ net219 _0941_ _0964_ VSS VSS VDD VDD _1043_ sky130_fd_sc_hd__a21oi_1
X_2935_ _1041_ _0961_ _1042_ _1043_ _0966_ VSS VSS VDD VDD
+ _1044_ sky130_fd_sc_hd__a221o_1
X_2936_ _0993_ net34 _0968_ VSS VSS VDD VDD _1045_ sky130_fd_sc_hd__a21oi_1
X_2937_ _0986_ _1040_ _1044_ _1045_ _0970_ VSS VSS VDD VDD
+ _1046_ sky130_fd_sc_hd__a221o_1
X_2938_ _1027_ net105 VSS VSS VDD VDD _1047_ sky130_fd_sc_hd__nand2_1
X_2939_ net141 _0916_ VSS VSS VDD VDD _1048_ sky130_fd_sc_hd__nand2b_1
X_2940_ _1048_ net176 _1008_ VSS VSS VDD VDD _1049_ sky130_fd_sc_hd__mux2i_1
X_2941_ _1020_ _1046_ _1047_ _1049_ VSS VSS VDD VDD net284
+ sky130_fd_sc_hd__a31oi_1
X_2942_ net255 VSS VSS VDD VDD _1050_ sky130_fd_sc_hd__inv_1
X_2943_ _0962_ _0989_ net169 VSS VSS VDD VDD _1051_ sky130_fd_sc_hd__nand3b_1
X_2944_ net220 _0941_ _0964_ VSS VSS VDD VDD _1052_ sky130_fd_sc_hd__a21oi_1
X_2945_ _1050_ _0961_ _1051_ _1052_ _0966_ VSS VSS VDD VDD
+ _1053_ sky130_fd_sc_hd__a221o_1
X_2946_ _0993_ net35 _0968_ VSS VSS VDD VDD _1054_ sky130_fd_sc_hd__a21oi_1
X_2947_ _0986_ _1454_ _1053_ _1054_ _0970_ VSS VSS VDD VDD
+ _1055_ sky130_fd_sc_hd__a221o_1
X_2948_ _1027_ net106 VSS VSS VDD VDD _1056_ sky130_fd_sc_hd__nand2_1
X_2949_ _0892_ _0427_ VSS VSS VDD VDD _1057_ sky130_fd_sc_hd__nand2_1
X_2950_ _1057_ net177 _1008_ VSS VSS VDD VDD _1058_ sky130_fd_sc_hd__mux2i_1
X_2951_ _1020_ _1055_ _1056_ _1058_ VSS VSS VDD VDD net285
+ sky130_fd_sc_hd__a31oi_1
X_2952_ net72 VSS VSS VDD VDD _1059_ sky130_fd_sc_hd__inv_1
X_2953_ _0962_ _0989_ net180 VSS VSS VDD VDD _1060_ sky130_fd_sc_hd__nand3b_1
X_2954_ _0873_ VSS VSS VDD VDD _1061_ sky130_fd_sc_hd__clkbuf_2
X_2955_ net221 _1061_ _0964_ VSS VSS VDD VDD _1062_ sky130_fd_sc_hd__a21oi_1
X_2956_ _0834_ _0961_ _1060_ _1062_ _0966_ VSS VSS VDD VDD
+ _1063_ sky130_fd_sc_hd__a221o_1
X_2957_ _0993_ net37 _0968_ VSS VSS VDD VDD _1064_ sky130_fd_sc_hd__a21oi_1
X_2958_ _0986_ _1059_ _1063_ _1064_ _0970_ VSS VSS VDD VDD
+ _1065_ sky130_fd_sc_hd__a221o_1
X_2959_ _1027_ net107 VSS VSS VDD VDD _1066_ sky130_fd_sc_hd__nand2_1
X_2960_ net143 _0916_ VSS VSS VDD VDD _1067_ sky130_fd_sc_hd__nand2b_1
X_2961_ _1067_ net178 _1008_ VSS VSS VDD VDD _1068_ sky130_fd_sc_hd__mux2i_1
X_2962_ _1020_ _1065_ _1066_ _1068_ VSS VSS VDD VDD net286
+ sky130_fd_sc_hd__a31oi_1
X_2963_ net73 VSS VSS VDD VDD _1069_ sky130_fd_sc_hd__inv_1
X_2964_ _0871_ VSS VSS VDD VDD _1070_ sky130_fd_sc_hd__buf_2
X_2965_ _0873_ VSS VSS VDD VDD _1071_ sky130_fd_sc_hd__clkbuf_2
X_2966_ _1071_ _0989_ net187 VSS VSS VDD VDD _1072_ sky130_fd_sc_hd__nand3b_1
X_2967_ _0871_ VSS VSS VDD VDD _1073_ sky130_fd_sc_hd__clkbuf_2
X_2968_ _0695_ _1061_ _1073_ VSS VSS VDD VDD _1074_ sky130_fd_sc_hd__a21oi_1
X_2969_ _0879_ VSS VSS VDD VDD _1075_ sky130_fd_sc_hd__buf_2
X_2970_ _0831_ _1070_ _1072_ _1074_ _1075_ VSS VSS VDD VDD
+ _1076_ sky130_fd_sc_hd__a221o_1
X_2971_ _0869_ VSS VSS VDD VDD _1077_ sky130_fd_sc_hd__buf_2
X_2972_ _0993_ net38 _1077_ VSS VSS VDD VDD _1078_ sky130_fd_sc_hd__a21oi_1
X_2973_ _0885_ VSS VSS VDD VDD _1079_ sky130_fd_sc_hd__buf_2
X_2974_ _0986_ _1069_ _1076_ _1078_ _1079_ VSS VSS VDD VDD
+ _1080_ sky130_fd_sc_hd__a221o_1
X_2975_ _1027_ net108 VSS VSS VDD VDD _1081_ sky130_fd_sc_hd__nand2_1
X_2976_ net2 VSS VSS VDD VDD _1082_ sky130_fd_sc_hd__clkbuf_4
X_2977_ net144 _1082_ VSS VSS VDD VDD _1083_ sky130_fd_sc_hd__nand2b_1
X_2978_ _1083_ net179 _1008_ VSS VSS VDD VDD _1084_ sky130_fd_sc_hd__mux2i_1
X_2979_ _1020_ _1080_ _1081_ _1084_ VSS VSS VDD VDD net287
+ sky130_fd_sc_hd__a31oi_1
X_2980_ net74 VSS VSS VDD VDD _1085_ sky130_fd_sc_hd__inv_1
X_2981_ net259 VSS VSS VDD VDD _1086_ sky130_fd_sc_hd__inv_1
X_2982_ _1071_ _0989_ net188 VSS VSS VDD VDD _1087_ sky130_fd_sc_hd__nand3b_1
X_2983_ net223 _1061_ _1073_ VSS VSS VDD VDD _1088_ sky130_fd_sc_hd__a21oi_1
X_2984_ _1086_ _1070_ _1087_ _1088_ _1075_ VSS VSS VDD VDD
+ _1089_ sky130_fd_sc_hd__a221o_1
X_2985_ _0993_ net39 _1077_ VSS VSS VDD VDD _1090_ sky130_fd_sc_hd__a21oi_1
X_2986_ _0986_ _1085_ _1089_ _1090_ _1079_ VSS VSS VDD VDD
+ _1091_ sky130_fd_sc_hd__a221o_1
X_2987_ _1027_ net109 VSS VSS VDD VDD _1092_ sky130_fd_sc_hd__nand2_1
X_2988_ net145 _1082_ VSS VSS VDD VDD _1093_ sky130_fd_sc_hd__nand2b_1
X_2989_ _1093_ net181 _1008_ VSS VSS VDD VDD _1094_ sky130_fd_sc_hd__mux2i_1
X_2990_ _1020_ _1091_ _1092_ _1094_ VSS VSS VDD VDD net288
+ sky130_fd_sc_hd__a31oi_1
X_2991_ net75 VSS VSS VDD VDD _1095_ sky130_fd_sc_hd__inv_1
X_2992_ net260 VSS VSS VDD VDD _1096_ sky130_fd_sc_hd__inv_1
X_2993_ _0874_ _0875_ net189 VSS VSS VDD VDD _1097_ sky130_fd_sc_hd__nand3b_1
X_2994_ net224 _0874_ _0872_ VSS VSS VDD VDD _1098_ sky130_fd_sc_hd__a21oi_1
X_2995_ _1096_ _0872_ _1097_ _1098_ _0880_ VSS VSS VDD VDD
+ _1099_ sky130_fd_sc_hd__a221o_2
X_2996_ _0882_ net40 _0883_ VSS VSS VDD VDD _1100_ sky130_fd_sc_hd__a21oi_2
X_2997_ _0870_ _1095_ _1099_ _1100_ _0886_ VSS VSS VDD VDD
+ _1101_ sky130_fd_sc_hd__a221oi_4
X_2998_ _0886_ net110 VSS VSS VDD VDD _1102_ sky130_fd_sc_hd__nand2_1
X_2999_ _0890_ _1102_ VSS VSS VDD VDD _1103_ sky130_fd_sc_hd__nand2_1
X_3000_ net182 VSS VSS VDD VDD _1104_ sky130_fd_sc_hd__inv_1
X_3001_ net146 _0894_ _0892_ VSS VSS VDD VDD _1105_ sky130_fd_sc_hd__nor3b_1
X_3002_ _1104_ _0895_ _1105_ VSS VSS VDD VDD _1106_ sky130_fd_sc_hd__a21oi_1
X_3003_ _1101_ _1103_ _1106_ VSS VSS VDD VDD net289 sky130_fd_sc_hd__o21a_1
X_3004_ _0869_ VSS VSS VDD VDD _1107_ sky130_fd_sc_hd__buf_2
X_3005_ net76 VSS VSS VDD VDD _1108_ sky130_fd_sc_hd__inv_1
X_3006_ net261 VSS VSS VDD VDD _1109_ sky130_fd_sc_hd__inv_1
X_3007_ net1 VSS VSS VDD VDD _1110_ sky130_fd_sc_hd__buf_2
X_3008_ _1071_ _1110_ net190 VSS VSS VDD VDD _1111_ sky130_fd_sc_hd__nand3b_1
X_3009_ net226 _1061_ _1073_ VSS VSS VDD VDD _1112_ sky130_fd_sc_hd__a21oi_1
X_3010_ _1109_ _1070_ _1111_ _1112_ _1075_ VSS VSS VDD VDD
+ _1113_ sky130_fd_sc_hd__a221o_1
X_3011_ _0879_ VSS VSS VDD VDD _1114_ sky130_fd_sc_hd__buf_2
X_3012_ _1114_ net41 _1077_ VSS VSS VDD VDD _1115_ sky130_fd_sc_hd__a21oi_1
X_3013_ _1107_ _1108_ _1113_ _1115_ _1079_ VSS VSS VDD VDD
+ _1116_ sky130_fd_sc_hd__a221o_1
X_3014_ _1027_ net111 VSS VSS VDD VDD _1117_ sky130_fd_sc_hd__nand2_1
X_3015_ net148 _1082_ VSS VSS VDD VDD _1118_ sky130_fd_sc_hd__nand2b_1
X_3016_ _1118_ net183 _1008_ VSS VSS VDD VDD _1119_ sky130_fd_sc_hd__mux2i_1
X_3017_ _1020_ _1116_ _1117_ _1119_ VSS VSS VDD VDD net290
+ sky130_fd_sc_hd__a31oi_1
X_3018_ net77 VSS VSS VDD VDD _1120_ sky130_fd_sc_hd__inv_1
X_3019_ net262 VSS VSS VDD VDD _1121_ sky130_fd_sc_hd__inv_1
X_3020_ _1071_ _1110_ net191 VSS VSS VDD VDD _1122_ sky130_fd_sc_hd__nand3b_1
X_3021_ net227 _1061_ _1073_ VSS VSS VDD VDD _1123_ sky130_fd_sc_hd__a21oi_1
X_3022_ _1121_ _1070_ _1122_ _1123_ _1075_ VSS VSS VDD VDD
+ _1124_ sky130_fd_sc_hd__a221o_1
X_3023_ _1114_ net42 _1077_ VSS VSS VDD VDD _1125_ sky130_fd_sc_hd__a21oi_1
X_3024_ _1107_ _1120_ _1124_ _1125_ _1079_ VSS VSS VDD VDD
+ _1126_ sky130_fd_sc_hd__a221o_1
X_3025_ _1027_ net112 VSS VSS VDD VDD _1127_ sky130_fd_sc_hd__nand2_1
X_3026_ net149 _1082_ VSS VSS VDD VDD _1128_ sky130_fd_sc_hd__nand2b_1
X_3027_ _1128_ net184 _1008_ VSS VSS VDD VDD _1129_ sky130_fd_sc_hd__mux2i_1
X_3028_ _1020_ _1126_ _1127_ _1129_ VSS VSS VDD VDD net291
+ sky130_fd_sc_hd__a31oi_1
X_3029_ _1071_ _1110_ net192 VSS VSS VDD VDD _1130_ sky130_fd_sc_hd__nand3b_1
X_3030_ net197 _1061_ _1073_ VSS VSS VDD VDD _1131_ sky130_fd_sc_hd__a21oi_1
X_3031_ _0740_ _1070_ _1130_ _1131_ _1075_ VSS VSS VDD VDD
+ _1132_ sky130_fd_sc_hd__a221o_1
X_3032_ _1114_ net267 _1077_ VSS VSS VDD VDD _1133_ sky130_fd_sc_hd__a21oi_1
X_3033_ _1107_ _1356_ _1132_ _1133_ _1079_ VSS VSS VDD VDD
+ _1134_ sky130_fd_sc_hd__a221o_1
X_3034_ _1027_ net83 VSS VSS VDD VDD _1135_ sky130_fd_sc_hd__nand2_1
X_3035_ net118 _0894_ _0892_ VSS VSS VDD VDD _1136_ sky130_fd_sc_hd__nor3b_1
X_3036_ _0463_ _0894_ _1136_ VSS VSS VDD VDD _1137_ sky130_fd_sc_hd__a21o_1
X_3037_ _1020_ _1134_ _1135_ _1137_ VSS VSS VDD VDD net292
+ sky130_fd_sc_hd__a31oi_2
X_3038_ net263 VSS VSS VDD VDD _1138_ sky130_fd_sc_hd__inv_1
X_3039_ _1071_ _1110_ net193 VSS VSS VDD VDD _1139_ sky130_fd_sc_hd__nand3b_1
X_3040_ net228 _1061_ _1073_ VSS VSS VDD VDD _1140_ sky130_fd_sc_hd__a21oi_1
X_3041_ _1138_ _1070_ _1139_ _1140_ _1075_ VSS VSS VDD VDD
+ _1141_ sky130_fd_sc_hd__a221o_1
X_3042_ _1114_ net43 _1077_ VSS VSS VDD VDD _1142_ sky130_fd_sc_hd__a21oi_1
X_3043_ _1107_ _1480_ _1141_ _1142_ _1079_ VSS VSS VDD VDD
+ _1143_ sky130_fd_sc_hd__a221o_1
X_3044_ _0888_ net114 VSS VSS VDD VDD _1144_ sky130_fd_sc_hd__nand2_1
X_3045_ _0892_ _0455_ VSS VSS VDD VDD _1145_ sky130_fd_sc_hd__nand2_1
X_3046_ _1145_ net185 _0973_ VSS VSS VDD VDD _1146_ sky130_fd_sc_hd__mux2i_1
X_3047_ _0891_ _1143_ _1144_ _1146_ VSS VSS VDD VDD net293
+ sky130_fd_sc_hd__a31oi_1
X_3048_ net264 VSS VSS VDD VDD _1147_ sky130_fd_sc_hd__inv_1
X_3049_ _1071_ _1110_ net194 VSS VSS VDD VDD _1148_ sky130_fd_sc_hd__nand3b_1
X_3050_ net229 _1061_ _1073_ VSS VSS VDD VDD _1149_ sky130_fd_sc_hd__a21oi_1
X_3051_ _1147_ _1070_ _1148_ _1149_ _1075_ VSS VSS VDD VDD
+ _1150_ sky130_fd_sc_hd__a221o_1
X_3052_ _1114_ net44 _1077_ VSS VSS VDD VDD _1151_ sky130_fd_sc_hd__a21oi_1
X_3053_ _1107_ _1476_ _1150_ _1151_ _1079_ VSS VSS VDD VDD
+ _1152_ sky130_fd_sc_hd__a221o_1
X_3054_ _0888_ net115 VSS VSS VDD VDD _1153_ sky130_fd_sc_hd__nand2_1
X_3055_ net151 _1082_ VSS VSS VDD VDD _1154_ sky130_fd_sc_hd__nand2b_1
X_3056_ _1154_ net186 _0973_ VSS VSS VDD VDD _1155_ sky130_fd_sc_hd__mux2i_1
X_3057_ _0891_ _1152_ _1153_ _1155_ VSS VSS VDD VDD net294
+ sky130_fd_sc_hd__a31oi_1
X_3058_ _1071_ _1110_ net203 VSS VSS VDD VDD _1156_ sky130_fd_sc_hd__nand3b_1
X_3059_ net198 _1061_ _1073_ VSS VSS VDD VDD _1157_ sky130_fd_sc_hd__a21oi_1
X_3060_ _0739_ _1070_ _1156_ _1157_ _1075_ VSS VSS VDD VDD
+ _1158_ sky130_fd_sc_hd__a221o_1
X_3061_ _1114_ net268 _1077_ VSS VSS VDD VDD _1159_ sky130_fd_sc_hd__a21oi_1
X_3062_ _1107_ _1362_ _1158_ _1159_ _1079_ VSS VSS VDD VDD
+ _1160_ sky130_fd_sc_hd__a221o_2
X_3063_ _0888_ net84 VSS VSS VDD VDD _1161_ sky130_fd_sc_hd__nand2_1
X_3064_ net119 _1082_ VSS VSS VDD VDD _1162_ sky130_fd_sc_hd__nand2b_1
X_3065_ _1162_ net155 _0973_ VSS VSS VDD VDD _1163_ sky130_fd_sc_hd__mux2i_1
X_3066_ _0891_ _1160_ _1161_ _1163_ VSS VSS VDD VDD net295
+ sky130_fd_sc_hd__a31oi_1
X_3067_ _1071_ _1110_ net214 VSS VSS VDD VDD _1164_ sky130_fd_sc_hd__nand3b_1
X_3068_ net199 _1061_ _1073_ VSS VSS VDD VDD _1165_ sky130_fd_sc_hd__a21oi_1
X_3069_ _0747_ _1070_ _1164_ _1165_ _1075_ VSS VSS VDD VDD
+ _1166_ sky130_fd_sc_hd__a221o_1
X_3070_ _1114_ net15 _1077_ VSS VSS VDD VDD _1167_ sky130_fd_sc_hd__a21oi_1
X_3071_ _1107_ _1367_ _1166_ _1167_ _1079_ VSS VSS VDD VDD
+ _1168_ sky130_fd_sc_hd__a221o_2
X_3072_ _0888_ net85 VSS VSS VDD VDD _1169_ sky130_fd_sc_hd__nand2_1
X_3073_ net120 _1082_ VSS VSS VDD VDD _1170_ sky130_fd_sc_hd__nand2b_1
X_3074_ _1170_ net156 _0973_ VSS VSS VDD VDD _1171_ sky130_fd_sc_hd__mux2i_1
X_3075_ _0891_ _1168_ _1169_ _1171_ VSS VSS VDD VDD net296
+ sky130_fd_sc_hd__a31oi_1
X_3076_ _1071_ _1110_ net225 VSS VSS VDD VDD _1172_ sky130_fd_sc_hd__nand3b_1
X_3077_ net200 _0899_ _1073_ VSS VSS VDD VDD _1173_ sky130_fd_sc_hd__a21oi_1
X_3078_ _0754_ _1070_ _1172_ _1173_ _1075_ VSS VSS VDD VDD
+ _1174_ sky130_fd_sc_hd__a221o_1
X_3079_ _1114_ net16 _1077_ VSS VSS VDD VDD _1175_ sky130_fd_sc_hd__a21oi_1
X_3080_ _1107_ _1370_ _1174_ _1175_ _1079_ VSS VSS VDD VDD
+ _1176_ sky130_fd_sc_hd__a221o_2
X_3081_ _0888_ net86 VSS VSS VDD VDD _1177_ sky130_fd_sc_hd__nand2_1
X_3082_ net121 _1082_ VSS VSS VDD VDD _1178_ sky130_fd_sc_hd__nand2b_1
X_3083_ _1178_ net157 _0973_ VSS VSS VDD VDD _1179_ sky130_fd_sc_hd__mux2i_1
X_3084_ _0891_ _1176_ _1177_ _1179_ VSS VSS VDD VDD net297
+ sky130_fd_sc_hd__a31oi_1
X_3085_ net237 VSS VSS VDD VDD _1180_ sky130_fd_sc_hd__inv_1
X_3086_ _0873_ _1110_ net236 VSS VSS VDD VDD _1181_ sky130_fd_sc_hd__nand3b_1
X_3087_ net201 _0899_ _0871_ VSS VSS VDD VDD _1182_ sky130_fd_sc_hd__a21oi_1
X_3088_ _1180_ _0877_ _1181_ _1182_ _0879_ VSS VSS VDD VDD
+ _1183_ sky130_fd_sc_hd__a221o_1
X_3089_ _1114_ net17 _0869_ VSS VSS VDD VDD _1184_ sky130_fd_sc_hd__a21oi_1
X_3090_ _1107_ _1373_ _1183_ _1184_ _0885_ VSS VSS VDD VDD
+ _1185_ sky130_fd_sc_hd__a221o_2
X_3091_ _0888_ net87 VSS VSS VDD VDD _1186_ sky130_fd_sc_hd__nand2_1
X_3092_ net122 _1082_ VSS VSS VDD VDD _1187_ sky130_fd_sc_hd__nand2b_1
X_3093_ _1187_ net159 _0973_ VSS VSS VDD VDD _1188_ sky130_fd_sc_hd__mux2i_1
X_3094_ _0891_ _1185_ _1186_ _1188_ VSS VSS VDD VDD net298
+ sky130_fd_sc_hd__a31oi_1
X_3095_ net53 VSS VSS VDD VDD _1189_ sky130_fd_sc_hd__inv_1
X_3096_ _0873_ _1110_ net247 VSS VSS VDD VDD _1190_ sky130_fd_sc_hd__nand3b_1
X_3097_ net202 _0899_ _0871_ VSS VSS VDD VDD _1191_ sky130_fd_sc_hd__a21oi_1
X_3098_ _0760_ _0877_ _1190_ _1191_ _0879_ VSS VSS VDD VDD
+ _1192_ sky130_fd_sc_hd__a221o_1
X_3099_ _1114_ net18 _0869_ VSS VSS VDD VDD _1193_ sky130_fd_sc_hd__a21oi_1
X_3100_ _1107_ _1189_ _1192_ _1193_ _0885_ VSS VSS VDD VDD
+ _1194_ sky130_fd_sc_hd__a221o_2
X_3101_ _0888_ net88 VSS VSS VDD VDD _1195_ sky130_fd_sc_hd__nand2_1
X_3102_ net123 _1082_ VSS VSS VDD VDD _1196_ sky130_fd_sc_hd__nand2b_1
X_3103_ _1196_ net160 _0973_ VSS VSS VDD VDD _1197_ sky130_fd_sc_hd__mux2i_1
X_3104_ _0891_ _1194_ _1195_ _1197_ VSS VSS VDD VDD net299
+ sky130_fd_sc_hd__a31oi_1
X_3105_ _0873_ net1 net258 VSS VSS VDD VDD _1198_ sky130_fd_sc_hd__nand3b_1
X_3106_ net204 _0899_ _0871_ VSS VSS VDD VDD _1199_ sky130_fd_sc_hd__a21oi_1
X_3107_ _0764_ _0877_ _1198_ _1199_ _0879_ VSS VSS VDD VDD
+ _1200_ sky130_fd_sc_hd__a221o_1
X_3108_ _0880_ net19 _0869_ VSS VSS VDD VDD _1201_ sky130_fd_sc_hd__a21oi_1
X_3109_ _0883_ _1380_ _1200_ _1201_ _0885_ VSS VSS VDD VDD
+ _1202_ sky130_fd_sc_hd__a221o_2
X_3110_ _0888_ net89 VSS VSS VDD VDD _1203_ sky130_fd_sc_hd__nand2_1
X_3111_ net126 net2 VSS VSS VDD VDD _1204_ sky130_fd_sc_hd__nand2b_1
X_3112_ _1204_ net161 _0973_ VSS VSS VDD VDD _1205_ sky130_fd_sc_hd__mux2i_1
X_3113_ _0891_ _1202_ _1203_ _1205_ VSS VSS VDD VDD net300
+ sky130_fd_sc_hd__a31oi_1
X_3114_ net55 VSS VSS VDD VDD _1206_ sky130_fd_sc_hd__inv_1
X_3115_ _0873_ net1 net269 VSS VSS VDD VDD _1207_ sky130_fd_sc_hd__nand3b_1
X_3116_ net205 _0899_ _0871_ VSS VSS VDD VDD _1208_ sky130_fd_sc_hd__a21oi_1
X_3117_ _0763_ _0877_ _1207_ _1208_ _0879_ VSS VSS VDD VDD
+ _1209_ sky130_fd_sc_hd__a221o_1
X_3118_ _0880_ net20 _0869_ VSS VSS VDD VDD _1210_ sky130_fd_sc_hd__a21oi_1
X_3119_ _0883_ _1206_ _1209_ _1210_ _0885_ VSS VSS VDD VDD
+ _1211_ sky130_fd_sc_hd__a221o_2
X_3120_ _0888_ net90 VSS VSS VDD VDD _1212_ sky130_fd_sc_hd__nand2_1
X_3121_ net127 net2 VSS VSS VDD VDD _1213_ sky130_fd_sc_hd__nand2b_1
X_3122_ _1213_ net162 _0973_ VSS VSS VDD VDD _1214_ sky130_fd_sc_hd__mux2i_1
X_3123_ _0891_ _1211_ _1212_ _1214_ VSS VSS VDD VDD net301
+ sky130_fd_sc_hd__a31oi_1
X_3124_ net195 net196 VSS VSS VDD VDD _1538_ _1539_ sky130_fd_sc_hd__ha_1
X_3125_ net14 net125 VSS VSS VDD VDD _1540_ _1541_ sky130_fd_sc_hd__ha_1
X_3126_ net152 net153 VSS VSS VDD VDD _1542_ _1543_ sky130_fd_sc_hd__ha_1
X_3127_ net116 net117 VSS VSS VDD VDD _1544_ _1545_ sky130_fd_sc_hd__ha_2
X_3128_ net81 net82 VSS VSS VDD VDD _1546_ _1547_ sky130_fd_sc_hd__ha_1
X_3129_ net45 net46 VSS VSS VDD VDD _1548_ _1549_ sky130_fd_sc_hd__ha_2
X_3130_ net265 net266 VSS VSS VDD VDD _1550_ _1551_ sky130_fd_sc_hd__ha_1
X_3131_ net230 net231 VSS VSS VDD VDD _1552_ _1553_ sky130_fd_sc_hd__ha_1
Xcounters\[0\]$_DFFE_PN0P_ clknet_leaf_26_clk _0000_ net13
+ VSS VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_4
Xcounters\[100\]$_DFFE_PN0P_ clknet_leaf_18_clk _0001_ net13
+ VSS VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_4
Xcounters\[101\]$_DFFE_PN0P_ clknet_leaf_19_clk _0002_ net13
+ VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_2
Xcounters\[102\]$_DFFE_PN0P_ clknet_leaf_19_clk _0003_ net13
+ VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_2
Xcounters\[103\]$_DFFE_PN0P_ clknet_leaf_19_clk _0004_ net13
+ VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_2
Xcounters\[104\]$_DFFE_PN0P_ clknet_leaf_19_clk _0005_ net13
+ VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfrtp_2
Xcounters\[105\]$_DFFE_PN0P_ clknet_leaf_19_clk _0006_ net13
+ VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_2
Xcounters\[106\]$_DFFE_PN0P_ clknet_leaf_19_clk _0007_ net13
+ VSS VSS VDD VDD net21 sky130_fd_sc_hd__dfrtp_1
Xcounters\[107\]$_DFFE_PN0P_ clknet_leaf_19_clk _0008_ net13
+ VSS VSS VDD VDD net22 sky130_fd_sc_hd__dfrtp_2
Xcounters\[108\]$_DFFE_PN0P_ clknet_leaf_18_clk _0009_ net13
+ VSS VSS VDD VDD net23 sky130_fd_sc_hd__dfrtp_1
Xcounters\[109\]$_DFFE_PN0P_ clknet_leaf_19_clk _0010_ net13
+ VSS VSS VDD VDD net24 sky130_fd_sc_hd__dfrtp_4
Xcounters\[10\]$_DFFE_PN0P_ clknet_leaf_22_clk _0011_ net13
+ VSS VSS VDD VDD net25 sky130_fd_sc_hd__dfrtp_4
Xcounters\[110\]$_DFFE_PN0P_ clknet_leaf_18_clk _0012_ net13
+ VSS VSS VDD VDD net26 sky130_fd_sc_hd__dfrtp_1
Xcounters\[111\]$_DFFE_PN0P_ clknet_leaf_18_clk _0013_ net13
+ VSS VSS VDD VDD net27 sky130_fd_sc_hd__dfrtp_4
Xcounters\[112\]$_DFFE_PN0P_ clknet_leaf_20_clk _0014_ net13
+ VSS VSS VDD VDD net28 sky130_fd_sc_hd__dfrtp_2
Xcounters\[113\]$_DFFE_PN0P_ clknet_leaf_18_clk _0015_ net13
+ VSS VSS VDD VDD net29 sky130_fd_sc_hd__dfrtp_2
Xcounters\[114\]$_DFFE_PN0P_ clknet_leaf_18_clk _0016_ net13
+ VSS VSS VDD VDD net30 sky130_fd_sc_hd__dfrtp_2
Xcounters\[115\]$_DFFE_PN0P_ clknet_leaf_18_clk _0017_ net13
+ VSS VSS VDD VDD net31 sky130_fd_sc_hd__dfrtp_2
Xcounters\[116\]$_DFFE_PN0P_ clknet_leaf_18_clk _0018_ net13
+ VSS VSS VDD VDD net32 sky130_fd_sc_hd__dfrtp_1
Xcounters\[117\]$_DFFE_PN0P_ clknet_leaf_18_clk _0019_ net13
+ VSS VSS VDD VDD net33 sky130_fd_sc_hd__dfrtp_4
Xcounters\[118\]$_DFFE_PN0P_ clknet_leaf_17_clk _0020_ net13
+ VSS VSS VDD VDD net34 sky130_fd_sc_hd__dfrtp_2
Xcounters\[119\]$_DFFE_PN0P_ clknet_leaf_17_clk _0021_ net13
+ VSS VSS VDD VDD net35 sky130_fd_sc_hd__dfrtp_2
Xcounters\[11\]$_DFFE_PN0P_ clknet_leaf_25_clk _0022_ net13
+ VSS VSS VDD VDD net36 sky130_fd_sc_hd__dfrtp_2
Xcounters\[120\]$_DFFE_PN0P_ clknet_leaf_17_clk _0023_ net13
+ VSS VSS VDD VDD net37 sky130_fd_sc_hd__dfrtp_1
Xcounters\[121\]$_DFFE_PN0P_ clknet_leaf_17_clk _0024_ net13
+ VSS VSS VDD VDD net38 sky130_fd_sc_hd__dfrtp_2
Xcounters\[122\]$_DFFE_PN0P_ clknet_leaf_17_clk _0025_ net13
+ VSS VSS VDD VDD net39 sky130_fd_sc_hd__dfrtp_2
Xcounters\[123\]$_DFFE_PN0P_ clknet_leaf_17_clk _0026_ net13
+ VSS VSS VDD VDD net40 sky130_fd_sc_hd__dfrtp_2
Xcounters\[124\]$_DFFE_PN0P_ clknet_leaf_17_clk _0027_ net13
+ VSS VSS VDD VDD net41 sky130_fd_sc_hd__dfrtp_1
Xcounters\[125\]$_DFFE_PN0P_ clknet_leaf_17_clk _0028_ net13
+ VSS VSS VDD VDD net42 sky130_fd_sc_hd__dfrtp_1
Xcounters\[126\]$_DFFE_PN0P_ clknet_leaf_18_clk _0029_ net13
+ VSS VSS VDD VDD net43 sky130_fd_sc_hd__dfrtp_1
Xcounters\[127\]$_DFFE_PN0P_ clknet_leaf_17_clk _0030_ net13
+ VSS VSS VDD VDD net44 sky130_fd_sc_hd__dfrtp_1
Xcounters\[128\]$_DFFE_PN0P_ clknet_leaf_20_clk _0031_ net13
+ VSS VSS VDD VDD net45 sky130_fd_sc_hd__dfrtp_2
Xcounters\[129\]$_DFFE_PN0P_ clknet_leaf_20_clk _0032_ net13
+ VSS VSS VDD VDD net46 sky130_fd_sc_hd__dfrtp_2
Xcounters\[12\]$_DFFE_PN0P_ clknet_leaf_21_clk _0033_ net13
+ VSS VSS VDD VDD net47 sky130_fd_sc_hd__dfrtp_4
Xcounters\[130\]$_DFFE_PN0P_ clknet_leaf_21_clk _0034_ net13
+ VSS VSS VDD VDD net48 sky130_fd_sc_hd__dfrtp_1
Xcounters\[131\]$_DFFE_PN0P_ clknet_leaf_20_clk _0035_ net13
+ VSS VSS VDD VDD net49 sky130_fd_sc_hd__dfrtp_4
Xcounters\[132\]$_DFFE_PN0P_ clknet_leaf_20_clk _0036_ net13
+ VSS VSS VDD VDD net50 sky130_fd_sc_hd__dfrtp_2
Xcounters\[133\]$_DFFE_PN0P_ clknet_leaf_20_clk _0037_ net13
+ VSS VSS VDD VDD net51 sky130_fd_sc_hd__dfrtp_2
Xcounters\[134\]$_DFFE_PN0P_ clknet_leaf_14_clk _0038_ net13
+ VSS VSS VDD VDD net52 sky130_fd_sc_hd__dfrtp_2
Xcounters\[135\]$_DFFE_PN0P_ clknet_leaf_21_clk _0039_ net13
+ VSS VSS VDD VDD net53 sky130_fd_sc_hd__dfrtp_4
Xcounters\[136\]$_DFFE_PN0P_ clknet_leaf_20_clk _0040_ net13
+ VSS VSS VDD VDD net54 sky130_fd_sc_hd__dfrtp_2
Xcounters\[137\]$_DFFE_PN0P_ clknet_leaf_21_clk _0041_ net13
+ VSS VSS VDD VDD net55 sky130_fd_sc_hd__dfrtp_2
Xcounters\[138\]$_DFFE_PN0P_ clknet_leaf_14_clk _0042_ net13
+ VSS VSS VDD VDD net56 sky130_fd_sc_hd__dfrtp_1
Xcounters\[139\]$_DFFE_PN0P_ clknet_leaf_14_clk _0043_ net13
+ VSS VSS VDD VDD net57 sky130_fd_sc_hd__dfrtp_2
Xcounters\[13\]$_DFFE_PN0P_ clknet_leaf_21_clk _0044_ net13
+ VSS VSS VDD VDD net58 sky130_fd_sc_hd__dfrtp_4
Xcounters\[140\]$_DFFE_PN0P_ clknet_leaf_15_clk _0045_ net13
+ VSS VSS VDD VDD net59 sky130_fd_sc_hd__dfrtp_2
Xcounters\[141\]$_DFFE_PN0P_ clknet_leaf_14_clk _0046_ net13
+ VSS VSS VDD VDD net60 sky130_fd_sc_hd__dfrtp_2
Xcounters\[142\]$_DFFE_PN0P_ clknet_leaf_15_clk _0047_ net13
+ VSS VSS VDD VDD net61 sky130_fd_sc_hd__dfrtp_2
Xcounters\[143\]$_DFFE_PN0P_ clknet_leaf_14_clk _0048_ net13
+ VSS VSS VDD VDD net62 sky130_fd_sc_hd__dfrtp_4
Xcounters\[144\]$_DFFE_PN0P_ clknet_leaf_12_clk _0049_ net13
+ VSS VSS VDD VDD net63 sky130_fd_sc_hd__dfrtp_2
Xcounters\[145\]$_DFFE_PN0P_ clknet_leaf_13_clk _0050_ net13
+ VSS VSS VDD VDD net64 sky130_fd_sc_hd__dfrtp_2
Xcounters\[146\]$_DFFE_PN0P_ clknet_leaf_15_clk _0051_ net13
+ VSS VSS VDD VDD net65 sky130_fd_sc_hd__dfrtp_4
Xcounters\[147\]$_DFFE_PN0P_ clknet_leaf_15_clk _0052_ net13
+ VSS VSS VDD VDD net66 sky130_fd_sc_hd__dfrtp_2
Xcounters\[148\]$_DFFE_PN0P_ clknet_leaf_15_clk _0053_ net13
+ VSS VSS VDD VDD net67 sky130_fd_sc_hd__dfrtp_1
Xcounters\[149\]$_DFFE_PN0P_ clknet_leaf_15_clk _0054_ net13
+ VSS VSS VDD VDD net68 sky130_fd_sc_hd__dfrtp_1
Xcounters\[14\]$_DFFE_PN0P_ clknet_leaf_20_clk _0055_ net13
+ VSS VSS VDD VDD net69 sky130_fd_sc_hd__dfrtp_4
Xcounters\[150\]$_DFFE_PN0P_ clknet_leaf_15_clk _0056_ net13
+ VSS VSS VDD VDD net70 sky130_fd_sc_hd__dfrtp_1
Xcounters\[151\]$_DFFE_PN0P_ clknet_leaf_16_clk _0057_ net13
+ VSS VSS VDD VDD net71 sky130_fd_sc_hd__dfrtp_2
Xcounters\[152\]$_DFFE_PN0P_ clknet_leaf_15_clk _0058_ net13
+ VSS VSS VDD VDD net72 sky130_fd_sc_hd__dfrtp_2
Xcounters\[153\]$_DFFE_PN0P_ clknet_leaf_16_clk _0059_ net13
+ VSS VSS VDD VDD net73 sky130_fd_sc_hd__dfrtp_1
Xcounters\[154\]$_DFFE_PN0P_ clknet_leaf_16_clk _0060_ net13
+ VSS VSS VDD VDD net74 sky130_fd_sc_hd__dfrtp_1
Xcounters\[155\]$_DFFE_PN0P_ clknet_leaf_16_clk _0061_ net13
+ VSS VSS VDD VDD net75 sky130_fd_sc_hd__dfrtp_2
Xcounters\[156\]$_DFFE_PN0P_ clknet_leaf_16_clk _0062_ net13
+ VSS VSS VDD VDD net76 sky130_fd_sc_hd__dfrtp_1
Xcounters\[157\]$_DFFE_PN0P_ clknet_leaf_16_clk _0063_ net13
+ VSS VSS VDD VDD net77 sky130_fd_sc_hd__dfrtp_1
Xcounters\[158\]$_DFFE_PN0P_ clknet_leaf_16_clk _0064_ net13
+ VSS VSS VDD VDD net78 sky130_fd_sc_hd__dfrtp_1
Xcounters\[159\]$_DFFE_PN0P_ clknet_leaf_15_clk _0065_ net13
+ VSS VSS VDD VDD net79 sky130_fd_sc_hd__dfrtp_1
Xcounters\[15\]$_DFFE_PN0P_ clknet_leaf_21_clk _0066_ net13
+ VSS VSS VDD VDD net80 sky130_fd_sc_hd__dfrtp_2
Xcounters\[160\]$_DFFE_PN0P_ clknet_leaf_4_clk _0067_ net13
+ VSS VSS VDD VDD net81 sky130_fd_sc_hd__dfrtp_4
Xcounters\[161\]$_DFFE_PN0P_ clknet_leaf_2_clk _0068_ net13
+ VSS VSS VDD VDD net82 sky130_fd_sc_hd__dfrtp_4
Xcounters\[162\]$_DFFE_PN0P_ clknet_leaf_2_clk _0069_ net13
+ VSS VSS VDD VDD net83 sky130_fd_sc_hd__dfrtp_4
Xcounters\[163\]$_DFFE_PN0P_ clknet_leaf_4_clk _0070_ net13
+ VSS VSS VDD VDD net84 sky130_fd_sc_hd__dfrtp_4
Xcounters\[164\]$_DFFE_PN0P_ clknet_leaf_4_clk _0071_ net13
+ VSS VSS VDD VDD net85 sky130_fd_sc_hd__dfrtp_4
Xcounters\[165\]$_DFFE_PN0P_ clknet_leaf_4_clk _0072_ net13
+ VSS VSS VDD VDD net86 sky130_fd_sc_hd__dfrtp_2
Xcounters\[166\]$_DFFE_PN0P_ clknet_leaf_4_clk _0073_ net13
+ VSS VSS VDD VDD net87 sky130_fd_sc_hd__dfrtp_4
Xcounters\[167\]$_DFFE_PN0P_ clknet_leaf_4_clk _0074_ net13
+ VSS VSS VDD VDD net88 sky130_fd_sc_hd__dfrtp_2
Xcounters\[168\]$_DFFE_PN0P_ clknet_leaf_4_clk _0075_ net13
+ VSS VSS VDD VDD net89 sky130_fd_sc_hd__dfrtp_2
Xcounters\[169\]$_DFFE_PN0P_ clknet_leaf_4_clk _0076_ net13
+ VSS VSS VDD VDD net90 sky130_fd_sc_hd__dfrtp_2
Xcounters\[16\]$_DFFE_PN0P_ clknet_leaf_0_clk _0077_ net13
+ VSS VSS VDD VDD net91 sky130_fd_sc_hd__dfrtp_4
Xcounters\[170\]$_DFFE_PN0P_ clknet_leaf_4_clk _0078_ net13
+ VSS VSS VDD VDD net92 sky130_fd_sc_hd__dfrtp_2
Xcounters\[171\]$_DFFE_PN0P_ clknet_leaf_5_clk _0079_ net13
+ VSS VSS VDD VDD net93 sky130_fd_sc_hd__dfrtp_2
Xcounters\[172\]$_DFFE_PN0P_ clknet_leaf_5_clk _0080_ net13
+ VSS VSS VDD VDD net94 sky130_fd_sc_hd__dfrtp_1
Xcounters\[173\]$_DFFE_PN0P_ clknet_leaf_5_clk _0081_ net13
+ VSS VSS VDD VDD net95 sky130_fd_sc_hd__dfrtp_1
Xcounters\[174\]$_DFFE_PN0P_ clknet_leaf_6_clk _0082_ net13
+ VSS VSS VDD VDD net96 sky130_fd_sc_hd__dfrtp_4
Xcounters\[175\]$_DFFE_PN0P_ clknet_leaf_5_clk _0083_ net13
+ VSS VSS VDD VDD net97 sky130_fd_sc_hd__dfrtp_4
Xcounters\[176\]$_DFFE_PN0P_ clknet_leaf_5_clk _0084_ net13
+ VSS VSS VDD VDD net98 sky130_fd_sc_hd__dfrtp_2
Xcounters\[177\]$_DFFE_PN0P_ clknet_leaf_5_clk _0085_ net13
+ VSS VSS VDD VDD net99 sky130_fd_sc_hd__dfrtp_2
Xcounters\[178\]$_DFFE_PN0P_ clknet_leaf_5_clk _0086_ net13
+ VSS VSS VDD VDD net100 sky130_fd_sc_hd__dfrtp_2
Xcounters\[179\]$_DFFE_PN0P_ clknet_leaf_5_clk _0087_ net13
+ VSS VSS VDD VDD net101 sky130_fd_sc_hd__dfrtp_1
Xcounters\[17\]$_DFFE_PN0P_ clknet_leaf_0_clk _0088_ net13
+ VSS VSS VDD VDD net102 sky130_fd_sc_hd__dfrtp_4
Xcounters\[180\]$_DFFE_PN0P_ clknet_leaf_5_clk _0089_ net13
+ VSS VSS VDD VDD net103 sky130_fd_sc_hd__dfrtp_4
Xcounters\[181\]$_DFFE_PN0P_ clknet_leaf_2_clk _0090_ net13
+ VSS VSS VDD VDD net104 sky130_fd_sc_hd__dfrtp_2
Xcounters\[182\]$_DFFE_PN0P_ clknet_leaf_6_clk _0091_ net13
+ VSS VSS VDD VDD net105 sky130_fd_sc_hd__dfrtp_2
Xcounters\[183\]$_DFFE_PN0P_ clknet_leaf_6_clk _0092_ net13
+ VSS VSS VDD VDD net106 sky130_fd_sc_hd__dfrtp_4
Xcounters\[184\]$_DFFE_PN0P_ clknet_leaf_0_clk _0093_ net13
+ VSS VSS VDD VDD net107 sky130_fd_sc_hd__dfrtp_4
Xcounters\[185\]$_DFFE_PN0P_ clknet_leaf_6_clk _0094_ net13
+ VSS VSS VDD VDD net108 sky130_fd_sc_hd__dfrtp_2
Xcounters\[186\]$_DFFE_PN0P_ clknet_leaf_6_clk _0095_ net13
+ VSS VSS VDD VDD net109 sky130_fd_sc_hd__dfrtp_2
Xcounters\[187\]$_DFFE_PN0P_ clknet_leaf_6_clk _0096_ net13
+ VSS VSS VDD VDD net110 sky130_fd_sc_hd__dfrtp_4
Xcounters\[188\]$_DFFE_PN0P_ clknet_leaf_6_clk _0097_ net13
+ VSS VSS VDD VDD net111 sky130_fd_sc_hd__dfrtp_2
Xcounters\[189\]$_DFFE_PN0P_ clknet_leaf_6_clk _0098_ net13
+ VSS VSS VDD VDD net112 sky130_fd_sc_hd__dfrtp_2
Xcounters\[18\]$_DFFE_PN0P_ clknet_leaf_7_clk _0099_ net13
+ VSS VSS VDD VDD net113 sky130_fd_sc_hd__dfrtp_4
Xcounters\[190\]$_DFFE_PN0P_ clknet_leaf_6_clk _0100_ net13
+ VSS VSS VDD VDD net114 sky130_fd_sc_hd__dfrtp_1
Xcounters\[191\]$_DFFE_PN0P_ clknet_leaf_6_clk _0101_ net13
+ VSS VSS VDD VDD net115 sky130_fd_sc_hd__dfrtp_1
Xcounters\[192\]$_DFFE_PN0P_ clknet_leaf_8_clk _0102_ net13
+ VSS VSS VDD VDD net116 sky130_fd_sc_hd__dfrtp_2
Xcounters\[193\]$_DFFE_PN0P_ clknet_leaf_8_clk _0103_ net13
+ VSS VSS VDD VDD net117 sky130_fd_sc_hd__dfrtp_2
Xcounters\[194\]$_DFFE_PN0P_ clknet_leaf_6_clk _0104_ net13
+ VSS VSS VDD VDD net118 sky130_fd_sc_hd__dfrtp_2
Xcounters\[195\]$_DFFE_PN0P_ clknet_leaf_9_clk _0105_ net13
+ VSS VSS VDD VDD net119 sky130_fd_sc_hd__dfrtp_2
Xcounters\[196\]$_DFFE_PN0P_ clknet_leaf_9_clk _0106_ net13
+ VSS VSS VDD VDD net120 sky130_fd_sc_hd__dfrtp_2
Xcounters\[197\]$_DFFE_PN0P_ clknet_leaf_9_clk _0107_ net13
+ VSS VSS VDD VDD net121 sky130_fd_sc_hd__dfrtp_1
Xcounters\[198\]$_DFFE_PN0P_ clknet_leaf_9_clk _0108_ net13
+ VSS VSS VDD VDD net122 sky130_fd_sc_hd__dfrtp_2
Xcounters\[199\]$_DFFE_PN0P_ clknet_leaf_5_clk _0109_ net13
+ VSS VSS VDD VDD net123 sky130_fd_sc_hd__dfrtp_2
Xcounters\[19\]$_DFFE_PN0P_ clknet_leaf_7_clk _0110_ net13
+ VSS VSS VDD VDD net124 sky130_fd_sc_hd__dfrtp_2
Xcounters\[1\]$_DFFE_PN0P_ clknet_leaf_26_clk _0111_ net13
+ VSS VSS VDD VDD net125 sky130_fd_sc_hd__dfrtp_4
Xcounters\[200\]$_DFFE_PN0P_ clknet_leaf_9_clk _0112_ net13
+ VSS VSS VDD VDD net126 sky130_fd_sc_hd__dfrtp_1
Xcounters\[201\]$_DFFE_PN0P_ clknet_leaf_5_clk _0113_ net13
+ VSS VSS VDD VDD net127 sky130_fd_sc_hd__dfrtp_1
Xcounters\[202\]$_DFFE_PN0P_ clknet_leaf_8_clk _0114_ net13
+ VSS VSS VDD VDD net128 sky130_fd_sc_hd__dfrtp_1
Xcounters\[203\]$_DFFE_PN0P_ clknet_leaf_9_clk _0115_ net13
+ VSS VSS VDD VDD net129 sky130_fd_sc_hd__dfrtp_2
Xcounters\[204\]$_DFFE_PN0P_ clknet_leaf_9_clk _0116_ net13
+ VSS VSS VDD VDD net130 sky130_fd_sc_hd__dfrtp_1
Xcounters\[205\]$_DFFE_PN0P_ clknet_leaf_9_clk _0117_ net13
+ VSS VSS VDD VDD net131 sky130_fd_sc_hd__dfrtp_1
Xcounters\[206\]$_DFFE_PN0P_ clknet_leaf_10_clk _0118_ net13
+ VSS VSS VDD VDD net132 sky130_fd_sc_hd__dfrtp_2
Xcounters\[207\]$_DFFE_PN0P_ clknet_leaf_9_clk _0119_ net13
+ VSS VSS VDD VDD net133 sky130_fd_sc_hd__dfrtp_2
Xcounters\[208\]$_DFFE_PN0P_ clknet_leaf_10_clk _0120_ net13
+ VSS VSS VDD VDD net134 sky130_fd_sc_hd__dfrtp_2
Xcounters\[209\]$_DFFE_PN0P_ clknet_leaf_10_clk _0121_ net13
+ VSS VSS VDD VDD net135 sky130_fd_sc_hd__dfrtp_1
Xcounters\[20\]$_DFFE_PN0P_ clknet_leaf_7_clk _0122_ net13
+ VSS VSS VDD VDD net136 sky130_fd_sc_hd__dfrtp_4
Xcounters\[210\]$_DFFE_PN0P_ clknet_leaf_8_clk _0123_ net13
+ VSS VSS VDD VDD net137 sky130_fd_sc_hd__dfrtp_2
Xcounters\[211\]$_DFFE_PN0P_ clknet_leaf_10_clk _0124_ net13
+ VSS VSS VDD VDD net138 sky130_fd_sc_hd__dfrtp_2
Xcounters\[212\]$_DFFE_PN0P_ clknet_leaf_10_clk _0125_ net13
+ VSS VSS VDD VDD net139 sky130_fd_sc_hd__dfrtp_1
Xcounters\[213\]$_DFFE_PN0P_ clknet_leaf_10_clk _0126_ net13
+ VSS VSS VDD VDD net140 sky130_fd_sc_hd__dfrtp_2
Xcounters\[214\]$_DFFE_PN0P_ clknet_leaf_10_clk _0127_ net13
+ VSS VSS VDD VDD net141 sky130_fd_sc_hd__dfrtp_1
Xcounters\[215\]$_DFFE_PN0P_ clknet_leaf_10_clk _0128_ net13
+ VSS VSS VDD VDD net142 sky130_fd_sc_hd__dfrtp_2
Xcounters\[216\]$_DFFE_PN0P_ clknet_leaf_11_clk _0129_ net13
+ VSS VSS VDD VDD net143 sky130_fd_sc_hd__dfrtp_2
Xcounters\[217\]$_DFFE_PN0P_ clknet_leaf_11_clk _0130_ net13
+ VSS VSS VDD VDD net144 sky130_fd_sc_hd__dfrtp_1
Xcounters\[218\]$_DFFE_PN0P_ clknet_leaf_11_clk _0131_ net13
+ VSS VSS VDD VDD net145 sky130_fd_sc_hd__dfrtp_1
Xcounters\[219\]$_DFFE_PN0P_ clknet_leaf_11_clk _0132_ net13
+ VSS VSS VDD VDD net146 sky130_fd_sc_hd__dfrtp_2
Xcounters\[21\]$_DFFE_PN0P_ clknet_leaf_7_clk _0133_ net13
+ VSS VSS VDD VDD net147 sky130_fd_sc_hd__dfrtp_4
Xcounters\[220\]$_DFFE_PN0P_ clknet_leaf_10_clk _0134_ net13
+ VSS VSS VDD VDD net148 sky130_fd_sc_hd__dfrtp_2
Xcounters\[221\]$_DFFE_PN0P_ clknet_leaf_10_clk _0135_ net13
+ VSS VSS VDD VDD net149 sky130_fd_sc_hd__dfrtp_1
Xcounters\[222\]$_DFFE_PN0P_ clknet_leaf_11_clk _0136_ net13
+ VSS VSS VDD VDD net150 sky130_fd_sc_hd__dfrtp_1
Xcounters\[223\]$_DFFE_PN0P_ clknet_leaf_10_clk _0137_ net13
+ VSS VSS VDD VDD net151 sky130_fd_sc_hd__dfrtp_1
Xcounters\[224\]$_DFFE_PN0P_ clknet_leaf_7_clk _0138_ net13
+ VSS VSS VDD VDD net152 sky130_fd_sc_hd__dfrtp_4
Xcounters\[225\]$_DFFE_PN0P_ clknet_leaf_7_clk _0139_ net13
+ VSS VSS VDD VDD net153 sky130_fd_sc_hd__dfrtp_4
Xcounters\[226\]$_DFFE_PN0P_ clknet_leaf_7_clk _0140_ net13
+ VSS VSS VDD VDD net154 sky130_fd_sc_hd__dfrtp_2
Xcounters\[227\]$_DFFE_PN0P_ clknet_leaf_7_clk _0141_ net13
+ VSS VSS VDD VDD net155 sky130_fd_sc_hd__dfrtp_2
Xcounters\[228\]$_DFFE_PN0P_ clknet_leaf_8_clk _0142_ net13
+ VSS VSS VDD VDD net156 sky130_fd_sc_hd__dfrtp_2
Xcounters\[229\]$_DFFE_PN0P_ clknet_leaf_8_clk _0143_ net13
+ VSS VSS VDD VDD net157 sky130_fd_sc_hd__dfrtp_4
Xcounters\[22\]$_DFFE_PN0P_ clknet_leaf_7_clk _0144_ net13
+ VSS VSS VDD VDD net158 sky130_fd_sc_hd__dfrtp_4
Xcounters\[230\]$_DFFE_PN0P_ clknet_leaf_8_clk _0145_ net13
+ VSS VSS VDD VDD net159 sky130_fd_sc_hd__dfrtp_4
Xcounters\[231\]$_DFFE_PN0P_ clknet_leaf_7_clk _0146_ net13
+ VSS VSS VDD VDD net160 sky130_fd_sc_hd__dfrtp_2
Xcounters\[232\]$_DFFE_PN0P_ clknet_leaf_13_clk _0147_ net13
+ VSS VSS VDD VDD net161 sky130_fd_sc_hd__dfrtp_2
Xcounters\[233\]$_DFFE_PN0P_ clknet_leaf_13_clk _0148_ net13
+ VSS VSS VDD VDD net162 sky130_fd_sc_hd__dfrtp_4
Xcounters\[234\]$_DFFE_PN0P_ clknet_leaf_13_clk _0149_ net13
+ VSS VSS VDD VDD net163 sky130_fd_sc_hd__dfrtp_4
Xcounters\[235\]$_DFFE_PN0P_ clknet_leaf_8_clk _0150_ net13
+ VSS VSS VDD VDD net164 sky130_fd_sc_hd__dfrtp_4
Xcounters\[236\]$_DFFE_PN0P_ clknet_leaf_8_clk _0151_ net13
+ VSS VSS VDD VDD net165 sky130_fd_sc_hd__dfrtp_2
Xcounters\[237\]$_DFFE_PN0P_ clknet_leaf_13_clk _0152_ net13
+ VSS VSS VDD VDD net166 sky130_fd_sc_hd__dfrtp_4
Xcounters\[238\]$_DFFE_PN0P_ clknet_leaf_13_clk _0153_ net13
+ VSS VSS VDD VDD net167 sky130_fd_sc_hd__dfrtp_2
Xcounters\[239\]$_DFFE_PN0P_ clknet_leaf_13_clk _0154_ net13
+ VSS VSS VDD VDD net168 sky130_fd_sc_hd__dfrtp_2
Xcounters\[23\]$_DFFE_PN0P_ clknet_leaf_14_clk _0155_ net13
+ VSS VSS VDD VDD net169 sky130_fd_sc_hd__dfrtp_2
Xcounters\[240\]$_DFFE_PN0P_ clknet_leaf_12_clk _0156_ net13
+ VSS VSS VDD VDD net170 sky130_fd_sc_hd__dfrtp_2
Xcounters\[241\]$_DFFE_PN0P_ clknet_leaf_12_clk _0157_ net13
+ VSS VSS VDD VDD net171 sky130_fd_sc_hd__dfrtp_4
Xcounters\[242\]$_DFFE_PN0P_ clknet_leaf_12_clk _0158_ net13
+ VSS VSS VDD VDD net172 sky130_fd_sc_hd__dfrtp_2
Xcounters\[243\]$_DFFE_PN0P_ clknet_leaf_13_clk _0159_ net13
+ VSS VSS VDD VDD net173 sky130_fd_sc_hd__dfrtp_2
Xcounters\[244\]$_DFFE_PN0P_ clknet_leaf_13_clk _0160_ net13
+ VSS VSS VDD VDD net174 sky130_fd_sc_hd__dfrtp_2
Xcounters\[245\]$_DFFE_PN0P_ clknet_leaf_11_clk _0161_ net13
+ VSS VSS VDD VDD net175 sky130_fd_sc_hd__dfrtp_1
Xcounters\[246\]$_DFFE_PN0P_ clknet_leaf_11_clk _0162_ net13
+ VSS VSS VDD VDD net176 sky130_fd_sc_hd__dfrtp_2
Xcounters\[247\]$_DFFE_PN0P_ clknet_leaf_11_clk _0163_ net13
+ VSS VSS VDD VDD net177 sky130_fd_sc_hd__dfrtp_1
Xcounters\[248\]$_DFFE_PN0P_ clknet_leaf_11_clk _0164_ net13
+ VSS VSS VDD VDD net178 sky130_fd_sc_hd__dfrtp_1
Xcounters\[249\]$_DFFE_PN0P_ clknet_leaf_12_clk _0165_ net13
+ VSS VSS VDD VDD net179 sky130_fd_sc_hd__dfrtp_2
Xcounters\[24\]$_DFFE_PN0P_ clknet_leaf_21_clk _0166_ net13
+ VSS VSS VDD VDD net180 sky130_fd_sc_hd__dfrtp_2
Xcounters\[250\]$_DFFE_PN0P_ clknet_leaf_16_clk _0167_ net13
+ VSS VSS VDD VDD net181 sky130_fd_sc_hd__dfrtp_2
Xcounters\[251\]$_DFFE_PN0P_ clknet_leaf_12_clk _0168_ net13
+ VSS VSS VDD VDD net182 sky130_fd_sc_hd__dfrtp_1
Xcounters\[252\]$_DFFE_PN0P_ clknet_leaf_11_clk _0169_ net13
+ VSS VSS VDD VDD net183 sky130_fd_sc_hd__dfrtp_1
Xcounters\[253\]$_DFFE_PN0P_ clknet_leaf_12_clk _0170_ net13
+ VSS VSS VDD VDD net184 sky130_fd_sc_hd__dfrtp_2
Xcounters\[254\]$_DFFE_PN0P_ clknet_leaf_12_clk _0171_ net13
+ VSS VSS VDD VDD net185 sky130_fd_sc_hd__dfrtp_2
Xcounters\[255\]$_DFFE_PN0P_ clknet_leaf_12_clk _0172_ net13
+ VSS VSS VDD VDD net186 sky130_fd_sc_hd__dfrtp_1
Xcounters\[25\]$_DFFE_PN0P_ clknet_leaf_14_clk _0173_ net13
+ VSS VSS VDD VDD net187 sky130_fd_sc_hd__dfrtp_4
Xcounters\[26\]$_DFFE_PN0P_ clknet_leaf_0_clk _0174_ net13
+ VSS VSS VDD VDD net188 sky130_fd_sc_hd__dfrtp_4
Xcounters\[27\]$_DFFE_PN0P_ clknet_leaf_0_clk _0175_ net13
+ VSS VSS VDD VDD net189 sky130_fd_sc_hd__dfrtp_4
Xcounters\[28\]$_DFFE_PN0P_ clknet_leaf_0_clk _0176_ net13
+ VSS VSS VDD VDD net190 sky130_fd_sc_hd__dfrtp_4
Xcounters\[29\]$_DFFE_PN0P_ clknet_leaf_0_clk _0177_ net13
+ VSS VSS VDD VDD net191 sky130_fd_sc_hd__dfrtp_4
Xcounters\[2\]$_DFFE_PN0P_ clknet_leaf_26_clk _0178_ net13
+ VSS VSS VDD VDD net192 sky130_fd_sc_hd__dfrtp_1
Xcounters\[30\]$_DFFE_PN0P_ clknet_leaf_0_clk _0179_ net13
+ VSS VSS VDD VDD net193 sky130_fd_sc_hd__dfrtp_2
Xcounters\[31\]$_DFFE_PN0P_ clknet_leaf_1_clk _0180_ net13
+ VSS VSS VDD VDD net194 sky130_fd_sc_hd__dfrtp_2
Xcounters\[32\]$_DFFE_PN0P_ clknet_leaf_3_clk _0181_ net13
+ VSS VSS VDD VDD net195 sky130_fd_sc_hd__dfrtp_4
Xcounters\[33\]$_DFFE_PN0P_ clknet_leaf_3_clk _0182_ net13
+ VSS VSS VDD VDD net196 sky130_fd_sc_hd__dfrtp_4
Xcounters\[34\]$_DFFE_PN0P_ clknet_leaf_3_clk _0183_ net13
+ VSS VSS VDD VDD net197 sky130_fd_sc_hd__dfrtp_4
Xcounters\[35\]$_DFFE_PN0P_ clknet_leaf_3_clk _0184_ net13
+ VSS VSS VDD VDD net198 sky130_fd_sc_hd__dfrtp_4
Xcounters\[36\]$_DFFE_PN0P_ clknet_leaf_3_clk _0185_ net13
+ VSS VSS VDD VDD net199 sky130_fd_sc_hd__dfrtp_4
Xcounters\[37\]$_DFFE_PN0P_ clknet_leaf_3_clk _0186_ net13
+ VSS VSS VDD VDD net200 sky130_fd_sc_hd__dfrtp_4
Xcounters\[38\]$_DFFE_PN0P_ clknet_leaf_2_clk _0187_ net13
+ VSS VSS VDD VDD net201 sky130_fd_sc_hd__dfrtp_4
Xcounters\[39\]$_DFFE_PN0P_ clknet_leaf_2_clk _0188_ net13
+ VSS VSS VDD VDD net202 sky130_fd_sc_hd__dfrtp_2
Xcounters\[3\]$_DFFE_PN0P_ clknet_leaf_25_clk _0189_ net13
+ VSS VSS VDD VDD net203 sky130_fd_sc_hd__dfrtp_4
Xcounters\[40\]$_DFFE_PN0P_ clknet_leaf_3_clk _0190_ net13
+ VSS VSS VDD VDD net204 sky130_fd_sc_hd__dfrtp_2
Xcounters\[41\]$_DFFE_PN0P_ clknet_leaf_2_clk _0191_ net13
+ VSS VSS VDD VDD net205 sky130_fd_sc_hd__dfrtp_2
Xcounters\[42\]$_DFFE_PN0P_ clknet_leaf_2_clk _0192_ net13
+ VSS VSS VDD VDD net206 sky130_fd_sc_hd__dfrtp_4
Xcounters\[43\]$_DFFE_PN0P_ clknet_leaf_2_clk _0193_ net13
+ VSS VSS VDD VDD net207 sky130_fd_sc_hd__dfrtp_4
Xcounters\[44\]$_DFFE_PN0P_ clknet_leaf_2_clk _0194_ net13
+ VSS VSS VDD VDD net208 sky130_fd_sc_hd__dfrtp_4
Xcounters\[45\]$_DFFE_PN0P_ clknet_leaf_0_clk _0195_ net13
+ VSS VSS VDD VDD net209 sky130_fd_sc_hd__dfrtp_4
Xcounters\[46\]$_DFFE_PN0P_ clknet_leaf_2_clk _0196_ net13
+ VSS VSS VDD VDD net210 sky130_fd_sc_hd__dfrtp_2
Xcounters\[47\]$_DFFE_PN0P_ clknet_leaf_0_clk _0197_ net13
+ VSS VSS VDD VDD net211 sky130_fd_sc_hd__dfrtp_2
Xcounters\[48\]$_DFFE_PN0P_ clknet_leaf_1_clk _0198_ net13
+ VSS VSS VDD VDD net212 sky130_fd_sc_hd__dfrtp_2
Xcounters\[49\]$_DFFE_PN0P_ clknet_leaf_1_clk _0199_ net13
+ VSS VSS VDD VDD net213 sky130_fd_sc_hd__dfrtp_4
Xcounters\[4\]$_DFFE_PN0P_ clknet_leaf_26_clk _0200_ net13
+ VSS VSS VDD VDD net214 sky130_fd_sc_hd__dfrtp_2
Xcounters\[50\]$_DFFE_PN0P_ clknet_leaf_1_clk _0201_ net13
+ VSS VSS VDD VDD net215 sky130_fd_sc_hd__dfrtp_2
Xcounters\[51\]$_DFFE_PN0P_ clknet_leaf_1_clk _0202_ net13
+ VSS VSS VDD VDD net216 sky130_fd_sc_hd__dfrtp_2
Xcounters\[52\]$_DFFE_PN0P_ clknet_leaf_1_clk _0203_ net13
+ VSS VSS VDD VDD net217 sky130_fd_sc_hd__dfrtp_1
Xcounters\[53\]$_DFFE_PN0P_ clknet_leaf_27_clk _0204_ net13
+ VSS VSS VDD VDD net218 sky130_fd_sc_hd__dfrtp_2
Xcounters\[54\]$_DFFE_PN0P_ clknet_leaf_26_clk _0205_ net13
+ VSS VSS VDD VDD net219 sky130_fd_sc_hd__dfrtp_2
Xcounters\[55\]$_DFFE_PN0P_ clknet_leaf_27_clk _0206_ net13
+ VSS VSS VDD VDD net220 sky130_fd_sc_hd__dfrtp_2
Xcounters\[56\]$_DFFE_PN0P_ clknet_leaf_26_clk _0207_ net13
+ VSS VSS VDD VDD net221 sky130_fd_sc_hd__dfrtp_1
Xcounters\[57\]$_DFFE_PN0P_ clknet_leaf_1_clk _0208_ net13
+ VSS VSS VDD VDD net222 sky130_fd_sc_hd__dfrtp_1
Xcounters\[58\]$_DFFE_PN0P_ clknet_leaf_1_clk _0209_ net13
+ VSS VSS VDD VDD net223 sky130_fd_sc_hd__dfrtp_2
Xcounters\[59\]$_DFFE_PN0P_ clknet_leaf_1_clk _0210_ net13
+ VSS VSS VDD VDD net224 sky130_fd_sc_hd__dfrtp_2
Xcounters\[5\]$_DFFE_PN0P_ clknet_leaf_25_clk _0211_ net13
+ VSS VSS VDD VDD net225 sky130_fd_sc_hd__dfrtp_2
Xcounters\[60\]$_DFFE_PN0P_ clknet_leaf_26_clk _0212_ net13
+ VSS VSS VDD VDD net226 sky130_fd_sc_hd__dfrtp_1
Xcounters\[61\]$_DFFE_PN0P_ clknet_leaf_26_clk _0213_ net13
+ VSS VSS VDD VDD net227 sky130_fd_sc_hd__dfrtp_1
Xcounters\[62\]$_DFFE_PN0P_ clknet_leaf_1_clk _0214_ net13
+ VSS VSS VDD VDD net228 sky130_fd_sc_hd__dfrtp_1
Xcounters\[63\]$_DFFE_PN0P_ clknet_leaf_26_clk _0215_ net13
+ VSS VSS VDD VDD net229 sky130_fd_sc_hd__dfrtp_1
Xcounters\[64\]$_DFFE_PN0P_ clknet_leaf_24_clk _0216_ net13
+ VSS VSS VDD VDD net230 sky130_fd_sc_hd__dfrtp_2
Xcounters\[65\]$_DFFE_PN0P_ clknet_leaf_24_clk _0217_ net13
+ VSS VSS VDD VDD net231 sky130_fd_sc_hd__dfrtp_4
Xcounters\[66\]$_DFFE_PN0P_ clknet_leaf_24_clk _0218_ net13
+ VSS VSS VDD VDD net232 sky130_fd_sc_hd__dfrtp_4
Xcounters\[67\]$_DFFE_PN0P_ clknet_leaf_25_clk _0219_ net13
+ VSS VSS VDD VDD net233 sky130_fd_sc_hd__dfrtp_2
Xcounters\[68\]$_DFFE_PN0P_ clknet_leaf_25_clk _0220_ net13
+ VSS VSS VDD VDD net234 sky130_fd_sc_hd__dfrtp_1
Xcounters\[69\]$_DFFE_PN0P_ clknet_leaf_25_clk _0221_ net13
+ VSS VSS VDD VDD net235 sky130_fd_sc_hd__dfrtp_1
Xcounters\[6\]$_DFFE_PN0P_ clknet_leaf_25_clk _0222_ net13
+ VSS VSS VDD VDD net236 sky130_fd_sc_hd__dfrtp_2
Xcounters\[70\]$_DFFE_PN0P_ clknet_leaf_25_clk _0223_ net13
+ VSS VSS VDD VDD net237 sky130_fd_sc_hd__dfrtp_1
Xcounters\[71\]$_DFFE_PN0P_ clknet_leaf_24_clk _0224_ net13
+ VSS VSS VDD VDD net238 sky130_fd_sc_hd__dfrtp_1
Xcounters\[72\]$_DFFE_PN0P_ clknet_leaf_25_clk _0225_ net13
+ VSS VSS VDD VDD net239 sky130_fd_sc_hd__dfrtp_1
Xcounters\[73\]$_DFFE_PN0P_ clknet_leaf_24_clk _0226_ net13
+ VSS VSS VDD VDD net240 sky130_fd_sc_hd__dfrtp_1
Xcounters\[74\]$_DFFE_PN0P_ clknet_leaf_24_clk _0227_ net13
+ VSS VSS VDD VDD net241 sky130_fd_sc_hd__dfrtp_2
Xcounters\[75\]$_DFFE_PN0P_ clknet_leaf_24_clk _0228_ net13
+ VSS VSS VDD VDD net242 sky130_fd_sc_hd__dfrtp_1
Xcounters\[76\]$_DFFE_PN0P_ clknet_leaf_24_clk _0229_ net13
+ VSS VSS VDD VDD net243 sky130_fd_sc_hd__dfrtp_1
Xcounters\[77\]$_DFFE_PN0P_ clknet_leaf_24_clk _0230_ net13
+ VSS VSS VDD VDD net244 sky130_fd_sc_hd__dfrtp_1
Xcounters\[78\]$_DFFE_PN0P_ clknet_leaf_24_clk _0231_ net13
+ VSS VSS VDD VDD net245 sky130_fd_sc_hd__dfrtp_1
Xcounters\[79\]$_DFFE_PN0P_ clknet_leaf_23_clk _0232_ net13
+ VSS VSS VDD VDD net246 sky130_fd_sc_hd__dfrtp_2
Xcounters\[7\]$_DFFE_PN0P_ clknet_leaf_25_clk _0233_ net13
+ VSS VSS VDD VDD net247 sky130_fd_sc_hd__dfrtp_4
Xcounters\[80\]$_DFFE_PN0P_ clknet_leaf_23_clk _0234_ net13
+ VSS VSS VDD VDD net248 sky130_fd_sc_hd__dfrtp_2
Xcounters\[81\]$_DFFE_PN0P_ clknet_leaf_23_clk _0235_ net13
+ VSS VSS VDD VDD net249 sky130_fd_sc_hd__dfrtp_2
Xcounters\[82\]$_DFFE_PN0P_ clknet_leaf_23_clk _0236_ net13
+ VSS VSS VDD VDD net250 sky130_fd_sc_hd__dfrtp_1
Xcounters\[83\]$_DFFE_PN0P_ clknet_leaf_23_clk _0237_ net13
+ VSS VSS VDD VDD net251 sky130_fd_sc_hd__dfrtp_1
Xcounters\[84\]$_DFFE_PN0P_ clknet_leaf_22_clk _0238_ net13
+ VSS VSS VDD VDD net252 sky130_fd_sc_hd__dfrtp_4
Xcounters\[85\]$_DFFE_PN0P_ clknet_leaf_23_clk _0239_ net13
+ VSS VSS VDD VDD net253 sky130_fd_sc_hd__dfrtp_2
Xcounters\[86\]$_DFFE_PN0P_ clknet_leaf_23_clk _0240_ net13
+ VSS VSS VDD VDD net254 sky130_fd_sc_hd__dfrtp_2
Xcounters\[87\]$_DFFE_PN0P_ clknet_leaf_23_clk _0241_ net13
+ VSS VSS VDD VDD net255 sky130_fd_sc_hd__dfrtp_1
Xcounters\[88\]$_DFFE_PN0P_ clknet_leaf_22_clk _0242_ net13
+ VSS VSS VDD VDD net256 sky130_fd_sc_hd__dfrtp_1
Xcounters\[89\]$_DFFE_PN0P_ clknet_leaf_22_clk _0243_ net13
+ VSS VSS VDD VDD net257 sky130_fd_sc_hd__dfrtp_1
Xcounters\[8\]$_DFFE_PN0P_ clknet_leaf_25_clk _0244_ net13
+ VSS VSS VDD VDD net258 sky130_fd_sc_hd__dfrtp_2
Xcounters\[90\]$_DFFE_PN0P_ clknet_leaf_22_clk _0245_ net13
+ VSS VSS VDD VDD net259 sky130_fd_sc_hd__dfrtp_4
Xcounters\[91\]$_DFFE_PN0P_ clknet_leaf_22_clk _0246_ net13
+ VSS VSS VDD VDD net260 sky130_fd_sc_hd__dfrtp_2
Xcounters\[92\]$_DFFE_PN0P_ clknet_leaf_21_clk _0247_ net13
+ VSS VSS VDD VDD net261 sky130_fd_sc_hd__dfrtp_2
Xcounters\[93\]$_DFFE_PN0P_ clknet_leaf_22_clk _0248_ net13
+ VSS VSS VDD VDD net262 sky130_fd_sc_hd__dfrtp_2
Xcounters\[94\]$_DFFE_PN0P_ clknet_leaf_22_clk _0249_ net13
+ VSS VSS VDD VDD net263 sky130_fd_sc_hd__dfrtp_2
Xcounters\[95\]$_DFFE_PN0P_ clknet_leaf_22_clk _0250_ net13
+ VSS VSS VDD VDD net264 sky130_fd_sc_hd__dfrtp_1
Xcounters\[96\]$_DFFE_PN0P_ clknet_leaf_23_clk _0251_ net13
+ VSS VSS VDD VDD net265 sky130_fd_sc_hd__dfrtp_2
Xcounters\[97\]$_DFFE_PN0P_ clknet_leaf_23_clk _0252_ net13
+ VSS VSS VDD VDD net266 sky130_fd_sc_hd__dfrtp_2
Xcounters\[98\]$_DFFE_PN0P_ clknet_leaf_22_clk _0253_ net13
+ VSS VSS VDD VDD net267 sky130_fd_sc_hd__dfrtp_1
Xcounters\[99\]$_DFFE_PN0P_ clknet_leaf_19_clk _0254_ net13
+ VSS VSS VDD VDD net268 sky130_fd_sc_hd__dfrtp_1
Xcounters\[9\]$_DFFE_PN0P_ clknet_leaf_27_clk _0255_ net13
+ VSS VSS VDD VDD net269 sky130_fd_sc_hd__dfrtp_4
Xprev_event_inc\[0\]$_DFFE_PN0N_ clknet_leaf_26_clk _0256_
+ net13 VSS VSS VDD VDD prev_event_inc\[0\] sky130_fd_sc_hd__dfrtp_1
Xprev_event_inc\[1\]$_DFFE_PN0N_ clknet_leaf_3_clk _0257_
+ net13 VSS VSS VDD VDD prev_event_inc\[1\] sky130_fd_sc_hd__dfrtp_1
Xprev_event_inc\[2\]$_DFFE_PN0N_ clknet_leaf_24_clk _0258_
+ net13 VSS VSS VDD VDD prev_event_inc\[2\] sky130_fd_sc_hd__dfrtp_1
Xprev_event_inc\[3\]$_DFFE_PN0N_ clknet_leaf_22_clk _0259_
+ net13 VSS VSS VDD VDD prev_event_inc\[3\] sky130_fd_sc_hd__dfrtp_1
Xprev_event_inc\[4\]$_DFFE_PN0N_ clknet_leaf_21_clk _0260_
+ net13 VSS VSS VDD VDD prev_event_inc\[4\] sky130_fd_sc_hd__dfrtp_1
Xprev_event_inc\[5\]$_DFFE_PN0N_ clknet_leaf_3_clk _0261_
+ net13 VSS VSS VDD VDD prev_event_inc\[5\] sky130_fd_sc_hd__dfrtp_1
Xprev_event_inc\[6\]$_DFFE_PN0N_ clknet_leaf_5_clk _0262_
+ net13 VSS VSS VDD VDD prev_event_inc\[6\] sky130_fd_sc_hd__dfrtp_1
Xprev_event_inc\[7\]$_DFFE_PN0N_ clknet_leaf_7_clk _0263_
+ net13 VSS VSS VDD VDD prev_event_inc\[7\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 counter_sel[0] VSS VSS VDD VDD net1 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput2 counter_sel[6] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xinput3 counter_sel[7] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput4 enable VSS VSS VDD VDD net4 sky130_fd_sc_hd__buf_6
Xinput5 net304 VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput6 net302 VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput7 net307 VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput8 net306 VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput9 net303 VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_2
Xinput10 net305 VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_2
Xinput11 net309 VSS VSS VDD VDD net11 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput12 net308 VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_2
Xinput13 rst_n VSS VSS VDD VDD net13 sky130_fd_sc_hd__buf_16
Xoutput14 net14 VSS VSS VDD VDD all_counts[0] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net15 VSS VSS VDD VDD all_counts[100] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net16 VSS VSS VDD VDD all_counts[101] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net17 VSS VSS VDD VDD all_counts[102] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net18 VSS VSS VDD VDD all_counts[103] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net19 VSS VSS VDD VDD all_counts[104] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net20 VSS VSS VDD VDD all_counts[105] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net21 VSS VSS VDD VDD all_counts[106] sky130_fd_sc_hd__clkbuf_1
Xoutput22 net22 VSS VSS VDD VDD all_counts[107] sky130_fd_sc_hd__clkbuf_1
Xoutput23 net23 VSS VSS VDD VDD all_counts[108] sky130_fd_sc_hd__clkbuf_1
Xoutput24 net24 VSS VSS VDD VDD all_counts[109] sky130_fd_sc_hd__clkbuf_1
Xoutput25 net25 VSS VSS VDD VDD all_counts[10] sky130_fd_sc_hd__clkbuf_1
Xoutput26 net26 VSS VSS VDD VDD all_counts[110] sky130_fd_sc_hd__clkbuf_1
Xoutput27 net27 VSS VSS VDD VDD all_counts[111] sky130_fd_sc_hd__clkbuf_1
Xoutput28 net28 VSS VSS VDD VDD all_counts[112] sky130_fd_sc_hd__clkbuf_1
Xoutput29 net29 VSS VSS VDD VDD all_counts[113] sky130_fd_sc_hd__clkbuf_1
Xoutput30 net30 VSS VSS VDD VDD all_counts[114] sky130_fd_sc_hd__clkbuf_1
Xoutput31 net31 VSS VSS VDD VDD all_counts[115] sky130_fd_sc_hd__clkbuf_1
Xoutput32 net32 VSS VSS VDD VDD all_counts[116] sky130_fd_sc_hd__clkbuf_1
Xoutput33 net33 VSS VSS VDD VDD all_counts[117] sky130_fd_sc_hd__clkbuf_1
Xoutput34 net34 VSS VSS VDD VDD all_counts[118] sky130_fd_sc_hd__clkbuf_1
Xoutput35 net35 VSS VSS VDD VDD all_counts[119] sky130_fd_sc_hd__clkbuf_1
Xoutput36 net36 VSS VSS VDD VDD all_counts[11] sky130_fd_sc_hd__clkbuf_1
Xoutput37 net37 VSS VSS VDD VDD all_counts[120] sky130_fd_sc_hd__clkbuf_1
Xoutput38 net38 VSS VSS VDD VDD all_counts[121] sky130_fd_sc_hd__clkbuf_1
Xoutput39 net39 VSS VSS VDD VDD all_counts[122] sky130_fd_sc_hd__clkbuf_1
Xoutput40 net40 VSS VSS VDD VDD all_counts[123] sky130_fd_sc_hd__clkbuf_1
Xoutput41 net41 VSS VSS VDD VDD all_counts[124] sky130_fd_sc_hd__clkbuf_1
Xoutput42 net42 VSS VSS VDD VDD all_counts[125] sky130_fd_sc_hd__clkbuf_1
Xoutput43 net43 VSS VSS VDD VDD all_counts[126] sky130_fd_sc_hd__clkbuf_1
Xoutput44 net44 VSS VSS VDD VDD all_counts[127] sky130_fd_sc_hd__clkbuf_1
Xoutput45 net45 VSS VSS VDD VDD all_counts[128] sky130_fd_sc_hd__clkbuf_1
Xoutput46 net46 VSS VSS VDD VDD all_counts[129] sky130_fd_sc_hd__clkbuf_1
Xoutput47 net47 VSS VSS VDD VDD all_counts[12] sky130_fd_sc_hd__clkbuf_1
Xoutput48 net48 VSS VSS VDD VDD all_counts[130] sky130_fd_sc_hd__clkbuf_1
Xoutput49 net49 VSS VSS VDD VDD all_counts[131] sky130_fd_sc_hd__clkbuf_1
Xoutput50 net50 VSS VSS VDD VDD all_counts[132] sky130_fd_sc_hd__clkbuf_1
Xoutput51 net51 VSS VSS VDD VDD all_counts[133] sky130_fd_sc_hd__clkbuf_1
Xoutput52 net52 VSS VSS VDD VDD all_counts[134] sky130_fd_sc_hd__clkbuf_1
Xoutput53 net53 VSS VSS VDD VDD all_counts[135] sky130_fd_sc_hd__clkbuf_1
Xoutput54 net54 VSS VSS VDD VDD all_counts[136] sky130_fd_sc_hd__clkbuf_1
Xoutput55 net55 VSS VSS VDD VDD all_counts[137] sky130_fd_sc_hd__clkbuf_1
Xoutput56 net56 VSS VSS VDD VDD all_counts[138] sky130_fd_sc_hd__clkbuf_1
Xoutput57 net57 VSS VSS VDD VDD all_counts[139] sky130_fd_sc_hd__clkbuf_1
Xoutput58 net58 VSS VSS VDD VDD all_counts[13] sky130_fd_sc_hd__clkbuf_1
Xoutput59 net59 VSS VSS VDD VDD all_counts[140] sky130_fd_sc_hd__clkbuf_1
Xoutput60 net60 VSS VSS VDD VDD all_counts[141] sky130_fd_sc_hd__clkbuf_1
Xoutput61 net61 VSS VSS VDD VDD all_counts[142] sky130_fd_sc_hd__clkbuf_1
Xoutput62 net62 VSS VSS VDD VDD all_counts[143] sky130_fd_sc_hd__clkbuf_1
Xoutput63 net63 VSS VSS VDD VDD all_counts[144] sky130_fd_sc_hd__clkbuf_1
Xoutput64 net64 VSS VSS VDD VDD all_counts[145] sky130_fd_sc_hd__clkbuf_1
Xoutput65 net65 VSS VSS VDD VDD all_counts[146] sky130_fd_sc_hd__clkbuf_1
Xoutput66 net66 VSS VSS VDD VDD all_counts[147] sky130_fd_sc_hd__clkbuf_1
Xoutput67 net67 VSS VSS VDD VDD all_counts[148] sky130_fd_sc_hd__clkbuf_1
Xoutput68 net68 VSS VSS VDD VDD all_counts[149] sky130_fd_sc_hd__clkbuf_1
Xoutput69 net69 VSS VSS VDD VDD all_counts[14] sky130_fd_sc_hd__clkbuf_1
Xoutput70 net70 VSS VSS VDD VDD all_counts[150] sky130_fd_sc_hd__clkbuf_1
Xoutput71 net71 VSS VSS VDD VDD all_counts[151] sky130_fd_sc_hd__clkbuf_1
Xoutput72 net72 VSS VSS VDD VDD all_counts[152] sky130_fd_sc_hd__clkbuf_1
Xoutput73 net73 VSS VSS VDD VDD all_counts[153] sky130_fd_sc_hd__clkbuf_1
Xoutput74 net74 VSS VSS VDD VDD all_counts[154] sky130_fd_sc_hd__clkbuf_1
Xoutput75 net75 VSS VSS VDD VDD all_counts[155] sky130_fd_sc_hd__clkbuf_1
Xoutput76 net76 VSS VSS VDD VDD all_counts[156] sky130_fd_sc_hd__clkbuf_1
Xoutput77 net77 VSS VSS VDD VDD all_counts[157] sky130_fd_sc_hd__clkbuf_1
Xoutput78 net78 VSS VSS VDD VDD all_counts[158] sky130_fd_sc_hd__clkbuf_1
Xoutput79 net79 VSS VSS VDD VDD all_counts[159] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net80 VSS VSS VDD VDD all_counts[15] sky130_fd_sc_hd__clkbuf_1
Xoutput81 net81 VSS VSS VDD VDD all_counts[160] sky130_fd_sc_hd__clkbuf_1
Xoutput82 net82 VSS VSS VDD VDD all_counts[161] sky130_fd_sc_hd__clkbuf_1
Xoutput83 net83 VSS VSS VDD VDD all_counts[162] sky130_fd_sc_hd__clkbuf_1
Xoutput84 net84 VSS VSS VDD VDD all_counts[163] sky130_fd_sc_hd__clkbuf_1
Xoutput85 net85 VSS VSS VDD VDD all_counts[164] sky130_fd_sc_hd__clkbuf_1
Xoutput86 net86 VSS VSS VDD VDD all_counts[165] sky130_fd_sc_hd__clkbuf_1
Xoutput87 net87 VSS VSS VDD VDD all_counts[166] sky130_fd_sc_hd__clkbuf_1
Xoutput88 net88 VSS VSS VDD VDD all_counts[167] sky130_fd_sc_hd__clkbuf_1
Xoutput89 net89 VSS VSS VDD VDD all_counts[168] sky130_fd_sc_hd__clkbuf_1
Xoutput90 net90 VSS VSS VDD VDD all_counts[169] sky130_fd_sc_hd__clkbuf_1
Xoutput91 net91 VSS VSS VDD VDD all_counts[16] sky130_fd_sc_hd__clkbuf_1
Xoutput92 net92 VSS VSS VDD VDD all_counts[170] sky130_fd_sc_hd__clkbuf_1
Xoutput93 net93 VSS VSS VDD VDD all_counts[171] sky130_fd_sc_hd__clkbuf_1
Xoutput94 net94 VSS VSS VDD VDD all_counts[172] sky130_fd_sc_hd__clkbuf_1
Xoutput95 net95 VSS VSS VDD VDD all_counts[173] sky130_fd_sc_hd__clkbuf_1
Xoutput96 net96 VSS VSS VDD VDD all_counts[174] sky130_fd_sc_hd__clkbuf_1
Xoutput97 net97 VSS VSS VDD VDD all_counts[175] sky130_fd_sc_hd__clkbuf_1
Xoutput98 net98 VSS VSS VDD VDD all_counts[176] sky130_fd_sc_hd__clkbuf_1
Xoutput99 net99 VSS VSS VDD VDD all_counts[177] sky130_fd_sc_hd__clkbuf_1
Xoutput100 net100 VSS VSS VDD VDD all_counts[178] sky130_fd_sc_hd__clkbuf_1
Xoutput101 net101 VSS VSS VDD VDD all_counts[179] sky130_fd_sc_hd__clkbuf_1
Xoutput102 net102 VSS VSS VDD VDD all_counts[17] sky130_fd_sc_hd__clkbuf_1
Xoutput103 net103 VSS VSS VDD VDD all_counts[180] sky130_fd_sc_hd__clkbuf_1
Xoutput104 net104 VSS VSS VDD VDD all_counts[181] sky130_fd_sc_hd__clkbuf_1
Xoutput105 net105 VSS VSS VDD VDD all_counts[182] sky130_fd_sc_hd__clkbuf_1
Xoutput106 net106 VSS VSS VDD VDD all_counts[183] sky130_fd_sc_hd__clkbuf_1
Xoutput107 net107 VSS VSS VDD VDD all_counts[184] sky130_fd_sc_hd__clkbuf_1
Xoutput108 net108 VSS VSS VDD VDD all_counts[185] sky130_fd_sc_hd__clkbuf_1
Xoutput109 net109 VSS VSS VDD VDD all_counts[186] sky130_fd_sc_hd__clkbuf_1
Xoutput110 net110 VSS VSS VDD VDD all_counts[187] sky130_fd_sc_hd__clkbuf_1
Xoutput111 net111 VSS VSS VDD VDD all_counts[188] sky130_fd_sc_hd__clkbuf_1
Xoutput112 net112 VSS VSS VDD VDD all_counts[189] sky130_fd_sc_hd__clkbuf_1
Xoutput113 net113 VSS VSS VDD VDD all_counts[18] sky130_fd_sc_hd__clkbuf_1
Xoutput114 net114 VSS VSS VDD VDD all_counts[190] sky130_fd_sc_hd__clkbuf_1
Xoutput115 net115 VSS VSS VDD VDD all_counts[191] sky130_fd_sc_hd__clkbuf_1
Xoutput116 net116 VSS VSS VDD VDD all_counts[192] sky130_fd_sc_hd__clkbuf_1
Xoutput117 net117 VSS VSS VDD VDD all_counts[193] sky130_fd_sc_hd__clkbuf_1
Xoutput118 net118 VSS VSS VDD VDD all_counts[194] sky130_fd_sc_hd__clkbuf_1
Xoutput119 net119 VSS VSS VDD VDD all_counts[195] sky130_fd_sc_hd__clkbuf_1
Xoutput120 net120 VSS VSS VDD VDD all_counts[196] sky130_fd_sc_hd__clkbuf_1
Xoutput121 net121 VSS VSS VDD VDD all_counts[197] sky130_fd_sc_hd__clkbuf_1
Xoutput122 net122 VSS VSS VDD VDD all_counts[198] sky130_fd_sc_hd__clkbuf_1
Xoutput123 net123 VSS VSS VDD VDD all_counts[199] sky130_fd_sc_hd__clkbuf_1
Xoutput124 net124 VSS VSS VDD VDD all_counts[19] sky130_fd_sc_hd__clkbuf_1
Xoutput125 net125 VSS VSS VDD VDD all_counts[1] sky130_fd_sc_hd__clkbuf_1
Xoutput126 net126 VSS VSS VDD VDD all_counts[200] sky130_fd_sc_hd__clkbuf_1
Xoutput127 net127 VSS VSS VDD VDD all_counts[201] sky130_fd_sc_hd__clkbuf_1
Xoutput128 net128 VSS VSS VDD VDD all_counts[202] sky130_fd_sc_hd__clkbuf_1
Xoutput129 net129 VSS VSS VDD VDD all_counts[203] sky130_fd_sc_hd__clkbuf_1
Xoutput130 net130 VSS VSS VDD VDD all_counts[204] sky130_fd_sc_hd__clkbuf_1
Xoutput131 net131 VSS VSS VDD VDD all_counts[205] sky130_fd_sc_hd__clkbuf_1
Xoutput132 net132 VSS VSS VDD VDD all_counts[206] sky130_fd_sc_hd__clkbuf_1
Xoutput133 net133 VSS VSS VDD VDD all_counts[207] sky130_fd_sc_hd__clkbuf_1
Xoutput134 net134 VSS VSS VDD VDD all_counts[208] sky130_fd_sc_hd__clkbuf_1
Xoutput135 net135 VSS VSS VDD VDD all_counts[209] sky130_fd_sc_hd__clkbuf_1
Xoutput136 net136 VSS VSS VDD VDD all_counts[20] sky130_fd_sc_hd__clkbuf_1
Xoutput137 net137 VSS VSS VDD VDD all_counts[210] sky130_fd_sc_hd__clkbuf_1
Xoutput138 net138 VSS VSS VDD VDD all_counts[211] sky130_fd_sc_hd__clkbuf_1
Xoutput139 net139 VSS VSS VDD VDD all_counts[212] sky130_fd_sc_hd__clkbuf_1
Xoutput140 net140 VSS VSS VDD VDD all_counts[213] sky130_fd_sc_hd__clkbuf_1
Xoutput141 net141 VSS VSS VDD VDD all_counts[214] sky130_fd_sc_hd__clkbuf_1
Xoutput142 net142 VSS VSS VDD VDD all_counts[215] sky130_fd_sc_hd__clkbuf_1
Xoutput143 net143 VSS VSS VDD VDD all_counts[216] sky130_fd_sc_hd__clkbuf_1
Xoutput144 net144 VSS VSS VDD VDD all_counts[217] sky130_fd_sc_hd__clkbuf_1
Xoutput145 net145 VSS VSS VDD VDD all_counts[218] sky130_fd_sc_hd__clkbuf_1
Xoutput146 net146 VSS VSS VDD VDD all_counts[219] sky130_fd_sc_hd__clkbuf_1
Xoutput147 net147 VSS VSS VDD VDD all_counts[21] sky130_fd_sc_hd__clkbuf_1
Xoutput148 net148 VSS VSS VDD VDD all_counts[220] sky130_fd_sc_hd__clkbuf_1
Xoutput149 net149 VSS VSS VDD VDD all_counts[221] sky130_fd_sc_hd__clkbuf_1
Xoutput150 net150 VSS VSS VDD VDD all_counts[222] sky130_fd_sc_hd__clkbuf_1
Xoutput151 net151 VSS VSS VDD VDD all_counts[223] sky130_fd_sc_hd__clkbuf_1
Xoutput152 net152 VSS VSS VDD VDD all_counts[224] sky130_fd_sc_hd__clkbuf_1
Xoutput153 net153 VSS VSS VDD VDD all_counts[225] sky130_fd_sc_hd__clkbuf_1
Xoutput154 net154 VSS VSS VDD VDD all_counts[226] sky130_fd_sc_hd__clkbuf_1
Xoutput155 net155 VSS VSS VDD VDD all_counts[227] sky130_fd_sc_hd__clkbuf_1
Xoutput156 net156 VSS VSS VDD VDD all_counts[228] sky130_fd_sc_hd__clkbuf_1
Xoutput157 net157 VSS VSS VDD VDD all_counts[229] sky130_fd_sc_hd__clkbuf_1
Xoutput158 net158 VSS VSS VDD VDD all_counts[22] sky130_fd_sc_hd__clkbuf_1
Xoutput159 net159 VSS VSS VDD VDD all_counts[230] sky130_fd_sc_hd__clkbuf_1
Xoutput160 net160 VSS VSS VDD VDD all_counts[231] sky130_fd_sc_hd__clkbuf_1
Xoutput161 net161 VSS VSS VDD VDD all_counts[232] sky130_fd_sc_hd__clkbuf_1
Xoutput162 net162 VSS VSS VDD VDD all_counts[233] sky130_fd_sc_hd__clkbuf_1
Xoutput163 net163 VSS VSS VDD VDD all_counts[234] sky130_fd_sc_hd__clkbuf_1
Xoutput164 net164 VSS VSS VDD VDD all_counts[235] sky130_fd_sc_hd__clkbuf_1
Xoutput165 net165 VSS VSS VDD VDD all_counts[236] sky130_fd_sc_hd__clkbuf_1
Xoutput166 net166 VSS VSS VDD VDD all_counts[237] sky130_fd_sc_hd__clkbuf_1
Xoutput167 net167 VSS VSS VDD VDD all_counts[238] sky130_fd_sc_hd__clkbuf_1
Xoutput168 net168 VSS VSS VDD VDD all_counts[239] sky130_fd_sc_hd__clkbuf_1
Xoutput169 net169 VSS VSS VDD VDD all_counts[23] sky130_fd_sc_hd__clkbuf_1
Xoutput170 net170 VSS VSS VDD VDD all_counts[240] sky130_fd_sc_hd__clkbuf_1
Xoutput171 net171 VSS VSS VDD VDD all_counts[241] sky130_fd_sc_hd__clkbuf_1
Xoutput172 net172 VSS VSS VDD VDD all_counts[242] sky130_fd_sc_hd__clkbuf_1
Xoutput173 net173 VSS VSS VDD VDD all_counts[243] sky130_fd_sc_hd__clkbuf_1
Xoutput174 net174 VSS VSS VDD VDD all_counts[244] sky130_fd_sc_hd__clkbuf_1
Xoutput175 net175 VSS VSS VDD VDD all_counts[245] sky130_fd_sc_hd__clkbuf_1
Xoutput176 net176 VSS VSS VDD VDD all_counts[246] sky130_fd_sc_hd__clkbuf_1
Xoutput177 net177 VSS VSS VDD VDD all_counts[247] sky130_fd_sc_hd__clkbuf_1
Xoutput178 net178 VSS VSS VDD VDD all_counts[248] sky130_fd_sc_hd__clkbuf_1
Xoutput179 net179 VSS VSS VDD VDD all_counts[249] sky130_fd_sc_hd__clkbuf_1
Xoutput180 net180 VSS VSS VDD VDD all_counts[24] sky130_fd_sc_hd__clkbuf_1
Xoutput181 net181 VSS VSS VDD VDD all_counts[250] sky130_fd_sc_hd__clkbuf_1
Xoutput182 net182 VSS VSS VDD VDD all_counts[251] sky130_fd_sc_hd__clkbuf_1
Xoutput183 net183 VSS VSS VDD VDD all_counts[252] sky130_fd_sc_hd__clkbuf_1
Xoutput184 net184 VSS VSS VDD VDD all_counts[253] sky130_fd_sc_hd__clkbuf_1
Xoutput185 net185 VSS VSS VDD VDD all_counts[254] sky130_fd_sc_hd__clkbuf_1
Xoutput186 net186 VSS VSS VDD VDD all_counts[255] sky130_fd_sc_hd__clkbuf_1
Xoutput187 net187 VSS VSS VDD VDD all_counts[25] sky130_fd_sc_hd__clkbuf_1
Xoutput188 net188 VSS VSS VDD VDD all_counts[26] sky130_fd_sc_hd__clkbuf_1
Xoutput189 net189 VSS VSS VDD VDD all_counts[27] sky130_fd_sc_hd__clkbuf_1
Xoutput190 net190 VSS VSS VDD VDD all_counts[28] sky130_fd_sc_hd__clkbuf_1
Xoutput191 net191 VSS VSS VDD VDD all_counts[29] sky130_fd_sc_hd__clkbuf_1
Xoutput192 net192 VSS VSS VDD VDD all_counts[2] sky130_fd_sc_hd__clkbuf_1
Xoutput193 net193 VSS VSS VDD VDD all_counts[30] sky130_fd_sc_hd__clkbuf_1
Xoutput194 net194 VSS VSS VDD VDD all_counts[31] sky130_fd_sc_hd__clkbuf_1
Xoutput195 net195 VSS VSS VDD VDD all_counts[32] sky130_fd_sc_hd__clkbuf_1
Xoutput196 net196 VSS VSS VDD VDD all_counts[33] sky130_fd_sc_hd__clkbuf_1
Xoutput197 net197 VSS VSS VDD VDD all_counts[34] sky130_fd_sc_hd__clkbuf_1
Xoutput198 net198 VSS VSS VDD VDD all_counts[35] sky130_fd_sc_hd__clkbuf_1
Xoutput199 net199 VSS VSS VDD VDD all_counts[36] sky130_fd_sc_hd__clkbuf_1
Xoutput200 net200 VSS VSS VDD VDD all_counts[37] sky130_fd_sc_hd__clkbuf_1
Xoutput201 net201 VSS VSS VDD VDD all_counts[38] sky130_fd_sc_hd__clkbuf_1
Xoutput202 net202 VSS VSS VDD VDD all_counts[39] sky130_fd_sc_hd__clkbuf_1
Xoutput203 net203 VSS VSS VDD VDD all_counts[3] sky130_fd_sc_hd__clkbuf_1
Xoutput204 net204 VSS VSS VDD VDD all_counts[40] sky130_fd_sc_hd__clkbuf_1
Xoutput205 net205 VSS VSS VDD VDD all_counts[41] sky130_fd_sc_hd__clkbuf_1
Xoutput206 net206 VSS VSS VDD VDD all_counts[42] sky130_fd_sc_hd__clkbuf_1
Xoutput207 net207 VSS VSS VDD VDD all_counts[43] sky130_fd_sc_hd__clkbuf_1
Xoutput208 net208 VSS VSS VDD VDD all_counts[44] sky130_fd_sc_hd__clkbuf_1
Xoutput209 net209 VSS VSS VDD VDD all_counts[45] sky130_fd_sc_hd__clkbuf_1
Xoutput210 net210 VSS VSS VDD VDD all_counts[46] sky130_fd_sc_hd__clkbuf_1
Xoutput211 net211 VSS VSS VDD VDD all_counts[47] sky130_fd_sc_hd__clkbuf_1
Xoutput212 net212 VSS VSS VDD VDD all_counts[48] sky130_fd_sc_hd__clkbuf_1
Xoutput213 net213 VSS VSS VDD VDD all_counts[49] sky130_fd_sc_hd__clkbuf_1
Xoutput214 net214 VSS VSS VDD VDD all_counts[4] sky130_fd_sc_hd__clkbuf_1
Xoutput215 net215 VSS VSS VDD VDD all_counts[50] sky130_fd_sc_hd__clkbuf_1
Xoutput216 net216 VSS VSS VDD VDD all_counts[51] sky130_fd_sc_hd__clkbuf_1
Xoutput217 net217 VSS VSS VDD VDD all_counts[52] sky130_fd_sc_hd__clkbuf_1
Xoutput218 net218 VSS VSS VDD VDD all_counts[53] sky130_fd_sc_hd__clkbuf_1
Xoutput219 net219 VSS VSS VDD VDD all_counts[54] sky130_fd_sc_hd__clkbuf_1
Xoutput220 net220 VSS VSS VDD VDD all_counts[55] sky130_fd_sc_hd__clkbuf_1
Xoutput221 net221 VSS VSS VDD VDD all_counts[56] sky130_fd_sc_hd__clkbuf_1
Xoutput222 net222 VSS VSS VDD VDD all_counts[57] sky130_fd_sc_hd__clkbuf_1
Xoutput223 net223 VSS VSS VDD VDD all_counts[58] sky130_fd_sc_hd__clkbuf_1
Xoutput224 net224 VSS VSS VDD VDD all_counts[59] sky130_fd_sc_hd__clkbuf_1
Xoutput225 net225 VSS VSS VDD VDD all_counts[5] sky130_fd_sc_hd__clkbuf_1
Xoutput226 net226 VSS VSS VDD VDD all_counts[60] sky130_fd_sc_hd__clkbuf_1
Xoutput227 net227 VSS VSS VDD VDD all_counts[61] sky130_fd_sc_hd__clkbuf_1
Xoutput228 net228 VSS VSS VDD VDD all_counts[62] sky130_fd_sc_hd__clkbuf_1
Xoutput229 net229 VSS VSS VDD VDD all_counts[63] sky130_fd_sc_hd__clkbuf_1
Xoutput230 net230 VSS VSS VDD VDD all_counts[64] sky130_fd_sc_hd__clkbuf_1
Xoutput231 net231 VSS VSS VDD VDD all_counts[65] sky130_fd_sc_hd__clkbuf_1
Xoutput232 net232 VSS VSS VDD VDD all_counts[66] sky130_fd_sc_hd__clkbuf_1
Xoutput233 net233 VSS VSS VDD VDD all_counts[67] sky130_fd_sc_hd__clkbuf_1
Xoutput234 net234 VSS VSS VDD VDD all_counts[68] sky130_fd_sc_hd__clkbuf_1
Xoutput235 net235 VSS VSS VDD VDD all_counts[69] sky130_fd_sc_hd__clkbuf_1
Xoutput236 net236 VSS VSS VDD VDD all_counts[6] sky130_fd_sc_hd__clkbuf_1
Xoutput237 net237 VSS VSS VDD VDD all_counts[70] sky130_fd_sc_hd__clkbuf_1
Xoutput238 net238 VSS VSS VDD VDD all_counts[71] sky130_fd_sc_hd__clkbuf_1
Xoutput239 net239 VSS VSS VDD VDD all_counts[72] sky130_fd_sc_hd__clkbuf_1
Xoutput240 net240 VSS VSS VDD VDD all_counts[73] sky130_fd_sc_hd__clkbuf_1
Xoutput241 net241 VSS VSS VDD VDD all_counts[74] sky130_fd_sc_hd__clkbuf_1
Xoutput242 net242 VSS VSS VDD VDD all_counts[75] sky130_fd_sc_hd__clkbuf_1
Xoutput243 net243 VSS VSS VDD VDD all_counts[76] sky130_fd_sc_hd__clkbuf_1
Xoutput244 net244 VSS VSS VDD VDD all_counts[77] sky130_fd_sc_hd__clkbuf_1
Xoutput245 net245 VSS VSS VDD VDD all_counts[78] sky130_fd_sc_hd__clkbuf_1
Xoutput246 net246 VSS VSS VDD VDD all_counts[79] sky130_fd_sc_hd__clkbuf_1
Xoutput247 net247 VSS VSS VDD VDD all_counts[7] sky130_fd_sc_hd__clkbuf_1
Xoutput248 net248 VSS VSS VDD VDD all_counts[80] sky130_fd_sc_hd__clkbuf_1
Xoutput249 net249 VSS VSS VDD VDD all_counts[81] sky130_fd_sc_hd__clkbuf_1
Xoutput250 net250 VSS VSS VDD VDD all_counts[82] sky130_fd_sc_hd__clkbuf_1
Xoutput251 net251 VSS VSS VDD VDD all_counts[83] sky130_fd_sc_hd__clkbuf_1
Xoutput252 net252 VSS VSS VDD VDD all_counts[84] sky130_fd_sc_hd__clkbuf_1
Xoutput253 net253 VSS VSS VDD VDD all_counts[85] sky130_fd_sc_hd__clkbuf_1
Xoutput254 net254 VSS VSS VDD VDD all_counts[86] sky130_fd_sc_hd__clkbuf_1
Xoutput255 net255 VSS VSS VDD VDD all_counts[87] sky130_fd_sc_hd__clkbuf_1
Xoutput256 net256 VSS VSS VDD VDD all_counts[88] sky130_fd_sc_hd__clkbuf_1
Xoutput257 net257 VSS VSS VDD VDD all_counts[89] sky130_fd_sc_hd__clkbuf_1
Xoutput258 net258 VSS VSS VDD VDD all_counts[8] sky130_fd_sc_hd__clkbuf_1
Xoutput259 net259 VSS VSS VDD VDD all_counts[90] sky130_fd_sc_hd__clkbuf_1
Xoutput260 net260 VSS VSS VDD VDD all_counts[91] sky130_fd_sc_hd__clkbuf_1
Xoutput261 net261 VSS VSS VDD VDD all_counts[92] sky130_fd_sc_hd__clkbuf_1
Xoutput262 net262 VSS VSS VDD VDD all_counts[93] sky130_fd_sc_hd__clkbuf_1
Xoutput263 net263 VSS VSS VDD VDD all_counts[94] sky130_fd_sc_hd__clkbuf_1
Xoutput264 net264 VSS VSS VDD VDD all_counts[95] sky130_fd_sc_hd__clkbuf_1
Xoutput265 net265 VSS VSS VDD VDD all_counts[96] sky130_fd_sc_hd__clkbuf_1
Xoutput266 net266 VSS VSS VDD VDD all_counts[97] sky130_fd_sc_hd__clkbuf_1
Xoutput267 net267 VSS VSS VDD VDD all_counts[98] sky130_fd_sc_hd__clkbuf_1
Xoutput268 net268 VSS VSS VDD VDD all_counts[99] sky130_fd_sc_hd__clkbuf_1
Xoutput269 net269 VSS VSS VDD VDD all_counts[9] sky130_fd_sc_hd__clkbuf_1
Xoutput270 net270 VSS VSS VDD VDD count_value[0] sky130_fd_sc_hd__clkbuf_1
Xoutput271 net271 VSS VSS VDD VDD count_value[10] sky130_fd_sc_hd__clkbuf_1
Xoutput272 net272 VSS VSS VDD VDD count_value[11] sky130_fd_sc_hd__clkbuf_1
Xoutput273 net273 VSS VSS VDD VDD count_value[12] sky130_fd_sc_hd__clkbuf_1
Xoutput274 net274 VSS VSS VDD VDD count_value[13] sky130_fd_sc_hd__clkbuf_1
Xoutput275 net275 VSS VSS VDD VDD count_value[14] sky130_fd_sc_hd__clkbuf_1
Xoutput276 net276 VSS VSS VDD VDD count_value[15] sky130_fd_sc_hd__clkbuf_1
Xoutput277 net277 VSS VSS VDD VDD count_value[16] sky130_fd_sc_hd__clkbuf_1
Xoutput278 net278 VSS VSS VDD VDD count_value[17] sky130_fd_sc_hd__clkbuf_1
Xoutput279 net279 VSS VSS VDD VDD count_value[18] sky130_fd_sc_hd__clkbuf_1
Xoutput280 net280 VSS VSS VDD VDD count_value[19] sky130_fd_sc_hd__clkbuf_1
Xoutput281 net281 VSS VSS VDD VDD count_value[1] sky130_fd_sc_hd__clkbuf_1
Xoutput282 net282 VSS VSS VDD VDD count_value[20] sky130_fd_sc_hd__clkbuf_1
Xoutput283 net283 VSS VSS VDD VDD count_value[21] sky130_fd_sc_hd__clkbuf_1
Xoutput284 net284 VSS VSS VDD VDD count_value[22] sky130_fd_sc_hd__clkbuf_1
Xoutput285 net285 VSS VSS VDD VDD count_value[23] sky130_fd_sc_hd__clkbuf_1
Xoutput286 net286 VSS VSS VDD VDD count_value[24] sky130_fd_sc_hd__clkbuf_1
Xoutput287 net287 VSS VSS VDD VDD count_value[25] sky130_fd_sc_hd__clkbuf_1
Xoutput288 net288 VSS VSS VDD VDD count_value[26] sky130_fd_sc_hd__clkbuf_1
Xoutput289 net289 VSS VSS VDD VDD count_value[27] sky130_fd_sc_hd__clkbuf_1
Xoutput290 net290 VSS VSS VDD VDD count_value[28] sky130_fd_sc_hd__clkbuf_1
Xoutput291 net291 VSS VSS VDD VDD count_value[29] sky130_fd_sc_hd__clkbuf_1
Xoutput292 net292 VSS VSS VDD VDD count_value[2] sky130_fd_sc_hd__clkbuf_1
Xoutput293 net293 VSS VSS VDD VDD count_value[30] sky130_fd_sc_hd__clkbuf_1
Xoutput294 net294 VSS VSS VDD VDD count_value[31] sky130_fd_sc_hd__clkbuf_1
Xoutput295 net295 VSS VSS VDD VDD count_value[3] sky130_fd_sc_hd__clkbuf_1
Xoutput296 net296 VSS VSS VDD VDD count_value[4] sky130_fd_sc_hd__clkbuf_1
Xoutput297 net297 VSS VSS VDD VDD count_value[5] sky130_fd_sc_hd__clkbuf_1
Xoutput298 net298 VSS VSS VDD VDD count_value[6] sky130_fd_sc_hd__clkbuf_1
Xoutput299 net299 VSS VSS VDD VDD count_value[7] sky130_fd_sc_hd__clkbuf_1
Xoutput300 net300 VSS VSS VDD VDD count_value[8] sky130_fd_sc_hd__clkbuf_1
Xoutput301 net301 VSS VSS VDD VDD count_value[9] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_0_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_1_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_1_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_2_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_2_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_3_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_3_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_4_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_4_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_5_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_5_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_6_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_6_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_7_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_7_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_8_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_8_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_9_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_9_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_10_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_10_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_11_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_11_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_12_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_12_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_13_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_13_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_14_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_14_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_15_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_15_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_16_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_16_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_17_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_17_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_18_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_18_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_19_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_19_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_20_clk clknet_1_1__leaf_clk VSS VSS VDD VDD clknet_leaf_20_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_21_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_21_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_22_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_22_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_23_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_23_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_24_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_24_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_25_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_25_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_26_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_26_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_27_clk clknet_1_0__leaf_clk VSS VSS VDD VDD clknet_leaf_27_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__inv_6
Xclkload1 clknet_leaf_0_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkbuf_8
Xclkload2 clknet_leaf_1_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__clkbuf_8
Xclkload3 clknet_leaf_2_clk VSS VSS VDD VDD _unconnected_3
+ sky130_fd_sc_hd__clkbuf_8
Xclkload4 clknet_leaf_3_clk VSS VSS VDD VDD _unconnected_4
+ sky130_fd_sc_hd__clkinv_2
Xclkload5 clknet_leaf_4_clk VSS VSS VDD VDD _unconnected_5
+ sky130_fd_sc_hd__clkinv_2
Xclkload6 clknet_leaf_6_clk VSS VSS VDD VDD _unconnected_6
+ sky130_fd_sc_hd__clkbuf_1
Xclkload7 clknet_leaf_7_clk VSS VSS VDD VDD _unconnected_7
+ sky130_fd_sc_hd__clkbuf_1
Xclkload8 clknet_leaf_21_clk VSS VSS VDD VDD _unconnected_8
+ sky130_fd_sc_hd__clkinv_2
Xclkload9 clknet_leaf_22_clk VSS VSS VDD VDD _unconnected_9
+ sky130_fd_sc_hd__clkbuf_1
Xclkload10 clknet_leaf_23_clk VSS VSS VDD VDD _unconnected_10
+ sky130_fd_sc_hd__clkbuf_8
Xclkload11 clknet_leaf_24_clk VSS VSS VDD VDD _unconnected_11
+ sky130_fd_sc_hd__clkbuf_1
Xclkload12 clknet_leaf_25_clk VSS VSS VDD VDD _unconnected_12
+ sky130_fd_sc_hd__clkbuf_1
Xclkload13 clknet_leaf_26_clk VSS VSS VDD VDD _unconnected_13
+ sky130_fd_sc_hd__clkbuf_8
Xclkload14 clknet_leaf_27_clk VSS VSS VDD VDD _unconnected_14
+ sky130_fd_sc_hd__inv_8
Xclkload15 clknet_leaf_8_clk VSS VSS VDD VDD _unconnected_15
+ sky130_fd_sc_hd__clkbuf_8
Xclkload16 clknet_leaf_9_clk VSS VSS VDD VDD _unconnected_16
+ sky130_fd_sc_hd__clkbuf_8
Xclkload17 clknet_leaf_11_clk VSS VSS VDD VDD _unconnected_17
+ sky130_fd_sc_hd__clkbuf_1
Xclkload18 clknet_leaf_12_clk VSS VSS VDD VDD _unconnected_18
+ sky130_fd_sc_hd__clkbuf_8
Xclkload19 clknet_leaf_13_clk VSS VSS VDD VDD _unconnected_19
+ sky130_fd_sc_hd__clkbuf_8
Xclkload20 clknet_leaf_14_clk VSS VSS VDD VDD _unconnected_20
+ sky130_fd_sc_hd__bufinv_16
Xclkload21 clknet_leaf_15_clk VSS VSS VDD VDD _unconnected_21
+ sky130_fd_sc_hd__clkbuf_8
Xclkload22 clknet_leaf_16_clk VSS VSS VDD VDD _unconnected_22
+ sky130_fd_sc_hd__clkinv_2
Xclkload23 clknet_leaf_17_clk VSS VSS VDD VDD _unconnected_23
+ sky130_fd_sc_hd__clkbuf_8
Xclkload24 clknet_leaf_18_clk VSS VSS VDD VDD _unconnected_24
+ sky130_fd_sc_hd__clkbuf_1
Xclkload25 clknet_leaf_19_clk VSS VSS VDD VDD _unconnected_25
+ sky130_fd_sc_hd__clkbuf_8
Xclkload26 clknet_leaf_20_clk VSS VSS VDD VDD _unconnected_26
+ sky130_fd_sc_hd__clkinv_2
Xhold1 event_inc[1] VSS VSS VDD VDD net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold2 event_inc[4] VSS VSS VDD VDD net303 sky130_fd_sc_hd__dlygate4sd3_1
Xhold3 event_inc[0] VSS VSS VDD VDD net304 sky130_fd_sc_hd__dlygate4sd3_1
Xhold4 event_inc[5] VSS VSS VDD VDD net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold5 event_inc[3] VSS VSS VDD VDD net306 sky130_fd_sc_hd__dlygate4sd3_1
Xhold6 event_inc[2] VSS VSS VDD VDD net307 sky130_fd_sc_hd__dlygate4sd3_1
Xhold7 event_inc[7] VSS VSS VDD VDD net308 sky130_fd_sc_hd__dlygate4sd3_1
Xhold8 event_inc[6] VSS VSS VDD VDD net309 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_1 _0912_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_2 net191 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS performance_counter
