* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT configurable_carry_skip_adder a[0] a[10] a[11] a[12]
+ a[13] a[14] a[15] a[16] a[17] a[18] a[19] a[1] a[20] a[21]
+ a[22] a[23] a[24] a[25] a[26] a[27] a[28] a[29] a[2] a[30]
+ a[31] a[3] a[4] a[5] a[6] a[7] a[8] a[9] b[0] b[10] b[11]
+ b[12] b[13] b[14] b[15] b[16] b[17] b[18] b[19] b[1] b[20]
+ b[21] b[22] b[23] b[24] b[25] b[26] b[27] b[28] b[29] b[2]
+ b[30] b[31] b[3] b[4] b[5] b[6] b[7] b[8] b[9] cin cout sum[0]
+ sum[10] sum[11] sum[12] sum[13] sum[14] sum[15] sum[16] sum[17]
+ sum[18] sum[19] sum[1] sum[20] sum[21] sum[22] sum[23] sum[24]
+ sum[25] sum[26] sum[27] sum[28] sum[29] sum[2] sum[30] sum[31]
+ sum[3] sum[4] sum[5] sum[6] sum[7] sum[8] sum[9]
X_225_ net65 VSS VSS VDD VDD _053_ sky130_fd_sc_hd__inv_1
X_226_ net25 VSS VSS VDD VDD _030_ sky130_fd_sc_hd__inv_1
X_227_ net57 VSS VSS VDD VDD _031_ sky130_fd_sc_hd__inv_1
X_228_ _102_ _106_ _110_ _114_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__nand4_2
X_229_ net65 _035_ _000_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__mux2i_4
X_230_ _001_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__inv_1
X_231_ _118_ _122_ _126_ _130_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__and4_1
X_232_ _044_ _002_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__nor2_1
X_233_ _001_ _002_ _003_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__a21oi_1
X_234_ _134_ _138_ _142_ _146_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__nand4_1
X_235_ _001_ _002_ _003_ _004_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__a211oi_2
X_236_ _057_ _004_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__nand2_1
X_237_ _005_ _006_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__nand2b_1
X_238_ _150_ _154_ _158_ _162_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__and4_1
X_239_ _006_ _007_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__nand2_1
X_240_ _066_ _007_ _008_ _005_ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__o22a_1
X_241_ _054_ VSS VSS VDD VDD _077_ sky130_fd_sc_hd__inv_1
X_242_ _166_ _170_ _174_ _178_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__nand4_2
X_243_ _068_ _075_ _009_ VSS VSS VDD VDD _079_ sky130_fd_sc_hd__mux2_1
X_244_ _066_ _007_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__nor2_1
X_245_ _182_ _186_ _190_ _194_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__nand4_1
X_246_ _010_ _009_ _011_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__nor3_1
X_247_ _005_ _008_ _012_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__o21ai_1
X_248_ _075_ _009_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__nand2_1
X_249_ _086_ _011_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__nand2_1
X_250_ _014_ _011_ _015_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__o21ai_1
X_251_ _016_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__inv_1
X_252_ _013_ _017_ VSS VSS VDD VDD _088_ sky130_fd_sc_hd__nand2_1
X_253_ _198_ _202_ _206_ _210_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__nand4_1
X_254_ _016_ _018_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__nor2_1
X_255_ _095_ _018_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__nor2b_1
X_256_ _013_ _019_ _020_ VSS VSS VDD VDD _097_ sky130_fd_sc_hd__a21oi_1
X_257_ _026_ VSS VSS VDD VDD net89 sky130_fd_sc_hd__inv_1
X_258_ _029_ VSS VSS VDD VDD net90 sky130_fd_sc_hd__inv_1
X_259_ _034_ VSS VSS VDD VDD net91 sky130_fd_sc_hd__inv_1
X_260_ _036_ VSS VSS VDD VDD net92 sky130_fd_sc_hd__inv_1
X_261_ _039_ VSS VSS VDD VDD net93 sky130_fd_sc_hd__inv_1
X_262_ _041_ VSS VSS VDD VDD net94 sky130_fd_sc_hd__inv_1
X_263_ _043_ VSS VSS VDD VDD net95 sky130_fd_sc_hd__inv_1
X_264_ _045_ VSS VSS VDD VDD net96 sky130_fd_sc_hd__inv_1
X_265_ _048_ VSS VSS VDD VDD net97 sky130_fd_sc_hd__inv_1
X_266_ _050_ VSS VSS VDD VDD net98 sky130_fd_sc_hd__inv_1
X_267_ _056_ VSS VSS VDD VDD net68 sky130_fd_sc_hd__inv_1
X_268_ _058_ VSS VSS VDD VDD net69 sky130_fd_sc_hd__inv_1
X_269_ _061_ VSS VSS VDD VDD net70 sky130_fd_sc_hd__inv_1
X_270_ _063_ VSS VSS VDD VDD net71 sky130_fd_sc_hd__inv_1
X_271_ _065_ VSS VSS VDD VDD net72 sky130_fd_sc_hd__inv_1
X_272_ _067_ VSS VSS VDD VDD net73 sky130_fd_sc_hd__inv_1
X_273_ _070_ VSS VSS VDD VDD net74 sky130_fd_sc_hd__inv_1
X_274_ _072_ VSS VSS VDD VDD net75 sky130_fd_sc_hd__inv_1
X_275_ _074_ VSS VSS VDD VDD net76 sky130_fd_sc_hd__inv_1
X_276_ _076_ VSS VSS VDD VDD net77 sky130_fd_sc_hd__inv_1
X_277_ _078_ VSS VSS VDD VDD net78 sky130_fd_sc_hd__inv_1
X_278_ _081_ VSS VSS VDD VDD net79 sky130_fd_sc_hd__inv_1
X_279_ _083_ VSS VSS VDD VDD net80 sky130_fd_sc_hd__inv_1
X_280_ _085_ VSS VSS VDD VDD net81 sky130_fd_sc_hd__inv_1
X_281_ _087_ VSS VSS VDD VDD net82 sky130_fd_sc_hd__inv_1
X_282_ _090_ VSS VSS VDD VDD net83 sky130_fd_sc_hd__inv_1
X_283_ _092_ VSS VSS VDD VDD net84 sky130_fd_sc_hd__inv_1
X_284_ _094_ VSS VSS VDD VDD net85 sky130_fd_sc_hd__inv_1
X_285_ _096_ VSS VSS VDD VDD net86 sky130_fd_sc_hd__inv_1
X_286_ _099_ VSS VSS VDD VDD net87 sky130_fd_sc_hd__inv_1
X_287_ _100_ VSS VSS VDD VDD net88 sky130_fd_sc_hd__inv_1
X_288_ _028_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__inv_1
X_289_ net1 VSS VSS VDD VDD _051_ sky130_fd_sc_hd__inv_1
X_290_ net12 VSS VSS VDD VDD _103_ sky130_fd_sc_hd__inv_1
X_291_ net23 VSS VSS VDD VDD _107_ sky130_fd_sc_hd__inv_1
X_292_ net26 VSS VSS VDD VDD _111_ sky130_fd_sc_hd__inv_1
X_293_ net27 VSS VSS VDD VDD _115_ sky130_fd_sc_hd__inv_1
X_294_ net28 VSS VSS VDD VDD _119_ sky130_fd_sc_hd__inv_1
X_295_ net29 VSS VSS VDD VDD _123_ sky130_fd_sc_hd__inv_1
X_296_ net30 VSS VSS VDD VDD _127_ sky130_fd_sc_hd__inv_1
X_297_ net31 VSS VSS VDD VDD _131_ sky130_fd_sc_hd__inv_1
X_298_ net32 VSS VSS VDD VDD _135_ sky130_fd_sc_hd__inv_1
X_299_ net2 VSS VSS VDD VDD _139_ sky130_fd_sc_hd__inv_1
X_300_ net3 VSS VSS VDD VDD _143_ sky130_fd_sc_hd__inv_1
X_301_ net4 VSS VSS VDD VDD _147_ sky130_fd_sc_hd__inv_1
X_302_ net5 VSS VSS VDD VDD _151_ sky130_fd_sc_hd__inv_1
X_303_ net6 VSS VSS VDD VDD _155_ sky130_fd_sc_hd__inv_1
X_304_ net7 VSS VSS VDD VDD _159_ sky130_fd_sc_hd__inv_1
X_305_ net8 VSS VSS VDD VDD _163_ sky130_fd_sc_hd__inv_1
X_306_ net9 VSS VSS VDD VDD _167_ sky130_fd_sc_hd__inv_1
X_307_ net10 VSS VSS VDD VDD _171_ sky130_fd_sc_hd__inv_1
X_308_ net11 VSS VSS VDD VDD _175_ sky130_fd_sc_hd__inv_1
X_309_ net13 VSS VSS VDD VDD _179_ sky130_fd_sc_hd__inv_1
X_310_ net14 VSS VSS VDD VDD _183_ sky130_fd_sc_hd__inv_1
X_311_ net15 VSS VSS VDD VDD _187_ sky130_fd_sc_hd__inv_1
X_312_ net16 VSS VSS VDD VDD _191_ sky130_fd_sc_hd__inv_1
X_313_ net17 VSS VSS VDD VDD _195_ sky130_fd_sc_hd__inv_1
X_314_ net18 VSS VSS VDD VDD _199_ sky130_fd_sc_hd__inv_1
X_315_ net19 VSS VSS VDD VDD _203_ sky130_fd_sc_hd__inv_1
X_316_ net20 VSS VSS VDD VDD _207_ sky130_fd_sc_hd__inv_1
X_317_ net21 VSS VSS VDD VDD _211_ sky130_fd_sc_hd__inv_1
X_318_ net22 VSS VSS VDD VDD _215_ sky130_fd_sc_hd__inv_1
X_319_ net24 VSS VSS VDD VDD _219_ sky130_fd_sc_hd__inv_1
X_320_ net33 VSS VSS VDD VDD _052_ sky130_fd_sc_hd__inv_1
X_321_ net44 VSS VSS VDD VDD _104_ sky130_fd_sc_hd__inv_1
X_322_ net55 VSS VSS VDD VDD _108_ sky130_fd_sc_hd__inv_1
X_323_ net58 VSS VSS VDD VDD _112_ sky130_fd_sc_hd__inv_1
X_324_ net59 VSS VSS VDD VDD _116_ sky130_fd_sc_hd__inv_1
X_325_ net60 VSS VSS VDD VDD _120_ sky130_fd_sc_hd__inv_1
X_326_ net61 VSS VSS VDD VDD _124_ sky130_fd_sc_hd__inv_1
X_327_ net62 VSS VSS VDD VDD _128_ sky130_fd_sc_hd__inv_1
X_328_ net63 VSS VSS VDD VDD _132_ sky130_fd_sc_hd__inv_1
X_329_ net64 VSS VSS VDD VDD _136_ sky130_fd_sc_hd__inv_1
X_330_ net34 VSS VSS VDD VDD _140_ sky130_fd_sc_hd__inv_1
X_331_ net35 VSS VSS VDD VDD _144_ sky130_fd_sc_hd__inv_1
X_332_ net36 VSS VSS VDD VDD _148_ sky130_fd_sc_hd__inv_1
X_333_ net37 VSS VSS VDD VDD _152_ sky130_fd_sc_hd__inv_1
X_334_ net38 VSS VSS VDD VDD _156_ sky130_fd_sc_hd__inv_1
X_335_ net39 VSS VSS VDD VDD _160_ sky130_fd_sc_hd__inv_1
X_336_ net40 VSS VSS VDD VDD _164_ sky130_fd_sc_hd__inv_1
X_337_ net41 VSS VSS VDD VDD _168_ sky130_fd_sc_hd__inv_1
X_338_ net42 VSS VSS VDD VDD _172_ sky130_fd_sc_hd__inv_1
X_339_ net43 VSS VSS VDD VDD _176_ sky130_fd_sc_hd__inv_1
X_340_ net45 VSS VSS VDD VDD _180_ sky130_fd_sc_hd__inv_1
X_341_ net46 VSS VSS VDD VDD _184_ sky130_fd_sc_hd__inv_1
X_342_ net47 VSS VSS VDD VDD _188_ sky130_fd_sc_hd__inv_1
X_343_ net48 VSS VSS VDD VDD _192_ sky130_fd_sc_hd__inv_1
X_344_ net49 VSS VSS VDD VDD _196_ sky130_fd_sc_hd__inv_1
X_345_ net50 VSS VSS VDD VDD _200_ sky130_fd_sc_hd__inv_1
X_346_ net51 VSS VSS VDD VDD _204_ sky130_fd_sc_hd__inv_1
X_347_ net52 VSS VSS VDD VDD _208_ sky130_fd_sc_hd__inv_1
X_348_ net53 VSS VSS VDD VDD _212_ sky130_fd_sc_hd__inv_1
X_349_ net54 VSS VSS VDD VDD _216_ sky130_fd_sc_hd__inv_1
X_350_ net56 VSS VSS VDD VDD _220_ sky130_fd_sc_hd__inv_1
X_351_ _214_ _218_ _222_ _224_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__nand4_1
X_352_ _016_ _018_ _021_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__nor3_1
X_353_ _020_ _033_ _021_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__mux2_1
X_354_ _013_ _022_ _023_ VSS VSS VDD VDD net66 sky130_fd_sc_hd__a21oi_1
X_355_ net23 net55 _024_ VSS VSS VDD VDD _025_ _026_ sky130_fd_sc_hd__fa_1
X_356_ net24 net56 _027_ VSS VSS VDD VDD _028_ _029_ sky130_fd_sc_hd__fa_1
X_357_ _030_ _031_ _032_ VSS VSS VDD VDD _033_ _034_ sky130_fd_sc_hd__fa_1
X_358_ net26 net58 _025_ VSS VSS VDD VDD _035_ _036_ sky130_fd_sc_hd__fa_1
X_359_ net27 net59 _037_ VSS VSS VDD VDD _038_ _039_ sky130_fd_sc_hd__fa_1
X_360_ net28 net60 _038_ VSS VSS VDD VDD _040_ _041_ sky130_fd_sc_hd__fa_1
X_361_ net29 net61 _040_ VSS VSS VDD VDD _042_ _043_ sky130_fd_sc_hd__fa_1
X_362_ net30 net62 _042_ VSS VSS VDD VDD _044_ _045_ sky130_fd_sc_hd__fa_1
X_363_ net31 net63 _046_ VSS VSS VDD VDD _047_ _048_ sky130_fd_sc_hd__fa_1
X_364_ net32 net64 _047_ VSS VSS VDD VDD _049_ _050_ sky130_fd_sc_hd__fa_1
X_365_ _051_ _052_ _053_ VSS VSS VDD VDD _054_ net67 sky130_fd_sc_hd__fa_1
X_366_ net2 net34 _049_ VSS VSS VDD VDD _055_ _056_ sky130_fd_sc_hd__fa_1
X_367_ net3 net35 _055_ VSS VSS VDD VDD _057_ _058_ sky130_fd_sc_hd__fa_1
X_368_ net4 net36 _059_ VSS VSS VDD VDD _060_ _061_ sky130_fd_sc_hd__fa_1
X_369_ net5 net37 _060_ VSS VSS VDD VDD _062_ _063_ sky130_fd_sc_hd__fa_1
X_370_ net6 net38 _062_ VSS VSS VDD VDD _064_ _065_ sky130_fd_sc_hd__fa_1
X_371_ net7 net39 _064_ VSS VSS VDD VDD _066_ _067_ sky130_fd_sc_hd__fa_1
X_372_ net8 net40 _068_ VSS VSS VDD VDD _069_ _070_ sky130_fd_sc_hd__fa_1
X_373_ net9 net41 _069_ VSS VSS VDD VDD _071_ _072_ sky130_fd_sc_hd__fa_1
X_374_ net10 net42 _071_ VSS VSS VDD VDD _073_ _074_ sky130_fd_sc_hd__fa_1
X_375_ net11 net43 _073_ VSS VSS VDD VDD _075_ _076_ sky130_fd_sc_hd__fa_1
X_376_ net12 net44 _077_ VSS VSS VDD VDD _024_ _078_ sky130_fd_sc_hd__fa_1
X_377_ net13 net45 _079_ VSS VSS VDD VDD _080_ _081_ sky130_fd_sc_hd__fa_1
X_378_ net14 net46 _080_ VSS VSS VDD VDD _082_ _083_ sky130_fd_sc_hd__fa_1
X_379_ net15 net47 _082_ VSS VSS VDD VDD _084_ _085_ sky130_fd_sc_hd__fa_1
X_380_ net16 net48 _084_ VSS VSS VDD VDD _086_ _087_ sky130_fd_sc_hd__fa_1
X_381_ net17 net49 _088_ VSS VSS VDD VDD _089_ _090_ sky130_fd_sc_hd__fa_1
X_382_ net18 net50 _089_ VSS VSS VDD VDD _091_ _092_ sky130_fd_sc_hd__fa_1
X_383_ net19 net51 _091_ VSS VSS VDD VDD _093_ _094_ sky130_fd_sc_hd__fa_1
X_384_ net20 net52 _093_ VSS VSS VDD VDD _095_ _096_ sky130_fd_sc_hd__fa_1
X_385_ net21 net53 _097_ VSS VSS VDD VDD _098_ _099_ sky130_fd_sc_hd__fa_1
X_386_ net22 net54 _098_ VSS VSS VDD VDD _027_ _100_ sky130_fd_sc_hd__fa_1
X_387_ _051_ _052_ VSS VSS VDD VDD _101_ _102_ sky130_fd_sc_hd__ha_1
X_388_ _103_ _104_ VSS VSS VDD VDD _105_ _106_ sky130_fd_sc_hd__ha_1
X_389_ _107_ _108_ VSS VSS VDD VDD _109_ _110_ sky130_fd_sc_hd__ha_1
X_390_ _111_ _112_ VSS VSS VDD VDD _113_ _114_ sky130_fd_sc_hd__ha_1
X_391_ _115_ _116_ VSS VSS VDD VDD _117_ _118_ sky130_fd_sc_hd__ha_1
X_392_ _119_ _120_ VSS VSS VDD VDD _121_ _122_ sky130_fd_sc_hd__ha_1
X_393_ _123_ _124_ VSS VSS VDD VDD _125_ _126_ sky130_fd_sc_hd__ha_1
X_394_ _127_ _128_ VSS VSS VDD VDD _129_ _130_ sky130_fd_sc_hd__ha_1
X_395_ _131_ _132_ VSS VSS VDD VDD _133_ _134_ sky130_fd_sc_hd__ha_1
X_396_ _135_ _136_ VSS VSS VDD VDD _137_ _138_ sky130_fd_sc_hd__ha_1
X_397_ _139_ _140_ VSS VSS VDD VDD _141_ _142_ sky130_fd_sc_hd__ha_1
X_398_ _143_ _144_ VSS VSS VDD VDD _145_ _146_ sky130_fd_sc_hd__ha_1
X_399_ _147_ _148_ VSS VSS VDD VDD _149_ _150_ sky130_fd_sc_hd__ha_1
X_400_ _151_ _152_ VSS VSS VDD VDD _153_ _154_ sky130_fd_sc_hd__ha_1
X_401_ _155_ _156_ VSS VSS VDD VDD _157_ _158_ sky130_fd_sc_hd__ha_1
X_402_ _159_ _160_ VSS VSS VDD VDD _161_ _162_ sky130_fd_sc_hd__ha_1
X_403_ _163_ _164_ VSS VSS VDD VDD _165_ _166_ sky130_fd_sc_hd__ha_1
X_404_ _167_ _168_ VSS VSS VDD VDD _169_ _170_ sky130_fd_sc_hd__ha_1
X_405_ _171_ _172_ VSS VSS VDD VDD _173_ _174_ sky130_fd_sc_hd__ha_1
X_406_ _175_ _176_ VSS VSS VDD VDD _177_ _178_ sky130_fd_sc_hd__ha_1
X_407_ _179_ _180_ VSS VSS VDD VDD _181_ _182_ sky130_fd_sc_hd__ha_1
X_408_ _183_ _184_ VSS VSS VDD VDD _185_ _186_ sky130_fd_sc_hd__ha_1
X_409_ _187_ _188_ VSS VSS VDD VDD _189_ _190_ sky130_fd_sc_hd__ha_1
X_410_ _191_ _192_ VSS VSS VDD VDD _193_ _194_ sky130_fd_sc_hd__ha_1
X_411_ _195_ _196_ VSS VSS VDD VDD _197_ _198_ sky130_fd_sc_hd__ha_1
X_412_ _199_ _200_ VSS VSS VDD VDD _201_ _202_ sky130_fd_sc_hd__ha_1
X_413_ _203_ _204_ VSS VSS VDD VDD _205_ _206_ sky130_fd_sc_hd__ha_1
X_414_ _207_ _208_ VSS VSS VDD VDD _209_ _210_ sky130_fd_sc_hd__ha_1
X_415_ _211_ _212_ VSS VSS VDD VDD _213_ _214_ sky130_fd_sc_hd__ha_1
X_416_ _215_ _216_ VSS VSS VDD VDD _217_ _218_ sky130_fd_sc_hd__ha_1
X_417_ _219_ _220_ VSS VSS VDD VDD _221_ _222_ sky130_fd_sc_hd__ha_1
X_418_ _030_ _031_ VSS VSS VDD VDD _223_ _224_ sky130_fd_sc_hd__ha_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 a[0] VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_1
Xinput2 a[10] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput3 a[11] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput4 a[12] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput5 a[13] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput6 a[14] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput7 a[15] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput8 a[16] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput9 a[17] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput10 a[18] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput11 a[19] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput12 a[1] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput13 a[20] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput14 a[21] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput15 a[22] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput16 a[23] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput17 a[24] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput18 a[25] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xinput19 a[26] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
Xinput20 a[27] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_1
Xinput21 a[28] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_1
Xinput22 a[29] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_1
Xinput23 a[2] VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_1
Xinput24 a[30] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
Xinput25 a[31] VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_1
Xinput26 a[3] VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_1
Xinput27 a[4] VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_1
Xinput28 a[5] VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_1
Xinput29 a[6] VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_1
Xinput30 a[7] VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_1
Xinput31 a[8] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_1
Xinput32 a[9] VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_1
Xinput33 b[0] VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_1
Xinput34 b[10] VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_1
Xinput35 b[11] VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_1
Xinput36 b[12] VSS VSS VDD VDD net36 sky130_fd_sc_hd__clkbuf_1
Xinput37 b[13] VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_1
Xinput38 b[14] VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkbuf_1
Xinput39 b[15] VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_1
Xinput40 b[16] VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_1
Xinput41 b[17] VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_1
Xinput42 b[18] VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_1
Xinput43 b[19] VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_1
Xinput44 b[1] VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_1
Xinput45 b[20] VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_1
Xinput46 b[21] VSS VSS VDD VDD net46 sky130_fd_sc_hd__clkbuf_1
Xinput47 b[22] VSS VSS VDD VDD net47 sky130_fd_sc_hd__clkbuf_1
Xinput48 b[23] VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkbuf_1
Xinput49 b[24] VSS VSS VDD VDD net49 sky130_fd_sc_hd__clkbuf_1
Xinput50 b[25] VSS VSS VDD VDD net50 sky130_fd_sc_hd__clkbuf_1
Xinput51 b[26] VSS VSS VDD VDD net51 sky130_fd_sc_hd__clkbuf_1
Xinput52 b[27] VSS VSS VDD VDD net52 sky130_fd_sc_hd__clkbuf_1
Xinput53 b[28] VSS VSS VDD VDD net53 sky130_fd_sc_hd__clkbuf_1
Xinput54 b[29] VSS VSS VDD VDD net54 sky130_fd_sc_hd__clkbuf_1
Xinput55 b[2] VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkbuf_1
Xinput56 b[30] VSS VSS VDD VDD net56 sky130_fd_sc_hd__clkbuf_1
Xinput57 b[31] VSS VSS VDD VDD net57 sky130_fd_sc_hd__clkbuf_1
Xinput58 b[3] VSS VSS VDD VDD net58 sky130_fd_sc_hd__clkbuf_1
Xinput59 b[4] VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_1
Xinput60 b[5] VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkbuf_1
Xinput61 b[6] VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkbuf_1
Xinput62 b[7] VSS VSS VDD VDD net62 sky130_fd_sc_hd__clkbuf_1
Xinput63 b[8] VSS VSS VDD VDD net63 sky130_fd_sc_hd__clkbuf_1
Xinput64 b[9] VSS VSS VDD VDD net64 sky130_fd_sc_hd__clkbuf_1
Xinput65 cin VSS VSS VDD VDD net65 sky130_fd_sc_hd__clkbuf_1
Xoutput66 net66 VSS VSS VDD VDD cout sky130_fd_sc_hd__clkbuf_1
Xoutput67 net67 VSS VSS VDD VDD sum[0] sky130_fd_sc_hd__clkbuf_1
Xoutput68 net68 VSS VSS VDD VDD sum[10] sky130_fd_sc_hd__clkbuf_1
Xoutput69 net69 VSS VSS VDD VDD sum[11] sky130_fd_sc_hd__clkbuf_1
Xoutput70 net70 VSS VSS VDD VDD sum[12] sky130_fd_sc_hd__clkbuf_1
Xoutput71 net71 VSS VSS VDD VDD sum[13] sky130_fd_sc_hd__clkbuf_1
Xoutput72 net72 VSS VSS VDD VDD sum[14] sky130_fd_sc_hd__clkbuf_1
Xoutput73 net73 VSS VSS VDD VDD sum[15] sky130_fd_sc_hd__clkbuf_1
Xoutput74 net74 VSS VSS VDD VDD sum[16] sky130_fd_sc_hd__clkbuf_1
Xoutput75 net75 VSS VSS VDD VDD sum[17] sky130_fd_sc_hd__clkbuf_1
Xoutput76 net76 VSS VSS VDD VDD sum[18] sky130_fd_sc_hd__clkbuf_1
Xoutput77 net77 VSS VSS VDD VDD sum[19] sky130_fd_sc_hd__clkbuf_1
Xoutput78 net78 VSS VSS VDD VDD sum[1] sky130_fd_sc_hd__clkbuf_1
Xoutput79 net79 VSS VSS VDD VDD sum[20] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net80 VSS VSS VDD VDD sum[21] sky130_fd_sc_hd__clkbuf_1
Xoutput81 net81 VSS VSS VDD VDD sum[22] sky130_fd_sc_hd__clkbuf_1
Xoutput82 net82 VSS VSS VDD VDD sum[23] sky130_fd_sc_hd__clkbuf_1
Xoutput83 net83 VSS VSS VDD VDD sum[24] sky130_fd_sc_hd__clkbuf_1
Xoutput84 net84 VSS VSS VDD VDD sum[25] sky130_fd_sc_hd__clkbuf_1
Xoutput85 net85 VSS VSS VDD VDD sum[26] sky130_fd_sc_hd__clkbuf_1
Xoutput86 net86 VSS VSS VDD VDD sum[27] sky130_fd_sc_hd__clkbuf_1
Xoutput87 net87 VSS VSS VDD VDD sum[28] sky130_fd_sc_hd__clkbuf_1
Xoutput88 net88 VSS VSS VDD VDD sum[29] sky130_fd_sc_hd__clkbuf_1
Xoutput89 net89 VSS VSS VDD VDD sum[2] sky130_fd_sc_hd__clkbuf_1
Xoutput90 net90 VSS VSS VDD VDD sum[30] sky130_fd_sc_hd__clkbuf_1
Xoutput91 net91 VSS VSS VDD VDD sum[31] sky130_fd_sc_hd__clkbuf_1
Xoutput92 net92 VSS VSS VDD VDD sum[3] sky130_fd_sc_hd__clkbuf_1
Xoutput93 net93 VSS VSS VDD VDD sum[4] sky130_fd_sc_hd__clkbuf_1
Xoutput94 net94 VSS VSS VDD VDD sum[5] sky130_fd_sc_hd__clkbuf_1
Xoutput95 net95 VSS VSS VDD VDD sum[6] sky130_fd_sc_hd__clkbuf_1
Xoutput96 net96 VSS VSS VDD VDD sum[7] sky130_fd_sc_hd__clkbuf_1
Xoutput97 net97 VSS VSS VDD VDD sum[8] sky130_fd_sc_hd__clkbuf_1
Xoutput98 net98 VSS VSS VDD VDD sum[9] sky130_fd_sc_hd__clkbuf_1
.ENDS configurable_carry_skip_adder
