* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT riscv aluout[0] aluout[10] aluout[11] aluout[12] aluout[13]
+ aluout[14] aluout[15] aluout[16] aluout[17] aluout[18] aluout[19]
+ aluout[1] aluout[20] aluout[21] aluout[22] aluout[23] aluout[24]
+ aluout[25] aluout[26] aluout[27] aluout[28] aluout[29] aluout[2]
+ aluout[30] aluout[31] aluout[3] aluout[4] aluout[5] aluout[6]
+ aluout[7] aluout[8] aluout[9] clk instr[0] instr[10] instr[11]
+ instr[12] instr[13] instr[14] instr[15] instr[16] instr[17]
+ instr[18] instr[19] instr[1] instr[20] instr[21] instr[22]
+ instr[23] instr[24] instr[25] instr[26] instr[27] instr[28]
+ instr[29] instr[2] instr[30] instr[31] instr[3] instr[4] instr[5]
+ instr[6] instr[7] instr[8] instr[9] memread memwrite pc[0]
+ pc[10] pc[11] pc[12] pc[13] pc[14] pc[15] pc[16] pc[17] pc[18]
+ pc[19] pc[1] pc[20] pc[21] pc[22] pc[23] pc[24] pc[25] pc[26]
+ pc[27] pc[28] pc[29] pc[2] pc[30] pc[31] pc[3] pc[4] pc[5]
+ pc[6] pc[7] pc[8] pc[9] readdata[0] readdata[10] readdata[11]
+ readdata[12] readdata[13] readdata[14] readdata[15] readdata[16]
+ readdata[17] readdata[18] readdata[19] readdata[1] readdata[20]
+ readdata[21] readdata[22] readdata[23] readdata[24] readdata[25]
+ readdata[26] readdata[27] readdata[28] readdata[29] readdata[2]
+ readdata[30] readdata[31] readdata[3] readdata[4] readdata[5]
+ readdata[6] readdata[7] readdata[8] readdata[9] reset suspend
+ writedata[0] writedata[10] writedata[11] writedata[12] writedata[13]
+ writedata[14] writedata[15] writedata[16] writedata[17] writedata[18]
+ writedata[19] writedata[1] writedata[20] writedata[21] writedata[22]
+ writedata[23] writedata[24] writedata[25] writedata[26] writedata[27]
+ writedata[28] writedata[29] writedata[2] writedata[30] writedata[31]
+ writedata[3] writedata[4] writedata[5] writedata[6] writedata[7]
+ writedata[8] writedata[9]
X_05201_ net22 _01027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_16
X_05202_ _01027_ _01028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05203_ net23 _01029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05204_ _01028_ _01029_ _01030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05205_ net24 _01031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05206_ net10 net1 _01032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05207_ instr[2] _01033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05208_ _01033_ _01034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05209_ net21 _01034_ _01035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_05210_ _01031_ net230 _01035_ _01036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_05211_ _01030_ _01036_ net94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05212_ net13 _01037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05213_ instr[20] _01038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05214_ instr[21] _01039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05215_ dp.rf.rf\[24\]\[0\] dp.rf.rf\[25\]\[0\] dp.rf.rf\[26\]\[0\]
+ dp.rf.rf\[27\]\[0\] _01038_ _01039_ _01040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05216_ dp.rf.rf\[16\]\[0\] dp.rf.rf\[17\]\[0\] dp.rf.rf\[18\]\[0\]
+ dp.rf.rf\[19\]\[0\] _01038_ _01039_ _01041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05217_ net12 _01042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_05218_ _01040_ _01041_ _01042_ _01043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05219_ dp.rf.rf\[28\]\[0\] dp.rf.rf\[29\]\[0\] dp.rf.rf\[30\]\[0\]
+ dp.rf.rf\[31\]\[0\] _01038_ _01039_ _01044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05220_ dp.rf.rf\[20\]\[0\] dp.rf.rf\[21\]\[0\] dp.rf.rf\[22\]\[0\]
+ dp.rf.rf\[23\]\[0\] _01038_ _01039_ _01045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05221_ _01044_ _01045_ _01042_ _01046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05222_ net11 _01047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05223_ _01043_ _01046_ net196 _01048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_05224_ instr[20] _01049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
X_05225_ dp.rf.rf\[8\]\[0\] dp.rf.rf\[9\]\[0\] dp.rf.rf\[10\]\[0\]
+ dp.rf.rf\[11\]\[0\] net264 _01039_ _01050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05226_ dp.rf.rf\[0\]\[0\] dp.rf.rf\[1\]\[0\] dp.rf.rf\[2\]\[0\]
+ dp.rf.rf\[3\]\[0\] net264 _01039_ _01051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05227_ _01050_ _01051_ _01042_ _01052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05228_ dp.rf.rf\[12\]\[0\] dp.rf.rf\[13\]\[0\] dp.rf.rf\[14\]\[0\]
+ dp.rf.rf\[15\]\[0\] net264 _01039_ _01053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05229_ dp.rf.rf\[4\]\[0\] dp.rf.rf\[5\]\[0\] dp.rf.rf\[6\]\[0\]
+ dp.rf.rf\[7\]\[0\] net264 _01039_ _01054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05230_ _01053_ _01054_ _01042_ _01055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05231_ _01052_ _01055_ net196 _01056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_05232_ net13 _01057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_05233_ _01057_ _01058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05234_ instr[20] _01059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05235_ _01047_ _01059_ _01039_ net12 _01060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_05236_ _01058_ _01060_ _01061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05237_ _01037_ _01048_ _01056_ _01061_ _01062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_05238_ net270 net128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05239_ net10 net1 _01063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_05240_ net21 _01033_ _01064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_05241_ net24 _01063_ _01064_ _01065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_05242_ _01029_ net19 _01066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05243_ net4 _01067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_05244_ net5 _01068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_05245_ _01067_ _01068_ _01069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_05246_ net5 _01066_ _01070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05247_ _01065_ _01066_ _01069_ _01070_ _01071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_05248_ net5 _01065_ _01071_ net22 _01072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_05249_ net21 net24 _01073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
Xsplit62 _03041_ net221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_05251_ net1 _01033_ net10 _01075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_05252_ _01073_ _01027_ _01075_ _01076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_05253_ _01076_ _01077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_05254_ _01077_ _01078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_05255_ net230 _01035_ _01079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer102 _02427_ net275 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_05257_ _01029_ net24 _01081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05258_ _01028_ _01081_ _01082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05259_ _01079_ _01082_ _01083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_05260_ _01078_ _01083_ _01084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05261_ _01084_ _01072_ net6 _01085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_05262_ _01085_ _01086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_05263_ net24 net22 _01029_ _01087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05264_ net23 net24 _01088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05265_ _01073_ _01088_ _01027_ _01089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05266_ _01033_ _01090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05267_ _01090_ _01091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05268_ _01064_ _01087_ _01089_ _01091_ _01092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_05269_ net232 _01092_ _01093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05270_ net10 net1 net21 _01033_ _01094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_05271_ _01063_ _01064_ _01094_ _01031_ _01095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_05272_ net21 net24 _01096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_05273_ _01032_ net22 _01033_ _01096_ _01097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_05274_ _01049_ _01098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05275_ _01098_ _01099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_05276_ _01030_ _01095_ _01097_ _01099_ _01100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_05277_ net26 _01101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_05278_ instr[21] _01102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05279_ _01102_ _01103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_05280_ _01101_ _01063_ _01064_ _01094_ _01103_ _01104_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_05281_ _01082_ _01104_ _01105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05282_ net25 _01030_ _01036_ _01106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_05283_ net22 _01063_ _01088_ _01107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_05284_ net21 _01033_ _01108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_05285_ _01107_ _01108_ _01109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_05286_ _01100_ _01105_ _01106_ _01109_ _01110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_05287_ _01037_ _01111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05288_ _01061_ _01112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_05289_ _01111_ net212 net197 _01112_ _01092_ _01032_ _01113_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_4
X_05290_ _01093_ _01110_ _01113_ _01114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_05291_ _01114_ _01115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05292_ _01115_ _01116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_05293_ _01086_ _01116_ _04825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_05294_ _04825_ _04829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05295_ net7 _01117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05296_ _01117_ _01118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05297_ _01118_ _01119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05298_ instr[15] _01120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_05299_ _01120_ _01121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05300_ instr[17] _01122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05301_ _01122_ _01123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05302_ _01123_ _01124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05303_ dp.rf.rf\[2\]\[0\] dp.rf.rf\[3\]\[0\] dp.rf.rf\[6\]\[0\]
+ dp.rf.rf\[7\]\[0\] _01121_ _01124_ _01125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05304_ _01119_ _01125_ _01126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05305_ instr[15] _01127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05306_ _01127_ _01128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05307_ _01122_ _01129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05308_ _01128_ _01129_ _01130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_05309_ net8 _01131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_05310_ _01117_ _01130_ _01131_ _01132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05311_ net7 _01133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_05312_ _01133_ _01131_ _01134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05313_ _01127_ _01135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05314_ _01135_ _01136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05315_ _01122_ _01137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05316_ _01137_ _01138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05317_ _01138_ _01139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05318_ dp.rf.rf\[0\]\[0\] dp.rf.rf\[1\]\[0\] dp.rf.rf\[4\]\[0\]
+ dp.rf.rf\[5\]\[0\] _01136_ _01139_ _01140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_05319_ net9 _01141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_05320_ _01141_ net186 _01142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05321_ _01126_ _01132_ _01134_ _01140_ _01142_ _01143_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_05322_ _01137_ _01144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05323_ _01144_ _01145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05324_ _01145_ _01146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05325_ _01120_ _01147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05326_ dp.rf.rf\[14\]\[0\] dp.rf.rf\[15\]\[0\] _01147_ _01148_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05327_ _01148_ _01149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05328_ net180 _01027_ net216 net7 _01150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_05329_ _01150_ _01151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05330_ _01146_ _01149_ _01151_ _01152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05331_ _01073_ _01153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05332_ net10 _01154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_05333_ net1 _01155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_05334_ dp.rf.rf\[10\]\[0\] _01154_ _01155_ _01034_ _01156_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_05335_ _01135_ _01157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05336_ dp.rf.rf\[10\]\[0\] _01158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05337_ _01028_ _01153_ _01156_ _01157_ _01158_ _01159_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_05338_ _01128_ _01160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05339_ dp.rf.rf\[11\]\[0\] _01160_ _01161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05340_ _01122_ _01162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_8
X_05341_ net22 _01096_ _01162_ _01163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_05342_ _01163_ _01164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_05343_ _01137_ _01075_ _01165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05344_ _01165_ _01166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05345_ _01159_ _01161_ _01164_ _01166_ _01167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_05346_ _01137_ _01168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05347_ _01168_ _01169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05348_ dp.rf.rf\[8\]\[0\] dp.rf.rf\[9\]\[0\] dp.rf.rf\[12\]\[0\]
+ dp.rf.rf\[13\]\[0\] _01136_ _01169_ _01170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_05349_ _01133_ _01171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05350_ _01171_ _01172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05351_ _01172_ _01173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05352_ _01075_ _01174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05353_ _01027_ net167 _01174_ net8 _01175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_05354_ _01175_ _01176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05355_ _01152_ _01167_ _01170_ _01173_ _01176_ _01177_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_05356_ net8 _01178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05357_ _01127_ _01179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05358_ dp.rf.rf\[20\]\[0\] dp.rf.rf\[21\]\[0\] dp.rf.rf\[22\]\[0\]
+ dp.rf.rf\[23\]\[0\] _01179_ _01117_ _01180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05359_ dp.rf.rf\[16\]\[0\] dp.rf.rf\[17\]\[0\] dp.rf.rf\[18\]\[0\]
+ dp.rf.rf\[19\]\[0\] _01179_ _01117_ _01181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05360_ _01162_ _01182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05361_ _01180_ _01181_ _01182_ _01183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05362_ dp.rf.rf\[24\]\[0\] _01184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05363_ net180 _01185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05364_ _01127_ _01186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05365_ _01186_ _01117_ _01187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_05366_ _01028_ _01185_ _01174_ _01187_ _01188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_05367_ _01127_ _01189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_05368_ _01189_ _01190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05369_ dp.rf.rf\[25\]\[0\] _01190_ _01118_ _01191_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_05370_ net161 _01192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05371_ _01133_ _01193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05372_ _01127_ _01194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05373_ dp.rf.rf\[26\]\[0\] dp.rf.rf\[27\]\[0\] _01194_ _01195_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05374_ _01162_ _01196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05375_ _01193_ _01195_ _01196_ _01197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05376_ _01184_ _01188_ _01191_ _01192_ _01197_ _01198_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_05377_ _01175_ _01199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05378_ _01137_ _01200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05379_ _01200_ _01201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05380_ _01127_ _01202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05381_ dp.rf.rf\[28\]\[0\] dp.rf.rf\[29\]\[0\] dp.rf.rf\[30\]\[0\]
+ dp.rf.rf\[31\]\[0\] _01202_ _01117_ _01203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05382_ _01201_ _01203_ _01204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05383_ _01199_ _01204_ _01205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_05384_ net9 net161 _01206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05385_ _01206_ _01207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05386_ _01178_ _01183_ _01198_ _01205_ _01207_ _01208_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_05387_ _01143_ _01177_ _01208_ _04824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_05388_ net169 _04828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05389_ _01129_ _01209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05390_ _01209_ _01210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05391_ _01210_ _01211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05392_ _01186_ _01212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05393_ _01117_ _01213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05394_ dp.rf.rf\[28\]\[31\] dp.rf.rf\[29\]\[31\] dp.rf.rf\[30\]\[31\]
+ dp.rf.rf\[31\]\[31\] _01212_ _01213_ _01214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05395_ dp.rf.rf\[24\]\[31\] _01215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05396_ dp.rf.rf\[25\]\[31\] _01216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05397_ _01216_ _01160_ _01171_ _01217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_05398_ _01133_ _01218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05399_ dp.rf.rf\[26\]\[31\] dp.rf.rf\[27\]\[31\] _01128_
+ _01219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05400_ _01218_ _01219_ _01196_ _01220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05401_ _01215_ _01188_ _01217_ _01192_ _01220_ _01221_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_05402_ _01211_ _01214_ _01221_ _01176_ _01222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_05403_ _01027_ net251 net218 _01137_ _01223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_05404_ _01223_ _01224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05405_ _01120_ _01225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05406_ dp.rf.rf\[20\]\[31\] dp.rf.rf\[21\]\[31\] dp.rf.rf\[22\]\[31\]
+ dp.rf.rf\[23\]\[31\] _01225_ _01118_ _01226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05407_ _01226_ _01227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05408_ _01131_ _01228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05409_ _01224_ _01227_ _01228_ _01229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05410_ _01162_ _01230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05411_ dp.rf.rf\[16\]\[31\] _01187_ _01231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_05412_ dp.rf.rf\[17\]\[31\] dp.rf.rf\[19\]\[31\] net7 _01232_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05413_ _01190_ _01232_ _01233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_05414_ dp.rf.rf\[18\]\[31\] _01160_ _01171_ _01234_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_05415_ _01230_ _01231_ _01233_ _01234_ _01235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_05416_ _01229_ _01235_ net177 _01236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05417_ _01175_ _01237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05418_ _01127_ _01238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05419_ dp.rf.rf\[10\]\[31\] dp.rf.rf\[11\]\[31\] dp.rf.rf\[14\]\[31\]
+ dp.rf.rf\[15\]\[31\] _01238_ _01209_ _01239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05420_ dp.rf.rf\[8\]\[31\] dp.rf.rf\[9\]\[31\] dp.rf.rf\[12\]\[31\]
+ dp.rf.rf\[13\]\[31\] _01238_ _01209_ _01240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05421_ _01133_ _01241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05422_ _01239_ _01240_ _01241_ _01242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05423_ _01237_ _01242_ _01243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05424_ net9 _01244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05425_ _01097_ _01245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05426_ dp.rf.rf\[2\]\[31\] dp.rf.rf\[3\]\[31\] dp.rf.rf\[6\]\[31\]
+ dp.rf.rf\[7\]\[31\] _01194_ _01138_ _01246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05427_ _01213_ _01246_ _01132_ _01247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05428_ _01122_ _01248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05429_ _01189_ _01248_ _01249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05430_ dp.rf.rf\[1\]\[31\] dp.rf.rf\[5\]\[31\] _01248_ _01250_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05431_ dp.rf.rf\[0\]\[31\] _01251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05432_ _01202_ _01129_ _01252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_05433_ _01117_ net8 _01253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05434_ _01251_ _01252_ _01253_ _01254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05435_ dp.rf.rf\[4\]\[31\] _01249_ _01250_ _01212_ _01254_
+ _01255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_05436_ _01244_ _01245_ _01247_ _01255_ _01256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_05437_ _01222_ _01236_ _01243_ _01256_ _01257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_05438_ _01257_ _01258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05439_ _01258_ _04837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_05440_ net232 _01092_ _01259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_05441_ net262 _01260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_05442_ _01260_ _01261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05443_ instr[21] _01262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05444_ _01262_ _01263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05445_ dp.rf.rf\[24\]\[31\] dp.rf.rf\[25\]\[31\] dp.rf.rf\[26\]\[31\]
+ dp.rf.rf\[27\]\[31\] _01261_ _01263_ _01264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05446_ dp.rf.rf\[16\]\[31\] dp.rf.rf\[17\]\[31\] dp.rf.rf\[18\]\[31\]
+ dp.rf.rf\[19\]\[31\] _01261_ _01263_ _01265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05447_ _01049_ _01266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_05448_ _01266_ _01267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05449_ _01262_ _01268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05450_ dp.rf.rf\[28\]\[31\] dp.rf.rf\[29\]\[31\] dp.rf.rf\[30\]\[31\]
+ dp.rf.rf\[31\]\[31\] _01267_ _01268_ _01269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05451_ dp.rf.rf\[20\]\[31\] dp.rf.rf\[21\]\[31\] dp.rf.rf\[22\]\[31\]
+ dp.rf.rf\[23\]\[31\] _01267_ _01263_ _01270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05452_ _01042_ _01271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_05453_ _01271_ _01272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xsplit89 _01049_ net264 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_05455_ _01264_ _01265_ _01269_ _01270_ _01272_ net194 _01274_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_05456_ _01266_ _01275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05457_ _01262_ _01276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05458_ dp.rf.rf\[8\]\[31\] dp.rf.rf\[9\]\[31\] dp.rf.rf\[10\]\[31\]
+ dp.rf.rf\[11\]\[31\] _01275_ _01276_ _01277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05459_ dp.rf.rf\[0\]\[31\] dp.rf.rf\[1\]\[31\] dp.rf.rf\[2\]\[31\]
+ dp.rf.rf\[3\]\[31\] _01275_ _01268_ _01278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05460_ _01266_ _01279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_05461_ dp.rf.rf\[12\]\[31\] dp.rf.rf\[13\]\[31\] dp.rf.rf\[14\]\[31\]
+ dp.rf.rf\[15\]\[31\] _01279_ _01276_ _01280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05462_ dp.rf.rf\[4\]\[31\] dp.rf.rf\[5\]\[31\] dp.rf.rf\[6\]\[31\]
+ dp.rf.rf\[7\]\[31\] _01275_ _01276_ _01281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05463_ _01271_ _01282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05464_ _01277_ _01278_ _01280_ _01281_ _01282_ net194 _01283_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05465_ _01037_ _01274_ _01283_ _01061_ _01284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_05466_ net20 _01285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05467_ _01285_ net233 _01092_ _01286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_05468_ _01259_ _01284_ _01286_ _01287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05469_ _01086_ _01287_ _04832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_05470_ _04832_ _04836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05471_ net247 _01288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05472_ _01259_ _01289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05473_ _01289_ _01290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05474_ _01030_ _01079_ _01291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05475_ _01030_ _01095_ _01097_ _01292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_05476_ net20 _01291_ _01292_ _01293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_05477_ net10 net1 net21 _01034_ _01294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_05478_ _01082_ _01294_ _01295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05479_ _01295_ _01296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05480_ net20 _01296_ _01297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05481_ _01293_ _01297_ _01298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05482_ _01298_ _01299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05483_ _01245_ _01300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_05484_ _01300_ _01301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05485_ net19 _01301_ _01302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05486_ _01285_ _01292_ _01303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05487_ _01303_ _01304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_05488_ _01299_ _01302_ _01304_ _05198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05489_ _01275_ _01305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05490_ _01276_ _01306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05491_ dp.rf.rf\[24\]\[30\] dp.rf.rf\[25\]\[30\] dp.rf.rf\[26\]\[30\]
+ dp.rf.rf\[27\]\[30\] _01305_ _01306_ _01307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05492_ dp.rf.rf\[16\]\[30\] dp.rf.rf\[17\]\[30\] dp.rf.rf\[18\]\[30\]
+ dp.rf.rf\[19\]\[30\] _01305_ _01306_ _01308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05493_ dp.rf.rf\[28\]\[30\] dp.rf.rf\[29\]\[30\] dp.rf.rf\[30\]\[30\]
+ dp.rf.rf\[31\]\[30\] _01305_ _01306_ _01309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05494_ dp.rf.rf\[20\]\[30\] dp.rf.rf\[21\]\[30\] dp.rf.rf\[22\]\[30\]
+ dp.rf.rf\[23\]\[30\] _01305_ _01306_ _01310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05495_ _01282_ _01311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05496_ net194 _01312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05497_ _01307_ _01308_ _01309_ _01310_ _01311_ _01312_ _01313_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05498_ dp.rf.rf\[8\]\[30\] dp.rf.rf\[9\]\[30\] dp.rf.rf\[10\]\[30\]
+ dp.rf.rf\[11\]\[30\] _01305_ _01306_ _01314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05499_ dp.rf.rf\[0\]\[30\] dp.rf.rf\[1\]\[30\] dp.rf.rf\[2\]\[30\]
+ dp.rf.rf\[3\]\[30\] _01305_ _01306_ _01315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05500_ _01102_ _01316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05501_ _01316_ _01317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05502_ dp.rf.rf\[12\]\[30\] dp.rf.rf\[13\]\[30\] dp.rf.rf\[14\]\[30\]
+ dp.rf.rf\[15\]\[30\] _01305_ _01317_ _01318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05503_ dp.rf.rf\[4\]\[30\] dp.rf.rf\[5\]\[30\] dp.rf.rf\[6\]\[30\]
+ dp.rf.rf\[7\]\[30\] _01305_ _01306_ _01319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05504_ _01314_ _01315_ _01318_ _01319_ _01311_ _01312_ _01320_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05505_ _01111_ _01313_ _01320_ _01112_ _01321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_05506_ _01290_ _01321_ _01322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05507_ _01290_ _05198_ _01322_ _01323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05508_ _01288_ _01323_ _04841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_05509_ _04841_ _04845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05510_ net160 _01324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05511_ net257 _01252_ _01325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05512_ dp.rf.rf\[28\]\[30\] _01326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05513_ _01249_ _01327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05514_ _01189_ _01328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05515_ dp.rf.rf\[25\]\[30\] dp.rf.rf\[29\]\[30\] _01248_
+ _01329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05516_ _01328_ _01329_ _01330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05517_ _01326_ _01327_ _01330_ _01213_ _01331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_05518_ dp.rf.rf\[24\]\[30\] _01325_ _01331_ _01245_ _01332_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_05519_ net7 net186 _01333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05520_ _01333_ _01334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05521_ _01334_ _01335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05522_ dp.rf.rf\[26\]\[30\] dp.rf.rf\[27\]\[30\] dp.rf.rf\[30\]\[30\]
+ dp.rf.rf\[31\]\[30\] _01136_ _01139_ _01336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05523_ _01131_ _01337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05524_ _01335_ _01336_ _01337_ _01338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05525_ _01182_ _01339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05526_ _01194_ _01340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05527_ dp.rf.rf\[22\]\[30\] dp.rf.rf\[23\]\[30\] _01340_
+ _01341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05528_ net180 _01027_ net217 _01120_ _01342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_05529_ dp.rf.rf\[18\]\[30\] net201 _01343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05530_ _01223_ _01344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05531_ _01238_ _01345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05532_ dp.rf.rf\[19\]\[30\] _01345_ _01346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05533_ _01344_ _01346_ _01347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05534_ _01339_ _01341_ _01343_ _01347_ _01334_ _01348_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_05535_ _01174_ net167 _01027_ _01131_ _01349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_05536_ dp.rf.rf\[20\]\[30\] _01350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05537_ dp.rf.rf\[17\]\[30\] dp.rf.rf\[21\]\[30\] _01129_
+ _01351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05538_ _01190_ _01351_ _01352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05539_ _01117_ _01353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05540_ _01350_ _01249_ _01352_ _01353_ _01354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_05541_ _01127_ _01122_ net8 _01355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_05542_ _01324_ _01355_ _01356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05543_ net234 _01354_ _01356_ dp.rf.rf\[16\]\[30\] _01357_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_05544_ _01153_ _01028_ _01174_ net9 _01358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_05545_ _01332_ _01338_ _01348_ _01357_ net208 _01359_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_05546_ _01131_ net161 _01360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05547_ _01360_ _01361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05548_ _01353_ _01362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05549_ _01202_ _01363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_05550_ _01123_ _01364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05551_ dp.rf.rf\[2\]\[30\] dp.rf.rf\[3\]\[30\] dp.rf.rf\[6\]\[30\]
+ dp.rf.rf\[7\]\[30\] _01363_ _01364_ _01365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05552_ _01362_ _01365_ _01366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05553_ _01189_ _01137_ _01367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_05554_ _01367_ _01368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05555_ _01137_ _01369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05556_ dp.rf.rf\[1\]\[30\] dp.rf.rf\[5\]\[30\] _01369_ _01370_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05557_ _01189_ _01371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05558_ _01171_ _01372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05559_ dp.rf.rf\[4\]\[30\] _01368_ _01370_ _01371_ _01372_
+ _01373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_05560_ _01361_ _01366_ _01373_ _01374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_05561_ _01130_ _01253_ net9 net198 _01375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_05562_ _01375_ _01376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05563_ _01252_ _01377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05564_ net168 _01377_ dp.rf.rf\[8\]\[30\] _01378_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05565_ dp.rf.rf\[9\]\[30\] dp.rf.rf\[13\]\[30\] _01168_
+ _01379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05566_ dp.rf.rf\[12\]\[30\] _01368_ _01379_ _01371_ _01172_
+ _01380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_05567_ _01123_ _01381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05568_ dp.rf.rf\[10\]\[30\] dp.rf.rf\[11\]\[30\] dp.rf.rf\[14\]\[30\]
+ dp.rf.rf\[15\]\[30\] _01225_ _01381_ _01382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05569_ _01119_ _01382_ _01383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05570_ net8 net162 _01384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05571_ _01384_ _01385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05572_ _01378_ _01380_ _01383_ _01385_ _01386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_05573_ _01374_ _01376_ _01386_ _01387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_05574_ _01359_ _01387_ _01388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_05575_ _01388_ _04844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_05576_ net18 _01301_ _01389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05577_ _01299_ _01389_ _01304_ _05194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05578_ _01038_ _01390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05579_ _01102_ _01391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05580_ dp.rf.rf\[24\]\[29\] dp.rf.rf\[25\]\[29\] dp.rf.rf\[26\]\[29\]
+ dp.rf.rf\[27\]\[29\] _01390_ _01391_ _01392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05581_ dp.rf.rf\[16\]\[29\] dp.rf.rf\[17\]\[29\] dp.rf.rf\[18\]\[29\]
+ dp.rf.rf\[19\]\[29\] _01390_ _01391_ _01393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05582_ _01271_ _01394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05583_ _01392_ _01393_ _01394_ _01395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05584_ dp.rf.rf\[28\]\[29\] dp.rf.rf\[29\]\[29\] dp.rf.rf\[30\]\[29\]
+ dp.rf.rf\[31\]\[29\] _01390_ _01391_ _01396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05585_ dp.rf.rf\[20\]\[29\] dp.rf.rf\[21\]\[29\] dp.rf.rf\[22\]\[29\]
+ dp.rf.rf\[23\]\[29\] _01390_ _01391_ _01397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05586_ _01042_ _01398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05587_ _01396_ _01397_ _01398_ _01399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05588_ net194 _01400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05589_ _01395_ _01399_ _01400_ _01401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05590_ _01038_ _01402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05591_ _01102_ _01403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05592_ dp.rf.rf\[8\]\[29\] dp.rf.rf\[9\]\[29\] dp.rf.rf\[10\]\[29\]
+ dp.rf.rf\[11\]\[29\] _01402_ _01403_ _01404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05593_ dp.rf.rf\[0\]\[29\] dp.rf.rf\[1\]\[29\] dp.rf.rf\[2\]\[29\]
+ dp.rf.rf\[3\]\[29\] _01402_ _01403_ _01405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05594_ _01404_ _01405_ _01398_ _01406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05595_ dp.rf.rf\[12\]\[29\] dp.rf.rf\[13\]\[29\] dp.rf.rf\[14\]\[29\]
+ dp.rf.rf\[15\]\[29\] _01402_ _01403_ _01407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05596_ _01039_ _01408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05597_ dp.rf.rf\[4\]\[29\] dp.rf.rf\[5\]\[29\] dp.rf.rf\[6\]\[29\]
+ dp.rf.rf\[7\]\[29\] _01402_ _01408_ _01409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05598_ _01407_ _01409_ _01398_ _01410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05599_ _01406_ _01410_ _01400_ _01411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05600_ _01111_ _01401_ _01411_ _01112_ _01412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_05601_ _01290_ _01412_ _01413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05602_ _01290_ _05194_ _01413_ _01414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05603_ _01288_ _01414_ _04849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_05604_ _04849_ _04853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05605_ _01228_ _01415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05606_ _01118_ _01416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05607_ dp.rf.rf\[10\]\[29\] _01416_ _01377_ dp.rf.rf\[8\]\[29\]
+ _01417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_05608_ _01415_ _01244_ _01245_ _01417_ _01418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_05609_ dp.rf.rf\[10\]\[29\] dp.rf.rf\[11\]\[29\] dp.rf.rf\[14\]\[29\]
+ dp.rf.rf\[15\]\[29\] _01136_ _01169_ _01419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05610_ _01419_ _01420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05611_ dp.rf.rf\[9\]\[29\] dp.rf.rf\[13\]\[29\] _01381_
+ _01421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05612_ _01328_ _01422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05613_ dp.rf.rf\[12\]\[29\] _01368_ _01421_ _01422_ _01423_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_05614_ _01420_ _01423_ _01173_ _01424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05615_ dp.rf.rf\[25\]\[29\] dp.rf.rf\[29\]\[29\] _01381_
+ _01425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05616_ _01422_ _01425_ _01426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05617_ _01127_ _01427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05618_ _01427_ _01428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05619_ _01428_ _01429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05620_ _01171_ _01430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05621_ dp.rf.rf\[28\]\[29\] _01429_ _01230_ _01430_ _01431_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_05622_ _01123_ _01432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05623_ dp.rf.rf\[26\]\[29\] dp.rf.rf\[27\]\[29\] dp.rf.rf\[30\]\[29\]
+ dp.rf.rf\[31\]\[29\] _01121_ _01432_ _01433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05624_ _01416_ _01433_ _01434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05625_ _01324_ _01435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05626_ _01426_ _01431_ _01434_ _01435_ _01436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_05627_ dp.rf.rf\[24\]\[29\] _01437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05628_ _01028_ _01438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05629_ dp.rf.rf\[26\]\[29\] _01118_ _01439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05630_ _01438_ _01185_ _01174_ _01377_ _01439_ _01440_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_05631_ _01437_ _01440_ _01337_ _01441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05632_ _01190_ _01442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05633_ _01248_ _01443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05634_ dp.rf.rf\[17\]\[29\] dp.rf.rf\[21\]\[29\] _01443_
+ _01444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05635_ _01442_ _01444_ _01445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05636_ dp.rf.rf\[20\]\[29\] _01429_ _01230_ _01430_ _01446_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_05637_ dp.rf.rf\[18\]\[29\] dp.rf.rf\[19\]\[29\] dp.rf.rf\[22\]\[29\]
+ dp.rf.rf\[23\]\[29\] _01225_ _01381_ _01447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05638_ _01416_ _01447_ _01448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05639_ _01445_ _01446_ _01448_ _01435_ _01449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_05640_ dp.rf.rf\[16\]\[29\] _01450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05641_ dp.rf.rf\[18\]\[29\] _01118_ _01451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05642_ _01438_ _01185_ _01174_ _01252_ _01451_ _01452_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_05643_ _01450_ _01452_ _01178_ _01453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05644_ _01436_ _01441_ _01449_ _01453_ _01454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_05645_ net207 _01455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05646_ _01353_ _01456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05647_ _01137_ _01457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05648_ _01457_ _01458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05649_ dp.rf.rf\[2\]\[29\] dp.rf.rf\[3\]\[29\] dp.rf.rf\[6\]\[29\]
+ dp.rf.rf\[7\]\[29\] _01345_ _01458_ _01459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05650_ _01456_ _01459_ _01460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05651_ dp.rf.rf\[4\]\[29\] _01461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05652_ dp.rf.rf\[1\]\[29\] dp.rf.rf\[5\]\[29\] _01381_ _01462_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05653_ _01422_ _01462_ _01463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05654_ _01461_ _01327_ _01463_ _01456_ _01464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_05655_ dp.rf.rf\[2\]\[29\] _01362_ dp.rf.rf\[0\]\[29\] _01465_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05656_ _01119_ _01377_ _01141_ _01466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05657_ _01130_ _01465_ _01466_ net234 _01467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_05658_ _01460_ _01464_ _01467_ _01468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05659_ _01418_ _01424_ _01454_ _01455_ _01468_ _01469_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_05660_ _01469_ _04848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_05661_ _04848_ _04852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05662_ net17 _01301_ _01470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05663_ _01299_ _01470_ _01304_ _05190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05664_ _01059_ _01471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05665_ dp.rf.rf\[24\]\[28\] dp.rf.rf\[25\]\[28\] dp.rf.rf\[26\]\[28\]
+ dp.rf.rf\[27\]\[28\] _01471_ _01316_ _01472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05666_ dp.rf.rf\[16\]\[28\] dp.rf.rf\[17\]\[28\] dp.rf.rf\[18\]\[28\]
+ dp.rf.rf\[19\]\[28\] _01471_ _01316_ _01473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05667_ _01472_ _01473_ _01282_ _01474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05668_ dp.rf.rf\[28\]\[28\] dp.rf.rf\[29\]\[28\] dp.rf.rf\[30\]\[28\]
+ dp.rf.rf\[31\]\[28\] _01471_ _01316_ _01475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05669_ dp.rf.rf\[20\]\[28\] dp.rf.rf\[21\]\[28\] dp.rf.rf\[22\]\[28\]
+ dp.rf.rf\[23\]\[28\] _01471_ _01316_ _01476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05670_ _01475_ _01476_ _01394_ _01477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05671_ net194 _01478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05672_ _01474_ _01477_ _01478_ _01479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05673_ dp.rf.rf\[8\]\[28\] dp.rf.rf\[9\]\[28\] dp.rf.rf\[10\]\[28\]
+ dp.rf.rf\[11\]\[28\] _01471_ _01316_ _01480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05674_ dp.rf.rf\[0\]\[28\] dp.rf.rf\[1\]\[28\] dp.rf.rf\[2\]\[28\]
+ dp.rf.rf\[3\]\[28\] _01471_ _01316_ _01481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05675_ _01480_ _01481_ _01394_ _01482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05676_ dp.rf.rf\[12\]\[28\] dp.rf.rf\[13\]\[28\] dp.rf.rf\[14\]\[28\]
+ dp.rf.rf\[15\]\[28\] _01471_ _01316_ _01483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05677_ _01059_ _01484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_05678_ _01102_ _01485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05679_ dp.rf.rf\[4\]\[28\] dp.rf.rf\[5\]\[28\] dp.rf.rf\[6\]\[28\]
+ dp.rf.rf\[7\]\[28\] _01484_ _01485_ _01486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05680_ _01483_ _01486_ _01394_ _01487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05681_ _01482_ _01487_ _01478_ _01488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05682_ _01111_ _01479_ _01488_ _01112_ _01489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_05683_ _01290_ _01489_ _01490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05684_ _01290_ _05190_ _01490_ _01491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05685_ _01288_ _01491_ _04857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_05686_ _04857_ _04861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05687_ dp.rf.rf\[10\]\[28\] _01362_ _01377_ dp.rf.rf\[8\]\[28\]
+ _01492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_05688_ _01415_ _01244_ _01245_ _01492_ _01493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_05689_ dp.rf.rf\[10\]\[28\] dp.rf.rf\[11\]\[28\] dp.rf.rf\[14\]\[28\]
+ dp.rf.rf\[15\]\[28\] _01345_ _01458_ _01494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05690_ _01494_ _01495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05691_ _01367_ _01496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05692_ _01496_ _01497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05693_ dp.rf.rf\[9\]\[28\] dp.rf.rf\[13\]\[28\] _01364_
+ _01498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05694_ dp.rf.rf\[12\]\[28\] _01497_ _01498_ _01422_ _01499_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_05695_ _01372_ _01500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05696_ _01495_ _01499_ _01500_ _01501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05697_ dp.rf.rf\[25\]\[28\] dp.rf.rf\[29\]\[28\] _01364_
+ _01502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05698_ _01422_ _01502_ _01503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05699_ _01212_ _01504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05700_ _01196_ _01505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05701_ _01218_ _01506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05702_ dp.rf.rf\[28\]\[28\] _01504_ _01505_ _01506_ _01507_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_05703_ _01128_ _01508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_05704_ dp.rf.rf\[26\]\[28\] dp.rf.rf\[27\]\[28\] dp.rf.rf\[30\]\[28\]
+ dp.rf.rf\[31\]\[28\] _01508_ _01145_ _01509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05705_ _01362_ _01509_ _01510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05706_ _01192_ _01511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05707_ _01503_ _01507_ _01510_ _01511_ _01512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_05708_ dp.rf.rf\[24\]\[28\] _01513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05709_ dp.rf.rf\[26\]\[28\] _01353_ _01514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05710_ _01438_ _01185_ _01174_ _01377_ _01514_ _01515_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_05711_ _01513_ _01515_ _01337_ _01516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05712_ dp.rf.rf\[17\]\[28\] dp.rf.rf\[21\]\[28\] _01432_
+ _01517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05713_ _01422_ _01517_ _01518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05714_ dp.rf.rf\[20\]\[28\] _01504_ _01505_ _01506_ _01519_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_05715_ _01128_ _01520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05716_ dp.rf.rf\[18\]\[28\] dp.rf.rf\[19\]\[28\] dp.rf.rf\[22\]\[28\]
+ dp.rf.rf\[23\]\[28\] _01520_ _01201_ _01521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05717_ _01362_ _01521_ _01522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05718_ _01518_ _01519_ _01522_ _01511_ _01523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_05719_ dp.rf.rf\[16\]\[28\] _01524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05720_ dp.rf.rf\[18\]\[28\] _01353_ _01525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05721_ _01438_ _01185_ _01174_ _01377_ _01525_ _01526_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_05722_ _01524_ _01526_ _01178_ _01527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05723_ _01512_ _01516_ _01523_ _01527_ _01528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_05724_ _01117_ _01529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05725_ _01529_ _01530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05726_ _01120_ _01531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05727_ _01531_ _01532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05728_ _01209_ _01533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05729_ dp.rf.rf\[2\]\[28\] dp.rf.rf\[3\]\[28\] dp.rf.rf\[6\]\[28\]
+ dp.rf.rf\[7\]\[28\] _01532_ _01533_ _01534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05730_ _01530_ _01534_ _01535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05731_ dp.rf.rf\[4\]\[28\] _01536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05732_ dp.rf.rf\[1\]\[28\] dp.rf.rf\[5\]\[28\] _01124_ _01537_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05733_ _01422_ _01537_ _01538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05734_ _01536_ _01327_ _01538_ _01456_ _01539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_05735_ dp.rf.rf\[2\]\[28\] _01362_ dp.rf.rf\[0\]\[28\] _01540_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_05736_ net227 _01541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_05737_ _01130_ _01540_ _01466_ _01541_ _01542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_05738_ _01535_ _01539_ _01542_ _01543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05739_ _01493_ _01501_ _01528_ _01455_ _01543_ _01544_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_05740_ _01544_ _04856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_05741_ _04856_ _04860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05742_ net16 _01301_ _01545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05743_ _01299_ _01545_ _01304_ _05186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05744_ _01289_ _01546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05745_ _01049_ _01547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
X_05746_ _01547_ _01548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
X_05747_ instr[21] _01549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05748_ _01549_ _01550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05749_ dp.rf.rf\[24\]\[27\] dp.rf.rf\[25\]\[27\] dp.rf.rf\[26\]\[27\]
+ dp.rf.rf\[27\]\[27\] net249 _01550_ _01551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05750_ dp.rf.rf\[16\]\[27\] dp.rf.rf\[17\]\[27\] dp.rf.rf\[18\]\[27\]
+ dp.rf.rf\[19\]\[27\] net249 _01550_ _01552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05751_ _01547_ _01553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
X_05752_ instr[21] _01554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05753_ _01554_ _01555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05754_ dp.rf.rf\[28\]\[27\] dp.rf.rf\[29\]\[27\] dp.rf.rf\[30\]\[27\]
+ dp.rf.rf\[31\]\[27\] net256 _01555_ _01556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05755_ dp.rf.rf\[20\]\[27\] dp.rf.rf\[21\]\[27\] dp.rf.rf\[22\]\[27\]
+ dp.rf.rf\[23\]\[27\] net249 _01550_ _01557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05756_ _01551_ _01552_ _01556_ _01557_ _01272_ _01400_ _01558_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05757_ dp.rf.rf\[8\]\[27\] dp.rf.rf\[9\]\[27\] dp.rf.rf\[10\]\[27\]
+ dp.rf.rf\[11\]\[27\] net256 _01555_ _01559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05758_ dp.rf.rf\[0\]\[27\] dp.rf.rf\[1\]\[27\] dp.rf.rf\[2\]\[27\]
+ dp.rf.rf\[3\]\[27\] net256 _01555_ _01560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05759_ _01554_ _01561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05760_ dp.rf.rf\[12\]\[27\] dp.rf.rf\[13\]\[27\] dp.rf.rf\[14\]\[27\]
+ dp.rf.rf\[15\]\[27\] _01261_ _01561_ _01562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05761_ dp.rf.rf\[4\]\[27\] dp.rf.rf\[5\]\[27\] dp.rf.rf\[6\]\[27\]
+ dp.rf.rf\[7\]\[27\] net256 _01555_ _01563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05762_ _01559_ _01560_ _01562_ _01563_ _01272_ _01400_ _01564_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05763_ _01037_ _01558_ _01564_ _01112_ _01565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_05764_ _01546_ _01565_ _01566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05765_ _01290_ _05186_ _01566_ _01567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_05766_ _01288_ _01567_ _04865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_05767_ _04865_ _04869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05768_ _01230_ _01568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05769_ _01363_ _01569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05770_ dp.rf.rf\[14\]\[27\] dp.rf.rf\[15\]\[27\] _01569_
+ _01570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05771_ net202 _01571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05772_ dp.rf.rf\[10\]\[27\] _01571_ _01572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05773_ dp.rf.rf\[11\]\[27\] _01429_ _01573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05774_ _01224_ _01573_ _01574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05775_ _01568_ _01570_ _01572_ _01574_ _01335_ _01575_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_05776_ _01430_ _01576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05777_ _01121_ _01577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05778_ _01381_ _01578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05779_ dp.rf.rf\[8\]\[27\] dp.rf.rf\[9\]\[27\] dp.rf.rf\[12\]\[27\]
+ dp.rf.rf\[13\]\[27\] _01577_ _01578_ _01579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05780_ _01199_ _01580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05781_ _01576_ _01579_ _01580_ _01581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05782_ _01202_ _01582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05783_ dp.rf.rf\[2\]\[27\] dp.rf.rf\[3\]\[27\] dp.rf.rf\[6\]\[27\]
+ dp.rf.rf\[7\]\[27\] _01582_ _01124_ _01583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05784_ _01583_ _01584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05785_ dp.rf.rf\[1\]\[27\] dp.rf.rf\[5\]\[27\] _01369_ _01585_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05786_ dp.rf.rf\[4\]\[27\] _01368_ _01585_ _01442_ _01586_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_05787_ _01584_ _01586_ _01506_ _01587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05788_ _01252_ _01134_ _01142_ _01588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_05789_ _01588_ _01589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05790_ _01575_ _01581_ _01587_ _01361_ _01589_ _01590_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_05791_ dp.rf.rf\[22\]\[27\] dp.rf.rf\[23\]\[27\] _01569_
+ _01591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05792_ dp.rf.rf\[18\]\[27\] dp.rf.rf\[19\]\[27\] _01577_
+ _01592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05793_ _01139_ _01324_ _01593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05794_ _01568_ _01591_ _01592_ _01593_ _01530_ _01594_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_05795_ dp.rf.rf\[20\]\[27\] _01595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05796_ dp.rf.rf\[17\]\[27\] dp.rf.rf\[21\]\[27\] _01138_
+ _01596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05797_ _01371_ _01596_ _01597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05798_ _01595_ _01327_ _01597_ _01416_ _01598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_05799_ dp.rf.rf\[16\]\[27\] _01356_ _01598_ _01541_ _01599_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_05800_ _01179_ _01600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05801_ dp.rf.rf\[26\]\[27\] dp.rf.rf\[27\]\[27\] dp.rf.rf\[30\]\[27\]
+ dp.rf.rf\[31\]\[27\] _01600_ _01210_ _01601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05802_ dp.rf.rf\[24\]\[27\] dp.rf.rf\[25\]\[27\] dp.rf.rf\[28\]\[27\]
+ dp.rf.rf\[29\]\[27\] _01600_ _01210_ _01602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05803_ _01335_ _01601_ _01602_ _01500_ _01603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_05804_ _01594_ _01599_ _01603_ _01385_ _01455_ _01604_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_05805_ _01590_ _01604_ _04864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_05806_ _04864_ _04868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05807_ _01093_ _01605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05808_ net15 _01301_ _01606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05809_ _01299_ _01606_ _01304_ _05182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05810_ _01037_ _01060_ _01607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_05811_ _01607_ _01608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_05812_ _01098_ _01609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05813_ dp.rf.rf\[24\]\[26\] dp.rf.rf\[25\]\[26\] dp.rf.rf\[26\]\[26\]
+ dp.rf.rf\[27\]\[26\] _01609_ _01561_ _01610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05814_ dp.rf.rf\[16\]\[26\] dp.rf.rf\[17\]\[26\] dp.rf.rf\[18\]\[26\]
+ dp.rf.rf\[19\]\[26\] _01553_ _01555_ _01611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05815_ dp.rf.rf\[28\]\[26\] dp.rf.rf\[29\]\[26\] dp.rf.rf\[30\]\[26\]
+ dp.rf.rf\[31\]\[26\] _01261_ _01561_ _01612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05816_ dp.rf.rf\[20\]\[26\] dp.rf.rf\[21\]\[26\] dp.rf.rf\[22\]\[26\]
+ dp.rf.rf\[23\]\[26\] _01609_ _01561_ _01613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05817_ _01610_ _01611_ _01612_ _01613_ _01272_ _01400_ _01614_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05818_ dp.rf.rf\[8\]\[26\] dp.rf.rf\[9\]\[26\] dp.rf.rf\[10\]\[26\]
+ dp.rf.rf\[11\]\[26\] _01609_ _01561_ _01615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05819_ dp.rf.rf\[0\]\[26\] dp.rf.rf\[1\]\[26\] dp.rf.rf\[2\]\[26\]
+ dp.rf.rf\[3\]\[26\] _01609_ _01561_ _01616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05820_ dp.rf.rf\[12\]\[26\] dp.rf.rf\[13\]\[26\] dp.rf.rf\[14\]\[26\]
+ dp.rf.rf\[15\]\[26\] _01261_ _01561_ _01617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05821_ dp.rf.rf\[4\]\[26\] dp.rf.rf\[5\]\[26\] dp.rf.rf\[6\]\[26\]
+ dp.rf.rf\[7\]\[26\] _01609_ _01561_ _01618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05822_ _01615_ _01616_ _01617_ _01618_ _01272_ _01400_ _01619_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05823_ _01614_ _01619_ _01058_ _01620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05824_ net192 _01620_ _01621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_05825_ _01621_ _01622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05826_ _01289_ _01622_ _01623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05827_ _01605_ _05182_ _01623_ _01624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05828_ _01288_ _01624_ _04873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_05829_ _04873_ _04877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05830_ dp.rf.rf\[14\]\[26\] dp.rf.rf\[15\]\[26\] _01577_
+ _01625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05831_ net202 _01626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05832_ dp.rf.rf\[10\]\[26\] _01626_ _01627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05833_ dp.rf.rf\[11\]\[26\] _01569_ _01628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05834_ _01224_ _01628_ _01629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05835_ _01568_ _01625_ _01627_ _01629_ _01335_ _01630_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_05836_ dp.rf.rf\[8\]\[26\] dp.rf.rf\[9\]\[26\] dp.rf.rf\[12\]\[26\]
+ dp.rf.rf\[13\]\[26\] _01532_ _01533_ _01631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05837_ _01576_ _01631_ _01237_ _01632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05838_ dp.rf.rf\[2\]\[26\] dp.rf.rf\[3\]\[26\] dp.rf.rf\[6\]\[26\]
+ dp.rf.rf\[7\]\[26\] _01531_ _01443_ _01633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05839_ _01119_ _01633_ _01634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05840_ dp.rf.rf\[1\]\[26\] dp.rf.rf\[5\]\[26\] _01144_ _01635_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05841_ _01189_ _01636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05842_ dp.rf.rf\[4\]\[26\] _01496_ _01635_ _01636_ _01241_
+ _01637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_05843_ _01337_ _01435_ _01634_ _01637_ _01638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_05844_ _01630_ _01632_ _01638_ _01589_ _01639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_05845_ dp.rf.rf\[26\]\[26\] dp.rf.rf\[27\]\[26\] dp.rf.rf\[30\]\[26\]
+ dp.rf.rf\[31\]\[26\] _01212_ _01458_ _01640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05846_ dp.rf.rf\[24\]\[26\] dp.rf.rf\[25\]\[26\] dp.rf.rf\[28\]\[26\]
+ dp.rf.rf\[29\]\[26\] _01212_ _01458_ _01641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05847_ _01335_ _01640_ _01641_ _01500_ _01642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_05848_ dp.rf.rf\[22\]\[26\] dp.rf.rf\[23\]\[26\] _01345_
+ _01643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05849_ dp.rf.rf\[18\]\[26\] _01626_ _01644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05850_ _01147_ _01645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05851_ dp.rf.rf\[19\]\[26\] _01645_ _01646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05852_ _01224_ _01646_ _01647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05853_ _01339_ _01643_ _01644_ _01647_ _01335_ _01648_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_05854_ dp.rf.rf\[20\]\[26\] _01649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05855_ dp.rf.rf\[17\]\[26\] dp.rf.rf\[21\]\[26\] _01248_
+ _01650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05856_ _01328_ _01650_ _01651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05857_ _01649_ _01327_ _01651_ _01213_ _01652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_05858_ dp.rf.rf\[16\]\[26\] _01356_ _01652_ net235 _01653_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_05859_ _01385_ _01642_ _01648_ _01653_ _01455_ _01654_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_05860_ _01639_ _01654_ _04872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_05861_ _04872_ _04876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_05862_ net14 _01301_ _01655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05863_ _01299_ _01655_ _01304_ _05178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05864_ _01058_ _01656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_05865_ _01049_ _01657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
X_05866_ _01657_ _01658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05867_ _01408_ _01659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05868_ dp.rf.rf\[28\]\[25\] dp.rf.rf\[29\]\[25\] dp.rf.rf\[30\]\[25\]
+ dp.rf.rf\[31\]\[25\] _01658_ _01659_ _01660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05869_ _01038_ _01661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05870_ _01661_ _01662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05871_ dp.rf.rf\[20\]\[25\] dp.rf.rf\[21\]\[25\] dp.rf.rf\[22\]\[25\]
+ dp.rf.rf\[23\]\[25\] _01662_ _01659_ _01663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05872_ dp.rf.rf\[24\]\[25\] dp.rf.rf\[25\]\[25\] dp.rf.rf\[26\]\[25\]
+ dp.rf.rf\[27\]\[25\] _01658_ _01659_ _01664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05873_ dp.rf.rf\[16\]\[25\] dp.rf.rf\[17\]\[25\] dp.rf.rf\[18\]\[25\]
+ dp.rf.rf\[19\]\[25\] _01658_ _01659_ _01665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05874_ _01398_ _01666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05875_ net11 _01667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_05876_ _01667_ _01668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05877_ _01668_ _01669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05878_ _01660_ _01663_ _01664_ _01665_ _01666_ _01669_ _01670_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_05879_ net12 _01671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05880_ _01057_ _01671_ _01672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_05881_ dp.rf.rf\[12\]\[25\] dp.rf.rf\[13\]\[25\] dp.rf.rf\[14\]\[25\]
+ dp.rf.rf\[15\]\[25\] _01657_ _01408_ _01673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05882_ dp.rf.rf\[8\]\[25\] dp.rf.rf\[9\]\[25\] dp.rf.rf\[10\]\[25\]
+ dp.rf.rf\[11\]\[25\] _01657_ _01408_ _01674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05883_ _01673_ _01674_ _01668_ _01675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05884_ _01672_ _01675_ _01676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_05885_ _01398_ _01057_ _01677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_05886_ dp.rf.rf\[4\]\[25\] dp.rf.rf\[5\]\[25\] dp.rf.rf\[6\]\[25\]
+ dp.rf.rf\[7\]\[25\] net226 _01549_ _01678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05887_ dp.rf.rf\[0\]\[25\] dp.rf.rf\[1\]\[25\] dp.rf.rf\[2\]\[25\]
+ dp.rf.rf\[3\]\[25\] net226 _01549_ _01679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05888_ _01678_ _01679_ _01668_ _01680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05889_ net224 _01680_ _01681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_05890_ net192 _01676_ _01681_ _01682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_05891_ _01656_ _01670_ _01682_ _01683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_05892_ _01605_ _01683_ _01684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05893_ _01605_ _05178_ _01684_ _01685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05894_ _01288_ _01685_ _04881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_05895_ _04881_ _04885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05896_ dp.rf.rf\[10\]\[25\] dp.rf.rf\[11\]\[25\] dp.rf.rf\[14\]\[25\]
+ dp.rf.rf\[15\]\[25\] _01582_ _01124_ _01686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05897_ dp.rf.rf\[8\]\[25\] dp.rf.rf\[9\]\[25\] dp.rf.rf\[12\]\[25\]
+ dp.rf.rf\[13\]\[25\] _01582_ _01124_ _01687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05898_ _01686_ _01687_ _01372_ _01688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05899_ _01580_ _01688_ _01689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_05900_ dp.rf.rf\[2\]\[25\] dp.rf.rf\[3\]\[25\] dp.rf.rf\[6\]\[25\]
+ dp.rf.rf\[7\]\[25\] _01532_ _01533_ _01690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05901_ _01530_ _01690_ _01691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05902_ dp.rf.rf\[1\]\[25\] dp.rf.rf\[5\]\[25\] _01145_ _01692_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05903_ _01636_ _01693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05904_ dp.rf.rf\[4\]\[25\] _01497_ _01692_ _01693_ _01173_
+ _01694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_05905_ _01361_ _01691_ _01694_ _01695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_05906_ _01376_ _01689_ _01695_ _01696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_05907_ _01141_ net273 _01697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_05908_ dp.rf.rf\[18\]\[25\] dp.rf.rf\[19\]\[25\] dp.rf.rf\[22\]\[25\]
+ dp.rf.rf\[23\]\[25\] _01645_ _01533_ _01698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05909_ _01698_ _01699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05910_ dp.rf.rf\[16\]\[25\] dp.rf.rf\[17\]\[25\] dp.rf.rf\[20\]\[25\]
+ dp.rf.rf\[21\]\[25\] _01157_ _01458_ _01700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05911_ _01500_ _01700_ _01178_ _01701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05912_ _01697_ _01699_ _01701_ _01455_ _01702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_05913_ dp.rf.rf\[30\]\[25\] dp.rf.rf\[31\]\[25\] _01645_
+ _01703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05914_ _01568_ _01703_ _01511_ _01456_ _01704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_05915_ dp.rf.rf\[27\]\[25\] _01577_ _01705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05916_ _01146_ _01435_ _01571_ dp.rf.rf\[26\]\[25\] _01705_
+ _01706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_05917_ dp.rf.rf\[24\]\[25\] dp.rf.rf\[25\]\[25\] dp.rf.rf\[28\]\[25\]
+ dp.rf.rf\[29\]\[25\] _01345_ _01458_ _01707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05918_ _01500_ _01707_ _01708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05919_ _01704_ _01706_ _01708_ _01385_ _01709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_05920_ _01702_ _01709_ _01710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05921_ _01696_ _01710_ _04880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_05922_ _04880_ _04884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05923_ dp.rf.rf\[24\]\[24\] dp.rf.rf\[25\]\[24\] dp.rf.rf\[26\]\[24\]
+ dp.rf.rf\[27\]\[24\] _01484_ _01485_ _01711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05924_ dp.rf.rf\[16\]\[24\] dp.rf.rf\[17\]\[24\] dp.rf.rf\[18\]\[24\]
+ dp.rf.rf\[19\]\[24\] _01484_ _01485_ _01712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05925_ _01711_ _01712_ _01394_ _01713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05926_ _01669_ _01713_ _01714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05927_ dp.rf.rf\[28\]\[24\] dp.rf.rf\[29\]\[24\] dp.rf.rf\[30\]\[24\]
+ dp.rf.rf\[31\]\[24\] _01390_ _01391_ _01715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05928_ dp.rf.rf\[20\]\[24\] dp.rf.rf\[21\]\[24\] dp.rf.rf\[22\]\[24\]
+ dp.rf.rf\[23\]\[24\] _01390_ _01391_ _01716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05929_ _01715_ _01716_ _01394_ _01717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05930_ _01478_ _01717_ _01058_ _01718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05931_ dp.rf.rf\[12\]\[24\] dp.rf.rf\[13\]\[24\] dp.rf.rf\[14\]\[24\]
+ dp.rf.rf\[15\]\[24\] _01661_ _01391_ _01719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05932_ dp.rf.rf\[8\]\[24\] dp.rf.rf\[9\]\[24\] dp.rf.rf\[10\]\[24\]
+ dp.rf.rf\[11\]\[24\] _01661_ _01391_ _01720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05933_ _01719_ _01720_ _01668_ _01721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05934_ dp.rf.rf\[4\]\[24\] dp.rf.rf\[5\]\[24\] dp.rf.rf\[6\]\[24\]
+ dp.rf.rf\[7\]\[24\] _01657_ _01408_ _01722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05935_ dp.rf.rf\[0\]\[24\] dp.rf.rf\[1\]\[24\] dp.rf.rf\[2\]\[24\]
+ dp.rf.rf\[3\]\[24\] _01657_ _01408_ _01723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05936_ _01722_ _01723_ _01668_ _01724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05937_ _01672_ _01721_ _01724_ net225 _01607_ _01725_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_05938_ _01714_ _01718_ _01725_ _01726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_05939_ _01111_ _01301_ _01727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05940_ _01299_ _01727_ _01304_ _05174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05941_ _01605_ _05174_ _01728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05942_ _01290_ _01726_ _01728_ _01729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05943_ _01288_ _01729_ _04889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_05944_ _04889_ _04893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05945_ dp.rf.rf\[18\]\[24\] dp.rf.rf\[19\]\[24\] dp.rf.rf\[22\]\[24\]
+ dp.rf.rf\[23\]\[24\] _01577_ _01578_ _01730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05946_ dp.rf.rf\[17\]\[24\] dp.rf.rf\[21\]\[24\] _01209_
+ _01731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05947_ _01442_ _01731_ _01732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05948_ dp.rf.rf\[20\]\[24\] _01429_ _01230_ _01372_ _01733_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_05949_ _01732_ _01733_ _01337_ _01435_ _01734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_05950_ dp.rf.rf\[16\]\[24\] _01735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05951_ _01027_ net180 _01174_ _01355_ _01736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_05952_ _01736_ _01737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05953_ _01735_ _01737_ _01738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05954_ _01335_ _01730_ _01734_ _01738_ _01739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_05955_ dp.rf.rf\[26\]\[24\] dp.rf.rf\[27\]\[24\] dp.rf.rf\[30\]\[24\]
+ dp.rf.rf\[31\]\[24\] _01520_ _01364_ _01740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05956_ dp.rf.rf\[24\]\[24\] dp.rf.rf\[25\]\[24\] dp.rf.rf\[28\]\[24\]
+ dp.rf.rf\[29\]\[24\] _01363_ _01364_ _01741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05957_ _01740_ _01741_ _01430_ _01742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05958_ _01415_ _01742_ net205 _01743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_05959_ dp.rf.rf\[14\]\[24\] dp.rf.rf\[15\]\[24\] _01508_
+ _01744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05960_ _01744_ _01745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05961_ _01146_ _01745_ _01151_ _01746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05962_ _01154_ _01155_ _01090_ dp.rf.rf\[10\]\[24\] _01747_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_05963_ dp.rf.rf\[10\]\[24\] _01748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05964_ _01028_ _01185_ _01747_ _01748_ _01212_ _01749_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_05965_ dp.rf.rf\[11\]\[24\] _01428_ _01750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05966_ _01164_ _01166_ _01749_ _01750_ _01751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_05967_ dp.rf.rf\[8\]\[24\] dp.rf.rf\[9\]\[24\] dp.rf.rf\[12\]\[24\]
+ dp.rf.rf\[13\]\[24\] _01345_ _01458_ _01752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05968_ _01746_ _01751_ _01752_ _01500_ _01237_ _01753_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_05969_ dp.rf.rf\[2\]\[24\] dp.rf.rf\[3\]\[24\] dp.rf.rf\[6\]\[24\]
+ dp.rf.rf\[7\]\[24\] _01520_ _01201_ _01754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05970_ _01416_ _01754_ _01755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05971_ dp.rf.rf\[4\]\[24\] _01756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05972_ dp.rf.rf\[1\]\[24\] dp.rf.rf\[5\]\[24\] _01168_ _01757_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05973_ _01371_ _01757_ _01758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_05974_ _01756_ _01327_ _01758_ _01416_ _01759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_05975_ _01541_ _01755_ _01759_ _01376_ _01760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_05976_ _01739_ _01743_ _01753_ _01760_ _04888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_05977_ _04888_ _04892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_05978_ _01671_ _01761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05979_ _01761_ _01301_ _01762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_05980_ _01299_ _01762_ _01304_ _05170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_05981_ _01671_ _01763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05982_ dp.rf.rf\[6\]\[23\] dp.rf.rf\[7\]\[23\] dp.rf.rf\[14\]\[23\]
+ dp.rf.rf\[15\]\[23\] _01279_ _01763_ _01764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05983_ dp.rf.rf\[4\]\[23\] dp.rf.rf\[5\]\[23\] dp.rf.rf\[12\]\[23\]
+ dp.rf.rf\[13\]\[23\] _01279_ _01763_ _01765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05984_ _01103_ _01766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05985_ _01764_ _01765_ _01766_ _01767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05986_ dp.rf.rf\[8\]\[23\] dp.rf.rf\[9\]\[23\] dp.rf.rf\[10\]\[23\]
+ dp.rf.rf\[11\]\[23\] net226 _01549_ _01768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05987_ dp.rf.rf\[0\]\[23\] dp.rf.rf\[1\]\[23\] dp.rf.rf\[2\]\[23\]
+ dp.rf.rf\[3\]\[23\] net226 _01549_ _01769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05988_ _01768_ _01769_ _01398_ _01770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05989_ _01607_ _01770_ _01771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_05990_ _01767_ _01771_ _01669_ _01772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05991_ _01471_ _01773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_05992_ _01485_ _01774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_05993_ dp.rf.rf\[28\]\[23\] dp.rf.rf\[29\]\[23\] dp.rf.rf\[30\]\[23\]
+ dp.rf.rf\[31\]\[23\] _01773_ _01774_ _01775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05994_ dp.rf.rf\[20\]\[23\] dp.rf.rf\[21\]\[23\] dp.rf.rf\[22\]\[23\]
+ dp.rf.rf\[23\]\[23\] _01773_ _01774_ _01776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_05995_ _01775_ _01776_ _01311_ _01777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_05996_ net13 net195 _01778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05997_ _01667_ _01779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_05998_ _01037_ _01779_ _01780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_05999_ dp.rf.rf\[18\]\[23\] dp.rf.rf\[19\]\[23\] dp.rf.rf\[26\]\[23\]
+ dp.rf.rf\[27\]\[23\] _01609_ _01763_ _01781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06000_ dp.rf.rf\[16\]\[23\] dp.rf.rf\[17\]\[23\] dp.rf.rf\[24\]\[23\]
+ dp.rf.rf\[25\]\[23\] _01609_ _01763_ _01782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06001_ _01781_ _01782_ _01766_ _01783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06002_ _01780_ _01783_ _01784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06003_ _01656_ _01772_ _01777_ net214 _01784_ _01785_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_06004_ _01546_ _01785_ _01786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06005_ _01290_ _05170_ _01786_ _01787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06006_ _01288_ _01787_ _04897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_06007_ _04897_ _04901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06008_ dp.rf.rf\[25\]\[23\] dp.rf.rf\[29\]\[23\] _01533_
+ _01788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06009_ _01693_ _01788_ _01789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06010_ _01372_ _01244_ _01790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06011_ dp.rf.rf\[24\]\[23\] _01377_ _01497_ dp.rf.rf\[28\]\[23\]
+ _01790_ _01791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06012_ _01580_ _01789_ _01791_ _01792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_06013_ dp.rf.rf\[17\]\[23\] dp.rf.rf\[21\]\[23\] _01533_
+ _01793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06014_ _01693_ _01793_ _01794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06015_ dp.rf.rf\[16\]\[23\] _01377_ _01497_ dp.rf.rf\[20\]\[23\]
+ _01790_ _01795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06016_ _01541_ _01794_ _01795_ _01796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_06017_ dp.rf.rf\[26\]\[23\] dp.rf.rf\[27\]\[23\] dp.rf.rf\[30\]\[23\]
+ dp.rf.rf\[31\]\[23\] _01532_ _01210_ _01797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06018_ dp.rf.rf\[18\]\[23\] dp.rf.rf\[19\]\[23\] dp.rf.rf\[22\]\[23\]
+ dp.rf.rf\[23\]\[23\] _01532_ _01210_ _01798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06019_ _01797_ _01798_ _01337_ _01799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06020_ _01244_ _01335_ _01799_ _01800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_06021_ dp.rf.rf\[1\]\[23\] dp.rf.rf\[5\]\[23\] _01201_ _01801_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06022_ dp.rf.rf\[4\]\[23\] _01497_ _01801_ _01693_ _01173_
+ _01802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06023_ dp.rf.rf\[2\]\[23\] dp.rf.rf\[6\]\[23\] _01369_ _01803_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06024_ _01442_ _01529_ _01803_ _01804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06025_ dp.rf.rf\[3\]\[23\] dp.rf.rf\[7\]\[23\] _01138_ _01805_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06026_ _01569_ _01213_ _01805_ _01806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06027_ _01245_ _01804_ _01806_ _01807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_06028_ dp.rf.rf\[2\]\[23\] _01213_ _01169_ _01645_ _01808_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_06029_ _01808_ _01809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06030_ _01435_ _01809_ dp.rf.rf\[0\]\[23\] _01810_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06031_ _01802_ _01807_ _01810_ _01385_ _01811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_06032_ dp.rf.rf\[10\]\[23\] dp.rf.rf\[11\]\[23\] dp.rf.rf\[14\]\[23\]
+ dp.rf.rf\[15\]\[23\] _01121_ _01432_ _01812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06033_ dp.rf.rf\[8\]\[23\] dp.rf.rf\[9\]\[23\] dp.rf.rf\[12\]\[23\]
+ dp.rf.rf\[13\]\[23\] _01121_ _01432_ _01813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06034_ _01812_ _01813_ _01372_ _01814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06035_ _01385_ _01814_ _01815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06036_ _01811_ _01815_ _01376_ _01816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06037_ _01792_ _01796_ _01800_ _01816_ _01817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_06038_ _01817_ _04896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_06039_ _04896_ _04900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06040_ _01312_ _01301_ _01818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06041_ _01299_ _01818_ _01304_ _05166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06042_ _01550_ _01819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_06043_ _01657_ _01820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_06044_ dp.rf.rf\[16\]\[22\] dp.rf.rf\[17\]\[22\] dp.rf.rf\[24\]\[22\]
+ dp.rf.rf\[25\]\[22\] _01820_ _01761_ _01821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06045_ _01819_ _01821_ _01822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06046_ _01408_ _01671_ _01823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06047_ dp.rf.rf\[26\]\[22\] dp.rf.rf\[27\]\[22\] _01658_
+ _01824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06048_ dp.rf.rf\[18\]\[22\] dp.rf.rf\[19\]\[22\] _01657_
+ _01825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06049_ _01766_ _01763_ _01825_ _01826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_06050_ _01823_ _01824_ _01826_ _01779_ _01827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06051_ _01058_ _01822_ _01827_ _01828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_06052_ dp.rf.rf\[6\]\[22\] dp.rf.rf\[7\]\[22\] dp.rf.rf\[14\]\[22\]
+ dp.rf.rf\[15\]\[22\] _01609_ _01763_ _01829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06053_ dp.rf.rf\[4\]\[22\] dp.rf.rf\[5\]\[22\] dp.rf.rf\[12\]\[22\]
+ dp.rf.rf\[13\]\[22\] _01609_ _01763_ _01830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06054_ _01829_ _01830_ _01766_ _01831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06055_ _01058_ _01312_ _01831_ _01832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_06056_ dp.rf.rf\[28\]\[22\] dp.rf.rf\[29\]\[22\] dp.rf.rf\[30\]\[22\]
+ dp.rf.rf\[31\]\[22\] _01261_ _01263_ _01833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06057_ dp.rf.rf\[20\]\[22\] dp.rf.rf\[21\]\[22\] dp.rf.rf\[22\]\[22\]
+ dp.rf.rf\[23\]\[22\] _01261_ _01263_ _01834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06058_ _01833_ _01834_ _01272_ _01835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06059_ _01669_ _01061_ _01836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06060_ dp.rf.rf\[2\]\[22\] dp.rf.rf\[3\]\[22\] dp.rf.rf\[10\]\[22\]
+ dp.rf.rf\[11\]\[22\] _01275_ _01763_ _01837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06061_ dp.rf.rf\[0\]\[22\] dp.rf.rf\[1\]\[22\] dp.rf.rf\[8\]\[22\]
+ dp.rf.rf\[9\]\[22\] _01279_ _01763_ _01838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06062_ _01837_ _01838_ _01766_ _01839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06063_ net213 _01835_ _01836_ _01839_ _01840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06064_ _01828_ _01832_ _01840_ _01841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_06065_ _01546_ _01841_ _01842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06066_ _01290_ _05166_ _01842_ _01843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06067_ _01288_ _01843_ _04905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_06068_ _04905_ _04909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06069_ dp.rf.rf\[14\]\[22\] dp.rf.rf\[15\]\[22\] _01186_
+ _01844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06070_ _01844_ _01845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06071_ _01578_ _01845_ _01151_ _01846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06072_ _01154_ _01155_ _01034_ dp.rf.rf\[10\]\[22\] _01847_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_06073_ dp.rf.rf\[10\]\[22\] _01848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06074_ _01028_ _01153_ _01847_ _01848_ _01582_ _01849_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_06075_ dp.rf.rf\[11\]\[22\] _01531_ _01850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06076_ _01163_ _01165_ _01849_ _01850_ _01851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_06077_ dp.rf.rf\[8\]\[22\] dp.rf.rf\[9\]\[22\] dp.rf.rf\[12\]\[22\]
+ dp.rf.rf\[13\]\[22\] _01520_ _01364_ _01852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06078_ _01846_ _01851_ _01852_ _01506_ _01199_ _01853_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_06079_ _01360_ _01854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_06080_ dp.rf.rf\[2\]\[22\] dp.rf.rf\[3\]\[22\] dp.rf.rf\[6\]\[22\]
+ dp.rf.rf\[7\]\[22\] _01238_ _01209_ _01855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06081_ _01529_ _01855_ _01856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06082_ dp.rf.rf\[1\]\[22\] dp.rf.rf\[5\]\[22\] _01123_ _01857_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06083_ dp.rf.rf\[4\]\[22\] _01496_ _01857_ _01328_ _01241_
+ _01858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06084_ _01854_ _01856_ _01858_ _01859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06085_ dp.rf.rf\[24\]\[22\] dp.rf.rf\[25\]\[22\] dp.rf.rf\[28\]\[22\]
+ dp.rf.rf\[29\]\[22\] _01600_ _01210_ _01860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06086_ dp.rf.rf\[26\]\[22\] dp.rf.rf\[27\]\[22\] _01147_
+ _01861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06087_ _01861_ _01862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06088_ dp.rf.rf\[30\]\[22\] dp.rf.rf\[31\]\[22\] _01238_
+ _01863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06089_ _01182_ _01863_ _01213_ _01864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06090_ _01224_ _01862_ _01864_ _01865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06091_ _01576_ _01860_ _01865_ _01237_ _01866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_06092_ dp.rf.rf\[18\]\[22\] dp.rf.rf\[19\]\[22\] dp.rf.rf\[22\]\[22\]
+ dp.rf.rf\[23\]\[22\] _01531_ _01443_ _01867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06093_ dp.rf.rf\[16\]\[22\] dp.rf.rf\[17\]\[22\] dp.rf.rf\[20\]\[22\]
+ dp.rf.rf\[21\]\[22\] _01531_ _01443_ _01868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06094_ _01867_ _01868_ _01172_ _01869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06095_ _01178_ _01869_ net205 _01870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06096_ _01589_ _01853_ _01859_ _01866_ _01870_ _01871_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_06097_ _01871_ _04904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_06098_ _04904_ _04908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06099_ _01819_ _01301_ _01872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06100_ _01299_ _01872_ _01304_ _05162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06101_ dp.rf.rf\[28\]\[21\] dp.rf.rf\[29\]\[21\] dp.rf.rf\[30\]\[21\]
+ dp.rf.rf\[31\]\[21\] _01267_ _01263_ _01873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06102_ dp.rf.rf\[20\]\[21\] dp.rf.rf\[21\]\[21\] dp.rf.rf\[22\]\[21\]
+ dp.rf.rf\[23\]\[21\] _01267_ _01263_ _01874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06103_ dp.rf.rf\[24\]\[21\] dp.rf.rf\[25\]\[21\] dp.rf.rf\[26\]\[21\]
+ dp.rf.rf\[27\]\[21\] _01275_ _01268_ _01875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06104_ dp.rf.rf\[16\]\[21\] dp.rf.rf\[17\]\[21\] dp.rf.rf\[18\]\[21\]
+ dp.rf.rf\[19\]\[21\] _01267_ _01263_ _01876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06105_ _01873_ _01874_ _01875_ _01876_ _01282_ _01669_ _01877_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06106_ dp.rf.rf\[4\]\[21\] dp.rf.rf\[5\]\[21\] dp.rf.rf\[6\]\[21\]
+ dp.rf.rf\[7\]\[21\] _01261_ _01561_ _01878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06107_ dp.rf.rf\[0\]\[21\] dp.rf.rf\[1\]\[21\] dp.rf.rf\[2\]\[21\]
+ dp.rf.rf\[3\]\[21\] _01261_ _01263_ _01879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06108_ _01878_ _01879_ _01779_ _01880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06109_ dp.rf.rf\[12\]\[21\] dp.rf.rf\[13\]\[21\] dp.rf.rf\[14\]\[21\]
+ dp.rf.rf\[15\]\[21\] _01059_ _01102_ _01881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06110_ dp.rf.rf\[8\]\[21\] dp.rf.rf\[9\]\[21\] dp.rf.rf\[10\]\[21\]
+ dp.rf.rf\[11\]\[21\] _01059_ _01102_ _01882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06111_ _01881_ _01882_ _01667_ _01883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06112_ _01672_ _01883_ _01884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06113_ _01607_ _01884_ _01885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06114_ _01656_ _01877_ _01880_ net223 _01885_ _01886_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_06115_ _01605_ _01886_ _01887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06116_ _01605_ _05162_ _01887_ _01888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06117_ _01288_ _01888_ _04913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_06118_ _04913_ _04917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06119_ _01193_ _01889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_06120_ dp.rf.rf\[8\]\[21\] dp.rf.rf\[9\]\[21\] dp.rf.rf\[12\]\[21\]
+ dp.rf.rf\[13\]\[21\] _01508_ _01201_ _01890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06121_ dp.rf.rf\[10\]\[21\] dp.rf.rf\[11\]\[21\] _01427_
+ _01891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06122_ _01891_ _01892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06123_ dp.rf.rf\[14\]\[21\] dp.rf.rf\[15\]\[21\] _01202_
+ _01893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06124_ _01196_ _01893_ _01118_ _01894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06125_ _01344_ _01892_ _01894_ _01895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06126_ _01889_ _01890_ _01895_ _01199_ _01896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_06127_ dp.rf.rf\[2\]\[21\] dp.rf.rf\[3\]\[21\] dp.rf.rf\[6\]\[21\]
+ dp.rf.rf\[7\]\[21\] _01135_ _01369_ _01897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06128_ _01213_ _01897_ _01898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06129_ dp.rf.rf\[1\]\[21\] dp.rf.rf\[5\]\[21\] _01248_ _01899_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06130_ dp.rf.rf\[4\]\[21\] _01367_ _01899_ _01190_ _01193_
+ _01900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06131_ _01854_ _01898_ _01900_ _01901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06132_ dp.rf.rf\[18\]\[21\] dp.rf.rf\[19\]\[21\] dp.rf.rf\[22\]\[21\]
+ dp.rf.rf\[23\]\[21\] _01238_ _01457_ _01902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06133_ dp.rf.rf\[16\]\[21\] dp.rf.rf\[17\]\[21\] dp.rf.rf\[20\]\[21\]
+ dp.rf.rf\[21\]\[21\] _01238_ _01457_ _01903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06134_ _01902_ _01903_ _01241_ _01904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06135_ _01178_ _01904_ _01511_ _01905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06136_ dp.rf.rf\[30\]\[21\] dp.rf.rf\[31\]\[21\] _01120_
+ _01906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06137_ _01162_ _01906_ _01907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06138_ _01529_ _01244_ _01192_ _01907_ _01908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_06139_ _01154_ _01155_ _01034_ dp.rf.rf\[26\]\[21\] _01909_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_06140_ dp.rf.rf\[26\]\[21\] _01910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06141_ _01028_ _01153_ _01909_ _01910_ _01428_ _01911_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_06142_ dp.rf.rf\[27\]\[21\] _01520_ _01912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06143_ _01164_ _01166_ _01911_ _01912_ _01913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_06144_ dp.rf.rf\[24\]\[21\] dp.rf.rf\[25\]\[21\] dp.rf.rf\[28\]\[21\]
+ dp.rf.rf\[29\]\[21\] _01120_ _01248_ _01914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06145_ _01171_ net9 _01914_ _01915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06146_ _01175_ _01915_ _01916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06147_ _01908_ _01913_ _01916_ _01244_ _01917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06148_ net191 _01896_ _01901_ _01905_ _01917_ _01918_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_06149_ _01918_ _04912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_06150_ _04912_ _04916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06151_ _01261_ _01919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_06152_ _01293_ _01297_ _01920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06153_ _01919_ _01300_ _01920_ _01921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06154_ _01303_ _01921_ _01922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06155_ dp.rf.rf\[28\]\[20\] dp.rf.rf\[29\]\[20\] dp.rf.rf\[30\]\[20\]
+ dp.rf.rf\[31\]\[20\] _01553_ _01555_ _01923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06156_ dp.rf.rf\[20\]\[20\] dp.rf.rf\[21\]\[20\] dp.rf.rf\[22\]\[20\]
+ dp.rf.rf\[23\]\[20\] _01553_ _01555_ _01924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06157_ dp.rf.rf\[24\]\[20\] dp.rf.rf\[25\]\[20\] dp.rf.rf\[26\]\[20\]
+ dp.rf.rf\[27\]\[20\] _01609_ _01561_ _01925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06158_ dp.rf.rf\[16\]\[20\] dp.rf.rf\[17\]\[20\] dp.rf.rf\[18\]\[20\]
+ dp.rf.rf\[19\]\[20\] _01553_ _01555_ _01926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06159_ _01923_ _01924_ _01925_ _01926_ _01272_ _01669_ _01927_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06160_ net226 _01928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_06161_ _01549_ _01929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_06162_ dp.rf.rf\[4\]\[20\] dp.rf.rf\[5\]\[20\] dp.rf.rf\[6\]\[20\]
+ dp.rf.rf\[7\]\[20\] _01928_ _01929_ _01930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06163_ dp.rf.rf\[0\]\[20\] dp.rf.rf\[1\]\[20\] dp.rf.rf\[2\]\[20\]
+ dp.rf.rf\[3\]\[20\] _01928_ _01929_ _01931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06164_ _01930_ _01931_ _01779_ _01932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06165_ dp.rf.rf\[12\]\[20\] dp.rf.rf\[13\]\[20\] dp.rf.rf\[14\]\[20\]
+ dp.rf.rf\[15\]\[20\] _01059_ _01262_ _01933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06166_ dp.rf.rf\[8\]\[20\] dp.rf.rf\[9\]\[20\] dp.rf.rf\[10\]\[20\]
+ dp.rf.rf\[11\]\[20\] _01059_ _01262_ _01934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06167_ _01933_ _01934_ _01667_ _01935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06168_ _01672_ _01935_ _01936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06169_ _01607_ _01936_ _01937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06170_ _01656_ _01927_ _01932_ net224 _01937_ _01938_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_06171_ _01922_ _01938_ _01546_ _01939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06172_ _01086_ _01939_ _04921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_06173_ _04921_ _04925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06174_ dp.rf.rf\[26\]\[20\] dp.rf.rf\[27\]\[20\] dp.rf.rf\[30\]\[20\]
+ dp.rf.rf\[31\]\[20\] _01186_ _01457_ _01940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06175_ dp.rf.rf\[24\]\[20\] dp.rf.rf\[25\]\[20\] dp.rf.rf\[28\]\[20\]
+ dp.rf.rf\[29\]\[20\] _01186_ _01457_ _01941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06176_ _01940_ _01941_ _01193_ _01942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06177_ _01415_ _01942_ _01943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06178_ dp.rf.rf\[22\]\[20\] dp.rf.rf\[23\]\[20\] _01225_
+ _01944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06179_ _01944_ _01945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06180_ _01146_ _01945_ _01151_ _01946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06181_ _01154_ _01155_ _01034_ dp.rf.rf\[18\]\[20\] _01947_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_06182_ dp.rf.rf\[18\]\[20\] _01948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06183_ _01028_ _01153_ _01947_ _01948_ _01160_ _01949_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_06184_ dp.rf.rf\[19\]\[20\] _01582_ _01950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06185_ _01164_ _01166_ _01949_ _01950_ _01951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_06186_ dp.rf.rf\[17\]\[20\] dp.rf.rf\[21\]\[20\] _01144_
+ _01952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06187_ _01636_ _01952_ _01953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06188_ dp.rf.rf\[20\]\[20\] _01600_ _01196_ _01193_ _01954_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06189_ _01953_ _01954_ _01228_ net168 _01955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06190_ dp.rf.rf\[16\]\[20\] _01956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06191_ _01956_ _01737_ _01957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06192_ _01946_ _01951_ _01955_ _01957_ _01958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06193_ dp.rf.rf\[14\]\[20\] dp.rf.rf\[15\]\[20\] _01135_
+ _01959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06194_ _01959_ _01960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06195_ _01533_ _01960_ net274 _01961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06196_ net10 net1 _01034_ dp.rf.rf\[10\]\[20\] _01962_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_06197_ dp.rf.rf\[10\]\[20\] _01963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06198_ _01028_ _01153_ _01962_ _01963_ _01147_ _01964_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_06199_ dp.rf.rf\[11\]\[20\] _01179_ _01965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06200_ _01163_ _01165_ _01964_ _01965_ _01966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_06201_ dp.rf.rf\[8\]\[20\] dp.rf.rf\[9\]\[20\] dp.rf.rf\[12\]\[20\]
+ dp.rf.rf\[13\]\[20\] _01582_ _01124_ _01967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06202_ _01961_ _01966_ _01967_ _01506_ _01199_ _01968_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_06203_ dp.rf.rf\[2\]\[20\] dp.rf.rf\[3\]\[20\] dp.rf.rf\[6\]\[20\]
+ dp.rf.rf\[7\]\[20\] _01186_ _01457_ _01969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06204_ _01529_ _01969_ _01970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06205_ dp.rf.rf\[1\]\[20\] dp.rf.rf\[5\]\[20\] _01248_ _01971_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06206_ dp.rf.rf\[4\]\[20\] _01496_ _01971_ _01328_ _01193_
+ _01972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06207_ _01854_ _01970_ _01972_ _01973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06208_ _01455_ _01943_ _01958_ _01968_ _01973_ net191 _01974_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_4
X_06209_ _01974_ _04920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_06210_ _04920_ _04924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06211_ _01178_ _01300_ _01296_ _01244_ _01975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06212_ _01293_ _01975_ _01303_ _01976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06213_ _01244_ _01300_ _01977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06214_ _01298_ _01977_ _01303_ _01978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06215_ _01976_ _01978_ _01109_ _05154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06216_ dp.rf.rf\[24\]\[19\] dp.rf.rf\[25\]\[19\] dp.rf.rf\[26\]\[19\]
+ dp.rf.rf\[27\]\[19\] _01773_ _01774_ _01979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06217_ dp.rf.rf\[16\]\[19\] dp.rf.rf\[17\]\[19\] dp.rf.rf\[18\]\[19\]
+ dp.rf.rf\[19\]\[19\] _01773_ _01774_ _01980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06218_ dp.rf.rf\[28\]\[19\] dp.rf.rf\[29\]\[19\] dp.rf.rf\[30\]\[19\]
+ dp.rf.rf\[31\]\[19\] _01662_ _01659_ _01981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06219_ dp.rf.rf\[20\]\[19\] dp.rf.rf\[21\]\[19\] dp.rf.rf\[22\]\[19\]
+ dp.rf.rf\[23\]\[19\] _01662_ _01774_ _01982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06220_ _01979_ _01980_ _01981_ _01982_ _01666_ _01312_ _01983_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_06221_ dp.rf.rf\[8\]\[19\] dp.rf.rf\[9\]\[19\] dp.rf.rf\[10\]\[19\]
+ dp.rf.rf\[11\]\[19\] _01662_ _01659_ _01984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06222_ dp.rf.rf\[0\]\[19\] dp.rf.rf\[1\]\[19\] dp.rf.rf\[2\]\[19\]
+ dp.rf.rf\[3\]\[19\] _01662_ _01659_ _01985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06223_ dp.rf.rf\[12\]\[19\] dp.rf.rf\[13\]\[19\] dp.rf.rf\[14\]\[19\]
+ dp.rf.rf\[15\]\[19\] _01662_ _01659_ _01986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06224_ dp.rf.rf\[4\]\[19\] dp.rf.rf\[5\]\[19\] dp.rf.rf\[6\]\[19\]
+ dp.rf.rf\[7\]\[19\] _01662_ _01659_ _01987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06225_ _01984_ _01985_ _01986_ _01987_ _01666_ _01478_ _01988_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06226_ _01111_ _01983_ _01988_ _01112_ _01989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_06227_ _01989_ _01990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_06228_ _05154_ _01990_ _01289_ _01991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06229_ _01086_ _01991_ _04929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_06230_ _04929_ _04933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06231_ dp.rf.rf\[26\]\[19\] _01571_ _01992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06232_ dp.rf.rf\[27\]\[19\] _01429_ _01533_ _01192_ _01993_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06233_ dp.rf.rf\[30\]\[19\] dp.rf.rf\[31\]\[19\] _01147_
+ _01994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06234_ _01230_ _01994_ _01192_ _01529_ _01995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06235_ _01992_ _01993_ _01995_ _01996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06236_ dp.rf.rf\[24\]\[19\] dp.rf.rf\[25\]\[19\] dp.rf.rf\[28\]\[19\]
+ dp.rf.rf\[29\]\[19\] _01508_ _01145_ _01997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06237_ _01889_ _01997_ _01998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06238_ _01580_ _01996_ _01998_ _01999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_06239_ dp.rf.rf\[22\]\[19\] dp.rf.rf\[23\]\[19\] _01340_
+ _02000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06240_ dp.rf.rf\[18\]\[19\] net204 _02001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06241_ dp.rf.rf\[19\]\[19\] _01345_ _02002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06242_ _01344_ _02002_ _02003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06243_ _01339_ _02000_ _02001_ _02003_ _01334_ _02004_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06244_ dp.rf.rf\[20\]\[19\] _02005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06245_ dp.rf.rf\[17\]\[19\] dp.rf.rf\[21\]\[19\] _01129_
+ _02006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06246_ _01190_ _02006_ _02007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06247_ _02005_ _01249_ _02007_ _01353_ _02008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_06248_ dp.rf.rf\[16\]\[19\] _01356_ _02008_ net229 _02009_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_06249_ _02004_ _02009_ _02010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06250_ dp.rf.rf\[0\]\[19\] _02011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06251_ _01438_ _01185_ _01174_ _01252_ _02012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_06252_ dp.rf.rf\[1\]\[19\] dp.rf.rf\[5\]\[19\] _01209_ _02013_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06253_ dp.rf.rf\[4\]\[19\] _01368_ _02013_ _01442_ _01506_
+ _02014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06254_ _02011_ _02012_ _02014_ _01511_ _02015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06255_ dp.rf.rf\[2\]\[19\] dp.rf.rf\[3\]\[19\] dp.rf.rf\[6\]\[19\]
+ dp.rf.rf\[7\]\[19\] _01428_ _01169_ _02016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06256_ _01456_ _02016_ _02017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06257_ _01415_ _02017_ _01245_ _02018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06258_ net272 _02019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_06259_ dp.rf.rf\[14\]\[19\] dp.rf.rf\[15\]\[19\] _01428_
+ _02020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06260_ _01339_ _02020_ _02021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06261_ dp.rf.rf\[11\]\[19\] _01340_ _02022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06262_ _01578_ net168 _01626_ dp.rf.rf\[10\]\[19\] _02022_
+ _02023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_06263_ dp.rf.rf\[8\]\[19\] dp.rf.rf\[9\]\[19\] dp.rf.rf\[12\]\[19\]
+ dp.rf.rf\[13\]\[19\] _01363_ _01124_ _02024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06264_ _01506_ _02024_ _01199_ _02025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06265_ _02019_ _02021_ _02023_ _02025_ _02026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06266_ _02015_ _02018_ _02026_ _01376_ _02027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_06267_ _01455_ _01999_ _02010_ _02027_ _04928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_06268_ _04928_ _04932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_06269_ _01211_ _01300_ _01296_ _01178_ _02028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06270_ _01293_ _02028_ _01303_ _02029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06271_ _01063_ _01108_ _01088_ net22 _02030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_06272_ _01976_ _02029_ net241 _05150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06273_ _05150_ _02031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06274_ _01279_ _02032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_06275_ dp.rf.rf\[18\]\[18\] dp.rf.rf\[19\]\[18\] _02032_
+ _02033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06276_ dp.rf.rf\[16\]\[18\] dp.rf.rf\[17\]\[18\] _02032_
+ _02034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06277_ dp.rf.rf\[26\]\[18\] dp.rf.rf\[27\]\[18\] _01773_
+ _02035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06278_ dp.rf.rf\[24\]\[18\] dp.rf.rf\[25\]\[18\] _02032_
+ _02036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06279_ _02033_ _02034_ _02035_ _02036_ _01766_ _01761_ _02037_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06280_ _01780_ _02037_ _02038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06281_ dp.rf.rf\[12\]\[18\] dp.rf.rf\[13\]\[18\] dp.rf.rf\[14\]\[18\]
+ dp.rf.rf\[15\]\[18\] _01773_ _01317_ _02039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06282_ dp.rf.rf\[4\]\[18\] dp.rf.rf\[5\]\[18\] dp.rf.rf\[6\]\[18\]
+ dp.rf.rf\[7\]\[18\] _01773_ _01317_ _02040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06283_ _02039_ _02040_ _01311_ _02041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06284_ _01656_ _01312_ _02041_ _02042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_06285_ dp.rf.rf\[28\]\[18\] dp.rf.rf\[29\]\[18\] dp.rf.rf\[30\]\[18\]
+ dp.rf.rf\[31\]\[18\] _01773_ _01774_ _02043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06286_ dp.rf.rf\[20\]\[18\] dp.rf.rf\[21\]\[18\] dp.rf.rf\[22\]\[18\]
+ dp.rf.rf\[23\]\[18\] _01773_ _01774_ _02044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06287_ _02043_ _02044_ _01311_ _02045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06288_ dp.rf.rf\[8\]\[18\] dp.rf.rf\[9\]\[18\] dp.rf.rf\[10\]\[18\]
+ dp.rf.rf\[11\]\[18\] _01662_ _01774_ _02046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06289_ dp.rf.rf\[0\]\[18\] dp.rf.rf\[1\]\[18\] dp.rf.rf\[2\]\[18\]
+ dp.rf.rf\[3\]\[18\] _01662_ _01774_ _02047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06290_ _02046_ _02047_ _01666_ _02048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06291_ net215 _02045_ _02048_ _01836_ _02049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06292_ _02038_ _02042_ _02049_ _02050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_06293_ _02031_ _02050_ _01546_ _02051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06294_ _01086_ _02051_ _04937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_06295_ _04937_ _04941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06296_ dp.rf.rf\[2\]\[18\] _01353_ _02052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06297_ _01355_ _02052_ _02053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06298_ net206 _02053_ dp.rf.rf\[0\]\[18\] _02054_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06299_ dp.rf.rf\[10\]\[18\] dp.rf.rf\[11\]\[18\] dp.rf.rf\[14\]\[18\]
+ dp.rf.rf\[15\]\[18\] _01531_ _01443_ _02055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06300_ dp.rf.rf\[8\]\[18\] dp.rf.rf\[9\]\[18\] dp.rf.rf\[12\]\[18\]
+ dp.rf.rf\[13\]\[18\] _01531_ _01443_ _02056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06301_ _02055_ _02056_ _01172_ _02057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06302_ _01237_ _02057_ _02058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06303_ dp.rf.rf\[2\]\[18\] dp.rf.rf\[3\]\[18\] dp.rf.rf\[6\]\[18\]
+ dp.rf.rf\[7\]\[18\] _01147_ _01432_ _02059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06304_ _01416_ _02059_ _02060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06305_ dp.rf.rf\[1\]\[18\] dp.rf.rf\[5\]\[18\] _01168_ _02061_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06306_ dp.rf.rf\[4\]\[18\] _01368_ _02061_ _01371_ _01172_
+ _02062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06307_ _01854_ _02060_ _02062_ _02063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06308_ _01589_ _02054_ _02058_ _02063_ _02064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_06309_ dp.rf.rf\[18\]\[18\] _01571_ _02065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06310_ dp.rf.rf\[19\]\[18\] _01504_ _01211_ _01511_ _02066_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06311_ dp.rf.rf\[22\]\[18\] dp.rf.rf\[23\]\[18\] _01645_
+ _02067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06312_ _01568_ _02067_ _02068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06313_ _02065_ _02066_ _02019_ _02068_ _02069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_06314_ dp.rf.rf\[16\]\[18\] _02070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06315_ dp.rf.rf\[17\]\[18\] dp.rf.rf\[21\]\[18\] _01201_
+ _02071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06316_ dp.rf.rf\[20\]\[18\] _01497_ _02071_ _01693_ _01173_
+ _02072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06317_ _02070_ _01737_ _02072_ _01361_ _02073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06318_ dp.rf.rf\[27\]\[18\] _01569_ _02074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06319_ _01211_ _01511_ _01571_ dp.rf.rf\[26\]\[18\] _02074_
+ _02075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_06320_ dp.rf.rf\[30\]\[18\] dp.rf.rf\[31\]\[18\] _01645_
+ _02076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06321_ _01568_ _02076_ _01511_ _01456_ _02077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06322_ dp.rf.rf\[24\]\[18\] dp.rf.rf\[25\]\[18\] dp.rf.rf\[28\]\[18\]
+ dp.rf.rf\[29\]\[18\] _01345_ _01210_ _02078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06323_ _01576_ _02078_ _01237_ _02079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06324_ _02075_ _02077_ _02079_ _02080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06325_ _02069_ _02073_ net205 _02080_ _02081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06326_ _02064_ _02081_ _04936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_06327_ _04936_ _04940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_06328_ _01530_ _01300_ _01296_ _01211_ _02082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06329_ _01293_ _02082_ _01303_ _02083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06330_ _02029_ _02083_ net240 _05146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06331_ _05146_ _02084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06332_ dp.rf.rf\[24\]\[17\] dp.rf.rf\[25\]\[17\] dp.rf.rf\[26\]\[17\]
+ dp.rf.rf\[27\]\[17\] _01919_ _01819_ _02085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06333_ dp.rf.rf\[16\]\[17\] dp.rf.rf\[17\]\[17\] dp.rf.rf\[18\]\[17\]
+ dp.rf.rf\[19\]\[17\] _01919_ _01819_ _02086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06334_ dp.rf.rf\[28\]\[17\] dp.rf.rf\[29\]\[17\] dp.rf.rf\[30\]\[17\]
+ dp.rf.rf\[31\]\[17\] _01919_ _01819_ _02087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06335_ dp.rf.rf\[20\]\[17\] dp.rf.rf\[21\]\[17\] dp.rf.rf\[22\]\[17\]
+ dp.rf.rf\[23\]\[17\] _01919_ _01819_ _02088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06336_ _02085_ _02086_ _02087_ _02088_ _01311_ _01312_ _02089_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_06337_ dp.rf.rf\[8\]\[17\] dp.rf.rf\[9\]\[17\] dp.rf.rf\[10\]\[17\]
+ dp.rf.rf\[11\]\[17\] _01919_ _01819_ _02090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06338_ dp.rf.rf\[0\]\[17\] dp.rf.rf\[1\]\[17\] dp.rf.rf\[2\]\[17\]
+ dp.rf.rf\[3\]\[17\] _01919_ _01819_ _02091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06339_ dp.rf.rf\[12\]\[17\] dp.rf.rf\[13\]\[17\] dp.rf.rf\[14\]\[17\]
+ dp.rf.rf\[15\]\[17\] _01919_ _01306_ _02092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06340_ dp.rf.rf\[4\]\[17\] dp.rf.rf\[5\]\[17\] dp.rf.rf\[6\]\[17\]
+ dp.rf.rf\[7\]\[17\] _01919_ _01819_ _02093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06341_ _02090_ _02091_ _02092_ _02093_ _01311_ _01312_ _02094_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06342_ _01111_ _02089_ _02094_ _01112_ _02095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_06343_ _02084_ _02095_ _01546_ _02096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06344_ _01086_ _02096_ _04945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_06345_ _04945_ _04949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06346_ dp.rf.rf\[30\]\[17\] dp.rf.rf\[31\]\[17\] _01532_
+ _02097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06347_ dp.rf.rf\[26\]\[17\] _01626_ _02098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06348_ dp.rf.rf\[27\]\[17\] _01569_ _02099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06349_ _01224_ _02099_ _02100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06350_ _01568_ _02097_ _02098_ _02100_ _01335_ _02101_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_06351_ dp.rf.rf\[24\]\[17\] dp.rf.rf\[25\]\[17\] dp.rf.rf\[28\]\[17\]
+ dp.rf.rf\[29\]\[17\] _01345_ _01458_ _02102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06352_ _01500_ _02102_ _01237_ _02103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06353_ dp.rf.rf\[18\]\[17\] dp.rf.rf\[19\]\[17\] dp.rf.rf\[22\]\[17\]
+ dp.rf.rf\[23\]\[17\] _01135_ _01369_ _02104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06354_ dp.rf.rf\[16\]\[17\] dp.rf.rf\[17\]\[17\] dp.rf.rf\[20\]\[17\]
+ dp.rf.rf\[21\]\[17\] _01135_ _01369_ _02105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06355_ _02104_ _02105_ _01193_ _02106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06356_ _01178_ _02106_ _02107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06357_ _02103_ _02101_ _01455_ _02107_ _02108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_06358_ dp.rf.rf\[2\]\[17\] dp.rf.rf\[3\]\[17\] dp.rf.rf\[6\]\[17\]
+ dp.rf.rf\[7\]\[17\] _01238_ _01209_ _02109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06359_ _02109_ _02110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06360_ dp.rf.rf\[1\]\[17\] dp.rf.rf\[5\]\[17\] _01200_ _02111_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06361_ dp.rf.rf\[4\]\[17\] _01496_ _02111_ _01328_ _02112_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_06362_ _02110_ _02112_ _01430_ _02113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06363_ dp.rf.rf\[14\]\[17\] dp.rf.rf\[15\]\[17\] _01157_
+ _02114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06364_ dp.rf.rf\[10\]\[17\] net202 _02115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06365_ dp.rf.rf\[11\]\[17\] _01532_ _02116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06366_ _01344_ _02116_ _02117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06367_ _01339_ _02114_ _02115_ _02117_ _01334_ _02118_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_06368_ dp.rf.rf\[8\]\[17\] dp.rf.rf\[9\]\[17\] dp.rf.rf\[12\]\[17\]
+ dp.rf.rf\[13\]\[17\] _01340_ _01169_ _02119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06369_ _01889_ _02119_ _01176_ _02120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06370_ _01361_ _02113_ _02118_ _02120_ net189 _02121_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_06371_ _02108_ _02121_ _02122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06372_ _02122_ _04944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_06373_ _04944_ _04948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_06374_ _01504_ _01300_ _01296_ _01530_ _02123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06375_ _01293_ _02123_ _01303_ _02124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06376_ _02083_ _02124_ net240 _05142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06377_ _05142_ _02125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06378_ dp.rf.rf\[28\]\[16\] dp.rf.rf\[29\]\[16\] dp.rf.rf\[30\]\[16\]
+ dp.rf.rf\[31\]\[16\] _02032_ _01317_ _02126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06379_ dp.rf.rf\[20\]\[16\] dp.rf.rf\[21\]\[16\] dp.rf.rf\[22\]\[16\]
+ dp.rf.rf\[23\]\[16\] _02032_ _01317_ _02127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06380_ dp.rf.rf\[24\]\[16\] dp.rf.rf\[25\]\[16\] dp.rf.rf\[26\]\[16\]
+ dp.rf.rf\[27\]\[16\] _02032_ _01317_ _02128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06381_ dp.rf.rf\[16\]\[16\] dp.rf.rf\[17\]\[16\] dp.rf.rf\[18\]\[16\]
+ dp.rf.rf\[19\]\[16\] _02032_ _01317_ _02129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06382_ _02126_ _02127_ _02128_ _02129_ _01311_ _01669_ _02130_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06383_ dp.rf.rf\[12\]\[16\] dp.rf.rf\[13\]\[16\] dp.rf.rf\[14\]\[16\]
+ dp.rf.rf\[15\]\[16\] _01305_ _01306_ _02131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06384_ dp.rf.rf\[8\]\[16\] dp.rf.rf\[9\]\[16\] dp.rf.rf\[10\]\[16\]
+ dp.rf.rf\[11\]\[16\] _01305_ _01306_ _02132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06385_ _02131_ _02132_ _01669_ _02133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06386_ dp.rf.rf\[4\]\[16\] dp.rf.rf\[5\]\[16\] dp.rf.rf\[6\]\[16\]
+ dp.rf.rf\[7\]\[16\] _01484_ _01485_ _02134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06387_ dp.rf.rf\[0\]\[16\] dp.rf.rf\[1\]\[16\] dp.rf.rf\[2\]\[16\]
+ dp.rf.rf\[3\]\[16\] _01484_ _01485_ _02135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06388_ _02134_ _02135_ _01779_ _02136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06389_ net223 _02136_ _02137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06390_ _01608_ _02137_ _02138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06391_ _01656_ _02130_ _02133_ _01672_ _02138_ _02139_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_06392_ _02125_ _02139_ _01546_ _02140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06393_ _01086_ _02140_ _04953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_06394_ _04953_ _04957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06395_ dp.rf.rf\[26\]\[16\] dp.rf.rf\[27\]\[16\] dp.rf.rf\[30\]\[16\]
+ dp.rf.rf\[31\]\[16\] _01157_ _01458_ _02141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06396_ dp.rf.rf\[24\]\[16\] dp.rf.rf\[25\]\[16\] dp.rf.rf\[28\]\[16\]
+ dp.rf.rf\[29\]\[16\] _01157_ _01139_ _02142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06397_ _02141_ _02142_ _01889_ _02143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06398_ _01415_ _02143_ _02144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06399_ dp.rf.rf\[18\]\[16\] dp.rf.rf\[19\]\[16\] dp.rf.rf\[22\]\[16\]
+ dp.rf.rf\[23\]\[16\] _01429_ _01146_ _02145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06400_ dp.rf.rf\[17\]\[16\] dp.rf.rf\[21\]\[16\] _01201_
+ _02146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06401_ _01693_ _02146_ _02147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06402_ dp.rf.rf\[20\]\[16\] _01504_ _01339_ _01889_ _02148_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06403_ _02147_ _02148_ _01415_ _01511_ _02149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06404_ dp.rf.rf\[16\]\[16\] _02150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06405_ _02150_ _01737_ _02151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06406_ _01335_ _02145_ _02149_ _02151_ _02152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06407_ dp.rf.rf\[14\]\[16\] dp.rf.rf\[15\]\[16\] _01136_
+ _02153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06408_ _02153_ _02154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06409_ _01211_ _02154_ _02019_ _02155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06410_ _01154_ _01155_ _01090_ dp.rf.rf\[10\]\[16\] _02156_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_06411_ dp.rf.rf\[10\]\[16\] _02157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06412_ _01028_ _01185_ _02156_ _02157_ _01645_ _02158_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_06413_ dp.rf.rf\[11\]\[16\] _01600_ _02159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06414_ _01164_ _01166_ _02158_ _02159_ _02160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_06415_ dp.rf.rf\[8\]\[16\] dp.rf.rf\[9\]\[16\] dp.rf.rf\[12\]\[16\]
+ dp.rf.rf\[13\]\[16\] _01577_ _01578_ _02161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06416_ _02155_ _02160_ _02161_ _01576_ _01580_ _02162_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_06417_ dp.rf.rf\[2\]\[16\] dp.rf.rf\[3\]\[16\] dp.rf.rf\[6\]\[16\]
+ dp.rf.rf\[7\]\[16\] _01157_ _01139_ _02163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06418_ _01456_ _02163_ _02164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06419_ dp.rf.rf\[1\]\[16\] dp.rf.rf\[5\]\[16\] _01381_ _02165_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06420_ dp.rf.rf\[4\]\[16\] _01497_ _02165_ _01422_ _01889_
+ _02166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06421_ _01361_ _02164_ _02166_ _02167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06422_ _02152_ _02144_ _01455_ _02162_ _02167_ _01589_ _02168_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_4
X_06423_ _02168_ _04952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_06424_ _04952_ _04956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_06425_ _01292_ _01291_ net20 _02169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_06426_ net6 _02170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_06427_ _02170_ _01300_ _01296_ _01504_ _02171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06428_ _02169_ _02171_ _02172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06429_ _02124_ _02172_ net240 _05138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06430_ _05138_ _02173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06431_ dp.rf.rf\[24\]\[15\] dp.rf.rf\[25\]\[15\] dp.rf.rf\[26\]\[15\]
+ dp.rf.rf\[27\]\[15\] _01928_ _01929_ _02174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06432_ _01657_ _02175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_06433_ _01549_ _02176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_06434_ dp.rf.rf\[16\]\[15\] dp.rf.rf\[17\]\[15\] dp.rf.rf\[18\]\[15\]
+ dp.rf.rf\[19\]\[15\] _02175_ _02176_ _02177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06435_ dp.rf.rf\[28\]\[15\] dp.rf.rf\[29\]\[15\] dp.rf.rf\[30\]\[15\]
+ dp.rf.rf\[31\]\[15\] _01928_ _01929_ _02178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06436_ dp.rf.rf\[20\]\[15\] dp.rf.rf\[21\]\[15\] dp.rf.rf\[22\]\[15\]
+ dp.rf.rf\[23\]\[15\] _01928_ _01929_ _02179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06437_ _02174_ _02177_ _02178_ _02179_ _01666_ _01400_ _02180_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06438_ dp.rf.rf\[8\]\[15\] dp.rf.rf\[9\]\[15\] dp.rf.rf\[10\]\[15\]
+ dp.rf.rf\[11\]\[15\] _01928_ _01929_ _02181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06439_ dp.rf.rf\[0\]\[15\] dp.rf.rf\[1\]\[15\] dp.rf.rf\[2\]\[15\]
+ dp.rf.rf\[3\]\[15\] _02175_ _02176_ _02182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06440_ dp.rf.rf\[12\]\[15\] dp.rf.rf\[13\]\[15\] dp.rf.rf\[14\]\[15\]
+ dp.rf.rf\[15\]\[15\] net249 _01929_ _02183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06441_ dp.rf.rf\[4\]\[15\] dp.rf.rf\[5\]\[15\] dp.rf.rf\[6\]\[15\]
+ dp.rf.rf\[7\]\[15\] _01928_ _01929_ _02184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06442_ _02181_ _02182_ _02183_ _02184_ _01272_ _01400_ _02185_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06443_ _02180_ _02185_ _01058_ _02186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06444_ net192 _02186_ _02187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_06445_ _02173_ _02187_ _01546_ _02188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06446_ _01086_ _02188_ _04961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_06447_ _04961_ _04965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06448_ dp.rf.rf\[22\]\[15\] dp.rf.rf\[23\]\[15\] _01429_
+ _02189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06449_ _01568_ _02189_ _02190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06450_ _02019_ _02190_ _02191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06451_ dp.rf.rf\[18\]\[15\] _01571_ _02192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06452_ dp.rf.rf\[19\]\[15\] _01504_ _02193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06453_ _01593_ _02192_ _02193_ _02194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_06454_ dp.rf.rf\[17\]\[15\] dp.rf.rf\[21\]\[15\] _01169_
+ _02195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06455_ dp.rf.rf\[20\]\[15\] _01497_ _02195_ _01693_ _01500_
+ _02196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06456_ net206 _01355_ dp.rf.rf\[16\]\[15\] _02197_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06457_ _01361_ _02196_ _02197_ _02198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06458_ _02191_ _02194_ _02198_ _02199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06459_ dp.rf.rf\[30\]\[15\] dp.rf.rf\[31\]\[15\] _01577_
+ _02200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06460_ _01568_ _02200_ net206 _01530_ _02201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06461_ dp.rf.rf\[27\]\[15\] _01569_ _02202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06462_ _01211_ _01511_ _01571_ dp.rf.rf\[26\]\[15\] _02202_
+ _02203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_06463_ net206 _01377_ dp.rf.rf\[24\]\[15\] _02204_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06464_ dp.rf.rf\[25\]\[15\] dp.rf.rf\[29\]\[15\] _01201_
+ _02205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06465_ dp.rf.rf\[28\]\[15\] _01497_ _02205_ _01693_ _01889_
+ _02206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06466_ _02201_ _02203_ _02204_ _02206_ _01385_ _02207_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06467_ _01207_ _02207_ _02208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06468_ dp.rf.rf\[14\]\[15\] dp.rf.rf\[15\]\[15\] _01577_
+ _02209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06469_ _02209_ _02210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06470_ dp.rf.rf\[10\]\[15\] _01571_ _02211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06471_ dp.rf.rf\[11\]\[15\] _01504_ _01146_ _01435_ _02212_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06472_ _01211_ _02210_ _02211_ _02212_ _02019_ _02213_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_06473_ dp.rf.rf\[8\]\[15\] dp.rf.rf\[9\]\[15\] dp.rf.rf\[12\]\[15\]
+ dp.rf.rf\[13\]\[15\] _01577_ _01146_ _02214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06474_ _01576_ _02214_ _02215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06475_ _01580_ _02213_ _02215_ _02216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_06476_ dp.rf.rf\[1\]\[15\] dp.rf.rf\[5\]\[15\] _01381_ _02217_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06477_ _01422_ _02217_ _02218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06478_ dp.rf.rf\[4\]\[15\] _01429_ _01505_ _01430_ _02219_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06479_ _02218_ _02219_ _01435_ _02220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06480_ dp.rf.rf\[0\]\[15\] _02221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06481_ _02221_ _02012_ _02222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06482_ dp.rf.rf\[2\]\[15\] dp.rf.rf\[3\]\[15\] dp.rf.rf\[6\]\[15\]
+ dp.rf.rf\[7\]\[15\] _01520_ _01364_ _02223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06483_ _01362_ _02223_ _02224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06484_ _01337_ _02224_ _02225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06485_ _02220_ _02222_ _02225_ net206 _02226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06486_ _01589_ _02226_ _02227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06487_ _02208_ _02199_ _02216_ _02227_ _02228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_06488_ net243 _04964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_06489_ _01085_ _02229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_06490_ net5 _01300_ _01296_ _02170_ _02230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06491_ _02169_ _02230_ _02231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06492_ _02172_ _02231_ net240 _05134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06493_ _01102_ _02232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_06494_ dp.rf.rf\[24\]\[14\] dp.rf.rf\[25\]\[14\] dp.rf.rf\[26\]\[14\]
+ dp.rf.rf\[27\]\[14\] _01661_ _02232_ _02233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06495_ dp.rf.rf\[16\]\[14\] dp.rf.rf\[17\]\[14\] dp.rf.rf\[18\]\[14\]
+ dp.rf.rf\[19\]\[14\] _01661_ _02232_ _02234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06496_ dp.rf.rf\[28\]\[14\] dp.rf.rf\[29\]\[14\] dp.rf.rf\[30\]\[14\]
+ dp.rf.rf\[31\]\[14\] _01661_ _01391_ _02235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06497_ dp.rf.rf\[20\]\[14\] dp.rf.rf\[21\]\[14\] dp.rf.rf\[22\]\[14\]
+ dp.rf.rf\[23\]\[14\] _01661_ _02232_ _02236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06498_ _02233_ _02234_ _02235_ _02236_ _01394_ net194 _02237_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_06499_ dp.rf.rf\[8\]\[14\] dp.rf.rf\[9\]\[14\] dp.rf.rf\[10\]\[14\]
+ dp.rf.rf\[11\]\[14\] _01390_ _01403_ _02238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06500_ dp.rf.rf\[0\]\[14\] dp.rf.rf\[1\]\[14\] dp.rf.rf\[2\]\[14\]
+ dp.rf.rf\[3\]\[14\] _01390_ _01391_ _02239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06501_ dp.rf.rf\[12\]\[14\] dp.rf.rf\[13\]\[14\] dp.rf.rf\[14\]\[14\]
+ dp.rf.rf\[15\]\[14\] _01402_ _01403_ _02240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06502_ dp.rf.rf\[4\]\[14\] dp.rf.rf\[5\]\[14\] dp.rf.rf\[6\]\[14\]
+ dp.rf.rf\[7\]\[14\] _01390_ _01403_ _02241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06503_ _02238_ _02239_ _02240_ _02241_ _01394_ net194 _02242_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_06504_ _01037_ _02237_ _02242_ _01061_ _02243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_06505_ _02243_ _02244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_06506_ _05134_ _02244_ _01289_ _02245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06507_ _02229_ _02245_ _04969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_06508_ _04969_ _04973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06509_ dp.rf.rf\[11\]\[14\] _01340_ _02246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06510_ _01578_ net168 _01626_ dp.rf.rf\[10\]\[14\] _02246_
+ _02247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_06511_ dp.rf.rf\[14\]\[14\] dp.rf.rf\[15\]\[14\] _01160_
+ _02248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06512_ _01505_ _02248_ _02249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06513_ dp.rf.rf\[8\]\[14\] dp.rf.rf\[9\]\[14\] dp.rf.rf\[12\]\[14\]
+ dp.rf.rf\[13\]\[14\] _01363_ _01364_ _02250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06514_ _01889_ _02250_ _02251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06515_ _02019_ _02247_ _02249_ _02251_ _02252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06516_ dp.rf.rf\[2\]\[14\] dp.rf.rf\[3\]\[14\] dp.rf.rf\[6\]\[14\]
+ dp.rf.rf\[7\]\[14\] _01508_ _01201_ _02253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06517_ _01362_ _02253_ _02254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06518_ dp.rf.rf\[1\]\[14\] dp.rf.rf\[5\]\[14\] _01457_ _02255_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06519_ dp.rf.rf\[4\]\[14\] _01368_ _02255_ _01442_ _01430_
+ _02256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06520_ _01361_ _02254_ _02256_ _02257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_06521_ _01580_ _02252_ _02257_ _01376_ _02258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_06522_ dp.rf.rf\[22\]\[14\] dp.rf.rf\[23\]\[14\] _01428_
+ _02259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06523_ _02259_ _02260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06524_ dp.rf.rf\[18\]\[14\] _01571_ _02261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06525_ dp.rf.rf\[19\]\[14\] _01429_ _01210_ _01192_ _02262_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06526_ _01211_ _02260_ _02261_ _02262_ _01151_ _02263_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_06527_ dp.rf.rf\[16\]\[14\] _02264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06528_ dp.rf.rf\[17\]\[14\] dp.rf.rf\[21\]\[14\] _01369_
+ _02265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06529_ dp.rf.rf\[20\]\[14\] _01368_ _02265_ _01442_ _01372_
+ _02266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06530_ _02264_ _01737_ _02266_ _01854_ _02267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06531_ dp.rf.rf\[26\]\[14\] dp.rf.rf\[27\]\[14\] _01531_
+ _02268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06532_ dp.rf.rf\[30\]\[14\] dp.rf.rf\[31\]\[14\] _01520_
+ _02269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06533_ _01164_ _01166_ _02268_ _02269_ _01505_ _02270_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_06534_ dp.rf.rf\[24\]\[14\] dp.rf.rf\[25\]\[14\] dp.rf.rf\[28\]\[14\]
+ dp.rf.rf\[29\]\[14\] _01121_ _01432_ _02271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06535_ _01506_ _02271_ _02272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06536_ _01173_ _02270_ _02272_ _01385_ _02273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06537_ _02263_ _02267_ net205 _02273_ _02274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_06538_ _02258_ _02274_ _04968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_06539_ _04968_ _04972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_06540_ net4 _01300_ _01296_ net5 _02275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06541_ _02169_ _02275_ _02276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06542_ _02231_ _02276_ net240 _05130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06543_ _05130_ _02277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06544_ _01408_ _02278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_06545_ dp.rf.rf\[24\]\[13\] dp.rf.rf\[25\]\[13\] dp.rf.rf\[26\]\[13\]
+ dp.rf.rf\[27\]\[13\] _01658_ _02278_ _02279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06546_ dp.rf.rf\[16\]\[13\] dp.rf.rf\[17\]\[13\] dp.rf.rf\[18\]\[13\]
+ dp.rf.rf\[19\]\[13\] _01658_ _02278_ _02280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06547_ dp.rf.rf\[28\]\[13\] dp.rf.rf\[29\]\[13\] dp.rf.rf\[30\]\[13\]
+ dp.rf.rf\[31\]\[13\] _01820_ _02278_ _02281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06548_ dp.rf.rf\[20\]\[13\] dp.rf.rf\[21\]\[13\] dp.rf.rf\[22\]\[13\]
+ dp.rf.rf\[23\]\[13\] _01820_ _02278_ _02282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06549_ _02279_ _02280_ _02281_ _02282_ _01666_ _01478_ _02283_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_06550_ dp.rf.rf\[8\]\[13\] dp.rf.rf\[9\]\[13\] dp.rf.rf\[10\]\[13\]
+ dp.rf.rf\[11\]\[13\] _01820_ _02278_ _02284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06551_ dp.rf.rf\[0\]\[13\] dp.rf.rf\[1\]\[13\] dp.rf.rf\[2\]\[13\]
+ dp.rf.rf\[3\]\[13\] _01820_ _02278_ _02285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06552_ dp.rf.rf\[12\]\[13\] dp.rf.rf\[13\]\[13\] dp.rf.rf\[14\]\[13\]
+ dp.rf.rf\[15\]\[13\] _01820_ _02278_ _02286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06553_ dp.rf.rf\[4\]\[13\] dp.rf.rf\[5\]\[13\] dp.rf.rf\[6\]\[13\]
+ dp.rf.rf\[7\]\[13\] _01820_ _02278_ _02287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06554_ _02284_ _02285_ _02286_ _02287_ _01666_ _01478_ _02288_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_06555_ _01111_ _02283_ _02288_ _01112_ _02289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_06556_ _02277_ _02289_ _01546_ _02290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06557_ _01086_ _02290_ _04977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_06558_ _04977_ _04981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06559_ dp.rf.rf\[17\]\[13\] dp.rf.rf\[21\]\[13\] _01144_
+ _02291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06560_ _01636_ _02291_ _02292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06561_ dp.rf.rf\[20\]\[13\] _01600_ _01196_ _01193_ _02293_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06562_ _02292_ _02293_ _01228_ _01077_ _02294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06563_ dp.rf.rf\[16\]\[13\] _02295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06564_ _02295_ _01737_ _02296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06565_ dp.rf.rf\[18\]\[13\] dp.rf.rf\[19\]\[13\] _01238_
+ _02297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06566_ _02297_ _02298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06567_ dp.rf.rf\[22\]\[13\] dp.rf.rf\[23\]\[13\] _01194_
+ _02299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06568_ _01182_ _02299_ _01118_ _02300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06569_ _01224_ _02298_ _02300_ _02301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06570_ _02294_ _02296_ _02301_ _02302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06571_ dp.rf.rf\[26\]\[13\] dp.rf.rf\[27\]\[13\] dp.rf.rf\[30\]\[13\]
+ dp.rf.rf\[31\]\[13\] _01508_ _01201_ _02303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_06572_ dp.rf.rf\[24\]\[13\] dp.rf.rf\[25\]\[13\] dp.rf.rf\[28\]\[13\]
+ dp.rf.rf\[29\]\[13\] _01582_ _01124_ _02304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06573_ _01334_ _02303_ _02304_ _01506_ _01199_ _02305_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_06574_ dp.rf.rf\[4\]\[13\] _01532_ _01182_ _02306_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_06575_ dp.rf.rf\[1\]\[13\] dp.rf.rf\[5\]\[13\] _01200_ _02307_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06576_ _01636_ _02307_ _02308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06577_ dp.rf.rf\[2\]\[13\] dp.rf.rf\[3\]\[13\] dp.rf.rf\[6\]\[13\]
+ dp.rf.rf\[7\]\[13\] _01194_ _01369_ _02309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06578_ _01213_ _02309_ _02310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06579_ _01119_ _02306_ _02308_ _02310_ _02311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06580_ dp.rf.rf\[10\]\[13\] dp.rf.rf\[11\]\[13\] dp.rf.rf\[14\]\[13\]
+ dp.rf.rf\[15\]\[13\] _01427_ _01168_ _02312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06581_ dp.rf.rf\[8\]\[13\] dp.rf.rf\[9\]\[13\] dp.rf.rf\[12\]\[13\]
+ dp.rf.rf\[13\]\[13\] _01427_ _01168_ _02313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06582_ _02312_ _02313_ _01218_ _02314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06583_ _01541_ _02311_ _02314_ _01176_ _01375_ _02315_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_06584_ net211 _02302_ _02305_ _02315_ _04976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_06585_ _04976_ _04980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_06586_ net4 _01296_ _02316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06587_ _01293_ _02316_ _02317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06588_ _02276_ _02317_ net240 _05126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06589_ _05126_ _02318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06590_ dp.rf.rf\[28\]\[12\] dp.rf.rf\[29\]\[12\] dp.rf.rf\[30\]\[12\]
+ dp.rf.rf\[31\]\[12\] _01390_ _01403_ _02319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06591_ dp.rf.rf\[20\]\[12\] dp.rf.rf\[21\]\[12\] dp.rf.rf\[22\]\[12\]
+ dp.rf.rf\[23\]\[12\] _01402_ _01403_ _02320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06592_ _02319_ _02320_ _01398_ _02321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06593_ dp.rf.rf\[24\]\[12\] dp.rf.rf\[25\]\[12\] dp.rf.rf\[26\]\[12\]
+ dp.rf.rf\[27\]\[12\] _01402_ _01403_ _02322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06594_ dp.rf.rf\[16\]\[12\] dp.rf.rf\[17\]\[12\] dp.rf.rf\[18\]\[12\]
+ dp.rf.rf\[19\]\[12\] _01402_ _01403_ _02323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06595_ _02322_ _02323_ _01398_ _02324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06596_ _02321_ _02324_ _01669_ _02325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06597_ instr[21] _02326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_06598_ dp.rf.rf\[12\]\[12\] dp.rf.rf\[13\]\[12\] dp.rf.rf\[14\]\[12\]
+ dp.rf.rf\[15\]\[12\] _01260_ _02326_ _02327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06599_ dp.rf.rf\[8\]\[12\] dp.rf.rf\[9\]\[12\] dp.rf.rf\[10\]\[12\]
+ dp.rf.rf\[11\]\[12\] _01260_ _02326_ _02328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06600_ _02327_ _02328_ _01668_ _02329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06601_ _01672_ _02329_ _02330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06602_ dp.rf.rf\[4\]\[12\] dp.rf.rf\[5\]\[12\] dp.rf.rf\[6\]\[12\]
+ dp.rf.rf\[7\]\[12\] _01260_ _02326_ _02331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06603_ dp.rf.rf\[0\]\[12\] dp.rf.rf\[1\]\[12\] dp.rf.rf\[2\]\[12\]
+ dp.rf.rf\[3\]\[12\] _01260_ _02326_ _02332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06604_ _02331_ _02332_ _01668_ _02333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06605_ _01677_ _02333_ _02334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06606_ net192 _02330_ _02334_ _02335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06607_ _01656_ _02325_ _02335_ _02336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_06608_ _02318_ _02336_ _01546_ _02337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06609_ _01086_ _02337_ _04985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_06610_ _04985_ _04989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06611_ dp.rf.rf\[8\]\[12\] dp.rf.rf\[9\]\[12\] dp.rf.rf\[12\]\[12\]
+ dp.rf.rf\[13\]\[12\] _01157_ _01139_ _02338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06612_ dp.rf.rf\[10\]\[12\] dp.rf.rf\[11\]\[12\] _01186_
+ _02339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06613_ _02339_ _02340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06614_ dp.rf.rf\[14\]\[12\] dp.rf.rf\[15\]\[12\] _01427_
+ _02341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06615_ _01196_ _02341_ _02342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06616_ _01344_ _02340_ _02342_ _01172_ _02343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_06617_ _01500_ _02338_ _02343_ _01176_ _02344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_06618_ dp.rf.rf\[2\]\[12\] dp.rf.rf\[3\]\[12\] dp.rf.rf\[6\]\[12\]
+ dp.rf.rf\[7\]\[12\] _01531_ _01443_ _02345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06619_ _01119_ _02345_ _02346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06620_ dp.rf.rf\[1\]\[12\] dp.rf.rf\[5\]\[12\] _01144_ _02347_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06621_ dp.rf.rf\[4\]\[12\] _01496_ _02347_ _01636_ _01241_
+ _02348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06622_ _01854_ _02346_ _02348_ _02349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06623_ dp.rf.rf\[26\]\[12\] dp.rf.rf\[27\]\[12\] dp.rf.rf\[30\]\[12\]
+ dp.rf.rf\[31\]\[12\] _01194_ _01138_ _02350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06624_ dp.rf.rf\[24\]\[12\] dp.rf.rf\[25\]\[12\] dp.rf.rf\[28\]\[12\]
+ dp.rf.rf\[29\]\[12\] _01194_ _01138_ _02351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06625_ _02350_ _02351_ _01193_ _02352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06626_ _01337_ _02352_ _02353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06627_ dp.rf.rf\[18\]\[12\] dp.rf.rf\[19\]\[12\] dp.rf.rf\[22\]\[12\]
+ dp.rf.rf\[23\]\[12\] _01428_ _01145_ _02354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06628_ dp.rf.rf\[17\]\[12\] dp.rf.rf\[21\]\[12\] _01123_
+ _02355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06629_ _01328_ _02355_ _02356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06630_ dp.rf.rf\[20\]\[12\] _01157_ _01196_ _01218_ _02357_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06631_ _02356_ _02357_ _01228_ net257 _02358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06632_ dp.rf.rf\[16\]\[12\] _02359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06633_ _02359_ _01736_ _02360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06634_ _01334_ _02354_ _02358_ _02360_ _02361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06635_ _02349_ _02344_ _01589_ _02353_ _02361_ net210 _04984_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_4
X_06636_ _04984_ _04988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_06637_ _01079_ _01082_ _02362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06638_ net25 _02362_ _01296_ _01919_ _02363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06639_ net239 _02169_ _02363_ _05122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06640_ dp.rf.rf\[24\]\[11\] dp.rf.rf\[25\]\[11\] dp.rf.rf\[26\]\[11\]
+ dp.rf.rf\[27\]\[11\] _02032_ _01317_ _02364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06641_ dp.rf.rf\[16\]\[11\] dp.rf.rf\[17\]\[11\] dp.rf.rf\[18\]\[11\]
+ dp.rf.rf\[19\]\[11\] _02032_ _01317_ _02365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06642_ dp.rf.rf\[28\]\[11\] dp.rf.rf\[29\]\[11\] dp.rf.rf\[30\]\[11\]
+ dp.rf.rf\[31\]\[11\] _01773_ _01774_ _02366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06643_ dp.rf.rf\[20\]\[11\] dp.rf.rf\[21\]\[11\] dp.rf.rf\[22\]\[11\]
+ dp.rf.rf\[23\]\[11\] _02032_ _01317_ _02367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06644_ _02364_ _02365_ _02366_ _02367_ _01311_ _01312_ _02368_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06645_ dp.rf.rf\[8\]\[11\] dp.rf.rf\[9\]\[11\] dp.rf.rf\[10\]\[11\]
+ dp.rf.rf\[11\]\[11\] _01548_ _01550_ _02369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06646_ dp.rf.rf\[0\]\[11\] dp.rf.rf\[1\]\[11\] dp.rf.rf\[2\]\[11\]
+ dp.rf.rf\[3\]\[11\] _01548_ _01550_ _02370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06647_ dp.rf.rf\[12\]\[11\] dp.rf.rf\[13\]\[11\] dp.rf.rf\[14\]\[11\]
+ dp.rf.rf\[15\]\[11\] _01553_ _01555_ _02371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06648_ dp.rf.rf\[4\]\[11\] dp.rf.rf\[5\]\[11\] dp.rf.rf\[6\]\[11\]
+ dp.rf.rf\[7\]\[11\] net249 _01550_ _02372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06649_ _02369_ _02370_ _02371_ _02372_ _01272_ _01400_ _02373_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06650_ _01608_ _02373_ _02374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06651_ _02368_ _02374_ _01656_ _02375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_06652_ _05122_ _02375_ _01289_ _02376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06653_ _02229_ _02376_ _04993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_06654_ _04993_ _04997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06655_ dp.rf.rf\[1\]\[11\] dp.rf.rf\[5\]\[11\] _01248_ _02377_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06656_ _01190_ _02377_ _02378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06657_ dp.rf.rf\[4\]\[11\] _01340_ _01162_ _01218_ _02379_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06658_ _02378_ _02379_ net257 _02380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06659_ dp.rf.rf\[0\]\[11\] _01325_ _02380_ _02381_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06660_ dp.rf.rf\[2\]\[11\] dp.rf.rf\[3\]\[11\] dp.rf.rf\[6\]\[11\]
+ dp.rf.rf\[7\]\[11\] _01128_ _01144_ _02382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06661_ _01353_ _02382_ net8 _02383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06662_ net199 _02383_ _02384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06663_ dp.rf.rf\[14\]\[11\] dp.rf.rf\[15\]\[11\] _01121_
+ _02385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06664_ dp.rf.rf\[10\]\[11\] net203 _02386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06665_ dp.rf.rf\[11\]\[11\] _01428_ _02387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06666_ _01223_ _02387_ _02388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06667_ _01230_ _02385_ _02386_ _02388_ _01334_ _02389_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06668_ dp.rf.rf\[8\]\[11\] dp.rf.rf\[9\]\[11\] dp.rf.rf\[12\]\[11\]
+ dp.rf.rf\[13\]\[11\] _01225_ _01443_ _02390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06669_ _01430_ _02390_ _01199_ _02391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06670_ _02381_ _02384_ _02391_ _02389_ net190 _02392_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_06671_ dp.rf.rf\[22\]\[11\] dp.rf.rf\[23\]\[11\] _01428_
+ _02393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06672_ dp.rf.rf\[18\]\[11\] net203 _02394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06673_ dp.rf.rf\[19\]\[11\] _01212_ _02395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06674_ _01344_ _02395_ _02396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06675_ _01339_ _02393_ _02394_ _02396_ _01334_ _02397_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06676_ dp.rf.rf\[20\]\[11\] _02398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06677_ dp.rf.rf\[17\]\[11\] dp.rf.rf\[21\]\[11\] _01129_
+ _02399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06678_ _01190_ _02399_ _02400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06679_ _02398_ _01249_ _02400_ _01353_ _02401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_06680_ dp.rf.rf\[16\]\[11\] _01356_ _02401_ net229 _02402_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_06681_ dp.rf.rf\[26\]\[11\] dp.rf.rf\[27\]\[11\] dp.rf.rf\[30\]\[11\]
+ dp.rf.rf\[31\]\[11\] _01202_ _01200_ _02403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06682_ dp.rf.rf\[24\]\[11\] dp.rf.rf\[25\]\[11\] dp.rf.rf\[28\]\[11\]
+ dp.rf.rf\[29\]\[11\] _01202_ _01200_ _02404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06683_ _02403_ _02404_ _01171_ _02405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06684_ _01228_ _02405_ net177 _02406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06685_ _02397_ _02402_ _02406_ _02407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06686_ _02392_ _02407_ _04992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_06687_ net237 _02408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06688_ _02408_ _04996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_06689_ _01078_ _02409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_06690_ net19 _02409_ _05118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06691_ dp.rf.rf\[6\]\[10\] dp.rf.rf\[7\]\[10\] dp.rf.rf\[14\]\[10\]
+ dp.rf.rf\[15\]\[10\] _01820_ _01761_ _02410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06692_ dp.rf.rf\[2\]\[10\] dp.rf.rf\[3\]\[10\] dp.rf.rf\[10\]\[10\]
+ dp.rf.rf\[11\]\[10\] _01820_ _01761_ _02411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06693_ dp.rf.rf\[4\]\[10\] dp.rf.rf\[5\]\[10\] dp.rf.rf\[12\]\[10\]
+ dp.rf.rf\[13\]\[10\] _02175_ _01763_ _02412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06694_ dp.rf.rf\[0\]\[10\] dp.rf.rf\[1\]\[10\] dp.rf.rf\[8\]\[10\]
+ dp.rf.rf\[9\]\[10\] _01820_ _01761_ _02413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06695_ _02410_ _02411_ _02412_ _02413_ _01779_ _01766_ _02414_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06696_ _01112_ _02414_ _02415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06697_ dp.rf.rf\[24\]\[10\] dp.rf.rf\[25\]\[10\] dp.rf.rf\[26\]\[10\]
+ dp.rf.rf\[27\]\[10\] _01662_ _01659_ _02416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06698_ _01311_ _02416_ _02417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06699_ dp.rf.rf\[18\]\[10\] dp.rf.rf\[19\]\[10\] _01658_
+ _02418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06700_ _01766_ _01761_ _02418_ _02419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_06701_ dp.rf.rf\[16\]\[10\] dp.rf.rf\[17\]\[10\] _01658_
+ _02420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06702_ _01819_ _01761_ _02420_ _02421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_06703_ _01780_ _02417_ _02419_ _02421_ _02422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_06704_ dp.rf.rf\[28\]\[10\] dp.rf.rf\[29\]\[10\] dp.rf.rf\[30\]\[10\]
+ dp.rf.rf\[31\]\[10\] _01658_ _02278_ _02423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06705_ dp.rf.rf\[20\]\[10\] dp.rf.rf\[21\]\[10\] dp.rf.rf\[22\]\[10\]
+ dp.rf.rf\[23\]\[10\] _01658_ _02278_ _02424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06706_ _02423_ _02424_ _01666_ _02425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06707_ net213 _02425_ _02426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06708_ _02422_ _02415_ _02426_ _02427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_06709_ _05118_ _02427_ _01289_ _02428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06710_ _02229_ _02428_ _05001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_06711_ _05001_ _05005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06712_ dp.rf.rf\[2\]\[10\] _01118_ _01355_ _02429_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06713_ net199 _02429_ _02430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06714_ dp.rf.rf\[0\]\[10\] _02430_ _02431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06715_ dp.rf.rf\[10\]\[10\] dp.rf.rf\[11\]\[10\] dp.rf.rf\[14\]\[10\]
+ dp.rf.rf\[15\]\[10\] _01202_ _01123_ _02432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06716_ dp.rf.rf\[8\]\[10\] dp.rf.rf\[9\]\[10\] dp.rf.rf\[12\]\[10\]
+ dp.rf.rf\[13\]\[10\] _01202_ _01123_ _02433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06717_ _02432_ _02433_ _01171_ _02434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06718_ _01199_ _02434_ _02435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06719_ dp.rf.rf\[2\]\[10\] dp.rf.rf\[3\]\[10\] dp.rf.rf\[6\]\[10\]
+ dp.rf.rf\[7\]\[10\] _01128_ _01144_ _02436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06720_ _01353_ _02436_ _02437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06721_ dp.rf.rf\[1\]\[10\] dp.rf.rf\[5\]\[10\] _01129_ _02438_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06722_ dp.rf.rf\[4\]\[10\] _01367_ _02438_ _01190_ _01218_
+ _02439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06723_ _01360_ _02437_ _02439_ _02440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06724_ net189 _02431_ _02435_ _02440_ _02441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_06725_ dp.rf.rf\[18\]\[10\] _01571_ _02442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06726_ dp.rf.rf\[19\]\[10\] _01429_ _01578_ _01077_ _02443_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06727_ dp.rf.rf\[22\]\[10\] dp.rf.rf\[23\]\[10\] _01582_
+ _02444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06728_ _01230_ _02444_ _02445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06729_ _02442_ _02443_ _01151_ _02445_ _02446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_06730_ dp.rf.rf\[16\]\[10\] _02447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06731_ dp.rf.rf\[17\]\[10\] dp.rf.rf\[21\]\[10\] _01168_
+ _02448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06732_ dp.rf.rf\[20\]\[10\] _01496_ _02448_ _01371_ _01172_
+ _02449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06733_ _02447_ _01737_ _02449_ _01854_ _02450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06734_ dp.rf.rf\[30\]\[10\] dp.rf.rf\[31\]\[10\] _01202_
+ _02451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06735_ _02451_ _02452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06736_ dp.rf.rf\[26\]\[10\] dp.rf.rf\[27\]\[10\] _01120_
+ _02453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06737_ _02453_ _02454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06738_ _01169_ _02452_ _02454_ _01223_ _02455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06739_ dp.rf.rf\[24\]\[10\] dp.rf.rf\[25\]\[10\] dp.rf.rf\[28\]\[10\]
+ dp.rf.rf\[29\]\[10\] _01225_ _01443_ _02456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06740_ _02455_ _02456_ _01172_ _02457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06741_ _02446_ _02450_ _02457_ _01237_ _01207_ _02458_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_06742_ _02441_ _02458_ _05000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_06743_ _05000_ _02459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06744_ _02459_ _05004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_06745_ net18 _02409_ _05114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06746_ dp.rf.rf\[24\]\[9\] dp.rf.rf\[25\]\[9\] dp.rf.rf\[26\]\[9\]
+ dp.rf.rf\[27\]\[9\] _01484_ _01485_ _02460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06747_ dp.rf.rf\[16\]\[9\] dp.rf.rf\[17\]\[9\] dp.rf.rf\[18\]\[9\]
+ dp.rf.rf\[19\]\[9\] _01484_ _01485_ _02461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06748_ _02460_ _02461_ _01394_ _02462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06749_ dp.rf.rf\[28\]\[9\] dp.rf.rf\[29\]\[9\] dp.rf.rf\[30\]\[9\]
+ dp.rf.rf\[31\]\[9\] _01484_ _01485_ _02463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06750_ dp.rf.rf\[20\]\[9\] dp.rf.rf\[21\]\[9\] dp.rf.rf\[22\]\[9\]
+ dp.rf.rf\[23\]\[9\] _01484_ _02232_ _02464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06751_ _02463_ _02464_ _01394_ _02465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06752_ _02462_ _02465_ _01478_ _02466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06753_ dp.rf.rf\[4\]\[9\] dp.rf.rf\[5\]\[9\] dp.rf.rf\[6\]\[9\]
+ dp.rf.rf\[7\]\[9\] net261 _01549_ _02467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06754_ dp.rf.rf\[0\]\[9\] dp.rf.rf\[1\]\[9\] dp.rf.rf\[2\]\[9\]
+ dp.rf.rf\[3\]\[9\] net261 _01549_ _02468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06755_ _02467_ _02468_ _01668_ _02469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06756_ _01677_ _02469_ _02470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06757_ dp.rf.rf\[12\]\[9\] dp.rf.rf\[13\]\[9\] dp.rf.rf\[14\]\[9\]
+ dp.rf.rf\[15\]\[9\] net261 _01549_ _02471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06758_ dp.rf.rf\[8\]\[9\] dp.rf.rf\[9\]\[9\] dp.rf.rf\[10\]\[9\]
+ dp.rf.rf\[11\]\[9\] _01098_ _01554_ _02472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06759_ _02471_ _02472_ _01668_ _02473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06760_ _01672_ _02473_ _02474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06761_ _01608_ _02470_ _02474_ _02475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_06762_ _01656_ _02466_ _02475_ _02476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_06763_ _02476_ _02477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_06764_ _05114_ _02477_ _01289_ _02478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06765_ _02478_ _02229_ _05009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_06766_ _05009_ _05013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06767_ dp.rf.rf\[8\]\[9\] dp.rf.rf\[9\]\[9\] dp.rf.rf\[12\]\[9\]
+ dp.rf.rf\[13\]\[9\] _01136_ _01169_ _02479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06768_ dp.rf.rf\[10\]\[9\] dp.rf.rf\[11\]\[9\] _01135_ _02480_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06769_ _02480_ _02481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06770_ dp.rf.rf\[14\]\[9\] dp.rf.rf\[15\]\[9\] _01427_ _02482_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06771_ _01196_ _02482_ _02483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06772_ _01344_ _02481_ _02483_ _01241_ _02484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_06773_ _01173_ _02479_ _02484_ _01176_ _02485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_06774_ dp.rf.rf\[2\]\[9\] dp.rf.rf\[3\]\[9\] dp.rf.rf\[6\]\[9\]
+ dp.rf.rf\[7\]\[9\] _01179_ _01209_ _02486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06775_ _01119_ _02486_ _02487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06776_ dp.rf.rf\[1\]\[9\] dp.rf.rf\[5\]\[9\] _01144_ _02488_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06777_ dp.rf.rf\[4\]\[9\] _01496_ _02488_ _01636_ _01241_
+ _02489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06778_ _01854_ _02487_ _02489_ _02490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06779_ dp.rf.rf\[18\]\[9\] dp.rf.rf\[19\]\[9\] dp.rf.rf\[22\]\[9\]
+ dp.rf.rf\[23\]\[9\] _01121_ _01432_ _02491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06780_ dp.rf.rf\[16\]\[9\] dp.rf.rf\[17\]\[9\] dp.rf.rf\[20\]\[9\]
+ dp.rf.rf\[21\]\[9\] _01121_ _01432_ _02492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06781_ _02491_ _02492_ _01372_ _02493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06782_ _01178_ _02493_ _01207_ _02494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06783_ dp.rf.rf\[24\]\[9\] dp.rf.rf\[25\]\[9\] dp.rf.rf\[28\]\[9\]
+ dp.rf.rf\[29\]\[9\] _01645_ _01578_ _02495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06784_ dp.rf.rf\[26\]\[9\] dp.rf.rf\[27\]\[9\] _01582_ _02496_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06785_ _02496_ _02497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06786_ dp.rf.rf\[30\]\[9\] dp.rf.rf\[31\]\[9\] _01179_ _02498_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06787_ _01182_ _02498_ _02499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06788_ _01224_ _02497_ _02499_ _01506_ _02500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_06789_ _01576_ _02495_ _02500_ _01237_ _02501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_06790_ _02490_ _02485_ _01589_ _02494_ _02501_ _05008_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_06791_ net184 _05012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_06792_ net17 _02409_ _05110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06793_ dp.rf.rf\[28\]\[8\] dp.rf.rf\[29\]\[8\] dp.rf.rf\[30\]\[8\]
+ dp.rf.rf\[31\]\[8\] _01548_ _01550_ _02502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06794_ dp.rf.rf\[20\]\[8\] dp.rf.rf\[21\]\[8\] dp.rf.rf\[22\]\[8\]
+ dp.rf.rf\[23\]\[8\] _01548_ _01550_ _02503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06795_ dp.rf.rf\[24\]\[8\] dp.rf.rf\[25\]\[8\] dp.rf.rf\[26\]\[8\]
+ dp.rf.rf\[27\]\[8\] _01553_ _01555_ _02504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06796_ dp.rf.rf\[16\]\[8\] dp.rf.rf\[17\]\[8\] dp.rf.rf\[18\]\[8\]
+ dp.rf.rf\[19\]\[8\] _01548_ _01550_ _02505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06797_ _02502_ _02503_ _02504_ _02505_ _01272_ _01669_ _02506_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_06798_ dp.rf.rf\[12\]\[8\] dp.rf.rf\[13\]\[8\] dp.rf.rf\[14\]\[8\]
+ dp.rf.rf\[15\]\[8\] _02175_ _02176_ _02507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06799_ dp.rf.rf\[8\]\[8\] dp.rf.rf\[9\]\[8\] dp.rf.rf\[10\]\[8\]
+ dp.rf.rf\[11\]\[8\] _02175_ _02176_ _02508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06800_ _02507_ _02508_ _01779_ _02509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06801_ dp.rf.rf\[4\]\[8\] dp.rf.rf\[5\]\[8\] dp.rf.rf\[6\]\[8\]
+ dp.rf.rf\[7\]\[8\] _01266_ _01262_ _02510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06802_ dp.rf.rf\[0\]\[8\] dp.rf.rf\[1\]\[8\] dp.rf.rf\[2\]\[8\]
+ dp.rf.rf\[3\]\[8\] _01266_ _01262_ _02511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06803_ _02510_ _02511_ _01668_ _02512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06804_ _01677_ _02512_ _02513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06805_ _01607_ _02513_ _02514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06806_ _01656_ _02506_ _02509_ _01672_ _02514_ _02515_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_06807_ _02515_ _02516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_06808_ _05110_ _02516_ _01289_ _02517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06809_ _02517_ _02229_ _05017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_06810_ _05017_ _05021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06811_ dp.rf.rf\[14\]\[8\] dp.rf.rf\[15\]\[8\] _01179_ _02518_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06812_ _02518_ _02519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06813_ _01578_ _02519_ _01151_ _02520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06814_ dp.rf.rf\[10\]\[8\] _01154_ _01155_ _01034_ _02521_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_06815_ dp.rf.rf\[10\]\[8\] _02522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06816_ _01028_ _01153_ _02521_ _01520_ _02522_ _02523_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_06817_ dp.rf.rf\[11\]\[8\] _01225_ _02524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06818_ _01164_ _01166_ _02523_ _02524_ _02525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_06819_ dp.rf.rf\[8\]\[8\] dp.rf.rf\[9\]\[8\] dp.rf.rf\[12\]\[8\]
+ dp.rf.rf\[13\]\[8\] _01508_ _01145_ _02526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06820_ _02520_ _02525_ _02526_ _01889_ _01176_ _02527_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_06821_ dp.rf.rf\[2\]\[8\] dp.rf.rf\[3\]\[8\] dp.rf.rf\[6\]\[8\]
+ dp.rf.rf\[7\]\[8\] _01179_ _01209_ _02528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06822_ _01529_ _02528_ _02529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06823_ dp.rf.rf\[1\]\[8\] dp.rf.rf\[5\]\[8\] _01200_ _02530_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06824_ dp.rf.rf\[4\]\[8\] _01496_ _02530_ _01636_ _01241_
+ _02531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06825_ _01854_ _02529_ _02531_ _02532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06826_ dp.rf.rf\[26\]\[8\] dp.rf.rf\[27\]\[8\] dp.rf.rf\[30\]\[8\]
+ dp.rf.rf\[31\]\[8\] _01147_ _01432_ _02533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06827_ dp.rf.rf\[24\]\[8\] dp.rf.rf\[25\]\[8\] dp.rf.rf\[28\]\[8\]
+ dp.rf.rf\[29\]\[8\] _01147_ _01381_ _02534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06828_ _02533_ _02534_ _01372_ _02535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06829_ _01415_ _02535_ _01207_ _02536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06830_ dp.rf.rf\[22\]\[8\] dp.rf.rf\[23\]\[8\] _01160_ _02537_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06831_ _02537_ _02538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06832_ _01146_ _02538_ _02019_ _02539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06833_ dp.rf.rf\[18\]\[8\] _01154_ _01155_ _01090_ _02540_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_06834_ dp.rf.rf\[18\]\[8\] _02541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06835_ _01028_ _01185_ _02540_ _01345_ _02541_ _02542_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_06836_ dp.rf.rf\[19\]\[8\] _01136_ _02543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06837_ _01164_ _01166_ _02542_ _02543_ _02544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_06838_ dp.rf.rf\[17\]\[8\] dp.rf.rf\[21\]\[8\] _01457_ _02545_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06839_ _01442_ _02545_ _02546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06840_ dp.rf.rf\[20\]\[8\] _01569_ _01230_ _01172_ _02547_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06841_ _02546_ _02547_ _01337_ _01435_ _02548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06842_ dp.rf.rf\[16\]\[8\] _02549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06843_ _02549_ _01737_ _02550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06844_ _02539_ _02544_ _02548_ _02550_ _02551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_06845_ _02532_ _02527_ _01589_ _02536_ _02551_ _05016_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_06846_ net170 _05020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_06847_ dp.rf.rf\[24\]\[7\] dp.rf.rf\[25\]\[7\] dp.rf.rf\[26\]\[7\]
+ dp.rf.rf\[27\]\[7\] _02175_ _02176_ _02552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06848_ dp.rf.rf\[16\]\[7\] dp.rf.rf\[17\]\[7\] dp.rf.rf\[18\]\[7\]
+ dp.rf.rf\[19\]\[7\] _02175_ _02176_ _02553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06849_ dp.rf.rf\[28\]\[7\] dp.rf.rf\[29\]\[7\] dp.rf.rf\[30\]\[7\]
+ dp.rf.rf\[31\]\[7\] _01928_ _01929_ _02554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06850_ dp.rf.rf\[20\]\[7\] dp.rf.rf\[21\]\[7\] dp.rf.rf\[22\]\[7\]
+ dp.rf.rf\[23\]\[7\] _02175_ _02176_ _02555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06851_ _02552_ _02553_ _02554_ _02555_ _01666_ _01478_ _02556_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06852_ dp.rf.rf\[8\]\[7\] dp.rf.rf\[9\]\[7\] dp.rf.rf\[10\]\[7\]
+ dp.rf.rf\[11\]\[7\] _02175_ _02176_ _02557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06853_ dp.rf.rf\[0\]\[7\] dp.rf.rf\[1\]\[7\] dp.rf.rf\[2\]\[7\]
+ dp.rf.rf\[3\]\[7\] _02175_ _02176_ _02558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06854_ dp.rf.rf\[12\]\[7\] dp.rf.rf\[13\]\[7\] dp.rf.rf\[14\]\[7\]
+ dp.rf.rf\[15\]\[7\] _01928_ _01929_ _02559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06855_ dp.rf.rf\[4\]\[7\] dp.rf.rf\[5\]\[7\] dp.rf.rf\[6\]\[7\]
+ dp.rf.rf\[7\]\[7\] _01928_ _02176_ _02560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06856_ _02557_ _02558_ _02559_ _02560_ _01666_ _01400_ _02561_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06857_ _02556_ _02561_ _01058_ _02562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06858_ _01608_ _02562_ net157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_06859_ net16 _02409_ _05106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06860_ net157 _05106_ _01605_ _02563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06861_ _02229_ _02563_ _05025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_06862_ _05025_ _05029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06863_ dp.rf.rf\[2\]\[7\] dp.rf.rf\[3\]\[7\] dp.rf.rf\[6\]\[7\]
+ dp.rf.rf\[7\]\[7\] _01363_ _01364_ _02564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06864_ _01362_ _02564_ _02565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06865_ dp.rf.rf\[1\]\[7\] dp.rf.rf\[5\]\[7\] _01138_ _02566_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06866_ dp.rf.rf\[4\]\[7\] _01368_ _02566_ _01371_ _01372_
+ _02567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06867_ _01854_ _02565_ _02567_ _02568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_06868_ dp.rf.rf\[10\]\[7\] dp.rf.rf\[11\]\[7\] dp.rf.rf\[14\]\[7\]
+ dp.rf.rf\[15\]\[7\] _01128_ _01200_ _02569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06869_ dp.rf.rf\[8\]\[7\] dp.rf.rf\[9\]\[7\] dp.rf.rf\[12\]\[7\]
+ dp.rf.rf\[13\]\[7\] _01128_ _01200_ _02570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06870_ _02569_ _02570_ _01218_ _02571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06871_ _01176_ _02571_ _02572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_06872_ _01376_ _02568_ _02572_ _02573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_06873_ dp.rf.rf\[22\]\[7\] dp.rf.rf\[23\]\[7\] _01600_ _02574_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06874_ dp.rf.rf\[18\]\[7\] dp.rf.rf\[19\]\[7\] _01212_ _02575_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06875_ _01568_ _02574_ _02575_ _01593_ _01456_ _02576_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06876_ dp.rf.rf\[20\]\[7\] _02577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06877_ dp.rf.rf\[17\]\[7\] dp.rf.rf\[21\]\[7\] _01123_ _02578_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06878_ _01328_ _02578_ _02579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06879_ _02577_ _01327_ _02579_ _01529_ _02580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_06880_ dp.rf.rf\[16\]\[7\] _01356_ _02580_ net227 _02581_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_06881_ dp.rf.rf\[30\]\[7\] dp.rf.rf\[31\]\[7\] _01212_ _02582_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06882_ dp.rf.rf\[26\]\[7\] net200 _02583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06883_ dp.rf.rf\[27\]\[7\] _01532_ _02584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06884_ _01344_ _02584_ _02585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06885_ _01339_ _02582_ _02583_ _02585_ _01334_ _02586_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_06886_ dp.rf.rf\[24\]\[7\] dp.rf.rf\[25\]\[7\] dp.rf.rf\[28\]\[7\]
+ dp.rf.rf\[29\]\[7\] _01340_ _01169_ _02587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06887_ _01173_ _02587_ _01176_ _02588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06888_ _02576_ _02581_ _02586_ _02588_ net209 _02589_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_06889_ _02589_ _02573_ _05024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_06890_ _05024_ _05028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_06891_ dp.rf.rf\[24\]\[6\] dp.rf.rf\[25\]\[6\] dp.rf.rf\[26\]\[6\]
+ dp.rf.rf\[27\]\[6\] _01267_ _01263_ _02590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06892_ dp.rf.rf\[16\]\[6\] dp.rf.rf\[17\]\[6\] dp.rf.rf\[18\]\[6\]
+ dp.rf.rf\[19\]\[6\] _01267_ _01268_ _02591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06893_ _02590_ _02591_ _01282_ _02592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06894_ dp.rf.rf\[28\]\[6\] dp.rf.rf\[29\]\[6\] dp.rf.rf\[30\]\[6\]
+ dp.rf.rf\[31\]\[6\] _01267_ _01268_ _02593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06895_ dp.rf.rf\[20\]\[6\] dp.rf.rf\[21\]\[6\] dp.rf.rf\[22\]\[6\]
+ dp.rf.rf\[23\]\[6\] _01267_ _01268_ _02594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06896_ _02593_ _02594_ _01282_ _02595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06897_ _02592_ _02595_ _01478_ _02596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06898_ dp.rf.rf\[8\]\[6\] dp.rf.rf\[9\]\[6\] dp.rf.rf\[10\]\[6\]
+ dp.rf.rf\[11\]\[6\] _01279_ _01276_ _02597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06899_ dp.rf.rf\[0\]\[6\] dp.rf.rf\[1\]\[6\] dp.rf.rf\[2\]\[6\]
+ dp.rf.rf\[3\]\[6\] _01279_ _01276_ _02598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06900_ _02597_ _02598_ _01282_ _02599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06901_ dp.rf.rf\[12\]\[6\] dp.rf.rf\[13\]\[6\] dp.rf.rf\[14\]\[6\]
+ dp.rf.rf\[15\]\[6\] _01471_ _01316_ _02600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06902_ dp.rf.rf\[4\]\[6\] dp.rf.rf\[5\]\[6\] dp.rf.rf\[6\]\[6\]
+ dp.rf.rf\[7\]\[6\] _01471_ _01316_ _02601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06903_ _02600_ _02601_ _01282_ _02602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06904_ _02599_ _02602_ _01478_ _02603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06905_ _01111_ _02596_ _02603_ _01112_ _02604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_06906_ _02604_ net156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06907_ net15 _02409_ _05102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06908_ net156 _05102_ _01605_ _02605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06909_ _02229_ _02605_ _05033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_06910_ _05033_ _05037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06911_ dp.rf.rf\[17\]\[6\] dp.rf.rf\[21\]\[6\] _01145_ _02606_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06912_ _01693_ _02606_ _02607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06913_ dp.rf.rf\[16\]\[6\] _01600_ _01145_ _02608_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or3_2
X_06914_ dp.rf.rf\[20\]\[6\] _01504_ _01339_ _02608_ _02609_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06915_ _01530_ _02607_ _02609_ _01415_ _02610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06916_ dp.rf.rf\[18\]\[6\] dp.rf.rf\[19\]\[6\] dp.rf.rf\[22\]\[6\]
+ dp.rf.rf\[23\]\[6\] _01157_ _01139_ _02611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06917_ _01456_ _01244_ _01435_ _02611_ _02612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_06918_ net205 _02610_ _02612_ _02613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06919_ dp.rf.rf\[30\]\[6\] dp.rf.rf\[31\]\[6\] _01600_ _02614_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06920_ _02614_ _02615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06921_ _01211_ _02615_ _02019_ _02616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06922_ dp.rf.rf\[26\]\[6\] _01154_ _01155_ _01090_ _02617_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_06923_ dp.rf.rf\[26\]\[6\] _02618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06924_ _01028_ _01185_ _02617_ _01569_ _02618_ _02619_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_06925_ dp.rf.rf\[27\]\[6\] _01645_ _02620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06926_ _01164_ _01166_ _02619_ _02620_ _02621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_06927_ dp.rf.rf\[24\]\[6\] dp.rf.rf\[25\]\[6\] dp.rf.rf\[28\]\[6\]
+ dp.rf.rf\[29\]\[6\] _01569_ _01146_ _02622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06928_ _02616_ _02621_ _02622_ _01576_ _01580_ _02623_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_06929_ dp.rf.rf\[10\]\[6\] dp.rf.rf\[11\]\[6\] dp.rf.rf\[14\]\[6\]
+ dp.rf.rf\[15\]\[6\] _01136_ _01139_ _02624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06930_ dp.rf.rf\[8\]\[6\] dp.rf.rf\[9\]\[6\] dp.rf.rf\[12\]\[6\]
+ dp.rf.rf\[13\]\[6\] _01136_ _01139_ _02625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06931_ _02624_ _02625_ _01889_ _02626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06932_ dp.rf.rf\[4\]\[6\] _01504_ _01505_ _02627_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_06933_ dp.rf.rf\[1\]\[6\] dp.rf.rf\[5\]\[6\] _01432_ _02628_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06934_ _01422_ _02628_ _02629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06935_ dp.rf.rf\[2\]\[6\] dp.rf.rf\[3\]\[6\] dp.rf.rf\[6\]\[6\]
+ dp.rf.rf\[7\]\[6\] _01160_ _01145_ _02630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06936_ _01456_ _02630_ _02631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06937_ _01530_ _02627_ _02629_ _02631_ _02632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06938_ _01580_ _02626_ _02632_ _01541_ _01376_ _02633_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_06939_ _02613_ _02623_ _02633_ _05032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_06940_ _05032_ _05036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_06941_ dp.rf.rf\[24\]\[5\] dp.rf.rf\[25\]\[5\] dp.rf.rf\[26\]\[5\]
+ dp.rf.rf\[27\]\[5\] _01098_ _01554_ _02634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06942_ dp.rf.rf\[16\]\[5\] dp.rf.rf\[17\]\[5\] dp.rf.rf\[18\]\[5\]
+ dp.rf.rf\[19\]\[5\] _01098_ _01554_ _02635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06943_ dp.rf.rf\[28\]\[5\] dp.rf.rf\[29\]\[5\] dp.rf.rf\[30\]\[5\]
+ dp.rf.rf\[31\]\[5\] _01098_ _01554_ _02636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06944_ dp.rf.rf\[20\]\[5\] dp.rf.rf\[21\]\[5\] dp.rf.rf\[22\]\[5\]
+ dp.rf.rf\[23\]\[5\] _01098_ _01554_ _02637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06945_ _02634_ _02635_ _02636_ _02637_ _01398_ net194 _02638_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06946_ dp.rf.rf\[8\]\[5\] dp.rf.rf\[9\]\[5\] dp.rf.rf\[10\]\[5\]
+ dp.rf.rf\[11\]\[5\] _01098_ _01554_ _02639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06947_ dp.rf.rf\[0\]\[5\] dp.rf.rf\[1\]\[5\] dp.rf.rf\[2\]\[5\]
+ dp.rf.rf\[3\]\[5\] _01098_ _01554_ _02640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06948_ dp.rf.rf\[12\]\[5\] dp.rf.rf\[13\]\[5\] dp.rf.rf\[14\]\[5\]
+ dp.rf.rf\[15\]\[5\] _01260_ _02326_ _02641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06949_ dp.rf.rf\[4\]\[5\] dp.rf.rf\[5\]\[5\] dp.rf.rf\[6\]\[5\]
+ dp.rf.rf\[7\]\[5\] _01098_ _01554_ _02642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06950_ _02639_ _02640_ _02641_ _02642_ _01271_ net194 _02643_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06951_ _02638_ _02643_ _01058_ _02644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06952_ net192 _02644_ net155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_06953_ net14 _02409_ _05098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06954_ net155 _05098_ _01605_ _02645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06955_ _02229_ _02645_ _05041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_06956_ _05041_ _05045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06957_ dp.rf.rf\[17\]\[5\] dp.rf.rf\[21\]\[5\] _01200_ _02646_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06958_ _01636_ _02646_ _02647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06959_ dp.rf.rf\[20\]\[5\] _01600_ _01196_ _01193_ _02648_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06960_ _02647_ _02648_ _01228_ _01192_ _02649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06961_ dp.rf.rf\[16\]\[5\] _02650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06962_ _02650_ _01736_ _02651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06963_ dp.rf.rf\[18\]\[5\] dp.rf.rf\[19\]\[5\] _01186_ _02652_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06964_ _02652_ _02653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06965_ dp.rf.rf\[22\]\[5\] dp.rf.rf\[23\]\[5\] _01427_ _02654_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06966_ _01182_ _02654_ _01118_ _02655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06967_ _01344_ _02653_ _02655_ _02656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06968_ _02649_ _02651_ _02656_ _02657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_06969_ dp.rf.rf\[26\]\[5\] dp.rf.rf\[27\]\[5\] dp.rf.rf\[30\]\[5\]
+ dp.rf.rf\[31\]\[5\] _01427_ _01168_ _02658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06970_ dp.rf.rf\[24\]\[5\] dp.rf.rf\[25\]\[5\] dp.rf.rf\[28\]\[5\]
+ dp.rf.rf\[29\]\[5\] _01427_ _01168_ _02659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06971_ _02658_ _02659_ _01218_ _02660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06972_ _01337_ _02660_ _02661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06973_ dp.rf.rf\[4\]\[5\] _01645_ _01182_ _02662_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_06974_ dp.rf.rf\[1\]\[5\] dp.rf.rf\[5\]\[5\] _01144_ _02663_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06975_ _01371_ _02663_ _02664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_06976_ dp.rf.rf\[2\]\[5\] dp.rf.rf\[3\]\[5\] dp.rf.rf\[6\]\[5\]
+ dp.rf.rf\[7\]\[5\] _01194_ _01369_ _02665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06977_ _01213_ _02665_ _02666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06978_ _01416_ _02662_ _02664_ _02666_ _02667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_06979_ dp.rf.rf\[10\]\[5\] dp.rf.rf\[11\]\[5\] dp.rf.rf\[14\]\[5\]
+ dp.rf.rf\[15\]\[5\] _01194_ _01138_ _02668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06980_ dp.rf.rf\[8\]\[5\] dp.rf.rf\[9\]\[5\] dp.rf.rf\[12\]\[5\]
+ dp.rf.rf\[13\]\[5\] _01194_ _01138_ _02669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06981_ _02668_ _02669_ _01218_ _02670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06982_ _01541_ _02667_ _02670_ _01176_ _01376_ _02671_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_06983_ net209 _02657_ _02661_ _02671_ _05040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_06984_ _05040_ _05044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_06985_ net3 _02672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_06986_ _02672_ net94 _02673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_06987_ _01111_ _01291_ _01109_ _01078_ _02674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_06988_ _01438_ net231 _01081_ _02675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_06989_ _01037_ net21 _01090_ _02676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_06990_ _02672_ _01064_ _02676_ _02677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06991_ _02675_ _02677_ _02678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_06992_ _02673_ _02674_ _02678_ _05094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_06993_ dp.rf.rf\[4\]\[4\] dp.rf.rf\[5\]\[4\] dp.rf.rf\[6\]\[4\]
+ dp.rf.rf\[7\]\[4\] _01484_ _02232_ _02679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06994_ dp.rf.rf\[0\]\[4\] dp.rf.rf\[1\]\[4\] dp.rf.rf\[2\]\[4\]
+ dp.rf.rf\[3\]\[4\] _01661_ _02232_ _02680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06995_ _02679_ _02680_ _01779_ _02681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_06996_ _01677_ _02681_ _01607_ _02682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_06997_ _01778_ _02683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_06998_ dp.rf.rf\[22\]\[4\] dp.rf.rf\[23\]\[4\] dp.rf.rf\[30\]\[4\]
+ dp.rf.rf\[31\]\[4\] _01402_ _01671_ _02684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_06999_ dp.rf.rf\[20\]\[4\] dp.rf.rf\[21\]\[4\] dp.rf.rf\[28\]\[4\]
+ dp.rf.rf\[29\]\[4\] _01402_ _01671_ _02685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07000_ _02684_ _02685_ _01766_ _02686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07001_ dp.rf.rf\[24\]\[4\] dp.rf.rf\[25\]\[4\] dp.rf.rf\[26\]\[4\]
+ dp.rf.rf\[27\]\[4\] _01657_ _01408_ _02687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07002_ dp.rf.rf\[16\]\[4\] dp.rf.rf\[17\]\[4\] dp.rf.rf\[18\]\[4\]
+ dp.rf.rf\[19\]\[4\] _01657_ _01408_ _02688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07003_ _02687_ _02688_ _01398_ _02689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07004_ _01037_ _01779_ _02690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07005_ _02683_ _02686_ _02689_ _02690_ _02691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_07006_ dp.rf.rf\[12\]\[4\] dp.rf.rf\[13\]\[4\] dp.rf.rf\[14\]\[4\]
+ dp.rf.rf\[15\]\[4\] _01661_ _02232_ _02692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07007_ dp.rf.rf\[8\]\[4\] dp.rf.rf\[9\]\[4\] dp.rf.rf\[10\]\[4\]
+ dp.rf.rf\[11\]\[4\] _01661_ _02232_ _02693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07008_ _02692_ _02693_ _01779_ _02694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07009_ _01672_ _02694_ _02695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07010_ _02682_ _02691_ _02695_ _02696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_07011_ _02696_ net154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07012_ _05094_ net154 _01289_ _02697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
Xrebuffer22 _05008_ net181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07014_ _02697_ _02699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07015_ _02229_ _02699_ _05049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07016_ _05049_ _05053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07017_ dp.rf.rf\[2\]\[4\] dp.rf.rf\[3\]\[4\] dp.rf.rf\[6\]\[4\]
+ dp.rf.rf\[7\]\[4\] _01225_ _01381_ _02700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07018_ _01119_ _02700_ _02701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07019_ dp.rf.rf\[4\]\[4\] _02702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07020_ dp.rf.rf\[1\]\[4\] dp.rf.rf\[5\]\[4\] _01200_ _02703_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07021_ _01636_ _02703_ _02704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07022_ _02702_ _01327_ _02704_ _01529_ _02705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_07023_ dp.rf.rf\[10\]\[4\] dp.rf.rf\[11\]\[4\] dp.rf.rf\[14\]\[4\]
+ dp.rf.rf\[15\]\[4\] _01120_ _01129_ _02706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07024_ dp.rf.rf\[8\]\[4\] dp.rf.rf\[9\]\[4\] dp.rf.rf\[12\]\[4\]
+ dp.rf.rf\[13\]\[4\] _01120_ _01129_ _02707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07025_ _02706_ _02707_ _01171_ _02708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07026_ _01199_ _02708_ _02709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07027_ _01541_ _02701_ _02705_ _02709_ _02710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07028_ dp.rf.rf\[17\]\[4\] dp.rf.rf\[21\]\[4\] _01138_ _02711_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07029_ _01442_ _02711_ _02712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07030_ dp.rf.rf\[20\]\[4\] _01577_ _01182_ _01241_ _02713_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07031_ _02712_ _02713_ _01228_ net168 _02714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07032_ dp.rf.rf\[16\]\[4\] _02715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07033_ _02715_ _01737_ _02716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07034_ dp.rf.rf\[18\]\[4\] dp.rf.rf\[19\]\[4\] _01225_ _02717_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07035_ _02717_ _02718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07036_ dp.rf.rf\[22\]\[4\] dp.rf.rf\[23\]\[4\] _01135_ _02719_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07037_ _01182_ _02719_ _02720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07038_ _01224_ _02718_ _02720_ _01151_ _02721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_07039_ _02714_ _02716_ _02721_ _02722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07040_ dp.rf.rf\[26\]\[4\] dp.rf.rf\[27\]\[4\] dp.rf.rf\[30\]\[4\]
+ dp.rf.rf\[31\]\[4\] _01186_ _01457_ _02723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07041_ dp.rf.rf\[24\]\[4\] dp.rf.rf\[25\]\[4\] dp.rf.rf\[28\]\[4\]
+ dp.rf.rf\[29\]\[4\] _01186_ _01457_ _02724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07042_ _02723_ _02724_ _01241_ _02725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07043_ _01415_ _02725_ _01206_ _02726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07044_ _01589_ _02710_ _02722_ _02726_ _05048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_07045_ _05048_ _05052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_07046_ net21 _01034_ _02727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07047_ net2 _01035_ _02727_ _01761_ _02728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07048_ _01107_ _02728_ _02729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07049_ _01028_ _01029_ _02730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07050_ net230 _01035_ _01294_ net24 _02731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07051_ _02730_ _02731_ _01078_ _02732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07052_ net2 _01078_ _02675_ _02677_ _02733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07053_ _01030_ _01095_ _01245_ _01761_ _02734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_07054_ _02732_ _02733_ _02734_ net236 _02735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_07055_ _02729_ _02735_ _05088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07056_ dp.rf.rf\[24\]\[3\] dp.rf.rf\[25\]\[3\] dp.rf.rf\[26\]\[3\]
+ dp.rf.rf\[27\]\[3\] _01275_ _01268_ _02736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07057_ dp.rf.rf\[16\]\[3\] dp.rf.rf\[17\]\[3\] dp.rf.rf\[18\]\[3\]
+ dp.rf.rf\[19\]\[3\] _01267_ _01268_ _02737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07058_ dp.rf.rf\[28\]\[3\] dp.rf.rf\[29\]\[3\] dp.rf.rf\[30\]\[3\]
+ dp.rf.rf\[31\]\[3\] _01279_ _01276_ _02738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07059_ dp.rf.rf\[20\]\[3\] dp.rf.rf\[21\]\[3\] dp.rf.rf\[22\]\[3\]
+ dp.rf.rf\[23\]\[3\] _01275_ _01268_ _02739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07060_ _02736_ _02737_ _02738_ _02739_ _01282_ net194 _02740_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07061_ dp.rf.rf\[8\]\[3\] dp.rf.rf\[9\]\[3\] dp.rf.rf\[10\]\[3\]
+ dp.rf.rf\[11\]\[3\] _01275_ _01276_ _02741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07062_ dp.rf.rf\[0\]\[3\] dp.rf.rf\[1\]\[3\] dp.rf.rf\[2\]\[3\]
+ dp.rf.rf\[3\]\[3\] _01275_ _01268_ _02742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07063_ dp.rf.rf\[12\]\[3\] dp.rf.rf\[13\]\[3\] dp.rf.rf\[14\]\[3\]
+ dp.rf.rf\[15\]\[3\] _01279_ _01276_ _02743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07064_ dp.rf.rf\[4\]\[3\] dp.rf.rf\[5\]\[3\] dp.rf.rf\[6\]\[3\]
+ dp.rf.rf\[7\]\[3\] _01279_ _01276_ _02744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07065_ _02741_ _02742_ _02743_ _02744_ _01282_ net194 _02745_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07066_ _02740_ _02745_ _01058_ _02746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07067_ _01608_ _02746_ net153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_07068_ _02735_ _02729_ _01093_ _02747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07069_ net153 _01259_ _02748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_07070_ _02747_ _02748_ _02749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_07071_ _02749_ _02750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xsplit9 _01077_ net168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xsplit28 net253 net187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_07074_ _02229_ _02750_ _05057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07075_ _05057_ _05061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07076_ dp.rf.rf\[30\]\[3\] dp.rf.rf\[31\]\[3\] _01212_ _02753_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07077_ dp.rf.rf\[26\]\[3\] _01626_ _02754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07078_ dp.rf.rf\[27\]\[3\] _01532_ _02755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07079_ _01344_ _02755_ _02756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07080_ _01339_ _02753_ _02754_ _02756_ _01334_ _02757_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_07081_ dp.rf.rf\[24\]\[3\] dp.rf.rf\[25\]\[3\] dp.rf.rf\[28\]\[3\]
+ dp.rf.rf\[29\]\[3\] _01340_ _01169_ _02758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07082_ _01173_ _02758_ net209 _02759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07083_ _02757_ _02759_ _02760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07084_ dp.rf.rf\[9\]\[3\] dp.rf.rf\[13\]\[3\] _01369_ _02761_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07085_ dp.rf.rf\[12\]\[3\] _01368_ _02761_ _01442_ _01430_
+ _02762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_07086_ _01141_ _01130_ _02763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07087_ _01077_ _02763_ _02764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07088_ dp.rf.rf\[8\]\[3\] _02765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07089_ net267 _02762_ _02764_ _02765_ _02766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07090_ dp.rf.rf\[11\]\[3\] _01340_ _02767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07091_ _01578_ _01077_ _01626_ dp.rf.rf\[10\]\[3\] _02767_
+ _02768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_07092_ dp.rf.rf\[14\]\[3\] dp.rf.rf\[15\]\[3\] _01160_ _02769_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07093_ _01505_ _02769_ _02770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07094_ _01500_ _02768_ _02770_ _02771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_07095_ _02766_ _02771_ _01385_ _02772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07096_ _01530_ _02763_ _01361_ _02773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07097_ dp.rf.rf\[6\]\[3\] dp.rf.rf\[7\]\[3\] _01508_ _02774_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07098_ _01505_ _02774_ _02775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07099_ dp.rf.rf\[3\]\[3\] _01428_ _02776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07100_ _01533_ _01192_ _01626_ dp.rf.rf\[2\]\[3\] _02776_
+ _02777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_07101_ _02019_ _02775_ _02777_ _02778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_07102_ dp.rf.rf\[0\]\[3\] _02779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07103_ dp.rf.rf\[1\]\[3\] dp.rf.rf\[5\]\[3\] _01168_ _02780_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07104_ dp.rf.rf\[4\]\[3\] _01496_ _02780_ _01371_ _01172_
+ _02781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_07105_ _02779_ _02764_ _02781_ net267 _02782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07106_ dp.rf.rf\[19\]\[3\] _01508_ _02783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07107_ _01210_ _01192_ _01626_ dp.rf.rf\[18\]\[3\] _02783_
+ _02784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_07108_ dp.rf.rf\[22\]\[3\] dp.rf.rf\[23\]\[3\] _01363_ _02785_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07109_ _01505_ _02785_ _02786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07110_ dp.rf.rf\[16\]\[3\] dp.rf.rf\[17\]\[3\] dp.rf.rf\[20\]\[3\]
+ dp.rf.rf\[21\]\[3\] _01531_ _01443_ _02787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07111_ _01430_ _02787_ net207 _02788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07112_ _02019_ _02784_ _02786_ _02788_ _02789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07113_ _02778_ _02782_ _02789_ _02790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07114_ _02760_ _02772_ _02790_ _02773_ _05056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_07115_ _05056_ _05060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_07116_ net27 _01035_ _02727_ _01047_ _02791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07117_ _01107_ _02791_ _02792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07118_ net27 _02793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_07119_ _02793_ _01245_ _01107_ _02728_ _02794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_07120_ _01312_ _02794_ _02732_ _02795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07121_ _01109_ _02795_ _02796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07122_ _02792_ _02796_ _05084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07123_ dp.rf.rf\[24\]\[2\] dp.rf.rf\[25\]\[2\] dp.rf.rf\[26\]\[2\]
+ dp.rf.rf\[27\]\[2\] _01260_ _02326_ _02797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07124_ dp.rf.rf\[16\]\[2\] dp.rf.rf\[17\]\[2\] dp.rf.rf\[18\]\[2\]
+ dp.rf.rf\[19\]\[2\] _01260_ _02326_ _02798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07125_ _02797_ _02798_ _01271_ _02799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07126_ dp.rf.rf\[28\]\[2\] dp.rf.rf\[29\]\[2\] dp.rf.rf\[30\]\[2\]
+ dp.rf.rf\[31\]\[2\] _01260_ _02326_ _02800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07127_ dp.rf.rf\[20\]\[2\] dp.rf.rf\[21\]\[2\] dp.rf.rf\[22\]\[2\]
+ dp.rf.rf\[23\]\[2\] _01266_ _02326_ _02801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07128_ _02800_ _02801_ _01271_ _02802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07129_ _02799_ _02802_ net194 _02803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07130_ dp.rf.rf\[8\]\[2\] dp.rf.rf\[9\]\[2\] dp.rf.rf\[10\]\[2\]
+ dp.rf.rf\[11\]\[2\] _01266_ _02326_ _02804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07131_ dp.rf.rf\[0\]\[2\] dp.rf.rf\[1\]\[2\] dp.rf.rf\[2\]\[2\]
+ dp.rf.rf\[3\]\[2\] _01266_ _01262_ _02805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07132_ _02804_ _02805_ _01271_ _02806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07133_ dp.rf.rf\[12\]\[2\] dp.rf.rf\[13\]\[2\] dp.rf.rf\[14\]\[2\]
+ dp.rf.rf\[15\]\[2\] _01266_ _01262_ _02807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07134_ dp.rf.rf\[4\]\[2\] dp.rf.rf\[5\]\[2\] dp.rf.rf\[6\]\[2\]
+ dp.rf.rf\[7\]\[2\] _01266_ _01262_ _02808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07135_ _02807_ _02808_ _01271_ _02809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07136_ _02806_ _02809_ net194 _02810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07137_ _01037_ _02803_ _02810_ _01061_ _02811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_07138_ _02811_ net150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07139_ _02795_ _01109_ _02792_ _01259_ _02812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_07140_ _01259_ _02811_ _02813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_07141_ _02812_ _02813_ _02814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xsplit16 _02816_ net175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07143_ _02814_ _02816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xrebuffer5 _02891_ net164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_07145_ net245 _02816_ _05065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07146_ _05065_ _05069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07147_ dp.rf.rf\[6\]\[2\] dp.rf.rf\[7\]\[2\] _01135_ _02818_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07148_ _02818_ _02819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07149_ _01533_ _02819_ _01151_ _02820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07150_ dp.rf.rf\[2\]\[2\] net10 net1 _01033_ _02821_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_07151_ dp.rf.rf\[2\]\[2\] _02822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07152_ _01028_ _01153_ _02821_ _01147_ _02822_ _02823_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_07153_ dp.rf.rf\[3\]\[2\] _01179_ _02824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07154_ _01163_ _01165_ _02823_ _02824_ _02825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_07155_ dp.rf.rf\[1\]\[2\] dp.rf.rf\[5\]\[2\] _01248_ _02826_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07156_ _01328_ _02826_ _02827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07157_ dp.rf.rf\[4\]\[2\] _01340_ _01162_ _01218_ _02828_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07158_ _02827_ _02828_ _01228_ _01324_ _02829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07159_ dp.rf.rf\[0\]\[2\] _02830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07160_ _02830_ _01736_ _02831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07161_ _02820_ _02825_ _02829_ _02831_ _02832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07162_ dp.rf.rf\[10\]\[2\] dp.rf.rf\[11\]\[2\] dp.rf.rf\[14\]\[2\]
+ dp.rf.rf\[15\]\[2\] _01508_ _01145_ _02833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07163_ dp.rf.rf\[9\]\[2\] dp.rf.rf\[13\]\[2\] _01122_ _02834_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07164_ _01225_ _01133_ _02834_ _02835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07165_ _01128_ net7 _02836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07166_ dp.rf.rf\[8\]\[2\] dp.rf.rf\[12\]\[2\] _01137_ _02837_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07167_ _02836_ _02837_ _02838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07168_ _01175_ _02835_ _02838_ _02839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07169_ _01362_ _02833_ _02839_ _02840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07170_ dp.rf.rf\[22\]\[2\] dp.rf.rf\[23\]\[2\] _01427_ _02841_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07171_ _02841_ _02842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07172_ _01458_ _02842_ _01150_ _02843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07173_ dp.rf.rf\[18\]\[2\] net10 net1 _01033_ _02844_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_07174_ dp.rf.rf\[18\]\[2\] _02845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07175_ _01028_ _01153_ _02844_ _01179_ _02845_ _02846_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_07176_ dp.rf.rf\[19\]\[2\] _01135_ _02847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07177_ _01163_ _01165_ _02846_ _02847_ _02848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_07178_ dp.rf.rf\[17\]\[2\] dp.rf.rf\[21\]\[2\] _01129_ _02849_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07179_ _01190_ _02849_ _02850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07180_ dp.rf.rf\[20\]\[2\] _01160_ _01162_ _01171_ _02851_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07181_ _02850_ _02851_ _01228_ net257 _02852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07182_ dp.rf.rf\[16\]\[2\] _02853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07183_ _02853_ _01736_ _02854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07184_ _02843_ _02848_ _02852_ _02854_ _02855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07185_ dp.rf.rf\[26\]\[2\] dp.rf.rf\[27\]\[2\] dp.rf.rf\[30\]\[2\]
+ dp.rf.rf\[31\]\[2\] _01121_ _01124_ _02856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07186_ dp.rf.rf\[25\]\[2\] dp.rf.rf\[29\]\[2\] _01122_ _02857_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07187_ _01238_ _01133_ _02857_ _02858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07188_ dp.rf.rf\[24\]\[2\] dp.rf.rf\[28\]\[2\] _01122_ _02859_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07189_ _02836_ _02859_ _02860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07190_ _01175_ _02858_ _02860_ _02861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07191_ _01416_ _02856_ _02861_ _02862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07192_ net188 _02832_ _02840_ _02862_ _02855_ _01358_ _05064_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_4
X_07193_ net266 _05068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07194_ _01082_ _01104_ _02863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07195_ _01101_ _01097_ _02030_ _02791_ _01107_ _02864_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_07196_ _02730_ _02731_ _01324_ _01766_ _02865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07197_ _01292_ _02864_ _02865_ _01109_ _02866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_07198_ _02863_ _02866_ _04821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_07199_ dp.rf.rf\[26\]\[1\] dp.rf.rf\[27\]\[1\] _01260_ _02867_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07200_ _01823_ _02867_ _02868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07201_ dp.rf.rf\[18\]\[1\] dp.rf.rf\[19\]\[1\] _01059_ _02869_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07202_ _01103_ _01671_ _02869_ _02870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07203_ dp.rf.rf\[16\]\[1\] dp.rf.rf\[17\]\[1\] _01059_ _02871_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07204_ _02232_ _01671_ _02871_ _02872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07205_ dp.rf.rf\[24\]\[1\] dp.rf.rf\[25\]\[1\] _01059_ _02873_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07206_ _02232_ _01271_ _02873_ _02874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07207_ _02868_ _02870_ _02872_ _02874_ _02875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_07208_ _01057_ _01103_ _01060_ _02876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07209_ dp.rf.rf\[1\]\[1\] dp.rf.rf\[5\]\[1\] dp.rf.rf\[9\]\[1\]
+ dp.rf.rf\[13\]\[1\] _01047_ _01671_ _02877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07210_ dp.rf.rf\[0\]\[1\] dp.rf.rf\[4\]\[1\] dp.rf.rf\[8\]\[1\]
+ dp.rf.rf\[12\]\[1\] net11 _01671_ _02878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07211_ _02877_ _02878_ _01099_ _02879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07212_ dp.rf.rf\[6\]\[1\] dp.rf.rf\[7\]\[1\] dp.rf.rf\[14\]\[1\]
+ dp.rf.rf\[15\]\[1\] _01038_ net12 _02880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07213_ dp.rf.rf\[2\]\[1\] dp.rf.rf\[3\]\[1\] dp.rf.rf\[10\]\[1\]
+ dp.rf.rf\[11\]\[1\] net264 net12 _02881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07214_ _02880_ _02881_ _01667_ _02882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07215_ _01057_ _01485_ _02883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07216_ _02876_ _02879_ _02882_ _02883_ _02884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_07217_ dp.rf.rf\[28\]\[1\] dp.rf.rf\[29\]\[1\] dp.rf.rf\[30\]\[1\]
+ dp.rf.rf\[31\]\[1\] _01038_ _01102_ _02885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07218_ dp.rf.rf\[20\]\[1\] dp.rf.rf\[21\]\[1\] dp.rf.rf\[22\]\[1\]
+ dp.rf.rf\[23\]\[1\] _01038_ _01102_ _02886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07219_ _02885_ _02886_ _01271_ _02887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07220_ _01778_ _02887_ _02888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07221_ _02690_ _02875_ _02884_ _02888_ net139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_07222_ _01093_ _02863_ _02866_ _02889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_07223_ _01093_ net139 _02890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_07224_ _02890_ _02889_ _02891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_07225_ _02891_ _02892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xrebuffer8 _01073_ net167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
X_07227_ _01085_ _02892_ _04816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07228_ _04816_ _05075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07229_ dp.rf.rf\[14\]\[1\] dp.rf.rf\[15\]\[1\] _01147_ _02894_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07230_ _01230_ _02894_ _02895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07231_ _01151_ _02895_ _02896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07232_ dp.rf.rf\[10\]\[1\] _01154_ _01155_ _01034_ _02897_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_07233_ dp.rf.rf\[10\]\[1\] _02898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07234_ _01028_ _01153_ _02897_ _01136_ _02898_ _02899_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_07235_ dp.rf.rf\[11\]\[1\] _01160_ _02900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07236_ _01164_ _01166_ _02899_ _02900_ _02901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_07237_ dp.rf.rf\[8\]\[1\] dp.rf.rf\[9\]\[1\] dp.rf.rf\[12\]\[1\]
+ dp.rf.rf\[13\]\[1\] _01157_ _01139_ _02902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07238_ _02896_ _02901_ _02902_ _01173_ _01237_ _02903_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_07239_ dp.rf.rf\[2\]\[1\] dp.rf.rf\[3\]\[1\] dp.rf.rf\[6\]\[1\]
+ dp.rf.rf\[7\]\[1\] _01582_ _01124_ _02904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07240_ _01119_ _02904_ _02905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07241_ dp.rf.rf\[4\]\[1\] _02906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07242_ dp.rf.rf\[1\]\[1\] dp.rf.rf\[5\]\[1\] _01144_ _02907_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07243_ _01371_ _02907_ _02908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07244_ _02906_ _01327_ _02908_ _01119_ _02909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_07245_ _01541_ _02905_ _02909_ _01376_ _02910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07246_ _02903_ _02910_ _02911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07247_ dp.rf.rf\[24\]\[1\] dp.rf.rf\[25\]\[1\] dp.rf.rf\[28\]\[1\]
+ dp.rf.rf\[29\]\[1\] _01363_ _01364_ _02912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07248_ dp.rf.rf\[26\]\[1\] dp.rf.rf\[27\]\[1\] _01520_ _02913_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07249_ _02913_ _02914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07250_ dp.rf.rf\[30\]\[1\] dp.rf.rf\[31\]\[1\] _01363_ _02915_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07251_ _02915_ _02916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07252_ _01224_ _02914_ _02916_ _01146_ _02917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07253_ _02912_ _02917_ _01530_ _02918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07254_ dp.rf.rf\[22\]\[1\] dp.rf.rf\[23\]\[1\] _01363_ _02919_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07255_ _01505_ _02919_ _02920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07256_ dp.rf.rf\[19\]\[1\] _01520_ _02921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07257_ _01210_ net257 _01626_ dp.rf.rf\[18\]\[1\] _02921_
+ _02922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_07258_ _01697_ _02920_ _02922_ _02923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_07259_ dp.rf.rf\[16\]\[1\] _02924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07260_ dp.rf.rf\[17\]\[1\] dp.rf.rf\[21\]\[1\] _01123_ _02925_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07261_ dp.rf.rf\[20\]\[1\] _01497_ _02925_ _01693_ _01576_
+ _02926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_07262_ _02924_ _01737_ _02926_ _01361_ _01455_ _02927_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_07263_ _01580_ _02918_ _02923_ _02927_ _02928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_07264_ _02928_ _02911_ _04815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_07265_ _04815_ _05074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07266_ _04835_ _02929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07267_ _01438_ _01036_ _02930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_07268_ net6 net4 _02931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_07269_ _02930_ _02931_ _02932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07270_ net22 _01066_ _01065_ _02933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07271_ _01438_ _01068_ _01067_ _02934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07272_ _02933_ _02934_ net6 _02935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07273_ _01068_ _02932_ _02935_ _01084_ _02936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_07274_ _02936_ _02937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07275_ _01029_ _01031_ _01438_ _02938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07276_ net24 _01066_ _02938_ _02939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07277_ _01079_ _02939_ _01245_ _02940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07278_ net5 _02931_ _02940_ _02941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_07279_ _02941_ _02942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07280_ _02170_ _01067_ _01068_ _02933_ _02943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_07281_ _01258_ _01287_ _02944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_07282_ _02943_ _02944_ _02945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07283_ net248 _02945_ _02946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07284_ _02929_ _02937_ _02942_ _02946_ _02947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_07285_ _04834_ _04842_ _02937_ _02942_ _02948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_07286_ _02946_ _02948_ _02949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07287_ _04995_ _02950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_07288_ _05011_ _02951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_07289_ _05026_ _05019_ _05018_ _02952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07290_ _05010_ _02953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07291_ _02952_ _02951_ _02953_ _02954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07292_ _05003_ _02954_ _05002_ _02955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07293_ _04986_ _04994_ _02956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07294_ _02955_ _02950_ _02956_ _02957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07295_ _04979_ _02958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07296_ _04986_ _04987_ _02959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07297_ _02958_ _02959_ _02960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07298_ _05059_ _02961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07299_ _05067_ _04817_ _05066_ _02962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07300_ _05058_ _02963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07301_ _02961_ _02962_ _02963_ _02964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07302_ _05051_ _02964_ _05050_ _02965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07303_ _05035_ _05043_ _02966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07304_ _05035_ _05042_ _05034_ _02967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07305_ _02965_ _02966_ _02967_ _02968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07306_ _05003_ _05011_ _05019_ _05027_ _02969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_07307_ _04979_ _04987_ _04995_ _02969_ _02970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_07308_ _02957_ _02960_ _02968_ _02970_ _04978_ _02971_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_07309_ _04971_ _02972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07310_ _04955_ _04963_ _02973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07311_ _02972_ _02973_ _02974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07312_ _04970_ _04955_ _04963_ _02975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07313_ _04955_ _04962_ _02975_ _02976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07314_ net268 _02974_ _02976_ _02977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07315_ _04939_ _04923_ _04931_ _04947_ _02978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_07316_ _04939_ _02979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_07317_ _04946_ _02980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07318_ _04923_ _04931_ _02981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07319_ _04954_ _02982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07320_ _02982_ _02979_ _02981_ _02983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07321_ _04947_ _02984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_07322_ _02979_ _02980_ _02981_ _02983_ _02984_ _02985_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_07323_ _04923_ _02986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07324_ _04938_ _04931_ _04930_ _02987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07325_ _04922_ _02988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07326_ _02986_ _02987_ _02988_ _02989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07327_ _04906_ _04914_ _02989_ _02990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07328_ _02977_ _02978_ _02985_ _02990_ _02991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_07329_ _04906_ _04915_ _04914_ _02992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07330_ _04906_ _04907_ _02992_ _02993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07331_ _04891_ _04883_ _02994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07332_ _04875_ _04899_ _02994_ _02995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07333_ _04867_ _02995_ _02996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07334_ _04874_ _02997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07335_ _04890_ _04883_ _02998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07336_ _04898_ _02994_ _02999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07337_ _04882_ _02998_ _02999_ _04875_ _03000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07338_ _02997_ _03000_ _03001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07339_ _04867_ _03001_ _04866_ _03002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07340_ _02996_ _02993_ _02991_ _03002_ _03003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_07341_ _04851_ _04859_ _03003_ _04843_ _03004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_07342_ _04851_ _04843_ _04858_ _03005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07343_ _04843_ _04850_ _03004_ _03005_ _03006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_07344_ _02947_ _02949_ _03006_ _03007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07345_ net4 _01068_ _03008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07346_ _02170_ _03009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_07347_ _03009_ net19 _03010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07348_ _02409_ _02930_ _03008_ _03010_ _03011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_07349_ _03011_ _03012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07350_ _02937_ _03013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07351_ _02941_ _03014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07352_ _01067_ _01068_ _03015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_07353_ _02170_ _03015_ _02940_ _03016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_07354_ _02941_ _03016_ _03017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_07355_ _03017_ _03018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07356_ _04826_ _03018_ _03019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07357_ _04830_ _03014_ _03019_ _03020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07358_ _03013_ _03020_ _03021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07359_ net5 _02931_ _02940_ _03022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07360_ _02937_ _03022_ _03023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07361_ net247 _03023_ _03024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07362_ _02936_ _03022_ _03025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_07363_ _03025_ _03026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07364_ _02170_ _03015_ _02940_ _03027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07365_ _03027_ _03028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07366_ net247 _03026_ _03028_ _03029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07367_ _03024_ _03029_ _04827_ _03030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07368_ _02937_ _03031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07369_ _04835_ _04842_ _04834_ _03032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07370_ _04835_ _04834_ _03033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07371_ _03032_ _03033_ _02946_ _03034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07372_ _03031_ _02942_ _03034_ _03035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07373_ _03012_ _03021_ _03030_ _03035_ _03036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_07374_ _01259_ net154 _03037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07375_ _01605_ _05094_ _03037_ _03038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07376_ _03038_ _03039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07377_ _01062_ _01110_ _01093_ _03040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07378_ _03040_ _03041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07379_ _03041_ _03042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07380_ _02889_ _02890_ _03043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_07381_ _03043_ _03044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07382_ _03044_ _03045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07383_ _04896_ _04904_ _04912_ _04920_ _03042_ _03045_ _03046_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07384_ _04936_ _04952_ _03044_ _03047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07385_ _04928_ _04944_ _03044_ _03048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07386_ _03047_ _03048_ _01115_ _03049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07387_ _01388_ _04840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07388_ _03044_ _03050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07389_ _01258_ _04840_ _04848_ _04856_ _03042_ _03050_ _03051_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07390_ _04864_ _04872_ _04880_ _04888_ _03042_ _03050_ _03052_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07391_ _02812_ _02813_ _03053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_07392_ _03053_ _03054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07393_ _03046_ _03049_ _03051_ _03052_ _03054_ _02750_ _03055_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07394_ _05028_ _05036_ net221 _03056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07395_ _03041_ _03057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07396_ _05044_ _05052_ _03057_ _03058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07397_ _05060_ _05068_ _03057_ _03059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07398_ _04824_ net242 _01116_ _03060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07399_ _03060_ _03061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07400_ _03043_ _03062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07401_ _03062_ _03063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07402_ _03053_ _03064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07403_ _03064_ _03065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07404_ _03056_ _03058_ _03059_ _03061_ _03063_ _03065_ _03066_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07405_ _02750_ _03067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07406_ net243 _04968_ _04976_ _04984_ _03042_ _03050_ _03068_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07407_ net238 _05000_ net181 net174 _03042_ _03050_ _03069_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07408_ _03053_ _03070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07409_ _03068_ _03069_ _03070_ _03071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07410_ _03067_ _03071_ _03072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07411_ net222 _03066_ _03072_ _03039_ _03073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07412_ _02170_ net4 _01068_ _02930_ _03074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_07413_ _03074_ _03075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07414_ _03075_ _03076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07415_ _03039_ _03055_ _03073_ _03076_ _03077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_07416_ _03041_ _03078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07417_ _03078_ _03079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07418_ _03079_ _04824_ _03063_ _03080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07419_ _02170_ net4 _01068_ _02930_ _03081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_07420_ _03038_ _03081_ _03082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07421_ _02747_ _02748_ _03083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_07422_ _03083_ _03054_ _03084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07423_ _03082_ _03084_ _03085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07424_ _03080_ _03085_ _03012_ _03086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07425_ _03007_ _03036_ _03077_ _03086_ net61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_07426_ _01029_ _02930_ _03087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07427_ _03087_ _03088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_07428_ _03088_ _03089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07429_ _03089_ net93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07430_ net250 _03075_ _03090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07431_ _04896_ _04912_ _03062_ _03091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07432_ _04888_ _04904_ _03062_ _03092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07433_ _04920_ _04936_ _03062_ _03093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07434_ _03091_ _03048_ _03092_ _03093_ _03053_ _01116_ _03094_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07435_ _03094_ _03095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07436_ _02814_ _03096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07437_ _03044_ _03097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07438_ _04856_ _04864_ _04872_ _04880_ _03042_ _03097_ _03098_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07439_ _03078_ _04848_ _03099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07440_ _01359_ _01387_ _01115_ _03100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07441_ net164 _03101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07442_ _03101_ _03102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07443_ _03099_ _03100_ _03102_ _03103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07444_ _01093_ net139 _03104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07445_ _01259_ _04821_ _03104_ _01258_ _03105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_07446_ net163 _03105_ _03106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07447_ _03096_ _03098_ _03103_ _03106_ _03107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_07448_ _02889_ _02890_ _01469_ _03108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07449_ _03105_ _03108_ _03109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07450_ _04868_ _04884_ _03044_ _03110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07451_ _04840_ _03097_ _03111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07452_ _04860_ _04876_ _03043_ _03112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07453_ _03109_ _03110_ _03111_ _03112_ _03053_ _01115_ _03113_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07454_ net19 _03114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_07455_ _03107_ _03113_ _03114_ _03115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07456_ _02749_ _03116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07457_ _03095_ _03115_ _03116_ _03117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07458_ _03038_ _03075_ _03118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_07459_ _04964_ _04980_ _03062_ _03119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07460_ _04956_ _04972_ _03044_ _03120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07461_ _03119_ _03120_ _01115_ _03121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07462_ _04988_ _04996_ _05004_ _05012_ net221 _03097_ _03122_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07463_ _03121_ _03122_ _03054_ _03123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07464_ _05020_ _05028_ _05036_ _05044_ _03042_ _03097_ _03124_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07465_ _05052_ _05060_ _05068_ _05074_ _03057_ _03063_ _03125_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07466_ _03124_ _03125_ _03064_ _03126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07467_ _03083_ _03127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07468_ _03123_ _03126_ _03127_ _03128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07469_ _03041_ _04824_ _03129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_07470_ _01115_ net242 _03129_ _03097_ _03130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_07471_ _03130_ _03131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07472_ _03085_ _03131_ _03011_ _03132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07473_ _03090_ _03117_ _03118_ _03128_ _03132_ _03133_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_07474_ _03031_ _03022_ _03134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07475_ _02409_ _02930_ _03008_ _03010_ _03135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_07476_ _03135_ _03136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07477_ _05073_ _03028_ _03136_ _03137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07478_ _03017_ _03138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07479_ _03138_ _03139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07480_ _04818_ _03140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07481_ _03140_ _05072_ _02937_ _03141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07482_ _03139_ _03141_ _03142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07483_ _05076_ _03134_ _03137_ _03142_ _03143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07484_ _03133_ _03143_ net72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07485_ _03028_ _03144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07486_ _05067_ _03144_ _03136_ _03145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07487_ _04817_ _05067_ _03146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_07488_ _03146_ _05066_ _02937_ _03147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07489_ _03139_ _03147_ _03148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07490_ _05070_ _03134_ _03145_ _03148_ _03149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07491_ _03070_ _03150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07492_ _04852_ _04860_ _04868_ _04876_ _03078_ _03045_ _03151_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07493_ _03150_ _03151_ _03152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07494_ net178 _03152_ _03153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07495_ _03042_ _01258_ _03154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07496_ _01114_ _01359_ _01387_ _03155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_07497_ net271 _03154_ _03155_ _03156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07498_ net175 _03156_ _03157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07499_ _03114_ _03105_ _03157_ _03158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07500_ _03083_ _03159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07501_ _03159_ _03160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07502_ _04912_ _04928_ _03062_ _03161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07503_ _04880_ _04896_ _03097_ _03162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07504_ _03093_ _03092_ _03161_ _03162_ _03096_ _01116_ _03163_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07505_ _03160_ _03163_ _03164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07506_ _03153_ _03158_ _03164_ _03165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07507_ _05012_ _05020_ net221 _03166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07508_ _03166_ _03056_ _03097_ _03167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07509_ _03058_ _03059_ _03063_ _03168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07510_ _04944_ _04952_ net243 _04968_ net221 _03062_ _03169_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07511_ _03169_ _03170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07512_ _04980_ _04996_ _03043_ _03171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07513_ _04988_ _05004_ _03043_ _03172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07514_ _03171_ _03172_ _03042_ _03173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07515_ _03167_ _03168_ _03170_ _03173_ _03065_ net178 _03174_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07516_ _04824_ net258 _03044_ _03175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07517_ _03063_ net242 _03176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07518_ _03175_ _03176_ _01116_ _03177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07519_ _03011_ _03178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07520_ _03085_ _03177_ _03178_ _03179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07521_ _03090_ _03165_ _03174_ _03118_ _03179_ _03180_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_07522_ _03149_ _03180_ net83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07523_ net246 _03041_ _03181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07524_ _03181_ _03129_ _04814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_07525_ _03178_ _03182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07526_ _03031_ _03183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07527_ _02942_ _03184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07528_ _05058_ _03139_ _03185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07529_ _05062_ _03184_ _03185_ _03186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07530_ _03183_ _03186_ _03187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07531_ _03182_ _03187_ _03188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07532_ _03023_ _03189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07533_ _05066_ _03190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07534_ _05073_ _04814_ _03191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07535_ _05072_ _03191_ _05067_ _03192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07536_ _03190_ _03192_ _03193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07537_ _03016_ _03194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07538_ _03189_ _03193_ _03194_ _03195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07539_ _05059_ _03195_ _03196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07540_ _03026_ _03197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07541_ _02961_ _03197_ _03193_ _03198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07542_ _03079_ _03199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07543_ _05032_ _05040_ _05048_ _05056_ _03199_ _03063_ _03200_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07544_ _05004_ _05012_ _05020_ _05028_ _03078_ _03045_ _03201_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07545_ _03065_ _03201_ _03202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07546_ _03065_ _03200_ _03202_ _03203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07547_ _04972_ _04988_ _03045_ _03204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07548_ _04940_ _04956_ _03045_ _03205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07549_ _04948_ _04964_ _03045_ _03206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07550_ _03204_ _03205_ _03171_ _03206_ net179 _03199_ _03207_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07551_ _03203_ _03207_ _03067_ _03208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07552_ _04908_ _04924_ _03050_ _03209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07553_ _04876_ _04892_ _03050_ _03210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07554_ _04916_ _04932_ _03050_ _03211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07555_ _04884_ _04900_ _03097_ _03212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07556_ _03078_ _03213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07557_ _03209_ _03210_ _03211_ _03212_ _03096_ _03213_ _03214_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07558_ _03160_ _03214_ _03215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07559_ _04840_ _04848_ _04856_ _04864_ _03057_ _03063_ _03216_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07560_ _03150_ _03216_ _03217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07561_ _03078_ _03045_ _03218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07562_ _01258_ _04833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07563_ net19 _03218_ _02816_ _04833_ _03219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07564_ _03116_ _03217_ _03219_ _03220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07565_ _03090_ _03220_ _03221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07566_ net219 _04815_ _02891_ _03222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07567_ _03175_ _03222_ _03078_ _03223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_07568_ _03215_ _03221_ _03223_ _03085_ _03178_ _03224_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_07569_ _03118_ _03208_ _03224_ _03225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07570_ _03188_ _03196_ _03198_ _03225_ _03226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_07571_ _03226_ net86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07572_ _02750_ _03052_ net179 _04833_ _03227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07573_ _03046_ _03052_ _03096_ _03228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07574_ _02749_ _03064_ _03051_ _03229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07575_ _03127_ _03228_ _03229_ _03230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07576_ _03114_ _03227_ _03230_ _03231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07577_ _02699_ _03076_ _03231_ _03232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_07578_ _03127_ _03233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07579_ _05060_ _05074_ _02892_ _03234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07580_ _05052_ _05068_ _02892_ _03235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07581_ _03234_ _03235_ _03079_ _03236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07582_ _02816_ _03080_ _03237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07583_ _03081_ _03238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07584_ net175 _03236_ _03237_ _03238_ _03239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07585_ _03068_ _03049_ _02816_ _03240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07586_ _03233_ _03239_ _03240_ _03076_ _03241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07587_ _02699_ _03241_ _03242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07588_ _03038_ _03075_ _03243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07589_ _03056_ _03058_ _03063_ _03244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07590_ _03065_ _03244_ _03245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07591_ _03065_ _03069_ _03245_ _03246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07592_ _03233_ _03243_ _03246_ _03247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07593_ _03232_ _03242_ _03247_ _03248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07594_ _05050_ _03138_ _03249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07595_ _05054_ _02942_ _03249_ _03250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07596_ _03031_ _03250_ _03251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07597_ _02964_ _03026_ _03252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07598_ _03023_ _03253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07599_ _02964_ _03253_ _03016_ _03254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07600_ _03252_ _03254_ _05051_ _03255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07601_ _03251_ _03255_ _03256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07602_ _03248_ _03256_ _03182_ net87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07603_ _03053_ _03050_ _04837_ _03257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07604_ _03099_ _03100_ net163 _03102_ _03258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_07605_ _03257_ _03258_ _03259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07606_ _03078_ _03105_ _03108_ _03260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07607_ _04840_ _03045_ _03078_ _03261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07608_ _03096_ _03260_ _03261_ _03262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07609_ _03259_ _03262_ _03114_ _03263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07610_ _04900_ _04916_ _03044_ _03264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07611_ _04892_ _04908_ _03044_ _03265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07612_ _03264_ _03110_ _03265_ _03112_ net244 _01116_ _03266_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07613_ _03159_ _03266_ _03267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07614_ _03116_ _03263_ _03267_ _03081_ _03268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_07615_ _03038_ _03269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_07616_ net164 _03270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07617_ _05044_ _05052_ _05060_ _05068_ _01114_ _03270_ _03271_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07618_ _03122_ _03124_ _03130_ _03271_ _03070_ _03081_ _03272_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07619_ _04932_ _04948_ _03062_ _03273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07620_ _04924_ _04940_ _03062_ _03274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07621_ _03119_ _03273_ _03120_ _03274_ net244 _01116_ _03275_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07622_ _02749_ _03075_ _03276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07623_ net178 _03272_ _03275_ _03276_ _03277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_07624_ _03269_ _03277_ _03278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07625_ net187 _03268_ _03278_ _03279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07626_ _03025_ _03280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07627_ _05073_ _05072_ _05067_ _03281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07628_ _03190_ _03281_ _03282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07629_ _05051_ _05059_ _03282_ _03283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_07630_ _04814_ _03283_ _03284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07631_ _05072_ _05067_ _05066_ _03285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07632_ _03285_ _03286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07633_ _05058_ _05051_ _03283_ _03286_ _05050_ _03287_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_07634_ _03284_ _03287_ _03288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07635_ _05043_ _03288_ _03289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07636_ _05042_ _03017_ _03290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07637_ _05046_ _02941_ _03290_ _03291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07638_ _05043_ _03028_ _03280_ _03289_ _03291_ _02937_ _03292_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_07639_ _03279_ _03292_ _03178_ _03293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07640_ _03293_ net88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07641_ _03136_ _03294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07642_ _03112_ _03295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07643_ _04848_ _04864_ _03050_ _03296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07644_ _03092_ _03295_ _03162_ _03296_ _03096_ _01116_ _03297_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07645_ net19 _03257_ _03298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07646_ net163 _02892_ _03154_ _03155_ _03299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_07647_ _03083_ _03298_ _03299_ _03300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07648_ _03116_ _03297_ _03300_ _03075_ _03301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07649_ _01115_ _04815_ _03302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07650_ _03057_ _03175_ _03302_ _03045_ _03303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07651_ _05044_ _05060_ net165 _03304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07652_ _05036_ _05052_ net165 _03305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07653_ _03304_ _03305_ _03042_ _03306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07654_ _03303_ _03173_ _03306_ _03167_ _03075_ _03054_ _03307_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07655_ _03093_ _03161_ _01115_ _03308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07656_ _03096_ _03169_ _03309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07657_ _03064_ _03308_ _03309_ _03075_ _03310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07658_ _03307_ _03310_ net178 _03311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07659_ _03301_ _03311_ _03269_ _03312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07660_ _05034_ _03017_ _03313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07661_ _05038_ _02941_ _03313_ _03314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07662_ _02937_ _03314_ _03315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07663_ _05043_ _03316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07664_ _03316_ _02965_ _03317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07665_ _05042_ _03317_ _03318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07666_ _03025_ _03318_ _03319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07667_ _03028_ _03319_ _05035_ _03320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07668_ _05035_ _03023_ _03318_ _03321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07669_ _03178_ _03315_ _03320_ _03321_ _03322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_07670_ _03294_ _03312_ _03322_ net89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07671_ _05032_ _05048_ _03101_ _03323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07672_ _05024_ _05040_ _03101_ _03324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07673_ _03323_ _03324_ _03057_ _03325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07674_ _03223_ _03325_ _03054_ _03326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_07675_ _04972_ _04980_ _04988_ _04996_ _03057_ _03063_ _03327_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07676_ _03201_ _03327_ net179 _03328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07677_ _03238_ _03328_ _03329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07678_ _03238_ _03326_ _03329_ _03330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07679_ _04904_ _04920_ _03097_ _03331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07680_ _02228_ _04960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07681_ _04944_ _04960_ _03062_ _03332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07682_ _03331_ _03047_ _03161_ _03332_ _03070_ _03213_ _03333_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07683_ _03333_ _03334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07684_ _03269_ _03135_ _03335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07685_ net222 _03330_ _03334_ _03276_ _03335_ _03336_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_07686_ _04844_ _04860_ _03050_ _03337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07687_ _04852_ _04868_ _03097_ _03338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07688_ _03337_ _03210_ _03338_ _03212_ _03070_ _03213_ _03339_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07689_ _01258_ _03070_ _03218_ _03340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_07690_ _04837_ _03340_ _03114_ _03341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07691_ _03339_ _03341_ _03116_ _03342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07692_ net187 _03136_ _03343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07693_ _03238_ _03342_ _03343_ _03344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07694_ _03336_ _03344_ _03345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07695_ _05027_ _03346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07696_ _05035_ _05043_ _03283_ _03347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_07697_ net247 net221 _03347_ _03348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07698_ _03287_ _02966_ _02967_ _03349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07699_ _03129_ _03348_ _03349_ _03350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07700_ _03346_ net252 _03351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07701_ _05026_ _03138_ _03352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07702_ _05030_ _02942_ _03352_ _03353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07703_ _05027_ _03028_ _03353_ _03031_ _03354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07704_ _03189_ _03351_ _03354_ _03178_ _03355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07705_ _03345_ _03355_ net90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07706_ _03082_ _03356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_07707_ _05028_ _05044_ _02892_ _03357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07708_ _05020_ _05036_ _03101_ _03358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07709_ _03234_ _03235_ _03357_ _03358_ _03079_ _03070_ _03359_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07710_ _03150_ _03080_ _03360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07711_ _03359_ _03360_ _02750_ _03361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07712_ _03051_ _03052_ _03064_ _03362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07713_ net19 _03074_ _03363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_07714_ _02747_ _02748_ _01258_ _03364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07715_ _03114_ net166 _02748_ _03074_ _03365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_07716_ _03363_ _03364_ _03365_ _03366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07717_ net222 _03362_ _03366_ _03367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07718_ _03046_ _03049_ _03150_ _03368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07719_ _03159_ _03071_ _03369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07720_ net178 _03368_ _03118_ _03369_ _03370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_07721_ _03356_ _03361_ _03367_ net187 _03370_ _03371_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_07722_ _05019_ _03372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07723_ _05027_ _02968_ _05026_ _03373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07724_ _03197_ _03373_ _03028_ _03374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07725_ _05019_ _03253_ _03373_ _03375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07726_ _05018_ _03138_ _03376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07727_ _05022_ _02942_ _03376_ _03377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07728_ _03031_ _03377_ _03378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07729_ _03372_ _03374_ _03375_ _03378_ _03379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07730_ _03371_ _03379_ _03012_ net91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07731_ _03136_ _03380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_07732_ _05026_ _03381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07733_ _03346_ _03350_ _03381_ _03382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07734_ _05019_ _03382_ _05018_ _03383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07735_ _05011_ _03383_ _03384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07736_ _05010_ _03018_ _03385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07737_ _05014_ _03184_ _03385_ _03386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07738_ _05011_ _03144_ _03197_ _03384_ _03386_ _03183_ _03387_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_4
X_07739_ _03160_ _03107_ _03388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07740_ _03363_ _03364_ _03389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07741_ _03113_ _03365_ _03388_ _03389_ _02699_ _03390_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_07742_ _05012_ _05028_ _03101_ _03391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07743_ _03235_ _03304_ _03358_ _03391_ _03199_ _03150_ _03392_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07744_ net175 _03130_ _03393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07745_ _03067_ _03393_ _03394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07746_ net222 _03392_ _03394_ _03356_ _03395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07747_ _03067_ _03094_ _03396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07748_ net222 _03123_ _03396_ _03243_ _03397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07749_ _03380_ _03390_ _03395_ _03397_ _03398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_07750_ _03380_ _03387_ _03398_ net92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07751_ _05002_ _03138_ _03399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07752_ _05006_ _03014_ _03399_ _03400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07753_ _05018_ _03401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07754_ _03372_ _03373_ _03401_ _03402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07755_ _05011_ _03402_ _05010_ _03403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07756_ _03026_ _03403_ _03404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07757_ _03194_ _03404_ _03405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07758_ _05003_ _03253_ _03403_ _03406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_07759_ _03013_ _03400_ _03405_ _05003_ _03406_ _03407_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_07760_ _03038_ _03081_ _03408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_07761_ _02750_ _03150_ _03409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07762_ _05004_ _05020_ _03270_ _03410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07763_ _03304_ _03305_ _03391_ _03410_ _03079_ _03054_ _03411_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07764_ _03303_ _03409_ _03411_ net178 _03412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_07765_ _04976_ _04984_ net237 _05000_ _03078_ _03045_ _03413_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07766_ _03169_ _03413_ _03054_ _03414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07767_ _03163_ _03414_ _03159_ _03415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07768_ net271 _03154_ _03155_ net179 _03416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07769_ net19 _03074_ _03417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07770_ _01258_ net271 _03417_ _03418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07771_ _03416_ _03366_ _03418_ _03419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07772_ _03064_ _03151_ _03420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07773_ _03127_ _03389_ _03419_ _03420_ _03421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_07774_ _03408_ _03412_ _03415_ _03118_ _03421_ _03269_ _03422_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_07775_ _03407_ _03422_ _03294_ _03423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07776_ _03423_ net62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_07777_ _04996_ _05012_ _03270_ _03424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07778_ _03305_ _03357_ _03410_ _03424_ _03213_ _03064_ _03425_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07779_ _03065_ _03223_ _03160_ _03426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07780_ _03233_ _03425_ _03426_ _03427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07781_ _03214_ _03207_ _03127_ _03428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07782_ _03243_ _03428_ _03429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07783_ _04833_ net179 _03218_ _03430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_07784_ _03217_ _03430_ _03431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07785_ _04833_ _03216_ _03150_ _03432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07786_ _03363_ _03364_ _03433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_07787_ net178 _03432_ _03433_ _03434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07788_ _03365_ _03431_ _03434_ _02699_ _03435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07789_ _03408_ _03427_ _03429_ _03435_ _03436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_07790_ _02969_ _03437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07791_ _03437_ _03350_ _02955_ _03438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07792_ _02950_ _03438_ _03439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07793_ _04994_ _03138_ _03440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07794_ _04998_ _02942_ _03440_ _03441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07795_ _04995_ _03144_ _03280_ _03439_ _03441_ _03031_ _03442_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_07796_ _03012_ _03442_ _03443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07797_ _03380_ _03436_ _03443_ net63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07798_ _04986_ _03139_ _03444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07799_ _04990_ _03184_ _03444_ _03445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07800_ _02968_ _02969_ _03446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07801_ _02955_ _03446_ _02950_ _03447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07802_ _04994_ _03447_ _03448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07803_ _03026_ _03448_ _03449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07804_ _03253_ _03448_ _03194_ _03450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07805_ _03449_ _03450_ _04987_ _03451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07806_ _03183_ _03445_ _03451_ _03452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07807_ _03380_ _03452_ _03453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07808_ _03228_ _03240_ _03127_ _03454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07809_ _03118_ _03454_ _03455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07810_ net175 _03236_ _03237_ _03456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_07811_ _04988_ _05004_ _03101_ _03457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07812_ _03357_ _03358_ _03424_ _03457_ _03079_ _03054_ _03458_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07813_ _03116_ _03458_ _03459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07814_ net178 _03456_ _03459_ _03076_ _03460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_07815_ _03076_ _03051_ _03084_ _03461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_07816_ _04833_ _03417_ _03462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_07817_ _03269_ _03084_ _03462_ _03463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07818_ _02699_ _03460_ _03461_ _03463_ _03464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07819_ _03294_ _03455_ _03464_ _03465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07820_ _03453_ _03465_ net64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07821_ _04995_ _03438_ _04994_ _04986_ _03466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_07822_ _02959_ _03466_ _03197_ _03467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07823_ _03194_ _03467_ _02958_ _03468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07824_ _04978_ _03018_ _03469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07825_ _04982_ _03014_ _03469_ _03470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07826_ _03013_ _03470_ _03471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07827_ _04979_ _02959_ _03253_ _03466_ _03472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_07828_ _03471_ _03472_ _03473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07829_ _03130_ _03271_ _03070_ _03474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07830_ _04980_ _04996_ _02892_ _03475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07831_ _03358_ _03391_ _03457_ _03475_ _03057_ _03070_ _03476_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_07832_ _03474_ _03476_ _03083_ _03477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07833_ _03266_ _03275_ _03159_ _03478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07834_ _02749_ _03257_ _03258_ _03433_ _03479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07835_ _02816_ _03260_ _03261_ _03365_ _03480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_07836_ net253 _03479_ _03480_ _03481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07837_ _03356_ _03477_ _03478_ _03243_ _03481_ _03482_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_07838_ _03178_ _03482_ _03483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07839_ _03380_ _03468_ _03473_ _03483_ _03484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07840_ _03484_ net65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07841_ _03199_ _03175_ _03302_ _03063_ _03064_ _03485_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_07842_ _03065_ _03306_ _03485_ _03486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07843_ _03308_ _03169_ _03150_ _03487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07844_ net176 _05024_ _03102_ _03488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07845_ _05000_ net173 _03270_ _03489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07846_ _04976_ net237 _03102_ _03490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07847_ _04968_ _04984_ _03270_ _03491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07848_ _03488_ _03489_ _03490_ _03491_ _03213_ _03064_ _03492_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07849_ _03297_ _03486_ _03487_ _03492_ _03238_ _03233_ _03493_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07850_ _02699_ _03493_ _03494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07851_ _03067_ _03257_ _03495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07852_ _03299_ _03366_ _03495_ _03433_ _03039_ _03496_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_07853_ _02971_ _03197_ _03028_ _03497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07854_ _04971_ _02971_ _03253_ _03498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07855_ _04970_ _03138_ _03499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07856_ _04974_ _03014_ _03499_ _03500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07857_ _03013_ _03500_ _03501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07858_ _02972_ _03497_ _03498_ _03501_ _03502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07859_ _03182_ _03502_ _03503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07860_ _03182_ _03494_ _03496_ _03503_ net66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_07861_ _02970_ _03504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07862_ _02957_ _02960_ _04978_ _03505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07863_ _03504_ _03350_ _03505_ _03506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07864_ _04971_ _03506_ _04970_ _03507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07865_ _04963_ _03507_ _03508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07866_ _04962_ _03018_ _03509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07867_ _04966_ _03014_ _03509_ _03510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07868_ _04963_ _03144_ _03197_ _03508_ _03510_ _03013_ _03511_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_4
X_07869_ _03182_ _03511_ _03512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07870_ net237 net176 _03270_ _03513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07871_ net243 _04976_ _03270_ _03514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07872_ _03489_ _03513_ _03491_ _03514_ _03213_ _03054_ _03515_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07873_ _03326_ _03515_ _03159_ _03516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07874_ _03356_ _03516_ _03517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07875_ _03334_ _03339_ _02750_ _03518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07876_ _03118_ _03518_ _03519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07877_ _03340_ _03365_ _03520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07878_ _03039_ _03518_ _03520_ _03462_ _03521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07879_ _03012_ _03517_ _03519_ _03521_ _03522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_07880_ _03512_ _03522_ net67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07881_ _03075_ _03055_ _03523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07882_ _04964_ _04980_ _04996_ _05012_ _03270_ _02814_ _03524_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07883_ _04956_ _04972_ _04988_ _05004_ _02892_ _02814_ _03525_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07884_ _03524_ _03525_ _03079_ _03526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07885_ _03359_ _03526_ _03159_ _03527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07886_ _03076_ _03527_ _03528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07887_ _03083_ _03081_ _03529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07888_ _03529_ _03530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07889_ _03360_ _03530_ _03462_ net187 _03531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07890_ net250 _03523_ _03528_ _03531_ _03532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07891_ _04970_ _03533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07892_ _02972_ _02971_ _03533_ _03534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07893_ _04963_ _03534_ _04962_ _04955_ _03535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_07894_ _02977_ _03535_ _03536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07895_ _04954_ _03138_ _03537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07896_ _04958_ _02942_ _03537_ _03538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07897_ _04955_ _03144_ _03280_ _03536_ _03538_ _03031_ _03539_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_07898_ _03532_ _03539_ _03178_ _03540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07899_ _03540_ net68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07900_ _04955_ _04962_ _04954_ _03541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07901_ _02973_ _03507_ _03541_ _03542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07902_ _02984_ _03542_ _03543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_07903_ _04946_ _03018_ _03544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07904_ _04950_ _03014_ _03544_ _03545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07905_ _04947_ _03144_ _03197_ _03543_ _03545_ _03013_ _03546_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_4
X_07906_ _04837_ net254 _03363_ _03547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07907_ _03393_ _03529_ _03547_ _03548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07908_ _03462_ _03549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07909_ _04944_ _04960_ _04976_ net237 _03102_ _02814_ _03550_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07910_ _03199_ _03550_ _03551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07911_ _03199_ _03525_ _03551_ _03552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07912_ _03094_ _03552_ _03081_ _03553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07913_ _03094_ _03549_ _03553_ _03039_ _03554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_07914_ _04833_ _03038_ _03417_ _03555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07915_ _03114_ _03074_ _03556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07916_ net253 _03556_ _03557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_07917_ _03408_ _03392_ _03555_ _03107_ _03557_ _03113_ _03558_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_07918_ net222 _03558_ _03559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07919_ _03039_ _03548_ _03554_ net222 _03559_ _03560_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_07920_ _03182_ _03560_ _03561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07921_ _03182_ _03546_ _03561_ net69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07922_ _03105_ _03157_ _03420_ _03233_ _03562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_07923_ _02699_ _03164_ _03562_ _03547_ _03563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_07924_ _03557_ _03564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_07925_ _02750_ _03152_ _03416_ _03565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_07926_ _03164_ _03565_ _03566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07927_ _02750_ _03411_ _03567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07928_ _04936_ _04952_ _04968_ _04984_ net271 _03096_ _03568_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07929_ _03550_ _03568_ _03199_ _03569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07930_ _03067_ _03569_ _03570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_07931_ _02697_ _03081_ _03571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07932_ _03084_ _03571_ _03572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07933_ _03177_ _03572_ _03011_ _03573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07934_ _03408_ _03567_ _03570_ _03573_ _03574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07935_ _03564_ _03566_ _03574_ _03575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_07936_ _04938_ _03139_ _03576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07937_ _04942_ _03184_ _03576_ _03577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07938_ _03183_ _03577_ _03380_ _03578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07939_ _02971_ _02974_ _02976_ _02982_ _03579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07940_ _03579_ _04947_ _04946_ _03580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07941_ _03580_ _03197_ _03581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07942_ _03580_ _03189_ _02979_ _03582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07943_ _02979_ _03144_ _03581_ _03582_ _03583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07944_ _03563_ _03575_ _03578_ _03583_ net70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_07945_ _03067_ _03432_ _03584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07946_ net222 _03214_ _03584_ _03039_ _03585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07947_ net222 _03431_ _03557_ _03586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07948_ _04940_ _04956_ _04972_ _04988_ _03102_ _03096_ _03587_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07949_ _04932_ _04948_ _04964_ _04980_ _03102_ net163 _03588_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07950_ _03587_ _03588_ _03213_ _03589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07951_ _03425_ _03589_ _03127_ _03590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07952_ _03223_ _03572_ _03591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07953_ _03408_ _03590_ _03591_ _03136_ _03592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_07954_ _03547_ _03585_ _03586_ _03215_ _03592_ _03593_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_07955_ _04930_ _03018_ _03594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07956_ _04934_ _03014_ _03594_ _03595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07957_ _03013_ _03595_ _03596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07958_ _02973_ _03541_ _02984_ _03597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07959_ _04946_ _03597_ _03598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_07960_ _04939_ _03598_ _04938_ _03599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07961_ _04938_ _03600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07962_ _02984_ _03541_ _02980_ _03601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07963_ _04939_ _03601_ _03602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07964_ _03600_ _03505_ _03533_ _03602_ _03603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_07965_ _03129_ _03348_ _03349_ _03603_ _03604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_07966_ _03600_ _03602_ _03605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07967_ _04970_ _02970_ _03605_ _03606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07968_ _03505_ _03607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07969_ _04970_ _04971_ _03605_ _03606_ _03607_ _03608_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_07970_ _03599_ _03604_ _03608_ _03609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07971_ _03280_ _03609_ _03610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07972_ _03144_ _03610_ _04931_ _03611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07973_ _04931_ _03189_ _03609_ _03612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_07974_ _03012_ _03596_ _03611_ _03612_ _03613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_07975_ _03593_ _03613_ net71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_07976_ _02979_ _03580_ _03600_ _03614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07977_ _04931_ _03614_ _04930_ _03615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07978_ _03197_ _03615_ _03616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07979_ _03194_ _03616_ _02986_ _03617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07980_ _04922_ _03138_ _03618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07981_ _04926_ _02942_ _03618_ _03619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_07982_ _03031_ _03619_ _03620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_07983_ _04923_ _03189_ _03615_ _03620_ _03621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_07984_ _04928_ _04944_ _03101_ _03622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07985_ _04920_ _04936_ _02892_ _03623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07986_ _03622_ _03623_ _03057_ _03624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07987_ net263 _04968_ _02892_ _03625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07988_ _03514_ _03625_ _03079_ _03626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07989_ _03624_ _03626_ net175 _03627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07990_ _03456_ _03627_ _03269_ _03628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_07991_ _03529_ _03628_ _03629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_07992_ _03118_ _03462_ _03230_ _03630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07993_ _03269_ _03227_ _03555_ _03631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_07994_ _03160_ _03408_ _03458_ _03632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_07995_ _03178_ _03630_ _03631_ _03632_ _03633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_07996_ _03617_ _03621_ _03380_ _03629_ _03633_ _03634_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_07997_ _03634_ net73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_07998_ _04912_ _04928_ _04944_ _04960_ net271 _03096_ _03635_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_07999_ _03625_ _03623_ _03070_ _03636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08000_ _03635_ _03636_ _01116_ _03637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08001_ _03269_ _03075_ _03474_ _03638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08002_ _03266_ _03557_ _03639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08003_ _03356_ _03637_ _03638_ _03639_ _03640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08004_ _03408_ _03476_ _03557_ _03262_ _03641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_08005_ _03641_ _03642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08006_ _03640_ _03642_ net222 _03643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08007_ _03259_ _03266_ _03160_ _03644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08008_ _03039_ _03644_ _03645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08009_ _03547_ _03645_ _03012_ _03646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08010_ _02981_ _03599_ _03647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08011_ _04923_ _04930_ _04922_ _03648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08012_ _03647_ _03608_ _03604_ _03648_ _03649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08013_ _03189_ _03649_ _03194_ _03650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08014_ _04914_ _03018_ _03651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08015_ _04918_ _03184_ _03651_ _03652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08016_ _04915_ _03653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08017_ _03653_ _03280_ net265 _03654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08018_ _04915_ _03650_ _03652_ _03183_ _03654_ _03655_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08019_ _03643_ _03646_ _03655_ _03182_ net74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_08020_ _04906_ _03139_ _03656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08021_ _04910_ _03184_ _03656_ _03657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08022_ _02977_ _02978_ _02985_ _02989_ _03658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08023_ _04914_ _03659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08024_ _03653_ _03658_ _03659_ _03660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08025_ _03660_ _03026_ _03661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08026_ _03660_ _03253_ _03194_ _03662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08027_ _03661_ _03662_ _04907_ _03663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08028_ _03183_ _03657_ _03663_ _03664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08029_ net253 _03083_ _03257_ _03299_ _03665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08030_ _03038_ _03083_ _03666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08031_ _03547_ _03665_ _03666_ _03667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08032_ _03127_ _03564_ _03668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08033_ _03547_ _03665_ _03669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08034_ _03297_ _03667_ _03668_ _03669_ _03670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_08035_ _04904_ _04920_ _04936_ net263 _03270_ net163 _03671_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_08036_ _03635_ _03671_ _03199_ _03672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08037_ _03160_ _03672_ _03673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08038_ _03116_ _03492_ _03674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08039_ _03673_ _03674_ _03356_ _03675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08040_ _03159_ _03571_ _03676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08041_ _03116_ _03299_ _03564_ _03677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08042_ _03486_ _03676_ _03677_ _03678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08043_ _03294_ _03670_ _03675_ _03678_ _03679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08044_ _03182_ _03664_ _03679_ net75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08045_ _03159_ _03564_ _03680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08046_ _03038_ _03083_ _03681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08047_ _04833_ _03681_ _03417_ _03682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08048_ _03680_ _03682_ _03339_ _03683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08049_ _03340_ _03557_ _03682_ _03684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08050_ _03666_ _03684_ _03685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08051_ _03326_ _03676_ _03686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08052_ _03178_ _03683_ _03685_ _03686_ _03687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08053_ _04896_ _04912_ _03101_ _03688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08054_ _03622_ _03688_ _03053_ _03689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08055_ _03671_ _03689_ _03213_ _03690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08056_ _03233_ _03690_ _03691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08057_ _03067_ _03515_ _03692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08058_ _03691_ _03692_ _03408_ _03693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08059_ _03687_ _03693_ _03694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08060_ _04899_ _03695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08061_ _04907_ _04915_ _03696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08062_ _04907_ _04914_ _03649_ _03696_ _04906_ _03697_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08063_ _03197_ _03697_ _03144_ _03698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08064_ _04899_ _03189_ _03697_ _03699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08065_ _04898_ _03018_ _03700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08066_ _04902_ _03014_ _03700_ _03701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08067_ _03013_ _03701_ _03294_ _03702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08068_ _03695_ _03698_ _03699_ _03702_ _03703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08069_ _03694_ _03703_ net76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08070_ _03526_ _03704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08071_ _04888_ _04904_ _03270_ _03705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08072_ _03688_ _03705_ _03079_ _03706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08073_ _03624_ _03706_ _03150_ _03707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08074_ _03704_ _03707_ _03160_ _03708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08075_ _03367_ _03709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08076_ _03238_ _03708_ _03709_ _03710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08077_ _03076_ _03361_ _03711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08078_ _03462_ _03711_ _03712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08079_ _03710_ _03712_ _02699_ _03713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08080_ _04890_ _03139_ _03714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08081_ _04894_ _03184_ _03714_ _03715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08082_ _04898_ _03716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08083_ _03695_ _02991_ _02993_ _03716_ _03717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08084_ _03717_ _03026_ _03718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08085_ _03253_ _03717_ _03016_ _03719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08086_ _03718_ _03719_ _04891_ _03720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08087_ _03183_ _03715_ _03294_ _03720_ _03721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08088_ _03380_ _03713_ _03721_ net77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08089_ _03113_ _03680_ _03722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08090_ _04912_ _04928_ net271 _03723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08091_ _04880_ _04896_ _03102_ _03724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08092_ _03623_ _03723_ _03705_ _03724_ _03199_ _03150_ _03725_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_08093_ _03233_ _03356_ _03725_ _03726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08094_ _03116_ _03238_ _03393_ _03727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08095_ _03547_ _03727_ net187 _03728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08096_ _03294_ _03722_ _03726_ _03728_ _03729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08097_ _03116_ _03082_ _03730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08098_ _04837_ _03666_ _03363_ _03731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08099_ _03233_ _03107_ _03732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08100_ _03039_ _03067_ _03076_ _03392_ _03733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_08101_ _03552_ _03730_ _03731_ _03732_ _03733_ _03734_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08102_ _04882_ _03139_ _03735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08103_ _04886_ _03184_ _03735_ _03736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08104_ _03183_ _03736_ _03380_ _03737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08105_ _04890_ _03738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08106_ _04907_ _04914_ _04906_ _03739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08107_ _03695_ _03739_ _03716_ _03740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08108_ _04891_ _03740_ _03741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08109_ _03738_ _03741_ _03742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08110_ _04891_ _04899_ _03649_ _03696_ _03743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08111_ _03189_ _03742_ _03743_ _03194_ _03744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08112_ _03742_ _03745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08113_ _04891_ _04899_ _03649_ _03696_ _03746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08114_ _03745_ _03746_ _04883_ _03189_ _03747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08115_ _04883_ _03744_ _03747_ _03748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08116_ _03729_ _03734_ _03737_ _03748_ net78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08117_ _04874_ _03139_ _03749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08118_ _04878_ _03184_ _03749_ _03750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08119_ _03183_ _03750_ _03294_ _03751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08120_ _02994_ _03717_ _04882_ _02998_ _03752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08121_ _03253_ _03752_ _03753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08122_ _03280_ _03752_ _03028_ _03754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08123_ _03753_ _03754_ _04875_ _03755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08124_ _04872_ _04880_ _04888_ _04896_ _01115_ net271 _03756_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_08125_ _04904_ _04920_ _02892_ _03757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08126_ _03723_ _03757_ _03079_ _03758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08127_ _03756_ _03758_ net175 _03759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08128_ _03569_ _03759_ _03127_ _03760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08129_ _03269_ _03136_ _03761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08130_ _03238_ _03760_ _03421_ _03761_ _03762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08131_ _03238_ _03412_ _03763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08132_ _03259_ _03681_ _03764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08133_ _03731_ _03764_ _03011_ _03765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08134_ net187 _03763_ _03765_ _03766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08135_ _03751_ _03755_ _03762_ _03766_ net79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08136_ _04864_ _04872_ _04880_ _04888_ _01115_ net271 _03767_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_08137_ _03757_ _03688_ _03213_ _03768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08138_ _03767_ _03768_ net175 _03769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08139_ _03233_ _03356_ _03769_ _03770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08140_ _03233_ _03408_ _03589_ _03680_ _03431_ _03771_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_08141_ _03012_ _03770_ _03771_ _03772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08142_ _03427_ _03571_ _03773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08143_ _03432_ _03666_ _03731_ _03774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08144_ _03772_ _03773_ _03774_ _03775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08145_ _02995_ _03776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08146_ _03776_ _03697_ _02997_ _03000_ _03777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08147_ _03777_ _04867_ _03778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08148_ _04866_ _03018_ _03779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08149_ _04870_ _03014_ _03779_ _03780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08150_ _04867_ _03144_ _03780_ _03013_ _03294_ _03781_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_08151_ _03778_ _03189_ _03781_ _03782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08152_ _03782_ _03775_ net80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08153_ _03065_ _03681_ _03783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08154_ _03051_ _04833_ _03783_ _03784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08155_ _03065_ _03051_ _03668_ _03785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08156_ _03417_ _03784_ _03785_ _03012_ _03786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08157_ _03067_ _03456_ _03459_ _03269_ _03787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08158_ _04856_ _04864_ _04872_ _04880_ _01116_ net271 _03788_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_08159_ _03624_ _03626_ _03788_ _03706_ net175 _03127_ _03789_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_08160_ net187 _03789_ _03790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08161_ _03076_ _03787_ _03790_ _03791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08162_ _04858_ _03139_ _03792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08163_ _04862_ _03184_ _03792_ _03793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08164_ _03025_ _03003_ _03794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08165_ _03003_ _03253_ _03016_ _03795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08166_ _03794_ _03795_ _04859_ _03796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08167_ _03183_ _03793_ _03294_ _03796_ _03797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08168_ _03786_ _03791_ _03797_ net81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08169_ _03076_ _03477_ _03798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08170_ _02699_ _03765_ _03798_ _03799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08171_ _04856_ _04872_ _03102_ _03800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08172_ _04848_ _04864_ _03102_ _03801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08173_ _03705_ _03724_ _03800_ _03801_ _03213_ _03064_ _03802_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_08174_ _03529_ _03802_ _03803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08175_ _03480_ _03803_ _03804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08176_ net178 _03238_ _03637_ _03805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08177_ _03039_ _03765_ _03804_ _03805_ _03806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08178_ _04851_ _03026_ _03807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08179_ _04851_ _03808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08180_ _03808_ _03026_ _03809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08181_ _04858_ _03810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08182_ _04883_ _03742_ _03811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08183_ _04882_ _03811_ _04875_ _03812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08184_ _02995_ _03696_ _03813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08185_ _03648_ _03813_ _03814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08186_ _04866_ _04874_ _03815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08187_ _03810_ _03812_ _03814_ _03815_ _03816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08188_ _02981_ _03813_ _03817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08189_ _03599_ _03604_ _03608_ _03817_ _03818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08190_ _04867_ _04866_ _04859_ _03819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08191_ _03816_ _03818_ _03819_ _03810_ _03820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08192_ _03807_ _03809_ _03820_ _03821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08193_ _04850_ _03138_ _03822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08194_ _04854_ _02941_ _03822_ _03823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08195_ _04851_ _03028_ _03823_ _02937_ _03136_ _03824_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_08196_ _03821_ _03824_ _03825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08197_ _03799_ _03806_ _03825_ net82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08198_ _03486_ _03492_ _03160_ _03826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08199_ _03571_ _03826_ _03827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08200_ _03668_ _03731_ _03299_ _03828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08201_ _03160_ net175 _03356_ _03756_ _03829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08202_ _03257_ _03666_ _03830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08203_ _04840_ _04856_ _03101_ _03831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08204_ _03801_ _03831_ _03199_ _03832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08205_ _03731_ _03830_ _03832_ _03085_ _03011_ _03833_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_08206_ _03730_ _03672_ _03834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08207_ _03828_ _03829_ _03833_ _03834_ _03835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08208_ _04842_ _03017_ _03836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08209_ _04846_ _02941_ _03836_ _03837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08210_ _03031_ _03837_ _03136_ _03838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08211_ _04851_ _04859_ _03794_ _03839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08212_ _04851_ _04858_ _03026_ _03840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08213_ _04850_ _03280_ _03840_ _04843_ _03841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08214_ _03838_ _03839_ _03841_ _03842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08215_ _04859_ _03003_ _04858_ _03843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08216_ _04850_ _03844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08217_ _03808_ _03843_ _03280_ _03844_ _03845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08218_ _04843_ _03194_ _03845_ _03838_ _03846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08219_ _03827_ _03835_ _03846_ _03842_ net84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08220_ _04859_ _04866_ _04858_ _03847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08221_ _03808_ _03847_ _03844_ _03848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08222_ _04843_ _03848_ _04842_ _03849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08223_ _04835_ _03280_ _03849_ _03850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08224_ _04851_ _04859_ _04867_ _04843_ _03851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08225_ _04835_ _03023_ _03851_ _03852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08226_ _03850_ _03852_ _03777_ _03853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08227_ _04834_ _03018_ _03854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08228_ _04838_ _03014_ _03854_ _03855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08229_ _04835_ _03851_ _03856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08230_ _02929_ _03856_ _03849_ _03857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08231_ _02929_ _03194_ _03011_ _03858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08232_ _03013_ _03855_ _03857_ _03280_ _03858_ _03859_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08233_ _01258_ _04848_ _03101_ _03860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08234_ _03831_ _03860_ _03057_ _03861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08235_ _03767_ _03861_ _03054_ _03862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08236_ _03690_ _03862_ _03159_ _03863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08237_ _03340_ _03680_ _03462_ _03136_ _03864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08238_ _03516_ _03571_ _03863_ _03356_ _03864_ _03865_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08239_ _03853_ _03859_ _03865_ net85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08240_ net60 _00000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_20
X_08241_ _01029_ _02409_ _03866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08242_ _01109_ _03866_ _03867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08243_ _03867_ _03868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08244_ net95 _04824_ _03868_ _05078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08245_ net106 net242 _03868_ _04820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08246_ net117 net259 _03868_ _05083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08247_ net120 _05056_ _03868_ _05087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08248_ net121 _05048_ _03868_ _05093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08249_ net122 _05040_ _03868_ _05097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08250_ net123 _05032_ _03868_ _05101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08251_ net124 _05024_ _03868_ _05105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08252_ net125 net172 _03868_ _05109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08253_ net126 net185 _03868_ _05113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08254_ _03867_ _03869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_08255_ net96 _05000_ _03869_ _05117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08256_ net97 _04992_ _03869_ _05121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08257_ net98 _04984_ _03869_ _05125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08258_ net99 _04976_ _03869_ _05129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08259_ net100 _04968_ _03869_ _05133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08260_ net101 _04960_ _03869_ _05137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08261_ net102 net263 _03869_ _05141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08262_ net103 _04944_ _03869_ _05145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08263_ net104 _04936_ _03869_ _05149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08264_ net105 _04928_ _03869_ _05153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08265_ _03867_ _03870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_08266_ net107 _04920_ _03870_ _05157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08267_ net108 _04912_ _03870_ _05161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08268_ net109 _04904_ _03870_ _05165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08269_ net110 _04896_ _03870_ _05169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08270_ net111 _04888_ _03870_ _05173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08271_ net112 _04880_ _03870_ _05177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08272_ net113 _04872_ _03870_ _05181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08273_ net114 _04864_ _03870_ _05185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08274_ net115 _04856_ _03870_ _05189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08275_ net116 _04848_ _03870_ _05193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08276_ net118 _04840_ _03867_ _05197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08277_ _01110_ _05079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08278_ _01922_ _05158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08279_ _01090_ _02675_ _03871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08280_ _03871_ _03872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08281_ _02243_ _04968_ _03873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08282_ _02336_ _04984_ _03874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08283_ _02244_ _02258_ _02274_ _03875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08284_ _02289_ _03876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_08285_ _04980_ _03874_ _03875_ _03876_ _03877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08286_ _04980_ _03875_ _03874_ _03878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08287_ _03873_ _03877_ _03878_ _03879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08288_ _02289_ _04976_ _02336_ _04984_ _03880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_08289_ _02244_ _04972_ _03876_ _04980_ _03880_ _03881_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08290_ _02476_ net183 _03882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08291_ _02515_ net171 _02476_ _03883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08292_ _02515_ net170 net182 _03884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08293_ _03882_ _03883_ _03884_ _05004_ _02427_ _03885_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_08294_ _02427_ _05004_ _03886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08295_ _02375_ _04996_ _03875_ _03887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08296_ _03881_ _03885_ _03886_ _03887_ _03888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08297_ _02244_ _04972_ _03889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08298_ _02375_ _02408_ _03890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08299_ _03889_ _03881_ _03890_ _03891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08300_ _04960_ _03879_ _03888_ _03891_ _03892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08301_ _02604_ _05032_ _03893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08302_ _05028_ _03893_ _03894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08303_ _05028_ _03893_ net157 _03895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08304_ _02903_ _02910_ _03896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08305_ _01416_ _02912_ _03897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08306_ _01576_ _02917_ _03897_ _03898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08307_ _01697_ _02920_ _02922_ _03899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08308_ dp.rf.rf\[20\]\[1\] _03900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08309_ _01328_ _02925_ _03901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08310_ _03900_ _01327_ _03901_ _01529_ _03902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08311_ dp.rf.rf\[16\]\[1\] _01356_ _03902_ _01541_ _01206_
+ _03903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08312_ _01385_ _03898_ _03899_ _03903_ _03904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_08313_ _02868_ _02870_ _02872_ _02874_ _03905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08314_ _01778_ _02887_ _03905_ _01780_ _03906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08315_ _03896_ _03904_ _02884_ _03906_ _03907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08316_ _02811_ net260 _01062_ net169 _03908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08317_ _02903_ _02910_ net139 _03909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08318_ _02811_ net260 _03904_ _03909_ _03910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08319_ _02811_ _05064_ _03911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08320_ _03907_ _03908_ _03910_ _03911_ _03912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08321_ _02696_ _05048_ _05040_ _03913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08322_ _05040_ _02696_ _05048_ _03914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08323_ net155 _03913_ _03914_ _05060_ _03915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08324_ net155 _03916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08325_ _03916_ _05040_ _02696_ _05048_ _03917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08326_ net155 _05044_ _03917_ _03918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08327_ _03894_ _03895_ _03912_ _03915_ _03918_ _03919_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_08328_ _05040_ _02696_ _05048_ _03920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08329_ net155 _03913_ _03921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08330_ net153 _05060_ _03922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08331_ net155 _03913_ _03914_ net153 _03923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08332_ _03920_ _03921_ _03922_ _03923_ _03912_ _03924_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_08333_ _02604_ _05032_ _03925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08334_ _05028_ _03925_ _03926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08335_ _05028_ _03925_ net157 _03927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08336_ _03926_ _03927_ _03928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08337_ _03919_ _03924_ _03928_ _03929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08338_ _04960_ _03890_ _03930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08339_ _02187_ _03890_ _03931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08340_ _03873_ _03877_ _03878_ _03932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08341_ _02476_ net181 _02515_ net170 _03933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08342_ _05004_ _03882_ _03933_ _03934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08343_ _02375_ _04996_ _03935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08344_ _02375_ _04996_ _02427_ _03936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08345_ _03882_ _03933_ _02459_ _03937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08346_ _03934_ _03935_ _03936_ _03937_ _03938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08347_ _03930_ _03931_ _03932_ _03938_ _03939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08348_ _02187_ _03940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08349_ _03940_ _04964_ _03941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08350_ _02187_ _04960_ _03889_ _03881_ _03942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08351_ _03941_ _03942_ _03943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08352_ _03892_ _03929_ _03939_ _03943_ _03944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08353_ _03919_ _03924_ _03945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08354_ _03879_ _03888_ _03891_ _04960_ _03946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08355_ _03940_ _03928_ _03947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08356_ _03945_ _03946_ _03947_ _03948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08357_ _02095_ _03949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08358_ _02139_ net263 _03950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08359_ _03949_ _04948_ _03950_ _03951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08360_ _02050_ _03952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_08361_ _03952_ _04940_ _03949_ _04948_ _03953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08362_ _01989_ _04928_ _02050_ _04936_ _03951_ _03953_ _03954_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_08363_ _01785_ _01817_ _03955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08364_ _01841_ _01871_ _03956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08365_ _01886_ _01918_ _03957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08366_ _01886_ _01918_ _01938_ _01974_ _03958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08367_ _01841_ _01871_ _03959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08368_ _03956_ _03957_ _03958_ _03959_ _03960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08369_ _01990_ _04932_ _03961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08370_ _03955_ _03960_ _03961_ _03962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08371_ _01841_ _01871_ _01886_ _01918_ _01938_ _04920_ _03963_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_4
X_08372_ _01841_ _04904_ _01886_ _04912_ _03964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08373_ _03956_ _03963_ _03964_ _03965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08374_ _01785_ _04896_ _03966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08375_ _03955_ _03965_ _03966_ _03967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08376_ _03954_ _03962_ _03967_ _03968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08377_ _01565_ _01590_ _01604_ _03969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08378_ _01590_ _01604_ _01565_ _03970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08379_ _01622_ _04876_ _03969_ _03970_ _03971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08380_ _01739_ _01743_ _01753_ _01760_ _01726_ _03972_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08381_ _01696_ _01710_ _03972_ _03973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08382_ _01696_ _01710_ _03972_ _01683_ _03974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08383_ _01622_ _04876_ _03973_ _03974_ _03969_ _03975_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_08384_ _03971_ _03975_ _03976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08385_ _01257_ _01284_ _03977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08386_ _01257_ _01284_ _03978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08387_ _03977_ _03978_ _03979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_08388_ _01321_ _04840_ _03980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08389_ _01412_ _01469_ _03981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08390_ _01412_ _01469_ _01489_ _01544_ _03982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08391_ _03981_ _03982_ _03983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08392_ net5 _02362_ _03984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08393_ _03977_ _03978_ _03984_ _03985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08394_ _03979_ _03980_ _03983_ _03985_ _03986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08395_ _03976_ _03986_ _03987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08396_ _03979_ _03988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_08397_ _04844_ _03981_ _03982_ _03989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08398_ _03981_ _03982_ _04844_ _03990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08399_ _01321_ _03989_ _03990_ _03991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08400_ _04876_ _03969_ _03992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08401_ _01683_ _01696_ _01710_ _03993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08402_ _01714_ _01718_ _03994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08403_ _03994_ _01725_ _03995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08404_ _03995_ _04888_ _01696_ _01710_ _03996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08405_ _03995_ _04888_ _01683_ _03997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08406_ _03993_ _03996_ _03997_ _03998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08407_ _01565_ _01590_ _01604_ _01621_ _03999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08408_ _03993_ _03999_ _03996_ _03997_ _04000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_08409_ _03992_ _03998_ _04000_ _03971_ _04001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08410_ _03985_ _04002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08411_ _03988_ _03991_ _04001_ _04002_ _04003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08412_ _03968_ _03987_ _04003_ _04004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08413_ _02170_ _01067_ _04005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08414_ _03944_ _03948_ _04004_ _04005_ _04006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08415_ _02139_ net263 _04007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08416_ _03952_ _04940_ _04948_ _04007_ _04008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08417_ _02108_ _02121_ _02139_ _02168_ _04009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_08418_ _04940_ _03949_ _04009_ _04010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08419_ _03952_ _03949_ _04009_ _04011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08420_ _01990_ _04932_ _03952_ _04940_ _04012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08421_ _04008_ _04010_ _04011_ _04012_ _04013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_08422_ _01989_ _04928_ _03966_ _03965_ _04014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08423_ _03955_ _03960_ _03966_ _04015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08424_ _04013_ _04014_ _04015_ _04016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08425_ _03988_ _03991_ _03976_ _04002_ _04017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08426_ _03979_ _03980_ _03985_ _04018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08427_ _01412_ _01469_ _01489_ _04856_ _04019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08428_ _01412_ _04848_ _04020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08429_ _04019_ _04020_ _04021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08430_ _01321_ _04840_ _03979_ _04021_ _04022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08431_ _04018_ _04022_ _04023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08432_ _04003_ _04016_ _04017_ _04023_ _04024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08433_ _02931_ _04024_ _03944_ _03948_ _04025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08434_ _02931_ _04024_ _04004_ _04026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08435_ _04024_ _04005_ _04027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08436_ _04006_ _04025_ _04026_ _04027_ _04028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08437_ _03009_ _03015_ _04029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08438_ _04029_ _04030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08439_ _03009_ _03008_ _04031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08440_ _04960_ _03879_ _03888_ _03891_ _04032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_08441_ _03928_ _04032_ _03946_ _03947_ _04033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08442_ _01321_ _04840_ _03988_ _03983_ _04034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08443_ _03978_ _03977_ _03984_ _04035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08444_ _01321_ _04036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08445_ _04036_ _04844_ _03979_ _04037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08446_ _04035_ _04037_ _04038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08447_ _02095_ _04944_ _02139_ _02168_ _04039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08448_ _02050_ _04936_ _02095_ _02122_ _04040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_08449_ _01990_ _04932_ _03952_ _04940_ _04039_ _04040_ _04041_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_4
X_08450_ _03955_ _03960_ _03961_ _04042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08451_ _03955_ _03965_ _04041_ _04042_ _03966_ _04043_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08452_ _03976_ _03986_ _04044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08453_ _04034_ _04038_ _04043_ _04044_ _04001_ _04045_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08454_ _03889_ _03881_ _04046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08455_ _03890_ _04047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08456_ _03932_ _03938_ _04047_ _04048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08457_ net153 _04049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08458_ _03904_ _03909_ _01062_ net169 _04050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08459_ _03907_ _04050_ _03911_ _04051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08460_ _04049_ net220 net193 _05064_ _04051_ _04052_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08461_ _03918_ _03922_ _04053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08462_ _03941_ _03921_ _04054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08463_ _04052_ _04053_ _04054_ _03914_ _04055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08464_ _04046_ _04048_ _03945_ _04055_ _04056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08465_ _04024_ _04033_ _04045_ _04056_ _04057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08466_ _04030_ _04031_ _04057_ _04058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08467_ _04028_ _04058_ _01083_ _04059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08468_ _03872_ _04059_ _04060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08469_ _04060_ _04061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_08470_ net95 _05080_ _04061_ _00001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08471_ _04823_ _04062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08472_ net106 _04062_ _04061_ _00002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08473_ dp.rf.rf\[0\]\[0\] _00003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08474_ dp.rf.rf\[0\]\[10\] _00004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08475_ dp.rf.rf\[0\]\[11\] _00005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08476_ dp.rf.rf\[0\]\[12\] _00006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08477_ dp.rf.rf\[0\]\[13\] _00007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08478_ dp.rf.rf\[0\]\[14\] _00008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08479_ dp.rf.rf\[0\]\[15\] _00009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08480_ dp.rf.rf\[0\]\[16\] _00010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08481_ dp.rf.rf\[0\]\[17\] _00011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08482_ dp.rf.rf\[0\]\[18\] _00012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08483_ dp.rf.rf\[0\]\[19\] _00013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08484_ dp.rf.rf\[0\]\[1\] _00014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08485_ dp.rf.rf\[0\]\[20\] _00015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08486_ dp.rf.rf\[0\]\[21\] _00016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08487_ dp.rf.rf\[0\]\[22\] _00017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08488_ dp.rf.rf\[0\]\[23\] _00018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08489_ dp.rf.rf\[0\]\[24\] _00019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08490_ dp.rf.rf\[0\]\[25\] _00020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08491_ dp.rf.rf\[0\]\[26\] _00021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08492_ dp.rf.rf\[0\]\[27\] _00022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08493_ dp.rf.rf\[0\]\[28\] _00023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08494_ dp.rf.rf\[0\]\[29\] _00024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08495_ dp.rf.rf\[0\]\[2\] _00025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08496_ dp.rf.rf\[0\]\[30\] _00026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08497_ dp.rf.rf\[0\]\[31\] _00027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08498_ dp.rf.rf\[0\]\[3\] _00028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08499_ dp.rf.rf\[0\]\[4\] _00029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08500_ dp.rf.rf\[0\]\[5\] _00030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08501_ dp.rf.rf\[0\]\[6\] _00031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08502_ dp.rf.rf\[0\]\[7\] _00032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08503_ dp.rf.rf\[0\]\[8\] _00033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08504_ dp.rf.rf\[0\]\[9\] _00034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_08505_ _03866_ _04063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08506_ _01090_ _02675_ _04064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08507_ _05080_ _04063_ _04064_ net95 _04065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_08508_ _03866_ _04064_ _04066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08509_ _04066_ _04067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08510_ _03089_ _04068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08511_ net28 _04068_ _04069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08512_ _03089_ _04065_ _04070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08513_ net61 _04070_ _04071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08514_ _04065_ _04067_ _04069_ _04071_ _04072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08515_ _04072_ _04073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08516_ _02672_ _02793_ _04074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08517_ net2 _04074_ _04075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08518_ net25 _04076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08519_ _01090_ _01029_ _01438_ _04077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08520_ _01090_ _01082_ _04077_ _01096_ _04078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08521_ _01063_ _04078_ _04079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_08522_ _04076_ _04079_ _04080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08523_ net26 _04080_ _04081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08524_ _04075_ _04081_ _04082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08525_ _04082_ _04083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08526_ dp.rf.rf\[10\]\[0\] _04073_ _04083_ _00035_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08527_ net29 _04084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08528_ _03015_ _03088_ _04085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08529_ _04085_ _04086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_08530_ _04086_ _04087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08531_ net57 _04029_ _04088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08532_ _03088_ _04088_ _04089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08533_ _04089_ _04090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08534_ _04090_ _04091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08535_ _04084_ _04087_ _04091_ _04092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08536_ net93 net62 _04067_ _04092_ _04093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08537_ _01029_ _02409_ _04094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_08538_ _04094_ _04095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08539_ _05108_ _05103_ _04096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08540_ _05107_ _04096_ _04097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08541_ _05100_ _04098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08542_ _05090_ _04099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08543_ _04822_ _05086_ _05085_ _04100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08544_ _05089_ _04101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08545_ _04099_ _04100_ _04101_ _04102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08546_ _05096_ _04102_ _05095_ _04103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08547_ _05099_ _04104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08548_ _04098_ _04103_ _04104_ _04105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08549_ _05108_ _05112_ _04106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08550_ _05104_ _04106_ _04107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08551_ _05112_ _04097_ _04105_ _04107_ _05111_ _04108_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08552_ _04108_ _04109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08553_ _05116_ _04109_ _04110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08554_ _05115_ _04110_ _04111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08555_ _05120_ _04111_ _04112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08556_ net121 _05091_ net122 _04113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08557_ net123 net124 net125 net126 _04114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08558_ _04113_ _04114_ _04115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08559_ _04115_ _04116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08560_ net96 _04116_ _04117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08561_ _04095_ _04112_ _04117_ _03872_ _04118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08562_ _04093_ _04118_ _04119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08563_ _04119_ _04120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08564_ dp.rf.rf\[10\]\[10\] _04120_ _04083_ _00036_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08565_ _03088_ _04088_ _04121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08566_ net30 _01069_ _04122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08567_ _04066_ _04123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08568_ _04068_ net63 _04121_ _04122_ _04123_ _04124_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08569_ _05096_ _04125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08570_ _05086_ _04126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08571_ _04819_ _05082_ _05081_ _04127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08572_ _05085_ _04128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08573_ _04126_ _04127_ _04128_ _04129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08574_ _05090_ _04129_ _05089_ _04130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08575_ _05095_ _04131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08576_ _04125_ _04130_ _04131_ _04132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08577_ _05100_ _04132_ _05099_ _04133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08578_ _05104_ _05116_ _04106_ _04134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08579_ _05112_ _05107_ _04135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08580_ _05111_ _04135_ _04136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08581_ _05116_ _05103_ _04137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08582_ _05116_ _04136_ _04137_ _04106_ _04138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08583_ _04133_ _04134_ _04138_ _04139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08584_ _05115_ _04139_ _04140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08585_ _05120_ _04140_ _05119_ _04141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08586_ _05124_ _04141_ _04142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08587_ net117 net120 net121 net122 _04143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08588_ _04114_ _04143_ _04144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08589_ _04144_ _04145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08590_ net96 _04145_ _04146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08591_ net97 _04146_ _04147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08592_ _04095_ _04142_ _04147_ _03872_ _04148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08593_ _04124_ _04148_ _04149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08594_ _04149_ _04150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_08595_ dp.rf.rf\[10\]\[11\] _04150_ _04083_ _00037_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08596_ _04063_ _04064_ _04151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08597_ _03089_ _03453_ _03465_ _04152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08598_ net31 _01069_ _04121_ _04153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08599_ _04094_ _04154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_08600_ _05120_ _04111_ _04155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08601_ _05119_ _04155_ _04156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08602_ _05124_ _04156_ _05123_ _04157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08603_ _05128_ _04157_ _04158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08604_ net96 net97 _04115_ _04159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08605_ net98 _04159_ _04160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08606_ _03871_ _04161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08607_ _04154_ _04158_ _04160_ _04161_ _04162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08608_ _04151_ _04152_ _04153_ _04162_ _04163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08609_ _04163_ _04164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08610_ dp.rf.rf\[10\]\[12\] _04164_ _04083_ _00038_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08611_ _03087_ _04165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08612_ net32 _01069_ _04121_ _04166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08613_ _04165_ _03484_ _04151_ _04166_ _04167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08614_ _05127_ _04168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08615_ _05124_ _04169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08616_ _04169_ _04141_ _04170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08617_ _05123_ _04170_ _05128_ _04171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08618_ _04168_ _04171_ _04172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08619_ _05132_ _04172_ _04173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08620_ net96 net97 net98 _04145_ _04174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08621_ net99 _04174_ _04175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08622_ _04063_ _04173_ _04175_ _04064_ _04176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_08623_ _04167_ _04176_ _04177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08624_ _04177_ _04178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08625_ dp.rf.rf\[10\]\[13\] _04178_ _04083_ _00039_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08626_ net33 _04179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08627_ _04179_ _04087_ _04091_ _04180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08628_ net93 net66 _04067_ _04180_ _04181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08629_ _03871_ _04182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_08630_ net96 net97 net98 net99 _04183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08631_ _04116_ _04183_ _04184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08632_ net100 _04184_ _04185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08633_ _05120_ _05124_ _05128_ _05132_ _04186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08634_ _05116_ _04186_ _04187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08635_ _05124_ _05119_ _04188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08636_ _05123_ _04188_ _05128_ _04189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08637_ _04168_ _04189_ _04190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08638_ _05132_ _04190_ _04186_ _05115_ _05131_ _04191_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08639_ _04108_ _04187_ _04191_ _04192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08640_ _05136_ _04192_ _04193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08641_ _04182_ _04185_ _04193_ _04154_ _04194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08642_ _04181_ _04194_ _04195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08643_ _04195_ _04196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08644_ dp.rf.rf\[10\]\[14\] _04196_ _04083_ _00040_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08645_ _04139_ _04186_ _04197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08646_ _04191_ _04197_ _04198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08647_ _05136_ _04198_ _05135_ _04199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08648_ _05140_ _04199_ _04200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08649_ _04095_ _04200_ _04201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08650_ net100 _04145_ _04183_ _04202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08651_ net101 _04202_ _04203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08652_ _03012_ _04165_ _04204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08653_ net34 _01069_ _04121_ _04205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08654_ _03511_ _04204_ _04205_ _04151_ _04206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08655_ _04182_ _04203_ _04206_ _03522_ _04207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08656_ _04201_ _04207_ _04208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08657_ _04208_ _04209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_08658_ dp.rf.rf\[10\]\[15\] _04209_ _04083_ _00041_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08659_ _04165_ _03540_ _04210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08660_ _03008_ _03088_ _04211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08661_ _04211_ _04212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08662_ _04211_ _04213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08663_ _03009_ net34 _04213_ _04214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08664_ _04214_ _04215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08665_ net35 _04212_ _04215_ _04216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08666_ _04087_ _04216_ _04091_ _04217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08667_ _04067_ _04217_ _04218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08668_ net100 net101 _04116_ _04183_ _04219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08669_ net102 _04219_ _04220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08670_ _05136_ _04192_ _04221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08671_ _05135_ _04221_ _04222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08672_ _05140_ _04222_ _05139_ _04223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08673_ _05144_ _04223_ _04224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08674_ _04161_ _04220_ _04224_ _04154_ _04225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08675_ _04210_ _04218_ _04225_ _04226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08676_ _04226_ _04227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08677_ dp.rf.rf\[10\]\[16\] _04227_ _04083_ _00042_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08678_ net36 _04212_ _04215_ _04228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08679_ _04086_ _04228_ _04090_ _04229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08680_ _04123_ _04229_ _04230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08681_ _03546_ _04204_ _04231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08682_ net100 net101 net102 _04183_ _04232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08683_ _04145_ _04232_ _04233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08684_ net103 _04233_ _04234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08685_ _05136_ _05140_ _05144_ _04235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08686_ _05143_ _04236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08687_ _05140_ _05135_ _04237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08688_ _05139_ _04237_ _05144_ _04238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08689_ _04236_ _04238_ _04239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08690_ _04198_ _04235_ _04239_ _04240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08691_ _05148_ _04240_ _04241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08692_ _04161_ _04234_ _04241_ _04154_ _04242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08693_ _03561_ _04230_ _04231_ _04242_ _04243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08694_ _04243_ _04244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08695_ _04082_ _04245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_08696_ dp.rf.rf\[10\]\[17\] _04244_ _04245_ _00043_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08697_ net57 _04086_ _04213_ net34 _04246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08698_ net5 net37 _04247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08699_ _02170_ _04246_ _04247_ _03089_ _04248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08700_ net93 net70 _04067_ _04248_ _04249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08701_ net103 _04116_ _04232_ _04250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08702_ net104 _04250_ _04251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08703_ _05148_ _04252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08704_ _04192_ _04235_ _04239_ _04253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08705_ _05147_ _04254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08706_ _04252_ _04253_ _04254_ _04255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08707_ _05152_ _04255_ _04256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08708_ _04182_ _04251_ _04256_ _04154_ _04257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08709_ _04249_ _04257_ _04258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08710_ _04258_ _04259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08711_ dp.rf.rf\[10\]\[18\] _04259_ _04245_ _00044_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08712_ net38 _04212_ _04215_ _04260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08713_ _04087_ _04260_ _04091_ _04261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08714_ net93 net71 _04123_ _04261_ _04262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08715_ net103 net104 _04145_ _04232_ _04263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08716_ net105 _04263_ _04264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08717_ _04252_ _04240_ _04254_ _04265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08718_ _05152_ _04265_ _05151_ _04266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08719_ _05156_ _04266_ _04267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08720_ _04182_ _04264_ _04267_ _04154_ _04268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08721_ _04262_ _04268_ _04269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08722_ _04269_ _04270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_08723_ dp.rf.rf\[10\]\[19\] _04270_ _04245_ _00045_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08724_ net106 _04064_ _04271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08725_ net39 _03089_ _04272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08726_ _04165_ net72 _04151_ _04272_ _04273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08727_ _04823_ _04095_ _04271_ _04273_ _04274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08728_ _04274_ _04275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08729_ dp.rf.rf\[10\]\[1\] _04275_ _04245_ _00046_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08730_ _04165_ _03634_ _04276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08731_ net40 _04212_ _04215_ _04277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08732_ _04087_ _04277_ _04091_ _04278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08733_ _04067_ _04278_ _04279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08734_ _05148_ _05152_ _04192_ _04235_ _04280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08735_ _05148_ _05152_ _04239_ _04281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08736_ _05152_ _05147_ _04282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08737_ _04281_ _04282_ _04283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08738_ _05151_ _04280_ _04283_ _04284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08739_ _05156_ _04284_ _05155_ _04285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08740_ _05160_ _04285_ _04286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08741_ net103 net104 net105 _04232_ _04287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08742_ _04116_ _04287_ _04288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08743_ net107 _04288_ _04289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08744_ _04154_ _04286_ _04289_ _04161_ _04290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08745_ _04276_ _04279_ _04290_ _04291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08746_ _04291_ _04292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_08747_ dp.rf.rf\[10\]\[20\] _04292_ _04245_ _00047_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08748_ net41 _04212_ _04215_ _04293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08749_ _04087_ _04293_ _04091_ _04294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08750_ net93 net74 _04123_ _04294_ _04295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08751_ _05160_ _04296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08752_ _05148_ _04186_ _04235_ _04297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08753_ _05148_ _04235_ _04298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08754_ _05148_ _04239_ _04299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08755_ _04191_ _04298_ _04299_ _04300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08756_ _05147_ _05151_ _05155_ _04301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08757_ _04139_ _04297_ _04300_ _04301_ _04302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08758_ _05152_ _05151_ _04303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08759_ _05156_ _04303_ _05155_ _04304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08760_ _05159_ _04305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08761_ _04296_ _04302_ _04304_ _04305_ _04306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08762_ _05164_ _04306_ _04307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08763_ net107 _04287_ _04308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08764_ _04145_ _04308_ _04309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08765_ net108 _04309_ _04310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08766_ _04095_ _04307_ _04310_ _03872_ _04311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08767_ _04295_ _04311_ _04312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08768_ _04312_ _04313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08769_ dp.rf.rf\[10\]\[21\] _04313_ _04245_ _00048_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08770_ net42 _04212_ _04215_ _04314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08771_ _04087_ _04314_ _04091_ _04315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08772_ net93 net75 _04123_ _04315_ _04316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08773_ _05151_ _05155_ _04317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08774_ _05156_ _05155_ _04318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08775_ _05160_ _04318_ _04319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08776_ _04280_ _04283_ _04317_ _04319_ _04320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08777_ _04305_ _04320_ _04321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08778_ _05164_ _04321_ _05163_ _04322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08779_ _05168_ _04322_ _04323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08780_ net108 _04116_ _04308_ _04324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08781_ net109 _04324_ _04325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08782_ _04095_ _04323_ _04325_ _03872_ _04326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08783_ _04316_ _04326_ _04327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08784_ _04327_ _04328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_08785_ dp.rf.rf\[10\]\[22\] _04328_ _04245_ _00049_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08786_ _05167_ _04329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08787_ _05164_ _04306_ _04330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08788_ _05163_ _04330_ _05168_ _04331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08789_ _04329_ _04331_ _04332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08790_ _05172_ _04332_ _04333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08791_ net43 _04211_ _04214_ _04334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08792_ _04086_ _04334_ _04090_ _04335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08793_ _04123_ _04335_ _04336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08794_ _03694_ _03703_ _03089_ _04337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08795_ net108 net109 _04338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08796_ _04145_ _04308_ _04338_ _04339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08797_ net110 _04339_ _04340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08798_ _04063_ _04333_ _04336_ _04337_ _04340_ _04064_ _04341_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_4
X_08799_ _04341_ _04342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_08800_ dp.rf.rf\[10\]\[23\] _04342_ _04245_ _00050_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08801_ _03335_ _03710_ _03721_ _04343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08802_ _04068_ _04343_ _04344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08803_ net44 _04212_ _04215_ _04345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08804_ _04087_ _04345_ _04091_ _04346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08805_ _03343_ _03712_ _04347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08806_ _04067_ _04346_ _04347_ _04348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08807_ net110 _04116_ _04308_ _04338_ _04349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08808_ net111 _04349_ _04350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08809_ _05159_ _05163_ _05167_ _04351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08810_ _05164_ _05163_ _04352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08811_ _05168_ _04352_ _05167_ _04353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08812_ _04320_ _04351_ _04353_ _04354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08813_ _05172_ _04354_ _05171_ _04355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08814_ _05176_ _04355_ _04356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08815_ _04161_ _04350_ _04356_ _04154_ _04357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_08816_ _04344_ _04348_ _04357_ _04358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08817_ _04358_ _04359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_08818_ dp.rf.rf\[10\]\[24\] _04359_ _04245_ _00051_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08819_ net45 _04212_ _04215_ _04360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08820_ _04087_ _04360_ _04091_ _04361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08821_ net93 net78 _04123_ _04361_ _04362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08822_ net110 net111 _04308_ _04338_ _04363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08823_ _04145_ _04363_ _04364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08824_ net112 _04364_ _04365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08825_ _05168_ _05172_ _05176_ _04366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08826_ _05160_ _05164_ _04366_ _04367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08827_ _04302_ _04304_ _04367_ _04368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08828_ _05171_ _04369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08829_ _05168_ _05163_ _04370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08830_ _05167_ _04370_ _05172_ _04371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08831_ _04369_ _04371_ _04372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08832_ _05164_ _05159_ _04366_ _04373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08833_ _05176_ _04372_ _04373_ _05175_ _04374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08834_ _05180_ _04375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08835_ _04368_ _04374_ _04375_ _04376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08836_ _04375_ _04368_ _04374_ _04377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08837_ _04376_ _04377_ _04378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08838_ _03872_ _04365_ _04378_ _04154_ _04379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08839_ _04362_ _04379_ _04380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08840_ _04380_ _04381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_08841_ dp.rf.rf\[10\]\[25\] _04381_ _04245_ _00052_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08842_ _05184_ _04382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08843_ _05171_ _05175_ _05179_ _04383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08844_ _05172_ _05171_ _05176_ _04384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08845_ _05175_ _05179_ _04385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08846_ _04384_ _04385_ _04386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08847_ _05180_ _05179_ _04354_ _04383_ _04386_ _04387_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08848_ _04382_ _04387_ _04388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08849_ net112 _04116_ _04363_ _04389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08850_ net113 _04389_ _04390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08851_ net46 _04211_ _04214_ _04391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08852_ _04086_ _04391_ _04090_ _04392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08853_ _04068_ net79 _04066_ _04392_ _04393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08854_ _04063_ _04388_ _04390_ _04064_ _04393_ _04394_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08855_ _04394_ _04395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08856_ _04082_ _04396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_08857_ dp.rf.rf\[10\]\[26\] _04395_ _04396_ _00053_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08858_ _03775_ _03782_ _04068_ _04397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08859_ net47 _04212_ _04215_ _04398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08860_ _04087_ _04398_ _04091_ _04399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08861_ _04067_ _04399_ _04400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08862_ _05183_ _04401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08863_ _05179_ _04376_ _05184_ _04402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08864_ _04401_ _04402_ _04403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08865_ _05188_ _04403_ _04404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08866_ net112 net113 _04145_ _04363_ _04405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08867_ net114 _04405_ _04406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08868_ _04154_ _04404_ _04406_ _04161_ _04407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08869_ _04397_ _04400_ _04407_ _04408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08870_ _04408_ _04409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08871_ dp.rf.rf\[10\]\[27\] _04409_ _04396_ _00054_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08872_ _04382_ _04387_ _04401_ _04410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08873_ _05188_ _04410_ _05187_ _04411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08874_ _05192_ _04411_ _04412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08875_ net112 net113 net114 _04363_ _04413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08876_ _04116_ _04413_ _04414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08877_ net115 _04414_ _04415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08878_ _03872_ _04415_ _04416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08879_ net48 _04211_ _04214_ _04417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08880_ _04086_ _04417_ _04090_ _04418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08881_ _04068_ net81 _04066_ _04418_ _04419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08882_ _04063_ _04412_ _04416_ _04419_ _04420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08883_ _04420_ _04421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_08884_ dp.rf.rf\[10\]\[28\] _04421_ _04396_ _00055_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08885_ _05180_ _05184_ _05188_ _04422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08886_ _04368_ _04374_ _04422_ _04423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08887_ _05188_ _05183_ _04424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08888_ _05184_ _05188_ _05179_ _04425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08889_ _05187_ _04423_ _04424_ _04425_ _04426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08890_ _05192_ _04426_ _04427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08891_ _05191_ _04427_ _04428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08892_ _05196_ _04428_ _04429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08893_ net115 _04413_ _04430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08894_ _04145_ _04430_ _04431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08895_ net116 _04431_ _04432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08896_ net49 _04211_ _04214_ _04433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08897_ _04086_ _04433_ _04090_ _04434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08898_ _04066_ _04434_ _04435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08899_ _03799_ _03806_ _03825_ _04165_ _04436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08900_ _04161_ _04432_ _04435_ _04436_ _04437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08901_ _04063_ _04182_ _04429_ _04437_ _04438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08902_ _04438_ _04439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_08903_ dp.rf.rf\[10\]\[29\] _04439_ _04396_ _00056_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08904_ net50 _03089_ _04440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08905_ _04165_ net83 _04440_ _04441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08906_ net117 _04442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08907_ _04822_ _05086_ _04443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08908_ _04442_ _04064_ _04443_ _04063_ _04444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_08909_ _04067_ _04441_ _04444_ _04445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08910_ _04445_ _04446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_08911_ dp.rf.rf\[10\]\[2\] _04446_ _04396_ _00057_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08912_ _05184_ _05188_ _05192_ _04447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08913_ _05188_ _05192_ _05183_ _04448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08914_ _05192_ _05187_ _04448_ _04449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08915_ _05191_ _04450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08916_ _04387_ _04447_ _04449_ _04450_ _04451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08917_ _05196_ _04451_ _05195_ _04452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08918_ _05200_ _04452_ _04453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08919_ net51 _04212_ _04215_ _04454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08920_ _04086_ _04454_ _04090_ _04455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08921_ _04068_ net84 _04123_ _04455_ _04456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08922_ net116 _04430_ _04457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08923_ _04116_ _04457_ _04458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08924_ net118 _04458_ _04459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08925_ _03872_ _04459_ _04460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08926_ _04063_ _04453_ _04456_ _04460_ _04461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08927_ _04461_ _04462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08928_ dp.rf.rf\[10\]\[30\] _04462_ _04396_ _00058_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08929_ net119 _04833_ _03867_ _04463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08930_ _05187_ _05191_ _04464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08931_ _04423_ _04424_ _04425_ _04464_ _04465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_08932_ _05192_ _05191_ _05196_ _04466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08933_ _05195_ _04467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08934_ _04465_ _04466_ _04467_ _04468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08935_ _05200_ _04468_ _05199_ _04469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08936_ net20 _04463_ _04469_ _04470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_08937_ _04059_ _04470_ _04095_ _04471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08938_ _04471_ _04472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08939_ net118 _04144_ _04457_ _04473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08940_ net119 _04473_ _04474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08941_ _03871_ _04474_ _04475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08942_ _04165_ _03853_ _03859_ _04475_ _04476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08943_ net52 _04211_ _04214_ _04477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08944_ _04086_ _04477_ _04090_ _04478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08945_ _03871_ _04474_ _04478_ _04066_ _04479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08946_ _04165_ _03865_ _04475_ _04480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08947_ _04476_ _04479_ _04480_ _04481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_08948_ _04481_ _04482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_08949_ _04083_ _04482_ _04483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08950_ dp.rf.rf\[10\]\[31\] _04083_ _04484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08951_ _04472_ _04483_ _04484_ _00059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08952_ _04099_ _04129_ _04485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08953_ net53 _03089_ _04094_ _04485_ _03871_ _05092_ _04486_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_4
X_08954_ net93 _03226_ _04151_ _04486_ _04487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08955_ _04487_ _04488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08956_ dp.rf.rf\[10\]\[3\] _04488_ _04396_ _00060_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08957_ _03380_ _03256_ _04489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08958_ _03087_ _04066_ _04490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08959_ _03182_ _03248_ _04489_ _04490_ _04491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08960_ net121 _05091_ _04492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08961_ _04125_ _04102_ _04493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08962_ net54 _04068_ _04161_ _04492_ _04493_ _04094_ _04494_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_4
X_08963_ _04491_ _04494_ _04495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08964_ _04495_ _04496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_08965_ dp.rf.rf\[10\]\[4\] _04496_ _04396_ _00061_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08966_ net55 _04497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08967_ _04497_ _03293_ _04165_ _04498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08968_ _04098_ _04132_ _04499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08969_ net117 net120 net121 _04500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08970_ net122 _04500_ _04501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08971_ _04063_ _04499_ _04501_ _04064_ _04502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_08972_ _04067_ _04498_ _04502_ _04503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08973_ _04503_ _04504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08974_ dp.rf.rf\[10\]\[5\] _04504_ _04396_ _00062_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08975_ _05104_ _04105_ _04505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08976_ _04094_ _04505_ _04506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08977_ net123 _04113_ _04507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08978_ _03871_ _04507_ _04508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08979_ net89 _04490_ _04509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08980_ net56 _03089_ _04510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08981_ _04506_ _04508_ _04509_ _04510_ _04511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_08982_ _04511_ _04512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_08983_ dp.rf.rf\[10\]\[6\] _04512_ _04396_ _00063_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08984_ _04133_ _04513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08985_ _05104_ _04513_ _04514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08986_ _05103_ _04514_ _04515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08987_ _05108_ _04515_ _04516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08988_ _04095_ _04516_ _04517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08989_ net123 _04143_ _04518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08990_ net124 _04518_ _04519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08991_ _03355_ _04490_ _04520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08992_ net57 _04068_ _04161_ _04519_ _04520_ _03345_ _04521_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_4
X_08993_ _04517_ _04521_ _04522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08994_ _04522_ _04523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_08995_ dp.rf.rf\[10\]\[7\] _04523_ _04082_ _00064_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08996_ net58 _01069_ _04524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08997_ _04068_ net91 _04121_ _04524_ _04123_ _04525_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08998_ _05104_ _04105_ _04526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08999_ _05103_ _04526_ _04527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09000_ _05108_ _04527_ _05107_ _04528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09001_ _05112_ _04528_ _04529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09002_ net123 net124 _04113_ _04530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09003_ net125 _04530_ _04531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09004_ _04095_ _04529_ _04531_ _03872_ _04532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09005_ _04525_ _04532_ _04533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09006_ _04533_ _04534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09007_ dp.rf.rf\[10\]\[8\] _04534_ _04082_ _00065_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09008_ net59 _04535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09009_ _04535_ _04086_ _04090_ _04536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09010_ net93 net92 _04123_ _04536_ _04537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09011_ _04106_ _04515_ _04136_ _05116_ _04538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_09012_ _04139_ _04538_ _04539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09013_ net123 net124 net125 _04143_ _04540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09014_ net126 _04540_ _04541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09015_ _04095_ _04539_ _04541_ _03872_ _04542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09016_ _04537_ _04542_ _04543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09017_ _04543_ _04544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09018_ dp.rf.rf\[10\]\[9\] _04544_ _04082_ _00066_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09019_ net26 net25 _04079_ _04545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_09020_ _04075_ _04545_ _04546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09021_ _04546_ _04547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09022_ dp.rf.rf\[11\]\[0\] _04073_ _04547_ _00067_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09023_ dp.rf.rf\[11\]\[10\] _04120_ _04547_ _00068_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09024_ dp.rf.rf\[11\]\[11\] _04150_ _04547_ _00069_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09025_ dp.rf.rf\[11\]\[12\] _04164_ _04547_ _00070_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09026_ dp.rf.rf\[11\]\[13\] _04178_ _04547_ _00071_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09027_ dp.rf.rf\[11\]\[14\] _04196_ _04547_ _00072_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09028_ dp.rf.rf\[11\]\[15\] _04209_ _04547_ _00073_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09029_ dp.rf.rf\[11\]\[16\] _04227_ _04547_ _00074_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09030_ _04546_ _04548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09031_ dp.rf.rf\[11\]\[17\] _04244_ _04548_ _00075_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09032_ dp.rf.rf\[11\]\[18\] _04259_ _04548_ _00076_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09033_ dp.rf.rf\[11\]\[19\] _04270_ _04548_ _00077_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09034_ dp.rf.rf\[11\]\[1\] _04275_ _04548_ _00078_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09035_ dp.rf.rf\[11\]\[20\] _04292_ _04548_ _00079_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09036_ dp.rf.rf\[11\]\[21\] _04313_ _04548_ _00080_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09037_ dp.rf.rf\[11\]\[22\] _04328_ _04548_ _00081_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09038_ dp.rf.rf\[11\]\[23\] _04342_ _04548_ _00082_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09039_ dp.rf.rf\[11\]\[24\] _04359_ _04548_ _00083_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09040_ dp.rf.rf\[11\]\[25\] _04381_ _04548_ _00084_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09041_ _04546_ _04549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_09042_ dp.rf.rf\[11\]\[26\] _04395_ _04549_ _00085_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09043_ dp.rf.rf\[11\]\[27\] _04409_ _04549_ _00086_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09044_ dp.rf.rf\[11\]\[28\] _04421_ _04549_ _00087_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09045_ dp.rf.rf\[11\]\[29\] _04439_ _04549_ _00088_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09046_ dp.rf.rf\[11\]\[2\] _04446_ _04549_ _00089_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09047_ dp.rf.rf\[11\]\[30\] _04462_ _04549_ _00090_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09048_ _04481_ _04550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09049_ _04550_ _04547_ _04551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09050_ dp.rf.rf\[11\]\[31\] _04547_ _04552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09051_ _04472_ _04551_ _04552_ _00091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09052_ dp.rf.rf\[11\]\[3\] _04488_ _04549_ _00092_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09053_ dp.rf.rf\[11\]\[4\] _04496_ _04549_ _00093_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09054_ dp.rf.rf\[11\]\[5\] _04504_ _04549_ _00094_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09055_ dp.rf.rf\[11\]\[6\] _04512_ _04549_ _00095_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09056_ dp.rf.rf\[11\]\[7\] _04523_ _04546_ _00096_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09057_ dp.rf.rf\[11\]\[8\] _04534_ _04546_ _00097_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09058_ dp.rf.rf\[11\]\[9\] _04544_ _04546_ _00098_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09059_ _04072_ _04553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09060_ _02672_ net2 net27 _04554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09061_ net2 _04555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09062_ _04555_ _04074_ _04556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09063_ net26 _04556_ _04557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09064_ _04080_ _04557_ _04558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09065_ _04554_ _04558_ _04559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09066_ _04559_ _04560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09067_ dp.rf.rf\[12\]\[0\] _04553_ _04560_ _00099_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09068_ _04119_ _04561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09069_ dp.rf.rf\[12\]\[10\] _04561_ _04560_ _00100_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09070_ _04149_ _04562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09071_ dp.rf.rf\[12\]\[11\] _04562_ _04560_ _00101_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09072_ _04163_ _04563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09073_ dp.rf.rf\[12\]\[12\] _04563_ _04560_ _00102_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09074_ _04177_ _04564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09075_ dp.rf.rf\[12\]\[13\] _04564_ _04560_ _00103_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09076_ _04195_ _04565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09077_ dp.rf.rf\[12\]\[14\] _04565_ _04560_ _00104_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09078_ _04208_ _04566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09079_ dp.rf.rf\[12\]\[15\] _04566_ _04560_ _00105_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09080_ _04226_ _04567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09081_ dp.rf.rf\[12\]\[16\] _04567_ _04560_ _00106_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09082_ _04243_ _04568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09083_ _04559_ _04569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_09084_ dp.rf.rf\[12\]\[17\] _04568_ _04569_ _00107_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09085_ _04258_ _04570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09086_ dp.rf.rf\[12\]\[18\] _04570_ _04569_ _00108_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09087_ _04269_ _04571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09088_ dp.rf.rf\[12\]\[19\] _04571_ _04569_ _00109_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09089_ _04274_ _04572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09090_ dp.rf.rf\[12\]\[1\] _04572_ _04569_ _00110_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09091_ _04291_ _04573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09092_ dp.rf.rf\[12\]\[20\] _04573_ _04569_ _00111_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09093_ _04312_ _04574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09094_ dp.rf.rf\[12\]\[21\] _04574_ _04569_ _00112_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09095_ _04327_ _04575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09096_ dp.rf.rf\[12\]\[22\] _04575_ _04569_ _00113_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09097_ _04341_ _04576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09098_ dp.rf.rf\[12\]\[23\] _04576_ _04569_ _00114_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09099_ _04358_ _04577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09100_ dp.rf.rf\[12\]\[24\] _04577_ _04569_ _00115_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09101_ _04380_ _04578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09102_ dp.rf.rf\[12\]\[25\] _04578_ _04569_ _00116_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09103_ _04394_ _04579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09104_ _04559_ _04580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09105_ dp.rf.rf\[12\]\[26\] _04579_ _04580_ _00117_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09106_ _04408_ _04581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09107_ dp.rf.rf\[12\]\[27\] _04581_ _04580_ _00118_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09108_ _04420_ _04582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09109_ dp.rf.rf\[12\]\[28\] _04582_ _04580_ _00119_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09110_ _04438_ _04583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09111_ dp.rf.rf\[12\]\[29\] _04583_ _04580_ _00120_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09112_ _04445_ _04584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09113_ dp.rf.rf\[12\]\[2\] _04584_ _04580_ _00121_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09114_ _04461_ _04585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09115_ dp.rf.rf\[12\]\[30\] _04585_ _04580_ _00122_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09116_ _04550_ _04560_ _04586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09117_ dp.rf.rf\[12\]\[31\] _04560_ _04587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09118_ _04472_ _04586_ _04587_ _00123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09119_ _04487_ _04588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09120_ dp.rf.rf\[12\]\[3\] _04588_ _04580_ _00124_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09121_ _04495_ _04589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09122_ dp.rf.rf\[12\]\[4\] _04589_ _04580_ _00125_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09123_ _04503_ _04590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09124_ dp.rf.rf\[12\]\[5\] _04590_ _04580_ _00126_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09125_ _04511_ _04591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09126_ dp.rf.rf\[12\]\[6\] _04591_ _04580_ _00127_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09127_ _04522_ _04592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09128_ dp.rf.rf\[12\]\[7\] _04592_ _04559_ _00128_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09129_ _04533_ _04593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09130_ dp.rf.rf\[12\]\[8\] _04593_ _04559_ _00129_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09131_ _04543_ _04594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09132_ dp.rf.rf\[12\]\[9\] _04594_ _04559_ _00130_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09133_ _01101_ net25 _04079_ _04595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_09134_ _04554_ _04595_ _04596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09135_ _04596_ _04597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09136_ _04073_ dp.rf.rf\[13\]\[0\] _04597_ _00131_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09137_ _04120_ dp.rf.rf\[13\]\[10\] _04597_ _00132_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09138_ _04150_ dp.rf.rf\[13\]\[11\] _04597_ _00133_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09139_ _04164_ dp.rf.rf\[13\]\[12\] _04597_ _00134_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09140_ _04178_ dp.rf.rf\[13\]\[13\] _04597_ _00135_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09141_ _04196_ dp.rf.rf\[13\]\[14\] _04597_ _00136_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09142_ _04209_ dp.rf.rf\[13\]\[15\] _04597_ _00137_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09143_ _04227_ dp.rf.rf\[13\]\[16\] _04597_ _00138_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09144_ _04244_ dp.rf.rf\[13\]\[17\] _04597_ _00139_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09145_ _04596_ _04598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_09146_ _04259_ dp.rf.rf\[13\]\[18\] _04598_ _00140_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09147_ _04270_ dp.rf.rf\[13\]\[19\] _04598_ _00141_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09148_ _04275_ dp.rf.rf\[13\]\[1\] _04598_ _00142_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09149_ _04292_ dp.rf.rf\[13\]\[20\] _04598_ _00143_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09150_ _04313_ dp.rf.rf\[13\]\[21\] _04598_ _00144_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09151_ _04328_ dp.rf.rf\[13\]\[22\] _04598_ _00145_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09152_ _04342_ dp.rf.rf\[13\]\[23\] _04598_ _00146_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09153_ _04359_ dp.rf.rf\[13\]\[24\] _04598_ _00147_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09154_ _04381_ dp.rf.rf\[13\]\[25\] _04598_ _00148_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09155_ _04395_ dp.rf.rf\[13\]\[26\] _04598_ _00149_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09156_ _04596_ _04599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_09157_ _04409_ dp.rf.rf\[13\]\[27\] _04599_ _00150_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09158_ _04421_ dp.rf.rf\[13\]\[28\] _04599_ _00151_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09159_ _04439_ dp.rf.rf\[13\]\[29\] _04599_ _00152_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09160_ _04446_ dp.rf.rf\[13\]\[2\] _04599_ _00153_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09161_ _04462_ dp.rf.rf\[13\]\[30\] _04599_ _00154_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09162_ dp.rf.rf\[13\]\[31\] _04600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09163_ _04595_ _04601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09164_ _04482_ _04554_ _04601_ _04602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09165_ _04471_ _04603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09166_ _04600_ _04597_ _04602_ _04603_ _00155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09167_ _04488_ dp.rf.rf\[13\]\[3\] _04599_ _00156_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09168_ _04496_ dp.rf.rf\[13\]\[4\] _04599_ _00157_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09169_ _04504_ dp.rf.rf\[13\]\[5\] _04599_ _00158_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09170_ _04512_ dp.rf.rf\[13\]\[6\] _04599_ _00159_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09171_ _04523_ dp.rf.rf\[13\]\[7\] _04599_ _00160_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09172_ _04534_ dp.rf.rf\[13\]\[8\] _04596_ _00161_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09173_ _04544_ dp.rf.rf\[13\]\[9\] _04596_ _00162_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09174_ _04081_ _04554_ _04604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09175_ _04604_ _04605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09176_ dp.rf.rf\[14\]\[0\] _04553_ _04605_ _00163_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09177_ dp.rf.rf\[14\]\[10\] _04561_ _04605_ _00164_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09178_ dp.rf.rf\[14\]\[11\] _04562_ _04605_ _00165_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09179_ dp.rf.rf\[14\]\[12\] _04563_ _04605_ _00166_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09180_ dp.rf.rf\[14\]\[13\] _04564_ _04605_ _00167_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09181_ dp.rf.rf\[14\]\[14\] _04565_ _04605_ _00168_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09182_ dp.rf.rf\[14\]\[15\] _04566_ _04605_ _00169_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09183_ dp.rf.rf\[14\]\[16\] _04567_ _04605_ _00170_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09184_ _04604_ _04606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_09185_ dp.rf.rf\[14\]\[17\] _04568_ _04606_ _00171_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09186_ dp.rf.rf\[14\]\[18\] _04570_ _04606_ _00172_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09187_ dp.rf.rf\[14\]\[19\] _04571_ _04606_ _00173_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09188_ dp.rf.rf\[14\]\[1\] _04572_ _04606_ _00174_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09189_ dp.rf.rf\[14\]\[20\] _04573_ _04606_ _00175_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09190_ dp.rf.rf\[14\]\[21\] _04574_ _04606_ _00176_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09191_ dp.rf.rf\[14\]\[22\] _04575_ _04606_ _00177_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09192_ dp.rf.rf\[14\]\[23\] _04576_ _04606_ _00178_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09193_ dp.rf.rf\[14\]\[24\] _04577_ _04606_ _00179_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09194_ dp.rf.rf\[14\]\[25\] _04578_ _04606_ _00180_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09195_ _04604_ _04607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09196_ dp.rf.rf\[14\]\[26\] _04579_ _04607_ _00181_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09197_ dp.rf.rf\[14\]\[27\] _04581_ _04607_ _00182_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09198_ dp.rf.rf\[14\]\[28\] _04582_ _04607_ _00183_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09199_ dp.rf.rf\[14\]\[29\] _04583_ _04607_ _00184_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09200_ dp.rf.rf\[14\]\[2\] _04584_ _04607_ _00185_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09201_ dp.rf.rf\[14\]\[30\] _04585_ _04607_ _00186_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09202_ _04550_ _04605_ _04608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09203_ dp.rf.rf\[14\]\[31\] _04605_ _04609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09204_ _04472_ _04608_ _04609_ _00187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09205_ dp.rf.rf\[14\]\[3\] _04588_ _04607_ _00188_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09206_ dp.rf.rf\[14\]\[4\] _04589_ _04607_ _00189_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09207_ dp.rf.rf\[14\]\[5\] _04590_ _04607_ _00190_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09208_ dp.rf.rf\[14\]\[6\] _04591_ _04607_ _00191_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09209_ dp.rf.rf\[14\]\[7\] _04592_ _04604_ _00192_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09210_ dp.rf.rf\[14\]\[8\] _04593_ _04604_ _00193_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09211_ dp.rf.rf\[14\]\[9\] _04594_ _04604_ _00194_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09212_ _04545_ _04554_ _04610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09213_ _04610_ _04611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09214_ dp.rf.rf\[15\]\[0\] _04553_ _04611_ _00195_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09215_ dp.rf.rf\[15\]\[10\] _04561_ _04611_ _00196_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09216_ dp.rf.rf\[15\]\[11\] _04562_ _04611_ _00197_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09217_ dp.rf.rf\[15\]\[12\] _04563_ _04611_ _00198_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09218_ dp.rf.rf\[15\]\[13\] _04564_ _04611_ _00199_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09219_ dp.rf.rf\[15\]\[14\] _04565_ _04611_ _00200_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09220_ dp.rf.rf\[15\]\[15\] _04566_ _04611_ _00201_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09221_ dp.rf.rf\[15\]\[16\] _04567_ _04611_ _00202_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09222_ _04610_ _04612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_09223_ dp.rf.rf\[15\]\[17\] _04568_ _04612_ _00203_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09224_ dp.rf.rf\[15\]\[18\] _04570_ _04612_ _00204_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09225_ dp.rf.rf\[15\]\[19\] _04571_ _04612_ _00205_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09226_ dp.rf.rf\[15\]\[1\] _04572_ _04612_ _00206_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09227_ dp.rf.rf\[15\]\[20\] _04573_ _04612_ _00207_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09228_ dp.rf.rf\[15\]\[21\] _04574_ _04612_ _00208_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09229_ dp.rf.rf\[15\]\[22\] _04575_ _04612_ _00209_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09230_ dp.rf.rf\[15\]\[23\] _04576_ _04612_ _00210_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09231_ dp.rf.rf\[15\]\[24\] _04577_ _04612_ _00211_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09232_ dp.rf.rf\[15\]\[25\] _04578_ _04612_ _00212_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09233_ _04610_ _04613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09234_ dp.rf.rf\[15\]\[26\] _04579_ _04613_ _00213_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09235_ dp.rf.rf\[15\]\[27\] _04581_ _04613_ _00214_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09236_ dp.rf.rf\[15\]\[28\] _04582_ _04613_ _00215_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09237_ dp.rf.rf\[15\]\[29\] _04583_ _04613_ _00216_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09238_ dp.rf.rf\[15\]\[2\] _04584_ _04613_ _00217_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09239_ dp.rf.rf\[15\]\[30\] _04585_ _04613_ _00218_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09240_ _04550_ _04611_ _04614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09241_ dp.rf.rf\[15\]\[31\] _04611_ _04615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09242_ _04472_ _04614_ _04615_ _00219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09243_ dp.rf.rf\[15\]\[3\] _04588_ _04613_ _00220_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09244_ dp.rf.rf\[15\]\[4\] _04589_ _04613_ _00221_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09245_ dp.rf.rf\[15\]\[5\] _04590_ _04613_ _00222_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09246_ dp.rf.rf\[15\]\[6\] _04591_ _04613_ _00223_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09247_ dp.rf.rf\[15\]\[7\] _04592_ _04610_ _00224_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09248_ dp.rf.rf\[15\]\[8\] _04593_ _04610_ _00225_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09249_ dp.rf.rf\[15\]\[9\] _04594_ _04610_ _00226_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09250_ net3 _04555_ _02793_ _04616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09251_ _04558_ _04616_ _04617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09252_ _04617_ _04618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09253_ dp.rf.rf\[16\]\[0\] _04553_ _04618_ _00227_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09254_ dp.rf.rf\[16\]\[10\] _04561_ _04618_ _00228_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09255_ dp.rf.rf\[16\]\[11\] _04562_ _04618_ _00229_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09256_ dp.rf.rf\[16\]\[12\] _04563_ _04618_ _00230_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09257_ dp.rf.rf\[16\]\[13\] _04564_ _04618_ _00231_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09258_ dp.rf.rf\[16\]\[14\] _04565_ _04618_ _00232_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09259_ dp.rf.rf\[16\]\[15\] _04566_ _04618_ _00233_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09260_ dp.rf.rf\[16\]\[16\] _04567_ _04618_ _00234_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09261_ _04617_ _04619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09262_ dp.rf.rf\[16\]\[17\] _04568_ _04619_ _00235_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09263_ dp.rf.rf\[16\]\[18\] _04570_ _04619_ _00236_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09264_ dp.rf.rf\[16\]\[19\] _04571_ _04619_ _00237_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09265_ dp.rf.rf\[16\]\[1\] _04572_ _04619_ _00238_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09266_ dp.rf.rf\[16\]\[20\] _04573_ _04619_ _00239_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09267_ dp.rf.rf\[16\]\[21\] _04574_ _04619_ _00240_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09268_ dp.rf.rf\[16\]\[22\] _04575_ _04619_ _00241_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09269_ dp.rf.rf\[16\]\[23\] _04576_ _04619_ _00242_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09270_ dp.rf.rf\[16\]\[24\] _04577_ _04619_ _00243_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09271_ dp.rf.rf\[16\]\[25\] _04578_ _04619_ _00244_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09272_ _04617_ _04620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09273_ dp.rf.rf\[16\]\[26\] _04579_ _04620_ _00245_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09274_ dp.rf.rf\[16\]\[27\] _04581_ _04620_ _00246_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09275_ dp.rf.rf\[16\]\[28\] _04582_ _04620_ _00247_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09276_ dp.rf.rf\[16\]\[29\] _04583_ _04620_ _00248_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09277_ dp.rf.rf\[16\]\[2\] _04584_ _04620_ _00249_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09278_ dp.rf.rf\[16\]\[30\] _04585_ _04620_ _00250_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09279_ _04550_ _04618_ _04621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09280_ dp.rf.rf\[16\]\[31\] _04618_ _04622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09281_ _04472_ _04621_ _04622_ _00251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09282_ dp.rf.rf\[16\]\[3\] _04588_ _04620_ _00252_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09283_ dp.rf.rf\[16\]\[4\] _04589_ _04620_ _00253_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09284_ dp.rf.rf\[16\]\[5\] _04590_ _04620_ _00254_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09285_ dp.rf.rf\[16\]\[6\] _04591_ _04620_ _00255_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09286_ dp.rf.rf\[16\]\[7\] _04592_ _04617_ _00256_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09287_ dp.rf.rf\[16\]\[8\] _04593_ _04617_ _00257_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09288_ dp.rf.rf\[16\]\[9\] _04594_ _04617_ _00258_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09289_ _04601_ _04616_ _04623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09290_ _04623_ _04624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09291_ _04073_ dp.rf.rf\[17\]\[0\] _04624_ _00259_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09292_ _04120_ dp.rf.rf\[17\]\[10\] _04624_ _00260_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09293_ _04150_ dp.rf.rf\[17\]\[11\] _04624_ _00261_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09294_ _04164_ dp.rf.rf\[17\]\[12\] _04624_ _00262_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09295_ _04178_ dp.rf.rf\[17\]\[13\] _04624_ _00263_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09296_ _04196_ dp.rf.rf\[17\]\[14\] _04624_ _00264_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09297_ _04209_ dp.rf.rf\[17\]\[15\] _04624_ _00265_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09298_ _04227_ dp.rf.rf\[17\]\[16\] _04624_ _00266_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09299_ _04244_ dp.rf.rf\[17\]\[17\] _04624_ _00267_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09300_ _04623_ _04625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_09301_ _04259_ dp.rf.rf\[17\]\[18\] _04625_ _00268_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09302_ _04270_ dp.rf.rf\[17\]\[19\] _04625_ _00269_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09303_ _04275_ dp.rf.rf\[17\]\[1\] _04625_ _00270_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09304_ _04292_ dp.rf.rf\[17\]\[20\] _04625_ _00271_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09305_ _04313_ dp.rf.rf\[17\]\[21\] _04625_ _00272_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09306_ _04328_ dp.rf.rf\[17\]\[22\] _04625_ _00273_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09307_ _04342_ dp.rf.rf\[17\]\[23\] _04625_ _00274_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09308_ _04359_ dp.rf.rf\[17\]\[24\] _04625_ _00275_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09309_ _04381_ dp.rf.rf\[17\]\[25\] _04625_ _00276_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09310_ _04395_ dp.rf.rf\[17\]\[26\] _04625_ _00277_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09311_ _04623_ _04626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09312_ _04409_ dp.rf.rf\[17\]\[27\] _04626_ _00278_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09313_ _04421_ dp.rf.rf\[17\]\[28\] _04626_ _00279_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09314_ _04439_ dp.rf.rf\[17\]\[29\] _04626_ _00280_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09315_ _04446_ dp.rf.rf\[17\]\[2\] _04626_ _00281_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09316_ _04462_ dp.rf.rf\[17\]\[30\] _04626_ _00282_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09317_ dp.rf.rf\[17\]\[31\] _04627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09318_ _04482_ _04601_ _04616_ _04628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09319_ _04627_ _04624_ _04628_ _04603_ _00283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09320_ _04488_ dp.rf.rf\[17\]\[3\] _04626_ _00284_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09321_ _04496_ dp.rf.rf\[17\]\[4\] _04626_ _00285_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09322_ _04504_ dp.rf.rf\[17\]\[5\] _04626_ _00286_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09323_ _04512_ dp.rf.rf\[17\]\[6\] _04626_ _00287_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09324_ _04523_ dp.rf.rf\[17\]\[7\] _04626_ _00288_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09325_ _04534_ dp.rf.rf\[17\]\[8\] _04623_ _00289_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09326_ _04544_ dp.rf.rf\[17\]\[9\] _04623_ _00290_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09327_ _04081_ _04616_ _04629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09328_ _04629_ _04630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09329_ dp.rf.rf\[18\]\[0\] _04553_ _04630_ _00291_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09330_ dp.rf.rf\[18\]\[10\] _04561_ _04630_ _00292_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09331_ dp.rf.rf\[18\]\[11\] _04562_ _04630_ _00293_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09332_ dp.rf.rf\[18\]\[12\] _04563_ _04630_ _00294_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09333_ dp.rf.rf\[18\]\[13\] _04564_ _04630_ _00295_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09334_ dp.rf.rf\[18\]\[14\] _04565_ _04630_ _00296_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09335_ dp.rf.rf\[18\]\[15\] _04566_ _04630_ _00297_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09336_ dp.rf.rf\[18\]\[16\] _04567_ _04630_ _00298_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09337_ _04629_ _04631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09338_ dp.rf.rf\[18\]\[17\] _04568_ _04631_ _00299_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09339_ dp.rf.rf\[18\]\[18\] _04570_ _04631_ _00300_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09340_ dp.rf.rf\[18\]\[19\] _04571_ _04631_ _00301_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09341_ dp.rf.rf\[18\]\[1\] _04572_ _04631_ _00302_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09342_ dp.rf.rf\[18\]\[20\] _04573_ _04631_ _00303_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09343_ dp.rf.rf\[18\]\[21\] _04574_ _04631_ _00304_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09344_ dp.rf.rf\[18\]\[22\] _04575_ _04631_ _00305_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09345_ dp.rf.rf\[18\]\[23\] _04576_ _04631_ _00306_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09346_ dp.rf.rf\[18\]\[24\] _04577_ _04631_ _00307_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09347_ dp.rf.rf\[18\]\[25\] _04578_ _04631_ _00308_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09348_ _04629_ _04632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09349_ dp.rf.rf\[18\]\[26\] _04579_ _04632_ _00309_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09350_ dp.rf.rf\[18\]\[27\] _04581_ _04632_ _00310_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09351_ dp.rf.rf\[18\]\[28\] _04582_ _04632_ _00311_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09352_ dp.rf.rf\[18\]\[29\] _04583_ _04632_ _00312_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09353_ dp.rf.rf\[18\]\[2\] _04584_ _04632_ _00313_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09354_ dp.rf.rf\[18\]\[30\] _04585_ _04632_ _00314_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09355_ _04550_ _04630_ _04633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09356_ dp.rf.rf\[18\]\[31\] _04630_ _04634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09357_ _04472_ _04633_ _04634_ _00315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09358_ dp.rf.rf\[18\]\[3\] _04588_ _04632_ _00316_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09359_ dp.rf.rf\[18\]\[4\] _04589_ _04632_ _00317_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09360_ dp.rf.rf\[18\]\[5\] _04590_ _04632_ _00318_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09361_ dp.rf.rf\[18\]\[6\] _04591_ _04632_ _00319_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09362_ dp.rf.rf\[18\]\[7\] _04592_ _04629_ _00320_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09363_ dp.rf.rf\[18\]\[8\] _04593_ _04629_ _00321_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09364_ dp.rf.rf\[18\]\[9\] _04594_ _04629_ _00322_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09365_ _04545_ _04616_ _04635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09366_ _04635_ _04636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09367_ dp.rf.rf\[19\]\[0\] _04553_ _04636_ _00323_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09368_ dp.rf.rf\[19\]\[10\] _04561_ _04636_ _00324_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09369_ dp.rf.rf\[19\]\[11\] _04562_ _04636_ _00325_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09370_ dp.rf.rf\[19\]\[12\] _04563_ _04636_ _00326_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09371_ dp.rf.rf\[19\]\[13\] _04564_ _04636_ _00327_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09372_ dp.rf.rf\[19\]\[14\] _04565_ _04636_ _00328_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09373_ dp.rf.rf\[19\]\[15\] _04566_ _04636_ _00329_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09374_ dp.rf.rf\[19\]\[16\] _04567_ _04636_ _00330_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09375_ _04635_ _04637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09376_ dp.rf.rf\[19\]\[17\] _04568_ _04637_ _00331_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09377_ dp.rf.rf\[19\]\[18\] _04570_ _04637_ _00332_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09378_ dp.rf.rf\[19\]\[19\] _04571_ _04637_ _00333_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09379_ dp.rf.rf\[19\]\[1\] _04572_ _04637_ _00334_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09380_ dp.rf.rf\[19\]\[20\] _04573_ _04637_ _00335_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09381_ dp.rf.rf\[19\]\[21\] _04574_ _04637_ _00336_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09382_ dp.rf.rf\[19\]\[22\] _04575_ _04637_ _00337_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09383_ dp.rf.rf\[19\]\[23\] _04576_ _04637_ _00338_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09384_ dp.rf.rf\[19\]\[24\] _04577_ _04637_ _00339_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09385_ dp.rf.rf\[19\]\[25\] _04578_ _04637_ _00340_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09386_ _04635_ _04638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09387_ dp.rf.rf\[19\]\[26\] _04579_ _04638_ _00341_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09388_ dp.rf.rf\[19\]\[27\] _04581_ _04638_ _00342_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09389_ dp.rf.rf\[19\]\[28\] _04582_ _04638_ _00343_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09390_ dp.rf.rf\[19\]\[29\] _04583_ _04638_ _00344_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09391_ dp.rf.rf\[19\]\[2\] _04584_ _04638_ _00345_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09392_ dp.rf.rf\[19\]\[30\] _04585_ _04638_ _00346_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09393_ _04550_ _04636_ _04639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09394_ dp.rf.rf\[19\]\[31\] _04636_ _04640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09395_ _04472_ _04639_ _04640_ _00347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09396_ dp.rf.rf\[19\]\[3\] _04588_ _04638_ _00348_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09397_ dp.rf.rf\[19\]\[4\] _04589_ _04638_ _00349_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09398_ dp.rf.rf\[19\]\[5\] _04590_ _04638_ _00350_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09399_ dp.rf.rf\[19\]\[6\] _04591_ _04638_ _00351_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09400_ dp.rf.rf\[19\]\[7\] _04592_ _04635_ _00352_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09401_ dp.rf.rf\[19\]\[8\] _04593_ _04635_ _00353_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09402_ dp.rf.rf\[19\]\[9\] _04594_ _04635_ _00354_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09403_ _04556_ _04595_ _04641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09404_ _04641_ _04642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09405_ _04073_ dp.rf.rf\[1\]\[0\] _04642_ _00355_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09406_ _04120_ dp.rf.rf\[1\]\[10\] _04642_ _00356_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09407_ _04150_ dp.rf.rf\[1\]\[11\] _04642_ _00357_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09408_ _04164_ dp.rf.rf\[1\]\[12\] _04642_ _00358_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09409_ _04178_ dp.rf.rf\[1\]\[13\] _04642_ _00359_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09410_ _04196_ dp.rf.rf\[1\]\[14\] _04642_ _00360_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09411_ _04209_ dp.rf.rf\[1\]\[15\] _04642_ _00361_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09412_ _04227_ dp.rf.rf\[1\]\[16\] _04642_ _00362_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09413_ _04244_ dp.rf.rf\[1\]\[17\] _04642_ _00363_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09414_ _04641_ _04643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09415_ _04259_ dp.rf.rf\[1\]\[18\] _04643_ _00364_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09416_ _04270_ dp.rf.rf\[1\]\[19\] _04643_ _00365_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09417_ _04275_ dp.rf.rf\[1\]\[1\] _04643_ _00366_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09418_ _04292_ dp.rf.rf\[1\]\[20\] _04643_ _00367_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09419_ _04313_ dp.rf.rf\[1\]\[21\] _04643_ _00368_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09420_ _04328_ dp.rf.rf\[1\]\[22\] _04643_ _00369_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09421_ _04342_ dp.rf.rf\[1\]\[23\] _04643_ _00370_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09422_ _04359_ dp.rf.rf\[1\]\[24\] _04643_ _00371_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09423_ _04381_ dp.rf.rf\[1\]\[25\] _04643_ _00372_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09424_ _04395_ dp.rf.rf\[1\]\[26\] _04643_ _00373_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09425_ _04641_ _04644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09426_ _04409_ dp.rf.rf\[1\]\[27\] _04644_ _00374_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09427_ _04421_ dp.rf.rf\[1\]\[28\] _04644_ _00375_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09428_ _04439_ dp.rf.rf\[1\]\[29\] _04644_ _00376_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09429_ _04446_ dp.rf.rf\[1\]\[2\] _04644_ _00377_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09430_ _04462_ dp.rf.rf\[1\]\[30\] _04644_ _00378_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09431_ dp.rf.rf\[1\]\[31\] _04645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09432_ _04482_ _04556_ _04601_ _04646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09433_ _04645_ _04642_ _04646_ _04603_ _00379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09434_ _04488_ dp.rf.rf\[1\]\[3\] _04644_ _00380_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09435_ _04496_ dp.rf.rf\[1\]\[4\] _04644_ _00381_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09436_ _04504_ dp.rf.rf\[1\]\[5\] _04644_ _00382_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09437_ _04512_ dp.rf.rf\[1\]\[6\] _04644_ _00383_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09438_ _04523_ dp.rf.rf\[1\]\[7\] _04644_ _00384_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09439_ _04534_ dp.rf.rf\[1\]\[8\] _04641_ _00385_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09440_ _04544_ dp.rf.rf\[1\]\[9\] _04641_ _00386_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09441_ net3 _04555_ net27 _04647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09442_ _04558_ _04647_ _04648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09443_ _04648_ _04649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09444_ dp.rf.rf\[20\]\[0\] _04553_ _04649_ _00387_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09445_ dp.rf.rf\[20\]\[10\] _04561_ _04649_ _00388_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09446_ dp.rf.rf\[20\]\[11\] _04562_ _04649_ _00389_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09447_ dp.rf.rf\[20\]\[12\] _04563_ _04649_ _00390_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09448_ dp.rf.rf\[20\]\[13\] _04564_ _04649_ _00391_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09449_ dp.rf.rf\[20\]\[14\] _04565_ _04649_ _00392_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09450_ dp.rf.rf\[20\]\[15\] _04566_ _04649_ _00393_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09451_ dp.rf.rf\[20\]\[16\] _04567_ _04649_ _00394_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09452_ _04648_ _04650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09453_ dp.rf.rf\[20\]\[17\] _04568_ _04650_ _00395_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09454_ dp.rf.rf\[20\]\[18\] _04570_ _04650_ _00396_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09455_ dp.rf.rf\[20\]\[19\] _04571_ _04650_ _00397_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09456_ dp.rf.rf\[20\]\[1\] _04572_ _04650_ _00398_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09457_ dp.rf.rf\[20\]\[20\] _04573_ _04650_ _00399_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09458_ dp.rf.rf\[20\]\[21\] _04574_ _04650_ _00400_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09459_ dp.rf.rf\[20\]\[22\] _04575_ _04650_ _00401_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09460_ dp.rf.rf\[20\]\[23\] _04576_ _04650_ _00402_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09461_ dp.rf.rf\[20\]\[24\] _04577_ _04650_ _00403_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09462_ dp.rf.rf\[20\]\[25\] _04578_ _04650_ _00404_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09463_ _04648_ _04651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09464_ dp.rf.rf\[20\]\[26\] _04579_ _04651_ _00405_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09465_ dp.rf.rf\[20\]\[27\] _04581_ _04651_ _00406_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09466_ dp.rf.rf\[20\]\[28\] _04582_ _04651_ _00407_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09467_ dp.rf.rf\[20\]\[29\] _04583_ _04651_ _00408_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09468_ dp.rf.rf\[20\]\[2\] _04584_ _04651_ _00409_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09469_ dp.rf.rf\[20\]\[30\] _04585_ _04651_ _00410_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09470_ _04550_ _04649_ _04652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09471_ dp.rf.rf\[20\]\[31\] _04649_ _04653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09472_ _04472_ _04652_ _04653_ _00411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09473_ dp.rf.rf\[20\]\[3\] _04588_ _04651_ _00412_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09474_ dp.rf.rf\[20\]\[4\] _04589_ _04651_ _00413_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09475_ dp.rf.rf\[20\]\[5\] _04590_ _04651_ _00414_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09476_ dp.rf.rf\[20\]\[6\] _04591_ _04651_ _00415_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09477_ dp.rf.rf\[20\]\[7\] _04592_ _04648_ _00416_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09478_ dp.rf.rf\[20\]\[8\] _04593_ _04648_ _00417_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09479_ dp.rf.rf\[20\]\[9\] _04594_ _04648_ _00418_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09480_ _04601_ _04647_ _04654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09481_ _04654_ _04655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09482_ _04073_ dp.rf.rf\[21\]\[0\] _04655_ _00419_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09483_ _04120_ dp.rf.rf\[21\]\[10\] _04655_ _00420_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09484_ _04150_ dp.rf.rf\[21\]\[11\] _04655_ _00421_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09485_ _04164_ dp.rf.rf\[21\]\[12\] _04655_ _00422_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09486_ _04178_ dp.rf.rf\[21\]\[13\] _04655_ _00423_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09487_ _04196_ dp.rf.rf\[21\]\[14\] _04655_ _00424_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09488_ _04209_ dp.rf.rf\[21\]\[15\] _04655_ _00425_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09489_ _04227_ dp.rf.rf\[21\]\[16\] _04655_ _00426_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09490_ _04244_ dp.rf.rf\[21\]\[17\] _04655_ _00427_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09491_ _04654_ _04656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09492_ _04259_ dp.rf.rf\[21\]\[18\] _04656_ _00428_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09493_ _04270_ dp.rf.rf\[21\]\[19\] _04656_ _00429_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09494_ _04275_ dp.rf.rf\[21\]\[1\] _04656_ _00430_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09495_ _04292_ dp.rf.rf\[21\]\[20\] _04656_ _00431_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09496_ _04313_ dp.rf.rf\[21\]\[21\] _04656_ _00432_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09497_ _04328_ dp.rf.rf\[21\]\[22\] _04656_ _00433_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09498_ _04342_ dp.rf.rf\[21\]\[23\] _04656_ _00434_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09499_ _04359_ dp.rf.rf\[21\]\[24\] _04656_ _00435_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09500_ _04381_ dp.rf.rf\[21\]\[25\] _04656_ _00436_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09501_ _04395_ dp.rf.rf\[21\]\[26\] _04656_ _00437_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09502_ _04654_ _04657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09503_ _04409_ dp.rf.rf\[21\]\[27\] _04657_ _00438_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09504_ _04421_ dp.rf.rf\[21\]\[28\] _04657_ _00439_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09505_ _04439_ dp.rf.rf\[21\]\[29\] _04657_ _00440_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09506_ _04446_ dp.rf.rf\[21\]\[2\] _04657_ _00441_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09507_ _04462_ dp.rf.rf\[21\]\[30\] _04657_ _00442_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09508_ dp.rf.rf\[21\]\[31\] _04658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09509_ _04482_ _04601_ _04647_ _04659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09510_ _04658_ _04655_ _04659_ _04603_ _00443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09511_ _04488_ dp.rf.rf\[21\]\[3\] _04657_ _00444_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09512_ _04496_ dp.rf.rf\[21\]\[4\] _04657_ _00445_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09513_ _04504_ dp.rf.rf\[21\]\[5\] _04657_ _00446_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09514_ _04512_ dp.rf.rf\[21\]\[6\] _04657_ _00447_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09515_ _04523_ dp.rf.rf\[21\]\[7\] _04657_ _00448_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09516_ _04534_ dp.rf.rf\[21\]\[8\] _04654_ _00449_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09517_ _04544_ dp.rf.rf\[21\]\[9\] _04654_ _00450_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09518_ _04081_ _04647_ _04660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09519_ _04660_ _04661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09520_ dp.rf.rf\[22\]\[0\] _04553_ _04661_ _00451_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09521_ dp.rf.rf\[22\]\[10\] _04561_ _04661_ _00452_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09522_ dp.rf.rf\[22\]\[11\] _04562_ _04661_ _00453_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09523_ dp.rf.rf\[22\]\[12\] _04563_ _04661_ _00454_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09524_ dp.rf.rf\[22\]\[13\] _04564_ _04661_ _00455_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09525_ dp.rf.rf\[22\]\[14\] _04565_ _04661_ _00456_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09526_ dp.rf.rf\[22\]\[15\] _04566_ _04661_ _00457_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09527_ dp.rf.rf\[22\]\[16\] _04567_ _04661_ _00458_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09528_ _04660_ _04662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09529_ dp.rf.rf\[22\]\[17\] _04568_ _04662_ _00459_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09530_ dp.rf.rf\[22\]\[18\] _04570_ _04662_ _00460_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09531_ dp.rf.rf\[22\]\[19\] _04571_ _04662_ _00461_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09532_ dp.rf.rf\[22\]\[1\] _04572_ _04662_ _00462_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09533_ dp.rf.rf\[22\]\[20\] _04573_ _04662_ _00463_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09534_ dp.rf.rf\[22\]\[21\] _04574_ _04662_ _00464_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09535_ dp.rf.rf\[22\]\[22\] _04575_ _04662_ _00465_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09536_ dp.rf.rf\[22\]\[23\] _04576_ _04662_ _00466_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09537_ dp.rf.rf\[22\]\[24\] _04577_ _04662_ _00467_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09538_ dp.rf.rf\[22\]\[25\] _04578_ _04662_ _00468_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09539_ _04660_ _04663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09540_ dp.rf.rf\[22\]\[26\] _04579_ _04663_ _00469_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09541_ dp.rf.rf\[22\]\[27\] _04581_ _04663_ _00470_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09542_ dp.rf.rf\[22\]\[28\] _04582_ _04663_ _00471_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09543_ dp.rf.rf\[22\]\[29\] _04583_ _04663_ _00472_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09544_ dp.rf.rf\[22\]\[2\] _04584_ _04663_ _00473_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09545_ dp.rf.rf\[22\]\[30\] _04585_ _04663_ _00474_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09546_ _04550_ _04661_ _04664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09547_ dp.rf.rf\[22\]\[31\] _04661_ _04665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09548_ _04472_ _04664_ _04665_ _00475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09549_ dp.rf.rf\[22\]\[3\] _04588_ _04663_ _00476_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09550_ dp.rf.rf\[22\]\[4\] _04589_ _04663_ _00477_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09551_ dp.rf.rf\[22\]\[5\] _04590_ _04663_ _00478_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09552_ dp.rf.rf\[22\]\[6\] _04591_ _04663_ _00479_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09553_ dp.rf.rf\[22\]\[7\] _04592_ _04660_ _00480_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09554_ dp.rf.rf\[22\]\[8\] _04593_ _04660_ _00481_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09555_ dp.rf.rf\[22\]\[9\] _04594_ _04660_ _00482_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09556_ _04545_ _04647_ _04666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09557_ _04666_ _04667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09558_ dp.rf.rf\[23\]\[0\] _04553_ _04667_ _00483_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09559_ dp.rf.rf\[23\]\[10\] _04561_ _04667_ _00484_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09560_ dp.rf.rf\[23\]\[11\] _04562_ _04667_ _00485_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09561_ dp.rf.rf\[23\]\[12\] _04563_ _04667_ _00486_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09562_ dp.rf.rf\[23\]\[13\] _04564_ _04667_ _00487_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09563_ dp.rf.rf\[23\]\[14\] _04565_ _04667_ _00488_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09564_ dp.rf.rf\[23\]\[15\] _04566_ _04667_ _00489_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09565_ dp.rf.rf\[23\]\[16\] _04567_ _04667_ _00490_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09566_ _04666_ _04668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09567_ dp.rf.rf\[23\]\[17\] _04568_ _04668_ _00491_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09568_ dp.rf.rf\[23\]\[18\] _04570_ _04668_ _00492_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09569_ dp.rf.rf\[23\]\[19\] _04571_ _04668_ _00493_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09570_ dp.rf.rf\[23\]\[1\] _04572_ _04668_ _00494_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09571_ dp.rf.rf\[23\]\[20\] _04573_ _04668_ _00495_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09572_ dp.rf.rf\[23\]\[21\] _04574_ _04668_ _00496_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09573_ dp.rf.rf\[23\]\[22\] _04575_ _04668_ _00497_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09574_ dp.rf.rf\[23\]\[23\] _04576_ _04668_ _00498_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09575_ dp.rf.rf\[23\]\[24\] _04577_ _04668_ _00499_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09576_ dp.rf.rf\[23\]\[25\] _04578_ _04668_ _00500_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09577_ _04666_ _04669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09578_ dp.rf.rf\[23\]\[26\] _04579_ _04669_ _00501_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09579_ dp.rf.rf\[23\]\[27\] _04581_ _04669_ _00502_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09580_ dp.rf.rf\[23\]\[28\] _04582_ _04669_ _00503_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09581_ dp.rf.rf\[23\]\[29\] _04583_ _04669_ _00504_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09582_ dp.rf.rf\[23\]\[2\] _04584_ _04669_ _00505_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09583_ dp.rf.rf\[23\]\[30\] _04585_ _04669_ _00506_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09584_ _04471_ _04670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09585_ _04550_ _04667_ _04671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09586_ dp.rf.rf\[23\]\[31\] _04667_ _04672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09587_ _04670_ _04671_ _04672_ _00507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09588_ dp.rf.rf\[23\]\[3\] _04588_ _04669_ _00508_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09589_ dp.rf.rf\[23\]\[4\] _04589_ _04669_ _00509_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09590_ dp.rf.rf\[23\]\[5\] _04590_ _04669_ _00510_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09591_ dp.rf.rf\[23\]\[6\] _04591_ _04669_ _00511_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09592_ dp.rf.rf\[23\]\[7\] _04592_ _04666_ _00512_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09593_ dp.rf.rf\[23\]\[8\] _04593_ _04666_ _00513_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09594_ dp.rf.rf\[23\]\[9\] _04594_ _04666_ _00514_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09595_ net3 net2 _02793_ _04673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09596_ _04558_ _04673_ _04674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09597_ _04674_ _04675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09598_ dp.rf.rf\[24\]\[0\] _04553_ _04675_ _00515_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09599_ dp.rf.rf\[24\]\[10\] _04561_ _04675_ _00516_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09600_ dp.rf.rf\[24\]\[11\] _04562_ _04675_ _00517_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09601_ dp.rf.rf\[24\]\[12\] _04563_ _04675_ _00518_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09602_ dp.rf.rf\[24\]\[13\] _04564_ _04675_ _00519_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09603_ dp.rf.rf\[24\]\[14\] _04565_ _04675_ _00520_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09604_ dp.rf.rf\[24\]\[15\] _04566_ _04675_ _00521_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09605_ dp.rf.rf\[24\]\[16\] _04567_ _04675_ _00522_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09606_ _04674_ _04676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09607_ dp.rf.rf\[24\]\[17\] _04568_ _04676_ _00523_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09608_ dp.rf.rf\[24\]\[18\] _04570_ _04676_ _00524_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09609_ dp.rf.rf\[24\]\[19\] _04571_ _04676_ _00525_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09610_ dp.rf.rf\[24\]\[1\] _04572_ _04676_ _00526_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09611_ dp.rf.rf\[24\]\[20\] _04573_ _04676_ _00527_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09612_ dp.rf.rf\[24\]\[21\] _04574_ _04676_ _00528_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09613_ dp.rf.rf\[24\]\[22\] _04575_ _04676_ _00529_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09614_ dp.rf.rf\[24\]\[23\] _04576_ _04676_ _00530_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09615_ dp.rf.rf\[24\]\[24\] _04577_ _04676_ _00531_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09616_ dp.rf.rf\[24\]\[25\] _04578_ _04676_ _00532_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09617_ _04674_ _04677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09618_ dp.rf.rf\[24\]\[26\] _04579_ _04677_ _00533_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09619_ dp.rf.rf\[24\]\[27\] _04581_ _04677_ _00534_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09620_ dp.rf.rf\[24\]\[28\] _04582_ _04677_ _00535_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09621_ dp.rf.rf\[24\]\[29\] _04583_ _04677_ _00536_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09622_ dp.rf.rf\[24\]\[2\] _04584_ _04677_ _00537_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09623_ dp.rf.rf\[24\]\[30\] _04585_ _04677_ _00538_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09624_ _04481_ _04678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09625_ _04678_ _04675_ _04679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09626_ dp.rf.rf\[24\]\[31\] _04675_ _04680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09627_ _04670_ _04679_ _04680_ _00539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09628_ dp.rf.rf\[24\]\[3\] _04588_ _04677_ _00540_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09629_ dp.rf.rf\[24\]\[4\] _04589_ _04677_ _00541_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09630_ dp.rf.rf\[24\]\[5\] _04590_ _04677_ _00542_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09631_ dp.rf.rf\[24\]\[6\] _04591_ _04677_ _00543_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09632_ dp.rf.rf\[24\]\[7\] _04592_ _04674_ _00544_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09633_ dp.rf.rf\[24\]\[8\] _04593_ _04674_ _00545_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09634_ dp.rf.rf\[24\]\[9\] _04594_ _04674_ _00546_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09635_ _04595_ _04673_ _04681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09636_ _04681_ _04682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09637_ _04073_ dp.rf.rf\[25\]\[0\] _04682_ _00547_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09638_ _04120_ dp.rf.rf\[25\]\[10\] _04682_ _00548_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09639_ _04150_ dp.rf.rf\[25\]\[11\] _04682_ _00549_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09640_ _04164_ dp.rf.rf\[25\]\[12\] _04682_ _00550_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09641_ _04178_ dp.rf.rf\[25\]\[13\] _04682_ _00551_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09642_ _04196_ dp.rf.rf\[25\]\[14\] _04682_ _00552_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09643_ _04209_ dp.rf.rf\[25\]\[15\] _04682_ _00553_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09644_ _04227_ dp.rf.rf\[25\]\[16\] _04682_ _00554_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09645_ _04244_ dp.rf.rf\[25\]\[17\] _04682_ _00555_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09646_ _04681_ _04683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_09647_ _04259_ dp.rf.rf\[25\]\[18\] _04683_ _00556_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09648_ _04270_ dp.rf.rf\[25\]\[19\] _04683_ _00557_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09649_ _04275_ dp.rf.rf\[25\]\[1\] _04683_ _00558_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09650_ _04292_ dp.rf.rf\[25\]\[20\] _04683_ _00559_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09651_ _04313_ dp.rf.rf\[25\]\[21\] _04683_ _00560_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09652_ _04328_ dp.rf.rf\[25\]\[22\] _04683_ _00561_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09653_ _04342_ dp.rf.rf\[25\]\[23\] _04683_ _00562_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09654_ _04359_ dp.rf.rf\[25\]\[24\] _04683_ _00563_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09655_ _04381_ dp.rf.rf\[25\]\[25\] _04683_ _00564_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09656_ _04395_ dp.rf.rf\[25\]\[26\] _04683_ _00565_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09657_ _04681_ _04684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09658_ _04409_ dp.rf.rf\[25\]\[27\] _04684_ _00566_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09659_ _04421_ dp.rf.rf\[25\]\[28\] _04684_ _00567_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09660_ _04439_ dp.rf.rf\[25\]\[29\] _04684_ _00568_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09661_ _04446_ dp.rf.rf\[25\]\[2\] _04684_ _00569_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09662_ _04462_ dp.rf.rf\[25\]\[30\] _04684_ _00570_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09663_ _04482_ _04601_ _04673_ _04685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09664_ _01216_ _04682_ _04685_ _04603_ _00571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09665_ _04488_ dp.rf.rf\[25\]\[3\] _04684_ _00572_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09666_ _04496_ dp.rf.rf\[25\]\[4\] _04684_ _00573_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09667_ _04504_ dp.rf.rf\[25\]\[5\] _04684_ _00574_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09668_ _04512_ dp.rf.rf\[25\]\[6\] _04684_ _00575_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09669_ _04523_ dp.rf.rf\[25\]\[7\] _04684_ _00576_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09670_ _04534_ dp.rf.rf\[25\]\[8\] _04681_ _00577_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09671_ _04544_ dp.rf.rf\[25\]\[9\] _04681_ _00578_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09672_ _04072_ _04686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09673_ _04081_ _04673_ _04687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09674_ _04687_ _04688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09675_ dp.rf.rf\[26\]\[0\] _04686_ _04688_ _00579_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09676_ _04119_ _04689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09677_ dp.rf.rf\[26\]\[10\] _04689_ _04688_ _00580_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09678_ _04149_ _04690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09679_ dp.rf.rf\[26\]\[11\] _04690_ _04688_ _00581_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09680_ _04163_ _04691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09681_ dp.rf.rf\[26\]\[12\] _04691_ _04688_ _00582_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09682_ _04177_ _04692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09683_ dp.rf.rf\[26\]\[13\] _04692_ _04688_ _00583_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09684_ _04195_ _04693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09685_ dp.rf.rf\[26\]\[14\] _04693_ _04688_ _00584_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09686_ _04208_ _04694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09687_ dp.rf.rf\[26\]\[15\] _04694_ _04688_ _00585_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09688_ _04226_ _04695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09689_ dp.rf.rf\[26\]\[16\] _04695_ _04688_ _00586_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09690_ _04243_ _04696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09691_ _04687_ _04697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09692_ dp.rf.rf\[26\]\[17\] _04696_ _04697_ _00587_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09693_ _04258_ _04698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09694_ dp.rf.rf\[26\]\[18\] _04698_ _04697_ _00588_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09695_ _04269_ _04699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09696_ dp.rf.rf\[26\]\[19\] _04699_ _04697_ _00589_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09697_ _04274_ _04700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09698_ dp.rf.rf\[26\]\[1\] _04700_ _04697_ _00590_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09699_ _04291_ _04701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09700_ dp.rf.rf\[26\]\[20\] _04701_ _04697_ _00591_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09701_ _04312_ _04702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09702_ dp.rf.rf\[26\]\[21\] _04702_ _04697_ _00592_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09703_ _04327_ _04703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09704_ dp.rf.rf\[26\]\[22\] _04703_ _04697_ _00593_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09705_ _04341_ _04704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09706_ dp.rf.rf\[26\]\[23\] _04704_ _04697_ _00594_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09707_ _04358_ _04705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09708_ dp.rf.rf\[26\]\[24\] _04705_ _04697_ _00595_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09709_ _04380_ _04706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09710_ dp.rf.rf\[26\]\[25\] _04706_ _04697_ _00596_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09711_ _04394_ _04707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09712_ _04687_ _04708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09713_ dp.rf.rf\[26\]\[26\] _04707_ _04708_ _00597_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09714_ _04408_ _04709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09715_ dp.rf.rf\[26\]\[27\] _04709_ _04708_ _00598_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09716_ _04420_ _04710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09717_ dp.rf.rf\[26\]\[28\] _04710_ _04708_ _00599_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09718_ _04438_ _04711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09719_ dp.rf.rf\[26\]\[29\] _04711_ _04708_ _00600_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09720_ _04445_ _04712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09721_ dp.rf.rf\[26\]\[2\] _04712_ _04708_ _00601_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09722_ _04461_ _04713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09723_ dp.rf.rf\[26\]\[30\] _04713_ _04708_ _00602_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09724_ _04678_ _04688_ _04714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09725_ dp.rf.rf\[26\]\[31\] _04688_ _04715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09726_ _04670_ _04714_ _04715_ _00603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09727_ _04487_ _04716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09728_ dp.rf.rf\[26\]\[3\] _04716_ _04708_ _00604_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09729_ _04495_ _04717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09730_ dp.rf.rf\[26\]\[4\] _04717_ _04708_ _00605_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09731_ _04503_ _04718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_09732_ dp.rf.rf\[26\]\[5\] _04718_ _04708_ _00606_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09733_ _04511_ _04719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09734_ dp.rf.rf\[26\]\[6\] _04719_ _04708_ _00607_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09735_ _04522_ _04720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09736_ dp.rf.rf\[26\]\[7\] _04720_ _04687_ _00608_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09737_ _04533_ _04721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09738_ dp.rf.rf\[26\]\[8\] _04721_ _04687_ _00609_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09739_ _04543_ _04722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_09740_ dp.rf.rf\[26\]\[9\] _04722_ _04687_ _00610_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09741_ _04545_ _04673_ _04723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09742_ _04723_ _04724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09743_ dp.rf.rf\[27\]\[0\] _04686_ _04724_ _00611_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09744_ dp.rf.rf\[27\]\[10\] _04689_ _04724_ _00612_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09745_ dp.rf.rf\[27\]\[11\] _04690_ _04724_ _00613_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09746_ dp.rf.rf\[27\]\[12\] _04691_ _04724_ _00614_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09747_ dp.rf.rf\[27\]\[13\] _04692_ _04724_ _00615_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09748_ dp.rf.rf\[27\]\[14\] _04693_ _04724_ _00616_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09749_ dp.rf.rf\[27\]\[15\] _04694_ _04724_ _00617_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09750_ dp.rf.rf\[27\]\[16\] _04695_ _04724_ _00618_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09751_ _04723_ _04725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09752_ dp.rf.rf\[27\]\[17\] _04696_ _04725_ _00619_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09753_ dp.rf.rf\[27\]\[18\] _04698_ _04725_ _00620_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09754_ dp.rf.rf\[27\]\[19\] _04699_ _04725_ _00621_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09755_ dp.rf.rf\[27\]\[1\] _04700_ _04725_ _00622_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09756_ dp.rf.rf\[27\]\[20\] _04701_ _04725_ _00623_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09757_ dp.rf.rf\[27\]\[21\] _04702_ _04725_ _00624_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09758_ dp.rf.rf\[27\]\[22\] _04703_ _04725_ _00625_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09759_ dp.rf.rf\[27\]\[23\] _04704_ _04725_ _00626_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09760_ dp.rf.rf\[27\]\[24\] _04705_ _04725_ _00627_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09761_ dp.rf.rf\[27\]\[25\] _04706_ _04725_ _00628_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09762_ _04723_ _04726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09763_ dp.rf.rf\[27\]\[26\] _04707_ _04726_ _00629_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09764_ dp.rf.rf\[27\]\[27\] _04709_ _04726_ _00630_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09765_ dp.rf.rf\[27\]\[28\] _04710_ _04726_ _00631_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09766_ dp.rf.rf\[27\]\[29\] _04711_ _04726_ _00632_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09767_ dp.rf.rf\[27\]\[2\] _04712_ _04726_ _00633_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09768_ dp.rf.rf\[27\]\[30\] _04713_ _04726_ _00634_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09769_ _04678_ _04724_ _04727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09770_ dp.rf.rf\[27\]\[31\] _04724_ _04728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09771_ _04670_ _04727_ _04728_ _00635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09772_ dp.rf.rf\[27\]\[3\] _04716_ _04726_ _00636_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09773_ dp.rf.rf\[27\]\[4\] _04717_ _04726_ _00637_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09774_ dp.rf.rf\[27\]\[5\] _04718_ _04726_ _00638_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09775_ dp.rf.rf\[27\]\[6\] _04719_ _04726_ _00639_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09776_ dp.rf.rf\[27\]\[7\] _04720_ _04723_ _00640_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09777_ dp.rf.rf\[27\]\[8\] _04721_ _04723_ _00641_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09778_ dp.rf.rf\[27\]\[9\] _04722_ _04723_ _00642_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09779_ net3 net2 net27 _04729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09780_ _04558_ _04729_ _04730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09781_ _04730_ _04731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09782_ dp.rf.rf\[28\]\[0\] _04686_ _04731_ _00643_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09783_ dp.rf.rf\[28\]\[10\] _04689_ _04731_ _00644_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09784_ dp.rf.rf\[28\]\[11\] _04690_ _04731_ _00645_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09785_ dp.rf.rf\[28\]\[12\] _04691_ _04731_ _00646_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09786_ dp.rf.rf\[28\]\[13\] _04692_ _04731_ _00647_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09787_ dp.rf.rf\[28\]\[14\] _04693_ _04731_ _00648_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09788_ dp.rf.rf\[28\]\[15\] _04694_ _04731_ _00649_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09789_ dp.rf.rf\[28\]\[16\] _04695_ _04731_ _00650_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09790_ _04730_ _04732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09791_ dp.rf.rf\[28\]\[17\] _04696_ _04732_ _00651_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09792_ dp.rf.rf\[28\]\[18\] _04698_ _04732_ _00652_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09793_ dp.rf.rf\[28\]\[19\] _04699_ _04732_ _00653_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09794_ dp.rf.rf\[28\]\[1\] _04700_ _04732_ _00654_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09795_ dp.rf.rf\[28\]\[20\] _04701_ _04732_ _00655_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09796_ dp.rf.rf\[28\]\[21\] _04702_ _04732_ _00656_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09797_ dp.rf.rf\[28\]\[22\] _04703_ _04732_ _00657_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09798_ dp.rf.rf\[28\]\[23\] _04704_ _04732_ _00658_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09799_ dp.rf.rf\[28\]\[24\] _04705_ _04732_ _00659_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09800_ dp.rf.rf\[28\]\[25\] _04706_ _04732_ _00660_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09801_ _04730_ _04733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09802_ dp.rf.rf\[28\]\[26\] _04707_ _04733_ _00661_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09803_ dp.rf.rf\[28\]\[27\] _04709_ _04733_ _00662_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09804_ dp.rf.rf\[28\]\[28\] _04710_ _04733_ _00663_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09805_ dp.rf.rf\[28\]\[29\] _04711_ _04733_ _00664_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09806_ dp.rf.rf\[28\]\[2\] _04712_ _04733_ _00665_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09807_ dp.rf.rf\[28\]\[30\] _04713_ _04733_ _00666_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09808_ _04678_ _04731_ _04734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09809_ dp.rf.rf\[28\]\[31\] _04731_ _04735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09810_ _04670_ _04734_ _04735_ _00667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09811_ dp.rf.rf\[28\]\[3\] _04716_ _04733_ _00668_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09812_ dp.rf.rf\[28\]\[4\] _04717_ _04733_ _00669_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09813_ dp.rf.rf\[28\]\[5\] _04718_ _04733_ _00670_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09814_ dp.rf.rf\[28\]\[6\] _04719_ _04733_ _00671_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09815_ dp.rf.rf\[28\]\[7\] _04720_ _04730_ _00672_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09816_ dp.rf.rf\[28\]\[8\] _04721_ _04730_ _00673_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09817_ dp.rf.rf\[28\]\[9\] _04722_ _04730_ _00674_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09818_ _04595_ _04729_ _04736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09819_ _04736_ _04737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09820_ _04073_ dp.rf.rf\[29\]\[0\] _04737_ _00675_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09821_ _04120_ dp.rf.rf\[29\]\[10\] _04737_ _00676_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09822_ _04150_ dp.rf.rf\[29\]\[11\] _04737_ _00677_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09823_ _04164_ dp.rf.rf\[29\]\[12\] _04737_ _00678_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09824_ _04178_ dp.rf.rf\[29\]\[13\] _04737_ _00679_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09825_ _04196_ dp.rf.rf\[29\]\[14\] _04737_ _00680_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09826_ _04209_ dp.rf.rf\[29\]\[15\] _04737_ _00681_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09827_ _04227_ dp.rf.rf\[29\]\[16\] _04737_ _00682_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09828_ _04244_ dp.rf.rf\[29\]\[17\] _04737_ _00683_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09829_ _04736_ _04738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_09830_ _04259_ dp.rf.rf\[29\]\[18\] _04738_ _00684_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09831_ _04270_ dp.rf.rf\[29\]\[19\] _04738_ _00685_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09832_ _04275_ dp.rf.rf\[29\]\[1\] _04738_ _00686_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09833_ _04292_ dp.rf.rf\[29\]\[20\] _04738_ _00687_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09834_ _04313_ dp.rf.rf\[29\]\[21\] _04738_ _00688_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09835_ _04328_ dp.rf.rf\[29\]\[22\] _04738_ _00689_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09836_ _04342_ dp.rf.rf\[29\]\[23\] _04738_ _00690_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09837_ _04359_ dp.rf.rf\[29\]\[24\] _04738_ _00691_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09838_ _04381_ dp.rf.rf\[29\]\[25\] _04738_ _00692_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09839_ _04395_ dp.rf.rf\[29\]\[26\] _04738_ _00693_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09840_ _04736_ _04739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09841_ _04409_ dp.rf.rf\[29\]\[27\] _04739_ _00694_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09842_ _04421_ dp.rf.rf\[29\]\[28\] _04739_ _00695_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09843_ _04439_ dp.rf.rf\[29\]\[29\] _04739_ _00696_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09844_ _04446_ dp.rf.rf\[29\]\[2\] _04739_ _00697_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09845_ _04462_ dp.rf.rf\[29\]\[30\] _04739_ _00698_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09846_ dp.rf.rf\[29\]\[31\] _04740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09847_ _04482_ _04601_ _04729_ _04741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09848_ _04740_ _04737_ _04741_ _04603_ _00699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09849_ _04488_ dp.rf.rf\[29\]\[3\] _04739_ _00700_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09850_ _04496_ dp.rf.rf\[29\]\[4\] _04739_ _00701_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09851_ _04504_ dp.rf.rf\[29\]\[5\] _04739_ _00702_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09852_ _04512_ dp.rf.rf\[29\]\[6\] _04739_ _00703_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09853_ _04523_ dp.rf.rf\[29\]\[7\] _04739_ _00704_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09854_ _04534_ dp.rf.rf\[29\]\[8\] _04736_ _00705_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09855_ _04544_ dp.rf.rf\[29\]\[9\] _04736_ _00706_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09856_ _04081_ _04556_ _04742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09857_ _04742_ _04743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09858_ dp.rf.rf\[2\]\[0\] _04686_ _04743_ _00707_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09859_ dp.rf.rf\[2\]\[10\] _04689_ _04743_ _00708_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09860_ dp.rf.rf\[2\]\[11\] _04690_ _04743_ _00709_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09861_ dp.rf.rf\[2\]\[12\] _04691_ _04743_ _00710_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09862_ dp.rf.rf\[2\]\[13\] _04692_ _04743_ _00711_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09863_ dp.rf.rf\[2\]\[14\] _04693_ _04743_ _00712_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09864_ dp.rf.rf\[2\]\[15\] _04694_ _04743_ _00713_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09865_ dp.rf.rf\[2\]\[16\] _04695_ _04743_ _00714_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09866_ _04742_ _04744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09867_ dp.rf.rf\[2\]\[17\] _04696_ _04744_ _00715_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09868_ dp.rf.rf\[2\]\[18\] _04698_ _04744_ _00716_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09869_ dp.rf.rf\[2\]\[19\] _04699_ _04744_ _00717_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09870_ dp.rf.rf\[2\]\[1\] _04700_ _04744_ _00718_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09871_ dp.rf.rf\[2\]\[20\] _04701_ _04744_ _00719_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09872_ dp.rf.rf\[2\]\[21\] _04702_ _04744_ _00720_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09873_ dp.rf.rf\[2\]\[22\] _04703_ _04744_ _00721_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09874_ dp.rf.rf\[2\]\[23\] _04704_ _04744_ _00722_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09875_ dp.rf.rf\[2\]\[24\] _04705_ _04744_ _00723_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09876_ dp.rf.rf\[2\]\[25\] _04706_ _04744_ _00724_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09877_ _04742_ _04745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_09878_ dp.rf.rf\[2\]\[26\] _04707_ _04745_ _00725_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09879_ dp.rf.rf\[2\]\[27\] _04709_ _04745_ _00726_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09880_ dp.rf.rf\[2\]\[28\] _04710_ _04745_ _00727_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09881_ dp.rf.rf\[2\]\[29\] _04711_ _04745_ _00728_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09882_ dp.rf.rf\[2\]\[2\] _04712_ _04745_ _00729_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09883_ dp.rf.rf\[2\]\[30\] _04713_ _04745_ _00730_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09884_ _04678_ _04743_ _04746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09885_ dp.rf.rf\[2\]\[31\] _04743_ _04747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09886_ _04670_ _04746_ _04747_ _00731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09887_ dp.rf.rf\[2\]\[3\] _04716_ _04745_ _00732_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09888_ dp.rf.rf\[2\]\[4\] _04717_ _04745_ _00733_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09889_ dp.rf.rf\[2\]\[5\] _04718_ _04745_ _00734_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09890_ dp.rf.rf\[2\]\[6\] _04719_ _04745_ _00735_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09891_ dp.rf.rf\[2\]\[7\] _04720_ _04742_ _00736_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09892_ dp.rf.rf\[2\]\[8\] _04721_ _04742_ _00737_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09893_ dp.rf.rf\[2\]\[9\] _04722_ _04742_ _00738_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09894_ _04081_ _04729_ _04748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09895_ _04748_ _04749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09896_ dp.rf.rf\[30\]\[0\] _04686_ _04749_ _00739_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09897_ dp.rf.rf\[30\]\[10\] _04689_ _04749_ _00740_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09898_ dp.rf.rf\[30\]\[11\] _04690_ _04749_ _00741_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09899_ dp.rf.rf\[30\]\[12\] _04691_ _04749_ _00742_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09900_ dp.rf.rf\[30\]\[13\] _04692_ _04749_ _00743_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09901_ dp.rf.rf\[30\]\[14\] _04693_ _04749_ _00744_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09902_ dp.rf.rf\[30\]\[15\] _04694_ _04749_ _00745_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09903_ dp.rf.rf\[30\]\[16\] _04695_ _04749_ _00746_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09904_ _04748_ _04750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09905_ dp.rf.rf\[30\]\[17\] _04696_ _04750_ _00747_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09906_ dp.rf.rf\[30\]\[18\] _04698_ _04750_ _00748_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09907_ dp.rf.rf\[30\]\[19\] _04699_ _04750_ _00749_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09908_ dp.rf.rf\[30\]\[1\] _04700_ _04750_ _00750_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09909_ dp.rf.rf\[30\]\[20\] _04701_ _04750_ _00751_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09910_ dp.rf.rf\[30\]\[21\] _04702_ _04750_ _00752_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09911_ dp.rf.rf\[30\]\[22\] _04703_ _04750_ _00753_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09912_ dp.rf.rf\[30\]\[23\] _04704_ _04750_ _00754_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09913_ dp.rf.rf\[30\]\[24\] _04705_ _04750_ _00755_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09914_ dp.rf.rf\[30\]\[25\] _04706_ _04750_ _00756_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09915_ _04748_ _04751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09916_ dp.rf.rf\[30\]\[26\] _04707_ _04751_ _00757_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09917_ dp.rf.rf\[30\]\[27\] _04709_ _04751_ _00758_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09918_ dp.rf.rf\[30\]\[28\] _04710_ _04751_ _00759_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09919_ dp.rf.rf\[30\]\[29\] _04711_ _04751_ _00760_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09920_ dp.rf.rf\[30\]\[2\] _04712_ _04751_ _00761_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09921_ dp.rf.rf\[30\]\[30\] _04713_ _04751_ _00762_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09922_ _04678_ _04749_ _04752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09923_ dp.rf.rf\[30\]\[31\] _04749_ _04753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09924_ _04670_ _04752_ _04753_ _00763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09925_ dp.rf.rf\[30\]\[3\] _04716_ _04751_ _00764_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09926_ dp.rf.rf\[30\]\[4\] _04717_ _04751_ _00765_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09927_ dp.rf.rf\[30\]\[5\] _04718_ _04751_ _00766_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09928_ dp.rf.rf\[30\]\[6\] _04719_ _04751_ _00767_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09929_ dp.rf.rf\[30\]\[7\] _04720_ _04748_ _00768_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09930_ dp.rf.rf\[30\]\[8\] _04721_ _04748_ _00769_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09931_ dp.rf.rf\[30\]\[9\] _04722_ _04748_ _00770_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09932_ _04545_ _04729_ _04754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09933_ _04754_ _04755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09934_ dp.rf.rf\[31\]\[0\] _04686_ _04755_ _00771_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09935_ dp.rf.rf\[31\]\[10\] _04689_ _04755_ _00772_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09936_ dp.rf.rf\[31\]\[11\] _04690_ _04755_ _00773_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09937_ dp.rf.rf\[31\]\[12\] _04691_ _04755_ _00774_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09938_ dp.rf.rf\[31\]\[13\] _04692_ _04755_ _00775_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09939_ dp.rf.rf\[31\]\[14\] _04693_ _04755_ _00776_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09940_ dp.rf.rf\[31\]\[15\] _04694_ _04755_ _00777_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09941_ dp.rf.rf\[31\]\[16\] _04695_ _04755_ _00778_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09942_ _04754_ _04756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09943_ dp.rf.rf\[31\]\[17\] _04696_ _04756_ _00779_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09944_ dp.rf.rf\[31\]\[18\] _04698_ _04756_ _00780_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09945_ dp.rf.rf\[31\]\[19\] _04699_ _04756_ _00781_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09946_ dp.rf.rf\[31\]\[1\] _04700_ _04756_ _00782_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09947_ dp.rf.rf\[31\]\[20\] _04701_ _04756_ _00783_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09948_ dp.rf.rf\[31\]\[21\] _04702_ _04756_ _00784_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09949_ dp.rf.rf\[31\]\[22\] _04703_ _04756_ _00785_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09950_ dp.rf.rf\[31\]\[23\] _04704_ _04756_ _00786_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09951_ dp.rf.rf\[31\]\[24\] _04705_ _04756_ _00787_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09952_ dp.rf.rf\[31\]\[25\] _04706_ _04756_ _00788_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09953_ _04754_ _04757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09954_ dp.rf.rf\[31\]\[26\] _04707_ _04757_ _00789_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09955_ dp.rf.rf\[31\]\[27\] _04709_ _04757_ _00790_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09956_ dp.rf.rf\[31\]\[28\] _04710_ _04757_ _00791_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09957_ dp.rf.rf\[31\]\[29\] _04711_ _04757_ _00792_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09958_ dp.rf.rf\[31\]\[2\] _04712_ _04757_ _00793_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09959_ dp.rf.rf\[31\]\[30\] _04713_ _04757_ _00794_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09960_ _04678_ _04755_ _04758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09961_ dp.rf.rf\[31\]\[31\] _04755_ _04759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09962_ _04670_ _04758_ _04759_ _00795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09963_ dp.rf.rf\[31\]\[3\] _04716_ _04757_ _00796_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09964_ dp.rf.rf\[31\]\[4\] _04717_ _04757_ _00797_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09965_ dp.rf.rf\[31\]\[5\] _04718_ _04757_ _00798_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09966_ dp.rf.rf\[31\]\[6\] _04719_ _04757_ _00799_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09967_ dp.rf.rf\[31\]\[7\] _04720_ _04754_ _00800_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09968_ dp.rf.rf\[31\]\[8\] _04721_ _04754_ _00801_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09969_ dp.rf.rf\[31\]\[9\] _04722_ _04754_ _00802_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09970_ _04545_ _04556_ _04760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09971_ _04760_ _04761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09972_ dp.rf.rf\[3\]\[0\] _04686_ _04761_ _00803_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09973_ dp.rf.rf\[3\]\[10\] _04689_ _04761_ _00804_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09974_ dp.rf.rf\[3\]\[11\] _04690_ _04761_ _00805_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09975_ dp.rf.rf\[3\]\[12\] _04691_ _04761_ _00806_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09976_ dp.rf.rf\[3\]\[13\] _04692_ _04761_ _00807_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09977_ dp.rf.rf\[3\]\[14\] _04693_ _04761_ _00808_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09978_ dp.rf.rf\[3\]\[15\] _04694_ _04761_ _00809_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09979_ dp.rf.rf\[3\]\[16\] _04695_ _04761_ _00810_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09980_ _04760_ _04762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09981_ dp.rf.rf\[3\]\[17\] _04696_ _04762_ _00811_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09982_ dp.rf.rf\[3\]\[18\] _04698_ _04762_ _00812_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09983_ dp.rf.rf\[3\]\[19\] _04699_ _04762_ _00813_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09984_ dp.rf.rf\[3\]\[1\] _04700_ _04762_ _00814_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09985_ dp.rf.rf\[3\]\[20\] _04701_ _04762_ _00815_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09986_ dp.rf.rf\[3\]\[21\] _04702_ _04762_ _00816_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09987_ dp.rf.rf\[3\]\[22\] _04703_ _04762_ _00817_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09988_ dp.rf.rf\[3\]\[23\] _04704_ _04762_ _00818_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09989_ dp.rf.rf\[3\]\[24\] _04705_ _04762_ _00819_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09990_ dp.rf.rf\[3\]\[25\] _04706_ _04762_ _00820_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09991_ _04760_ _04763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09992_ dp.rf.rf\[3\]\[26\] _04707_ _04763_ _00821_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09993_ dp.rf.rf\[3\]\[27\] _04709_ _04763_ _00822_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09994_ dp.rf.rf\[3\]\[28\] _04710_ _04763_ _00823_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09995_ dp.rf.rf\[3\]\[29\] _04711_ _04763_ _00824_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09996_ dp.rf.rf\[3\]\[2\] _04712_ _04763_ _00825_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09997_ dp.rf.rf\[3\]\[30\] _04713_ _04763_ _00826_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09998_ _04678_ _04761_ _04764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09999_ dp.rf.rf\[3\]\[31\] _04761_ _04765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10000_ _04670_ _04764_ _04765_ _00827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10001_ dp.rf.rf\[3\]\[3\] _04716_ _04763_ _00828_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10002_ dp.rf.rf\[3\]\[4\] _04717_ _04763_ _00829_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10003_ dp.rf.rf\[3\]\[5\] _04718_ _04763_ _00830_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10004_ dp.rf.rf\[3\]\[6\] _04719_ _04763_ _00831_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10005_ dp.rf.rf\[3\]\[7\] _04720_ _04760_ _00832_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10006_ dp.rf.rf\[3\]\[8\] _04721_ _04760_ _00833_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10007_ dp.rf.rf\[3\]\[9\] _04722_ _04760_ _00834_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10008_ _02672_ _04555_ net27 _04766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10009_ _04558_ _04766_ _04767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10010_ _04767_ _04768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10011_ dp.rf.rf\[4\]\[0\] _04686_ _04768_ _00835_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10012_ dp.rf.rf\[4\]\[10\] _04689_ _04768_ _00836_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10013_ dp.rf.rf\[4\]\[11\] _04690_ _04768_ _00837_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10014_ dp.rf.rf\[4\]\[12\] _04691_ _04768_ _00838_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10015_ dp.rf.rf\[4\]\[13\] _04692_ _04768_ _00839_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10016_ dp.rf.rf\[4\]\[14\] _04693_ _04768_ _00840_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10017_ dp.rf.rf\[4\]\[15\] _04694_ _04768_ _00841_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10018_ dp.rf.rf\[4\]\[16\] _04695_ _04768_ _00842_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10019_ _04767_ _04769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10020_ dp.rf.rf\[4\]\[17\] _04696_ _04769_ _00843_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10021_ dp.rf.rf\[4\]\[18\] _04698_ _04769_ _00844_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10022_ dp.rf.rf\[4\]\[19\] _04699_ _04769_ _00845_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10023_ dp.rf.rf\[4\]\[1\] _04700_ _04769_ _00846_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10024_ dp.rf.rf\[4\]\[20\] _04701_ _04769_ _00847_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10025_ dp.rf.rf\[4\]\[21\] _04702_ _04769_ _00848_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10026_ dp.rf.rf\[4\]\[22\] _04703_ _04769_ _00849_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10027_ dp.rf.rf\[4\]\[23\] _04704_ _04769_ _00850_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10028_ dp.rf.rf\[4\]\[24\] _04705_ _04769_ _00851_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10029_ dp.rf.rf\[4\]\[25\] _04706_ _04769_ _00852_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10030_ _04767_ _04770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10031_ dp.rf.rf\[4\]\[26\] _04707_ _04770_ _00853_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10032_ dp.rf.rf\[4\]\[27\] _04709_ _04770_ _00854_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10033_ dp.rf.rf\[4\]\[28\] _04710_ _04770_ _00855_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10034_ dp.rf.rf\[4\]\[29\] _04711_ _04770_ _00856_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10035_ dp.rf.rf\[4\]\[2\] _04712_ _04770_ _00857_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10036_ dp.rf.rf\[4\]\[30\] _04713_ _04770_ _00858_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10037_ _04678_ _04768_ _04771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10038_ dp.rf.rf\[4\]\[31\] _04768_ _04772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10039_ _04670_ _04771_ _04772_ _00859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10040_ dp.rf.rf\[4\]\[3\] _04716_ _04770_ _00860_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10041_ dp.rf.rf\[4\]\[4\] _04717_ _04770_ _00861_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10042_ dp.rf.rf\[4\]\[5\] _04718_ _04770_ _00862_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10043_ dp.rf.rf\[4\]\[6\] _04719_ _04770_ _00863_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10044_ dp.rf.rf\[4\]\[7\] _04720_ _04767_ _00864_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10045_ dp.rf.rf\[4\]\[8\] _04721_ _04767_ _00865_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10046_ dp.rf.rf\[4\]\[9\] _04722_ _04767_ _00866_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10047_ _04595_ _04766_ _04773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10048_ _04773_ _04774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10049_ _04073_ dp.rf.rf\[5\]\[0\] _04774_ _00867_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10050_ _04120_ dp.rf.rf\[5\]\[10\] _04774_ _00868_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10051_ _04150_ dp.rf.rf\[5\]\[11\] _04774_ _00869_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10052_ _04164_ dp.rf.rf\[5\]\[12\] _04774_ _00870_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10053_ _04178_ dp.rf.rf\[5\]\[13\] _04774_ _00871_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10054_ _04196_ dp.rf.rf\[5\]\[14\] _04774_ _00872_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10055_ _04209_ dp.rf.rf\[5\]\[15\] _04774_ _00873_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10056_ _04227_ dp.rf.rf\[5\]\[16\] _04774_ _00874_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10057_ _04244_ dp.rf.rf\[5\]\[17\] _04774_ _00875_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10058_ _04773_ _04775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10059_ _04259_ dp.rf.rf\[5\]\[18\] _04775_ _00876_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10060_ _04270_ dp.rf.rf\[5\]\[19\] _04775_ _00877_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10061_ _04275_ dp.rf.rf\[5\]\[1\] _04775_ _00878_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10062_ _04292_ dp.rf.rf\[5\]\[20\] _04775_ _00879_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10063_ _04313_ dp.rf.rf\[5\]\[21\] _04775_ _00880_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10064_ _04328_ dp.rf.rf\[5\]\[22\] _04775_ _00881_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10065_ _04342_ dp.rf.rf\[5\]\[23\] _04775_ _00882_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10066_ _04359_ dp.rf.rf\[5\]\[24\] _04775_ _00883_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10067_ _04381_ dp.rf.rf\[5\]\[25\] _04775_ _00884_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10068_ _04395_ dp.rf.rf\[5\]\[26\] _04775_ _00885_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10069_ _04773_ _04776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10070_ _04409_ dp.rf.rf\[5\]\[27\] _04776_ _00886_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10071_ _04421_ dp.rf.rf\[5\]\[28\] _04776_ _00887_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10072_ _04439_ dp.rf.rf\[5\]\[29\] _04776_ _00888_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10073_ _04446_ dp.rf.rf\[5\]\[2\] _04776_ _00889_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10074_ _04462_ dp.rf.rf\[5\]\[30\] _04776_ _00890_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10075_ dp.rf.rf\[5\]\[31\] _04777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10076_ _04482_ _04601_ _04766_ _04778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10077_ _04777_ _04774_ _04778_ _04603_ _00891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_10078_ _04488_ dp.rf.rf\[5\]\[3\] _04776_ _00892_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10079_ _04496_ dp.rf.rf\[5\]\[4\] _04776_ _00893_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10080_ _04504_ dp.rf.rf\[5\]\[5\] _04776_ _00894_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10081_ _04512_ dp.rf.rf\[5\]\[6\] _04776_ _00895_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10082_ _04523_ dp.rf.rf\[5\]\[7\] _04776_ _00896_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10083_ _04534_ dp.rf.rf\[5\]\[8\] _04773_ _00897_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10084_ _04544_ dp.rf.rf\[5\]\[9\] _04773_ _00898_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10085_ _04081_ _04766_ _04779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10086_ _04779_ _04780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10087_ dp.rf.rf\[6\]\[0\] _04686_ _04780_ _00899_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10088_ dp.rf.rf\[6\]\[10\] _04689_ _04780_ _00900_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10089_ dp.rf.rf\[6\]\[11\] _04690_ _04780_ _00901_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10090_ dp.rf.rf\[6\]\[12\] _04691_ _04780_ _00902_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10091_ dp.rf.rf\[6\]\[13\] _04692_ _04780_ _00903_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10092_ dp.rf.rf\[6\]\[14\] _04693_ _04780_ _00904_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10093_ dp.rf.rf\[6\]\[15\] _04694_ _04780_ _00905_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10094_ dp.rf.rf\[6\]\[16\] _04695_ _04780_ _00906_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10095_ _04779_ _04781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10096_ dp.rf.rf\[6\]\[17\] _04696_ _04781_ _00907_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10097_ dp.rf.rf\[6\]\[18\] _04698_ _04781_ _00908_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10098_ dp.rf.rf\[6\]\[19\] _04699_ _04781_ _00909_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10099_ dp.rf.rf\[6\]\[1\] _04700_ _04781_ _00910_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10100_ dp.rf.rf\[6\]\[20\] _04701_ _04781_ _00911_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10101_ dp.rf.rf\[6\]\[21\] _04702_ _04781_ _00912_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10102_ dp.rf.rf\[6\]\[22\] _04703_ _04781_ _00913_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10103_ dp.rf.rf\[6\]\[23\] _04704_ _04781_ _00914_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10104_ dp.rf.rf\[6\]\[24\] _04705_ _04781_ _00915_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10105_ dp.rf.rf\[6\]\[25\] _04706_ _04781_ _00916_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10106_ _04779_ _04782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10107_ dp.rf.rf\[6\]\[26\] _04707_ _04782_ _00917_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10108_ dp.rf.rf\[6\]\[27\] _04709_ _04782_ _00918_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10109_ dp.rf.rf\[6\]\[28\] _04710_ _04782_ _00919_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10110_ dp.rf.rf\[6\]\[29\] _04711_ _04782_ _00920_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10111_ dp.rf.rf\[6\]\[2\] _04712_ _04782_ _00921_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10112_ dp.rf.rf\[6\]\[30\] _04713_ _04782_ _00922_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10113_ _04678_ _04780_ _04783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10114_ dp.rf.rf\[6\]\[31\] _04780_ _04784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10115_ _04603_ _04783_ _04784_ _00923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10116_ dp.rf.rf\[6\]\[3\] _04716_ _04782_ _00924_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10117_ dp.rf.rf\[6\]\[4\] _04717_ _04782_ _00925_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10118_ dp.rf.rf\[6\]\[5\] _04718_ _04782_ _00926_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10119_ dp.rf.rf\[6\]\[6\] _04719_ _04782_ _00927_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10120_ dp.rf.rf\[6\]\[7\] _04720_ _04779_ _00928_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10121_ dp.rf.rf\[6\]\[8\] _04721_ _04779_ _00929_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10122_ dp.rf.rf\[6\]\[9\] _04722_ _04779_ _00930_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10123_ _04545_ _04766_ _04785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10124_ _04785_ _04786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10125_ dp.rf.rf\[7\]\[0\] _04686_ _04786_ _00931_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10126_ dp.rf.rf\[7\]\[10\] _04689_ _04786_ _00932_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10127_ dp.rf.rf\[7\]\[11\] _04690_ _04786_ _00933_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10128_ dp.rf.rf\[7\]\[12\] _04691_ _04786_ _00934_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10129_ dp.rf.rf\[7\]\[13\] _04692_ _04786_ _00935_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10130_ dp.rf.rf\[7\]\[14\] _04693_ _04786_ _00936_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10131_ dp.rf.rf\[7\]\[15\] _04694_ _04786_ _00937_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10132_ dp.rf.rf\[7\]\[16\] _04695_ _04786_ _00938_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10133_ _04785_ _04787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10134_ dp.rf.rf\[7\]\[17\] _04696_ _04787_ _00939_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10135_ dp.rf.rf\[7\]\[18\] _04698_ _04787_ _00940_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10136_ dp.rf.rf\[7\]\[19\] _04699_ _04787_ _00941_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10137_ dp.rf.rf\[7\]\[1\] _04700_ _04787_ _00942_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10138_ dp.rf.rf\[7\]\[20\] _04701_ _04787_ _00943_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10139_ dp.rf.rf\[7\]\[21\] _04702_ _04787_ _00944_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10140_ dp.rf.rf\[7\]\[22\] _04703_ _04787_ _00945_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10141_ dp.rf.rf\[7\]\[23\] _04704_ _04787_ _00946_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10142_ dp.rf.rf\[7\]\[24\] _04705_ _04787_ _00947_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10143_ dp.rf.rf\[7\]\[25\] _04706_ _04787_ _00948_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10144_ _04785_ _04788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10145_ dp.rf.rf\[7\]\[26\] _04707_ _04788_ _00949_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10146_ dp.rf.rf\[7\]\[27\] _04709_ _04788_ _00950_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10147_ dp.rf.rf\[7\]\[28\] _04710_ _04788_ _00951_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10148_ dp.rf.rf\[7\]\[29\] _04711_ _04788_ _00952_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10149_ dp.rf.rf\[7\]\[2\] _04712_ _04788_ _00953_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10150_ dp.rf.rf\[7\]\[30\] _04713_ _04788_ _00954_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10151_ _04482_ _04786_ _04789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10152_ dp.rf.rf\[7\]\[31\] _04786_ _04790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10153_ _04603_ _04789_ _04790_ _00955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10154_ dp.rf.rf\[7\]\[3\] _04716_ _04788_ _00956_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10155_ dp.rf.rf\[7\]\[4\] _04717_ _04788_ _00957_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10156_ dp.rf.rf\[7\]\[5\] _04718_ _04788_ _00958_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10157_ dp.rf.rf\[7\]\[6\] _04719_ _04788_ _00959_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10158_ dp.rf.rf\[7\]\[7\] _04720_ _04785_ _00960_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10159_ dp.rf.rf\[7\]\[8\] _04721_ _04785_ _00961_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10160_ dp.rf.rf\[7\]\[9\] _04722_ _04785_ _00962_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10161_ _04075_ _04558_ _04791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10162_ _04791_ _04792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10163_ dp.rf.rf\[8\]\[0\] _04072_ _04792_ _00963_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10164_ dp.rf.rf\[8\]\[10\] _04119_ _04792_ _00964_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10165_ dp.rf.rf\[8\]\[11\] _04149_ _04792_ _00965_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10166_ dp.rf.rf\[8\]\[12\] _04163_ _04792_ _00966_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10167_ dp.rf.rf\[8\]\[13\] _04177_ _04792_ _00967_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10168_ dp.rf.rf\[8\]\[14\] _04195_ _04792_ _00968_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10169_ dp.rf.rf\[8\]\[15\] _04208_ _04792_ _00969_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10170_ dp.rf.rf\[8\]\[16\] _04226_ _04792_ _00970_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10171_ _04791_ _04793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_10172_ dp.rf.rf\[8\]\[17\] _04243_ _04793_ _00971_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10173_ dp.rf.rf\[8\]\[18\] _04258_ _04793_ _00972_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10174_ dp.rf.rf\[8\]\[19\] _04269_ _04793_ _00973_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10175_ dp.rf.rf\[8\]\[1\] _04274_ _04793_ _00974_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10176_ dp.rf.rf\[8\]\[20\] _04291_ _04793_ _00975_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10177_ dp.rf.rf\[8\]\[21\] _04312_ _04793_ _00976_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10178_ dp.rf.rf\[8\]\[22\] _04327_ _04793_ _00977_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10179_ dp.rf.rf\[8\]\[23\] _04341_ _04793_ _00978_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10180_ dp.rf.rf\[8\]\[24\] _04358_ _04793_ _00979_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10181_ dp.rf.rf\[8\]\[25\] _04380_ _04793_ _00980_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10182_ _04791_ _04794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10183_ dp.rf.rf\[8\]\[26\] _04394_ _04794_ _00981_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10184_ dp.rf.rf\[8\]\[27\] _04408_ _04794_ _00982_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10185_ dp.rf.rf\[8\]\[28\] _04420_ _04794_ _00983_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10186_ dp.rf.rf\[8\]\[29\] _04438_ _04794_ _00984_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10187_ dp.rf.rf\[8\]\[2\] _04445_ _04794_ _00985_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10188_ dp.rf.rf\[8\]\[30\] _04461_ _04794_ _00986_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10189_ _04482_ _04792_ _04795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10190_ dp.rf.rf\[8\]\[31\] _04792_ _04796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10191_ _04603_ _04795_ _04796_ _00987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10192_ dp.rf.rf\[8\]\[3\] _04487_ _04794_ _00988_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10193_ dp.rf.rf\[8\]\[4\] _04495_ _04794_ _00989_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10194_ dp.rf.rf\[8\]\[5\] _04503_ _04794_ _00990_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10195_ dp.rf.rf\[8\]\[6\] _04511_ _04794_ _00991_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10196_ dp.rf.rf\[8\]\[7\] _04522_ _04791_ _00992_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10197_ dp.rf.rf\[8\]\[8\] _04533_ _04791_ _00993_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10198_ dp.rf.rf\[8\]\[9\] _04543_ _04791_ _00994_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10199_ _04075_ _04595_ _04797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10200_ _04797_ _04798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10201_ _04073_ dp.rf.rf\[9\]\[0\] _04798_ _00995_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10202_ _04120_ dp.rf.rf\[9\]\[10\] _04798_ _00996_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10203_ _04150_ dp.rf.rf\[9\]\[11\] _04798_ _00997_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10204_ _04164_ dp.rf.rf\[9\]\[12\] _04798_ _00998_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10205_ _04178_ dp.rf.rf\[9\]\[13\] _04798_ _00999_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10206_ _04196_ dp.rf.rf\[9\]\[14\] _04798_ _01000_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10207_ _04209_ dp.rf.rf\[9\]\[15\] _04798_ _01001_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10208_ _04227_ dp.rf.rf\[9\]\[16\] _04798_ _01002_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10209_ _04244_ dp.rf.rf\[9\]\[17\] _04798_ _01003_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10210_ _04797_ _04799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_10211_ _04259_ dp.rf.rf\[9\]\[18\] _04799_ _01004_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10212_ _04270_ dp.rf.rf\[9\]\[19\] _04799_ _01005_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10213_ _04275_ dp.rf.rf\[9\]\[1\] _04799_ _01006_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10214_ _04292_ dp.rf.rf\[9\]\[20\] _04799_ _01007_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10215_ _04313_ dp.rf.rf\[9\]\[21\] _04799_ _01008_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10216_ _04328_ dp.rf.rf\[9\]\[22\] _04799_ _01009_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10217_ _04342_ dp.rf.rf\[9\]\[23\] _04799_ _01010_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10218_ _04359_ dp.rf.rf\[9\]\[24\] _04799_ _01011_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10219_ _04381_ dp.rf.rf\[9\]\[25\] _04799_ _01012_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10220_ _04395_ dp.rf.rf\[9\]\[26\] _04799_ _01013_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10221_ _04797_ _04800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10222_ _04409_ dp.rf.rf\[9\]\[27\] _04800_ _01014_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10223_ _04421_ dp.rf.rf\[9\]\[28\] _04800_ _01015_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10224_ _04439_ dp.rf.rf\[9\]\[29\] _04800_ _01016_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10225_ _04446_ dp.rf.rf\[9\]\[2\] _04800_ _01017_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10226_ _04462_ dp.rf.rf\[9\]\[30\] _04800_ _01018_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10227_ dp.rf.rf\[9\]\[31\] _04801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10228_ _04075_ _04481_ _04601_ _04802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10229_ _04801_ _04798_ _04802_ _04471_ _01019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_10230_ _04488_ dp.rf.rf\[9\]\[3\] _04800_ _01020_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10231_ _04496_ dp.rf.rf\[9\]\[4\] _04800_ _01021_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10232_ _04504_ dp.rf.rf\[9\]\[5\] _04800_ _01022_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10233_ _04512_ dp.rf.rf\[9\]\[6\] _04800_ _01023_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10234_ _04523_ dp.rf.rf\[9\]\[7\] _04800_ _01024_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10235_ _04534_ dp.rf.rf\[9\]\[8\] _04797_ _01025_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10236_ _04544_ dp.rf.rf\[9\]\[9\] _04797_ _01026_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10237_ _04161_ _04059_ _04803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10238_ _04803_ _04804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10239_ _04112_ _04117_ _04804_ dp.ISRmux.d0\[10\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10240_ _04142_ _04147_ _04804_ dp.ISRmux.d0\[11\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10241_ _04158_ _04160_ _04804_ dp.ISRmux.d0\[12\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10242_ _04182_ _04059_ _04175_ _04805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10243_ _04804_ _04173_ _04805_ dp.ISRmux.d0\[13\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10244_ _04185_ _04193_ _04061_ dp.ISRmux.d0\[14\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10245_ _04200_ _04203_ _04804_ dp.ISRmux.d0\[15\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10246_ _04220_ _04224_ _04061_ dp.ISRmux.d0\[16\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10247_ _04234_ _04241_ _04061_ dp.ISRmux.d0\[17\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10248_ _04251_ _04256_ _04061_ dp.ISRmux.d0\[18\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10249_ _04264_ _04267_ _04061_ dp.ISRmux.d0\[19\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10250_ _04286_ _04289_ _04804_ dp.ISRmux.d0\[20\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10251_ _04307_ _04310_ _04804_ dp.ISRmux.d0\[21\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10252_ _04323_ _04325_ _04804_ dp.ISRmux.d0\[22\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10253_ _04182_ _04059_ _04340_ _04806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10254_ _04804_ _04333_ _04806_ dp.ISRmux.d0\[23\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10255_ _04350_ _04356_ _04061_ dp.ISRmux.d0\[24\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10256_ _04365_ _04378_ _04060_ dp.ISRmux.d0\[25\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10257_ _04182_ _04059_ _04390_ _04807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10258_ _04804_ _04388_ _04807_ dp.ISRmux.d0\[26\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10259_ _04404_ _04406_ _04803_ dp.ISRmux.d0\[27\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10260_ _04182_ _04059_ _04415_ _04808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_10261_ _04061_ _04412_ _04808_ dp.ISRmux.d0\[28\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10262_ _05196_ _04428_ _04809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10263_ _04432_ _04809_ _04060_ dp.ISRmux.d0\[29\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10264_ _04442_ _04443_ _04060_ dp.ISRmux.d0\[2\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10265_ _04182_ _04059_ _04459_ _04810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_10266_ _04061_ _04453_ _04810_ dp.ISRmux.d0\[30\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10267_ _04470_ _04474_ _04803_ dp.ISRmux.d0\[31\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10268_ _05092_ _04485_ _04060_ dp.ISRmux.d0\[3\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10269_ _04492_ _04493_ _04060_ dp.ISRmux.d0\[4\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10270_ _04499_ _04501_ _04803_ dp.ISRmux.d0\[5\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10271_ _04505_ _04507_ _04803_ dp.ISRmux.d0\[6\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10272_ _04519_ _04516_ _04060_ dp.ISRmux.d0\[7\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10273_ _04529_ _04531_ _04803_ dp.ISRmux.d0\[8\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10274_ _04539_ _04541_ _04803_ dp.ISRmux.d0\[9\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10275_ net22 _01079_ _01081_ net127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10276_ net94 _03015_ _04811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10277_ net275 _04811_ net129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10278_ _02375_ _04811_ net130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10279_ net94 _03015_ _02336_ net131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10280_ _03876_ _04811_ net132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10281_ _02244_ _04811_ net133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10282_ _03940_ _04811_ net134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10283_ _01068_ net94 _04812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10284_ _04812_ _04813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_10285_ net255 _04813_ net135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10286_ _02095_ _04813_ net136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10287_ _02050_ _04813_ net137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10288_ _01989_ _04813_ net138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10289_ _01938_ _04813_ net140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10290_ _01886_ _04813_ net141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10291_ _01841_ _04813_ net142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10292_ _01785_ _04813_ net143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10293_ _03995_ _04813_ net144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10294_ _01683_ _04813_ net145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10295_ _01621_ _04812_ net146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10296_ _01565_ _04812_ net147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10297_ _01489_ _04812_ net148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10298_ _01412_ _04812_ net149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10299_ _01321_ _04812_ net151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10300_ _01284_ _04812_ net152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10301_ _02516_ _04811_ net158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10302_ _02477_ _04811_ net159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10303_ _04814_ _04815_ _04816_ _04817_ _04818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_10304_ _04819_ _04820_ _04821_ _04822_ _04823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_10305_ net169 _04825_ _04826_ _04827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10306_ _04828_ _04829_ _04830_ _04831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10307_ _04832_ _04833_ _04834_ _04835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10308_ _04836_ _04837_ _04838_ _04839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10309_ _04840_ _04841_ _04842_ _04843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10310_ _04844_ _04845_ _04846_ _04847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10311_ _04848_ _04849_ _04850_ _04851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10312_ _04852_ _04853_ _04854_ _04855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10313_ _04856_ _04857_ _04858_ _04859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10314_ _04860_ _04861_ _04862_ _04863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10315_ _04864_ _04865_ _04866_ _04867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_10316_ _04868_ _04869_ _04870_ _04871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10317_ _04872_ _04873_ _04874_ _04875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10318_ _04876_ _04877_ _04878_ _04879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10319_ _04880_ _04881_ _04882_ _04883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10320_ _04884_ _04885_ _04886_ _04887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10321_ _04888_ _04889_ _04890_ _04891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10322_ _04892_ _04893_ _04894_ _04895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10323_ _04896_ _04897_ _04898_ _04899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10324_ _04900_ _04901_ _04902_ _04903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10325_ _04904_ _04905_ _04906_ _04907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10326_ _04908_ _04909_ _04910_ _04911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10327_ _04912_ _04913_ _04914_ _04915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10328_ _04916_ _04917_ _04918_ _04919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10329_ _04920_ _04921_ _04922_ _04923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10330_ _04924_ _04925_ _04926_ _04927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10331_ _04928_ _04929_ _04930_ _04931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10332_ _04932_ _04933_ _04934_ _04935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10333_ _04936_ _04937_ _04938_ _04939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10334_ _04940_ _04941_ _04942_ _04943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10335_ _04944_ _04945_ _04946_ _04947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_10336_ _04948_ _04949_ _04950_ _04951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10337_ _04952_ _04953_ _04954_ _04955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10338_ _04956_ _04957_ _04958_ _04959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10339_ _04960_ _04961_ _04962_ _04963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10340_ _04964_ _04965_ _04966_ _04967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10341_ _04968_ _04969_ _04970_ _04971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10342_ _04972_ _04973_ _04974_ _04975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10343_ _04976_ _04977_ _04978_ _04979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10344_ _04980_ _04981_ _04982_ _04983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10345_ _04984_ _04985_ _04986_ _04987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10346_ _04988_ _04989_ _04990_ _04991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10347_ _04992_ _04993_ _04994_ _04995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10348_ _04996_ _04997_ _04998_ _04999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10349_ _05000_ _05001_ _05002_ _05003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10350_ _05004_ _05005_ _05006_ _05007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10351_ net181 _05009_ _05010_ _05011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10352_ _05012_ _05013_ _05014_ _05015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10353_ _05017_ net170 _05018_ _05019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10354_ _05020_ _05021_ _05022_ _05023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10355_ _05024_ _05025_ _05026_ _05027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_10356_ _05028_ _05029_ _05030_ _05031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10357_ _05032_ _05033_ _05034_ _05035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10358_ _05036_ _05037_ _05038_ _05039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10359_ _05040_ _05041_ _05042_ _05043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10360_ _05044_ _05045_ _05046_ _05047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10361_ _05048_ _05049_ _05050_ _05051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10362_ _05052_ _05053_ _05054_ _05055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10363_ _05056_ _05057_ _05058_ _05059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10364_ _05060_ _05061_ _05062_ _05063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10365_ _05065_ net266 _05066_ _05067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_10366_ _05068_ _05069_ _05070_ _05071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10367_ _04815_ _04816_ _05072_ _05073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10368_ _05074_ _05075_ _05076_ _05077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10369_ _05078_ _05079_ _04819_ _05080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10370_ _04820_ _04821_ _05081_ _05082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10371_ _05083_ _05084_ _05085_ _05086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10372_ _05087_ _05088_ _05089_ _05090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10373_ net117 net120 _05091_ _05092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10374_ _05093_ _05094_ _05095_ _05096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_10375_ _05097_ _05098_ _05099_ _05100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10376_ _05101_ _05102_ _05103_ _05104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10377_ _05105_ _05106_ _05107_ _05108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10378_ _05109_ _05110_ _05111_ _05112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10379_ _05113_ _05114_ _05115_ _05116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_10380_ _05117_ _05118_ _05119_ _05120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10381_ _05121_ _05122_ _05123_ _05124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10382_ _05125_ _05126_ _05127_ _05128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10383_ _05129_ _05130_ _05131_ _05132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10384_ _05133_ _05134_ _05135_ _05136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10385_ _05137_ _05138_ _05139_ _05140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10386_ _05141_ _05142_ _05143_ _05144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10387_ _05145_ _05146_ _05147_ _05148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10388_ _05149_ _05150_ _05151_ _05152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10389_ _05153_ _05154_ _05155_ _05156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10390_ _05157_ _05158_ _05159_ _05160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10391_ _05161_ _05162_ _05163_ _05164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10392_ _05165_ _05166_ _05167_ _05168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10393_ _05169_ _05170_ _05171_ _05172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10394_ _05173_ _05174_ _05175_ _05176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10395_ _05177_ _05178_ _05179_ _05180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10396_ _05181_ _05182_ _05183_ _05184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10397_ _05185_ _05186_ _05187_ _05188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10398_ _05189_ _05190_ _05191_ _05192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10399_ _05193_ _05194_ _05195_ _05196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_10400_ _05197_ _05198_ _05199_ _05200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
Xdp.pcreg.q\[0\]$_DFFE_PP0P_ _00001_ _00000_ clknet_leaf_25_clk
+ net95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[10\]$_DFF_PP0_ dp.ISRmux.d0\[10\] _00000_ clknet_leaf_22_clk
+ net96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[11\]$_DFF_PP0_ dp.ISRmux.d0\[11\] _00000_ clknet_leaf_22_clk
+ net97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[12\]$_DFF_PP0_ dp.ISRmux.d0\[12\] _00000_ clknet_leaf_22_clk
+ net98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[13\]$_DFF_PP0_ dp.ISRmux.d0\[13\] _00000_ clknet_leaf_22_clk
+ net99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[14\]$_DFF_PP0_ dp.ISRmux.d0\[14\] _00000_ clknet_leaf_22_clk
+ net100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[15\]$_DFF_PP0_ dp.ISRmux.d0\[15\] _00000_ clknet_leaf_22_clk
+ net101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[16\]$_DFF_PP0_ dp.ISRmux.d0\[16\] _00000_ clknet_leaf_22_clk
+ net102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[17\]$_DFF_PP0_ dp.ISRmux.d0\[17\] _00000_ clknet_leaf_22_clk
+ net103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[18\]$_DFF_PP0_ dp.ISRmux.d0\[18\] _00000_ clknet_leaf_22_clk
+ net104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[19\]$_DFF_PP0_ dp.ISRmux.d0\[19\] _00000_ clknet_leaf_22_clk
+ net105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[1\]$_DFFE_PP0P_ _00002_ _00000_ clknet_leaf_25_clk
+ net106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[20\]$_DFF_PP0_ dp.ISRmux.d0\[20\] _00000_ clknet_leaf_22_clk
+ net107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[21\]$_DFF_PP0_ dp.ISRmux.d0\[21\] _00000_ clknet_leaf_22_clk
+ net108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[22\]$_DFF_PP0_ dp.ISRmux.d0\[22\] _00000_ clknet_leaf_22_clk
+ net109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[23\]$_DFF_PP0_ dp.ISRmux.d0\[23\] _00000_ clknet_leaf_22_clk
+ net110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[24\]$_DFF_PP0_ dp.ISRmux.d0\[24\] _00000_ clknet_leaf_22_clk
+ net111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[25\]$_DFF_PP0_ dp.ISRmux.d0\[25\] _00000_ clknet_leaf_23_clk
+ net112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[26\]$_DFF_PP0_ dp.ISRmux.d0\[26\] _00000_ clknet_leaf_23_clk
+ net113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[27\]$_DFF_PP0_ dp.ISRmux.d0\[27\] _00000_ clknet_leaf_23_clk
+ net114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[28\]$_DFF_PP0_ dp.ISRmux.d0\[28\] _00000_ clknet_leaf_23_clk
+ net115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[29\]$_DFF_PP0_ dp.ISRmux.d0\[29\] _00000_ clknet_leaf_23_clk
+ net116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[2\]$_DFF_PP0_ dp.ISRmux.d0\[2\] _00000_ clknet_leaf_25_clk
+ net117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[30\]$_DFF_PP0_ dp.ISRmux.d0\[30\] _00000_ clknet_leaf_23_clk
+ net118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[31\]$_DFF_PP0_ dp.ISRmux.d0\[31\] _00000_ clknet_leaf_25_clk
+ net119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[3\]$_DFF_PP0_ dp.ISRmux.d0\[3\] _00000_ clknet_leaf_25_clk
+ net120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[4\]$_DFF_PP0_ dp.ISRmux.d0\[4\] _00000_ clknet_leaf_25_clk
+ net121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[5\]$_DFF_PP0_ dp.ISRmux.d0\[5\] _00000_ clknet_leaf_25_clk
+ net122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[6\]$_DFF_PP0_ dp.ISRmux.d0\[6\] _00000_ clknet_leaf_25_clk
+ net123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[7\]$_DFF_PP0_ dp.ISRmux.d0\[7\] _00000_ clknet_leaf_25_clk
+ net124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[8\]$_DFF_PP0_ dp.ISRmux.d0\[8\] _00000_ clknet_leaf_25_clk
+ net125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.pcreg.q\[9\]$_DFF_PP0_ dp.ISRmux.d0\[9\] _00000_ clknet_leaf_25_clk
+ net126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdp.rf.rf\[0\]\[0\]$_DFFE_PP_ _00003_ clknet_leaf_0_clk dp.rf.rf\[0\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[10\]$_DFFE_PP_ _00004_ clknet_leaf_12_clk
+ dp.rf.rf\[0\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[11\]$_DFFE_PP_ _00005_ clknet_leaf_6_clk dp.rf.rf\[0\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[12\]$_DFFE_PP_ _00006_ clknet_leaf_2_clk dp.rf.rf\[0\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[13\]$_DFFE_PP_ _00007_ clknet_leaf_8_clk dp.rf.rf\[0\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[14\]$_DFFE_PP_ _00008_ clknet_leaf_8_clk dp.rf.rf\[0\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[15\]$_DFFE_PP_ _00009_ clknet_leaf_5_clk dp.rf.rf\[0\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[16\]$_DFFE_PP_ _00010_ clknet_leaf_8_clk dp.rf.rf\[0\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[17\]$_DFFE_PP_ _00011_ clknet_leaf_15_clk
+ dp.rf.rf\[0\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[18\]$_DFFE_PP_ _00012_ clknet_leaf_15_clk
+ dp.rf.rf\[0\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[19\]$_DFFE_PP_ _00013_ clknet_leaf_19_clk
+ dp.rf.rf\[0\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[1\]$_DFFE_PP_ _00014_ clknet_leaf_31_clk dp.rf.rf\[0\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[20\]$_DFFE_PP_ _00015_ clknet_leaf_16_clk
+ dp.rf.rf\[0\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[21\]$_DFFE_PP_ _00016_ clknet_leaf_16_clk
+ dp.rf.rf\[0\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[22\]$_DFFE_PP_ _00017_ clknet_leaf_18_clk
+ dp.rf.rf\[0\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[23\]$_DFFE_PP_ _00018_ clknet_leaf_19_clk
+ dp.rf.rf\[0\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[24\]$_DFFE_PP_ _00019_ clknet_leaf_23_clk
+ dp.rf.rf\[0\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[25\]$_DFFE_PP_ _00020_ clknet_leaf_19_clk
+ dp.rf.rf\[0\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[26\]$_DFFE_PP_ _00021_ clknet_leaf_31_clk
+ dp.rf.rf\[0\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[27\]$_DFFE_PP_ _00022_ clknet_leaf_26_clk
+ dp.rf.rf\[0\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[28\]$_DFFE_PP_ _00023_ clknet_leaf_26_clk
+ dp.rf.rf\[0\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[29\]$_DFFE_PP_ _00024_ clknet_leaf_35_clk
+ dp.rf.rf\[0\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[2\]$_DFFE_PP_ _00025_ clknet_leaf_3_clk dp.rf.rf\[0\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[30\]$_DFFE_PP_ _00026_ clknet_leaf_27_clk
+ dp.rf.rf\[0\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[31\]$_DFFE_PP_ _00027_ clknet_leaf_4_clk dp.rf.rf\[0\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[3\]$_DFFE_PP_ _00028_ clknet_leaf_35_clk dp.rf.rf\[0\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[4\]$_DFFE_PP_ _00029_ clknet_leaf_34_clk dp.rf.rf\[0\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[5\]$_DFFE_PP_ _00030_ clknet_leaf_36_clk dp.rf.rf\[0\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[6\]$_DFFE_PP_ _00031_ clknet_leaf_26_clk dp.rf.rf\[0\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[7\]$_DFFE_PP_ _00032_ clknet_leaf_37_clk dp.rf.rf\[0\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[8\]$_DFFE_PP_ _00033_ clknet_leaf_3_clk dp.rf.rf\[0\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[0\]\[9\]$_DFFE_PP_ _00034_ clknet_leaf_0_clk dp.rf.rf\[0\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[0\]$_DFFE_PP_ _00035_ clknet_leaf_0_clk dp.rf.rf\[10\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[10\]$_DFFE_PP_ _00036_ clknet_leaf_9_clk
+ dp.rf.rf\[10\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[11\]$_DFFE_PP_ _00037_ clknet_leaf_9_clk
+ dp.rf.rf\[10\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[12\]$_DFFE_PP_ _00038_ clknet_leaf_1_clk
+ dp.rf.rf\[10\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[13\]$_DFFE_PP_ _00039_ clknet_leaf_10_clk
+ dp.rf.rf\[10\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[14\]$_DFFE_PP_ _00040_ clknet_leaf_6_clk
+ dp.rf.rf\[10\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[15\]$_DFFE_PP_ _00041_ clknet_leaf_12_clk
+ dp.rf.rf\[10\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[16\]$_DFFE_PP_ _00042_ clknet_leaf_12_clk
+ dp.rf.rf\[10\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[17\]$_DFFE_PP_ _00043_ clknet_leaf_12_clk
+ dp.rf.rf\[10\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[18\]$_DFFE_PP_ _00044_ clknet_leaf_14_clk
+ dp.rf.rf\[10\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[19\]$_DFFE_PP_ _00045_ clknet_leaf_20_clk
+ dp.rf.rf\[10\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[1\]$_DFFE_PP_ _00046_ clknet_leaf_31_clk
+ dp.rf.rf\[10\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[20\]$_DFFE_PP_ _00047_ clknet_leaf_17_clk
+ dp.rf.rf\[10\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[21\]$_DFFE_PP_ _00048_ clknet_leaf_4_clk
+ dp.rf.rf\[10\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[22\]$_DFFE_PP_ _00049_ clknet_leaf_16_clk
+ dp.rf.rf\[10\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[23\]$_DFFE_PP_ _00050_ clknet_leaf_19_clk
+ dp.rf.rf\[10\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[24\]$_DFFE_PP_ _00051_ clknet_leaf_23_clk
+ dp.rf.rf\[10\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[25\]$_DFFE_PP_ _00052_ clknet_leaf_21_clk
+ dp.rf.rf\[10\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[26\]$_DFFE_PP_ _00053_ clknet_leaf_31_clk
+ dp.rf.rf\[10\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[27\]$_DFFE_PP_ _00054_ clknet_leaf_30_clk
+ dp.rf.rf\[10\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[28\]$_DFFE_PP_ _00055_ clknet_leaf_26_clk
+ dp.rf.rf\[10\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[29\]$_DFFE_PP_ _00056_ clknet_leaf_28_clk
+ dp.rf.rf\[10\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[2\]$_DFFE_PP_ _00057_ clknet_leaf_3_clk dp.rf.rf\[10\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[30\]$_DFFE_PP_ _00058_ clknet_leaf_28_clk
+ dp.rf.rf\[10\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[31\]$_DFFE_PP_ _00059_ clknet_leaf_4_clk
+ dp.rf.rf\[10\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[3\]$_DFFE_PP_ _00060_ clknet_leaf_35_clk
+ dp.rf.rf\[10\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[4\]$_DFFE_PP_ _00061_ clknet_leaf_34_clk
+ dp.rf.rf\[10\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[5\]$_DFFE_PP_ _00062_ clknet_leaf_36_clk
+ dp.rf.rf\[10\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[6\]$_DFFE_PP_ _00063_ clknet_leaf_27_clk
+ dp.rf.rf\[10\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[7\]$_DFFE_PP_ _00064_ clknet_leaf_37_clk
+ dp.rf.rf\[10\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[8\]$_DFFE_PP_ _00065_ clknet_leaf_2_clk dp.rf.rf\[10\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[10\]\[9\]$_DFFE_PP_ _00066_ clknet_leaf_3_clk dp.rf.rf\[10\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[0\]$_DFFE_PP_ _00067_ clknet_leaf_1_clk dp.rf.rf\[11\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[10\]$_DFFE_PP_ _00068_ clknet_leaf_10_clk
+ dp.rf.rf\[11\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[11\]$_DFFE_PP_ _00069_ clknet_leaf_9_clk
+ dp.rf.rf\[11\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[12\]$_DFFE_PP_ _00070_ clknet_leaf_1_clk
+ dp.rf.rf\[11\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[13\]$_DFFE_PP_ _00071_ clknet_leaf_8_clk
+ dp.rf.rf\[11\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[14\]$_DFFE_PP_ _00072_ clknet_leaf_6_clk
+ dp.rf.rf\[11\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[15\]$_DFFE_PP_ _00073_ clknet_leaf_12_clk
+ dp.rf.rf\[11\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[16\]$_DFFE_PP_ _00074_ clknet_leaf_12_clk
+ dp.rf.rf\[11\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[17\]$_DFFE_PP_ _00075_ clknet_leaf_12_clk
+ dp.rf.rf\[11\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[18\]$_DFFE_PP_ _00076_ clknet_leaf_14_clk
+ dp.rf.rf\[11\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[19\]$_DFFE_PP_ _00077_ clknet_leaf_20_clk
+ dp.rf.rf\[11\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[1\]$_DFFE_PP_ _00078_ clknet_leaf_4_clk dp.rf.rf\[11\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[20\]$_DFFE_PP_ _00079_ clknet_leaf_4_clk
+ dp.rf.rf\[11\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[21\]$_DFFE_PP_ _00080_ clknet_leaf_4_clk
+ dp.rf.rf\[11\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[22\]$_DFFE_PP_ _00081_ clknet_leaf_16_clk
+ dp.rf.rf\[11\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[23\]$_DFFE_PP_ _00082_ clknet_leaf_19_clk
+ dp.rf.rf\[11\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[24\]$_DFFE_PP_ _00083_ clknet_leaf_24_clk
+ dp.rf.rf\[11\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[25\]$_DFFE_PP_ _00084_ clknet_leaf_22_clk
+ dp.rf.rf\[11\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[26\]$_DFFE_PP_ _00085_ clknet_leaf_31_clk
+ dp.rf.rf\[11\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[27\]$_DFFE_PP_ _00086_ clknet_leaf_30_clk
+ dp.rf.rf\[11\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[28\]$_DFFE_PP_ _00087_ clknet_leaf_26_clk
+ dp.rf.rf\[11\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[29\]$_DFFE_PP_ _00088_ clknet_leaf_28_clk
+ dp.rf.rf\[11\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[2\]$_DFFE_PP_ _00089_ clknet_leaf_33_clk
+ dp.rf.rf\[11\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[30\]$_DFFE_PP_ _00090_ clknet_leaf_28_clk
+ dp.rf.rf\[11\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[31\]$_DFFE_PP_ _00091_ clknet_leaf_4_clk
+ dp.rf.rf\[11\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[3\]$_DFFE_PP_ _00092_ clknet_leaf_35_clk
+ dp.rf.rf\[11\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[4\]$_DFFE_PP_ _00093_ clknet_leaf_34_clk
+ dp.rf.rf\[11\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[5\]$_DFFE_PP_ _00094_ clknet_leaf_36_clk
+ dp.rf.rf\[11\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[6\]$_DFFE_PP_ _00095_ clknet_leaf_27_clk
+ dp.rf.rf\[11\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[7\]$_DFFE_PP_ _00096_ clknet_leaf_37_clk
+ dp.rf.rf\[11\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[8\]$_DFFE_PP_ _00097_ clknet_leaf_2_clk dp.rf.rf\[11\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[11\]\[9\]$_DFFE_PP_ _00098_ clknet_leaf_3_clk dp.rf.rf\[11\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[0\]$_DFFE_PP_ _00099_ clknet_leaf_1_clk dp.rf.rf\[12\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[10\]$_DFFE_PP_ _00100_ clknet_leaf_9_clk
+ dp.rf.rf\[12\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[11\]$_DFFE_PP_ _00101_ clknet_leaf_8_clk
+ dp.rf.rf\[12\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[12\]$_DFFE_PP_ _00102_ clknet_leaf_1_clk
+ dp.rf.rf\[12\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[13\]$_DFFE_PP_ _00103_ clknet_leaf_10_clk
+ dp.rf.rf\[12\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[14\]$_DFFE_PP_ _00104_ clknet_leaf_6_clk
+ dp.rf.rf\[12\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[15\]$_DFFE_PP_ _00105_ clknet_leaf_5_clk
+ dp.rf.rf\[12\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[16\]$_DFFE_PP_ _00106_ clknet_leaf_12_clk
+ dp.rf.rf\[12\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[17\]$_DFFE_PP_ _00107_ clknet_leaf_12_clk
+ dp.rf.rf\[12\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[18\]$_DFFE_PP_ _00108_ clknet_leaf_14_clk
+ dp.rf.rf\[12\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[19\]$_DFFE_PP_ _00109_ clknet_leaf_20_clk
+ dp.rf.rf\[12\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[1\]$_DFFE_PP_ _00110_ clknet_leaf_31_clk
+ dp.rf.rf\[12\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[20\]$_DFFE_PP_ _00111_ clknet_leaf_17_clk
+ dp.rf.rf\[12\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[21\]$_DFFE_PP_ _00112_ clknet_leaf_5_clk
+ dp.rf.rf\[12\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[22\]$_DFFE_PP_ _00113_ clknet_leaf_18_clk
+ dp.rf.rf\[12\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[23\]$_DFFE_PP_ _00114_ clknet_leaf_19_clk
+ dp.rf.rf\[12\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[24\]$_DFFE_PP_ _00115_ clknet_leaf_23_clk
+ dp.rf.rf\[12\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[25\]$_DFFE_PP_ _00116_ clknet_leaf_22_clk
+ dp.rf.rf\[12\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[26\]$_DFFE_PP_ _00117_ clknet_leaf_31_clk
+ dp.rf.rf\[12\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[27\]$_DFFE_PP_ _00118_ clknet_leaf_30_clk
+ dp.rf.rf\[12\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[28\]$_DFFE_PP_ _00119_ clknet_leaf_26_clk
+ dp.rf.rf\[12\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[29\]$_DFFE_PP_ _00120_ clknet_leaf_28_clk
+ dp.rf.rf\[12\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[2\]$_DFFE_PP_ _00121_ clknet_leaf_3_clk dp.rf.rf\[12\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[30\]$_DFFE_PP_ _00122_ clknet_leaf_28_clk
+ dp.rf.rf\[12\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[31\]$_DFFE_PP_ _00123_ clknet_leaf_4_clk
+ dp.rf.rf\[12\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[3\]$_DFFE_PP_ _00124_ clknet_leaf_34_clk
+ dp.rf.rf\[12\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[4\]$_DFFE_PP_ _00125_ clknet_leaf_32_clk
+ dp.rf.rf\[12\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[5\]$_DFFE_PP_ _00126_ clknet_leaf_37_clk
+ dp.rf.rf\[12\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[6\]$_DFFE_PP_ _00127_ clknet_leaf_26_clk
+ dp.rf.rf\[12\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[7\]$_DFFE_PP_ _00128_ clknet_leaf_37_clk
+ dp.rf.rf\[12\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[8\]$_DFFE_PP_ _00129_ clknet_leaf_2_clk dp.rf.rf\[12\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[12\]\[9\]$_DFFE_PP_ _00130_ clknet_leaf_38_clk
+ dp.rf.rf\[12\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[0\]$_DFFE_PP_ _00131_ clknet_leaf_1_clk dp.rf.rf\[13\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[10\]$_DFFE_PP_ _00132_ clknet_leaf_9_clk
+ dp.rf.rf\[13\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[11\]$_DFFE_PP_ _00133_ clknet_leaf_8_clk
+ dp.rf.rf\[13\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[12\]$_DFFE_PP_ _00134_ clknet_leaf_1_clk
+ dp.rf.rf\[13\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[13\]$_DFFE_PP_ _00135_ clknet_leaf_10_clk
+ dp.rf.rf\[13\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[14\]$_DFFE_PP_ _00136_ clknet_leaf_6_clk
+ dp.rf.rf\[13\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[15\]$_DFFE_PP_ _00137_ clknet_leaf_12_clk
+ dp.rf.rf\[13\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[16\]$_DFFE_PP_ _00138_ clknet_leaf_12_clk
+ dp.rf.rf\[13\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[17\]$_DFFE_PP_ _00139_ clknet_leaf_12_clk
+ dp.rf.rf\[13\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[18\]$_DFFE_PP_ _00140_ clknet_leaf_14_clk
+ dp.rf.rf\[13\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[19\]$_DFFE_PP_ _00141_ clknet_leaf_20_clk
+ dp.rf.rf\[13\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[1\]$_DFFE_PP_ _00142_ clknet_leaf_31_clk
+ dp.rf.rf\[13\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[20\]$_DFFE_PP_ _00143_ clknet_leaf_17_clk
+ dp.rf.rf\[13\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[21\]$_DFFE_PP_ _00144_ clknet_leaf_5_clk
+ dp.rf.rf\[13\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[22\]$_DFFE_PP_ _00145_ clknet_leaf_18_clk
+ dp.rf.rf\[13\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[23\]$_DFFE_PP_ _00146_ clknet_leaf_19_clk
+ dp.rf.rf\[13\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[24\]$_DFFE_PP_ _00147_ clknet_leaf_23_clk
+ dp.rf.rf\[13\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[25\]$_DFFE_PP_ _00148_ clknet_leaf_21_clk
+ dp.rf.rf\[13\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[26\]$_DFFE_PP_ _00149_ clknet_leaf_31_clk
+ dp.rf.rf\[13\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[27\]$_DFFE_PP_ _00150_ clknet_leaf_30_clk
+ dp.rf.rf\[13\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[28\]$_DFFE_PP_ _00151_ clknet_leaf_27_clk
+ dp.rf.rf\[13\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[29\]$_DFFE_PP_ _00152_ clknet_leaf_28_clk
+ dp.rf.rf\[13\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[2\]$_DFFE_PP_ _00153_ clknet_leaf_33_clk
+ dp.rf.rf\[13\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[30\]$_DFFE_PP_ _00154_ clknet_leaf_28_clk
+ dp.rf.rf\[13\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[31\]$_DFFE_PP_ _00155_ clknet_leaf_4_clk
+ dp.rf.rf\[13\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[3\]$_DFFE_PP_ _00156_ clknet_leaf_35_clk
+ dp.rf.rf\[13\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[4\]$_DFFE_PP_ _00157_ clknet_leaf_34_clk
+ dp.rf.rf\[13\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[5\]$_DFFE_PP_ _00158_ clknet_leaf_37_clk
+ dp.rf.rf\[13\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[6\]$_DFFE_PP_ _00159_ clknet_leaf_27_clk
+ dp.rf.rf\[13\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[7\]$_DFFE_PP_ _00160_ clknet_leaf_37_clk
+ dp.rf.rf\[13\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[8\]$_DFFE_PP_ _00161_ clknet_leaf_2_clk dp.rf.rf\[13\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[13\]\[9\]$_DFFE_PP_ _00162_ clknet_leaf_3_clk dp.rf.rf\[13\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[0\]$_DFFE_PP_ _00163_ clknet_leaf_1_clk dp.rf.rf\[14\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[10\]$_DFFE_PP_ _00164_ clknet_leaf_10_clk
+ dp.rf.rf\[14\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[11\]$_DFFE_PP_ _00165_ clknet_leaf_8_clk
+ dp.rf.rf\[14\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[12\]$_DFFE_PP_ _00166_ clknet_leaf_1_clk
+ dp.rf.rf\[14\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[13\]$_DFFE_PP_ _00167_ clknet_leaf_10_clk
+ dp.rf.rf\[14\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[14\]$_DFFE_PP_ _00168_ clknet_leaf_6_clk
+ dp.rf.rf\[14\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[15\]$_DFFE_PP_ _00169_ clknet_leaf_9_clk
+ dp.rf.rf\[14\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[16\]$_DFFE_PP_ _00170_ clknet_leaf_12_clk
+ dp.rf.rf\[14\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[17\]$_DFFE_PP_ _00171_ clknet_leaf_12_clk
+ dp.rf.rf\[14\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[18\]$_DFFE_PP_ _00172_ clknet_leaf_14_clk
+ dp.rf.rf\[14\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[19\]$_DFFE_PP_ _00173_ clknet_leaf_20_clk
+ dp.rf.rf\[14\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[1\]$_DFFE_PP_ _00174_ clknet_leaf_24_clk
+ dp.rf.rf\[14\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[20\]$_DFFE_PP_ _00175_ clknet_leaf_17_clk
+ dp.rf.rf\[14\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[21\]$_DFFE_PP_ _00176_ clknet_leaf_5_clk
+ dp.rf.rf\[14\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[22\]$_DFFE_PP_ _00177_ clknet_leaf_16_clk
+ dp.rf.rf\[14\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[23\]$_DFFE_PP_ _00178_ clknet_leaf_19_clk
+ dp.rf.rf\[14\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[24\]$_DFFE_PP_ _00179_ clknet_leaf_24_clk
+ dp.rf.rf\[14\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[25\]$_DFFE_PP_ _00180_ clknet_leaf_19_clk
+ dp.rf.rf\[14\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[26\]$_DFFE_PP_ _00181_ clknet_leaf_30_clk
+ dp.rf.rf\[14\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[27\]$_DFFE_PP_ _00182_ clknet_leaf_30_clk
+ dp.rf.rf\[14\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[28\]$_DFFE_PP_ _00183_ clknet_leaf_26_clk
+ dp.rf.rf\[14\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[29\]$_DFFE_PP_ _00184_ clknet_leaf_34_clk
+ dp.rf.rf\[14\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[2\]$_DFFE_PP_ _00185_ clknet_leaf_3_clk dp.rf.rf\[14\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[30\]$_DFFE_PP_ _00186_ clknet_leaf_28_clk
+ dp.rf.rf\[14\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[31\]$_DFFE_PP_ _00187_ clknet_leaf_5_clk
+ dp.rf.rf\[14\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[3\]$_DFFE_PP_ _00188_ clknet_leaf_35_clk
+ dp.rf.rf\[14\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[4\]$_DFFE_PP_ _00189_ clknet_leaf_32_clk
+ dp.rf.rf\[14\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[5\]$_DFFE_PP_ _00190_ clknet_leaf_37_clk
+ dp.rf.rf\[14\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[6\]$_DFFE_PP_ _00191_ clknet_leaf_27_clk
+ dp.rf.rf\[14\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[7\]$_DFFE_PP_ _00192_ clknet_leaf_37_clk
+ dp.rf.rf\[14\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[8\]$_DFFE_PP_ _00193_ clknet_leaf_2_clk dp.rf.rf\[14\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[14\]\[9\]$_DFFE_PP_ _00194_ clknet_leaf_38_clk
+ dp.rf.rf\[14\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[0\]$_DFFE_PP_ _00195_ clknet_leaf_1_clk dp.rf.rf\[15\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[10\]$_DFFE_PP_ _00196_ clknet_leaf_10_clk
+ dp.rf.rf\[15\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[11\]$_DFFE_PP_ _00197_ clknet_leaf_8_clk
+ dp.rf.rf\[15\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[12\]$_DFFE_PP_ _00198_ clknet_leaf_1_clk
+ dp.rf.rf\[15\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[13\]$_DFFE_PP_ _00199_ clknet_leaf_10_clk
+ dp.rf.rf\[15\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[14\]$_DFFE_PP_ _00200_ clknet_leaf_6_clk
+ dp.rf.rf\[15\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[15\]$_DFFE_PP_ _00201_ clknet_leaf_9_clk
+ dp.rf.rf\[15\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[16\]$_DFFE_PP_ _00202_ clknet_leaf_12_clk
+ dp.rf.rf\[15\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[17\]$_DFFE_PP_ _00203_ clknet_leaf_12_clk
+ dp.rf.rf\[15\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[18\]$_DFFE_PP_ _00204_ clknet_leaf_14_clk
+ dp.rf.rf\[15\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[19\]$_DFFE_PP_ _00205_ clknet_leaf_20_clk
+ dp.rf.rf\[15\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[1\]$_DFFE_PP_ _00206_ clknet_leaf_31_clk
+ dp.rf.rf\[15\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[20\]$_DFFE_PP_ _00207_ clknet_leaf_17_clk
+ dp.rf.rf\[15\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[21\]$_DFFE_PP_ _00208_ clknet_leaf_5_clk
+ dp.rf.rf\[15\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[22\]$_DFFE_PP_ _00209_ clknet_leaf_16_clk
+ dp.rf.rf\[15\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[23\]$_DFFE_PP_ _00210_ clknet_leaf_19_clk
+ dp.rf.rf\[15\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[24\]$_DFFE_PP_ _00211_ clknet_leaf_24_clk
+ dp.rf.rf\[15\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[25\]$_DFFE_PP_ _00212_ clknet_leaf_22_clk
+ dp.rf.rf\[15\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[26\]$_DFFE_PP_ _00213_ clknet_leaf_30_clk
+ dp.rf.rf\[15\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[27\]$_DFFE_PP_ _00214_ clknet_leaf_30_clk
+ dp.rf.rf\[15\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[28\]$_DFFE_PP_ _00215_ clknet_leaf_26_clk
+ dp.rf.rf\[15\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[29\]$_DFFE_PP_ _00216_ clknet_leaf_34_clk
+ dp.rf.rf\[15\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[2\]$_DFFE_PP_ _00217_ clknet_leaf_3_clk dp.rf.rf\[15\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[30\]$_DFFE_PP_ _00218_ clknet_leaf_28_clk
+ dp.rf.rf\[15\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[31\]$_DFFE_PP_ _00219_ clknet_leaf_4_clk
+ dp.rf.rf\[15\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[3\]$_DFFE_PP_ _00220_ clknet_leaf_35_clk
+ dp.rf.rf\[15\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[4\]$_DFFE_PP_ _00221_ clknet_leaf_34_clk
+ dp.rf.rf\[15\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[5\]$_DFFE_PP_ _00222_ clknet_leaf_37_clk
+ dp.rf.rf\[15\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[6\]$_DFFE_PP_ _00223_ clknet_leaf_27_clk
+ dp.rf.rf\[15\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[7\]$_DFFE_PP_ _00224_ clknet_leaf_37_clk
+ dp.rf.rf\[15\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[8\]$_DFFE_PP_ _00225_ clknet_leaf_2_clk dp.rf.rf\[15\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[15\]\[9\]$_DFFE_PP_ _00226_ clknet_leaf_38_clk
+ dp.rf.rf\[15\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[0\]$_DFFE_PP_ _00227_ clknet_leaf_7_clk dp.rf.rf\[16\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[10\]$_DFFE_PP_ _00228_ clknet_leaf_11_clk
+ dp.rf.rf\[16\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[11\]$_DFFE_PP_ _00229_ clknet_leaf_11_clk
+ dp.rf.rf\[16\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[12\]$_DFFE_PP_ _00230_ clknet_leaf_6_clk
+ dp.rf.rf\[16\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[13\]$_DFFE_PP_ _00231_ clknet_leaf_10_clk
+ dp.rf.rf\[16\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[14\]$_DFFE_PP_ _00232_ clknet_leaf_6_clk
+ dp.rf.rf\[16\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[15\]$_DFFE_PP_ _00233_ clknet_leaf_5_clk
+ dp.rf.rf\[16\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[16\]$_DFFE_PP_ _00234_ clknet_leaf_12_clk
+ dp.rf.rf\[16\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[17\]$_DFFE_PP_ _00235_ clknet_leaf_13_clk
+ dp.rf.rf\[16\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[18\]$_DFFE_PP_ _00236_ clknet_leaf_13_clk
+ dp.rf.rf\[16\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[19\]$_DFFE_PP_ _00237_ clknet_leaf_14_clk
+ dp.rf.rf\[16\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[1\]$_DFFE_PP_ _00238_ clknet_leaf_17_clk
+ dp.rf.rf\[16\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[20\]$_DFFE_PP_ _00239_ clknet_leaf_17_clk
+ dp.rf.rf\[16\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[21\]$_DFFE_PP_ _00240_ clknet_leaf_16_clk
+ dp.rf.rf\[16\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[22\]$_DFFE_PP_ _00241_ clknet_leaf_14_clk
+ dp.rf.rf\[16\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[23\]$_DFFE_PP_ _00242_ clknet_leaf_21_clk
+ dp.rf.rf\[16\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[24\]$_DFFE_PP_ _00243_ clknet_leaf_23_clk
+ dp.rf.rf\[16\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[25\]$_DFFE_PP_ _00244_ clknet_leaf_21_clk
+ dp.rf.rf\[16\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[26\]$_DFFE_PP_ _00245_ clknet_leaf_24_clk
+ dp.rf.rf\[16\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[27\]$_DFFE_PP_ _00246_ clknet_leaf_30_clk
+ dp.rf.rf\[16\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[28\]$_DFFE_PP_ _00247_ clknet_leaf_29_clk
+ dp.rf.rf\[16\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[29\]$_DFFE_PP_ _00248_ clknet_leaf_34_clk
+ dp.rf.rf\[16\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[2\]$_DFFE_PP_ _00249_ clknet_leaf_32_clk
+ dp.rf.rf\[16\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[30\]$_DFFE_PP_ _00250_ clknet_leaf_29_clk
+ dp.rf.rf\[16\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[31\]$_DFFE_PP_ _00251_ clknet_leaf_5_clk
+ dp.rf.rf\[16\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[3\]$_DFFE_PP_ _00252_ clknet_leaf_34_clk
+ dp.rf.rf\[16\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[4\]$_DFFE_PP_ _00253_ clknet_leaf_31_clk
+ dp.rf.rf\[16\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[5\]$_DFFE_PP_ _00254_ clknet_leaf_37_clk
+ dp.rf.rf\[16\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[6\]$_DFFE_PP_ _00255_ clknet_leaf_29_clk
+ dp.rf.rf\[16\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[7\]$_DFFE_PP_ _00256_ clknet_leaf_37_clk
+ dp.rf.rf\[16\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[8\]$_DFFE_PP_ _00257_ clknet_leaf_2_clk dp.rf.rf\[16\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[16\]\[9\]$_DFFE_PP_ _00258_ clknet_leaf_38_clk
+ dp.rf.rf\[16\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[0\]$_DFFE_PP_ _00259_ clknet_leaf_7_clk dp.rf.rf\[17\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[10\]$_DFFE_PP_ _00260_ clknet_leaf_11_clk
+ dp.rf.rf\[17\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[11\]$_DFFE_PP_ _00261_ clknet_leaf_11_clk
+ dp.rf.rf\[17\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[12\]$_DFFE_PP_ _00262_ clknet_leaf_6_clk
+ dp.rf.rf\[17\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[13\]$_DFFE_PP_ _00263_ clknet_leaf_10_clk
+ dp.rf.rf\[17\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[14\]$_DFFE_PP_ _00264_ clknet_leaf_9_clk
+ dp.rf.rf\[17\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[15\]$_DFFE_PP_ _00265_ clknet_leaf_16_clk
+ dp.rf.rf\[17\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[16\]$_DFFE_PP_ _00266_ clknet_leaf_12_clk
+ dp.rf.rf\[17\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[17\]$_DFFE_PP_ _00267_ clknet_leaf_13_clk
+ dp.rf.rf\[17\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[18\]$_DFFE_PP_ _00268_ clknet_leaf_14_clk
+ dp.rf.rf\[17\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[19\]$_DFFE_PP_ _00269_ clknet_leaf_14_clk
+ dp.rf.rf\[17\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[1\]$_DFFE_PP_ _00270_ clknet_leaf_17_clk
+ dp.rf.rf\[17\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[20\]$_DFFE_PP_ _00271_ clknet_leaf_17_clk
+ dp.rf.rf\[17\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[21\]$_DFFE_PP_ _00272_ clknet_leaf_16_clk
+ dp.rf.rf\[17\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[22\]$_DFFE_PP_ _00273_ clknet_leaf_20_clk
+ dp.rf.rf\[17\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[23\]$_DFFE_PP_ _00274_ clknet_leaf_21_clk
+ dp.rf.rf\[17\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[24\]$_DFFE_PP_ _00275_ clknet_leaf_23_clk
+ dp.rf.rf\[17\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[25\]$_DFFE_PP_ _00276_ clknet_leaf_21_clk
+ dp.rf.rf\[17\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[26\]$_DFFE_PP_ _00277_ clknet_leaf_24_clk
+ dp.rf.rf\[17\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[27\]$_DFFE_PP_ _00278_ clknet_leaf_30_clk
+ dp.rf.rf\[17\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[28\]$_DFFE_PP_ _00279_ clknet_leaf_26_clk
+ dp.rf.rf\[17\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[29\]$_DFFE_PP_ _00280_ clknet_leaf_35_clk
+ dp.rf.rf\[17\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[2\]$_DFFE_PP_ _00281_ clknet_leaf_32_clk
+ dp.rf.rf\[17\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[30\]$_DFFE_PP_ _00282_ clknet_leaf_28_clk
+ dp.rf.rf\[17\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[31\]$_DFFE_PP_ _00283_ clknet_leaf_4_clk
+ dp.rf.rf\[17\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[3\]$_DFFE_PP_ _00284_ clknet_leaf_34_clk
+ dp.rf.rf\[17\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[4\]$_DFFE_PP_ _00285_ clknet_leaf_32_clk
+ dp.rf.rf\[17\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[5\]$_DFFE_PP_ _00286_ clknet_leaf_36_clk
+ dp.rf.rf\[17\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[6\]$_DFFE_PP_ _00287_ clknet_leaf_29_clk
+ dp.rf.rf\[17\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[7\]$_DFFE_PP_ _00288_ clknet_leaf_33_clk
+ dp.rf.rf\[17\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[8\]$_DFFE_PP_ _00289_ clknet_leaf_2_clk dp.rf.rf\[17\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[17\]\[9\]$_DFFE_PP_ _00290_ clknet_leaf_38_clk
+ dp.rf.rf\[17\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[0\]$_DFFE_PP_ _00291_ clknet_leaf_7_clk dp.rf.rf\[18\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[10\]$_DFFE_PP_ _00292_ clknet_leaf_12_clk
+ dp.rf.rf\[18\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[11\]$_DFFE_PP_ _00293_ clknet_leaf_11_clk
+ dp.rf.rf\[18\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[12\]$_DFFE_PP_ _00294_ clknet_leaf_6_clk
+ dp.rf.rf\[18\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[13\]$_DFFE_PP_ _00295_ clknet_leaf_10_clk
+ dp.rf.rf\[18\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[14\]$_DFFE_PP_ _00296_ clknet_leaf_6_clk
+ dp.rf.rf\[18\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[15\]$_DFFE_PP_ _00297_ clknet_leaf_5_clk
+ dp.rf.rf\[18\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[16\]$_DFFE_PP_ _00298_ clknet_leaf_12_clk
+ dp.rf.rf\[18\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[17\]$_DFFE_PP_ _00299_ clknet_leaf_13_clk
+ dp.rf.rf\[18\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[18\]$_DFFE_PP_ _00300_ clknet_leaf_13_clk
+ dp.rf.rf\[18\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[19\]$_DFFE_PP_ _00301_ clknet_leaf_14_clk
+ dp.rf.rf\[18\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[1\]$_DFFE_PP_ _00302_ clknet_leaf_17_clk
+ dp.rf.rf\[18\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[20\]$_DFFE_PP_ _00303_ clknet_leaf_17_clk
+ dp.rf.rf\[18\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[21\]$_DFFE_PP_ _00304_ clknet_leaf_17_clk
+ dp.rf.rf\[18\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[22\]$_DFFE_PP_ _00305_ clknet_leaf_18_clk
+ dp.rf.rf\[18\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[23\]$_DFFE_PP_ _00306_ clknet_leaf_21_clk
+ dp.rf.rf\[18\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[24\]$_DFFE_PP_ _00307_ clknet_leaf_23_clk
+ dp.rf.rf\[18\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[25\]$_DFFE_PP_ _00308_ clknet_leaf_21_clk
+ dp.rf.rf\[18\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[26\]$_DFFE_PP_ _00309_ clknet_leaf_31_clk
+ dp.rf.rf\[18\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[27\]$_DFFE_PP_ _00310_ clknet_leaf_30_clk
+ dp.rf.rf\[18\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[28\]$_DFFE_PP_ _00311_ clknet_leaf_29_clk
+ dp.rf.rf\[18\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[29\]$_DFFE_PP_ _00312_ clknet_leaf_34_clk
+ dp.rf.rf\[18\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[2\]$_DFFE_PP_ _00313_ clknet_leaf_32_clk
+ dp.rf.rf\[18\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[30\]$_DFFE_PP_ _00314_ clknet_leaf_29_clk
+ dp.rf.rf\[18\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[31\]$_DFFE_PP_ _00315_ clknet_leaf_5_clk
+ dp.rf.rf\[18\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[3\]$_DFFE_PP_ _00316_ clknet_leaf_33_clk
+ dp.rf.rf\[18\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[4\]$_DFFE_PP_ _00317_ clknet_leaf_32_clk
+ dp.rf.rf\[18\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[5\]$_DFFE_PP_ _00318_ clknet_leaf_37_clk
+ dp.rf.rf\[18\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[6\]$_DFFE_PP_ _00319_ clknet_leaf_29_clk
+ dp.rf.rf\[18\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[7\]$_DFFE_PP_ _00320_ clknet_leaf_38_clk
+ dp.rf.rf\[18\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[8\]$_DFFE_PP_ _00321_ clknet_leaf_0_clk dp.rf.rf\[18\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[18\]\[9\]$_DFFE_PP_ _00322_ clknet_leaf_38_clk
+ dp.rf.rf\[18\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[0\]$_DFFE_PP_ _00323_ clknet_leaf_7_clk dp.rf.rf\[19\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[10\]$_DFFE_PP_ _00324_ clknet_leaf_12_clk
+ dp.rf.rf\[19\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[11\]$_DFFE_PP_ _00325_ clknet_leaf_11_clk
+ dp.rf.rf\[19\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[12\]$_DFFE_PP_ _00326_ clknet_leaf_6_clk
+ dp.rf.rf\[19\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[13\]$_DFFE_PP_ _00327_ clknet_leaf_10_clk
+ dp.rf.rf\[19\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[14\]$_DFFE_PP_ _00328_ clknet_leaf_6_clk
+ dp.rf.rf\[19\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[15\]$_DFFE_PP_ _00329_ clknet_leaf_5_clk
+ dp.rf.rf\[19\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[16\]$_DFFE_PP_ _00330_ clknet_leaf_12_clk
+ dp.rf.rf\[19\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[17\]$_DFFE_PP_ _00331_ clknet_leaf_13_clk
+ dp.rf.rf\[19\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[18\]$_DFFE_PP_ _00332_ clknet_leaf_13_clk
+ dp.rf.rf\[19\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[19\]$_DFFE_PP_ _00333_ clknet_leaf_14_clk
+ dp.rf.rf\[19\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[1\]$_DFFE_PP_ _00334_ clknet_leaf_17_clk
+ dp.rf.rf\[19\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[20\]$_DFFE_PP_ _00335_ clknet_leaf_17_clk
+ dp.rf.rf\[19\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[21\]$_DFFE_PP_ _00336_ clknet_leaf_17_clk
+ dp.rf.rf\[19\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[22\]$_DFFE_PP_ _00337_ clknet_leaf_20_clk
+ dp.rf.rf\[19\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[23\]$_DFFE_PP_ _00338_ clknet_leaf_21_clk
+ dp.rf.rf\[19\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[24\]$_DFFE_PP_ _00339_ clknet_leaf_23_clk
+ dp.rf.rf\[19\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[25\]$_DFFE_PP_ _00340_ clknet_leaf_21_clk
+ dp.rf.rf\[19\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[26\]$_DFFE_PP_ _00341_ clknet_leaf_31_clk
+ dp.rf.rf\[19\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[27\]$_DFFE_PP_ _00342_ clknet_leaf_30_clk
+ dp.rf.rf\[19\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[28\]$_DFFE_PP_ _00343_ clknet_leaf_28_clk
+ dp.rf.rf\[19\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[29\]$_DFFE_PP_ _00344_ clknet_leaf_34_clk
+ dp.rf.rf\[19\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[2\]$_DFFE_PP_ _00345_ clknet_leaf_32_clk
+ dp.rf.rf\[19\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[30\]$_DFFE_PP_ _00346_ clknet_leaf_29_clk
+ dp.rf.rf\[19\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[31\]$_DFFE_PP_ _00347_ clknet_leaf_5_clk
+ dp.rf.rf\[19\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[3\]$_DFFE_PP_ _00348_ clknet_leaf_33_clk
+ dp.rf.rf\[19\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[4\]$_DFFE_PP_ _00349_ clknet_leaf_32_clk
+ dp.rf.rf\[19\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[5\]$_DFFE_PP_ _00350_ clknet_leaf_37_clk
+ dp.rf.rf\[19\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[6\]$_DFFE_PP_ _00351_ clknet_leaf_29_clk
+ dp.rf.rf\[19\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[7\]$_DFFE_PP_ _00352_ clknet_leaf_38_clk
+ dp.rf.rf\[19\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[8\]$_DFFE_PP_ _00353_ clknet_leaf_1_clk dp.rf.rf\[19\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[19\]\[9\]$_DFFE_PP_ _00354_ clknet_leaf_38_clk
+ dp.rf.rf\[19\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[0\]$_DFFE_PP_ _00355_ clknet_leaf_0_clk dp.rf.rf\[1\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[10\]$_DFFE_PP_ _00356_ clknet_leaf_12_clk
+ dp.rf.rf\[1\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[11\]$_DFFE_PP_ _00357_ clknet_leaf_5_clk dp.rf.rf\[1\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[12\]$_DFFE_PP_ _00358_ clknet_leaf_2_clk dp.rf.rf\[1\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[13\]$_DFFE_PP_ _00359_ clknet_leaf_8_clk dp.rf.rf\[1\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[14\]$_DFFE_PP_ _00360_ clknet_leaf_8_clk dp.rf.rf\[1\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[15\]$_DFFE_PP_ _00361_ clknet_leaf_5_clk dp.rf.rf\[1\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[16\]$_DFFE_PP_ _00362_ clknet_leaf_8_clk dp.rf.rf\[1\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[17\]$_DFFE_PP_ _00363_ clknet_leaf_15_clk
+ dp.rf.rf\[1\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[18\]$_DFFE_PP_ _00364_ clknet_leaf_14_clk
+ dp.rf.rf\[1\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[19\]$_DFFE_PP_ _00365_ clknet_leaf_19_clk
+ dp.rf.rf\[1\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[1\]$_DFFE_PP_ _00366_ clknet_leaf_31_clk dp.rf.rf\[1\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[20\]$_DFFE_PP_ _00367_ clknet_leaf_16_clk
+ dp.rf.rf\[1\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[21\]$_DFFE_PP_ _00368_ clknet_leaf_16_clk
+ dp.rf.rf\[1\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[22\]$_DFFE_PP_ _00369_ clknet_leaf_18_clk
+ dp.rf.rf\[1\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[23\]$_DFFE_PP_ _00370_ clknet_leaf_19_clk
+ dp.rf.rf\[1\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[24\]$_DFFE_PP_ _00371_ clknet_leaf_23_clk
+ dp.rf.rf\[1\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[25\]$_DFFE_PP_ _00372_ clknet_leaf_19_clk
+ dp.rf.rf\[1\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[26\]$_DFFE_PP_ _00373_ clknet_leaf_31_clk
+ dp.rf.rf\[1\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[27\]$_DFFE_PP_ _00374_ clknet_leaf_26_clk
+ dp.rf.rf\[1\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[28\]$_DFFE_PP_ _00375_ clknet_leaf_26_clk
+ dp.rf.rf\[1\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[29\]$_DFFE_PP_ _00376_ clknet_leaf_35_clk
+ dp.rf.rf\[1\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[2\]$_DFFE_PP_ _00377_ clknet_leaf_33_clk dp.rf.rf\[1\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[30\]$_DFFE_PP_ _00378_ clknet_leaf_27_clk
+ dp.rf.rf\[1\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[31\]$_DFFE_PP_ _00379_ clknet_leaf_3_clk dp.rf.rf\[1\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[3\]$_DFFE_PP_ _00380_ clknet_leaf_35_clk dp.rf.rf\[1\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[4\]$_DFFE_PP_ _00381_ clknet_leaf_34_clk dp.rf.rf\[1\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[5\]$_DFFE_PP_ _00382_ clknet_leaf_37_clk dp.rf.rf\[1\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[6\]$_DFFE_PP_ _00383_ clknet_leaf_27_clk dp.rf.rf\[1\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[7\]$_DFFE_PP_ _00384_ clknet_leaf_37_clk dp.rf.rf\[1\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[8\]$_DFFE_PP_ _00385_ clknet_leaf_3_clk dp.rf.rf\[1\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[1\]\[9\]$_DFFE_PP_ _00386_ clknet_leaf_38_clk dp.rf.rf\[1\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[0\]$_DFFE_PP_ _00387_ clknet_leaf_7_clk dp.rf.rf\[20\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[10\]$_DFFE_PP_ _00388_ clknet_leaf_9_clk
+ dp.rf.rf\[20\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[11\]$_DFFE_PP_ _00389_ clknet_leaf_11_clk
+ dp.rf.rf\[20\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[12\]$_DFFE_PP_ _00390_ clknet_leaf_6_clk
+ dp.rf.rf\[20\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[13\]$_DFFE_PP_ _00391_ clknet_leaf_10_clk
+ dp.rf.rf\[20\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[14\]$_DFFE_PP_ _00392_ clknet_leaf_9_clk
+ dp.rf.rf\[20\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[15\]$_DFFE_PP_ _00393_ clknet_leaf_5_clk
+ dp.rf.rf\[20\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[16\]$_DFFE_PP_ _00394_ clknet_leaf_12_clk
+ dp.rf.rf\[20\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[17\]$_DFFE_PP_ _00395_ clknet_leaf_13_clk
+ dp.rf.rf\[20\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[18\]$_DFFE_PP_ _00396_ clknet_leaf_14_clk
+ dp.rf.rf\[20\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[19\]$_DFFE_PP_ _00397_ clknet_leaf_14_clk
+ dp.rf.rf\[20\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[1\]$_DFFE_PP_ _00398_ clknet_leaf_17_clk
+ dp.rf.rf\[20\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[20\]$_DFFE_PP_ _00399_ clknet_leaf_18_clk
+ dp.rf.rf\[20\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[21\]$_DFFE_PP_ _00400_ clknet_leaf_16_clk
+ dp.rf.rf\[20\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[22\]$_DFFE_PP_ _00401_ clknet_leaf_14_clk
+ dp.rf.rf\[20\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[23\]$_DFFE_PP_ _00402_ clknet_leaf_21_clk
+ dp.rf.rf\[20\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[24\]$_DFFE_PP_ _00403_ clknet_leaf_17_clk
+ dp.rf.rf\[20\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[25\]$_DFFE_PP_ _00404_ clknet_leaf_21_clk
+ dp.rf.rf\[20\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[26\]$_DFFE_PP_ _00405_ clknet_leaf_30_clk
+ dp.rf.rf\[20\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[27\]$_DFFE_PP_ _00406_ clknet_leaf_29_clk
+ dp.rf.rf\[20\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[28\]$_DFFE_PP_ _00407_ clknet_leaf_28_clk
+ dp.rf.rf\[20\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[29\]$_DFFE_PP_ _00408_ clknet_leaf_34_clk
+ dp.rf.rf\[20\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[2\]$_DFFE_PP_ _00409_ clknet_leaf_32_clk
+ dp.rf.rf\[20\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[30\]$_DFFE_PP_ _00410_ clknet_leaf_29_clk
+ dp.rf.rf\[20\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[31\]$_DFFE_PP_ _00411_ clknet_leaf_5_clk
+ dp.rf.rf\[20\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[3\]$_DFFE_PP_ _00412_ clknet_leaf_33_clk
+ dp.rf.rf\[20\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[4\]$_DFFE_PP_ _00413_ clknet_leaf_32_clk
+ dp.rf.rf\[20\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[5\]$_DFFE_PP_ _00414_ clknet_leaf_36_clk
+ dp.rf.rf\[20\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[6\]$_DFFE_PP_ _00415_ clknet_leaf_29_clk
+ dp.rf.rf\[20\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[7\]$_DFFE_PP_ _00416_ clknet_leaf_33_clk
+ dp.rf.rf\[20\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[8\]$_DFFE_PP_ _00417_ clknet_leaf_2_clk dp.rf.rf\[20\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[20\]\[9\]$_DFFE_PP_ _00418_ clknet_leaf_38_clk
+ dp.rf.rf\[20\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[0\]$_DFFE_PP_ _00419_ clknet_leaf_7_clk dp.rf.rf\[21\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[10\]$_DFFE_PP_ _00420_ clknet_leaf_9_clk
+ dp.rf.rf\[21\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[11\]$_DFFE_PP_ _00421_ clknet_leaf_11_clk
+ dp.rf.rf\[21\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[12\]$_DFFE_PP_ _00422_ clknet_leaf_6_clk
+ dp.rf.rf\[21\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[13\]$_DFFE_PP_ _00423_ clknet_leaf_10_clk
+ dp.rf.rf\[21\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[14\]$_DFFE_PP_ _00424_ clknet_leaf_9_clk
+ dp.rf.rf\[21\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[15\]$_DFFE_PP_ _00425_ clknet_leaf_5_clk
+ dp.rf.rf\[21\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[16\]$_DFFE_PP_ _00426_ clknet_leaf_13_clk
+ dp.rf.rf\[21\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[17\]$_DFFE_PP_ _00427_ clknet_leaf_13_clk
+ dp.rf.rf\[21\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[18\]$_DFFE_PP_ _00428_ clknet_leaf_14_clk
+ dp.rf.rf\[21\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[19\]$_DFFE_PP_ _00429_ clknet_leaf_14_clk
+ dp.rf.rf\[21\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[1\]$_DFFE_PP_ _00430_ clknet_leaf_17_clk
+ dp.rf.rf\[21\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[20\]$_DFFE_PP_ _00431_ clknet_leaf_18_clk
+ dp.rf.rf\[21\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[21\]$_DFFE_PP_ _00432_ clknet_leaf_16_clk
+ dp.rf.rf\[21\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[22\]$_DFFE_PP_ _00433_ clknet_leaf_20_clk
+ dp.rf.rf\[21\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[23\]$_DFFE_PP_ _00434_ clknet_leaf_21_clk
+ dp.rf.rf\[21\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[24\]$_DFFE_PP_ _00435_ clknet_leaf_24_clk
+ dp.rf.rf\[21\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[25\]$_DFFE_PP_ _00436_ clknet_leaf_21_clk
+ dp.rf.rf\[21\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[26\]$_DFFE_PP_ _00437_ clknet_leaf_31_clk
+ dp.rf.rf\[21\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[27\]$_DFFE_PP_ _00438_ clknet_leaf_29_clk
+ dp.rf.rf\[21\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[28\]$_DFFE_PP_ _00439_ clknet_leaf_27_clk
+ dp.rf.rf\[21\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[29\]$_DFFE_PP_ _00440_ clknet_leaf_34_clk
+ dp.rf.rf\[21\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[2\]$_DFFE_PP_ _00441_ clknet_leaf_32_clk
+ dp.rf.rf\[21\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[30\]$_DFFE_PP_ _00442_ clknet_leaf_28_clk
+ dp.rf.rf\[21\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[31\]$_DFFE_PP_ _00443_ clknet_leaf_4_clk
+ dp.rf.rf\[21\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[3\]$_DFFE_PP_ _00444_ clknet_leaf_33_clk
+ dp.rf.rf\[21\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[4\]$_DFFE_PP_ _00445_ clknet_leaf_32_clk
+ dp.rf.rf\[21\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[5\]$_DFFE_PP_ _00446_ clknet_leaf_36_clk
+ dp.rf.rf\[21\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[6\]$_DFFE_PP_ _00447_ clknet_leaf_29_clk
+ dp.rf.rf\[21\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[7\]$_DFFE_PP_ _00448_ clknet_leaf_33_clk
+ dp.rf.rf\[21\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[8\]$_DFFE_PP_ _00449_ clknet_leaf_0_clk dp.rf.rf\[21\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[21\]\[9\]$_DFFE_PP_ _00450_ clknet_leaf_38_clk
+ dp.rf.rf\[21\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[0\]$_DFFE_PP_ _00451_ clknet_leaf_7_clk dp.rf.rf\[22\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[10\]$_DFFE_PP_ _00452_ clknet_leaf_10_clk
+ dp.rf.rf\[22\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[11\]$_DFFE_PP_ _00453_ clknet_leaf_11_clk
+ dp.rf.rf\[22\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[12\]$_DFFE_PP_ _00454_ clknet_leaf_7_clk
+ dp.rf.rf\[22\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[13\]$_DFFE_PP_ _00455_ clknet_leaf_10_clk
+ dp.rf.rf\[22\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[14\]$_DFFE_PP_ _00456_ clknet_leaf_7_clk
+ dp.rf.rf\[22\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[15\]$_DFFE_PP_ _00457_ clknet_leaf_5_clk
+ dp.rf.rf\[22\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[16\]$_DFFE_PP_ _00458_ clknet_leaf_12_clk
+ dp.rf.rf\[22\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[17\]$_DFFE_PP_ _00459_ clknet_leaf_13_clk
+ dp.rf.rf\[22\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[18\]$_DFFE_PP_ _00460_ clknet_leaf_13_clk
+ dp.rf.rf\[22\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[19\]$_DFFE_PP_ _00461_ clknet_leaf_14_clk
+ dp.rf.rf\[22\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[1\]$_DFFE_PP_ _00462_ clknet_leaf_17_clk
+ dp.rf.rf\[22\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[20\]$_DFFE_PP_ _00463_ clknet_leaf_18_clk
+ dp.rf.rf\[22\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[21\]$_DFFE_PP_ _00464_ clknet_leaf_17_clk
+ dp.rf.rf\[22\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[22\]$_DFFE_PP_ _00465_ clknet_leaf_14_clk
+ dp.rf.rf\[22\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[23\]$_DFFE_PP_ _00466_ clknet_leaf_20_clk
+ dp.rf.rf\[22\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[24\]$_DFFE_PP_ _00467_ clknet_leaf_17_clk
+ dp.rf.rf\[22\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[25\]$_DFFE_PP_ _00468_ clknet_leaf_21_clk
+ dp.rf.rf\[22\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[26\]$_DFFE_PP_ _00469_ clknet_leaf_30_clk
+ dp.rf.rf\[22\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[27\]$_DFFE_PP_ _00470_ clknet_leaf_29_clk
+ dp.rf.rf\[22\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[28\]$_DFFE_PP_ _00471_ clknet_leaf_28_clk
+ dp.rf.rf\[22\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[29\]$_DFFE_PP_ _00472_ clknet_leaf_34_clk
+ dp.rf.rf\[22\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[2\]$_DFFE_PP_ _00473_ clknet_leaf_33_clk
+ dp.rf.rf\[22\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[30\]$_DFFE_PP_ _00474_ clknet_leaf_28_clk
+ dp.rf.rf\[22\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[31\]$_DFFE_PP_ _00475_ clknet_leaf_6_clk
+ dp.rf.rf\[22\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[3\]$_DFFE_PP_ _00476_ clknet_leaf_33_clk
+ dp.rf.rf\[22\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[4\]$_DFFE_PP_ _00477_ clknet_leaf_32_clk
+ dp.rf.rf\[22\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[5\]$_DFFE_PP_ _00478_ clknet_leaf_36_clk
+ dp.rf.rf\[22\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[6\]$_DFFE_PP_ _00479_ clknet_leaf_34_clk
+ dp.rf.rf\[22\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[7\]$_DFFE_PP_ _00480_ clknet_leaf_37_clk
+ dp.rf.rf\[22\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[8\]$_DFFE_PP_ _00481_ clknet_leaf_0_clk dp.rf.rf\[22\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[22\]\[9\]$_DFFE_PP_ _00482_ clknet_leaf_0_clk dp.rf.rf\[22\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[0\]$_DFFE_PP_ _00483_ clknet_leaf_7_clk dp.rf.rf\[23\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[10\]$_DFFE_PP_ _00484_ clknet_leaf_10_clk
+ dp.rf.rf\[23\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[11\]$_DFFE_PP_ _00485_ clknet_leaf_11_clk
+ dp.rf.rf\[23\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[12\]$_DFFE_PP_ _00486_ clknet_leaf_7_clk
+ dp.rf.rf\[23\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[13\]$_DFFE_PP_ _00487_ clknet_leaf_10_clk
+ dp.rf.rf\[23\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[14\]$_DFFE_PP_ _00488_ clknet_leaf_8_clk
+ dp.rf.rf\[23\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[15\]$_DFFE_PP_ _00489_ clknet_leaf_5_clk
+ dp.rf.rf\[23\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[16\]$_DFFE_PP_ _00490_ clknet_leaf_11_clk
+ dp.rf.rf\[23\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[17\]$_DFFE_PP_ _00491_ clknet_leaf_13_clk
+ dp.rf.rf\[23\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[18\]$_DFFE_PP_ _00492_ clknet_leaf_13_clk
+ dp.rf.rf\[23\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[19\]$_DFFE_PP_ _00493_ clknet_leaf_14_clk
+ dp.rf.rf\[23\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[1\]$_DFFE_PP_ _00494_ clknet_leaf_17_clk
+ dp.rf.rf\[23\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[20\]$_DFFE_PP_ _00495_ clknet_leaf_18_clk
+ dp.rf.rf\[23\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[21\]$_DFFE_PP_ _00496_ clknet_leaf_17_clk
+ dp.rf.rf\[23\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[22\]$_DFFE_PP_ _00497_ clknet_leaf_14_clk
+ dp.rf.rf\[23\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[23\]$_DFFE_PP_ _00498_ clknet_leaf_20_clk
+ dp.rf.rf\[23\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[24\]$_DFFE_PP_ _00499_ clknet_leaf_17_clk
+ dp.rf.rf\[23\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[25\]$_DFFE_PP_ _00500_ clknet_leaf_21_clk
+ dp.rf.rf\[23\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[26\]$_DFFE_PP_ _00501_ clknet_leaf_31_clk
+ dp.rf.rf\[23\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[27\]$_DFFE_PP_ _00502_ clknet_leaf_29_clk
+ dp.rf.rf\[23\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[28\]$_DFFE_PP_ _00503_ clknet_leaf_28_clk
+ dp.rf.rf\[23\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[29\]$_DFFE_PP_ _00504_ clknet_leaf_34_clk
+ dp.rf.rf\[23\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[2\]$_DFFE_PP_ _00505_ clknet_leaf_32_clk
+ dp.rf.rf\[23\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[30\]$_DFFE_PP_ _00506_ clknet_leaf_28_clk
+ dp.rf.rf\[23\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[31\]$_DFFE_PP_ _00507_ clknet_leaf_6_clk
+ dp.rf.rf\[23\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[3\]$_DFFE_PP_ _00508_ clknet_leaf_33_clk
+ dp.rf.rf\[23\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[4\]$_DFFE_PP_ _00509_ clknet_leaf_32_clk
+ dp.rf.rf\[23\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[5\]$_DFFE_PP_ _00510_ clknet_leaf_36_clk
+ dp.rf.rf\[23\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[6\]$_DFFE_PP_ _00511_ clknet_leaf_34_clk
+ dp.rf.rf\[23\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[7\]$_DFFE_PP_ _00512_ clknet_leaf_33_clk
+ dp.rf.rf\[23\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[8\]$_DFFE_PP_ _00513_ clknet_leaf_0_clk dp.rf.rf\[23\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[23\]\[9\]$_DFFE_PP_ _00514_ clknet_leaf_0_clk dp.rf.rf\[23\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[0\]$_DFFE_PP_ _00515_ clknet_leaf_7_clk dp.rf.rf\[24\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[10\]$_DFFE_PP_ _00516_ clknet_leaf_11_clk
+ dp.rf.rf\[24\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[11\]$_DFFE_PP_ _00517_ clknet_leaf_11_clk
+ dp.rf.rf\[24\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[12\]$_DFFE_PP_ _00518_ clknet_leaf_7_clk
+ dp.rf.rf\[24\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[13\]$_DFFE_PP_ _00519_ clknet_leaf_10_clk
+ dp.rf.rf\[24\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[14\]$_DFFE_PP_ _00520_ clknet_leaf_6_clk
+ dp.rf.rf\[24\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[15\]$_DFFE_PP_ _00521_ clknet_leaf_15_clk
+ dp.rf.rf\[24\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[16\]$_DFFE_PP_ _00522_ clknet_leaf_13_clk
+ dp.rf.rf\[24\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[17\]$_DFFE_PP_ _00523_ clknet_leaf_13_clk
+ dp.rf.rf\[24\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[18\]$_DFFE_PP_ _00524_ clknet_leaf_13_clk
+ dp.rf.rf\[24\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[19\]$_DFFE_PP_ _00525_ clknet_leaf_21_clk
+ dp.rf.rf\[24\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[1\]$_DFFE_PP_ _00526_ clknet_leaf_24_clk
+ dp.rf.rf\[24\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[20\]$_DFFE_PP_ _00527_ clknet_leaf_18_clk
+ dp.rf.rf\[24\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[21\]$_DFFE_PP_ _00528_ clknet_leaf_17_clk
+ dp.rf.rf\[24\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[22\]$_DFFE_PP_ _00529_ clknet_leaf_14_clk
+ dp.rf.rf\[24\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[23\]$_DFFE_PP_ _00530_ clknet_leaf_21_clk
+ dp.rf.rf\[24\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[24\]$_DFFE_PP_ _00531_ clknet_leaf_18_clk
+ dp.rf.rf\[24\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[25\]$_DFFE_PP_ _00532_ clknet_leaf_21_clk
+ dp.rf.rf\[24\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[26\]$_DFFE_PP_ _00533_ clknet_leaf_30_clk
+ dp.rf.rf\[24\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[27\]$_DFFE_PP_ _00534_ clknet_leaf_29_clk
+ dp.rf.rf\[24\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[28\]$_DFFE_PP_ _00535_ clknet_leaf_27_clk
+ dp.rf.rf\[24\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[29\]$_DFFE_PP_ _00536_ clknet_leaf_35_clk
+ dp.rf.rf\[24\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[2\]$_DFFE_PP_ _00537_ clknet_leaf_32_clk
+ dp.rf.rf\[24\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[30\]$_DFFE_PP_ _00538_ clknet_leaf_28_clk
+ dp.rf.rf\[24\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[31\]$_DFFE_PP_ _00539_ clknet_leaf_6_clk
+ dp.rf.rf\[24\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[3\]$_DFFE_PP_ _00540_ clknet_leaf_34_clk
+ dp.rf.rf\[24\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[4\]$_DFFE_PP_ _00541_ clknet_leaf_32_clk
+ dp.rf.rf\[24\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[5\]$_DFFE_PP_ _00542_ clknet_leaf_36_clk
+ dp.rf.rf\[24\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[6\]$_DFFE_PP_ _00543_ clknet_leaf_29_clk
+ dp.rf.rf\[24\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[7\]$_DFFE_PP_ _00544_ clknet_leaf_38_clk
+ dp.rf.rf\[24\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[8\]$_DFFE_PP_ _00545_ clknet_leaf_0_clk dp.rf.rf\[24\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[24\]\[9\]$_DFFE_PP_ _00546_ clknet_leaf_0_clk dp.rf.rf\[24\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[0\]$_DFFE_PP_ _00547_ clknet_leaf_7_clk dp.rf.rf\[25\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[10\]$_DFFE_PP_ _00548_ clknet_leaf_11_clk
+ dp.rf.rf\[25\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[11\]$_DFFE_PP_ _00549_ clknet_leaf_11_clk
+ dp.rf.rf\[25\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[12\]$_DFFE_PP_ _00550_ clknet_leaf_1_clk
+ dp.rf.rf\[25\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[13\]$_DFFE_PP_ _00551_ clknet_leaf_10_clk
+ dp.rf.rf\[25\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[14\]$_DFFE_PP_ _00552_ clknet_leaf_7_clk
+ dp.rf.rf\[25\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[15\]$_DFFE_PP_ _00553_ clknet_leaf_15_clk
+ dp.rf.rf\[25\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[16\]$_DFFE_PP_ _00554_ clknet_leaf_13_clk
+ dp.rf.rf\[25\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[17\]$_DFFE_PP_ _00555_ clknet_leaf_13_clk
+ dp.rf.rf\[25\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[18\]$_DFFE_PP_ _00556_ clknet_leaf_13_clk
+ dp.rf.rf\[25\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[19\]$_DFFE_PP_ _00557_ clknet_leaf_21_clk
+ dp.rf.rf\[25\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[1\]$_DFFE_PP_ _00558_ clknet_leaf_23_clk
+ dp.rf.rf\[25\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[20\]$_DFFE_PP_ _00559_ clknet_leaf_18_clk
+ dp.rf.rf\[25\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[21\]$_DFFE_PP_ _00560_ clknet_leaf_17_clk
+ dp.rf.rf\[25\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[22\]$_DFFE_PP_ _00561_ clknet_leaf_14_clk
+ dp.rf.rf\[25\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[23\]$_DFFE_PP_ _00562_ clknet_leaf_21_clk
+ dp.rf.rf\[25\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[24\]$_DFFE_PP_ _00563_ clknet_leaf_18_clk
+ dp.rf.rf\[25\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[25\]$_DFFE_PP_ _00564_ clknet_leaf_21_clk
+ dp.rf.rf\[25\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[26\]$_DFFE_PP_ _00565_ clknet_leaf_24_clk
+ dp.rf.rf\[25\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[27\]$_DFFE_PP_ _00566_ clknet_leaf_29_clk
+ dp.rf.rf\[25\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[28\]$_DFFE_PP_ _00567_ clknet_leaf_27_clk
+ dp.rf.rf\[25\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[29\]$_DFFE_PP_ _00568_ clknet_leaf_35_clk
+ dp.rf.rf\[25\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[2\]$_DFFE_PP_ _00569_ clknet_leaf_32_clk
+ dp.rf.rf\[25\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[30\]$_DFFE_PP_ _00570_ clknet_leaf_27_clk
+ dp.rf.rf\[25\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[31\]$_DFFE_PP_ _00571_ clknet_leaf_6_clk
+ dp.rf.rf\[25\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[3\]$_DFFE_PP_ _00572_ clknet_leaf_36_clk
+ dp.rf.rf\[25\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[4\]$_DFFE_PP_ _00573_ clknet_leaf_31_clk
+ dp.rf.rf\[25\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[5\]$_DFFE_PP_ _00574_ clknet_leaf_36_clk
+ dp.rf.rf\[25\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[6\]$_DFFE_PP_ _00575_ clknet_leaf_30_clk
+ dp.rf.rf\[25\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[7\]$_DFFE_PP_ _00576_ clknet_leaf_37_clk
+ dp.rf.rf\[25\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[8\]$_DFFE_PP_ _00577_ clknet_leaf_0_clk dp.rf.rf\[25\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[25\]\[9\]$_DFFE_PP_ _00578_ clknet_leaf_38_clk
+ dp.rf.rf\[25\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[0\]$_DFFE_PP_ _00579_ clknet_leaf_7_clk dp.rf.rf\[26\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[10\]$_DFFE_PP_ _00580_ clknet_leaf_11_clk
+ dp.rf.rf\[26\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[11\]$_DFFE_PP_ _00581_ clknet_leaf_11_clk
+ dp.rf.rf\[26\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[12\]$_DFFE_PP_ _00582_ clknet_leaf_1_clk
+ dp.rf.rf\[26\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[13\]$_DFFE_PP_ _00583_ clknet_leaf_10_clk
+ dp.rf.rf\[26\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[14\]$_DFFE_PP_ _00584_ clknet_leaf_7_clk
+ dp.rf.rf\[26\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[15\]$_DFFE_PP_ _00585_ clknet_leaf_5_clk
+ dp.rf.rf\[26\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[16\]$_DFFE_PP_ _00586_ clknet_leaf_11_clk
+ dp.rf.rf\[26\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[17\]$_DFFE_PP_ _00587_ clknet_leaf_13_clk
+ dp.rf.rf\[26\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[18\]$_DFFE_PP_ _00588_ clknet_leaf_13_clk
+ dp.rf.rf\[26\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[19\]$_DFFE_PP_ _00589_ clknet_leaf_20_clk
+ dp.rf.rf\[26\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[1\]$_DFFE_PP_ _00590_ clknet_leaf_4_clk dp.rf.rf\[26\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[20\]$_DFFE_PP_ _00591_ clknet_leaf_16_clk
+ dp.rf.rf\[26\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[21\]$_DFFE_PP_ _00592_ clknet_leaf_4_clk
+ dp.rf.rf\[26\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[22\]$_DFFE_PP_ _00593_ clknet_leaf_14_clk
+ dp.rf.rf\[26\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[23\]$_DFFE_PP_ _00594_ clknet_leaf_20_clk
+ dp.rf.rf\[26\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[24\]$_DFFE_PP_ _00595_ clknet_leaf_18_clk
+ dp.rf.rf\[26\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[25\]$_DFFE_PP_ _00596_ clknet_leaf_21_clk
+ dp.rf.rf\[26\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[26\]$_DFFE_PP_ _00597_ clknet_leaf_30_clk
+ dp.rf.rf\[26\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[27\]$_DFFE_PP_ _00598_ clknet_leaf_29_clk
+ dp.rf.rf\[26\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[28\]$_DFFE_PP_ _00599_ clknet_leaf_27_clk
+ dp.rf.rf\[26\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[29\]$_DFFE_PP_ _00600_ clknet_leaf_35_clk
+ dp.rf.rf\[26\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[2\]$_DFFE_PP_ _00601_ clknet_leaf_33_clk
+ dp.rf.rf\[26\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[30\]$_DFFE_PP_ _00602_ clknet_leaf_27_clk
+ dp.rf.rf\[26\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[31\]$_DFFE_PP_ _00603_ clknet_leaf_6_clk
+ dp.rf.rf\[26\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[3\]$_DFFE_PP_ _00604_ clknet_leaf_36_clk
+ dp.rf.rf\[26\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[4\]$_DFFE_PP_ _00605_ clknet_leaf_32_clk
+ dp.rf.rf\[26\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[5\]$_DFFE_PP_ _00606_ clknet_leaf_36_clk
+ dp.rf.rf\[26\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[6\]$_DFFE_PP_ _00607_ clknet_leaf_31_clk
+ dp.rf.rf\[26\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[7\]$_DFFE_PP_ _00608_ clknet_leaf_38_clk
+ dp.rf.rf\[26\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[8\]$_DFFE_PP_ _00609_ clknet_leaf_0_clk dp.rf.rf\[26\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[26\]\[9\]$_DFFE_PP_ _00610_ clknet_leaf_0_clk dp.rf.rf\[26\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[0\]$_DFFE_PP_ _00611_ clknet_leaf_7_clk dp.rf.rf\[27\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[10\]$_DFFE_PP_ _00612_ clknet_leaf_11_clk
+ dp.rf.rf\[27\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[11\]$_DFFE_PP_ _00613_ clknet_leaf_11_clk
+ dp.rf.rf\[27\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[12\]$_DFFE_PP_ _00614_ clknet_leaf_1_clk
+ dp.rf.rf\[27\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[13\]$_DFFE_PP_ _00615_ clknet_leaf_10_clk
+ dp.rf.rf\[27\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[14\]$_DFFE_PP_ _00616_ clknet_leaf_7_clk
+ dp.rf.rf\[27\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[15\]$_DFFE_PP_ _00617_ clknet_leaf_5_clk
+ dp.rf.rf\[27\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[16\]$_DFFE_PP_ _00618_ clknet_leaf_11_clk
+ dp.rf.rf\[27\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[17\]$_DFFE_PP_ _00619_ clknet_leaf_13_clk
+ dp.rf.rf\[27\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[18\]$_DFFE_PP_ _00620_ clknet_leaf_14_clk
+ dp.rf.rf\[27\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[19\]$_DFFE_PP_ _00621_ clknet_leaf_20_clk
+ dp.rf.rf\[27\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[1\]$_DFFE_PP_ _00622_ clknet_leaf_4_clk dp.rf.rf\[27\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[20\]$_DFFE_PP_ _00623_ clknet_leaf_16_clk
+ dp.rf.rf\[27\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[21\]$_DFFE_PP_ _00624_ clknet_leaf_4_clk
+ dp.rf.rf\[27\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[22\]$_DFFE_PP_ _00625_ clknet_leaf_14_clk
+ dp.rf.rf\[27\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[23\]$_DFFE_PP_ _00626_ clknet_leaf_20_clk
+ dp.rf.rf\[27\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[24\]$_DFFE_PP_ _00627_ clknet_leaf_18_clk
+ dp.rf.rf\[27\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[25\]$_DFFE_PP_ _00628_ clknet_leaf_20_clk
+ dp.rf.rf\[27\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[26\]$_DFFE_PP_ _00629_ clknet_leaf_30_clk
+ dp.rf.rf\[27\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[27\]$_DFFE_PP_ _00630_ clknet_leaf_29_clk
+ dp.rf.rf\[27\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[28\]$_DFFE_PP_ _00631_ clknet_leaf_27_clk
+ dp.rf.rf\[27\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[29\]$_DFFE_PP_ _00632_ clknet_leaf_35_clk
+ dp.rf.rf\[27\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[2\]$_DFFE_PP_ _00633_ clknet_leaf_33_clk
+ dp.rf.rf\[27\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[30\]$_DFFE_PP_ _00634_ clknet_leaf_28_clk
+ dp.rf.rf\[27\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[31\]$_DFFE_PP_ _00635_ clknet_leaf_6_clk
+ dp.rf.rf\[27\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[3\]$_DFFE_PP_ _00636_ clknet_leaf_37_clk
+ dp.rf.rf\[27\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[4\]$_DFFE_PP_ _00637_ clknet_leaf_32_clk
+ dp.rf.rf\[27\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[5\]$_DFFE_PP_ _00638_ clknet_leaf_36_clk
+ dp.rf.rf\[27\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[6\]$_DFFE_PP_ _00639_ clknet_leaf_31_clk
+ dp.rf.rf\[27\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[7\]$_DFFE_PP_ _00640_ clknet_leaf_38_clk
+ dp.rf.rf\[27\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[8\]$_DFFE_PP_ _00641_ clknet_leaf_0_clk dp.rf.rf\[27\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[27\]\[9\]$_DFFE_PP_ _00642_ clknet_leaf_0_clk dp.rf.rf\[27\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[0\]$_DFFE_PP_ _00643_ clknet_leaf_7_clk dp.rf.rf\[28\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[10\]$_DFFE_PP_ _00644_ clknet_leaf_11_clk
+ dp.rf.rf\[28\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[11\]$_DFFE_PP_ _00645_ clknet_leaf_11_clk
+ dp.rf.rf\[28\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[12\]$_DFFE_PP_ _00646_ clknet_leaf_1_clk
+ dp.rf.rf\[28\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[13\]$_DFFE_PP_ _00647_ clknet_leaf_10_clk
+ dp.rf.rf\[28\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[14\]$_DFFE_PP_ _00648_ clknet_leaf_7_clk
+ dp.rf.rf\[28\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[15\]$_DFFE_PP_ _00649_ clknet_leaf_5_clk
+ dp.rf.rf\[28\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[16\]$_DFFE_PP_ _00650_ clknet_leaf_11_clk
+ dp.rf.rf\[28\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[17\]$_DFFE_PP_ _00651_ clknet_leaf_13_clk
+ dp.rf.rf\[28\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[18\]$_DFFE_PP_ _00652_ clknet_leaf_13_clk
+ dp.rf.rf\[28\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[19\]$_DFFE_PP_ _00653_ clknet_leaf_20_clk
+ dp.rf.rf\[28\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[1\]$_DFFE_PP_ _00654_ clknet_leaf_24_clk
+ dp.rf.rf\[28\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[20\]$_DFFE_PP_ _00655_ clknet_leaf_16_clk
+ dp.rf.rf\[28\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[21\]$_DFFE_PP_ _00656_ clknet_leaf_4_clk
+ dp.rf.rf\[28\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[22\]$_DFFE_PP_ _00657_ clknet_leaf_15_clk
+ dp.rf.rf\[28\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[23\]$_DFFE_PP_ _00658_ clknet_leaf_19_clk
+ dp.rf.rf\[28\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[24\]$_DFFE_PP_ _00659_ clknet_leaf_18_clk
+ dp.rf.rf\[28\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[25\]$_DFFE_PP_ _00660_ clknet_leaf_21_clk
+ dp.rf.rf\[28\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[26\]$_DFFE_PP_ _00661_ clknet_leaf_30_clk
+ dp.rf.rf\[28\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[27\]$_DFFE_PP_ _00662_ clknet_leaf_29_clk
+ dp.rf.rf\[28\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[28\]$_DFFE_PP_ _00663_ clknet_leaf_27_clk
+ dp.rf.rf\[28\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[29\]$_DFFE_PP_ _00664_ clknet_leaf_35_clk
+ dp.rf.rf\[28\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[2\]$_DFFE_PP_ _00665_ clknet_leaf_33_clk
+ dp.rf.rf\[28\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[30\]$_DFFE_PP_ _00666_ clknet_leaf_28_clk
+ dp.rf.rf\[28\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[31\]$_DFFE_PP_ _00667_ clknet_leaf_6_clk
+ dp.rf.rf\[28\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[3\]$_DFFE_PP_ _00668_ clknet_leaf_36_clk
+ dp.rf.rf\[28\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[4\]$_DFFE_PP_ _00669_ clknet_leaf_32_clk
+ dp.rf.rf\[28\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[5\]$_DFFE_PP_ _00670_ clknet_leaf_36_clk
+ dp.rf.rf\[28\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[6\]$_DFFE_PP_ _00671_ clknet_leaf_30_clk
+ dp.rf.rf\[28\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[7\]$_DFFE_PP_ _00672_ clknet_leaf_38_clk
+ dp.rf.rf\[28\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[8\]$_DFFE_PP_ _00673_ clknet_leaf_0_clk dp.rf.rf\[28\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[28\]\[9\]$_DFFE_PP_ _00674_ clknet_leaf_0_clk dp.rf.rf\[28\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[0\]$_DFFE_PP_ _00675_ clknet_leaf_7_clk dp.rf.rf\[29\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[10\]$_DFFE_PP_ _00676_ clknet_leaf_10_clk
+ dp.rf.rf\[29\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[11\]$_DFFE_PP_ _00677_ clknet_leaf_11_clk
+ dp.rf.rf\[29\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[12\]$_DFFE_PP_ _00678_ clknet_leaf_1_clk
+ dp.rf.rf\[29\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[13\]$_DFFE_PP_ _00679_ clknet_leaf_10_clk
+ dp.rf.rf\[29\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[14\]$_DFFE_PP_ _00680_ clknet_leaf_7_clk
+ dp.rf.rf\[29\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[15\]$_DFFE_PP_ _00681_ clknet_leaf_5_clk
+ dp.rf.rf\[29\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[16\]$_DFFE_PP_ _00682_ clknet_leaf_11_clk
+ dp.rf.rf\[29\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[17\]$_DFFE_PP_ _00683_ clknet_leaf_13_clk
+ dp.rf.rf\[29\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[18\]$_DFFE_PP_ _00684_ clknet_leaf_13_clk
+ dp.rf.rf\[29\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[19\]$_DFFE_PP_ _00685_ clknet_leaf_21_clk
+ dp.rf.rf\[29\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[1\]$_DFFE_PP_ _00686_ clknet_leaf_24_clk
+ dp.rf.rf\[29\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[20\]$_DFFE_PP_ _00687_ clknet_leaf_16_clk
+ dp.rf.rf\[29\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[21\]$_DFFE_PP_ _00688_ clknet_leaf_4_clk
+ dp.rf.rf\[29\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[22\]$_DFFE_PP_ _00689_ clknet_leaf_15_clk
+ dp.rf.rf\[29\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[23\]$_DFFE_PP_ _00690_ clknet_leaf_21_clk
+ dp.rf.rf\[29\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[24\]$_DFFE_PP_ _00691_ clknet_leaf_18_clk
+ dp.rf.rf\[29\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[25\]$_DFFE_PP_ _00692_ clknet_leaf_21_clk
+ dp.rf.rf\[29\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[26\]$_DFFE_PP_ _00693_ clknet_leaf_24_clk
+ dp.rf.rf\[29\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[27\]$_DFFE_PP_ _00694_ clknet_leaf_29_clk
+ dp.rf.rf\[29\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[28\]$_DFFE_PP_ _00695_ clknet_leaf_27_clk
+ dp.rf.rf\[29\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[29\]$_DFFE_PP_ _00696_ clknet_leaf_35_clk
+ dp.rf.rf\[29\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[2\]$_DFFE_PP_ _00697_ clknet_leaf_33_clk
+ dp.rf.rf\[29\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[30\]$_DFFE_PP_ _00698_ clknet_leaf_28_clk
+ dp.rf.rf\[29\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[31\]$_DFFE_PP_ _00699_ clknet_leaf_2_clk
+ dp.rf.rf\[29\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[3\]$_DFFE_PP_ _00700_ clknet_leaf_36_clk
+ dp.rf.rf\[29\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[4\]$_DFFE_PP_ _00701_ clknet_leaf_32_clk
+ dp.rf.rf\[29\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[5\]$_DFFE_PP_ _00702_ clknet_leaf_36_clk
+ dp.rf.rf\[29\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[6\]$_DFFE_PP_ _00703_ clknet_leaf_30_clk
+ dp.rf.rf\[29\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[7\]$_DFFE_PP_ _00704_ clknet_leaf_37_clk
+ dp.rf.rf\[29\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[8\]$_DFFE_PP_ _00705_ clknet_leaf_0_clk dp.rf.rf\[29\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[29\]\[9\]$_DFFE_PP_ _00706_ clknet_leaf_38_clk
+ dp.rf.rf\[29\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[0\]$_DFFE_PP_ _00707_ clknet_leaf_0_clk dp.rf.rf\[2\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[10\]$_DFFE_PP_ _00708_ clknet_leaf_9_clk dp.rf.rf\[2\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[11\]$_DFFE_PP_ _00709_ clknet_leaf_8_clk dp.rf.rf\[2\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[12\]$_DFFE_PP_ _00710_ clknet_leaf_0_clk dp.rf.rf\[2\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[13\]$_DFFE_PP_ _00711_ clknet_leaf_8_clk dp.rf.rf\[2\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[14\]$_DFFE_PP_ _00712_ clknet_leaf_8_clk dp.rf.rf\[2\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[15\]$_DFFE_PP_ _00713_ clknet_leaf_5_clk dp.rf.rf\[2\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[16\]$_DFFE_PP_ _00714_ clknet_leaf_8_clk dp.rf.rf\[2\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[17\]$_DFFE_PP_ _00715_ clknet_leaf_15_clk
+ dp.rf.rf\[2\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[18\]$_DFFE_PP_ _00716_ clknet_leaf_15_clk
+ dp.rf.rf\[2\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[19\]$_DFFE_PP_ _00717_ clknet_leaf_20_clk
+ dp.rf.rf\[2\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[1\]$_DFFE_PP_ _00718_ clknet_leaf_31_clk dp.rf.rf\[2\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[20\]$_DFFE_PP_ _00719_ clknet_leaf_15_clk
+ dp.rf.rf\[2\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[21\]$_DFFE_PP_ _00720_ clknet_leaf_15_clk
+ dp.rf.rf\[2\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[22\]$_DFFE_PP_ _00721_ clknet_leaf_16_clk
+ dp.rf.rf\[2\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[23\]$_DFFE_PP_ _00722_ clknet_leaf_18_clk
+ dp.rf.rf\[2\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[24\]$_DFFE_PP_ _00723_ clknet_leaf_19_clk
+ dp.rf.rf\[2\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[25\]$_DFFE_PP_ _00724_ clknet_leaf_19_clk
+ dp.rf.rf\[2\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[26\]$_DFFE_PP_ _00725_ clknet_leaf_31_clk
+ dp.rf.rf\[2\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[27\]$_DFFE_PP_ _00726_ clknet_leaf_26_clk
+ dp.rf.rf\[2\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[28\]$_DFFE_PP_ _00727_ clknet_leaf_26_clk
+ dp.rf.rf\[2\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[29\]$_DFFE_PP_ _00728_ clknet_leaf_28_clk
+ dp.rf.rf\[2\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[2\]$_DFFE_PP_ _00729_ clknet_leaf_3_clk dp.rf.rf\[2\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[30\]$_DFFE_PP_ _00730_ clknet_leaf_27_clk
+ dp.rf.rf\[2\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[31\]$_DFFE_PP_ _00731_ clknet_leaf_2_clk dp.rf.rf\[2\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[3\]$_DFFE_PP_ _00732_ clknet_leaf_35_clk dp.rf.rf\[2\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[4\]$_DFFE_PP_ _00733_ clknet_leaf_34_clk dp.rf.rf\[2\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[5\]$_DFFE_PP_ _00734_ clknet_leaf_36_clk dp.rf.rf\[2\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[6\]$_DFFE_PP_ _00735_ clknet_leaf_26_clk dp.rf.rf\[2\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[7\]$_DFFE_PP_ _00736_ clknet_leaf_38_clk dp.rf.rf\[2\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[8\]$_DFFE_PP_ _00737_ clknet_leaf_2_clk dp.rf.rf\[2\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[2\]\[9\]$_DFFE_PP_ _00738_ clknet_leaf_38_clk dp.rf.rf\[2\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[0\]$_DFFE_PP_ _00739_ clknet_leaf_7_clk dp.rf.rf\[30\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[10\]$_DFFE_PP_ _00740_ clknet_leaf_10_clk
+ dp.rf.rf\[30\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[11\]$_DFFE_PP_ _00741_ clknet_leaf_11_clk
+ dp.rf.rf\[30\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[12\]$_DFFE_PP_ _00742_ clknet_leaf_1_clk
+ dp.rf.rf\[30\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[13\]$_DFFE_PP_ _00743_ clknet_leaf_10_clk
+ dp.rf.rf\[30\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[14\]$_DFFE_PP_ _00744_ clknet_leaf_7_clk
+ dp.rf.rf\[30\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[15\]$_DFFE_PP_ _00745_ clknet_leaf_9_clk
+ dp.rf.rf\[30\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[16\]$_DFFE_PP_ _00746_ clknet_leaf_11_clk
+ dp.rf.rf\[30\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[17\]$_DFFE_PP_ _00747_ clknet_leaf_13_clk
+ dp.rf.rf\[30\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[18\]$_DFFE_PP_ _00748_ clknet_leaf_13_clk
+ dp.rf.rf\[30\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[19\]$_DFFE_PP_ _00749_ clknet_leaf_20_clk
+ dp.rf.rf\[30\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[1\]$_DFFE_PP_ _00750_ clknet_leaf_24_clk
+ dp.rf.rf\[30\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[20\]$_DFFE_PP_ _00751_ clknet_leaf_16_clk
+ dp.rf.rf\[30\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[21\]$_DFFE_PP_ _00752_ clknet_leaf_4_clk
+ dp.rf.rf\[30\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[22\]$_DFFE_PP_ _00753_ clknet_leaf_15_clk
+ dp.rf.rf\[30\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[23\]$_DFFE_PP_ _00754_ clknet_leaf_20_clk
+ dp.rf.rf\[30\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[24\]$_DFFE_PP_ _00755_ clknet_leaf_18_clk
+ dp.rf.rf\[30\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[25\]$_DFFE_PP_ _00756_ clknet_leaf_21_clk
+ dp.rf.rf\[30\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[26\]$_DFFE_PP_ _00757_ clknet_leaf_30_clk
+ dp.rf.rf\[30\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[27\]$_DFFE_PP_ _00758_ clknet_leaf_29_clk
+ dp.rf.rf\[30\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[28\]$_DFFE_PP_ _00759_ clknet_leaf_27_clk
+ dp.rf.rf\[30\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[29\]$_DFFE_PP_ _00760_ clknet_leaf_35_clk
+ dp.rf.rf\[30\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[2\]$_DFFE_PP_ _00761_ clknet_leaf_33_clk
+ dp.rf.rf\[30\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[30\]$_DFFE_PP_ _00762_ clknet_leaf_28_clk
+ dp.rf.rf\[30\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[31\]$_DFFE_PP_ _00763_ clknet_leaf_6_clk
+ dp.rf.rf\[30\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[3\]$_DFFE_PP_ _00764_ clknet_leaf_36_clk
+ dp.rf.rf\[30\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[4\]$_DFFE_PP_ _00765_ clknet_leaf_32_clk
+ dp.rf.rf\[30\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[5\]$_DFFE_PP_ _00766_ clknet_leaf_36_clk
+ dp.rf.rf\[30\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[6\]$_DFFE_PP_ _00767_ clknet_leaf_30_clk
+ dp.rf.rf\[30\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[7\]$_DFFE_PP_ _00768_ clknet_leaf_38_clk
+ dp.rf.rf\[30\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[8\]$_DFFE_PP_ _00769_ clknet_leaf_0_clk dp.rf.rf\[30\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[30\]\[9\]$_DFFE_PP_ _00770_ clknet_leaf_0_clk dp.rf.rf\[30\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[0\]$_DFFE_PP_ _00771_ clknet_leaf_7_clk dp.rf.rf\[31\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[10\]$_DFFE_PP_ _00772_ clknet_leaf_10_clk
+ dp.rf.rf\[31\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[11\]$_DFFE_PP_ _00773_ clknet_leaf_11_clk
+ dp.rf.rf\[31\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[12\]$_DFFE_PP_ _00774_ clknet_leaf_1_clk
+ dp.rf.rf\[31\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[13\]$_DFFE_PP_ _00775_ clknet_leaf_10_clk
+ dp.rf.rf\[31\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[14\]$_DFFE_PP_ _00776_ clknet_leaf_7_clk
+ dp.rf.rf\[31\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[15\]$_DFFE_PP_ _00777_ clknet_leaf_9_clk
+ dp.rf.rf\[31\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[16\]$_DFFE_PP_ _00778_ clknet_leaf_11_clk
+ dp.rf.rf\[31\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[17\]$_DFFE_PP_ _00779_ clknet_leaf_13_clk
+ dp.rf.rf\[31\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[18\]$_DFFE_PP_ _00780_ clknet_leaf_13_clk
+ dp.rf.rf\[31\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[19\]$_DFFE_PP_ _00781_ clknet_leaf_20_clk
+ dp.rf.rf\[31\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[1\]$_DFFE_PP_ _00782_ clknet_leaf_24_clk
+ dp.rf.rf\[31\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[20\]$_DFFE_PP_ _00783_ clknet_leaf_16_clk
+ dp.rf.rf\[31\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[21\]$_DFFE_PP_ _00784_ clknet_leaf_4_clk
+ dp.rf.rf\[31\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[22\]$_DFFE_PP_ _00785_ clknet_leaf_15_clk
+ dp.rf.rf\[31\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[23\]$_DFFE_PP_ _00786_ clknet_leaf_20_clk
+ dp.rf.rf\[31\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[24\]$_DFFE_PP_ _00787_ clknet_leaf_18_clk
+ dp.rf.rf\[31\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[25\]$_DFFE_PP_ _00788_ clknet_leaf_21_clk
+ dp.rf.rf\[31\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[26\]$_DFFE_PP_ _00789_ clknet_leaf_30_clk
+ dp.rf.rf\[31\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[27\]$_DFFE_PP_ _00790_ clknet_leaf_29_clk
+ dp.rf.rf\[31\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[28\]$_DFFE_PP_ _00791_ clknet_leaf_27_clk
+ dp.rf.rf\[31\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[29\]$_DFFE_PP_ _00792_ clknet_leaf_35_clk
+ dp.rf.rf\[31\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[2\]$_DFFE_PP_ _00793_ clknet_leaf_33_clk
+ dp.rf.rf\[31\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[30\]$_DFFE_PP_ _00794_ clknet_leaf_28_clk
+ dp.rf.rf\[31\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[31\]$_DFFE_PP_ _00795_ clknet_leaf_6_clk
+ dp.rf.rf\[31\]\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[3\]$_DFFE_PP_ _00796_ clknet_leaf_36_clk
+ dp.rf.rf\[31\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[4\]$_DFFE_PP_ _00797_ clknet_leaf_32_clk
+ dp.rf.rf\[31\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[5\]$_DFFE_PP_ _00798_ clknet_leaf_36_clk
+ dp.rf.rf\[31\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[6\]$_DFFE_PP_ _00799_ clknet_leaf_32_clk
+ dp.rf.rf\[31\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[7\]$_DFFE_PP_ _00800_ clknet_leaf_38_clk
+ dp.rf.rf\[31\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[8\]$_DFFE_PP_ _00801_ clknet_leaf_0_clk dp.rf.rf\[31\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[31\]\[9\]$_DFFE_PP_ _00802_ clknet_leaf_0_clk dp.rf.rf\[31\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[0\]$_DFFE_PP_ _00803_ clknet_leaf_0_clk dp.rf.rf\[3\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[10\]$_DFFE_PP_ _00804_ clknet_leaf_9_clk dp.rf.rf\[3\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[11\]$_DFFE_PP_ _00805_ clknet_leaf_9_clk dp.rf.rf\[3\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[12\]$_DFFE_PP_ _00806_ clknet_leaf_1_clk dp.rf.rf\[3\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[13\]$_DFFE_PP_ _00807_ clknet_leaf_8_clk dp.rf.rf\[3\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[14\]$_DFFE_PP_ _00808_ clknet_leaf_8_clk dp.rf.rf\[3\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[15\]$_DFFE_PP_ _00809_ clknet_leaf_5_clk dp.rf.rf\[3\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[16\]$_DFFE_PP_ _00810_ clknet_leaf_8_clk dp.rf.rf\[3\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[17\]$_DFFE_PP_ _00811_ clknet_leaf_15_clk
+ dp.rf.rf\[3\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[18\]$_DFFE_PP_ _00812_ clknet_leaf_15_clk
+ dp.rf.rf\[3\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[19\]$_DFFE_PP_ _00813_ clknet_leaf_20_clk
+ dp.rf.rf\[3\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[1\]$_DFFE_PP_ _00814_ clknet_leaf_4_clk dp.rf.rf\[3\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[20\]$_DFFE_PP_ _00815_ clknet_leaf_16_clk
+ dp.rf.rf\[3\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[21\]$_DFFE_PP_ _00816_ clknet_leaf_15_clk
+ dp.rf.rf\[3\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[22\]$_DFFE_PP_ _00817_ clknet_leaf_16_clk
+ dp.rf.rf\[3\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[23\]$_DFFE_PP_ _00818_ clknet_leaf_18_clk
+ dp.rf.rf\[3\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[24\]$_DFFE_PP_ _00819_ clknet_leaf_19_clk
+ dp.rf.rf\[3\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[25\]$_DFFE_PP_ _00820_ clknet_leaf_19_clk
+ dp.rf.rf\[3\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[26\]$_DFFE_PP_ _00821_ clknet_leaf_32_clk
+ dp.rf.rf\[3\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[27\]$_DFFE_PP_ _00822_ clknet_leaf_26_clk
+ dp.rf.rf\[3\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[28\]$_DFFE_PP_ _00823_ clknet_leaf_26_clk
+ dp.rf.rf\[3\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[29\]$_DFFE_PP_ _00824_ clknet_leaf_35_clk
+ dp.rf.rf\[3\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[2\]$_DFFE_PP_ _00825_ clknet_leaf_3_clk dp.rf.rf\[3\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[30\]$_DFFE_PP_ _00826_ clknet_leaf_27_clk
+ dp.rf.rf\[3\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[31\]$_DFFE_PP_ _00827_ clknet_leaf_2_clk dp.rf.rf\[3\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[3\]$_DFFE_PP_ _00828_ clknet_leaf_36_clk dp.rf.rf\[3\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[4\]$_DFFE_PP_ _00829_ clknet_leaf_34_clk dp.rf.rf\[3\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[5\]$_DFFE_PP_ _00830_ clknet_leaf_36_clk dp.rf.rf\[3\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[6\]$_DFFE_PP_ _00831_ clknet_leaf_26_clk dp.rf.rf\[3\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[7\]$_DFFE_PP_ _00832_ clknet_leaf_37_clk dp.rf.rf\[3\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[8\]$_DFFE_PP_ _00833_ clknet_leaf_2_clk dp.rf.rf\[3\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[3\]\[9\]$_DFFE_PP_ _00834_ clknet_leaf_0_clk dp.rf.rf\[3\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[0\]$_DFFE_PP_ _00835_ clknet_leaf_1_clk dp.rf.rf\[4\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[10\]$_DFFE_PP_ _00836_ clknet_leaf_9_clk dp.rf.rf\[4\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[11\]$_DFFE_PP_ _00837_ clknet_leaf_9_clk dp.rf.rf\[4\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[12\]$_DFFE_PP_ _00838_ clknet_leaf_1_clk dp.rf.rf\[4\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[13\]$_DFFE_PP_ _00839_ clknet_leaf_8_clk dp.rf.rf\[4\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[14\]$_DFFE_PP_ _00840_ clknet_leaf_8_clk dp.rf.rf\[4\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[15\]$_DFFE_PP_ _00841_ clknet_leaf_5_clk dp.rf.rf\[4\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[16\]$_DFFE_PP_ _00842_ clknet_leaf_8_clk dp.rf.rf\[4\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[17\]$_DFFE_PP_ _00843_ clknet_leaf_15_clk
+ dp.rf.rf\[4\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[18\]$_DFFE_PP_ _00844_ clknet_leaf_15_clk
+ dp.rf.rf\[4\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[19\]$_DFFE_PP_ _00845_ clknet_leaf_20_clk
+ dp.rf.rf\[4\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[1\]$_DFFE_PP_ _00846_ clknet_leaf_31_clk dp.rf.rf\[4\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[20\]$_DFFE_PP_ _00847_ clknet_leaf_16_clk
+ dp.rf.rf\[4\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[21\]$_DFFE_PP_ _00848_ clknet_leaf_16_clk
+ dp.rf.rf\[4\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[22\]$_DFFE_PP_ _00849_ clknet_leaf_18_clk
+ dp.rf.rf\[4\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[23\]$_DFFE_PP_ _00850_ clknet_leaf_19_clk
+ dp.rf.rf\[4\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[24\]$_DFFE_PP_ _00851_ clknet_leaf_23_clk
+ dp.rf.rf\[4\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[25\]$_DFFE_PP_ _00852_ clknet_leaf_19_clk
+ dp.rf.rf\[4\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[26\]$_DFFE_PP_ _00853_ clknet_leaf_31_clk
+ dp.rf.rf\[4\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[27\]$_DFFE_PP_ _00854_ clknet_leaf_26_clk
+ dp.rf.rf\[4\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[28\]$_DFFE_PP_ _00855_ clknet_leaf_26_clk
+ dp.rf.rf\[4\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[29\]$_DFFE_PP_ _00856_ clknet_leaf_35_clk
+ dp.rf.rf\[4\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[2\]$_DFFE_PP_ _00857_ clknet_leaf_3_clk dp.rf.rf\[4\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[30\]$_DFFE_PP_ _00858_ clknet_leaf_27_clk
+ dp.rf.rf\[4\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[31\]$_DFFE_PP_ _00859_ clknet_leaf_2_clk dp.rf.rf\[4\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[3\]$_DFFE_PP_ _00860_ clknet_leaf_35_clk dp.rf.rf\[4\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[4\]$_DFFE_PP_ _00861_ clknet_leaf_32_clk dp.rf.rf\[4\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[5\]$_DFFE_PP_ _00862_ clknet_leaf_36_clk dp.rf.rf\[4\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[6\]$_DFFE_PP_ _00863_ clknet_leaf_27_clk dp.rf.rf\[4\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[7\]$_DFFE_PP_ _00864_ clknet_leaf_38_clk dp.rf.rf\[4\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[8\]$_DFFE_PP_ _00865_ clknet_leaf_2_clk dp.rf.rf\[4\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[4\]\[9\]$_DFFE_PP_ _00866_ clknet_leaf_38_clk dp.rf.rf\[4\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[0\]$_DFFE_PP_ _00867_ clknet_leaf_1_clk dp.rf.rf\[5\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[10\]$_DFFE_PP_ _00868_ clknet_leaf_9_clk dp.rf.rf\[5\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[11\]$_DFFE_PP_ _00869_ clknet_leaf_9_clk dp.rf.rf\[5\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[12\]$_DFFE_PP_ _00870_ clknet_leaf_1_clk dp.rf.rf\[5\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[13\]$_DFFE_PP_ _00871_ clknet_leaf_8_clk dp.rf.rf\[5\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[14\]$_DFFE_PP_ _00872_ clknet_leaf_8_clk dp.rf.rf\[5\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[15\]$_DFFE_PP_ _00873_ clknet_leaf_5_clk dp.rf.rf\[5\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[16\]$_DFFE_PP_ _00874_ clknet_leaf_8_clk dp.rf.rf\[5\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[17\]$_DFFE_PP_ _00875_ clknet_leaf_15_clk
+ dp.rf.rf\[5\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[18\]$_DFFE_PP_ _00876_ clknet_leaf_15_clk
+ dp.rf.rf\[5\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[19\]$_DFFE_PP_ _00877_ clknet_leaf_19_clk
+ dp.rf.rf\[5\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[1\]$_DFFE_PP_ _00878_ clknet_leaf_31_clk dp.rf.rf\[5\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[20\]$_DFFE_PP_ _00879_ clknet_leaf_16_clk
+ dp.rf.rf\[5\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[21\]$_DFFE_PP_ _00880_ clknet_leaf_16_clk
+ dp.rf.rf\[5\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[22\]$_DFFE_PP_ _00881_ clknet_leaf_18_clk
+ dp.rf.rf\[5\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[23\]$_DFFE_PP_ _00882_ clknet_leaf_19_clk
+ dp.rf.rf\[5\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[24\]$_DFFE_PP_ _00883_ clknet_leaf_23_clk
+ dp.rf.rf\[5\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[25\]$_DFFE_PP_ _00884_ clknet_leaf_19_clk
+ dp.rf.rf\[5\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[26\]$_DFFE_PP_ _00885_ clknet_leaf_31_clk
+ dp.rf.rf\[5\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[27\]$_DFFE_PP_ _00886_ clknet_leaf_26_clk
+ dp.rf.rf\[5\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[28\]$_DFFE_PP_ _00887_ clknet_leaf_26_clk
+ dp.rf.rf\[5\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[29\]$_DFFE_PP_ _00888_ clknet_leaf_35_clk
+ dp.rf.rf\[5\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[2\]$_DFFE_PP_ _00889_ clknet_leaf_33_clk dp.rf.rf\[5\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[30\]$_DFFE_PP_ _00890_ clknet_leaf_27_clk
+ dp.rf.rf\[5\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[31\]$_DFFE_PP_ _00891_ clknet_leaf_3_clk dp.rf.rf\[5\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[3\]$_DFFE_PP_ _00892_ clknet_leaf_35_clk dp.rf.rf\[5\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[4\]$_DFFE_PP_ _00893_ clknet_leaf_34_clk dp.rf.rf\[5\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[5\]$_DFFE_PP_ _00894_ clknet_leaf_37_clk dp.rf.rf\[5\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[6\]$_DFFE_PP_ _00895_ clknet_leaf_27_clk dp.rf.rf\[5\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[7\]$_DFFE_PP_ _00896_ clknet_leaf_37_clk dp.rf.rf\[5\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[8\]$_DFFE_PP_ _00897_ clknet_leaf_2_clk dp.rf.rf\[5\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[5\]\[9\]$_DFFE_PP_ _00898_ clknet_leaf_38_clk dp.rf.rf\[5\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[0\]$_DFFE_PP_ _00899_ clknet_leaf_1_clk dp.rf.rf\[6\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[10\]$_DFFE_PP_ _00900_ clknet_leaf_9_clk dp.rf.rf\[6\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[11\]$_DFFE_PP_ _00901_ clknet_leaf_8_clk dp.rf.rf\[6\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[12\]$_DFFE_PP_ _00902_ clknet_leaf_1_clk dp.rf.rf\[6\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[13\]$_DFFE_PP_ _00903_ clknet_leaf_8_clk dp.rf.rf\[6\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[14\]$_DFFE_PP_ _00904_ clknet_leaf_8_clk dp.rf.rf\[6\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[15\]$_DFFE_PP_ _00905_ clknet_leaf_5_clk dp.rf.rf\[6\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[16\]$_DFFE_PP_ _00906_ clknet_leaf_8_clk dp.rf.rf\[6\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[17\]$_DFFE_PP_ _00907_ clknet_leaf_15_clk
+ dp.rf.rf\[6\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[18\]$_DFFE_PP_ _00908_ clknet_leaf_15_clk
+ dp.rf.rf\[6\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[19\]$_DFFE_PP_ _00909_ clknet_leaf_20_clk
+ dp.rf.rf\[6\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[1\]$_DFFE_PP_ _00910_ clknet_leaf_4_clk dp.rf.rf\[6\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[20\]$_DFFE_PP_ _00911_ clknet_leaf_15_clk
+ dp.rf.rf\[6\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[21\]$_DFFE_PP_ _00912_ clknet_leaf_16_clk
+ dp.rf.rf\[6\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[22\]$_DFFE_PP_ _00913_ clknet_leaf_18_clk
+ dp.rf.rf\[6\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[23\]$_DFFE_PP_ _00914_ clknet_leaf_18_clk
+ dp.rf.rf\[6\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[24\]$_DFFE_PP_ _00915_ clknet_leaf_18_clk
+ dp.rf.rf\[6\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[25\]$_DFFE_PP_ _00916_ clknet_leaf_19_clk
+ dp.rf.rf\[6\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[26\]$_DFFE_PP_ _00917_ clknet_leaf_32_clk
+ dp.rf.rf\[6\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[27\]$_DFFE_PP_ _00918_ clknet_leaf_29_clk
+ dp.rf.rf\[6\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[28\]$_DFFE_PP_ _00919_ clknet_leaf_29_clk
+ dp.rf.rf\[6\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[29\]$_DFFE_PP_ _00920_ clknet_leaf_35_clk
+ dp.rf.rf\[6\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[2\]$_DFFE_PP_ _00921_ clknet_leaf_3_clk dp.rf.rf\[6\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[30\]$_DFFE_PP_ _00922_ clknet_leaf_27_clk
+ dp.rf.rf\[6\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[31\]$_DFFE_PP_ _00923_ clknet_leaf_2_clk dp.rf.rf\[6\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[3\]$_DFFE_PP_ _00924_ clknet_leaf_35_clk dp.rf.rf\[6\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[4\]$_DFFE_PP_ _00925_ clknet_leaf_32_clk dp.rf.rf\[6\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[5\]$_DFFE_PP_ _00926_ clknet_leaf_37_clk dp.rf.rf\[6\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[6\]$_DFFE_PP_ _00927_ clknet_leaf_26_clk dp.rf.rf\[6\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[7\]$_DFFE_PP_ _00928_ clknet_leaf_38_clk dp.rf.rf\[6\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[8\]$_DFFE_PP_ _00929_ clknet_leaf_2_clk dp.rf.rf\[6\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[6\]\[9\]$_DFFE_PP_ _00930_ clknet_leaf_38_clk dp.rf.rf\[6\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[0\]$_DFFE_PP_ _00931_ clknet_leaf_1_clk dp.rf.rf\[7\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[10\]$_DFFE_PP_ _00932_ clknet_leaf_9_clk dp.rf.rf\[7\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[11\]$_DFFE_PP_ _00933_ clknet_leaf_8_clk dp.rf.rf\[7\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[12\]$_DFFE_PP_ _00934_ clknet_leaf_1_clk dp.rf.rf\[7\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[13\]$_DFFE_PP_ _00935_ clknet_leaf_8_clk dp.rf.rf\[7\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[14\]$_DFFE_PP_ _00936_ clknet_leaf_8_clk dp.rf.rf\[7\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[15\]$_DFFE_PP_ _00937_ clknet_leaf_5_clk dp.rf.rf\[7\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[16\]$_DFFE_PP_ _00938_ clknet_leaf_8_clk dp.rf.rf\[7\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[17\]$_DFFE_PP_ _00939_ clknet_leaf_15_clk
+ dp.rf.rf\[7\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[18\]$_DFFE_PP_ _00940_ clknet_leaf_15_clk
+ dp.rf.rf\[7\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[19\]$_DFFE_PP_ _00941_ clknet_leaf_20_clk
+ dp.rf.rf\[7\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[1\]$_DFFE_PP_ _00942_ clknet_leaf_4_clk dp.rf.rf\[7\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[20\]$_DFFE_PP_ _00943_ clknet_leaf_15_clk
+ dp.rf.rf\[7\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[21\]$_DFFE_PP_ _00944_ clknet_leaf_15_clk
+ dp.rf.rf\[7\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[22\]$_DFFE_PP_ _00945_ clknet_leaf_16_clk
+ dp.rf.rf\[7\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[23\]$_DFFE_PP_ _00946_ clknet_leaf_19_clk
+ dp.rf.rf\[7\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[24\]$_DFFE_PP_ _00947_ clknet_leaf_18_clk
+ dp.rf.rf\[7\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[25\]$_DFFE_PP_ _00948_ clknet_leaf_19_clk
+ dp.rf.rf\[7\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[26\]$_DFFE_PP_ _00949_ clknet_leaf_31_clk
+ dp.rf.rf\[7\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[27\]$_DFFE_PP_ _00950_ clknet_leaf_29_clk
+ dp.rf.rf\[7\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[28\]$_DFFE_PP_ _00951_ clknet_leaf_26_clk
+ dp.rf.rf\[7\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[29\]$_DFFE_PP_ _00952_ clknet_leaf_35_clk
+ dp.rf.rf\[7\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[2\]$_DFFE_PP_ _00953_ clknet_leaf_3_clk dp.rf.rf\[7\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[30\]$_DFFE_PP_ _00954_ clknet_leaf_27_clk
+ dp.rf.rf\[7\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[31\]$_DFFE_PP_ _00955_ clknet_leaf_3_clk dp.rf.rf\[7\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[3\]$_DFFE_PP_ _00956_ clknet_leaf_36_clk dp.rf.rf\[7\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[4\]$_DFFE_PP_ _00957_ clknet_leaf_34_clk dp.rf.rf\[7\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[5\]$_DFFE_PP_ _00958_ clknet_leaf_36_clk dp.rf.rf\[7\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[6\]$_DFFE_PP_ _00959_ clknet_leaf_27_clk dp.rf.rf\[7\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[7\]$_DFFE_PP_ _00960_ clknet_leaf_38_clk dp.rf.rf\[7\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[8\]$_DFFE_PP_ _00961_ clknet_leaf_2_clk dp.rf.rf\[7\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[7\]\[9\]$_DFFE_PP_ _00962_ clknet_leaf_38_clk dp.rf.rf\[7\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[0\]$_DFFE_PP_ _00963_ clknet_leaf_1_clk dp.rf.rf\[8\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[10\]$_DFFE_PP_ _00964_ clknet_leaf_12_clk
+ dp.rf.rf\[8\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[11\]$_DFFE_PP_ _00965_ clknet_leaf_9_clk dp.rf.rf\[8\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[12\]$_DFFE_PP_ _00966_ clknet_leaf_2_clk dp.rf.rf\[8\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[13\]$_DFFE_PP_ _00967_ clknet_leaf_10_clk
+ dp.rf.rf\[8\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[14\]$_DFFE_PP_ _00968_ clknet_leaf_6_clk dp.rf.rf\[8\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[15\]$_DFFE_PP_ _00969_ clknet_leaf_15_clk
+ dp.rf.rf\[8\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[16\]$_DFFE_PP_ _00970_ clknet_leaf_12_clk
+ dp.rf.rf\[8\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[17\]$_DFFE_PP_ _00971_ clknet_leaf_12_clk
+ dp.rf.rf\[8\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[18\]$_DFFE_PP_ _00972_ clknet_leaf_14_clk
+ dp.rf.rf\[8\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[19\]$_DFFE_PP_ _00973_ clknet_leaf_20_clk
+ dp.rf.rf\[8\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[1\]$_DFFE_PP_ _00974_ clknet_leaf_24_clk dp.rf.rf\[8\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[20\]$_DFFE_PP_ _00975_ clknet_leaf_17_clk
+ dp.rf.rf\[8\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[21\]$_DFFE_PP_ _00976_ clknet_leaf_16_clk
+ dp.rf.rf\[8\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[22\]$_DFFE_PP_ _00977_ clknet_leaf_18_clk
+ dp.rf.rf\[8\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[23\]$_DFFE_PP_ _00978_ clknet_leaf_19_clk
+ dp.rf.rf\[8\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[24\]$_DFFE_PP_ _00979_ clknet_leaf_23_clk
+ dp.rf.rf\[8\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[25\]$_DFFE_PP_ _00980_ clknet_leaf_22_clk
+ dp.rf.rf\[8\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[26\]$_DFFE_PP_ _00981_ clknet_leaf_24_clk
+ dp.rf.rf\[8\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[27\]$_DFFE_PP_ _00982_ clknet_leaf_30_clk
+ dp.rf.rf\[8\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[28\]$_DFFE_PP_ _00983_ clknet_leaf_26_clk
+ dp.rf.rf\[8\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[29\]$_DFFE_PP_ _00984_ clknet_leaf_28_clk
+ dp.rf.rf\[8\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[2\]$_DFFE_PP_ _00985_ clknet_leaf_33_clk dp.rf.rf\[8\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[30\]$_DFFE_PP_ _00986_ clknet_leaf_27_clk
+ dp.rf.rf\[8\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[31\]$_DFFE_PP_ _00987_ clknet_leaf_4_clk dp.rf.rf\[8\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[3\]$_DFFE_PP_ _00988_ clknet_leaf_34_clk dp.rf.rf\[8\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[4\]$_DFFE_PP_ _00989_ clknet_leaf_34_clk dp.rf.rf\[8\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[5\]$_DFFE_PP_ _00990_ clknet_leaf_36_clk dp.rf.rf\[8\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[6\]$_DFFE_PP_ _00991_ clknet_leaf_26_clk dp.rf.rf\[8\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[7\]$_DFFE_PP_ _00992_ clknet_leaf_37_clk dp.rf.rf\[8\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[8\]$_DFFE_PP_ _00993_ clknet_leaf_3_clk dp.rf.rf\[8\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[8\]\[9\]$_DFFE_PP_ _00994_ clknet_leaf_33_clk dp.rf.rf\[8\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[0\]$_DFFE_PP_ _00995_ clknet_leaf_1_clk dp.rf.rf\[9\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[10\]$_DFFE_PP_ _00996_ clknet_leaf_12_clk
+ dp.rf.rf\[9\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[11\]$_DFFE_PP_ _00997_ clknet_leaf_9_clk dp.rf.rf\[9\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[12\]$_DFFE_PP_ _00998_ clknet_leaf_2_clk dp.rf.rf\[9\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[13\]$_DFFE_PP_ _00999_ clknet_leaf_10_clk
+ dp.rf.rf\[9\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[14\]$_DFFE_PP_ _01000_ clknet_leaf_6_clk dp.rf.rf\[9\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[15\]$_DFFE_PP_ _01001_ clknet_leaf_15_clk
+ dp.rf.rf\[9\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[16\]$_DFFE_PP_ _01002_ clknet_leaf_12_clk
+ dp.rf.rf\[9\]\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[17\]$_DFFE_PP_ _01003_ clknet_leaf_12_clk
+ dp.rf.rf\[9\]\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[18\]$_DFFE_PP_ _01004_ clknet_leaf_14_clk
+ dp.rf.rf\[9\]\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[19\]$_DFFE_PP_ _01005_ clknet_leaf_19_clk
+ dp.rf.rf\[9\]\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[1\]$_DFFE_PP_ _01006_ clknet_leaf_31_clk dp.rf.rf\[9\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[20\]$_DFFE_PP_ _01007_ clknet_leaf_17_clk
+ dp.rf.rf\[9\]\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[21\]$_DFFE_PP_ _01008_ clknet_leaf_17_clk
+ dp.rf.rf\[9\]\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[22\]$_DFFE_PP_ _01009_ clknet_leaf_18_clk
+ dp.rf.rf\[9\]\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[23\]$_DFFE_PP_ _01010_ clknet_leaf_19_clk
+ dp.rf.rf\[9\]\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[24\]$_DFFE_PP_ _01011_ clknet_leaf_23_clk
+ dp.rf.rf\[9\]\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[25\]$_DFFE_PP_ _01012_ clknet_leaf_22_clk
+ dp.rf.rf\[9\]\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[26\]$_DFFE_PP_ _01013_ clknet_leaf_31_clk
+ dp.rf.rf\[9\]\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[27\]$_DFFE_PP_ _01014_ clknet_leaf_30_clk
+ dp.rf.rf\[9\]\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[28\]$_DFFE_PP_ _01015_ clknet_leaf_26_clk
+ dp.rf.rf\[9\]\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[29\]$_DFFE_PP_ _01016_ clknet_leaf_28_clk
+ dp.rf.rf\[9\]\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[2\]$_DFFE_PP_ _01017_ clknet_leaf_33_clk dp.rf.rf\[9\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[30\]$_DFFE_PP_ _01018_ clknet_leaf_28_clk
+ dp.rf.rf\[9\]\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[31\]$_DFFE_PP_ _01019_ clknet_leaf_4_clk dp.rf.rf\[9\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[3\]$_DFFE_PP_ _01020_ clknet_leaf_35_clk dp.rf.rf\[9\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[4\]$_DFFE_PP_ _01021_ clknet_leaf_34_clk dp.rf.rf\[9\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[5\]$_DFFE_PP_ _01022_ clknet_leaf_36_clk dp.rf.rf\[9\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[6\]$_DFFE_PP_ _01023_ clknet_leaf_27_clk dp.rf.rf\[9\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[7\]$_DFFE_PP_ _01024_ clknet_leaf_37_clk dp.rf.rf\[9\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[8\]$_DFFE_PP_ _01025_ clknet_leaf_3_clk dp.rf.rf\[9\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdp.rf.rf\[9\]\[9\]$_DFFE_PP_ _01026_ clknet_leaf_33_clk dp.rf.rf\[9\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Right_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Right_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Right_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Right_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Right_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Right_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Right_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Right_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Right_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Right_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Right_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Right_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Right_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Right_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Right_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Right_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Right_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Right_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Right_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Right_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Right_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Right_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Right_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Right_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Right_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Right_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Right_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Right_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Right_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Right_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Right_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Right_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Right_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Right_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Right_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Right_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Right_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Right_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_67_Right_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_68_Right_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_69_Right_69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_70_Right_70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_71_Right_71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_72_Right_72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_73_Right_73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_74_Right_74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_75_Right_75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_76_Right_76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_77_Right_77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_78_Right_78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_79_Right_79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_80_Right_80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_81_Right_81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_82_Right_82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_83_Right_83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_84_Right_84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_85_Right_85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_86_Right_86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_87_Right_87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_88_Right_88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_89_Right_89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_90_Right_90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_91_Right_91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_92_Right_92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_93_Right_93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_94_Right_94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_95_Right_95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_96_Right_96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_97_Right_97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_98_Right_98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_99_Right_99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_100_Right_100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_101_Right_101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_102_Right_102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_103_Right_103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_104_Right_104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_105_Right_105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_106_Right_106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_107_Right_107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_108_Right_108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_109_Right_109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_110_Right_110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_111_Right_111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_112_Right_112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_113_Right_113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_114_Right_114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_115_Right_115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_116_Right_116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_117_Right_117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_118_Right_118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_119_Right_119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_120_Right_120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_121_Right_121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_122_Right_122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_123_Right_123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_124_Right_124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_125_Right_125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_126_Right_126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_127_Right_127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_128_Right_128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_129_Right_129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_130_Right_130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_131_Right_131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_132_Right_132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_133_Right_133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_134_Right_134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_135_Right_135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_136_Right_136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_137_Right_137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_138_Right_138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_139_Right_139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_140_Right_140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_141_Right_141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_142_Right_142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_143_Right_143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_144_Right_144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_145_Right_145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_146_Right_146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_147_Right_147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_148_Right_148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_149_Right_149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_150_Right_150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_151_Right_151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_152_Right_152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_153_Right_153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_154_Right_154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_155_Right_155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_156_Right_156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_157_Right_157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_158_Right_158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_159_Right_159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_160_Right_160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_161_Right_161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_162_Right_162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Left_190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Left_191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Left_192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Left_193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Left_194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Left_195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Left_196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Left_197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Left_198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Left_199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Left_200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Left_201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Left_202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Left_203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Left_204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Left_205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Left_206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Left_207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Left_208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Left_209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Left_210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Left_211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Left_212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Left_213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Left_214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Left_215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Left_216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Left_217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Left_218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Left_219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Left_220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Left_221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Left_222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Left_223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Left_224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Left_225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Left_226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Left_227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Left_228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Left_229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_67_Left_230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_68_Left_231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_69_Left_232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_70_Left_233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_71_Left_234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_72_Left_235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_73_Left_236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_74_Left_237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_75_Left_238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_76_Left_239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_77_Left_240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_78_Left_241 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_79_Left_242 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_80_Left_243 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_81_Left_244 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_82_Left_245 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_83_Left_246 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_84_Left_247 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_85_Left_248 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_86_Left_249 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_87_Left_250 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_88_Left_251 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_89_Left_252 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_90_Left_253 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_91_Left_254 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_92_Left_255 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_93_Left_256 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_94_Left_257 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_95_Left_258 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_96_Left_259 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_97_Left_260 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_98_Left_261 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_99_Left_262 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_100_Left_263 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_101_Left_264 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_102_Left_265 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_103_Left_266 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_104_Left_267 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_105_Left_268 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_106_Left_269 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_107_Left_270 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_108_Left_271 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_109_Left_272 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_110_Left_273 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_111_Left_274 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_112_Left_275 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_113_Left_276 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_114_Left_277 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_115_Left_278 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_116_Left_279 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_117_Left_280 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_118_Left_281 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_119_Left_282 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_120_Left_283 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_121_Left_284 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_122_Left_285 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_123_Left_286 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_124_Left_287 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_125_Left_288 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_126_Left_289 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_127_Left_290 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_128_Left_291 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_129_Left_292 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_130_Left_293 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_131_Left_294 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_132_Left_295 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_133_Left_296 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_134_Left_297 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_135_Left_298 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_136_Left_299 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_137_Left_300 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_138_Left_301 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_139_Left_302 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_140_Left_303 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_141_Left_304 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_142_Left_305 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_143_Left_306 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_144_Left_307 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_145_Left_308 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_146_Left_309 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_147_Left_310 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_148_Left_311 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_149_Left_312 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_150_Left_313 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_151_Left_314 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_152_Left_315 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_153_Left_316 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_154_Left_317 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_155_Left_318 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_156_Left_319 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_157_Left_320 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_158_Left_321 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_159_Left_322 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_160_Left_323 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_161_Left_324 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_162_Left_325 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_326 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_327 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_328 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_329 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_330 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_331 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_332 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_333 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_334 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_335 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_336 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_337 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_338 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_339 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_340 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_341 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_342 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_343 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_344 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_345 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_346 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_347 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_348 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_349 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_350 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_351 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_352 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_353 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_354 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_355 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_356 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_357 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_358 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_359 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_360 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_361 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_362 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_363 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_364 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_365 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_366 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_367 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_368 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_369 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_370 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_371 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_372 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_373 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_374 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_375 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_376 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_377 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_378 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_379 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_380 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_381 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_382 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_383 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_384 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_385 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_386 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_387 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_388 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_389 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_390 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_391 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_392 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_393 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_394 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_395 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_396 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_397 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_398 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_399 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_400 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_401 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_402 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_403 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_404 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_405 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_406 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_407 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_408 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_409 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_410 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_411 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_412 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_413 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_414 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_415 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_416 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_417 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_418 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_419 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_420 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_421 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_422 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_423 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_424 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_425 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_426 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_427 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_428 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_429 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_430 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_431 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_432 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_433 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_434 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_435 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_436 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_437 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_438 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_439 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_440 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_441 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_442 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_443 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_444 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_445 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_446 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_447 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_448 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_449 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_450 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_451 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_452 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_453 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_454 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_455 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_456 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_457 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_458 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_459 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_460 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_461 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_462 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_463 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_464 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_465 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_466 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_467 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_468 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_469 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_470 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_471 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_472 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_473 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_474 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_475 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_476 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_477 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_478 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_479 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_480 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_481 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_482 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_483 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_484 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_485 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_486 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_487 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_488 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_489 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_490 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_491 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_492 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_493 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_494 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_495 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_496 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_497 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_498 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_499 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_500 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_501 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_502 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_503 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_504 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_505 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_506 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_507 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_508 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_509 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_510 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_511 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_512 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_513 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_514 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_515 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_516 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_517 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_518 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_519 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_520 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_521 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_522 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_523 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_524 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_525 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_526 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_527 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_528 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_529 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_530 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_531 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_532 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_533 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_534 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_535 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_536 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_537 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_538 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_539 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_540 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_541 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_542 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_543 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_544 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_545 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_546 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_547 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_548 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_549 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_550 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_551 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_552 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_553 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_554 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_555 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_556 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_557 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_558 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_559 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_560 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_561 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_562 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_563 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_564 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_565 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_566 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_567 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_568 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_569 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_570 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_571 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_572 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_573 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_574 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_575 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_576 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_577 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_578 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_579 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_580 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_581 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_582 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_583 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_584 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_585 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_586 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_587 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_588 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_589 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_590 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_591 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_592 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_593 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_594 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_595 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_596 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_597 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_598 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_599 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_600 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_601 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_602 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_603 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_604 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_605 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_606 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_607 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_608 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_609 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_610 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_611 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_612 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_613 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_614 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_615 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_616 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_617 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_618 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_619 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_620 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_621 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_622 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_623 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_624 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_625 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_626 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_627 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_628 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_629 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_630 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_631 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_632 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_633 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_634 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_635 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_636 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_637 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_638 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_639 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_640 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_641 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_642 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_643 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_644 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_645 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_646 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_647 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_648 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_649 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_650 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_651 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_652 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_653 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_654 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_655 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_656 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_657 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_658 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_659 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_660 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_661 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_662 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_663 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_664 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_665 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_666 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_667 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_668 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_669 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_670 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_671 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_672 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_673 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_674 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_675 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_676 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_677 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_678 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_679 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_680 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_681 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_682 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_683 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_684 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_685 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_686 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_687 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_688 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_689 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_690 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_691 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_692 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_693 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_694 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_695 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_696 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_697 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_698 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_699 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_700 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_701 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_702 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_703 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_704 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_705 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_706 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_707 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_708 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_709 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_710 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_711 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_712 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_713 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_714 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_715 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_716 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_717 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_718 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_719 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_720 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_721 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_722 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_723 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_724 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_725 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_726 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_727 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_728 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_729 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_730 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_731 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_732 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_733 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_734 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_735 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_736 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_737 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_738 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_739 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_740 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_741 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_742 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_743 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_744 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_745 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_746 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_747 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_748 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_749 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_750 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_751 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_752 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_753 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_754 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_755 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_756 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_757 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_758 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_759 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_760 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_761 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_762 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_763 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_764 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_765 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_766 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_767 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_768 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_769 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_770 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_771 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_772 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_773 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_774 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_775 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_776 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_777 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_778 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_779 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_780 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_781 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_782 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_783 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_784 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_785 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_786 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_787 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_788 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_789 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_790 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_791 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_792 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_793 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_794 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_795 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_796 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_797 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_798 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_799 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_800 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_801 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_802 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_803 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_804 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_805 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_806 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_807 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_808 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_809 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_810 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_811 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_812 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_813 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_814 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_815 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_816 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_817 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_818 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_819 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_820 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_821 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_822 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_823 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_824 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_825 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_826 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_827 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_828 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_829 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_830 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_831 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_832 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_833 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_834 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_835 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_836 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_837 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_838 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_839 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_840 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_841 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_842 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_843 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_844 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_845 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_846 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_847 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_848 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_849 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_850 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_851 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_852 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_853 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_854 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_855 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_856 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_857 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_858 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_859 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_860 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_861 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_862 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_863 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_864 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_865 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_866 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_867 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_868 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_869 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_870 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_871 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_872 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_873 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_874 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_875 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_876 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_877 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_878 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_879 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_880 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_881 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_882 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_883 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_884 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_885 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_886 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_887 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_888 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_889 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_890 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_891 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_892 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_893 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_894 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_895 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_896 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_897 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_898 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_899 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_900 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_901 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_902 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_903 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_904 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_905 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_906 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_907 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_908 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_909 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_910 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_911 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_912 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_913 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_914 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_915 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_916 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_917 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_918 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_919 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_920 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_921 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_922 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_923 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_924 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_925 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_926 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_927 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_928 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_929 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_930 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_931 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_932 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_933 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_934 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_935 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_936 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_937 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_938 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_939 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_940 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_941 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_942 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_943 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_944 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_945 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_946 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_947 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_948 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_949 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_950 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_951 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_952 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_953 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_954 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_955 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_956 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_957 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_958 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_959 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_960 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_961 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_962 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_963 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_964 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_965 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_966 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_967 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_968 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_969 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_970 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_971 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_972 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_973 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_974 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_975 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_976 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_977 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_978 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_979 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_980 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_981 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_982 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_983 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_984 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_985 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 instr[0] net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xinput2 instr[10] net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xinput3 instr[11] net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput4 instr[12] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xinput5 instr[13] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xinput6 instr[14] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xinput7 instr[16] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xinput8 instr[18] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xinput9 instr[19] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xinput10 instr[1] net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xinput11 instr[22] net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xinput12 instr[23] net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xinput13 instr[24] net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput14 instr[25] net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput15 instr[26] net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput16 instr[27] net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput17 instr[28] net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput18 instr[29] net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput19 instr[30] net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xinput20 instr[31] net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xinput21 instr[3] net21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xinput22 instr[4] net22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xinput23 instr[5] net23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput24 instr[6] net24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xinput25 instr[7] net25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xinput26 instr[8] net26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput27 instr[9] net27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xinput28 readdata[0] net28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput29 readdata[10] net29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput30 readdata[11] net30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput31 readdata[12] net31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput32 readdata[13] net32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput33 readdata[14] net33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput34 readdata[15] net34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput35 readdata[16] net35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput36 readdata[17] net36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput37 readdata[18] net37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput38 readdata[19] net38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput39 readdata[1] net39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput40 readdata[20] net40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput41 readdata[21] net41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput42 readdata[22] net42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput43 readdata[23] net43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput44 readdata[24] net44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput45 readdata[25] net45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput46 readdata[26] net46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput47 readdata[27] net47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput48 readdata[28] net48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput49 readdata[29] net49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput50 readdata[2] net50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput51 readdata[30] net51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput52 readdata[31] net52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput53 readdata[3] net53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput54 readdata[4] net54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput55 readdata[5] net55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput56 readdata[6] net56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput57 readdata[7] net57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput58 readdata[8] net58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput59 readdata[9] net59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput60 reset net60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xoutput61 net61 aluout[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xoutput62 net62 aluout[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput63 net63 aluout[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput64 net64 aluout[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput65 net65 aluout[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput66 net66 aluout[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput67 net67 aluout[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput68 net68 aluout[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput69 net69 aluout[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput70 net70 aluout[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput71 net71 aluout[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput72 net72 aluout[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput73 net73 aluout[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput74 net74 aluout[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput75 net75 aluout[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput76 net76 aluout[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput77 net77 aluout[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xoutput78 net78 aluout[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput79 net79 aluout[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xoutput80 net80 aluout[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xoutput81 net81 aluout[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xoutput82 net82 aluout[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput83 net83 aluout[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput84 net84 aluout[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xoutput85 net85 aluout[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xoutput86 net86 aluout[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput87 net87 aluout[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput88 net88 aluout[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput89 net89 aluout[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput90 net90 aluout[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput91 net91 aluout[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput92 net92 aluout[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput93 net93 memread VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput94 net94 memwrite VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput95 net95 pc[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput96 net96 pc[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput97 net97 pc[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput98 net98 pc[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput99 net99 pc[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput100 net100 pc[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput101 net101 pc[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput102 net102 pc[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput103 net103 pc[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput104 net104 pc[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput105 net105 pc[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput106 net106 pc[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput107 net107 pc[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput108 net108 pc[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput109 net109 pc[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput110 net110 pc[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput111 net111 pc[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput112 net112 pc[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput113 net113 pc[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput114 net114 pc[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput115 net115 pc[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput116 net116 pc[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput117 net117 pc[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput118 net118 pc[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput119 net119 pc[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput120 net120 pc[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput121 net121 pc[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput122 net122 pc[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput123 net123 pc[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput124 net124 pc[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput125 net125 pc[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput126 net126 pc[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput127 net127 suspend VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput128 net128 writedata[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput129 net129 writedata[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput130 net130 writedata[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput131 net131 writedata[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput132 net132 writedata[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput133 net133 writedata[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput134 net134 writedata[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput135 net135 writedata[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput136 net136 writedata[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput137 net137 writedata[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput138 net138 writedata[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput139 net139 writedata[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput140 net140 writedata[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput141 net141 writedata[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput142 net142 writedata[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput143 net143 writedata[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput144 net144 writedata[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput145 net145 writedata[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput146 net146 writedata[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput147 net147 writedata[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput148 net148 writedata[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput149 net149 writedata[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput150 net150 writedata[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput151 net151 writedata[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput152 net152 writedata[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput153 net153 writedata[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput154 net154 writedata[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput155 net155 writedata[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput156 net156 writedata[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput157 net157 writedata[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput158 net158 writedata[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput159 net159 writedata[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_leaf_0_clk clknet_2_0__leaf_clk clknet_leaf_0_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_1_clk clknet_2_0__leaf_clk clknet_leaf_1_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_2_clk clknet_2_0__leaf_clk clknet_leaf_2_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_3_clk clknet_2_0__leaf_clk clknet_leaf_3_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_4_clk clknet_2_1__leaf_clk clknet_leaf_4_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_5_clk clknet_2_1__leaf_clk clknet_leaf_5_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_6_clk clknet_2_1__leaf_clk clknet_leaf_6_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_7_clk clknet_2_1__leaf_clk clknet_leaf_7_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_8_clk clknet_2_1__leaf_clk clknet_leaf_8_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_9_clk clknet_2_1__leaf_clk clknet_leaf_9_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_10_clk clknet_2_1__leaf_clk clknet_leaf_10_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_11_clk clknet_2_1__leaf_clk clknet_leaf_11_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_12_clk clknet_2_1__leaf_clk clknet_leaf_12_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_13_clk clknet_2_1__leaf_clk clknet_leaf_13_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_14_clk clknet_2_1__leaf_clk clknet_leaf_14_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_15_clk clknet_2_1__leaf_clk clknet_leaf_15_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_16_clk clknet_2_1__leaf_clk clknet_leaf_16_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_17_clk clknet_2_3__leaf_clk clknet_leaf_17_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_18_clk clknet_2_3__leaf_clk clknet_leaf_18_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_19_clk clknet_2_3__leaf_clk clknet_leaf_19_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_20_clk clknet_2_3__leaf_clk clknet_leaf_20_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_21_clk clknet_2_3__leaf_clk clknet_leaf_21_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_22_clk clknet_2_3__leaf_clk clknet_leaf_22_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_23_clk clknet_2_3__leaf_clk clknet_leaf_23_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_24_clk clknet_2_3__leaf_clk clknet_leaf_24_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_25_clk clknet_2_2__leaf_clk clknet_leaf_25_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_26_clk clknet_2_2__leaf_clk clknet_leaf_26_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_27_clk clknet_2_2__leaf_clk clknet_leaf_27_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_28_clk clknet_2_2__leaf_clk clknet_leaf_28_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_29_clk clknet_2_2__leaf_clk clknet_leaf_29_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_30_clk clknet_2_2__leaf_clk clknet_leaf_30_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_31_clk clknet_2_2__leaf_clk clknet_leaf_31_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_32_clk clknet_2_0__leaf_clk clknet_leaf_32_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_33_clk clknet_2_0__leaf_clk clknet_leaf_33_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_34_clk clknet_2_0__leaf_clk clknet_leaf_34_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_35_clk clknet_2_0__leaf_clk clknet_leaf_35_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_36_clk clknet_2_0__leaf_clk clknet_leaf_36_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_37_clk clknet_2_0__leaf_clk clknet_leaf_37_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_38_clk clknet_2_0__leaf_clk clknet_leaf_38_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_2_0__f_clk clknet_0_clk clknet_2_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_2_1__f_clk clknet_0_clk clknet_2_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_2_2__f_clk clknet_0_clk clknet_2_2__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_2_3__f_clk clknet_0_clk clknet_2_3__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkload0 clknet_2_0__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_20
Xclkload1 clknet_2_2__leaf_clk _unconnected_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_20
Xclkload2 clknet_2_3__leaf_clk _unconnected_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_20
Xclkload3 clknet_leaf_0_clk _unconnected_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload4 clknet_leaf_2_clk _unconnected_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload5 clknet_leaf_3_clk _unconnected_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_8
Xclkload6 clknet_leaf_33_clk _unconnected_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xclkload7 clknet_leaf_34_clk _unconnected_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload8 clknet_leaf_35_clk _unconnected_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload9 clknet_leaf_37_clk _unconnected_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload10 clknet_leaf_38_clk _unconnected_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_1
Xclkload11 clknet_leaf_4_clk _unconnected_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
Xclkload12 clknet_leaf_5_clk _unconnected_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload13 clknet_leaf_6_clk _unconnected_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xclkload14 clknet_leaf_7_clk _unconnected_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload15 clknet_leaf_9_clk _unconnected_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
Xclkload16 clknet_leaf_10_clk _unconnected_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload17 clknet_leaf_11_clk _unconnected_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload18 clknet_leaf_12_clk _unconnected_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload19 clknet_leaf_13_clk _unconnected_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload20 clknet_leaf_14_clk _unconnected_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload21 clknet_leaf_15_clk _unconnected_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload22 clknet_leaf_16_clk _unconnected_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload23 clknet_leaf_25_clk _unconnected_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_16
Xclkload24 clknet_leaf_26_clk _unconnected_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload25 clknet_leaf_28_clk _unconnected_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload26 clknet_leaf_29_clk _unconnected_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload27 clknet_leaf_30_clk _unconnected_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xclkload28 clknet_leaf_31_clk _unconnected_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload29 clknet_leaf_20_clk _unconnected_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload30 clknet_leaf_22_clk _unconnected_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkload31 clknet_leaf_23_clk _unconnected_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkload32 clknet_leaf_24_clk _unconnected_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
Xrebuffer1 _01076_ net160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xrebuffer2 net160 net161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer3 net160 net162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xsplit4 _02814_ net163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xrebuffer6 net164 net165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer7 _02747_ net166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xsplit10 _04824_ net169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer11 _05016_ net170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer12 net170 net171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer13 net170 net172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer14 net170 net173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer15 net173 net174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer17 net181 net176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer18 _01206_ net177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xsplit19 _02750_ net178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xsplit20 _02816_ net179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xsplit21 _01073_ net180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer23 net181 net182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer24 net181 net183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer25 net181 net184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer26 net181 net185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer27 _01076_ net186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xrebuffer29 _01588_ net188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer30 _01588_ net189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xrebuffer31 net189 net190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer32 _01588_ net191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xsplit33 _01608_ net192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xrebuffer34 _02811_ net193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer35 _01047_ net194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer36 _01047_ net195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xrebuffer37 net195 net196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer38 _01056_ net197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer39 _01097_ net198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer40 net198 net199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer41 _01342_ net200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer42 net200 net201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xrebuffer43 _01342_ net202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer44 net202 net203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xrebuffer45 net202 net204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xsplit46 _01207_ net205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xsplit47 _01078_ net206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xrebuffer48 _01358_ net207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer49 net207 net208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer50 net207 net209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer51 _01358_ net210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer52 net210 net211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xrebuffer53 _01048_ net212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer54 _01778_ net213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer55 net213 net214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer56 net213 net215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer57 _01075_ net216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer58 net269 net217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer59 net269 net218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer60 _05056_ net219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer61 net219 net220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xsplit63 _02750_ net222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xrebuffer71 _01032_ net230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer72 net230 net231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer73 net230 net232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer74 net232 net233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer78 _04992_ net237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer79 net237 net238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer92 _01073_ net251 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer93 _03350_ net252 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xrebuffer4 _01677_ net223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer9 net223 net224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer10 net224 net225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xsplit11 _01547_ net226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xrebuffer16 _01349_ net227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer19 _01349_ net228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer20 net228 net229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer21 net228 net234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer28 net234 net235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer33 _02030_ net236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer46 net236 net239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer47 net239 net240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer62 net240 net241 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xsplit64 _04815_ net242 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer65 _02228_ net243 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer66 _02814_ net244 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer67 _01085_ net245 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xrebuffer68 net245 net246 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer69 net245 net247 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer70 net247 net248 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xsplit71 _01548_ net249 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xrebuffer75 _02697_ net250 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer76 _02697_ net253 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer77 net253 net254 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer80 _02139_ net255 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer81 _01553_ net256 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xsplit82 _01324_ net257 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer83 _05064_ net258 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer84 net266 net259 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer85 _05064_ net260 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer86 _01547_ net261 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer87 _01049_ net262 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xsplit88 _04952_ net263 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xrebuffer90 _03649_ net265 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer91 _05064_ net266 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer94 _01142_ net267 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer95 _02971_ net268 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer96 _01075_ net269 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer97 _01062_ net270 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xsplit98 _02892_ net271 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer99 _01150_ net272 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer100 net272 net273 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer101 net273 net274 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
XANTENNA_1 _01588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_2 net157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_3 net153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
.ENDS riscv
