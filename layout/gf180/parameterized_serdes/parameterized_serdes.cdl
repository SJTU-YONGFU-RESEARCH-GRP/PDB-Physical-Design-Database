* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_serdes clk enable load mode parallel_in[0]
+ parallel_in[1] parallel_in[2] parallel_in[3] parallel_in[4]
+ parallel_in[5] parallel_in[6] parallel_in[7] parallel_out[0]
+ parallel_out[1] parallel_out[2] parallel_out[3] parallel_out[4]
+ parallel_out[5] parallel_out[6] parallel_out[7] rst_n rx_done
+ serial_in serial_out tx_done
X_084_ net3 _068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_085_ rx_bit_counter\[2\] _080_ rx_bit_counter\[3\] _069_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_086_ _068_ _069_ _070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_087_ rx_bit_counter\[2\] rx_bit_counter\[0\] rx_bit_counter\[1\]
+ _070_ _071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_088_ net2 net4 _072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_089_ _068_ net22 _072_ _073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_090_ rx_bit_counter\[3\] _071_ _073_ _000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_091_ net22 _074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_092_ net3 _069_ _075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_093_ _073_ _075_ _076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_094_ _074_ _072_ _076_ _001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_095_ _068_ net13 _077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_096_ rx_shift_reg\[0\] _077_ _076_ _002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_097_ _068_ rx_shift_reg\[0\] _078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_098_ rx_shift_reg\[1\] _078_ _076_ _003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_099_ _068_ rx_shift_reg\[1\] _079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_100_ rx_shift_reg\[2\] _079_ _076_ _004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_101_ _068_ rx_shift_reg\[2\] _033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_102_ rx_shift_reg\[3\] _033_ _076_ _005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_103_ _068_ rx_shift_reg\[3\] _034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_104_ rx_shift_reg\[4\] _034_ _076_ _006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_105_ _068_ rx_shift_reg\[4\] _035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_106_ rx_shift_reg\[5\] _035_ _076_ _007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_107_ _068_ rx_shift_reg\[5\] _036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_108_ rx_shift_reg\[6\] _036_ _076_ _008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_109_ net24 _037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_110_ net4 _038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_111_ net3 _037_ net2 _038_ _039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_112_ tx_bit_counter\[2\] _082_ net3 tx_bit_counter\[3\]
+ _040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_113_ net2 _038_ _037_ _040_ _041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_114_ tx_bit_counter\[0\] _042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_115_ _039_ _041_ _042_ _009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_116_ tx_bit_counter\[1\] _039_ _041_ _083_ _043_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_117_ _043_ _010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_118_ net2 _044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_119_ _068_ net24 _044_ net4 _045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_120_ _040_ _046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_121_ _082_ _045_ tx_bit_counter\[2\] _047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_122_ _045_ _046_ _047_ _011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_123_ tx_bit_counter\[2\] tx_bit_counter\[0\] tx_bit_counter\[1\]
+ _040_ _048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_124_ tx_bit_counter\[3\] _048_ _045_ _012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_125_ tx_bit_counter\[2\] _082_ _049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_126_ net2 _038_ _050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_127_ tx_bit_counter\[3\] _049_ _050_ _051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_128_ net3 _050_ _052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_129_ _052_ _053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_130_ _037_ _051_ _053_ _013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_131_ tx_shift_reg\[0\] net5 _053_ _014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_132_ tx_shift_reg\[1\] net6 _053_ _015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_133_ tx_shift_reg\[2\] net7 _053_ _016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_134_ tx_shift_reg\[3\] net8 _053_ _017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_135_ tx_shift_reg\[4\] net9 _053_ _018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_136_ tx_shift_reg\[5\] net10 _053_ _019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_137_ tx_shift_reg\[6\] net11 _053_ _020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_138_ tx_shift_reg\[7\] net12 _053_ _021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_139_ net22 _072_ _075_ _054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_140_ net13 net14 _054_ _022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_141_ rx_shift_reg\[0\] net15 _054_ _023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_142_ rx_shift_reg\[1\] net16 _054_ _024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_143_ rx_shift_reg\[2\] net17 _054_ _025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_144_ rx_shift_reg\[3\] net18 _054_ _026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_145_ rx_shift_reg\[4\] net19 _054_ _027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_146_ rx_shift_reg\[5\] net20 _054_ _028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_147_ rx_shift_reg\[6\] net21 _054_ _029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_148_ _073_ _070_ _055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_149_ _073_ _056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_150_ _055_ _056_ rx_bit_counter\[0\] _030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_151_ _081_ _070_ _057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_152_ rx_bit_counter\[1\] _057_ _073_ _031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_153_ _070_ _058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_154_ _080_ _073_ rx_bit_counter\[2\] _059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_155_ _073_ _058_ _059_ _032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_156_ tx_bit_counter\[3\] _060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_157_ tx_shift_reg\[3\] tx_shift_reg\[2\] tx_shift_reg\[1\]
+ tx_shift_reg\[0\] tx_bit_counter\[0\] tx_bit_counter\[1\]
+ _061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_158_ _061_ _062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_159_ tx_bit_counter\[2\] _062_ _063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_160_ tx_shift_reg\[7\] tx_shift_reg\[5\] tx_bit_counter\[1\]
+ _064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_161_ tx_bit_counter\[2\] tx_bit_counter\[0\] _064_ _065_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_162_ tx_shift_reg\[6\] tx_shift_reg\[4\] tx_bit_counter\[1\]
+ _066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_163_ tx_bit_counter\[2\] _042_ _066_ _067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_164_ _060_ _063_ _065_ _067_ net23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_165_ rx_bit_counter\[0\] rx_bit_counter\[1\] _080_ _081_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_166_ tx_bit_counter\[0\] tx_bit_counter\[1\] _082_ _083_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
Xparallel_out\[0\]$_DFFE_PN0P_ _022_ net1 clknet_2_0__leaf_clk
+ net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[1\]$_DFFE_PN0P_ _023_ net1 clknet_2_0__leaf_clk
+ net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[2\]$_DFFE_PN0P_ _024_ net1 clknet_2_1__leaf_clk
+ net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[3\]$_DFFE_PN0P_ _025_ net1 clknet_2_1__leaf_clk
+ net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[4\]$_DFFE_PN0P_ _026_ net1 clknet_2_1__leaf_clk
+ net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[5\]$_DFFE_PN0P_ _027_ net1 clknet_2_1__leaf_clk
+ net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[6\]$_DFFE_PN0P_ _028_ net1 clknet_2_1__leaf_clk
+ net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[7\]$_DFFE_PN0P_ _029_ net1 clknet_2_1__leaf_clk
+ net21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_bit_counter\[0\]$_DFFE_PN0P_ _030_ net1 clknet_2_0__leaf_clk
+ rx_bit_counter\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_bit_counter\[1\]$_DFFE_PN0P_ _031_ net1 clknet_2_0__leaf_clk
+ rx_bit_counter\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_bit_counter\[2\]$_DFFE_PN0P_ _032_ net1 clknet_2_0__leaf_clk
+ rx_bit_counter\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_bit_counter\[3\]$_DFFE_PN0P_ _000_ net1 clknet_2_2__leaf_clk
+ rx_bit_counter\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_done$_DFFE_PN0P_ _001_ net1 clknet_2_0__leaf_clk net22
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift_reg\[0\]$_DFFE_PN0P_ _002_ net1 clknet_2_0__leaf_clk
+ rx_shift_reg\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift_reg\[1\]$_DFFE_PN0P_ _003_ net1 clknet_2_0__leaf_clk
+ rx_shift_reg\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift_reg\[2\]$_DFFE_PN0P_ _004_ net1 clknet_2_1__leaf_clk
+ rx_shift_reg\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift_reg\[3\]$_DFFE_PN0P_ _005_ net1 clknet_2_1__leaf_clk
+ rx_shift_reg\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift_reg\[4\]$_DFFE_PN0P_ _006_ net1 clknet_2_1__leaf_clk
+ rx_shift_reg\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift_reg\[5\]$_DFFE_PN0P_ _007_ net1 clknet_2_1__leaf_clk
+ rx_shift_reg\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift_reg\[6\]$_DFFE_PN0P_ _008_ net1 clknet_2_1__leaf_clk
+ rx_shift_reg\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_bit_counter\[0\]$_DFFE_PN0P_ _009_ net1 clknet_2_2__leaf_clk
+ tx_bit_counter\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_bit_counter\[1\]$_DFFE_PN0P_ _010_ net1 clknet_2_3__leaf_clk
+ tx_bit_counter\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_bit_counter\[2\]$_DFFE_PN0P_ _011_ net1 clknet_2_2__leaf_clk
+ tx_bit_counter\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_bit_counter\[3\]$_DFFE_PN0P_ _012_ net1 clknet_2_2__leaf_clk
+ tx_bit_counter\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_done_reg$_DFFE_PN0P_ _013_ net1 clknet_2_2__leaf_clk net24
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift_reg\[0\]$_DFFE_PN0P_ _014_ net1 clknet_2_3__leaf_clk
+ tx_shift_reg\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift_reg\[1\]$_DFFE_PN0P_ _015_ net1 clknet_2_3__leaf_clk
+ tx_shift_reg\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift_reg\[2\]$_DFFE_PN0P_ _016_ net1 clknet_2_3__leaf_clk
+ tx_shift_reg\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift_reg\[3\]$_DFFE_PN0P_ _017_ net1 clknet_2_3__leaf_clk
+ tx_shift_reg\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift_reg\[4\]$_DFFE_PN0P_ _018_ net1 clknet_2_2__leaf_clk
+ tx_shift_reg\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift_reg\[5\]$_DFFE_PN0P_ _019_ net1 clknet_2_3__leaf_clk
+ tx_shift_reg\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift_reg\[6\]$_DFFE_PN0P_ _020_ net1 clknet_2_2__leaf_clk
+ tx_shift_reg\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift_reg\[7\]$_DFFE_PN0P_ _021_ net1 clknet_2_3__leaf_clk
+ tx_shift_reg\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xhold1 net25 net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 enable net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput2 load net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput3 mode net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput4 parallel_in[0] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput5 parallel_in[1] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput6 parallel_in[2] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput7 parallel_in[3] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput8 parallel_in[4] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput9 parallel_in[5] net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput10 parallel_in[6] net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput11 parallel_in[7] net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput12 serial_in net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput13 net14 parallel_out[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput14 net15 parallel_out[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput15 net16 parallel_out[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput16 net17 parallel_out[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput17 net18 parallel_out[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput18 net19 parallel_out[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput19 net20 parallel_out[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput20 net21 parallel_out[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput21 net22 rx_done VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput22 net23 serial_out VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput23 net24 tx_done VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_0__f_clk clknet_0_clk clknet_2_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_1__f_clk clknet_0_clk clknet_2_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_2__f_clk clknet_0_clk clknet_2_2__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_3__f_clk clknet_0_clk clknet_2_3__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkload0 clknet_2_0__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload1 clknet_2_2__leaf_clk _unconnected_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload2 clknet_2_3__leaf_clk _unconnected_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xhold2 rst_n net25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
.ENDS parameterized_serdes
