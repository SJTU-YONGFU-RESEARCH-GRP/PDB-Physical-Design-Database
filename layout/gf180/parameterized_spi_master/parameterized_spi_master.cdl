* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_spi_master clk rst_n rx_data[0] rx_data[1]
+ rx_data[2] rx_data[3] rx_data[4] rx_data[5] rx_data[6] rx_data[7]
+ rx_valid spi_clk spi_cs_n spi_miso spi_mosi tx_data[0] tx_data[1]
+ tx_data[2] tx_data[3] tx_data[4] tx_data[5] tx_data[6] tx_data[7]
+ tx_ready tx_valid
X_139_ bit_count\[3\] _122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_140_ _122_ bit_count\[2\] _037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_141_ _120_ _037_ _126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_142_ _126_ _133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_143_ state\[0\] _038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_144_ state\[1\] _038_ _039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_145_ _039_ _000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_146_ bit_count\[0\] _116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_147_ bit_count\[1\] _117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_148_ bit_count\[2\] _040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_149_ _040_ _116_ _117_ _123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_150_ bit_count\[3\] _123_ _136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_151_ state\[1\] _041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_152_ _041_ _042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_153_ _042_ _116_ _043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_154_ clk_divider\[2\] _044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_155_ _120_ net22 _045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_156_ _129_ net22 _046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_157_ bit_count\[3\] _040_ _045_ _046_ _047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_158_ _114_ _044_ _047_ _048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_159_ _116_ _043_ _048_ _049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_160_ state\[0\] net12 _042_ _050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_161_ bit_count\[0\] _050_ _051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_162_ _038_ _049_ _051_ _001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_163_ state\[0\] _114_ _044_ _052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_164_ _047_ _052_ _053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_165_ _042_ _119_ _053_ _054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_166_ _038_ net12 _117_ _053_ _055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_167_ state\[1\] bit_count\[1\] _056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_168_ _054_ _055_ _056_ _002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_169_ _038_ net12 _057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_170_ _129_ net22 _058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_171_ _041_ state\[0\] _114_ _044_ _059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_172_ _058_ _059_ _060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_173_ _053_ _057_ _060_ _120_ _042_ _061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_174_ _120_ _058_ _059_ _062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_175_ _061_ _062_ _040_ _003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_176_ _042_ _125_ _053_ _063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_177_ _038_ net12 _053_ _122_ _064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_178_ state\[1\] bit_count\[3\] _065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_179_ _063_ _064_ _065_ _004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_180_ _114_ _044_ clk_divider\[0\] _038_ _066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_181_ clk_divider\[0\] _066_ _042_ _005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_182_ _114_ _044_ _067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_183_ state\[0\] _115_ _067_ _068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_184_ clk_divider\[1\] _068_ _042_ _006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_185_ _038_ _114_ _042_ _069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_186_ clk_divider\[2\] _069_ _007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_187_ rx_shift\[0\] net13 _039_ _008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_188_ rx_shift\[1\] net14 _039_ _009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_189_ rx_shift\[2\] net15 _039_ _010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_190_ rx_shift\[3\] net16 _039_ _011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_191_ rx_shift\[4\] net17 _039_ _012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_192_ rx_shift\[5\] net18 _039_ _013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_193_ rx_shift\[6\] net19 _039_ _014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_194_ rx_shift\[7\] net20 _039_ _015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_195_ net22 _070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_196_ _128_ _138_ _071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_197_ _128_ _138_ _072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_198_ _124_ _137_ _072_ _073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_199_ _124_ _137_ _071_ _073_ _074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_200_ _119_ _075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_201_ bit_count\[0\] _075_ _076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_202_ bit_count\[2\] _120_ _077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_203_ _134_ _131_ _078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_204_ _128_ _125_ _079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_205_ _076_ _077_ _078_ _079_ _080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_206_ _070_ _059_ _074_ _080_ _081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_207_ rx_shift\[0\] net3 _081_ _016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_208_ _077_ _082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_209_ net22 _125_ _083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_210_ _059_ _082_ _083_ _084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_211_ _124_ _137_ _072_ _078_ _085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_212_ _116_ _119_ _085_ _086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_213_ _084_ _086_ _087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_214_ net3 rx_shift\[1\] _087_ _017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_215_ bit_count\[0\] _119_ _084_ _085_ _088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_216_ rx_shift\[2\] net3 _088_ _018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_217_ _116_ _075_ _089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_218_ _084_ _085_ _089_ _090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_219_ rx_shift\[3\] net3 _090_ _019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_220_ _076_ _084_ _085_ _091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_221_ rx_shift\[4\] net3 _091_ _020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_222_ _059_ _077_ _083_ _092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_223_ _086_ _092_ _093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_224_ net3 rx_shift\[5\] _093_ _021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_225_ bit_count\[0\] _119_ _085_ _092_ _094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_226_ rx_shift\[6\] net3 _094_ _022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_227_ _085_ _089_ _092_ _095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_228_ rx_shift\[7\] net3 _095_ _023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_229_ state\[1\] _067_ _096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_230_ net22 _096_ _097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_231_ state\[0\] _097_ _024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_232_ _042_ net12 _098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_233_ net23 _098_ _038_ _025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_234_ _041_ state\[0\] _099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_235_ net11 tx_shift\[6\] _099_ _100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_236_ _058_ _052_ _057_ _101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_237_ state\[1\] _101_ _102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_238_ net24 _100_ _102_ _026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_239_ bit_count\[3\] _040_ _070_ _118_ _103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_240_ _052_ _103_ _050_ _027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_241_ _059_ _103_ _028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_242_ net12 _104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_243_ _042_ _038_ _105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_244_ _104_ net25 _105_ _029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_245_ tx_shift\[0\] _106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_246_ _038_ net4 _107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_247_ _106_ _102_ _107_ _098_ _030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_248_ net5 tx_shift\[0\] _099_ _108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_249_ tx_shift\[1\] _108_ _102_ _031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_250_ net6 tx_shift\[1\] _099_ _109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_251_ tx_shift\[2\] _109_ _102_ _032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_252_ net7 tx_shift\[2\] _099_ _110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_253_ tx_shift\[3\] _110_ _102_ _033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_254_ net8 tx_shift\[3\] _099_ _111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_255_ tx_shift\[4\] _111_ _102_ _034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_256_ net9 tx_shift\[4\] _099_ _112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_257_ tx_shift\[5\] _112_ _102_ _035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_258_ net10 tx_shift\[5\] _099_ _113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_259_ tx_shift\[6\] _113_ _102_ _036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_260_ clk_divider\[0\] clk_divider\[1\] _114_ _115_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_2
X_261_ _116_ _117_ _118_ _119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_262_ bit_count\[0\] bit_count\[1\] _120_ _121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_263_ _122_ _123_ _124_ _125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_264_ _122_ _126_ _127_ _128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_265_ _122_ _126_ _129_ _130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_266_ bit_count\[3\] _126_ _131_ _132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_267_ bit_count\[3\] _133_ _134_ _135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_268_ _122_ _136_ _137_ _138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
Xbit_count\[0\]$_DFFE_PN0P_ _001_ net1 clknet_2_0__leaf_clk
+ bit_count\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_count\[1\]$_DFFE_PN0P_ _002_ net1 clknet_2_3__leaf_clk
+ bit_count\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_count\[2\]$_DFFE_PN0P_ _003_ net1 clknet_2_0__leaf_clk
+ bit_count\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_count\[3\]$_DFFE_PN0P_ _004_ net1 clknet_2_0__leaf_clk
+ bit_count\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_divider\[0\]$_DFFE_PN0P_ _005_ net1 clknet_2_1__leaf_clk
+ clk_divider\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_divider\[1\]$_DFFE_PN0P_ _006_ net1 clknet_2_0__leaf_clk
+ clk_divider\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_divider\[2\]$_DFFE_PN0P_ _007_ net1 clknet_2_1__leaf_clk
+ clk_divider\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[0\]$_DFFE_PN0P_ _008_ net1 clknet_2_2__leaf_clk
+ net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[1\]$_DFFE_PN0P_ _009_ net1 clknet_2_3__leaf_clk
+ net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[2\]$_DFFE_PN0P_ _010_ net1 clknet_2_2__leaf_clk
+ net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[3\]$_DFFE_PN0P_ _011_ net1 clknet_2_2__leaf_clk
+ net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[4\]$_DFFE_PN0P_ _012_ net1 clknet_2_2__leaf_clk
+ net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[5\]$_DFFE_PN0P_ _013_ net1 clknet_2_3__leaf_clk
+ net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[6\]$_DFFE_PN0P_ _014_ net1 clknet_2_3__leaf_clk
+ net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[7\]$_DFFE_PN0P_ _015_ net1 clknet_2_2__leaf_clk
+ net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift\[0\]$_DFFE_PN0P_ _016_ net1 clknet_2_2__leaf_clk
+ rx_shift\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift\[1\]$_DFFE_PN0P_ _017_ net1 clknet_2_0__leaf_clk
+ rx_shift\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift\[2\]$_DFFE_PN0P_ _018_ net1 clknet_2_2__leaf_clk
+ rx_shift\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift\[3\]$_DFFE_PN0P_ _019_ net1 clknet_2_2__leaf_clk
+ rx_shift\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift\[4\]$_DFFE_PN0P_ _020_ net1 clknet_2_2__leaf_clk
+ rx_shift\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift\[5\]$_DFFE_PN0P_ _021_ net1 clknet_2_3__leaf_clk
+ rx_shift\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift\[6\]$_DFFE_PN0P_ _022_ net1 clknet_2_3__leaf_clk
+ rx_shift\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_shift\[7\]$_DFFE_PN0P_ _023_ net1 clknet_2_2__leaf_clk
+ rx_shift\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_valid$_DFF_PN0_ _000_ net1 clknet_2_3__leaf_clk net21
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xspi_clk$_DFFE_PN0P_ _024_ net1 clknet_2_0__leaf_clk net22
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xspi_cs_n$_DFFE_PN1P_ _025_ net2 clknet_2_1__leaf_clk net23
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xspi_mosi$_DFFE_PN0P_ _026_ net1 clknet_2_3__leaf_clk net24
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xstate\[0\]$_DFFE_PN0P_ _027_ net1 clknet_2_1__leaf_clk state\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xstate\[1\]$_DFFE_PN0P_ _028_ net1 clknet_2_1__leaf_clk state\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_ready$_DFFE_PN1P_ _029_ net2 clknet_2_1__leaf_clk net25
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xtx_shift\[0\]$_DFFE_PN0P_ _030_ net1 clknet_2_1__leaf_clk
+ tx_shift\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[1\]$_DFFE_PN0P_ _031_ net1 clknet_2_1__leaf_clk
+ tx_shift\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[2\]$_DFFE_PN0P_ _032_ net1 clknet_2_1__leaf_clk
+ tx_shift\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[3\]$_DFFE_PN0P_ _033_ net1 clknet_2_3__leaf_clk
+ tx_shift\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[4\]$_DFFE_PN0P_ _034_ net1 clknet_2_3__leaf_clk
+ tx_shift\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[5\]$_DFFE_PN0P_ _035_ net1 clknet_2_3__leaf_clk
+ tx_shift\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[6\]$_DFFE_PN0P_ _036_ net1 clknet_2_3__leaf_clk
+ tx_shift\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xhold1 net2 net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 net26 net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput2 spi_miso net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput3 tx_data[0] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput4 tx_data[1] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput5 tx_data[2] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput6 tx_data[3] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput7 tx_data[4] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput8 tx_data[5] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput9 tx_data[6] net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput10 tx_data[7] net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput11 tx_valid net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xoutput12 net13 rx_data[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput13 net14 rx_data[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput14 net15 rx_data[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput15 net16 rx_data[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput16 net17 rx_data[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput17 net18 rx_data[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput18 net19 rx_data[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput19 net20 rx_data[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput20 net21 rx_valid VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput21 net22 spi_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput22 net23 spi_cs_n VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput23 net24 spi_mosi VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput24 net25 tx_ready VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_0__f_clk clknet_0_clk clknet_2_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_1__f_clk clknet_0_clk clknet_2_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_2__f_clk clknet_0_clk clknet_2_2__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_3__f_clk clknet_0_clk clknet_2_3__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkload0 clknet_2_0__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload1 clknet_2_1__leaf_clk _unconnected_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload2 clknet_2_2__leaf_clk _unconnected_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xhold2 rst_n net26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
.ENDS parameterized_spi_master
