* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT scan_register clk data_in[0] data_in[1] data_in[2]
+ data_in[3] data_in[4] data_in[5] data_in[6] data_in[7] data_out[0]
+ data_out[1] data_out[2] data_out[3] data_out[4] data_out[5]
+ data_out[6] data_out[7] rst_n scan_en scan_in scan_out
X_18_ scan_en VSS VSS VDD VDD _16_ sky130_fd_sc_hd__buf_6
X_19_ _16_ VSS VSS VDD VDD _17_ sky130_fd_sc_hd__buf_6
X_20_ scan_reg\[0\] net10 _17_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__mux2_1
X_21_ scan_reg\[1\] scan_reg\[0\] _17_ VSS VSS VDD VDD _01_
+ sky130_fd_sc_hd__mux2_1
X_22_ scan_reg\[2\] scan_reg\[1\] _17_ VSS VSS VDD VDD _02_
+ sky130_fd_sc_hd__mux2_1
X_23_ scan_reg\[3\] scan_reg\[2\] _17_ VSS VSS VDD VDD _03_
+ sky130_fd_sc_hd__mux2_1
X_24_ scan_reg\[4\] scan_reg\[3\] _17_ VSS VSS VDD VDD _04_
+ sky130_fd_sc_hd__mux2_1
X_25_ scan_reg\[5\] scan_reg\[4\] _17_ VSS VSS VDD VDD _05_
+ sky130_fd_sc_hd__mux2_1
X_26_ scan_reg\[6\] scan_reg\[5\] _17_ VSS VSS VDD VDD _06_
+ sky130_fd_sc_hd__mux2_1
X_27_ net19 scan_reg\[6\] _17_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__mux2_1
X_28_ net2 net10 _17_ VSS VSS VDD VDD _08_ sky130_fd_sc_hd__mux2_1
X_29_ net3 scan_reg\[0\] _17_ VSS VSS VDD VDD _09_ sky130_fd_sc_hd__mux2_1
X_30_ net4 scan_reg\[1\] _16_ VSS VSS VDD VDD _10_ sky130_fd_sc_hd__mux2_1
X_31_ net5 scan_reg\[2\] _16_ VSS VSS VDD VDD _11_ sky130_fd_sc_hd__mux2_1
X_32_ net6 scan_reg\[3\] _16_ VSS VSS VDD VDD _12_ sky130_fd_sc_hd__mux2_1
X_33_ net7 scan_reg\[4\] _16_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__mux2_1
X_34_ net8 scan_reg\[5\] _16_ VSS VSS VDD VDD _14_ sky130_fd_sc_hd__mux2_1
X_35_ net9 scan_reg\[6\] _16_ VSS VSS VDD VDD _15_ sky130_fd_sc_hd__mux2_1
Xdata_out\[0\]$_DFF_PN0_ clknet_1_0__leaf_clk _00_ net1 VSS
+ VSS VDD VDD net11 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[1\]$_DFF_PN0_ clknet_1_0__leaf_clk _01_ net1 VSS
+ VSS VDD VDD net12 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[2\]$_DFF_PN0_ clknet_1_0__leaf_clk _02_ net1 VSS
+ VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[3\]$_DFF_PN0_ clknet_1_0__leaf_clk _03_ net1 VSS
+ VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[4\]$_DFF_PN0_ clknet_1_1__leaf_clk _04_ net1 VSS
+ VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[5\]$_DFF_PN0_ clknet_1_1__leaf_clk _05_ net1 VSS
+ VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[6\]$_DFF_PN0_ clknet_1_1__leaf_clk _06_ net1 VSS
+ VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[7\]$_DFF_PN0_ clknet_1_1__leaf_clk _07_ net1 VSS
+ VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_1
Xscan_reg\[0\]$_DFF_PN0_ clknet_1_0__leaf_clk _08_ net1 VSS
+ VSS VDD VDD scan_reg\[0\] sky130_fd_sc_hd__dfrtp_1
Xscan_reg\[1\]$_DFF_PN0_ clknet_1_0__leaf_clk _09_ net1 VSS
+ VSS VDD VDD scan_reg\[1\] sky130_fd_sc_hd__dfrtp_1
Xscan_reg\[2\]$_DFF_PN0_ clknet_1_0__leaf_clk _10_ net1 VSS
+ VSS VDD VDD scan_reg\[2\] sky130_fd_sc_hd__dfrtp_1
Xscan_reg\[3\]$_DFF_PN0_ clknet_1_1__leaf_clk _11_ net1 VSS
+ VSS VDD VDD scan_reg\[3\] sky130_fd_sc_hd__dfrtp_1
Xscan_reg\[4\]$_DFF_PN0_ clknet_1_1__leaf_clk _12_ net1 VSS
+ VSS VDD VDD scan_reg\[4\] sky130_fd_sc_hd__dfrtp_1
Xscan_reg\[5\]$_DFF_PN0_ clknet_1_1__leaf_clk _13_ net1 VSS
+ VSS VDD VDD scan_reg\[5\] sky130_fd_sc_hd__dfrtp_1
Xscan_reg\[6\]$_DFF_PN0_ clknet_1_1__leaf_clk _14_ net1 VSS
+ VSS VDD VDD scan_reg\[6\] sky130_fd_sc_hd__dfrtp_1
Xscan_reg\[7\]$_DFF_PN0_ clknet_1_1__leaf_clk _15_ net1 VSS
+ VSS VDD VDD net19 sky130_fd_sc_hd__dfrtp_1
Xhold1 net20 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 data_in[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 data_in[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 data_in[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 data_in[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 data_in[4] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 data_in[5] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 data_in[6] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 data_in[7] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 scan_in VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xoutput10 net11 VSS VSS VDD VDD data_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput11 net12 VSS VSS VDD VDD data_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD data_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD data_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD data_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD data_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD data_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD data_out[7] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD scan_out sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_8
Xhold2 rst_n VSS VSS VDD VDD net20 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS scan_register
