* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT final_spi_master clk rst_n rx_data[0] rx_data[1] rx_data[2]
+ rx_data[3] rx_data[4] rx_data[5] rx_data[6] rx_data[7] rx_valid
+ spi_clk spi_cs_n spi_miso spi_mosi tx_data[0] tx_data[1] tx_data[2]
+ tx_data[3] tx_data[4] tx_data[5] tx_data[6] tx_data[7] tx_ready
+ tx_valid
X_131_ bit_counter\[2\] _108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_132_ _126_ _109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_133_ bit_counter\[3\] _108_ _109_ _113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_134_ _113_ _120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_135_ state\[0\] _110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_136_ state\[1\] _110_ _111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_137_ _111_ _000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_138_ bit_counter\[3\] _112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_139_ bit_counter\[2\] bit_counter\[1\] bit_counter\[0\]
+ _128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_140_ bit_counter\[3\] _128_ _123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_141_ net22 bit_counter\[3\] _034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_142_ state\[1\] _035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_143_ _110_ _034_ _035_ _036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_144_ _036_ _037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_145_ _035_ state\[0\] _034_ _038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_146_ bit_counter\[0\] _039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_147_ _037_ _038_ _039_ _001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_148_ bit_counter\[1\] _037_ _038_ _127_ _040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_149_ _040_ _002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_150_ _109_ _038_ _037_ _041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_151_ _108_ _126_ _038_ _042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_152_ _108_ _041_ _042_ _003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_153_ _130_ _043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_154_ state\[1\] net22 _043_ _044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_155_ _035_ _110_ _045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_156_ _112_ _044_ _045_ _004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_157_ _127_ _046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_158_ _115_ _046_ _130_ _047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_159_ bit_counter\[2\] _126_ _048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_160_ _121_ _118_ _049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_161_ _039_ _048_ _049_ _050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_162_ _124_ _129_ _051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_163_ _115_ _125_ _052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_164_ _124_ _129_ _053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_165_ _115_ _125_ _054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_166_ _051_ _052_ _053_ _054_ _055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_167_ _047_ _050_ _055_ _056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_168_ miso_capture\[0\] _038_ _057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_169_ _035_ state\[0\] net3 _034_ _058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_170_ _047_ _050_ _055_ _058_ _059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_171_ miso_capture\[0\] _037_ _060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_172_ _056_ _057_ _059_ _060_ _005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_173_ _043_ _048_ _061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_174_ _051_ _052_ _062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_175_ bit_counter\[0\] _049_ _062_ _058_ _063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_176_ state\[1\] state\[0\] _064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_177_ miso_capture\[1\] _064_ _065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_178_ _112_ _039_ _066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_179_ _046_ _036_ _066_ _061_ _067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_180_ _046_ _061_ _063_ _065_ _067_ _006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_181_ _121_ _118_ _068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_182_ bit_counter\[0\] _127_ _069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_183_ _068_ _051_ _052_ _069_ _070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_184_ miso_capture\[2\] _064_ _071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_185_ _037_ _061_ _070_ _071_ _072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_186_ _058_ _061_ _070_ _072_ _007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_187_ bit_counter\[2\] _126_ _073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_188_ _127_ _130_ _073_ _074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_189_ _066_ _074_ miso_capture\[3\] _038_ _075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_190_ miso_capture\[3\] _037_ _076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_191_ _063_ _074_ _075_ _076_ _008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_192_ miso_capture\[4\] _038_ _077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_193_ bit_counter\[0\] _068_ _078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_194_ _078_ _062_ _074_ _079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_195_ _078_ _062_ _058_ _074_ _080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_196_ miso_capture\[4\] _037_ _081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_197_ _077_ _079_ _080_ _081_ _009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_198_ _043_ _073_ _082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_199_ _046_ _037_ _066_ _082_ _083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_200_ miso_capture\[5\] _064_ _084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_201_ _046_ _063_ _082_ _083_ _084_ _010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_202_ miso_capture\[6\] _064_ _085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_203_ _037_ _070_ _082_ _085_ _086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_204_ _058_ _070_ _082_ _086_ _011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_205_ _127_ _130_ _048_ _087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_206_ miso_capture\[7\] _064_ _088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_207_ _037_ _066_ _087_ _088_ _089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_208_ _063_ _087_ _089_ _012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_209_ miso_capture\[0\] net13 _111_ _013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_210_ miso_capture\[1\] net14 _111_ _014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_211_ miso_capture\[2\] net15 _111_ _015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_212_ miso_capture\[3\] net16 _111_ _016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_213_ miso_capture\[4\] net17 _111_ _017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_214_ miso_capture\[5\] net18 _111_ _018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_215_ miso_capture\[6\] net19 _111_ _019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_216_ miso_capture\[7\] net20 _111_ _020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_217_ state\[1\] net22 _090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_218_ state\[0\] _090_ _021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_219_ net23 _091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_220_ state\[0\] _091_ _045_ net12 _022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_221_ _035_ state\[0\] _092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_222_ net11 tx_shift\[6\] _092_ _093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_223_ net22 _116_ _094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_224_ net12 _094_ state\[0\] _095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_225_ _035_ _095_ _096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_226_ net24 _093_ _096_ _023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_227_ _110_ net22 _113_ _097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_228_ net12 _098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_229_ _110_ _098_ _099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_230_ _035_ _097_ _099_ _024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_231_ bit_counter\[2\] _126_ _038_ _025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_232_ _098_ net25 _064_ _026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_233_ tx_shift\[0\] _100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_234_ net12 net4 _045_ _101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_235_ _100_ _096_ _101_ _027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_236_ net5 tx_shift\[0\] _092_ _102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_237_ tx_shift\[1\] _102_ _096_ _028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_238_ net6 tx_shift\[1\] _092_ _103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_239_ tx_shift\[2\] _103_ _096_ _029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_240_ net7 tx_shift\[2\] _092_ _104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_241_ tx_shift\[3\] _104_ _096_ _030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_242_ net8 tx_shift\[3\] _092_ _105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_243_ tx_shift\[4\] _105_ _096_ _031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_244_ net9 tx_shift\[4\] _092_ _106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_245_ tx_shift\[5\] _106_ _096_ _032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_246_ net10 tx_shift\[5\] _092_ _107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_247_ tx_shift\[6\] _107_ _096_ _033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_248_ _112_ _113_ _114_ _115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_249_ _112_ _113_ _116_ _117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_250_ bit_counter\[3\] _113_ _118_ _119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_251_ bit_counter\[3\] _120_ _121_ _122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_252_ _112_ _123_ _124_ _125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_253_ bit_counter\[0\] bit_counter\[1\] _126_ _127_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_2
X_254_ _112_ _128_ _129_ _130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
Xbit_counter\[0\]$_DFFE_PN0P_ _001_ net1 clknet_2_1__leaf_clk
+ bit_counter\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_counter\[1\]$_DFFE_PN0P_ _002_ net1 clknet_2_1__leaf_clk
+ bit_counter\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_counter\[2\]$_DFFE_PN0P_ _003_ net1 clknet_2_1__leaf_clk
+ bit_counter\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_counter\[3\]$_DFFE_PN0P_ _004_ net1 clknet_2_0__leaf_clk
+ bit_counter\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmiso_capture\[0\]$_DFFE_PN0P_ _005_ net1 clknet_2_1__leaf_clk
+ miso_capture\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmiso_capture\[1\]$_DFFE_PN0P_ _006_ net1 clknet_2_3__leaf_clk
+ miso_capture\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmiso_capture\[2\]$_DFFE_PN0P_ _007_ net1 clknet_2_2__leaf_clk
+ miso_capture\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmiso_capture\[3\]$_DFFE_PN0P_ _008_ net1 clknet_2_3__leaf_clk
+ miso_capture\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmiso_capture\[4\]$_DFFE_PN0P_ _009_ net1 clknet_2_3__leaf_clk
+ miso_capture\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmiso_capture\[5\]$_DFFE_PN0P_ _010_ net1 clknet_2_3__leaf_clk
+ miso_capture\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmiso_capture\[6\]$_DFFE_PN0P_ _011_ net1 clknet_2_2__leaf_clk
+ miso_capture\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmiso_capture\[7\]$_DFFE_PN0P_ _012_ net1 clknet_2_3__leaf_clk
+ miso_capture\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[0\]$_DFFE_PN0P_ _013_ net1 clknet_2_1__leaf_clk
+ net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[1\]$_DFFE_PN0P_ _014_ net1 clknet_2_3__leaf_clk
+ net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[2\]$_DFFE_PN0P_ _015_ net1 clknet_2_2__leaf_clk
+ net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[3\]$_DFFE_PN0P_ _016_ net1 clknet_2_3__leaf_clk
+ net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[4\]$_DFFE_PN0P_ _017_ net1 clknet_2_3__leaf_clk
+ net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[5\]$_DFFE_PN0P_ _018_ net1 clknet_2_3__leaf_clk
+ net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[6\]$_DFFE_PN0P_ _019_ net1 clknet_2_2__leaf_clk
+ net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_data\[7\]$_DFFE_PN0P_ _020_ net1 clknet_2_3__leaf_clk
+ net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_valid$_DFF_PN0_ _000_ net1 clknet_2_3__leaf_clk net21
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xspi_clk$_DFFE_PN0P_ _021_ net1 clknet_2_0__leaf_clk net22
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xspi_cs_n$_DFFE_PN1P_ _022_ net2 clknet_2_0__leaf_clk net23
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xspi_mosi$_DFFE_PN0P_ _023_ net1 clknet_2_2__leaf_clk net24
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xstate\[0\]$_DFFE_PN0P_ _024_ net1 clknet_2_0__leaf_clk state\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xstate\[1\]$_DFFE_PN0P_ _025_ net1 clknet_2_1__leaf_clk state\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_ready$_DFFE_PN1P_ _026_ net2 clknet_2_0__leaf_clk net25
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xtx_shift\[0\]$_DFFE_PN0P_ _027_ net1 clknet_2_0__leaf_clk
+ tx_shift\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[1\]$_DFFE_PN0P_ _028_ net1 clknet_2_0__leaf_clk
+ tx_shift\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[2\]$_DFFE_PN0P_ _029_ net1 clknet_2_0__leaf_clk
+ tx_shift\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[3\]$_DFFE_PN0P_ _030_ net1 clknet_2_2__leaf_clk
+ tx_shift\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[4\]$_DFFE_PN0P_ _031_ net1 clknet_2_2__leaf_clk
+ tx_shift\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[5\]$_DFFE_PN0P_ _032_ net1 clknet_2_2__leaf_clk
+ tx_shift\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx_shift\[6\]$_DFFE_PN0P_ _033_ net1 clknet_2_2__leaf_clk
+ tx_shift\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xhold1 net2 net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 net26 net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput2 spi_miso net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput3 tx_data[0] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput4 tx_data[1] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput5 tx_data[2] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput6 tx_data[3] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput7 tx_data[4] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput8 tx_data[5] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput9 tx_data[6] net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput10 tx_data[7] net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput11 tx_valid net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xoutput12 net13 rx_data[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput13 net14 rx_data[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput14 net15 rx_data[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput15 net16 rx_data[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput16 net17 rx_data[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput17 net18 rx_data[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput18 net19 rx_data[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput19 net20 rx_data[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput20 net21 rx_valid VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput21 net22 spi_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput22 net23 spi_cs_n VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput23 net24 spi_mosi VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput24 net25 tx_ready VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_0__f_clk clknet_0_clk clknet_2_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_1__f_clk clknet_0_clk clknet_2_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_2__f_clk clknet_0_clk clknet_2_2__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_2_3__f_clk clknet_0_clk clknet_2_3__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkload0 clknet_2_0__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload1 clknet_2_1__leaf_clk _unconnected_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xclkload2 clknet_2_2__leaf_clk _unconnected_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xhold2 rst_n net26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
.ENDS final_spi_master
