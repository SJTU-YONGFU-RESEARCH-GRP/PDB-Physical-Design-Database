* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT alu a[0] a[1] a[2] a[3] a[4] a[5] a[6] a[7] b[0] b[1]
+ b[2] b[3] b[4] b[5] b[6] b[7] clk op_code[0] op_code[1] op_code[2]
+ overflow_flag result[0] result[1] result[2] result[3] result[4]
+ result[5] result[6] result[7] rst_n zero_flag
X_347_ net1 _287_ VDD VSS INV_X1
X_348_ net2 _260_ VDD VSS BUF_X2
X_349_ _260_ _282_ VDD VSS INV_X1
X_350_ net3 _261_ VDD VSS BUF_X4
X_351_ _261_ _301_ VDD VSS INV_X1
X_352_ net4 _262_ VDD VSS BUF_X2
X_353_ _262_ _309_ VDD VSS INV_X1
X_354_ net5 _263_ VDD VSS BUF_X2
X_355_ _263_ _317_ VDD VSS INV_X1
X_356_ net6 _264_ VDD VSS CLKBUF_X2
X_357_ _264_ _325_ VDD VSS INV_X1
X_358_ net7 _265_ VDD VSS CLKBUF_X2
X_359_ _265_ _333_ VDD VSS INV_X1
X_360_ net8 _266_ VDD VSS CLKBUF_X2
X_361_ _266_ _341_ VDD VSS INV_X1
X_362_ net9 _267_ VDD VSS BUF_X8
X_363_ _267_ _268_ VDD VSS BUF_X4
X_364_ _268_ _288_ VDD VSS INV_X2
X_365_ net10 _010_ VDD VSS BUF_X2
X_366_ _010_ _011_ VDD VSS INV_X2
X_367_ _011_ _295_ VDD VSS BUF_X4
X_368_ net11 _012_ VDD VSS INV_X1
X_369_ _012_ _302_ VDD VSS BUF_X4
X_370_ net12 _310_ VDD VSS INV_X1
X_371_ net13 _318_ VDD VSS INV_X1
X_372_ net14 _326_ VDD VSS INV_X1
X_373_ net15 _334_ VDD VSS INV_X1
X_374_ net16 _342_ VDD VSS INV_X1
X_375_ rst_n _013_ VDD VSS CLKBUF_X2
X_376_ op_code[2] _014_ VDD VSS BUF_X4
X_377_ _014_ _015_ VDD VSS BUF_X4
X_378_ op_code[1] _016_ VDD VSS BUF_X2
X_379_ _016_ _017_ VDD VSS BUF_X4
X_380_ op_code[0] _018_ VDD VSS BUF_X2
X_381_ _018_ _019_ VDD VSS BUF_X4
X_382_ _015_ _017_ _019_ _020_ VDD VSS NOR3_X4
X_383_ _345_ _020_ _021_ VDD VSS NAND2_X1
X_384_ _344_ _022_ VDD VSS BUF_X2
X_385_ _019_ _023_ VDD VSS CLKBUF_X3
X_386_ _014_ _016_ _024_ VDD VSS NOR2_X1
X_387_ _023_ _024_ _025_ VDD VSS AND2_X1
X_388_ _022_ _025_ _026_ VDD VSS NAND2_X1
X_389_ _337_ _027_ VDD VSS INV_X1
X_390_ _312_ _028_ VDD VSS CLKBUF_X3
X_391_ _320_ _029_ VDD VSS CLKBUF_X3
X_392_ _336_ _030_ VDD VSS BUF_X2
X_393_ _028_ _029_ _328_ _030_ _031_ VDD VSS NOR4_X2
X_394_ _031_ _032_ VDD VSS INV_X1
X_395_ _304_ _033_ VDD VSS BUF_X4
X_396_ _033_ _034_ VDD VSS INV_X1
X_397_ _286_ _283_ _035_ VDD VSS NOR2_X1
X_398_ _297_ _305_ _036_ VDD VSS OR2_X1
X_399_ _034_ _305_ _035_ _036_ _037_ VDD VSS OAI22_X4
X_400_ _027_ _032_ _037_ _038_ VDD VSS OAI21_X1
X_401_ _329_ _039_ VDD VSS INV_X1
X_402_ _029_ _040_ VDD VSS INV_X1
X_403_ _321_ _040_ _313_ _041_ VDD VSS AOI21_X1
X_404_ _328_ _042_ VDD VSS CLKBUF_X3
X_405_ _039_ _041_ _042_ _043_ VDD VSS OAI21_X1
X_406_ _030_ _044_ VDD VSS INV_X1
X_407_ _038_ _043_ _044_ _045_ VDD VSS AOI21_X2
X_408_ _341_ _045_ _046_ VDD VSS XNOR2_X1
X_409_ _339_ _047_ VDD VSS CLKBUF_X2
X_410_ _331_ _048_ VDD VSS INV_X1
X_411_ _280_ _033_ _028_ _049_ VDD VSS NAND3_X1
X_412_ _307_ _050_ VDD VSS CLKBUF_X2
X_413_ _315_ _028_ _050_ _051_ VDD VSS AOI21_X1
X_414_ _040_ _049_ _051_ _052_ VDD VSS AOI21_X1
X_415_ _042_ _052_ _323_ _053_ VDD VSS OAI21_X1
X_416_ _048_ _053_ _054_ VDD VSS NAND2_X1
X_417_ _047_ _054_ _030_ _055_ VDD VSS AOI21_X1
X_418_ _022_ _020_ _056_ VDD VSS NAND2_X1
X_419_ _021_ _026_ _046_ _055_ _056_ _057_ VDD VSS OAI221_X1
X_420_ _013_ _057_ _000_ VDD VSS AND2_X1
X_421_ _290_ _058_ VDD VSS CLKBUF_X2
X_422_ _058_ _033_ _286_ _022_ _059_ VDD VSS NOR4_X1
X_423_ _031_ _059_ _060_ VDD VSS NAND2_X1
X_424_ _017_ _061_ VDD VSS CLKBUF_X3
X_425_ _061_ _023_ _062_ VDD VSS NAND2_X1
X_426_ _015_ _060_ _062_ _063_ VDD VSS OAI21_X1
X_427_ _019_ _279_ _064_ VDD VSS NOR2_X1
X_428_ _064_ _289_ _023_ _065_ VDD VSS AOI21_X1
X_429_ _058_ _065_ _061_ _066_ VDD VSS MUX2_X1
X_430_ _063_ _066_ _015_ _067_ VDD VSS OAI21_X1
X_431_ _018_ _068_ VDD VSS INV_X4
X_432_ _014_ _017_ _068_ _069_ VDD VSS NAND3_X2
X_433_ net11 _070_ VDD VSS CLKBUF_X3
X_434_ _261_ _262_ _268_ _071_ VDD VSS MUX2_X1
X_435_ _295_ _071_ _072_ VDD VSS NOR2_X1
X_436_ net1 _260_ _268_ _073_ VDD VSS MUX2_X1
X_437_ _010_ _073_ _074_ VDD VSS NOR2_X1
X_438_ _070_ _072_ _074_ _075_ VDD VSS NOR3_X1
X_439_ _265_ _266_ _267_ _076_ VDD VSS MUX2_X1
X_440_ _263_ _264_ _267_ _077_ VDD VSS MUX2_X1
X_441_ _076_ _077_ _295_ _078_ VDD VSS MUX2_X1
X_442_ _075_ _078_ _070_ _079_ VDD VSS AOI21_X1
X_443_ _010_ _070_ _080_ VDD VSS OR2_X1
X_444_ _014_ _018_ _081_ VDD VSS NAND2_X2
X_445_ _080_ _081_ _082_ VDD VSS NOR2_X1
X_446_ _068_ _058_ _292_ _082_ _083_ VDD VSS AOI22_X1
X_447_ _067_ _069_ _079_ _083_ _061_ _084_ VDD VSS OAI221_X1
X_448_ _013_ _084_ _001_ VDD VSS AND2_X1
X_449_ _013_ _085_ VDD VSS INV_X2
X_450_ _010_ _070_ _086_ VDD VSS NOR2_X2
X_451_ _016_ _081_ _087_ VDD VSS NOR2_X4
X_452_ _260_ net1 _267_ _088_ VDD VSS MUX2_X1
X_453_ _086_ _087_ _088_ _089_ VDD VSS NAND3_X1
X_454_ _015_ _023_ _285_ _090_ VDD VSS AOI21_X1
X_455_ _090_ _286_ _068_ _091_ VDD VSS AOI21_X1
X_456_ _014_ _092_ VDD VSS INV_X1
X_457_ _092_ _017_ _093_ VDD VSS NAND2_X1
X_458_ _023_ _296_ _094_ VDD VSS NAND2_X1
X_459_ _094_ _299_ _023_ _095_ VDD VSS OAI21_X1
X_460_ _089_ _091_ _061_ _093_ _095_ _096_ VDD VSS OAI221_X1
X_461_ _268_ _341_ _097_ VDD VSS NOR2_X1
X_462_ _264_ _265_ _268_ _098_ VDD VSS MUX2_X1
X_463_ _097_ _098_ _295_ _099_ VDD VSS MUX2_X1
X_464_ _262_ _263_ _268_ _100_ VDD VSS MUX2_X1
X_465_ _260_ _261_ _268_ _101_ VDD VSS MUX2_X1
X_466_ _100_ _101_ _295_ _102_ VDD VSS MUX2_X1
X_467_ _099_ _102_ _302_ _103_ VDD VSS MUX2_X1
X_468_ _069_ _104_ VDD VSS INV_X1
X_469_ _096_ _103_ _104_ _105_ VDD VSS AOI21_X1
X_470_ _068_ _024_ _106_ VDD VSS NAND2_X1
X_471_ _281_ _106_ _107_ VDD VSS NOR2_X1
X_472_ _085_ _105_ _107_ _002_ VDD VSS NOR3_X1
X_473_ _295_ _070_ _076_ _108_ VDD VSS AND3_X1
X_474_ _295_ _070_ _109_ VDD VSS NOR2_X1
X_475_ _108_ _109_ _077_ _071_ _086_ _110_ VDD VSS AOI221_X2
X_476_ _069_ _110_ _111_ VDD VSS NOR2_X1
X_477_ _023_ _034_ _015_ _112_ VDD VSS AOI21_X1
X_478_ _070_ _081_ _113_ VDD VSS NOR2_X1
X_479_ _261_ _260_ _267_ _114_ VDD VSS MUX2_X1
X_480_ _292_ _114_ _011_ _115_ VDD VSS MUX2_X1
X_481_ _112_ _113_ _115_ _116_ VDD VSS AOI21_X1
X_482_ _019_ _050_ _117_ VDD VSS NOR2_X1
X_483_ _117_ _303_ _023_ _118_ VDD VSS AOI21_X1
X_484_ _033_ _284_ _119_ VDD VSS XOR2_X2
X_485_ _061_ _068_ _120_ VDD VSS NOR2_X1
X_486_ _061_ _118_ _119_ _120_ _121_ VDD VSS AOI22_X1
X_487_ _061_ _116_ _121_ _015_ _122_ VDD VSS OAI22_X1
X_488_ _280_ _033_ _123_ VDD VSS XOR2_X2
X_489_ _013_ _111_ _122_ _123_ _106_ _124_ VDD VSS OAI221_X1
X_490_ _124_ _003_ VDD VSS INV_X1
X_491_ _019_ _024_ _125_ VDD VSS NAND2_X1
X_492_ _028_ _037_ _126_ VDD VSS XNOR2_X1
X_493_ _125_ _126_ _127_ VDD VSS NOR2_X1
X_494_ _262_ _261_ _267_ _128_ VDD VSS MUX2_X1
X_495_ _088_ _128_ _011_ _129_ VDD VSS MUX2_X1
X_496_ _302_ _087_ _129_ _130_ VDD VSS NAND3_X1
X_497_ _092_ _017_ _019_ _131_ VDD VSS NAND3_X2
X_498_ _315_ _132_ VDD VSS INV_X1
X_499_ _015_ _017_ _132_ _133_ VDD VSS AOI21_X1
X_500_ _016_ _134_ VDD VSS INV_X2
X_501_ _133_ _028_ _134_ _135_ VDD VSS AOI21_X1
X_502_ _130_ _131_ _311_ _023_ _135_ _136_ VDD VSS OAI221_X1
X_503_ _127_ _136_ _137_ VDD VSS NOR2_X1
X_504_ _070_ _288_ _266_ _138_ VDD VSS NAND3_X1
X_505_ _302_ _100_ _139_ VDD VSS NAND2_X1
X_506_ _010_ _138_ _139_ _140_ VDD VSS AOI21_X1
X_507_ _140_ _109_ _098_ _141_ VDD VSS AOI21_X1
X_508_ _069_ _141_ _142_ VDD VSS OR2_X1
X_509_ _050_ _143_ VDD VSS INV_X1
X_510_ _299_ _279_ _286_ _144_ VDD VSS AOI21_X2
X_511_ _143_ _144_ _034_ _145_ VDD VSS OAI21_X1
X_512_ _028_ _145_ _146_ VDD VSS XNOR2_X1
X_513_ _085_ _137_ _142_ _146_ _020_ _004_ VDD VSS AOI221_X1
X_514_ _305_ _147_ VDD VSS INV_X1
X_515_ _033_ _284_ _148_ VDD VSS OR2_X1
X_516_ _028_ _147_ _148_ _149_ VDD VSS AOI21_X1
X_517_ _313_ _149_ _150_ VDD VSS NOR2_X1
X_518_ _029_ _150_ _151_ VDD VSS XNOR2_X1
X_519_ _125_ _151_ _152_ VDD VSS OR2_X1
X_520_ _323_ _153_ VDD VSS INV_X1
X_521_ _014_ _017_ _153_ _154_ VDD VSS AOI21_X1
X_522_ _154_ _029_ _134_ _155_ VDD VSS AOI21_X1
X_523_ _319_ _131_ _155_ _019_ _156_ VDD VSS OAI22_X2
X_524_ _070_ _069_ _157_ VDD VSS NOR2_X1
X_525_ _011_ _302_ _114_ _158_ VDD VSS AOI21_X1
X_526_ _263_ _262_ _267_ _159_ VDD VSS MUX2_X1
X_527_ _292_ _302_ _080_ _159_ _160_ VDD VSS OAI22_X1
X_528_ _158_ _160_ _161_ VDD VSS NOR2_X1
X_529_ _156_ _157_ _078_ _087_ _161_ _162_ VDD VSS AOI221_X2
X_530_ _040_ _049_ _051_ _163_ VDD VSS AND3_X1
X_531_ _052_ _163_ _164_ VDD VSS OR2_X1
X_532_ _085_ _152_ _162_ _164_ _020_ _005_ VDD VSS AOI221_X1
X_533_ _323_ _029_ _315_ _165_ VDD VSS AOI21_X1
X_534_ _033_ _028_ _029_ _166_ VDD VSS NAND3_X1
X_535_ _050_ _028_ _167_ VDD VSS NAND2_X1
X_536_ _165_ _166_ _144_ _167_ _040_ _168_ VDD VSS OAI221_X2
X_537_ _042_ _168_ _169_ VDD VSS XOR2_X1
X_538_ _013_ _106_ _169_ _170_ VDD VSS OAI21_X1
X_539_ _099_ _157_ _171_ VDD VSS NAND2_X1
X_540_ _014_ _017_ _048_ _172_ VDD VSS AOI21_X1
X_541_ _172_ _042_ _134_ _173_ VDD VSS AOI21_X1
X_542_ _171_ _131_ _327_ _023_ _173_ _174_ VDD VSS OAI221_X2
X_543_ _313_ _175_ VDD VSS INV_X1
X_544_ _175_ _037_ _028_ _176_ VDD VSS OAI21_X1
X_545_ _321_ _176_ _040_ _177_ VDD VSS AOI21_X2
X_546_ _042_ _177_ _178_ VDD VSS XOR2_X2
X_547_ _012_ _128_ _179_ VDD VSS AND2_X1
X_548_ _264_ _263_ _267_ _180_ VDD VSS MUX2_X1
X_549_ _088_ _180_ _012_ _181_ VDD VSS MUX2_X1
X_550_ _179_ _181_ _011_ _182_ VDD VSS MUX2_X1
X_551_ _174_ _178_ _025_ _087_ _182_ _183_ VDD VSS AOI221_X2
X_552_ _170_ _183_ _006_ VDD VSS NOR2_X1
X_553_ _019_ _080_ _184_ VDD VSS NOR2_X1
X_554_ _015_ _076_ _184_ _185_ VDD VSS NAND3_X1
X_555_ _092_ _019_ _186_ VDD VSS NAND2_X1
X_556_ _185_ _186_ _335_ _187_ VDD VSS OAI21_X1
X_557_ _092_ _134_ _047_ _188_ VDD VSS OAI21_X1
X_558_ _188_ _044_ _017_ _189_ VDD VSS OAI21_X1
X_559_ _265_ _264_ _267_ _190_ VDD VSS MUX2_X1
X_560_ _159_ _190_ _011_ _191_ VDD VSS MUX2_X1
X_561_ _115_ _191_ _302_ _192_ VDD VSS MUX2_X1
X_562_ _061_ _187_ _189_ _068_ _192_ _087_ _193_ VDD VSS AOI222_X2
X_563_ _305_ _313_ _194_ VDD VSS NOR2_X1
X_564_ _029_ _148_ _194_ _175_ _312_ _195_ VDD VSS AOI221_X2
X_565_ _321_ _195_ _196_ VDD VSS NOR2_X1
X_566_ _039_ _196_ _042_ _197_ VDD VSS OAI21_X1
X_567_ _044_ _197_ _198_ VDD VSS XNOR2_X1
X_568_ _125_ _198_ _199_ VDD VSS OR2_X1
X_569_ _030_ _054_ _200_ VDD VSS XNOR2_X1
X_570_ _085_ _193_ _199_ _200_ _020_ _007_ VDD VSS AOI221_X1
X_571_ _042_ _030_ _168_ _201_ VDD VSS NAND3_X1
X_572_ _047_ _030_ _331_ _202_ VDD VSS AOI21_X2
X_573_ _201_ _202_ _203_ VDD VSS NAND2_X1
X_574_ _022_ _203_ _204_ VDD VSS XNOR2_X1
X_575_ _015_ _097_ _184_ _205_ VDD VSS NAND3_X1
X_576_ _205_ _186_ _343_ _206_ VDD VSS OAI21_X1
X_577_ _092_ _134_ _345_ _207_ VDD VSS OAI21_X1
X_578_ _022_ _208_ VDD VSS INV_X1
X_579_ _207_ _208_ _061_ _209_ VDD VSS OAI21_X1
X_580_ _266_ _265_ _267_ _210_ VDD VSS MUX2_X1
X_581_ _180_ _210_ _011_ _211_ VDD VSS MUX2_X1
X_582_ _129_ _211_ _302_ _212_ VDD VSS MUX2_X1
X_583_ _061_ _206_ _209_ _068_ _212_ _087_ _213_ VDD VSS AOI222_X2
X_584_ _022_ _045_ _214_ VDD VSS XNOR2_X1
X_585_ _125_ _214_ _215_ VDD VSS OR2_X1
X_586_ _085_ _020_ _204_ _213_ _215_ _008_ VDD VSS AOI221_X2
X_587_ _030_ _047_ _216_ VDD VSS NOR2_X1
X_588_ _208_ _216_ _217_ VDD VSS XNOR2_X1
X_589_ _042_ _168_ _217_ _218_ VDD VSS NAND3_X1
X_590_ _022_ _202_ _219_ VDD VSS XNOR2_X1
X_591_ _168_ _219_ _220_ VDD VSS OR2_X1
X_592_ _218_ _220_ _042_ _221_ VDD VSS OAI21_X1
X_593_ _058_ _085_ _123_ _222_ VDD VSS NOR3_X1
X_594_ _107_ _164_ _222_ _223_ VDD VSS AND3_X1
X_595_ _146_ _200_ _221_ _223_ _224_ VDD VSS AND4_X1
X_596_ _261_ _263_ _268_ _225_ VDD VSS MUX2_X1
X_597_ _295_ _070_ _262_ _225_ _226_ VDD VSS NOR4_X1
X_598_ _080_ _288_ net1 _227_ VDD VSS AOI21_X1
X_599_ _260_ _268_ _261_ _228_ VDD VSS AOI21_X1
X_600_ _226_ _227_ _228_ _229_ VDD VSS AOI21_X1
X_601_ _295_ _098_ _230_ VDD VSS NOR2_X1
X_602_ _266_ _265_ _288_ _231_ VDD VSS AOI21_X1
X_603_ _230_ _231_ _295_ _232_ VDD VSS AOI21_X1
X_604_ _302_ _229_ _232_ _233_ VDD VSS OAI21_X1
X_605_ _263_ _265_ _268_ _234_ VDD VSS MUX2_X1
X_606_ _010_ _264_ _234_ _235_ VDD VSS NOR3_X1
X_607_ _235_ _231_ _010_ _236_ VDD VSS AOI21_X1
X_608_ _069_ _140_ _236_ _237_ VDD VSS NOR3_X1
X_609_ _110_ _233_ _237_ _238_ VDD VSS NAND3_X1
X_610_ _319_ _327_ _335_ _343_ _239_ VDD VSS NAND4_X1
X_611_ _289_ _296_ _303_ _311_ _240_ VDD VSS NAND4_X1
X_612_ _068_ _239_ _240_ _241_ VDD VSS OR3_X1
X_613_ _323_ _331_ _345_ _047_ _242_ VDD VSS NOR4_X1
X_614_ _299_ _050_ _279_ _315_ _243_ VDD VSS NOR4_X1
X_615_ _068_ _242_ _243_ _244_ VDD VSS NAND3_X1
X_616_ _093_ _241_ _244_ _245_ VDD VSS AOI21_X1
X_617_ _161_ _182_ _246_ VDD VSS NOR2_X1
X_618_ _115_ _129_ _247_ VDD VSS NOR2_X1
X_619_ _086_ _088_ _292_ _248_ VDD VSS OAI21_X1
X_620_ _302_ _191_ _211_ _249_ VDD VSS OAI21_X1
X_621_ _087_ _247_ _248_ _249_ _250_ VDD VSS AND4_X1
X_622_ _017_ _019_ _060_ _251_ VDD VSS NAND3_X1
X_623_ _134_ _068_ _252_ VDD VSS NAND2_X1
X_624_ _251_ _252_ _060_ _253_ VDD VSS OAI21_X1
X_625_ _245_ _246_ _250_ _015_ _253_ _254_ VDD VSS AOI221_X2
X_626_ _085_ _238_ _254_ _255_ VDD VSS AOI21_X1
X_627_ _042_ _177_ _256_ VDD VSS XNOR2_X1
X_628_ _058_ _085_ _125_ _119_ _257_ VDD VSS NOR4_X1
X_629_ _285_ _126_ _151_ _257_ _258_ VDD VSS AND4_X1
X_630_ _256_ _198_ _214_ _258_ _259_ VDD VSS AND4_X1
X_631_ _224_ _255_ _259_ _009_ VDD VSS OR3_X1
X_632_ net2 net10 _279_ _280_ _281_ VDD VSS FA_X1
X_633_ _282_ net10 _283_ _284_ _285_ VDD VSS FA_X1
X_634_ _287_ _288_ _289_ _290_ VDD VSS HA_X1
X_635_ _287_ net9 _283_ _291_ VDD VSS HA_X1
X_636_ net1 _288_ _292_ _293_ VDD VSS HA_X1
X_637_ net1 net9 _279_ _294_ VDD VSS HA_X1
X_638_ _282_ _295_ _296_ _286_ VDD VSS HA_X1
X_639_ net2 _295_ _297_ _298_ VDD VSS HA_X1
X_640_ net2 net10 _299_ _300_ VDD VSS HA_X1
X_641_ _301_ _302_ _303_ _304_ VDD VSS HA_X1
X_642_ net3 _302_ _305_ _306_ VDD VSS HA_X1
X_643_ net3 net11 _307_ _308_ VDD VSS HA_X1
X_644_ _309_ _310_ _311_ _312_ VDD VSS HA_X1
X_645_ net4 _310_ _313_ _314_ VDD VSS HA_X1
X_646_ net4 net12 _315_ _316_ VDD VSS HA_X1
X_647_ _317_ _318_ _319_ _320_ VDD VSS HA_X1
X_648_ net5 _318_ _321_ _322_ VDD VSS HA_X1
X_649_ net5 net13 _323_ _324_ VDD VSS HA_X1
X_650_ _325_ _326_ _327_ _328_ VDD VSS HA_X1
X_651_ net6 _326_ _329_ _330_ VDD VSS HA_X1
X_652_ net6 net14 _331_ _332_ VDD VSS HA_X1
X_653_ _333_ _334_ _335_ _336_ VDD VSS HA_X1
X_654_ net7 _334_ _337_ _338_ VDD VSS HA_X1
X_655_ net7 net15 _339_ _340_ VDD VSS HA_X1
X_656_ _341_ _342_ _343_ _344_ VDD VSS HA_X1
X_657_ net8 net16 _345_ _346_ VDD VSS HA_X1
Xoverflow_flag$_SDFF_PN0_ _000_ clknet_1_0__leaf_clk net17
+ _278_ VDD VSS DFF_X1
Xresult\[0\]$_SDFF_PN0_ _001_ clknet_1_1__leaf_clk net18 _277_
+ VDD VSS DFF_X1
Xresult\[1\]$_SDFF_PN0_ _002_ clknet_1_1__leaf_clk net19 _276_
+ VDD VSS DFF_X1
Xresult\[2\]$_SDFF_PN0_ _003_ clknet_1_1__leaf_clk net20 _275_
+ VDD VSS DFF_X1
Xresult\[3\]$_SDFF_PN0_ _004_ clknet_1_1__leaf_clk net21 _274_
+ VDD VSS DFF_X1
Xresult\[4\]$_SDFF_PN0_ _005_ clknet_1_1__leaf_clk net22 _273_
+ VDD VSS DFF_X1
Xresult\[5\]$_SDFF_PN0_ _006_ clknet_1_0__leaf_clk net23 _272_
+ VDD VSS DFF_X1
Xresult\[6\]$_SDFF_PN0_ _007_ clknet_1_0__leaf_clk net24 _271_
+ VDD VSS DFF_X1
Xresult\[7\]$_SDFF_PN0_ _008_ clknet_1_0__leaf_clk net25 _270_
+ VDD VSS DFF_X1
Xzero_flag$_SDFF_PN0_ _009_ clknet_1_0__leaf_clk net26 _269_
+ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_83 VDD VSS TAPCELL_X1
Xinput1 a[0] net1 VDD VSS BUF_X2
Xinput2 a[1] net2 VDD VSS BUF_X2
Xinput3 a[2] net3 VDD VSS CLKBUF_X2
Xinput4 a[3] net4 VDD VSS BUF_X1
Xinput5 a[4] net5 VDD VSS BUF_X1
Xinput6 a[5] net6 VDD VSS BUF_X1
Xinput7 a[6] net7 VDD VSS BUF_X1
Xinput8 a[7] net8 VDD VSS BUF_X1
Xinput9 b[0] net9 VDD VSS BUF_X2
Xinput10 b[1] net10 VDD VSS BUF_X2
Xinput11 b[2] net11 VDD VSS BUF_X1
Xinput12 b[3] net12 VDD VSS BUF_X1
Xinput13 b[4] net13 VDD VSS BUF_X1
Xinput14 b[5] net14 VDD VSS BUF_X1
Xinput15 b[6] net15 VDD VSS BUF_X1
Xinput16 b[7] net16 VDD VSS BUF_X1
Xoutput17 net17 overflow_flag VDD VSS BUF_X1
Xoutput18 net18 result[0] VDD VSS BUF_X1
Xoutput19 net19 result[1] VDD VSS BUF_X1
Xoutput20 net20 result[2] VDD VSS BUF_X1
Xoutput21 net21 result[3] VDD VSS BUF_X1
Xoutput22 net22 result[4] VDD VSS BUF_X1
Xoutput23 net23 result[5] VDD VSS BUF_X1
Xoutput24 net24 result[6] VDD VSS BUF_X1
Xoutput25 net25 result[7] VDD VSS BUF_X1
Xoutput26 net26 zero_flag VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ CLKBUF_X3
.ENDS alu
