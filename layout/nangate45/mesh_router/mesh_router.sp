* cell mesh_router
* pin clk
* pin north_in_data[31]
* pin east_in_data[29]
* pin east_in_data[6]
* pin east_in_data[28]
* pin east_in_data[5]
* pin east_in_data[31]
* pin east_in_data[30]
* pin east_out_data[29]
* pin east_out_data[30]
* pin south_out_data[31]
* pin south_out_data[29]
* pin south_out_data[30]
* pin west_out_data[31]
* pin west_out_data[29]
* pin west_out_data[30]
* pin west_out_data[28]
* pin east_out_data[31]
* pin south_in_data[31]
* pin south_out_data[28]
* pin east_out_data[28]
* pin south_in_data[29]
* pin south_in_data[28]
* pin east_out_ready
* pin south_in_data[30]
* pin west_in_valid
* pin local_in_valid
* pin south_in_ready
* pin south_in_valid
* pin local_in_ready
* pin local_out_data[28]
* pin local_out_data[31]
* pin local_out_data[30]
* pin local_out_data[29]
* pin west_in_data[29]
* pin east_out_data[7]
* pin north_out_data[30]
* pin west_in_data[28]
* pin local_out_data[9]
* pin north_out_data[31]
* pin north_out_data[9]
* pin west_in_data[30]
* pin north_out_data[29]
* pin north_out_data[7]
* pin north_out_data[28]
* pin local_out_data[7]
* pin east_out_data[9]
* pin west_in_data[31]
* pin north_out_data[8]
* pin south_out_data[8]
* pin south_out_data[7]
* pin local_in_data[29]
* pin north_out_data[6]
* pin local_in_data[28]
* pin local_out_data[6]
* pin local_out_data[8]
* pin west_out_data[8]
* pin local_in_data[30]
* pin north_out_data[5]
* pin local_out_data[4]
* pin local_out_data[5]
* pin north_out_data[4]
* pin north_out_data[3]
* pin north_out_data[2]
* pin local_in_data[31]
* pin west_out_data[9]
* pin south_out_data[5]
* pin south_in_data[5]
* pin south_in_data[6]
* pin south_out_data[9]
* pin west_out_data[5]
* pin south_in_data[4]
* pin south_in_data[3]
* pin west_out_data[6]
* pin west_in_data[4]
* pin west_out_data[7]
* pin south_out_data[6]
* pin west_in_data[2]
* pin south_in_data[2]
* pin west_in_data[3]
* pin west_in_data[5]
* pin south_in_data[7]
* pin west_in_data[6]
* pin local_in_data[5]
* pin east_out_data[5]
* pin local_in_data[2]
* pin PWELL
* pin NWELL
* pin north_in_data[28]
* pin local_in_data[4]
* pin north_in_data[29]
* pin north_in_data[30]
* pin east_out_data[25]
* pin local_in_data[24]
* pin rst_n
* pin north_in_data[5]
* pin local_in_data[7]
* pin local_in_data[6]
* pin local_out_data[25]
* pin north_in_data[6]
* pin local_out_data[27]
* pin east_out_data[6]
* pin east_in_data[7]
* pin west_in_data[7]
* pin local_in_data[3]
* pin north_in_data[7]
* pin local_out_ready
* pin east_out_data[2]
* pin east_in_data[4]
* pin east_out_data[3]
* pin north_in_data[4]
* pin south_in_data[26]
* pin east_in_data[2]
* pin north_in_data[3]
* pin south_in_data[9]
* pin west_in_data[9]
* pin local_in_data[9]
* pin east_in_data[3]
* pin east_in_data[9]
* pin east_out_data[4]
* pin west_out_data[4]
* pin local_out_data[3]
* pin south_out_data[4]
* pin north_in_data[2]
* pin north_in_data[9]
* pin local_in_data[8]
* pin north_out_ready
* pin east_in_data[8]
* pin west_in_data[8]
* pin south_in_data[8]
* pin east_in_ready
* pin south_out_valid
* pin east_in_valid
* pin east_out_data[8]
* pin west_out_data[3]
* pin south_in_data[27]
* pin north_in_data[8]
* pin south_in_data[24]
* pin south_in_data[25]
* pin north_in_valid
* pin south_out_data[3]
* pin north_in_ready
* pin west_out_data[2]
* pin local_in_data[25]
* pin south_out_data[2]
* pin west_out_valid
* pin north_out_valid
* pin local_in_data[27]
* pin west_in_data[27]
* pin north_out_data[26]
* pin east_out_valid
* pin south_out_ready
* pin west_in_ready
* pin local_out_data[2]
* pin north_in_data[27]
* pin north_in_data[25]
* pin west_in_data[25]
* pin local_in_data[26]
* pin west_out_ready
* pin north_out_data[27]
* pin west_out_data[25]
* pin west_out_data[26]
* pin south_out_data[25]
* pin west_in_data[24]
* pin local_out_data[26]
* pin north_in_data[26]
* pin north_out_data[25]
* pin west_in_data[26]
* pin north_in_data[24]
* pin east_out_data[26]
* pin south_out_data[26]
* pin south_out_data[24]
* pin east_in_data[25]
* pin west_out_data[24]
* pin local_in_data[23]
* pin local_out_data[24]
* pin east_out_data[24]
* pin east_in_data[26]
* pin north_out_data[24]
* pin west_out_data[23]
* pin east_in_data[24]
* pin west_in_data[23]
* pin west_out_data[27]
* pin east_in_data[23]
* pin east_out_data[23]
* pin west_out_data[22]
* pin north_out_data[22]
* pin north_in_data[23]
* pin east_in_data[27]
* pin south_out_data[22]
* pin east_out_data[22]
* pin south_in_data[22]
* pin east_in_data[22]
* pin north_out_data[23]
* pin north_out_data[21]
* pin north_in_data[21]
* pin east_in_data[21]
* pin north_in_data[22]
* pin west_in_data[22]
* pin local_out_data[21]
* pin local_out_data[22]
* pin east_in_data[20]
* pin north_in_data[20]
* pin south_out_data[21]
* pin west_out_data[21]
* pin local_in_data[22]
* pin west_in_data[20]
* pin local_out_data[23]
* pin east_in_data[19]
* pin east_in_data[1]
* pin east_in_data[11]
* pin south_in_data[19]
* pin local_in_data[21]
* pin north_in_data[19]
* pin north_in_data[1]
* pin west_out_data[1]
* pin east_out_data[1]
* pin south_out_data[23]
* pin north_in_data[11]
* pin east_in_data[0]
* pin south_out_data[20]
* pin south_in_data[20]
* pin north_in_data[0]
* pin local_in_data[1]
* pin local_in_data[19]
* pin west_in_data[1]
* pin east_in_data[10]
* pin east_in_data[18]
* pin south_in_data[1]
* pin local_in_data[0]
* pin north_in_data[10]
* pin local_in_data[10]
* pin north_in_data[18]
* pin south_out_data[1]
* pin south_in_data[21]
* pin west_in_data[19]
* pin local_in_data[18]
* pin north_in_data[17]
* pin north_in_data[12]
* pin east_out_data[20]
* pin west_in_data[21]
* pin east_out_data[21]
* pin local_in_data[20]
* pin south_in_data[23]
* pin north_in_data[14]
* pin east_out_data[19]
* pin north_in_data[13]
* pin west_in_data[18]
* pin south_out_data[16]
* pin local_out_data[19]
* pin south_in_data[14]
* pin south_in_data[12]
* pin local_out_data[0]
* pin north_out_data[13]
* pin local_out_data[11]
* pin local_in_data[16]
* pin west_in_data[0]
* pin south_out_data[10]
* pin east_out_data[0]
* pin north_out_data[11]
* pin west_out_data[10]
* pin west_out_data[17]
* pin west_out_data[18]
* pin north_out_data[14]
* pin east_out_data[17]
* pin north_out_data[1]
* pin south_out_data[19]
* pin east_out_data[13]
* pin south_out_data[11]
* pin south_out_data[14]
* pin west_in_data[10]
* pin east_out_data[15]
* pin local_out_data[15]
* pin south_out_data[18]
* pin west_out_data[19]
* pin south_out_data[17]
* pin local_out_data[1]
* pin south_out_data[15]
* pin east_out_data[18]
* pin west_out_data[15]
* pin local_out_data[20]
* pin north_out_data[0]
* pin local_out_data[16]
* pin local_out_data[18]
* pin north_out_data[19]
* pin local_out_data[17]
* pin north_out_data[20]
* pin north_out_data[16]
* pin north_out_data[15]
* pin north_out_data[17]
* pin south_out_data[27]
* pin west_out_data[14]
* pin west_out_data[13]
* pin east_out_data[27]
* pin west_out_data[12]
* pin south_out_data[13]
* pin local_out_valid
* pin west_out_data[20]
* pin east_out_data[14]
* pin east_out_data[11]
* pin south_out_data[0]
* pin local_out_data[10]
* pin local_out_data[12]
* pin local_out_data[14]
* pin north_out_data[12]
* pin east_out_data[10]
* pin local_out_data[13]
* pin west_out_data[11]
* pin north_out_data[10]
* pin north_in_data[15]
* pin north_in_data[16]
* pin east_in_data[12]
* pin east_in_data[14]
* pin east_in_data[13]
* pin east_in_data[17]
* pin east_in_data[16]
* pin east_in_data[15]
* pin west_in_data[12]
* pin south_in_data[10]
* pin south_in_data[11]
* pin south_in_data[0]
* pin west_in_data[11]
* pin west_out_data[0]
* pin east_out_data[12]
* pin west_in_data[13]
* pin south_in_data[13]
* pin south_out_data[12]
* pin south_in_data[15]
* pin west_in_data[16]
* pin south_in_data[16]
* pin south_in_data[17]
* pin west_in_data[14]
* pin west_in_data[15]
* pin west_in_data[17]
* pin south_in_data[18]
* pin local_in_data[14]
* pin local_in_data[13]
* pin west_out_data[16]
* pin local_in_data[12]
* pin local_in_data[11]
* pin east_out_data[16]
* pin local_in_data[15]
* pin local_in_data[17]
* pin north_out_data[18]
.SUBCKT mesh_router 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23
+ 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49
+ 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73 74 75
+ 76 77 78 79 80 81 82 83 84 85 86 109 150 254 350 362 385 394 395 409 410 432
+ 433 434 447 468 469 493 507 509 526 527 537 551 566 578 594 604 605 630 631
+ 632 647 648 675 676 679 680 698 699 728 747 748 775 776 798 799 800 816 817
+ 818 833 848 849 862 878 894 910 912 913 926 927 951 955 957 969 970 971 989
+ 1008 1009 1031 1032 1051 1072 1073 1074 1077 1123 1124 1147 1171 1173 1192
+ 1208 1209 1240 1255 1256 1266 1267 1296 1313 1326 1327 1342 1357 1370 1371
+ 1384 1385 1410 1423 1424 1435 1436 1437 1453 1471 1472 1491 1492 1493 1511
+ 1512 1513 1529 1530 1545 1546 1580 1581 1582 1596 1634 1635 1653 1654 1669
+ 1670 1686 1687 1688 1710 1711 1729 1730 1757 1768 1769 1791 1813 1814 1828
+ 1829 1842 1855 1874 1881 1882 1904 1905 1921 1922 1932 1933 1967 1968 1972
+ 2001 2025 2043 2144 2156 2157 2175 2197 2200 2226 2227 2235 2236 2237 2238
+ 2239 2240 2241 2242 2243 2245 2246 2247 2249 2250 2251 2253 2255 2256 2257
+ 2258 2259 2260 2261 2262 2263 2264 2265 2266 2267 2268 2269 2270 2271 2272
+ 2273 2274 2275 2276 2277 2278 2279 2280 2281 2282 2283 2284 2285 2286 2287
+ 2288 2289 2290 2291 2292 2293 2294 2295 2296 2297 2298 2299 2300 2301 2302
+ 2303 2304 2305 2306 2308 2309 2310 2311 2312 2313 2314 2315 2316 2317 2318
+ 2319 2320 2321 2322 2323 2324 2325 2326 2327 2328
* net 1 clk
* net 2 north_in_data[31]
* net 3 east_in_data[29]
* net 4 east_in_data[6]
* net 5 east_in_data[28]
* net 6 east_in_data[5]
* net 7 east_in_data[31]
* net 8 east_in_data[30]
* net 9 east_out_data[29]
* net 10 east_out_data[30]
* net 11 south_out_data[31]
* net 12 south_out_data[29]
* net 13 south_out_data[30]
* net 14 west_out_data[31]
* net 15 west_out_data[29]
* net 16 west_out_data[30]
* net 17 west_out_data[28]
* net 18 east_out_data[31]
* net 19 south_in_data[31]
* net 20 south_out_data[28]
* net 21 east_out_data[28]
* net 22 south_in_data[29]
* net 23 south_in_data[28]
* net 24 east_out_ready
* net 25 south_in_data[30]
* net 26 west_in_valid
* net 27 local_in_valid
* net 28 south_in_ready
* net 29 south_in_valid
* net 30 local_in_ready
* net 31 local_out_data[28]
* net 32 local_out_data[31]
* net 33 local_out_data[30]
* net 34 local_out_data[29]
* net 35 west_in_data[29]
* net 36 east_out_data[7]
* net 37 north_out_data[30]
* net 38 west_in_data[28]
* net 39 local_out_data[9]
* net 40 north_out_data[31]
* net 41 north_out_data[9]
* net 42 west_in_data[30]
* net 43 north_out_data[29]
* net 44 north_out_data[7]
* net 45 north_out_data[28]
* net 46 local_out_data[7]
* net 47 east_out_data[9]
* net 48 west_in_data[31]
* net 49 north_out_data[8]
* net 50 south_out_data[8]
* net 51 south_out_data[7]
* net 52 local_in_data[29]
* net 53 north_out_data[6]
* net 54 local_in_data[28]
* net 55 local_out_data[6]
* net 56 local_out_data[8]
* net 57 west_out_data[8]
* net 58 local_in_data[30]
* net 59 north_out_data[5]
* net 60 local_out_data[4]
* net 61 local_out_data[5]
* net 62 north_out_data[4]
* net 63 north_out_data[3]
* net 64 north_out_data[2]
* net 65 local_in_data[31]
* net 66 west_out_data[9]
* net 67 south_out_data[5]
* net 68 south_in_data[5]
* net 69 south_in_data[6]
* net 70 south_out_data[9]
* net 71 west_out_data[5]
* net 72 south_in_data[4]
* net 73 south_in_data[3]
* net 74 west_out_data[6]
* net 75 west_in_data[4]
* net 76 west_out_data[7]
* net 77 south_out_data[6]
* net 78 west_in_data[2]
* net 79 south_in_data[2]
* net 80 west_in_data[3]
* net 81 west_in_data[5]
* net 82 south_in_data[7]
* net 83 west_in_data[6]
* net 84 local_in_data[5]
* net 85 east_out_data[5]
* net 86 local_in_data[2]
* net 109 PWELL
* net 150 NWELL
* net 254 north_in_data[28]
* net 350 local_in_data[4]
* net 362 north_in_data[29]
* net 385 north_in_data[30]
* net 394 east_out_data[25]
* net 395 local_in_data[24]
* net 409 rst_n
* net 410 north_in_data[5]
* net 432 local_in_data[7]
* net 433 local_in_data[6]
* net 434 local_out_data[25]
* net 447 north_in_data[6]
* net 468 local_out_data[27]
* net 469 east_out_data[6]
* net 493 east_in_data[7]
* net 507 west_in_data[7]
* net 509 local_in_data[3]
* net 526 north_in_data[7]
* net 527 local_out_ready
* net 537 east_out_data[2]
* net 551 east_in_data[4]
* net 566 east_out_data[3]
* net 578 north_in_data[4]
* net 594 south_in_data[26]
* net 604 east_in_data[2]
* net 605 north_in_data[3]
* net 630 south_in_data[9]
* net 631 west_in_data[9]
* net 632 local_in_data[9]
* net 647 east_in_data[3]
* net 648 east_in_data[9]
* net 675 east_out_data[4]
* net 676 west_out_data[4]
* net 679 local_out_data[3]
* net 680 south_out_data[4]
* net 698 north_in_data[2]
* net 699 north_in_data[9]
* net 728 local_in_data[8]
* net 747 north_out_ready
* net 748 east_in_data[8]
* net 775 west_in_data[8]
* net 776 south_in_data[8]
* net 798 east_in_ready
* net 799 south_out_valid
* net 800 east_in_valid
* net 816 east_out_data[8]
* net 817 west_out_data[3]
* net 818 south_in_data[27]
* net 833 north_in_data[8]
* net 848 south_in_data[24]
* net 849 south_in_data[25]
* net 862 north_in_valid
* net 878 south_out_data[3]
* net 894 north_in_ready
* net 910 west_out_data[2]
* net 912 local_in_data[25]
* net 913 south_out_data[2]
* net 926 west_out_valid
* net 927 north_out_valid
* net 951 local_in_data[27]
* net 955 west_in_data[27]
* net 957 north_out_data[26]
* net 969 east_out_valid
* net 970 south_out_ready
* net 971 west_in_ready
* net 989 local_out_data[2]
* net 1008 north_in_data[27]
* net 1009 north_in_data[25]
* net 1031 west_in_data[25]
* net 1032 local_in_data[26]
* net 1051 west_out_ready
* net 1072 north_out_data[27]
* net 1073 west_out_data[25]
* net 1074 west_out_data[26]
* net 1077 south_out_data[25]
* net 1123 west_in_data[24]
* net 1124 local_out_data[26]
* net 1147 north_in_data[26]
* net 1171 north_out_data[25]
* net 1173 west_in_data[26]
* net 1192 north_in_data[24]
* net 1208 east_out_data[26]
* net 1209 south_out_data[26]
* net 1240 south_out_data[24]
* net 1255 east_in_data[25]
* net 1256 west_out_data[24]
* net 1266 local_in_data[23]
* net 1267 local_out_data[24]
* net 1296 east_out_data[24]
* net 1313 east_in_data[26]
* net 1326 north_out_data[24]
* net 1327 west_out_data[23]
* net 1342 east_in_data[24]
* net 1357 west_in_data[23]
* net 1370 west_out_data[27]
* net 1371 east_in_data[23]
* net 1384 east_out_data[23]
* net 1385 west_out_data[22]
* net 1410 north_out_data[22]
* net 1423 north_in_data[23]
* net 1424 east_in_data[27]
* net 1435 south_out_data[22]
* net 1436 east_out_data[22]
* net 1437 south_in_data[22]
* net 1453 east_in_data[22]
* net 1471 north_out_data[23]
* net 1472 north_out_data[21]
* net 1491 north_in_data[21]
* net 1492 east_in_data[21]
* net 1493 north_in_data[22]
* net 1511 west_in_data[22]
* net 1512 local_out_data[21]
* net 1513 local_out_data[22]
* net 1529 east_in_data[20]
* net 1530 north_in_data[20]
* net 1545 south_out_data[21]
* net 1546 west_out_data[21]
* net 1580 local_in_data[22]
* net 1581 west_in_data[20]
* net 1582 local_out_data[23]
* net 1596 east_in_data[19]
* net 1634 east_in_data[1]
* net 1635 east_in_data[11]
* net 1653 south_in_data[19]
* net 1654 local_in_data[21]
* net 1669 north_in_data[19]
* net 1670 north_in_data[1]
* net 1686 west_out_data[1]
* net 1687 east_out_data[1]
* net 1688 south_out_data[23]
* net 1710 north_in_data[11]
* net 1711 east_in_data[0]
* net 1729 south_out_data[20]
* net 1730 south_in_data[20]
* net 1757 north_in_data[0]
* net 1768 local_in_data[1]
* net 1769 local_in_data[19]
* net 1791 west_in_data[1]
* net 1813 east_in_data[10]
* net 1814 east_in_data[18]
* net 1828 south_in_data[1]
* net 1829 local_in_data[0]
* net 1842 north_in_data[10]
* net 1855 local_in_data[10]
* net 1874 north_in_data[18]
* net 1881 south_out_data[1]
* net 1882 south_in_data[21]
* net 1904 west_in_data[19]
* net 1905 local_in_data[18]
* net 1921 north_in_data[17]
* net 1922 north_in_data[12]
* net 1932 east_out_data[20]
* net 1933 west_in_data[21]
* net 1967 east_out_data[21]
* net 1968 local_in_data[20]
* net 1972 south_in_data[23]
* net 2001 north_in_data[14]
* net 2025 east_out_data[19]
* net 2043 north_in_data[13]
* net 2144 west_in_data[18]
* net 2156 south_out_data[16]
* net 2157 local_out_data[19]
* net 2175 south_in_data[14]
* net 2197 south_in_data[12]
* net 2200 local_out_data[0]
* net 2226 north_out_data[13]
* net 2227 local_out_data[11]
* net 2235 local_in_data[16]
* net 2236 west_in_data[0]
* net 2237 south_out_data[10]
* net 2238 east_out_data[0]
* net 2239 north_out_data[11]
* net 2240 west_out_data[10]
* net 2241 west_out_data[17]
* net 2242 west_out_data[18]
* net 2243 north_out_data[14]
* net 2245 east_out_data[17]
* net 2246 north_out_data[1]
* net 2247 south_out_data[19]
* net 2249 east_out_data[13]
* net 2250 south_out_data[11]
* net 2251 south_out_data[14]
* net 2253 west_in_data[10]
* net 2255 east_out_data[15]
* net 2256 local_out_data[15]
* net 2257 south_out_data[18]
* net 2258 west_out_data[19]
* net 2259 south_out_data[17]
* net 2260 local_out_data[1]
* net 2261 south_out_data[15]
* net 2262 east_out_data[18]
* net 2263 west_out_data[15]
* net 2264 local_out_data[20]
* net 2265 north_out_data[0]
* net 2266 local_out_data[16]
* net 2267 local_out_data[18]
* net 2268 north_out_data[19]
* net 2269 local_out_data[17]
* net 2270 north_out_data[20]
* net 2271 north_out_data[16]
* net 2272 north_out_data[15]
* net 2273 north_out_data[17]
* net 2274 south_out_data[27]
* net 2275 west_out_data[14]
* net 2276 west_out_data[13]
* net 2277 east_out_data[27]
* net 2278 west_out_data[12]
* net 2279 south_out_data[13]
* net 2280 local_out_valid
* net 2281 west_out_data[20]
* net 2282 east_out_data[14]
* net 2283 east_out_data[11]
* net 2284 south_out_data[0]
* net 2285 local_out_data[10]
* net 2286 local_out_data[12]
* net 2287 local_out_data[14]
* net 2288 north_out_data[12]
* net 2289 east_out_data[10]
* net 2290 local_out_data[13]
* net 2291 west_out_data[11]
* net 2292 north_out_data[10]
* net 2293 north_in_data[15]
* net 2294 north_in_data[16]
* net 2295 east_in_data[12]
* net 2296 east_in_data[14]
* net 2297 east_in_data[13]
* net 2298 east_in_data[17]
* net 2299 east_in_data[16]
* net 2300 east_in_data[15]
* net 2301 west_in_data[12]
* net 2302 south_in_data[10]
* net 2303 south_in_data[11]
* net 2304 south_in_data[0]
* net 2305 west_in_data[11]
* net 2306 west_out_data[0]
* net 2308 east_out_data[12]
* net 2309 west_in_data[13]
* net 2310 south_in_data[13]
* net 2311 south_out_data[12]
* net 2312 south_in_data[15]
* net 2313 west_in_data[16]
* net 2314 south_in_data[16]
* net 2315 south_in_data[17]
* net 2316 west_in_data[14]
* net 2317 west_in_data[15]
* net 2318 west_in_data[17]
* net 2319 south_in_data[18]
* net 2320 local_in_data[14]
* net 2321 local_in_data[13]
* net 2322 west_out_data[16]
* net 2323 local_in_data[12]
* net 2324 local_in_data[11]
* net 2325 east_out_data[16]
* net 2326 local_in_data[15]
* net 2327 local_in_data[17]
* net 2328 north_out_data[18]
* cell instance $10 r0 *1 40.09,37.8
X$10 1 109 150 673 CLKBUF_X3
* cell instance $12 r0 *1 8.55,1.4
X$12 2 109 150 120 BUF_X1
* cell instance $18 r0 *1 12.92,1.4
X$18 3 109 150 166 BUF_X1
* cell instance $24 r0 *1 13.49,1.4
X$24 4 109 150 121 BUF_X1
* cell instance $30 r0 *1 14.63,1.4
X$30 5 109 150 202 BUF_X1
* cell instance $36 r0 *1 16.72,1.4
X$36 6 109 150 437 BUF_X1
* cell instance $42 m0 *1 17.29,4.2
X$42 7 109 150 236 BUF_X1
* cell instance $48 r0 *1 17.29,1.4
X$48 8 109 150 122 BUF_X1
* cell instance $54 r0 *1 19,1.4
X$54 152 109 150 9 BUF_X1
* cell instance $60 r0 *1 20.14,1.4
X$60 123 109 150 10 BUF_X1
* cell instance $66 m0 *1 18.62,4.2
X$66 185 109 150 11 BUF_X1
* cell instance $72 r0 *1 19.57,1.4
X$72 87 109 150 12 BUF_X1
* cell instance $78 r0 *1 20.71,1.4
X$78 88 109 150 13 BUF_X1
* cell instance $84 r0 *1 21.28,1.4
X$84 125 109 150 14 BUF_X1
* cell instance $90 r0 *1 21.85,1.4
X$90 89 109 150 15 BUF_X1
* cell instance $96 r0 *1 22.42,1.4
X$96 127 109 150 16 BUF_X1
* cell instance $102 r0 *1 23.56,1.4
X$102 128 109 150 17 BUF_X1
* cell instance $108 r0 *1 22.99,1.4
X$108 90 109 150 18 BUF_X1
* cell instance $114 r0 *1 25.46,1.4
X$114 19 109 150 130 BUF_X1
* cell instance $120 r0 *1 24.13,1.4
X$120 91 109 150 20 BUF_X1
* cell instance $126 r0 *1 24.89,1.4
X$126 92 109 150 21 BUF_X1
* cell instance $132 r0 *1 26.79,1.4
X$132 22 109 150 132 BUF_X1
* cell instance $138 r0 *1 26.03,1.4
X$138 23 109 150 131 BUF_X1
* cell instance $144 m0 *1 25.46,4.2
X$144 24 109 150 295 BUF_X1
* cell instance $150 r0 *1 27.36,1.4
X$150 25 109 150 133 BUF_X1
* cell instance $156 r0 *1 28.5,1.4
X$156 26 109 150 159 CLKBUF_X2
* cell instance $162 r0 *1 29.45,1.4
X$162 27 109 150 134 BUF_X1
* cell instance $168 m0 *1 29.26,7
X$168 204 109 150 28 BUF_X1
* cell instance $174 r0 *1 27.93,1.4
X$174 29 109 150 173 BUF_X1
* cell instance $180 r0 *1 30.02,1.4
X$180 112 109 150 30 BUF_X1
* cell instance $186 r0 *1 31.73,1.4
X$186 113 109 150 31 BUF_X1
* cell instance $192 r0 *1 31.16,1.4
X$192 94 109 150 32 BUF_X1
* cell instance $198 r0 *1 32.3,1.4
X$198 114 109 150 33 BUF_X1
* cell instance $204 r0 *1 30.59,1.4
X$204 93 109 150 34 BUF_X1
* cell instance $210 r0 *1 34.2,1.4
X$210 35 109 150 115 BUF_X1
* cell instance $216 r0 *1 36.48,4.2
X$216 194 109 150 36 BUF_X1
* cell instance $222 r0 *1 36.67,1.4
X$222 97 109 150 37 BUF_X1
* cell instance $228 r0 *1 34.77,1.4
X$228 38 109 150 96 BUF_X1
* cell instance $234 r0 *1 37.05,4.2
X$234 195 109 150 39 BUF_X1
* cell instance $240 r0 *1 37.24,1.4
X$240 98 109 150 40 BUF_X1
* cell instance $246 r0 *1 37.81,1.4
X$246 116 109 150 41 BUF_X1
* cell instance $252 r0 *1 38.95,1.4
X$252 42 109 150 118 BUF_X1
* cell instance $258 r0 *1 38.38,1.4
X$258 224 109 150 43 BUF_X1
* cell instance $264 r0 *1 39.52,1.4
X$264 99 109 150 44 BUF_X1
* cell instance $270 r0 *1 40.09,1.4
X$270 248 109 150 45 BUF_X1
* cell instance $276 r0 *1 40.66,1.4
X$276 117 109 150 46 BUF_X1
* cell instance $282 m0 *1 41.23,7
X$282 208 109 150 47 BUF_X1
* cell instance $288 r0 *1 42.18,4.2
X$288 48 109 150 178 BUF_X1
* cell instance $294 r0 *1 42.56,1.4
X$294 162 109 150 49 BUF_X1
* cell instance $302 m0 *1 42.75,7
X$302 247 109 150 50 BUF_X1
* cell instance $308 m0 *1 43.32,7
X$308 347 109 150 51 BUF_X1
* cell instance $312 m0 *1 45.79,4.2
X$312 52 109 150 102 BUF_X1
* cell instance $318 r0 *1 44.65,1.4
X$318 246 109 150 53 BUF_X1
* cell instance $324 r0 *1 45.22,1.4
X$324 54 109 150 137 BUF_X1
* cell instance $330 m0 *1 47.12,4.2
X$330 138 109 150 55 BUF_X1
* cell instance $336 r0 *1 47.12,1.4
X$336 119 109 150 56 BUF_X1
* cell instance $342 m0 *1 47.12,7
X$342 244 109 150 57 BUF_X1
* cell instance $348 r0 *1 47.88,4.2
X$348 58 109 150 200 BUF_X1
* cell instance $354 r0 *1 48.64,1.4
X$354 179 109 150 59 BUF_X1
* cell instance $360 r0 *1 48.45,4.2
X$360 214 109 150 60 BUF_X1
* cell instance $368 r0 *1 49.02,4.2
X$368 201 109 150 61 BUF_X1
* cell instance $374 r0 *1 49.59,4.2
X$374 227 109 150 62 BUF_X1
* cell instance $378 r0 *1 49.97,1.4
X$378 103 109 150 63 BUF_X1
* cell instance $384 r0 *1 50.54,1.4
X$384 181 109 150 64 BUF_X1
* cell instance $390 r0 *1 51.87,4.2
X$390 65 109 150 104 BUF_X1
* cell instance $396 m0 *1 52.82,7
X$396 242 109 150 66 BUF_X1
* cell instance $402 r0 *1 52.44,4.2
X$402 483 109 150 67 BUF_X1
* cell instance $408 r0 *1 54.34,1.4
X$408 68 109 150 105 BUF_X1
* cell instance $418 r0 *1 53.77,1.4
X$418 69 109 150 141 BUF_X1
* cell instance $420 r0 *1 54.34,4.2
X$420 197 109 150 70 BUF_X1
* cell instance $426 m0 *1 54.15,7
X$426 209 109 150 71 BUF_X1
* cell instance $432 r0 *1 54.91,4.2
X$432 72 109 150 210 BUF_X1
* cell instance $438 r0 *1 56.43,1.4
X$438 73 109 150 196 BUF_X1
* cell instance $444 m0 *1 56.62,7
X$444 311 109 150 74 BUF_X1
* cell instance $450 m0 *1 55.86,4.2
X$450 75 109 150 153 BUF_X1
* cell instance $456 m0 *1 57.19,7
X$456 348 109 150 76 BUF_X1
* cell instance $462 m0 *1 57.76,7
X$462 239 109 150 77 BUF_X1
* cell instance $468 r0 *1 58.9,4.2
X$468 78 109 150 143 BUF_X1
* cell instance $474 r0 *1 59.47,4.2
X$474 79 109 150 211 BUF_X1
* cell instance $480 m0 *1 60.23,7
X$480 80 109 150 232 BUF_X1
* cell instance $486 r0 *1 60.23,1.4
X$486 81 109 150 145 BUF_X1
* cell instance $492 r0 *1 60.8,1.4
X$492 82 109 150 151 BUF_X1
* cell instance $498 r0 *1 61.37,4.2
X$498 83 109 150 213 BUF_X1
* cell instance $504 r0 *1 61.56,1.4
X$504 84 109 150 146 BUF_X1
* cell instance $510 r0 *1 62.7,4.2
X$510 186 109 150 85 BUF_X1
* cell instance $516 r0 *1 66.88,1.4
X$516 86 109 150 108 BUF_X1
* cell instance $522 m0 *1 19.76,4.2
X$522 167 124 109 150 87 NOR2_X1
* cell instance $525 m0 *1 20.9,4.2
X$525 167 169 109 150 88 NOR2_X1
* cell instance $528 m0 *1 22.04,4.2
X$528 126 124 109 150 89 NOR2_X1
* cell instance $531 m0 *1 23.18,4.2
X$531 170 168 109 150 90 NOR2_X1
* cell instance $535 m0 *1 24.32,4.2
X$535 167 129 109 150 91 NOR2_X1
* cell instance $537 m0 *1 24.89,4.2
X$537 168 129 109 150 92 NOR2_X1
* cell instance $541 m0 *1 31.16,9.8
X$541 258 297 285 259 261 150 109 93 OAI221_X1
* cell instance $546 r0 *1 30.97,7
X$546 257 281 250 259 260 150 109 94 OAI221_X1
* cell instance $548 r0 *1 35.34,1.4
X$548 96 95 174 109 150 135 MUX2_X1
* cell instance $551 r0 *1 33.63,15.4
X$551 517 109 150 95 CLKBUF_X3
* cell instance $553 r0 *1 60.04,4.2
X$553 145 95 183 109 150 189 MUX2_X1
* cell instance $555 r0 *1 59.28,15.4
X$555 511 95 423 109 150 478 MUX2_X1
* cell instance $557 r0 *1 60.61,9.8
X$557 213 95 353 109 150 375 MUX2_X1
* cell instance $559 m0 *1 59.47,9.8
X$559 232 95 271 109 150 319 MUX2_X1
* cell instance $561 r0 *1 57.38,1.4
X$561 153 95 182 109 150 154 MUX2_X1
* cell instance $564 r0 *1 58.9,1.4
X$564 143 95 107 109 150 111 MUX2_X1
* cell instance $567 r0 *1 43.32,1.4
X$567 178 95 100 109 150 160 MUX2_X1
* cell instance $570 r0 *1 41.23,1.4
X$570 118 95 175 109 150 163 MUX2_X1
* cell instance $573 r0 *1 32.87,1.4
X$573 115 95 193 109 150 165 MUX2_X1
* cell instance $584 m0 *1 36.67,7
X$584 206 205 251 109 97 150 AOI21_X1
* cell instance $587 m0 *1 37.43,7
X$587 253 205 252 109 98 150 AOI21_X1
* cell instance $589 m0 *1 39.52,12.6
X$589 387 205 418 109 99 150 AOI21_X1
* cell instance $592 m0 *1 46.36,4.2
X$592 157 109 150 100 BUF_X2
* cell instance $595 m0 *1 32.49,7
X$595 109 249 175 100 174 193 150 OR4_X4
* cell instance $598 r0 *1 31.92,4.2
X$598 109 193 174 100 175 191 150 NOR4_X4
* cell instance $600 r0 *1 37.43,7
X$600 304 100 223 109 252 150 AOI21_X1
* cell instance $602 r0 *1 32.11,7
X$602 100 221 109 150 260 NAND2_X1
* cell instance $612 r0 *1 64.22,15.4
X$612 439 109 150 101 CLKBUF_X3
* cell instance $614 r0 *1 52.25,1.4
X$614 104 101 140 109 150 156 MUX2_X1
* cell instance $616 m0 *1 66.69,15.4
X$616 474 101 442 109 150 438 MUX2_X1
* cell instance $619 m0 *1 48.07,4.2
X$619 200 101 180 109 150 139 MUX2_X1
* cell instance $621 m0 *1 44.84,7
X$621 137 101 226 109 150 245 MUX2_X1
* cell instance $623 m0 *1 62.13,7
X$623 146 101 212 109 150 233 MUX2_X1
* cell instance $625 r0 *1 45.79,1.4
X$625 102 101 243 109 150 199 MUX2_X1
* cell instance $627 r0 *1 65.36,1.4
X$627 108 101 148 109 150 149 MUX2_X1
* cell instance $629 r0 *1 64.22,12.6
X$629 431 101 393 109 150 397 MUX2_X1
* cell instance $632 r0 *1 65.55,9.8
X$632 352 101 313 109 150 315 MUX2_X1
* cell instance $634 m0 *1 68.02,15.4
X$634 435 101 419 109 150 430 MUX2_X1
* cell instance $648 m0 *1 49.97,12.6
X$648 391 205 403 109 103 150 AOI21_X1
* cell instance $657 r0 *1 55.1,1.4
X$657 105 158 106 109 150 155 MUX2_X1
* cell instance $659 r0 *1 60.61,15.4
X$659 106 514 505 150 540 109 OAI21_X1
* cell instance $661 r0 *1 55.67,4.2
X$661 198 109 150 106 CLKBUF_X2
* cell instance $664 r0 *1 50.92,15.4
X$664 183 499 458 106 498 150 109 485 OAI221_X1
* cell instance $666 m0 *1 49.4,12.6
X$666 267 106 109 150 369 NOR2_X1
* cell instance $668 r0 *1 53.2,15.4
X$668 106 464 504 150 503 109 OAI21_X1
* cell instance $670 r0 *1 52.63,18.2
X$670 106 564 588 150 502 109 OAI21_X1
* cell instance $683 m0 *1 50.92,29.4
X$683 107 499 458 270 498 150 109 943 OAI221_X1
* cell instance $686 m0 *1 52.44,29.4
X$686 107 557 556 875 842 109 150 946 AOI221_X1
* cell instance $689 r0 *1 59.66,29.4
X$689 107 1169 148 558 109 150 885 AOI22_X1
* cell instance $692 r0 *1 60.8,29.4
X$692 107 1121 148 573 109 150 987 AOI22_X1
* cell instance $695 m0 *1 58.14,29.4
X$695 107 536 148 466 109 150 918 AOI22_X1
* cell instance $698 m0 *1 62.89,4.2
X$698 110 109 150 107 BUF_X2
* cell instance $700 r0 *1 50.54,9.8
X$700 308 107 223 109 229 150 AOI21_X1
* cell instance $716 m0 *1 21.47,40.6
X$716 1228 1217 1167 109 1136 150 NAND3_X4
* cell instance $718 m0 *1 23.94,40.6
X$718 1253 109 150 1318 INV_X2
* cell instance $720 r0 *1 21.28,40.6
X$720 427 109 150 1374 CLKBUF_X3
* cell instance $721 r0 *1 22.23,40.6
X$721 1417 873 836 109 150 1365 NAND3_X2
* cell instance $723 r0 *1 23.75,40.6
X$723 1365 1136 1199 109 150 1332 NOR3_X1
* cell instance $725 m0 *1 56.24,32.2
X$725 941 109 150 983 INV_X2
* cell instance $730 m0 *1 61.56,32.2
X$730 109 997 725 2482 1030 150 DFF_X2
* cell instance $734 m0 *1 67.64,32.2
X$734 961 109 150 989 BUF_X1
* cell instance $736 m0 *1 68.97,32.2
X$736 109 2387 1035 988 725 150 DFF_X1
* cell instance $737 m0 *1 72.2,32.2
X$737 994 150 911 109 BUF_X4
* cell instance $738 m0 *1 73.53,32.2
X$738 1031 109 150 992 BUF_X1
* cell instance $740 r0 *1 56.05,32.2
X$740 1067 536 985 466 109 150 1029 AOI22_X1
* cell instance $742 r0 *1 57.38,32.2
X$742 1116 690 615 1114 670 109 150 1086 AOI221_X1
* cell instance $743 r0 *1 58.52,32.2
X$743 708 464 504 150 1117 109 OAI21_X1
* cell instance $748 r0 *1 60.04,32.2
X$748 708 947 906 150 1119 109 OAI21_X1
* cell instance $751 r0 *1 61.37,32.2
X$751 1030 109 150 1069 CLKBUF_X3
* cell instance $752 r0 *1 62.32,32.2
X$752 992 1070 1069 109 150 997 MUX2_X1
* cell instance $755 r0 *1 65.93,32.2
X$755 960 1070 1065 109 150 1132 MUX2_X1
* cell instance $758 r0 *1 68.4,32.2
X$758 1036 109 150 1074 BUF_X1
* cell instance $761 r0 *1 70.68,32.2
X$761 1035 150 941 109 BUF_X4
* cell instance $762 r0 *1 72.01,32.2
X$762 1032 109 150 1071 BUF_X1
* cell instance $763 r0 *1 72.58,32.2
X$763 1034 109 150 1072 BUF_X1
* cell instance $769 m0 *1 28.69,40.6
X$769 1278 1277 1229 983 109 150 1288 AOI22_X2
* cell instance $770 m0 *1 26.6,40.6
X$770 757 1303 1345 1304 1259 1277 109 150 OAI221_X2
* cell instance $771 m0 *1 30.4,40.6
X$771 1229 1134 1260 109 1278 150 AOI21_X1
* cell instance $772 m0 *1 31.16,40.6
X$772 1282 1290 1232 109 150 168 NAND3_X2
* cell instance $773 m0 *1 32.49,40.6
X$773 1284 807 1188 109 150 1282 NOR3_X1
* cell instance $776 m0 *1 34.2,40.6
X$776 1292 1005 1261 1291 150 167 109 OR4_X2
* cell instance $778 m0 *1 35.72,40.6
X$778 1227 1292 150 109 1305 AND2_X1
* cell instance $779 m0 *1 36.48,40.6
X$779 1305 1321 1005 109 150 1250 NOR3_X1
* cell instance $780 m0 *1 37.24,40.6
X$780 977 109 150 457 INV_X4
* cell instance $781 m0 *1 38.19,40.6
X$781 1261 1200 563 109 150 NOR2_X4
* cell instance $782 m0 *1 39.9,40.6
X$782 1244 109 150 1322 INV_X1
* cell instance $784 m0 *1 25.46,40.6
X$784 1217 1302 755 150 1304 109 OAI21_X1
* cell instance $785 m0 *1 24.89,40.6
X$785 1302 1199 109 150 1275 NOR2_X1
* cell instance $787 r0 *1 24.89,40.6
X$787 109 1001 1366 1302 1303 126 150 NAND4_X4
* cell instance $791 r0 *1 29.64,40.6
X$791 1367 1318 109 150 1290 NOR2_X1
* cell instance $793 r0 *1 30.4,40.6
X$793 1346 1284 109 150 1336 NOR2_X1
* cell instance $794 r0 *1 30.97,40.6
X$794 1290 1336 807 1227 1284 1333 150 109 AOI221_X2
* cell instance $796 r0 *1 33.44,40.6
X$796 1316 109 150 1348 INV_X2
* cell instance $797 r0 *1 34.01,40.6
X$797 1200 661 1316 109 150 1291 NAND3_X1
* cell instance $798 r0 *1 34.77,40.6
X$798 1320 1275 1369 109 150 1091 NOR3_X1
* cell instance $799 r0 *1 35.53,40.6
X$799 1332 1349 1005 109 150 1251 NOR3_X1
* cell instance $800 r0 *1 36.29,40.6
X$800 1292 1346 1367 1348 109 150 1321 NOR4_X1
* cell instance $801 r0 *1 37.24,40.6
X$801 1164 977 109 150 1377 NAND2_X1
* cell instance $803 r0 *1 38,40.6
X$803 1322 977 109 150 1346 NAND2_X1
* cell instance $806 m0 *1 40.85,40.6
X$806 457 109 150 1311 CLKBUF_X3
* cell instance $809 m0 *1 41.99,40.6
X$809 300 1244 341 109 150 1310 NOR3_X1
* cell instance $811 r0 *1 40.85,40.6
X$811 1261 1285 588 109 150 NOR2_X4
* cell instance $812 r0 *1 42.56,40.6
X$812 1261 150 558 109 BUF_X4
* cell instance $814 m0 *1 43.13,40.6
X$814 1261 109 150 1204 CLKBUF_X3
* cell instance $816 m0 *1 44.65,40.6
X$816 1262 1286 1312 1323 109 150 1298 AOI22_X2
* cell instance $819 m0 *1 46.55,40.6
X$819 1168 1310 1227 1098 109 150 1283 AOI22_X1
* cell instance $822 r0 *1 44.65,40.6
X$822 942 1322 840 109 150 1323 NAND3_X1
* cell instance $824 r0 *1 46.93,40.6
X$824 300 1319 1311 150 1378 109 NOR3_X2
* cell instance $826 m0 *1 49.78,40.6
X$826 1263 1134 1096 109 1307 150 AOI21_X1
* cell instance $827 m0 *1 48.64,40.6
X$827 1113 1283 1309 1143 302 109 150 1263 AOI221_X1
* cell instance $829 m0 *1 50.73,40.6
X$829 1281 1040 1307 109 1308 150 AOI21_X2
* cell instance $830 m0 *1 52.06,40.6
X$830 1186 941 109 150 1281 NOR2_X1
* cell instance $831 m0 *1 52.63,40.6
X$831 1202 1237 109 150 1279 NOR2_X1
* cell instance $832 m0 *1 53.2,40.6
X$832 1319 109 150 1306 INV_X1
* cell instance $834 r0 *1 49.02,40.6
X$834 1368 1113 1279 1143 302 1341 150 109 AOI221_X2
* cell instance $835 r0 *1 51.11,40.6
X$835 559 1343 150 109 1293 AND2_X2
* cell instance $836 r0 *1 52.06,40.6
X$836 942 1306 840 109 150 1337 NAND3_X1
* cell instance $838 r0 *1 53.01,40.6
X$838 1341 1239 1096 109 1339 150 AOI21_X1
* cell instance $840 r0 *1 53.96,40.6
X$840 1186 1254 109 150 1396 NOR2_X1
* cell instance $841 m0 *1 54.15,40.6
X$841 1287 1254 109 150 1340 NAND2_X1
* cell instance $844 m0 *1 54.91,40.6
X$844 1235 1239 1236 1293 842 1338 150 109 AOI221_X2
* cell instance $846 r0 *1 54.53,40.6
X$846 1340 1238 1338 1337 109 150 1364 AOI22_X2
* cell instance $847 r0 *1 56.24,40.6
X$847 1350 464 504 150 1363 109 OAI21_X1
* cell instance $848 r0 *1 57,40.6
X$848 814 1324 813 643 1293 1359 150 109 AOI221_X2
* cell instance $850 m0 *1 57.38,40.6
X$850 1293 690 615 1324 670 109 150 1294 AOI221_X1
* cell instance $851 m0 *1 58.71,40.6
X$851 1294 1264 1252 150 1269 109 OAI21_X1
* cell instance $856 r0 *1 59.09,40.6
X$856 560 1293 788 1324 561 1335 150 109 AOI221_X2
* cell instance $857 m0 *1 60.8,40.6
X$857 1237 947 906 150 1301 109 OAI21_X1
* cell instance $858 m0 *1 59.85,40.6
X$858 1239 1169 1254 1204 109 150 1265 AOI22_X1
* cell instance $859 m0 *1 61.56,40.6
X$859 757 907 963 150 1295 109 OAI21_X1
* cell instance $860 m0 *1 62.32,40.6
X$860 1134 1121 941 1183 109 150 1334 AOI22_X1
* cell instance $861 m0 *1 63.27,40.6
X$861 1237 907 963 150 1272 109 OAI21_X1
* cell instance $864 r0 *1 61.18,40.6
X$864 1335 1301 1265 150 1362 109 OAI21_X1
* cell instance $866 r0 *1 62.13,40.6
X$866 1333 1295 1334 150 1330 109 OAI21_X1
* cell instance $867 r0 *1 62.89,40.6
X$867 1239 1121 1254 1183 109 150 1360 AOI22_X1
* cell instance $869 r0 *1 64.03,40.6
X$869 1359 1272 1360 150 1356 109 OAI21_X1
* cell instance $871 m0 *1 65.36,40.6
X$871 109 2365 1271 1331 1206 150 DFF_X1
* cell instance $873 m0 *1 68.59,40.6
X$873 109 2413 1300 1354 1206 150 DFF_X1
* cell instance $874 m0 *1 71.82,40.6
X$874 1273 109 150 1240 BUF_X1
* cell instance $875 m0 *1 72.39,40.6
X$875 1266 109 150 1270 BUF_X1
* cell instance $876 m0 *1 72.96,40.6
X$876 1268 109 150 1254 CLKBUF_X2
* cell instance $878 m0 *1 73.91,40.6
X$878 1298 109 150 1267 BUF_X1
* cell instance $882 r0 *1 66.12,40.6
X$882 1352 1070 1239 109 150 1331 MUX2_X1
* cell instance $884 r0 *1 68.97,40.6
X$884 1353 726 1237 109 150 1354 MUX2_X1
* cell instance $887 r0 *1 71.44,40.6
X$887 1270 949 1254 109 150 1325 MUX2_X1
* cell instance $890 r0 *1 73.34,40.6
X$890 1269 109 150 1327 BUF_X1
* cell instance $891 r0 *1 73.91,40.6
X$891 1330 109 150 1296 BUF_X1
* cell instance $893 m0 *1 9.69,51.8
X$893 700 109 150 1075 CLKBUF_X3
* cell instance $894 m0 *1 9.12,51.8
X$894 1457 109 150 2355 INV_X2
* cell instance $895 m0 *1 10.64,51.8
X$895 1691 1075 1617 109 150 1637 MUX2_X1
* cell instance $896 m0 *1 11.97,51.8
X$896 673 109 150 1457 CLKBUF_X3
* cell instance $899 m0 *1 13.87,51.8
X$899 702 109 150 1659 CLKBUF_X3
* cell instance $900 m0 *1 14.82,51.8
X$900 109 2371 1599 1598 1638 150 DFF_X1
* cell instance $901 m0 *1 18.05,51.8
X$901 109 2380 1620 1692 1600 150 DFF_X1
* cell instance $902 m0 *1 21.28,51.8
X$902 1620 109 150 1230 BUF_X2
* cell instance $904 m0 *1 22.23,51.8
X$904 1599 524 109 150 1601 NAND2_X1
* cell instance $905 m0 *1 22.8,51.8
X$905 1373 661 1603 1302 150 109 1584 AND4_X1
* cell instance $906 m0 *1 23.94,51.8
X$906 1601 1499 1303 150 1661 109 OAI21_X1
* cell instance $907 m0 *1 24.7,51.8
X$907 1373 661 1664 1302 150 109 1663 AND4_X1
* cell instance $908 m0 *1 25.84,51.8
X$908 1623 1499 1303 150 1700 109 OAI21_X1
* cell instance $909 m0 *1 26.6,51.8
X$909 1591 1499 1303 150 1602 109 OAI21_X1
* cell instance $911 m0 *1 27.55,51.8
X$911 1624 1572 1625 109 1666 150 AOI21_X1
* cell instance $912 m0 *1 28.31,51.8
X$912 1001 1604 109 150 1624 NOR2_X1
* cell instance $913 m0 *1 28.88,51.8
X$913 661 1664 150 109 1639 AND2_X1
* cell instance $914 m0 *1 29.64,51.8
X$914 1229 1539 1260 109 1625 150 AOI21_X1
* cell instance $915 m0 *1 30.4,51.8
X$915 661 1603 150 109 1574 AND2_X1
* cell instance $916 m0 *1 31.16,51.8
X$916 1639 1535 807 891 1629 109 150 1667 AOI221_X1
* cell instance $917 m0 *1 32.3,51.8
X$917 1640 891 740 874 1574 1630 150 109 AOI221_X2
* cell instance $919 m0 *1 1.33,51.8
X$919 1636 1314 1597 109 150 1614 MUX2_X1
* cell instance $921 m0 *1 2.66,51.8
X$921 109 2393 1597 1614 1457 150 DFF_X1
* cell instance $923 m0 *1 6.65,51.8
X$923 1656 1075 1616 109 150 1690 MUX2_X1
* cell instance $927 r0 *1 1.33,51.8
X$927 1596 109 150 1636 BUF_X1
* cell instance $928 r0 *1 1.9,51.8
X$928 1634 109 150 1731 BUF_X1
* cell instance $929 r0 *1 2.47,51.8
X$929 109 2433 1626 1689 1457 150 DFF_X1
* cell instance $935 r0 *1 6.27,51.8
X$935 1635 109 150 1658 BUF_X1
* cell instance $936 r0 *1 6.84,51.8
X$936 109 1690 1457 1643 1616 150 DFF_X2
* cell instance $939 r0 *1 11.02,51.8
X$939 109 1637 1638 1646 1617 150 DFF_X2
* cell instance $942 r0 *1 15.2,51.8
X$942 1658 1659 1599 109 150 1598 MUX2_X1
* cell instance $946 r0 *1 20.71,51.8
X$946 1694 1695 1230 109 150 1692 MUX2_X1
* cell instance $949 r0 *1 23.18,51.8
X$949 1697 338 109 150 1623 NAND2_X1
* cell instance $950 r0 *1 23.75,51.8
X$950 1661 1584 1259 1715 1303 150 109 1801 OAI221_X1
* cell instance $951 r0 *1 24.89,51.8
X$951 1663 1602 1259 1303 1230 150 109 1718 OAI221_X1
* cell instance $952 r0 *1 26.03,51.8
X$952 1700 1571 1259 1699 1303 150 109 1719 OAI221_X1
* cell instance $956 r0 *1 30.78,51.8
X$956 1601 891 109 150 1703 NOR2_X1
* cell instance $957 r0 *1 31.35,51.8
X$957 1601 1429 109 150 1593 NOR2_X1
* cell instance $958 r0 *1 31.92,51.8
X$958 1601 1448 109 150 1640 NOR2_X1
* cell instance $959 r0 *1 32.49,51.8
X$959 1591 1448 109 150 1641 NOR2_X1
* cell instance $960 r0 *1 33.06,51.8
X$960 1639 874 740 1641 891 109 150 1673 AOI221_X1
* cell instance $961 r0 *1 34.2,51.8
X$961 874 150 1622 109 BUF_X4
* cell instance $963 m0 *1 34.77,51.8
X$963 589 661 1632 150 1575 109 OAI21_X1
* cell instance $965 r0 *1 35.53,51.8
X$965 366 150 1672 109 BUF_X4
* cell instance $966 r0 *1 36.86,51.8
X$966 564 109 150 1762 CLKBUF_X3
* cell instance $968 m0 *1 37.43,51.8
X$968 499 109 150 1642 CLKBUF_X3
* cell instance $971 m0 *1 38.95,51.8
X$971 1483 1501 1311 109 150 1633 NOR3_X1
* cell instance $974 m0 *1 39.9,51.8
X$974 1168 1633 1533 1098 109 150 1605 AOI22_X1
* cell instance $976 m0 *1 41.04,51.8
X$976 1113 1605 1631 1143 1594 109 150 1606 AOI221_X1
* cell instance $977 m0 *1 42.18,51.8
X$977 1606 1539 1096 109 1724 150 AOI21_X1
* cell instance $979 m0 *1 43.13,51.8
X$979 1576 891 740 874 1607 1752 150 109 AOI221_X2
* cell instance $980 m0 *1 45.22,51.8
X$980 1287 1604 109 150 1608 NAND2_X1
* cell instance $981 m0 *1 45.79,51.8
X$981 1608 1627 1628 1567 109 150 1668 AOI22_X1
* cell instance $984 m0 *1 47.69,51.8
X$984 559 1626 150 109 1650 AND2_X1
* cell instance $987 r0 *1 38.95,51.8
X$987 109 1406 150 623 BUF_X8
* cell instance $988 r0 *1 41.42,51.8
X$988 1483 1643 1311 109 150 1674 NOR3_X1
* cell instance $989 r0 *1 42.18,51.8
X$989 1168 1674 1597 1098 109 150 1709 AOI22_X1
* cell instance $991 r0 *1 43.32,51.8
X$991 1113 1709 1644 1143 1594 109 150 1675 AOI221_X1
* cell instance $994 r0 *1 45.03,51.8
X$994 1643 109 150 1754 INV_X1
* cell instance $995 r0 *1 45.41,51.8
X$995 1202 1645 109 150 1644 NOR2_X1
* cell instance $997 r0 *1 46.17,51.8
X$997 1483 1646 1311 109 150 1647 NOR3_X1
* cell instance $999 r0 *1 47.12,51.8
X$999 1168 1647 1626 1098 109 150 1676 AOI22_X1
* cell instance $1000 r0 *1 48.07,51.8
X$1000 1202 1578 109 150 1677 NOR2_X1
* cell instance $1002 r0 *1 48.83,51.8
X$1002 109 1406 1646 722 1649 150 NOR3_X4
* cell instance $1003 m0 *1 49.97,51.8
X$1003 942 1609 840 109 150 1610 NAND3_X1
* cell instance $1004 m0 *1 49.59,51.8
X$1004 1646 109 150 1609 INV_X1
* cell instance $1007 m0 *1 51.11,51.8
X$1007 1650 1407 1369 1649 1465 109 150 1665 AOI221_X1
* cell instance $1008 m0 *1 53.77,51.8
X$1008 1578 1484 1542 150 1611 109 OAI21_X1
* cell instance $1009 m0 *1 54.53,51.8
X$1009 1536 1540 788 1577 1622 1662 150 109 AOI221_X2
* cell instance $1011 m0 *1 59.66,51.8
X$1011 1539 1169 1604 1204 109 150 1621 AOI22_X1
* cell instance $1012 m0 *1 60.61,51.8
X$1012 1662 1612 1621 150 1583 109 OAI21_X1
* cell instance $1015 r0 *1 51.49,51.8
X$1015 1648 1235 1236 1650 842 109 150 1679 AOI221_X1
* cell instance $1016 r0 *1 52.63,51.8
X$1016 1648 1504 1651 1524 109 150 1707 AOI22_X1
* cell instance $1018 r0 *1 53.77,51.8
X$1018 1665 1611 1707 150 1705 109 OAI21_X1
* cell instance $1020 r0 *1 55.29,51.8
X$1020 1536 1650 788 1649 1622 1702 150 109 AOI221_X2
* cell instance $1021 r0 *1 57.38,51.8
X$1021 814 1649 813 1681 1650 1660 150 109 AOI221_X2
* cell instance $1025 r0 *1 59.47,51.8
X$1025 1683 109 150 2354 INV_X4
* cell instance $1027 r0 *1 60.61,51.8
X$1027 1648 1169 1651 1204 109 150 1684 AOI22_X1
* cell instance $1028 r0 *1 61.56,51.8
X$1028 1702 1589 1684 150 1885 109 OAI21_X1
* cell instance $1030 r0 *1 62.51,51.8
X$1030 1648 1121 1651 1183 109 150 1701 AOI22_X1
* cell instance $1031 m0 *1 63.46,51.8
X$1031 1586 1613 1619 150 1585 109 OAI21_X1
* cell instance $1032 m0 *1 62.51,51.8
X$1032 1539 1121 1604 1183 109 150 1619 AOI22_X1
* cell instance $1035 r0 *1 63.46,51.8
X$1035 1660 1587 1701 150 1739 109 OAI21_X1
* cell instance $1038 m0 *1 32.11,15.4
X$1038 416 109 150 497 BUF_X2
* cell instance $1045 r0 *1 32.11,15.4
X$1045 497 109 150 452 INV_X2
* cell instance $1046 r0 *1 32.68,15.4
X$1046 546 452 109 150 529 NOR2_X2
* cell instance $1047 r0 *1 34.58,15.4
X$1047 497 150 222 109 BUF_X4
* cell instance $1049 r0 *1 36.67,15.4
X$1049 420 453 457 109 150 454 NOR3_X1
* cell instance $1050 r0 *1 37.43,15.4
X$1050 520 454 450 368 109 150 486 AOI22_X1
* cell instance $1052 m0 *1 39.14,15.4
X$1052 264 486 417 456 332 109 150 488 AOI221_X1
* cell instance $1053 m0 *1 38.57,15.4
X$1053 388 349 109 150 417 NOR2_X1
* cell instance $1054 m0 *1 40.28,15.4
X$1054 488 423 223 109 418 150 AOI21_X1
* cell instance $1056 r0 *1 38.76,15.4
X$1056 453 109 150 455 INV_X1
* cell instance $1058 r0 *1 39.33,15.4
X$1058 366 455 427 109 150 521 NAND3_X1
* cell instance $1060 r0 *1 40.28,15.4
X$1060 525 522 521 530 109 150 117 AOI22_X1
* cell instance $1062 r0 *1 41.42,15.4
X$1062 423 499 458 349 498 150 109 522 OAI221_X1
* cell instance $1064 m0 *1 41.42,15.4
X$1064 487 109 150 223 CLKBUF_X3
* cell instance $1065 m0 *1 42.56,15.4
X$1065 420 490 457 109 150 389 NOR3_X1
* cell instance $1066 m0 *1 43.32,15.4
X$1066 420 424 457 109 150 421 NOR3_X1
* cell instance $1067 m0 *1 44.08,15.4
X$1067 420 422 457 109 150 445 NOR3_X1
* cell instance $1069 m0 *1 45.6,15.4
X$1069 424 109 150 492 INV_X1
* cell instance $1071 m0 *1 46.17,15.4
X$1071 366 492 427 109 150 425 NAND3_X1
* cell instance $1073 m0 *1 47.12,15.4
X$1073 366 491 427 109 150 461 NAND3_X1
* cell instance $1074 m0 *1 47.88,15.4
X$1074 490 109 150 491 INV_X1
* cell instance $1075 m0 *1 48.26,15.4
X$1075 366 489 427 109 150 428 NAND3_X1
* cell instance $1076 m0 *1 49.02,15.4
X$1076 422 109 150 489 INV_X1
* cell instance $1078 r0 *1 42.56,15.4
X$1078 459 419 109 150 525 NAND2_X1
* cell instance $1081 r0 *1 44.27,15.4
X$1081 524 408 150 109 533 AND2_X1
* cell instance $1082 r0 *1 45.03,15.4
X$1082 353 499 458 312 498 150 109 500 OAI221_X1
* cell instance $1083 r0 *1 46.17,15.4
X$1083 459 393 109 150 460 NAND2_X1
* cell instance $1084 r0 *1 46.74,15.4
X$1084 460 500 461 550 109 150 138 AOI22_X1
* cell instance $1087 r0 *1 48.64,15.4
X$1087 463 523 428 535 109 150 214 AOI22_X1
* cell instance $1088 r0 *1 49.59,15.4
X$1088 182 499 458 277 498 150 109 523 OAI221_X1
* cell instance $1089 m0 *1 50.73,15.4
X$1089 459 313 109 150 463 NAND2_X1
* cell instance $1090 m0 *1 49.78,15.4
X$1090 484 485 425 462 109 150 201 AOI22_X1
* cell instance $1091 m0 *1 51.3,15.4
X$1091 459 212 109 150 484 NAND2_X1
* cell instance $1097 r0 *1 52.25,15.4
X$1097 501 502 547 150 483 109 OAI21_X1
* cell instance $1099 r0 *1 53.96,15.4
X$1099 519 503 518 150 209 109 OAI21_X1
* cell instance $1100 r0 *1 54.72,15.4
X$1100 183 536 212 466 109 150 518 AOI22_X1
* cell instance $1102 r0 *1 55.86,15.4
X$1102 353 536 393 466 109 150 481 AOI22_X1
* cell instance $1103 m0 *1 56.24,15.4
X$1103 429 482 481 150 311 109 OAI21_X1
* cell instance $1107 m0 *1 58.71,15.4
X$1107 109 2383 477 478 142 150 DFF_X1
* cell instance $1108 m0 *1 61.94,15.4
X$1108 477 109 150 423 BUF_X2
* cell instance $1114 r0 *1 56.81,15.4
X$1114 644 516 465 150 348 109 OAI21_X1
* cell instance $1115 r0 *1 57.57,15.4
X$1115 349 464 504 150 516 109 OAI21_X1
* cell instance $1116 r0 *1 58.33,15.4
X$1116 423 536 419 466 109 150 465 AOI22_X1
* cell instance $1126 r0 *1 66.12,15.4
X$1126 109 2478 513 438 147 150 DFF_X1
* cell instance $1127 r0 *1 69.35,15.4
X$1127 513 109 150 442 BUF_X2
* cell instance $1130 m0 *1 70.49,15.4
X$1130 395 109 150 467 BUF_X1
* cell instance $1132 r0 *1 71.25,15.4
X$1132 506 109 150 469 BUF_X1
* cell instance $1134 m0 *1 71.44,15.4
X$1134 593 109 150 394 BUF_X1
* cell instance $1135 r0 *1 71.82,15.4
X$1135 509 109 150 474 BUF_X1
* cell instance $1136 m0 *1 72.96,15.4
X$1136 432 109 150 435 BUF_X1
* cell instance $1137 m0 *1 72.39,15.4
X$1137 475 109 150 434 BUF_X1
* cell instance $1141 r0 *1 72.39,15.4
X$1141 507 109 150 511 BUF_X1
* cell instance $1156 m0 *1 70.68,57.4
X$1156 109 2410 1830 1794 1579 150 DFF_X1
* cell instance $1157 m0 *1 69.35,57.4
X$1157 1728 949 1680 109 150 1794 MUX2_X1
* cell instance $1158 m0 *1 73.91,57.4
X$1158 1739 109 150 1687 BUF_X1
* cell instance $1161 r0 *1 69.54,57.4
X$1161 1730 109 150 1652 BUF_X1
* cell instance $1162 r0 *1 70.11,57.4
X$1162 1854 949 1604 109 150 1879 MUX2_X1
* cell instance $1165 r0 *1 72.01,57.4
X$1165 1830 109 150 1680 CLKBUF_X2
* cell instance $1167 r0 *1 73.53,57.4
X$1167 1880 109 150 1604 BUF_X2
* cell instance $1170 m0 *1 65.55,51.8
X$1170 1657 1070 1539 109 150 1562 MUX2_X1
* cell instance $1172 m0 *1 66.88,51.8
X$1172 109 2411 1618 1696 1579 150 DFF_X1
* cell instance $1173 m0 *1 70.11,51.8
X$1173 1618 109 150 1543 BUF_X2
* cell instance $1177 r0 *1 65.55,51.8
X$1177 1362 109 150 1688 BUF_X1
* cell instance $1180 r0 *1 67.07,51.8
X$1180 1693 726 1645 109 150 1698 MUX2_X1
* cell instance $1181 r0 *1 68.4,51.8
X$1181 1581 109 150 1657 BUF_X1
* cell instance $1182 r0 *1 68.97,51.8
X$1182 1652 726 1543 109 150 1696 MUX2_X1
* cell instance $1183 r0 *1 70.3,51.8
X$1183 1580 109 150 1409 BUF_X1
* cell instance $1185 r0 *1 71.25,51.8
X$1185 109 2438 1685 1655 1683 150 DFF_X1
* cell instance $1187 m0 *1 72.01,51.8
X$1187 1615 726 1578 109 150 1655 MUX2_X1
* cell instance $1194 m0 *1 3.04,18.2
X$1194 526 109 150 552 BUF_X1
* cell instance $1195 m0 *1 3.61,18.2
X$1195 552 333 570 109 150 571 MUX2_X1
* cell instance $1196 m0 *1 4.94,18.2
X$1196 109 571 274 453 570 150 DFF_X2
* cell instance $1197 m0 *1 8.55,18.2
X$1197 551 109 150 538 BUF_X1
* cell instance $1204 r0 *1 2.66,18.2
X$1204 578 109 150 633 BUF_X1
* cell instance $1210 r0 *1 7.03,18.2
X$1210 633 333 636 109 150 634 MUX2_X1
* cell instance $1211 r0 *1 8.36,18.2
X$1211 109 634 650 422 636 150 DFF_X2
* cell instance $1213 m0 *1 12.73,18.2
X$1213 527 109 150 554 CLKBUF_X2
* cell instance $1216 m0 *1 15.01,18.2
X$1216 538 216 407 109 150 541 MUX2_X1
* cell instance $1224 r0 *1 17.86,18.2
X$1224 652 109 150 609 INV_X1
* cell instance $1225 r0 *1 18.24,18.2
X$1225 607 109 150 608 INV_X1
* cell instance $1227 r0 *1 18.81,18.2
X$1227 608 609 2347 150 109 580 HA_X1
* cell instance $1229 m0 *1 20.52,18.2
X$1229 580 494 579 150 109 553 HA_X1
* cell instance $1230 m0 *1 22.61,18.2
X$1230 553 440 109 150 575 NAND2_X1
* cell instance $1232 r0 *1 20.71,18.2
X$1232 607 609 2345 150 109 581 HA_X1
* cell instance $1233 r0 *1 22.61,18.2
X$1233 581 109 150 582 BUF_X2
* cell instance $1234 r0 *1 23.37,18.2
X$1234 612 611 583 109 150 413 NAND3_X1
* cell instance $1235 m0 *1 26.03,18.2
X$1235 451 576 554 109 583 150 AOI21_X1
* cell instance $1236 m0 *1 23.56,18.2
X$1236 109 388 150 575 BUF_X8
* cell instance $1238 m0 *1 27.55,18.2
X$1238 109 451 494 546 556 452 150 OAI22_X4
* cell instance $1239 m0 *1 30.78,18.2
X$1239 576 440 109 150 220 NAND2_X2
* cell instance $1240 m0 *1 31.73,18.2
X$1240 610 109 150 528 INV_X1
* cell instance $1241 m0 *1 32.11,18.2
X$1241 584 528 600 109 150 NOR2_X4
* cell instance $1242 m0 *1 33.82,18.2
X$1242 529 109 150 259 CLKBUF_X3
* cell instance $1243 m0 *1 34.77,18.2
X$1243 388 150 267 109 BUF_X4
* cell instance $1245 m0 *1 36.29,18.2
X$1245 457 109 150 341 CLKBUF_X3
* cell instance $1246 m0 *1 37.24,18.2
X$1246 524 450 150 109 602 AND2_X1
* cell instance $1247 m0 *1 38,18.2
X$1247 619 555 548 150 194 109 OAI21_X1
* cell instance $1248 m0 *1 38.76,18.2
X$1248 349 514 505 150 555 109 OAI21_X1
* cell instance $1249 m0 *1 39.52,18.2
X$1249 423 542 419 573 109 150 548 AOI22_X1
* cell instance $1251 m0 *1 40.66,18.2
X$1251 423 557 556 602 549 109 150 530 AOI221_X1
* cell instance $1254 r0 *1 24.32,18.2
X$1254 386 451 641 109 150 NOR2_X4
* cell instance $1255 r0 *1 26.03,18.2
X$1255 641 613 660 150 109 584 OAI21_X4
* cell instance $1256 r0 *1 28.5,18.2
X$1256 386 614 451 150 642 109 NOR3_X2
* cell instance $1257 r0 *1 29.83,18.2
X$1257 109 339 688 440 582 564 150 NAND4_X4
* cell instance $1258 r0 *1 33.25,18.2
X$1258 688 642 150 109 646 AND2_X1
* cell instance $1260 r0 *1 34.2,18.2
X$1260 582 109 150 601 INV_X1
* cell instance $1262 r0 *1 34.77,18.2
X$1262 584 601 531 109 150 NOR2_X4
* cell instance $1263 r0 *1 36.48,18.2
X$1263 585 220 280 150 691 109 OAI21_X1
* cell instance $1266 r0 *1 37.81,18.2
X$1266 587 453 589 150 586 109 NOR3_X2
* cell instance $1270 r0 *1 41.61,18.2
X$1270 585 514 505 150 622 109 OAI21_X1
* cell instance $1271 m0 *1 42.37,18.2
X$1271 349 564 588 150 532 109 OAI21_X1
* cell instance $1273 m0 *1 43.13,18.2
X$1273 603 532 577 150 347 109 OAI21_X1
* cell instance $1275 m0 *1 44.08,18.2
X$1275 423 563 419 558 109 150 577 AOI22_X1
* cell instance $1278 r0 *1 42.75,18.2
X$1278 602 560 531 586 561 109 150 603 AOI221_X1
* cell instance $1281 r0 *1 44.46,18.2
X$1281 109 589 424 587 590 150 NOR3_X4
* cell instance $1282 m0 *1 46.36,18.2
X$1282 557 353 556 534 549 550 150 109 AOI221_X2
* cell instance $1283 m0 *1 45.41,18.2
X$1283 559 398 150 109 534 AND2_X2
* cell instance $1284 m0 *1 48.45,18.2
X$1284 559 407 150 109 591 AND2_X1
* cell instance $1286 m0 *1 49.4,18.2
X$1286 183 557 556 533 549 109 150 462 AOI221_X1
* cell instance $1287 m0 *1 50.54,18.2
X$1287 560 533 531 590 561 501 150 109 AOI221_X2
* cell instance $1288 m0 *1 52.63,18.2
X$1288 183 563 212 558 109 150 547 AOI22_X1
* cell instance $1292 r0 *1 48.26,18.2
X$1292 557 182 556 591 549 535 150 109 AOI221_X2
* cell instance $1293 r0 *1 50.35,18.2
X$1293 592 590 600 643 533 597 150 109 AOI221_X2
* cell instance $1297 m0 *1 56.05,18.2
X$1297 312 464 504 150 482 109 OAI21_X1
* cell instance $1298 m0 *1 53.96,18.2
X$1298 560 534 531 562 561 545 150 109 AOI221_X2
* cell instance $1300 m0 *1 57,18.2
X$1300 312 564 588 150 544 109 OAI21_X1
* cell instance $1301 m0 *1 57.76,18.2
X$1301 545 544 574 150 239 109 OAI21_X1
* cell instance $1302 m0 *1 58.52,18.2
X$1302 353 563 393 558 109 150 574 AOI22_X1
* cell instance $1304 r0 *1 53.96,18.2
X$1304 592 562 600 643 534 598 150 109 AOI221_X2
* cell instance $1308 r0 *1 57.38,18.2
X$1308 624 626 599 150 637 109 OAI21_X1
* cell instance $1309 r0 *1 58.14,18.2
X$1309 312 514 505 150 640 109 OAI21_X1
* cell instance $1314 r0 *1 59.66,18.2
X$1314 598 640 543 150 506 109 OAI21_X1
* cell instance $1315 m0 *1 60.8,18.2
X$1315 183 542 212 573 109 150 539 AOI22_X1
* cell instance $1316 m0 *1 59.85,18.2
X$1316 353 542 393 573 109 150 543 AOI22_X1
* cell instance $1317 m0 *1 61.75,18.2
X$1317 597 540 539 150 186 109 OAI21_X1
* cell instance $1320 m0 *1 64.22,18.2
X$1320 109 2363 572 565 142 150 DFF_X1
* cell instance $1325 r0 *1 62.32,18.2
X$1325 596 517 620 109 150 639 MUX2_X1
* cell instance $1328 r0 *1 64.6,18.2
X$1328 595 392 585 109 150 565 MUX2_X1
* cell instance $1331 r0 *1 66.5,18.2
X$1331 572 109 150 585 BUF_X2
* cell instance $1334 r0 *1 68.4,18.2
X$1334 109 2441 628 638 147 150 DFF_X1
* cell instance $1335 m0 *1 68.78,18.2
X$1335 569 109 150 468 BUF_X1
* cell instance $1339 r0 *1 71.63,18.2
X$1339 594 109 150 732 BUF_X1
* cell instance $1340 r0 *1 72.2,18.2
X$1340 631 109 150 596 BUF_X1
* cell instance $1342 m0 *1 72.96,18.2
X$1342 568 109 150 566 BUF_X1
* cell instance $1344 m0 *1 73.53,18.2
X$1344 567 109 150 537 BUF_X1
* cell instance $1347 r0 *1 73.91,18.2
X$1347 630 109 150 595 BUF_X1
* cell instance $1352 m0 *1 1.52,54.6
X$1352 1669 109 150 1656 BUF_X1
* cell instance $1353 m0 *1 2.09,54.6
X$1353 1731 1314 1626 109 150 1689 MUX2_X1
* cell instance $1355 m0 *1 4.18,54.6
X$1355 1711 109 150 1736 BUF_X1
* cell instance $1356 m0 *1 4.75,54.6
X$1356 109 1713 1734 1732 1638 150 DFF_X1
* cell instance $1357 m0 *1 7.98,54.6
X$1357 1670 109 150 1691 BUF_X1
* cell instance $1364 r0 *1 2.66,54.6
X$1364 1757 109 150 1771 BUF_X1
* cell instance $1370 r0 *1 3.8,54.6
X$1370 1710 109 150 1712 BUF_X1
* cell instance $1371 r0 *1 4.37,54.6
X$1371 1712 1733 1734 109 150 1732 MUX2_X1
* cell instance $1373 r0 *1 7.22,54.6
X$1373 1771 1733 1772 109 150 1770 MUX2_X1
* cell instance $1374 r0 *1 8.55,54.6
X$1374 109 1716 1772 1770 1457 150 DFF_X1
* cell instance $1376 m0 *1 9.69,54.6
X$1376 700 109 150 1733 CLKBUF_X3
* cell instance $1377 m0 *1 13.68,54.6
X$1377 1638 109 150 2357 INV_X2
* cell instance $1378 m0 *1 14.25,54.6
X$1378 1736 1659 1717 109 150 1714 MUX2_X1
* cell instance $1379 m0 *1 15.58,54.6
X$1379 673 109 150 1638 CLKBUF_X3
* cell instance $1384 r0 *1 13.87,54.6
X$1384 109 2431 1717 1714 1638 150 DFF_X1
* cell instance $1385 m0 *1 20.14,54.6
X$1385 1738 109 150 1715 CLKBUF_X2
* cell instance $1386 m0 *1 16.91,54.6
X$1386 109 2381 1738 1737 1600 150 DFF_X1
* cell instance $1391 r0 *1 18.81,54.6
X$1391 1784 1695 1715 109 150 1737 MUX2_X1
* cell instance $1394 r0 *1 21.28,54.6
X$1394 666 1713 336 150 1773 109 NOR3_X2
* cell instance $1395 m0 *1 22.8,54.6
X$1395 1713 623 109 150 1603 NOR2_X1
* cell instance $1396 m0 *1 22.04,54.6
X$1396 666 1716 336 109 150 1742 NOR3_X1
* cell instance $1399 r0 *1 22.99,54.6
X$1399 1361 1742 1717 1759 109 150 1800 AOI22_X1
* cell instance $1401 m0 *1 23.75,54.6
X$1401 1716 623 109 150 1664 NOR2_X1
* cell instance $1403 m0 *1 26.03,54.6
X$1403 1717 1460 109 150 1591 NAND2_X1
* cell instance $1405 r0 *1 23.94,54.6
X$1405 763 1230 109 150 1774 NOR2_X1
* cell instance $1409 r0 *1 26.6,54.6
X$1409 1001 1671 109 150 1805 NOR2_X1
* cell instance $1410 m0 *1 27.17,54.6
X$1410 259 1671 109 150 1720 NAND2_X1
* cell instance $1413 r0 *1 27.17,54.6
X$1413 1720 1777 1747 1721 109 150 1776 AOI22_X2
* cell instance $1415 m0 *1 28.12,54.6
X$1415 1403 1664 1672 109 1721 150 AOI21_X1
* cell instance $1417 r0 *1 28.88,54.6
X$1417 1230 1760 1642 1758 618 1777 109 150 OAI221_X2
* cell instance $1418 m0 *1 30.78,54.6
X$1418 1667 1280 1746 150 1704 109 OAI21_X1
* cell instance $1419 m0 *1 30.02,54.6
X$1419 1403 1603 1672 109 1761 150 AOI21_X1
* cell instance $1421 r0 *1 30.97,54.6
X$1421 1758 665 1779 1398 109 150 1747 AOI22_X2
* cell instance $1422 m0 *1 32.11,54.6
X$1422 1591 109 150 1779 INV_X1
* cell instance $1426 m0 *1 33.44,54.6
X$1426 1673 1234 1722 150 1749 109 OAI21_X1
* cell instance $1428 m0 *1 35.72,54.6
X$1428 514 109 150 1750 CLKBUF_X3
* cell instance $1430 m0 *1 36.86,54.6
X$1430 542 150 1780 109 BUF_X4
* cell instance $1431 m0 *1 38.19,54.6
X$1431 498 109 150 1760 CLKBUF_X3
* cell instance $1432 m0 *1 39.14,54.6
X$1432 505 109 150 1763 CLKBUF_X3
* cell instance $1434 r0 *1 32.68,54.6
X$1434 1715 1750 1763 150 1787 109 OAI21_X1
* cell instance $1435 r0 *1 33.44,54.6
X$1435 1758 1780 1671 1432 109 150 1746 AOI22_X1
* cell instance $1436 r0 *1 34.39,54.6
X$1436 1758 1723 1671 1462 109 150 1722 AOI22_X1
* cell instance $1440 r0 *1 36.67,54.6
X$1440 388 150 1810 109 BUF_X4
* cell instance $1444 m0 *1 41.42,54.6
X$1444 487 109 150 1096 CLKBUF_X3
* cell instance $1445 m0 *1 40.47,54.6
X$1445 563 109 150 1723 CLKBUF_X3
* cell instance $1447 r0 *1 40.47,54.6
X$1447 487 109 150 1788 CLKBUF_X3
* cell instance $1450 m0 *1 42.75,54.6
X$1450 1186 1604 109 150 1725 NOR2_X1
* cell instance $1452 r0 *1 43.13,54.6
X$1452 1725 1040 1724 109 1782 150 AOI21_X1
* cell instance $1453 m0 *1 46.36,54.6
X$1453 1675 1678 1096 109 1726 150 AOI21_X1
* cell instance $1454 m0 *1 43.7,54.6
X$1454 109 589 1643 587 1607 150 NOR3_X4
* cell instance $1456 m0 *1 47.31,54.6
X$1456 1113 1676 1677 1143 1594 109 150 1756 AOI221_X1
* cell instance $1457 m0 *1 48.45,54.6
X$1457 1756 1648 1096 109 1727 150 AOI21_X1
* cell instance $1459 m0 *1 49.4,54.6
X$1459 1186 1651 109 150 1765 NOR2_X1
* cell instance $1460 m0 *1 49.97,54.6
X$1460 1287 1651 109 150 1755 NAND2_X1
* cell instance $1462 r0 *1 43.89,54.6
X$1462 305 109 150 1040 CLKBUF_X3
* cell instance $1464 r0 *1 45.6,54.6
X$1464 942 1754 1374 109 150 1789 NAND3_X1
* cell instance $1465 r0 *1 46.36,54.6
X$1465 1645 1762 1527 150 1764 109 OAI21_X1
* cell instance $1466 r0 *1 47.12,54.6
X$1466 1752 1764 1767 150 1783 109 OAI21_X1
* cell instance $1468 r0 *1 48.26,54.6
X$1468 1765 1040 1727 109 1781 150 AOI21_X1
* cell instance $1472 r0 *1 50.35,54.6
X$1472 1645 1750 1763 150 1748 109 OAI21_X1
* cell instance $1473 m0 *1 51.87,54.6
X$1473 1648 1111 1141 1578 1110 150 109 1708 OAI221_X1
* cell instance $1474 m0 *1 50.92,54.6
X$1474 1755 1708 1610 1679 109 150 1753 AOI22_X1
* cell instance $1476 m0 *1 53.2,54.6
X$1476 1287 1680 109 150 1751 NAND2_X1
* cell instance $1477 m0 *1 53.77,54.6
X$1477 1645 1110 1111 1678 1141 1706 109 150 OAI221_X2
* cell instance $1478 m0 *1 55.86,54.6
X$1478 814 1607 813 1681 1595 1682 150 109 AOI221_X2
* cell instance $1479 m0 *1 57.95,54.6
X$1479 1682 1748 1745 150 1744 109 OAI21_X1
* cell instance $1480 m0 *1 58.71,54.6
X$1480 563 109 150 1169 CLKBUF_X3
* cell instance $1481 m0 *1 59.66,54.6
X$1481 673 109 150 1683 CLKBUF_X3
* cell instance $1483 r0 *1 51.11,54.6
X$1483 1186 1680 109 150 1806 NOR2_X1
* cell instance $1484 r0 *1 51.68,54.6
X$1484 1595 1407 1369 1607 1465 109 150 1766 AOI221_X1
* cell instance $1486 r0 *1 53.01,54.6
X$1486 1645 1484 1542 150 1790 109 OAI21_X1
* cell instance $1488 r0 *1 54.15,54.6
X$1488 1778 109 150 2353 INV_X4
* cell instance $1489 r0 *1 55.1,54.6
X$1489 1235 1678 1236 1595 842 1834 150 109 AOI221_X2
* cell instance $1490 r0 *1 57.19,54.6
X$1490 673 109 150 1778 CLKBUF_X3
* cell instance $1492 r0 *1 58.52,54.6
X$1492 1678 1169 1680 1204 109 150 1767 AOI22_X1
* cell instance $1496 r0 *1 59.47,54.6
X$1496 439 109 150 1799 CLKBUF_X3
* cell instance $1498 r0 *1 60.8,54.6
X$1498 1678 1121 1680 1183 109 150 1745 AOI22_X1
* cell instance $1499 m0 *1 62.32,54.6
X$1499 517 109 150 1070 CLKBUF_X3
* cell instance $1500 m0 *1 60.99,54.6
X$1500 542 150 1121 109 BUF_X4
* cell instance $1503 m0 *1 64.98,54.6
X$1503 109 2369 1743 1698 1683 150 DFF_X1
* cell instance $1504 m0 *1 68.21,54.6
X$1504 1743 109 150 1645 BUF_X2
* cell instance $1506 m0 *1 69.73,54.6
X$1506 1735 949 1651 109 150 1741 MUX2_X1
* cell instance $1507 m0 *1 71.06,54.6
X$1507 1740 109 150 1651 CLKBUF_X2
* cell instance $1508 m0 *1 71.82,54.6
X$1508 1654 109 150 1509 BUF_X1
* cell instance $1510 m0 *1 72.58,54.6
X$1510 1653 109 150 1693 BUF_X1
* cell instance $1514 r0 *1 62.32,54.6
X$1514 109 2447 1775 1796 1579 150 DFF_X1
* cell instance $1515 r0 *1 65.55,54.6
X$1515 1775 109 150 1648 BUF_X2
* cell instance $1519 r0 *1 67.64,54.6
X$1519 439 109 150 949 CLKBUF_X3
* cell instance $1520 r0 *1 68.59,54.6
X$1520 109 2446 1740 1741 1579 150 DFF_X1
* cell instance $1521 r0 *1 71.82,54.6
X$1521 1769 109 150 1728 BUF_X1
* cell instance $1522 r0 *1 72.39,54.6
X$1522 1583 109 150 1729 BUF_X1
* cell instance $1524 m0 *1 73.72,54.6
X$1524 1685 109 150 1578 CLKBUF_X2
* cell instance $1528 r0 *1 73.91,54.6
X$1528 1768 109 150 1735 BUF_X1
* cell instance $1531 m0 *1 53.39,60.2
X$1531 1823 1484 1542 150 1903 109 OAI21_X1
* cell instance $1532 m0 *1 54.34,60.2
X$1532 1943 1841 1822 109 150 1912 MUX2_X1
* cell instance $1533 m0 *1 55.67,60.2
X$1533 109 2388 1911 1912 1683 150 DFF_X1
* cell instance $1534 m0 *1 58.9,60.2
X$1534 1911 109 150 1822 BUF_X2
* cell instance $1536 r0 *1 53.39,60.2
X$1536 1914 1903 1853 150 1945 109 OAI21_X1
* cell instance $1539 r0 *1 54.72,60.2
X$1539 1930 1695 1823 109 150 1941 MUX2_X1
* cell instance $1540 r0 *1 56.05,60.2
X$1540 109 2436 1940 1941 1683 150 DFF_X1
* cell instance $1544 r0 *1 59.28,60.2
X$1544 1940 109 150 1823 CLKBUF_X2
* cell instance $1545 m0 *1 61.37,60.2
X$1545 1909 109 150 1872 BUF_X2
* cell instance $1546 m0 *1 60.04,60.2
X$1546 1907 1799 1872 109 150 1931 MUX2_X1
* cell instance $1548 m0 *1 62.32,60.2
X$1548 109 2372 1908 1878 1579 150 DFF_X1
* cell instance $1549 m0 *1 65.55,60.2
X$1549 1908 109 150 1826 CLKBUF_X2
* cell instance $1551 r0 *1 60.04,60.2
X$1551 109 2427 1909 1931 1683 150 DFF_X1
* cell instance $1555 r0 *1 64.6,60.2
X$1555 1937 1799 1826 109 150 1878 MUX2_X1
* cell instance $1557 m0 *1 67.26,60.2
X$1557 1855 109 150 1907 BUF_X1
* cell instance $1558 m0 *1 66.69,60.2
X$1558 1829 109 150 1884 BUF_X1
* cell instance $1561 m0 *1 69.16,60.2
X$1561 1885 109 150 1881 BUF_X1
* cell instance $1564 m0 *1 69.92,60.2
X$1564 1904 109 150 1859 BUF_X1
* cell instance $1566 m0 *1 70.68,60.2
X$1566 109 2368 1880 1879 1579 150 DFF_X1
* cell instance $1567 m0 *1 73.91,60.2
X$1567 1828 109 150 1615 BUF_X1
* cell instance $1571 r0 *1 69.92,60.2
X$1571 1933 109 150 1557 BUF_X1
* cell instance $1574 r0 *1 71.63,60.2
X$1574 1585 109 150 1932 BUF_X1
* cell instance $1575 r0 *1 72.2,60.2
X$1575 1905 109 150 1937 BUF_X1
* cell instance $1578 r0 *1 73.91,60.2
X$1578 1882 109 150 1514 BUF_X1
* cell instance $1582 r0 *1 62.13,1.4
X$1582 109 2430 110 111 147 150 DFF_X1
* cell instance $1597 m0 *1 1.33,23.8
X$1597 748 109 150 730 BUF_X1
* cell instance $1599 m0 *1 1.9,23.8
X$1599 698 109 150 749 BUF_X1
* cell instance $1601 m0 *1 2.66,23.8
X$1601 749 333 777 109 150 729 MUX2_X1
* cell instance $1602 m0 *1 3.99,23.8
X$1602 109 729 650 446 777 150 DFF_X2
* cell instance $1603 m0 *1 7.6,23.8
X$1603 700 109 150 333 CLKBUF_X3
* cell instance $1604 m0 *1 8.55,23.8
X$1604 699 109 150 701 BUF_X1
* cell instance $1615 r0 *1 7.22,23.8
X$1615 747 109 150 659 CLKBUF_X2
* cell instance $1618 m0 *1 10.83,23.8
X$1618 109 710 750 779 335 150 DFF_X1
* cell instance $1619 m0 *1 9.5,23.8
X$1619 701 700 750 109 150 779 MUX2_X1
* cell instance $1620 m0 *1 14.06,23.8
X$1620 109 2389 718 651 335 150 DFF_X1
* cell instance $1622 m0 *1 17.48,23.8
X$1622 607 652 2335 150 109 654 HA_X1
* cell instance $1623 m0 *1 19.38,23.8
X$1623 673 109 150 335 CLKBUF_X3
* cell instance $1624 m0 *1 20.33,23.8
X$1624 335 109 150 2349 INV_X4
* cell instance $1627 r0 *1 10.07,23.8
X$1627 730 702 751 109 150 819 MUX2_X1
* cell instance $1628 r0 *1 11.4,23.8
X$1628 109 2481 751 819 650 150 DFF_X1
* cell instance $1630 r0 *1 15.01,23.8
X$1630 274 109 150 2490 CLKBUF_X2
* cell instance $1634 r0 *1 19.38,23.8
X$1634 752 656 109 150 782 NAND2_X1
* cell instance $1636 r0 *1 20.33,23.8
X$1636 704 109 150 801 INV_X1
* cell instance $1637 r0 *1 20.71,23.8
X$1637 803 652 753 109 150 705 MUX2_X1
* cell instance $1638 m0 *1 22.42,23.8
X$1638 673 109 150 172 CLKBUF_X3
* cell instance $1639 m0 *1 21.66,23.8
X$1639 737 660 339 150 704 109 OAI21_X1
* cell instance $1640 m0 *1 23.37,23.8
X$1640 109 757 754 756 660 150 NOR3_X4
* cell instance $1641 m0 *1 26.03,23.8
X$1641 109 607 825 759 786 150 AOI21_X4
* cell instance $1643 m0 *1 28.69,23.8
X$1643 707 708 760 109 150 761 OR3_X4
* cell instance $1644 m0 *1 30.78,23.8
X$1644 805 758 109 150 789 NOR2_X2
* cell instance $1645 m0 *1 31.73,23.8
X$1645 109 740 709 761 759 150 AOI21_X4
* cell instance $1646 m0 *1 34.2,23.8
X$1646 789 150 665 109 BUF_X4
* cell instance $1647 m0 *1 35.53,23.8
X$1647 388 585 109 150 744 NOR2_X1
* cell instance $1648 m0 *1 36.1,23.8
X$1648 763 711 744 456 332 109 150 790 AOI221_X1
* cell instance $1650 m0 *1 38,23.8
X$1650 790 620 487 109 712 150 AOI21_X1
* cell instance $1653 m0 *1 41.04,23.8
X$1653 765 764 487 109 793 150 AOI21_X1
* cell instance $1654 m0 *1 41.8,23.8
X$1654 715 714 793 109 162 150 AOI21_X1
* cell instance $1655 m0 *1 42.56,23.8
X$1655 305 674 109 150 715 NOR2_X1
* cell instance $1659 r0 *1 23.18,23.8
X$1659 109 386 754 756 757 652 150 NOR4_X4
* cell instance $1660 r0 *1 26.6,23.8
X$1660 707 109 150 756 INV_X2
* cell instance $1662 r0 *1 27.36,23.8
X$1662 754 804 761 109 737 150 AOI21_X2
* cell instance $1664 r0 *1 29.07,23.8
X$1664 109 440 576 758 498 805 150 OAI211_X4
* cell instance $1665 r0 *1 32.3,23.8
X$1665 827 760 707 109 759 150 NAND3_X4
* cell instance $1666 r0 *1 34.77,23.8
X$1666 789 150 557 109 BUF_X4
* cell instance $1668 r0 *1 36.48,23.8
X$1668 420 150 666 109 BUF_X4
* cell instance $1669 r0 *1 37.81,23.8
X$1669 420 808 457 109 150 762 NOR3_X1
* cell instance $1670 r0 *1 38.57,23.8
X$1670 520 762 751 666 109 150 830 AOI22_X1
* cell instance $1671 r0 *1 39.52,23.8
X$1671 524 751 150 109 797 AND2_X1
* cell instance $1673 r0 *1 40.47,23.8
X$1673 763 830 832 456 332 109 150 765 AOI221_X1
* cell instance $1675 r0 *1 41.8,23.8
X$1675 764 563 674 558 109 150 831 AOI22_X1
* cell instance $1676 r0 *1 42.75,23.8
X$1676 766 717 831 150 247 109 OAI21_X1
* cell instance $1677 r0 *1 43.51,23.8
X$1677 388 767 109 150 832 NOR2_X1
* cell instance $1678 m0 *1 43.7,23.8
X$1678 767 564 588 150 717 109 OAI21_X1
* cell instance $1680 m0 *1 44.46,23.8
X$1680 808 109 150 796 INV_X1
* cell instance $1681 m0 *1 44.84,23.8
X$1681 529 674 109 150 795 NAND2_X1
* cell instance $1682 m0 *1 45.41,23.8
X$1682 669 797 150 109 746 AND2_X1
* cell instance $1683 m0 *1 46.17,23.8
X$1683 645 746 646 719 720 109 150 768 AOI221_X1
* cell instance $1684 m0 *1 47.31,23.8
X$1684 768 792 770 150 244 109 OAI21_X1
* cell instance $1685 m0 *1 48.07,23.8
X$1685 767 742 769 150 792 109 OAI21_X1
* cell instance $1686 m0 *1 48.83,23.8
X$1686 764 721 674 771 109 150 770 AOI22_X1
* cell instance $1690 m0 *1 52.25,23.8
X$1690 620 721 625 771 109 150 723 AOI22_X1
* cell instance $1691 m0 *1 53.2,23.8
X$1691 585 742 769 150 743 109 OAI21_X1
* cell instance $1693 r0 *1 44.08,23.8
X$1693 524 718 150 109 812 AND2_X1
* cell instance $1694 r0 *1 44.84,23.8
X$1694 366 796 427 109 150 794 NAND3_X1
* cell instance $1695 r0 *1 45.6,23.8
X$1695 764 499 458 767 498 150 109 809 OAI221_X1
* cell instance $1697 r0 *1 46.93,23.8
X$1697 795 809 794 791 109 150 119 AOI22_X1
* cell instance $1699 r0 *1 48.26,23.8
X$1699 764 557 556 797 549 109 150 791 AOI221_X1
* cell instance $1703 r0 *1 51.49,23.8
X$1703 459 442 109 150 811 NAND2_X1
* cell instance $1706 m0 *1 55.29,23.8
X$1706 814 739 813 643 591 687 150 109 AOI221_X2
* cell instance $1707 m0 *1 54.34,23.8
X$1707 721 109 150 536 CLKBUF_X3
* cell instance $1708 m0 *1 57.38,23.8
X$1708 591 560 788 739 561 109 150 787 AOI221_X1
* cell instance $1710 m0 *1 58.71,23.8
X$1710 277 564 588 150 738 109 OAI21_X1
* cell instance $1711 m0 *1 59.47,23.8
X$1711 787 738 785 150 736 109 OAI21_X1
* cell instance $1712 m0 *1 60.23,23.8
X$1712 767 514 505 150 772 109 OAI21_X1
* cell instance $1715 r0 *1 54.72,23.8
X$1715 771 109 150 466 CLKBUF_X3
* cell instance $1719 r0 *1 57.76,23.8
X$1719 322 464 504 150 845 109 OAI21_X1
* cell instance $1720 r0 *1 58.52,23.8
X$1720 271 536 442 466 109 150 861 AOI22_X1
* cell instance $1725 r0 *1 60.23,23.8
X$1725 815 772 826 150 822 109 OAI21_X1
* cell instance $1726 r0 *1 60.99,23.8
X$1726 764 542 674 573 109 150 826 AOI22_X1
* cell instance $1727 m0 *1 62.32,23.8
X$1727 780 517 764 109 150 784 MUX2_X1
* cell instance $1728 m0 *1 61.37,23.8
X$1728 673 109 150 147 CLKBUF_X3
* cell instance $1729 m0 *1 63.65,23.8
X$1729 725 109 150 2489 INV_X1
* cell instance $1731 m0 *1 64.22,23.8
X$1731 783 109 150 764 BUF_X2
* cell instance $1732 m0 *1 64.98,23.8
X$1732 781 392 767 109 150 773 MUX2_X1
* cell instance $1733 m0 *1 66.31,23.8
X$1733 775 109 150 780 BUF_X1
* cell instance $1734 m0 *1 66.88,23.8
X$1734 776 109 150 781 BUF_X1
* cell instance $1736 r0 *1 61.94,23.8
X$1736 109 2479 783 784 142 150 DFF_X1
* cell instance $1737 r0 *1 65.17,23.8
X$1737 109 2468 824 773 725 150 DFF_X1
* cell instance $1738 m0 *1 68.02,23.8
X$1738 109 2423 735 724 725 150 DFF_X1
* cell instance $1740 m0 *1 71.25,23.8
X$1740 109 2414 778 727 725 150 DFF_X1
* cell instance $1742 r0 *1 68.4,23.8
X$1742 824 109 150 767 CLKBUF_X2
* cell instance $1744 r0 *1 70.68,23.8
X$1744 822 109 150 816 BUF_X1
* cell instance $1747 r0 *1 71.82,23.8
X$1747 818 109 150 821 BUF_X1
* cell instance $1749 r0 *1 72.58,23.8
X$1749 774 150 757 109 BUF_X4
* cell instance $1753 m0 *1 1.33,15.4
X$1753 410 109 150 448 BUF_X1
* cell instance $1755 m0 *1 1.9,15.4
X$1755 448 333 470 109 150 471 MUX2_X1
* cell instance $1756 m0 *1 3.23,15.4
X$1756 109 471 274 424 470 150 DFF_X2
* cell instance $1758 m0 *1 7.6,15.4
X$1758 409 150 473 109 BUF_X4
* cell instance $1765 r0 *1 2.66,15.4
X$1765 447 109 150 508 BUF_X1
* cell instance $1771 r0 *1 3.8,15.4
X$1771 493 109 150 512 BUF_X1
* cell instance $1775 r0 *1 6.84,15.4
X$1775 508 333 472 109 150 510 MUX2_X1
* cell instance $1776 r0 *1 8.17,15.4
X$1776 109 510 274 490 472 150 DFF_X2
* cell instance $1777 r0 *1 11.78,15.4
X$1777 512 216 450 109 150 449 MUX2_X1
* cell instance $1779 m0 *1 12.35,15.4
X$1779 109 2370 450 449 274 150 DFF_X1
* cell instance $1784 r0 *1 15.39,15.4
X$1784 109 2454 407 541 274 150 DFF_X1
* cell instance $1786 m0 *1 18.24,15.4
X$1786 109 2402 408 476 335 150 DFF_X1
* cell instance $1788 m0 *1 22.42,15.4
X$1788 109 204 479 412 172 150 DFF_X1
* cell instance $1789 m0 *1 25.65,15.4
X$1789 479 150 440 109 BUF_X4
* cell instance $1791 m0 *1 27.17,15.4
X$1791 576 109 150 494 INV_X2
* cell instance $1797 r0 *1 23.56,15.4
X$1797 473 109 150 414 INV_X1
* cell instance $1798 r0 *1 23.94,15.4
X$1798 440 109 150 451 INV_X4
* cell instance $1799 r0 *1 24.89,15.4
X$1799 457 109 150 336 CLKBUF_X3
* cell instance $1800 r0 *1 25.84,15.4
X$1800 494 451 294 109 150 NOR2_X4
* cell instance $1802 r0 *1 27.74,15.4
X$1802 495 515 473 222 134 150 109 496 OAI221_X1
* cell instance $1804 m0 *1 28.88,15.4
X$1804 496 109 150 480 INV_X1
* cell instance $1806 r0 *1 29.07,15.4
X$1806 134 452 473 109 439 150 NAND3_X4
* cell instance $1808 m0 *1 29.83,15.4
X$1808 415 473 109 392 150 NAND2_X4
* cell instance $1811 m0 *1 1.9,21
X$1811 605 109 150 677 BUF_X1
* cell instance $1813 m0 *1 2.47,21
X$1813 677 333 606 109 150 649 MUX2_X1
* cell instance $1821 r0 *1 2.28,21
X$1821 109 649 274 716 606 150 DFF_X2
* cell instance $1826 m0 *1 5.7,21
X$1826 648 109 150 678 BUF_X1
* cell instance $1827 m0 *1 7.79,21
X$1827 604 109 150 682 BUF_X1
* cell instance $1830 m0 *1 11.59,21
X$1830 682 216 379 109 150 683 MUX2_X1
* cell instance $1831 m0 *1 12.92,21
X$1831 109 683 274 2486 379 150 DFF_X2
* cell instance $1833 m0 *1 18.05,21
X$1833 608 652 653 150 109 685 HA_X1
* cell instance $1834 m0 *1 19.95,21
X$1834 685 109 150 610 BUF_X2
* cell instance $1835 m0 *1 20.71,21
X$1835 660 656 579 109 150 657 NOR3_X1
* cell instance $1838 r0 *1 6.08,21
X$1838 647 109 150 733 BUF_X1
* cell instance $1841 r0 *1 7.22,21
X$1841 678 702 663 109 150 731 MUX2_X1
* cell instance $1842 r0 *1 8.55,21
X$1842 109 2437 663 731 650 150 DFF_X1
* cell instance $1844 r0 *1 11.97,21
X$1844 702 109 150 216 CLKBUF_X3
* cell instance $1847 r0 *1 13.87,21
X$1847 733 216 718 109 150 651 MUX2_X1
* cell instance $1850 r0 *1 18.43,21
X$1850 653 109 150 656 INV_X1
* cell instance $1853 r0 *1 19.38,21
X$1853 654 109 150 655 BUF_X2
* cell instance $1855 r0 *1 20.33,21
X$1855 440 579 150 109 752 AND2_X1
* cell instance $1857 r0 *1 21.47,21
X$1857 657 737 641 109 150 703 NAND3_X1
* cell instance $1858 m0 *1 22.04,21
X$1858 658 705 607 109 150 611 NAND3_X1
* cell instance $1860 m0 *1 22.8,21
X$1860 553 610 655 582 109 150 658 OR4_X1
* cell instance $1864 r0 *1 22.8,21
X$1864 737 706 658 339 109 150 612 NAND4_X1
* cell instance $1865 r0 *1 23.75,21
X$1865 659 660 295 109 150 706 MUX2_X1
* cell instance $1866 m0 *1 25.27,21
X$1866 655 109 150 614 INV_X1
* cell instance $1867 m0 *1 24.32,21
X$1867 172 109 150 2348 INV_X4
* cell instance $1869 m0 *1 25.84,21
X$1869 339 660 613 150 109 576 OAI21_X4
* cell instance $1870 m0 *1 28.31,21
X$1870 109 339 688 440 610 514 150 NAND4_X4
* cell instance $1871 m0 *1 31.73,21
X$1871 339 610 440 109 150 838 NAND3_X1
* cell instance $1872 m0 *1 32.49,21
X$1872 584 614 615 109 150 NOR2_X4
* cell instance $1874 r0 *1 25.08,21
X$1874 109 655 641 613 755 660 150 OAI211_X4
* cell instance $1875 r0 *1 28.31,21
X$1875 109 760 708 707 613 150 NOR3_X4
* cell instance $1876 r0 *1 30.97,21
X$1876 339 582 440 109 150 709 NAND3_X2
* cell instance $1877 r0 *1 32.3,21
X$1877 759 761 109 150 688 NAND2_X2
* cell instance $1878 r0 *1 33.25,21
X$1878 642 688 109 150 742 NAND2_X2
* cell instance $1879 r0 *1 34.2,21
X$1879 710 623 109 150 616 NOR2_X1
* cell instance $1880 m0 *1 35.72,21
X$1880 661 616 150 109 664 AND2_X1
* cell instance $1881 m0 *1 34.58,21
X$1881 616 296 294 621 549 109 150 617 AOI221_X1
* cell instance $1882 m0 *1 36.48,21
X$1882 617 691 693 618 692 150 109 195 OAI221_X1
* cell instance $1883 m0 *1 37.62,21
X$1883 665 618 620 109 150 693 NAND3_X1
* cell instance $1885 m0 *1 38.57,21
X$1885 625 109 150 692 INV_X1
* cell instance $1886 m0 *1 38.95,21
X$1886 586 592 600 667 602 109 150 619 AOI221_X1
* cell instance $1887 m0 *1 40.09,21
X$1887 664 592 600 667 621 109 150 668 AOI221_X1
* cell instance $1888 m0 *1 41.23,21
X$1888 668 622 694 150 208 109 OAI21_X1
* cell instance $1889 m0 *1 41.99,21
X$1889 620 542 625 573 109 150 694 AOI22_X1
* cell instance $1891 m0 *1 44.46,21
X$1891 669 602 150 109 697 AND2_X1
* cell instance $1892 m0 *1 45.22,21
X$1892 697 645 646 670 586 644 150 109 AOI221_X2
* cell instance $1893 m0 *1 47.31,21
X$1893 109 623 490 745 562 150 NOR3_X4
* cell instance $1896 r0 *1 34.77,21
X$1896 420 710 457 109 150 662 NOR3_X1
* cell instance $1897 r0 *1 35.53,21
X$1897 520 662 663 666 109 150 711 AOI22_X1
* cell instance $1898 r0 *1 36.48,21
X$1898 524 663 150 109 621 AND2_X1
* cell instance $1900 r0 *1 37.43,21
X$1900 713 714 712 109 116 150 AOI21_X1
* cell instance $1901 r0 *1 38.19,21
X$1901 305 625 109 150 713 NOR2_X1
* cell instance $1904 r0 *1 39.71,21
X$1904 666 150 368 109 BUF_X4
* cell instance $1907 r0 *1 43.32,21
X$1907 420 716 341 109 150 695 NOR3_X1
* cell instance $1908 r0 *1 44.08,21
X$1908 367 695 718 368 109 150 426 AOI22_X1
* cell instance $1911 r0 *1 45.6,21
X$1911 669 533 150 109 696 AND2_X1
* cell instance $1912 r0 *1 46.36,21
X$1912 696 645 646 670 590 519 150 109 AOI221_X2
* cell instance $1913 r0 *1 48.45,21
X$1913 745 150 722 109 BUF_X4
* cell instance $1915 r0 *1 50.16,21
X$1915 722 422 623 150 739 109 NOR3_X2
* cell instance $1916 m0 *1 51.3,21
X$1916 136 109 150 2356 INV_X2
* cell instance $1918 m0 *1 51.87,21
X$1918 621 560 531 664 561 109 150 672 AOI221_X1
* cell instance $1919 m0 *1 53.01,21
X$1919 673 109 150 136 CLKBUF_X3
* cell instance $1921 m0 *1 54.15,21
X$1921 690 534 615 562 670 429 150 109 AOI221_X2
* cell instance $1922 m0 *1 56.24,21
X$1922 585 564 588 150 689 109 OAI21_X1
* cell instance $1923 m0 *1 57,21
X$1923 277 464 504 150 626 109 OAI21_X1
* cell instance $1925 r0 *1 51.49,21
X$1925 621 690 615 664 670 109 150 671 AOI221_X1
* cell instance $1926 r0 *1 52.63,21
X$1926 671 743 723 150 242 109 OAI21_X1
* cell instance $1927 r0 *1 53.39,21
X$1927 672 689 741 150 197 109 OAI21_X1
* cell instance $1928 r0 *1 54.15,21
X$1928 620 563 625 558 109 150 741 AOI22_X1
* cell instance $1932 r0 *1 56.43,21
X$1932 591 690 615 739 670 109 150 624 AOI221_X1
* cell instance $1933 r0 *1 57.57,21
X$1933 182 542 313 573 109 150 686 AOI22_X1
* cell instance $1934 m0 *1 58.33,21
X$1934 182 536 313 466 109 150 599 AOI22_X1
* cell instance $1936 m0 *1 59.28,21
X$1936 687 627 686 150 629 109 OAI21_X1
* cell instance $1937 m0 *1 60.04,21
X$1937 277 514 505 150 627 109 OAI21_X1
* cell instance $1940 m0 *1 61.75,21
X$1940 109 2398 684 639 142 150 DFF_X1
* cell instance $1941 m0 *1 64.98,21
X$1941 684 109 150 620 CLKBUF_X2
* cell instance $1944 m0 *1 68.02,21
X$1944 635 439 625 109 150 638 MUX2_X1
* cell instance $1947 m0 *1 71.06,21
X$1947 628 109 150 625 BUF_X2
* cell instance $1949 r0 *1 58.52,21
X$1949 673 109 150 142 CLKBUF_X3
* cell instance $1953 r0 *1 59.47,21
X$1953 142 109 150 2352 INV_X4
* cell instance $1954 r0 *1 60.42,21
X$1954 182 563 313 558 109 150 785 AOI22_X1
* cell instance $1956 r0 *1 61.75,21
X$1956 147 109 150 2360 INV_X2
* cell instance $1959 r0 *1 66.88,21
X$1959 736 109 150 680 BUF_X1
* cell instance $1962 r0 *1 68.02,21
X$1962 681 439 674 109 150 724 MUX2_X1
* cell instance $1963 r0 *1 69.35,21
X$1963 735 109 150 674 CLKBUF_X2
* cell instance $1965 r0 *1 70.49,21
X$1965 734 109 150 679 BUF_X1
* cell instance $1966 r0 *1 71.06,21
X$1966 732 726 707 109 150 727 MUX2_X1
* cell instance $1967 m0 *1 72.39,21
X$1967 637 109 150 676 BUF_X1
* cell instance $1970 r0 *1 72.39,21
X$1970 728 109 150 681 BUF_X1
* cell instance $1972 r0 *1 73.15,21
X$1972 778 150 707 109 BUF_X4
* cell instance $1973 m0 *1 73.91,21
X$1973 629 109 150 675 BUF_X1
* cell instance $1974 m0 *1 73.34,21
X$1974 632 109 150 635 BUF_X1
* cell instance $1977 m0 *1 3.99,26.6
X$1977 823 109 150 799 BUF_X1
* cell instance $1979 m0 *1 4.56,26.6
X$1979 833 109 150 834 BUF_X1
* cell instance $1981 m0 *1 5.89,26.6
X$1981 834 700 852 109 150 851 MUX2_X1
* cell instance $1982 m0 *1 7.22,26.6
X$1982 109 851 650 808 852 150 DFF_X2
* cell instance $1986 m0 *1 13.3,26.6
X$1986 673 109 150 650 CLKBUF_X3
* cell instance $1987 m0 *1 14.25,26.6
X$1987 673 109 150 274 CLKBUF_X3
* cell instance $1988 m0 *1 15.2,26.6
X$1988 109 850 886 835 335 150 DFF_X1
* cell instance $1990 m0 *1 19.19,26.6
X$1990 782 801 899 802 900 150 109 823 OAI221_X1
* cell instance $1991 m0 *1 20.33,26.6
X$1991 803 802 753 109 150 860 MUX2_X1
* cell instance $1994 m0 *1 22.61,26.6
X$1994 745 109 150 837 INV_X2
* cell instance $1995 m0 *1 23.18,26.6
X$1995 837 150 661 109 BUF_X4
* cell instance $1997 m0 *1 25.27,26.6
X$1997 756 754 757 109 150 786 NAND3_X2
* cell instance $1998 m0 *1 26.6,26.6
X$1998 708 386 109 150 825 OR2_X2
* cell instance $2005 m0 *1 1.71,26.6
X$2005 850 109 150 798 BUF_X1
* cell instance $2006 m0 *1 2.85,26.6
X$2006 800 109 150 820 BUF_X1
* cell instance $2015 r0 *1 8.74,26.6
X$2015 862 109 150 863 BUF_X1
* cell instance $2018 r0 *1 10.26,26.6
X$2018 863 589 473 109 150 700 NAND3_X2
* cell instance $2020 r0 *1 11.78,26.6
X$2020 863 427 473 150 952 109 OAI21_X1
* cell instance $2024 r0 *1 13.87,26.6
X$2024 650 109 150 2351 INV_X4
* cell instance $2027 r0 *1 15.77,26.6
X$2027 897 864 882 109 835 150 AOI21_X1
* cell instance $2030 r0 *1 18.24,26.6
X$2030 886 109 150 836 CLKBUF_X3
* cell instance $2034 r0 *1 20.52,26.6
X$2034 868 869 865 109 150 900 NAND3_X1
* cell instance $2035 r0 *1 21.28,26.6
X$2035 866 109 150 865 INV_X1
* cell instance $2037 r0 *1 21.85,26.6
X$2037 222 867 150 109 868 AND2_X1
* cell instance $2039 r0 *1 22.8,26.6
X$2039 109 296 837 836 806 150 AOI21_X4
* cell instance $2042 r0 *1 26.41,26.6
X$2042 659 802 295 109 150 923 MUX2_X1
* cell instance $2043 r0 *1 27.74,26.6
X$2043 546 554 222 869 923 150 109 515 OAI221_X1
* cell instance $2044 m0 *1 28.69,26.6
X$2044 860 870 109 150 495 NOR2_X1
* cell instance $2045 m0 *1 27.93,26.6
X$2045 707 708 760 109 150 804 NAND3_X1
* cell instance $2047 r0 *1 28.88,26.6
X$2047 159 221 473 150 1050 109 OAI21_X1
* cell instance $2049 m0 *1 29.83,26.6
X$2049 758 473 159 109 517 150 NAND3_X4
* cell instance $2051 m0 *1 32.3,26.6
X$2051 109 807 838 761 759 150 AOI21_X4
* cell instance $2054 r0 *1 30.02,26.6
X$2054 802 109 150 924 INV_X1
* cell instance $2056 r0 *1 30.78,26.6
X$2056 925 546 867 150 109 888 HA_X1
* cell instance $2057 r0 *1 32.68,26.6
X$2057 870 109 150 902 INV_X1
* cell instance $2058 r0 *1 33.06,26.6
X$2058 524 109 150 889 INV_X2
* cell instance $2059 r0 *1 33.63,26.6
X$2059 888 497 109 150 892 NAND2_X1
* cell instance $2060 r0 *1 34.2,26.6
X$2060 806 109 150 645 INV_X4
* cell instance $2061 r0 *1 35.15,26.6
X$2061 871 150 332 109 BUF_X4
* cell instance $2063 m0 *1 35.91,26.6
X$2063 109 587 150 745 BUF_X8
* cell instance $2064 r0 *1 36.48,26.6
X$2064 892 109 150 305 CLKBUF_X3
* cell instance $2065 r0 *1 37.43,26.6
X$2065 871 456 150 109 893 AND2_X1
* cell instance $2066 r0 *1 38.19,26.6
X$2066 893 109 150 487 CLKBUF_X2
* cell instance $2067 m0 *1 38.95,26.6
X$2067 457 150 623 109 BUF_X4
* cell instance $2073 r0 *1 39.52,26.6
X$2073 306 911 109 150 872 NOR2_X1
* cell instance $2074 r0 *1 40.09,26.6
X$2074 388 150 763 109 BUF_X4
* cell instance $2075 r0 *1 41.42,26.6
X$2075 305 109 150 714 CLKBUF_X3
* cell instance $2076 m0 *1 42.18,26.6
X$2076 645 839 740 874 720 109 150 766 AOI221_X1
* cell instance $2077 m0 *1 41.42,26.6
X$2077 873 797 150 109 839 AND2_X1
* cell instance $2078 m0 *1 43.32,26.6
X$2078 587 808 589 150 720 109 NOR3_X2
* cell instance $2079 m0 *1 44.65,26.6
X$2079 109 589 716 587 843 150 NOR3_X4
* cell instance $2080 m0 *1 47.31,26.6
X$2080 592 720 600 667 797 815 150 109 AOI221_X2
* cell instance $2081 m0 *1 49.4,26.6
X$2081 716 109 150 841 INV_X1
* cell instance $2082 m0 *1 49.78,26.6
X$2082 366 841 840 109 150 810 NAND3_X1
* cell instance $2084 m0 *1 50.73,26.6
X$2084 271 499 458 322 498 150 109 829 OAI221_X1
* cell instance $2085 m0 *1 51.87,26.6
X$2085 811 829 810 828 109 150 734 AOI22_X1
* cell instance $2086 m0 *1 52.82,26.6
X$2086 271 557 556 812 842 109 150 828 AOI221_X1
* cell instance $2088 m0 *1 54.72,26.6
X$2088 812 690 615 843 670 109 150 844 AOI221_X1
* cell instance $2089 m0 *1 55.86,26.6
X$2089 814 843 813 643 812 858 150 109 AOI221_X2
* cell instance $2090 m0 *1 57.95,26.6
X$2090 844 845 861 150 846 109 OAI21_X1
* cell instance $2094 r0 *1 42.94,26.6
X$2094 873 812 150 109 890 AND2_X1
* cell instance $2095 r0 *1 43.7,26.6
X$2095 890 891 740 874 843 887 150 109 AOI221_X2
* cell instance $2097 r0 *1 46.55,26.6
X$2097 427 109 150 840 CLKBUF_X3
* cell instance $2098 r0 *1 47.5,26.6
X$2098 559 379 150 109 875 AND2_X1
* cell instance $2101 r0 *1 49.97,26.6
X$2101 549 150 842 109 BUF_X4
* cell instance $2102 r0 *1 51.3,26.6
X$2102 722 446 623 150 876 109 NOR3_X2
* cell instance $2105 r0 *1 53.77,26.6
X$2105 531 150 788 109 BUF_X4
* cell instance $2107 r0 *1 55.29,26.6
X$2107 875 560 788 876 561 109 150 859 AOI221_X1
* cell instance $2108 r0 *1 56.43,26.6
X$2108 875 690 615 876 670 109 150 905 AOI221_X1
* cell instance $2109 r0 *1 57.57,26.6
X$2109 814 876 813 643 875 884 150 109 AOI221_X2
* cell instance $2113 m0 *1 59.28,26.6
X$2113 271 563 442 558 109 150 847 AOI22_X1
* cell instance $2116 r0 *1 59.66,26.6
X$2116 887 917 847 150 880 109 OAI21_X1
* cell instance $2117 r0 *1 60.42,26.6
X$2117 859 877 885 150 879 109 OAI21_X1
* cell instance $2118 m0 *1 61.56,26.6
X$2118 858 916 857 150 568 109 OAI21_X1
* cell instance $2119 m0 *1 60.61,26.6
X$2119 271 542 442 573 109 150 857 AOI22_X1
* cell instance $2122 r0 *1 61.18,26.6
X$2122 884 883 987 150 567 109 OAI21_X1
* cell instance $2125 m0 *1 63.46,26.6
X$2125 673 109 150 725 CLKBUF_X3
* cell instance $2128 m0 *1 66.12,26.6
X$2128 109 2392 856 855 725 150 DFF_X1
* cell instance $2129 m0 *1 65.55,26.6
X$2129 846 109 150 817 BUF_X1
* cell instance $2130 m0 *1 69.35,26.6
X$2130 856 150 754 109 BUF_X4
* cell instance $2131 m0 *1 70.68,26.6
X$2131 821 726 754 109 150 855 MUX2_X1
* cell instance $2132 m0 *1 72.01,26.6
X$2132 853 726 757 109 150 854 MUX2_X1
* cell instance $2135 r0 *1 66.12,26.6
X$2135 881 726 708 109 150 914 MUX2_X1
* cell instance $2136 r0 *1 67.45,26.6
X$2136 849 109 150 881 BUF_X1
* cell instance $2137 r0 *1 68.02,26.6
X$2137 880 109 150 878 BUF_X1
* cell instance $2141 r0 *1 69.92,26.6
X$2141 879 109 150 913 BUF_X1
* cell instance $2143 r0 *1 70.87,26.6
X$2143 109 2432 774 854 725 150 DFF_X1
* cell instance $2144 m0 *1 73.91,26.6
X$2144 848 109 150 853 BUF_X1
* cell instance $2149 m0 *1 2.66,9.8
X$2149 254 109 150 316 BUF_X1
* cell instance $2154 m0 *1 8.55,9.8
X$2154 120 333 289 109 150 317 MUX2_X1
* cell instance $2155 m0 *1 9.88,9.8
X$2155 109 317 274 293 289 150 DFF_X2
* cell instance $2158 m0 *1 15.2,9.8
X$2158 202 216 255 109 150 321 MUX2_X1
* cell instance $2171 r0 *1 5.32,9.8
X$2171 316 333 287 109 150 351 MUX2_X1
* cell instance $2172 r0 *1 6.65,9.8
X$2172 109 351 274 288 287 150 DFF_X2
* cell instance $2173 r0 *1 10.26,9.8
X$2173 109 291 363 334 274 150 DFF_X1
* cell instance $2176 r0 *1 14.44,9.8
X$2176 109 2451 377 321 274 150 DFF_X1
* cell instance $2178 m0 *1 17.86,9.8
X$2178 122 216 290 109 150 292 MUX2_X1
* cell instance $2183 m0 *1 24.51,9.8
X$2183 170 109 150 256 INV_X1
* cell instance $2185 r0 *1 18.05,9.8
X$2185 109 2457 354 292 335 150 DFF_X1
* cell instance $2186 r0 *1 21.28,9.8
X$2186 354 109 150 290 BUF_X2
* cell instance $2187 r0 *1 22.04,9.8
X$2187 336 291 109 150 169 OR2_X1
* cell instance $2189 r0 *1 23.18,9.8
X$2189 336 293 109 150 170 OR2_X1
* cell instance $2190 r0 *1 23.94,9.8
X$2190 336 288 109 150 129 OR2_X1
* cell instance $2191 r0 *1 24.7,9.8
X$2191 129 109 150 356 INV_X1
* cell instance $2192 r0 *1 25.08,9.8
X$2192 296 256 294 237 338 281 150 109 AOI221_X2
* cell instance $2193 m0 *1 25.27,9.8
X$2193 169 109 150 279 INV_X1
* cell instance $2194 m0 *1 25.65,9.8
X$2194 296 279 294 290 338 327 150 109 AOI221_X2
* cell instance $2195 m0 *1 27.74,9.8
X$2195 109 386 164 218 215 203 150 OR4_X4
* cell instance $2197 m0 *1 30.4,9.8
X$2197 203 220 280 150 258 109 OAI21_X1
* cell instance $2198 m0 *1 32.3,9.8
X$2198 328 327 284 259 262 150 109 114 OAI221_X1
* cell instance $2199 m0 *1 33.44,9.8
X$2199 164 220 280 150 328 109 OAI21_X1
* cell instance $2200 m0 *1 34.2,9.8
X$2200 226 222 109 150 298 NAND2_X1
* cell instance $2202 m0 *1 35.53,9.8
X$2202 267 164 109 150 263 NOR2_X1
* cell instance $2203 m0 *1 36.1,9.8
X$2203 301 264 263 303 332 286 150 109 AOI221_X2
* cell instance $2204 m0 *1 38.19,9.8
X$2204 267 215 109 150 345 NOR2_X1
* cell instance $2206 m0 *1 38.95,9.8
X$2206 329 174 223 109 282 150 AOI21_X1
* cell instance $2210 m0 *1 42.18,9.8
X$2210 109 306 150 266 BUF_X8
* cell instance $2213 r0 *1 27.17,9.8
X$2213 109 203 215 218 164 339 150 NOR4_X4
* cell instance $2215 r0 *1 30.78,9.8
X$2215 215 220 280 150 340 109 OAI21_X1
* cell instance $2216 r0 *1 31.54,9.8
X$2216 340 382 298 259 299 150 109 113 OAI221_X1
* cell instance $2217 r0 *1 32.68,9.8
X$2217 174 221 109 150 299 NAND2_X1
* cell instance $2218 r0 *1 33.25,9.8
X$2218 300 293 341 109 150 342 NOR3_X1
* cell instance $2219 r0 *1 34.01,9.8
X$2219 300 288 341 109 150 331 NOR3_X1
* cell instance $2220 r0 *1 34.77,9.8
X$2220 267 203 109 150 359 NOR2_X1
* cell instance $2221 r0 *1 35.34,9.8
X$2221 267 218 109 150 343 NOR2_X1
* cell instance $2222 r0 *1 35.91,9.8
X$2222 344 264 359 303 302 330 150 109 AOI221_X2
* cell instance $2223 r0 *1 38,9.8
X$2223 346 264 345 303 302 329 150 109 AOI221_X2
* cell instance $2224 r0 *1 40.09,9.8
X$2224 305 109 150 225 CLKBUF_X3
* cell instance $2228 r0 *1 43.7,9.8
X$2228 305 109 150 205 CLKBUF_X3
* cell instance $2231 r0 *1 45.6,9.8
X$2231 380 205 361 109 246 150 AOI21_X1
* cell instance $2233 r0 *1 47.88,9.8
X$2233 360 264 358 303 302 308 150 109 AOI221_X2
* cell instance $2235 m0 *1 48.26,9.8
X$2235 264 307 326 303 332 109 150 268 AOI221_X1
* cell instance $2236 m0 *1 49.4,9.8
X$2236 267 277 109 150 326 NOR2_X1
* cell instance $2237 m0 *1 49.97,9.8
X$2237 309 183 223 109 325 150 AOI21_X1
* cell instance $2239 m0 *1 50.92,9.8
X$2239 310 205 325 109 179 150 AOI21_X1
* cell instance $2240 m0 *1 51.68,9.8
X$2240 225 212 109 150 310 NOR2_X1
* cell instance $2242 r0 *1 49.97,9.8
X$2242 225 313 109 150 269 NOR2_X1
* cell instance $2243 r0 *1 51.3,9.8
X$2243 267 270 109 150 358 NOR2_X1
* cell instance $2245 m0 *1 55.86,9.8
X$2245 323 109 150 277 CLKBUF_X2
* cell instance $2246 m0 *1 52.63,9.8
X$2246 109 2404 323 324 136 150 DFF_X1
* cell instance $2250 r0 *1 52.82,9.8
X$2250 141 158 312 109 150 376 MUX2_X1
* cell instance $2254 r0 *1 56.24,9.8
X$2254 357 109 150 312 CLKBUF_X2
* cell instance $2255 r0 *1 57,9.8
X$2255 151 158 349 109 150 355 MUX2_X1
* cell instance $2258 m0 *1 58.52,9.8
X$2258 320 109 150 322 BUF_X2
* cell instance $2259 m0 *1 60.8,9.8
X$2259 109 2391 318 319 147 150 DFF_X1
* cell instance $2260 m0 *1 64.03,9.8
X$2260 318 109 150 271 BUF_X2
* cell instance $2267 r0 *1 61.94,9.8
X$2267 272 109 150 270 BUF_X2
* cell instance $2273 m0 *1 65.93,9.8
X$2273 109 2395 314 315 147 150 DFF_X1
* cell instance $2279 r0 *1 68.78,9.8
X$2279 314 109 150 313 BUF_X2
* cell instance $2280 r0 *1 69.54,9.8
X$2280 350 109 150 352 BUF_X1
* cell instance $2286 m0 *1 2.66,65.8
X$2286 2043 109 150 2026 BUF_X1
* cell instance $2289 m0 *1 4.75,65.8
X$2289 2026 1733 2058 109 150 2030 MUX2_X1
* cell instance $2291 m0 *1 6.27,65.8
X$2291 109 2030 1457 2008 2058 150 DFF_X2
* cell instance $2293 m0 *1 10.07,65.8
X$2293 2222 1733 2032 109 150 2002 MUX2_X1
* cell instance $2294 m0 *1 11.4,65.8
X$2294 109 2044 1638 1962 2059 150 DFF_X2
* cell instance $2296 m0 *1 15.2,65.8
X$2296 2003 1659 2005 109 150 2004 MUX2_X1
* cell instance $2300 m0 *1 19,65.8
X$2300 109 2373 2046 2037 1600 150 DFF_X1
* cell instance $2302 m0 *1 22.42,65.8
X$2302 1361 2007 1759 2009 109 150 2064 AOI22_X2
* cell instance $2303 m0 *1 24.13,65.8
X$2303 1361 2010 1759 2005 109 150 2065 AOI22_X2
* cell instance $2304 m0 *1 25.84,65.8
X$2304 2012 1810 2011 1146 1594 2072 150 109 AOI221_X2
* cell instance $2305 m0 *1 27.93,65.8
X$2305 1460 2013 150 109 2042 AND2_X2
* cell instance $2318 r0 *1 11.4,65.8
X$2318 2127 1733 2059 109 150 2044 MUX2_X1
* cell instance $2320 r0 *1 14.25,65.8
X$2320 2069 1659 2006 109 150 2060 MUX2_X1
* cell instance $2321 r0 *1 15.58,65.8
X$2321 109 2470 2006 2060 1600 150 DFF_X1
* cell instance $2323 r0 *1 21.85,65.8
X$2323 2046 109 150 1849 BUF_X2
* cell instance $2325 r0 *1 22.8,65.8
X$2325 2083 109 150 1699 CLKBUF_X2
* cell instance $2326 r0 *1 23.56,65.8
X$2326 763 2047 109 150 2070 NOR2_X1
* cell instance $2327 r0 *1 24.13,65.8
X$2327 2064 1810 2070 1146 1594 2121 150 109 AOI221_X2
* cell instance $2328 r0 *1 26.22,65.8
X$2328 2065 1810 2071 1146 1594 2089 150 109 AOI221_X2
* cell instance $2329 r0 *1 28.31,65.8
X$2329 665 2066 1403 2042 1398 2073 150 109 AOI221_X2
* cell instance $2331 m0 *1 29.26,65.8
X$2331 2049 665 1403 1991 1398 109 150 2074 AOI221_X1
* cell instance $2332 m0 *1 30.59,65.8
X$2332 1535 2017 1042 1681 2015 2050 150 109 AOI221_X2
* cell instance $2333 m0 *1 32.68,65.8
X$2333 109 1406 2008 587 2017 150 NOR3_X4
* cell instance $2334 m0 *1 35.34,65.8
X$2334 1536 2015 1005 2017 1622 2078 150 109 AOI221_X2
* cell instance $2335 m0 *1 37.43,65.8
X$2335 1407 2015 1369 2017 1465 2125 150 109 AOI221_X2
* cell instance $2336 m0 *1 39.52,65.8
X$2336 1361 1961 1759 2018 109 150 2053 AOI22_X2
* cell instance $2338 r0 *1 30.4,65.8
X$2338 2075 665 1403 2015 1398 109 150 2094 AOI221_X1
* cell instance $2341 r0 *1 32.49,65.8
X$2341 1535 2000 1042 1681 2042 2051 150 109 AOI221_X2
* cell instance $2342 r0 *1 34.58,65.8
X$2342 1536 2042 1005 2000 1622 2077 150 109 AOI221_X2
* cell instance $2343 r0 *1 36.67,65.8
X$2343 2016 2068 2097 150 2133 109 OAI21_X1
* cell instance $2345 r0 *1 37.62,65.8
X$2345 2047 1762 1527 150 2068 109 OAI21_X1
* cell instance $2348 r0 *1 39.33,65.8
X$2348 1460 2018 150 109 2021 AND2_X2
* cell instance $2349 r0 *1 40.28,65.8
X$2349 2053 1810 2093 1146 1594 2092 150 109 AOI221_X2
* cell instance $2350 m0 *1 41.8,65.8
X$2350 2041 1810 2054 1146 1594 2106 150 109 AOI221_X2
* cell instance $2353 m0 *1 44.08,65.8
X$2353 109 1406 1984 587 2022 150 NOR3_X4
* cell instance $2354 m0 *1 46.74,65.8
X$2354 1407 2021 1369 2022 1465 2080 150 109 AOI221_X2
* cell instance $2355 m0 *1 48.83,65.8
X$2355 1535 1994 1042 1681 2023 2081 150 109 AOI221_X2
* cell instance $2356 m0 *1 50.92,65.8
X$2356 1407 2023 1369 1994 1465 2111 150 109 AOI221_X2
* cell instance $2359 m0 *1 53.96,65.8
X$2359 2063 109 150 1898 CLKBUF_X2
* cell instance $2360 m0 *1 54.72,65.8
X$2360 2061 1841 1897 109 150 2035 MUX2_X1
* cell instance $2361 m0 *1 56.05,65.8
X$2361 109 2396 2034 2035 1778 150 DFF_X1
* cell instance $2362 m0 *1 59.28,65.8
X$2362 2034 109 150 1897 BUF_X2
* cell instance $2366 r0 *1 42.37,65.8
X$2366 763 2088 109 150 2054 NOR2_X1
* cell instance $2368 r0 *1 43.32,65.8
X$2368 665 2087 1403 2021 1398 2134 150 109 AOI221_X2
* cell instance $2369 r0 *1 45.41,65.8
X$2369 2067 1235 1403 2023 1398 109 150 2079 AOI221_X1
* cell instance $2371 r0 *1 46.74,65.8
X$2371 1535 2022 1042 1681 2021 2135 150 109 AOI221_X2
* cell instance $2372 r0 *1 48.83,65.8
X$2372 1536 2021 1005 2022 1622 2120 150 109 AOI221_X2
* cell instance $2373 r0 *1 50.92,65.8
X$2373 109 2463 2063 2062 1778 150 DFF_X1
* cell instance $2374 r0 *1 54.15,65.8
X$2374 2159 1695 1898 109 150 2062 MUX2_X1
* cell instance $2380 r0 *1 61.94,65.8
X$2380 2056 1799 1900 109 150 2057 MUX2_X1
* cell instance $2381 m0 *1 65.93,65.8
X$2381 2031 109 150 1900 CLKBUF_X2
* cell instance $2382 m0 *1 62.7,65.8
X$2382 109 2407 2031 2057 1579 150 DFF_X1
* cell instance $2393 m0 *1 13.87,74.2
X$2393 1886 109 150 2265 BUF_X1
* cell instance $2395 m0 *1 14.44,74.2
X$2395 2297 109 150 2003 BUF_X1
* cell instance $2396 m0 *1 15.01,74.2
X$2396 2298 109 150 2045 BUF_X1
* cell instance $2397 m0 *1 15.58,74.2
X$2397 2299 109 150 2069 BUF_X1
* cell instance $2398 m0 *1 16.15,74.2
X$2398 2300 109 150 2195 BUF_X1
* cell instance $2399 m0 *1 16.72,74.2
X$2399 2223 1695 2047 109 150 2224 MUX2_X1
* cell instance $2400 m0 *1 18.05,74.2
X$2400 1666 109 150 2281 BUF_X1
* cell instance $2402 m0 *1 24.51,74.2
X$2402 1835 109 150 2291 BUF_X1
* cell instance $2404 m0 *1 25.08,74.2
X$2404 2253 109 150 1987 BUF_X1
* cell instance $2405 m0 *1 25.65,74.2
X$2405 1948 109 150 2289 BUF_X1
* cell instance $2406 m0 *1 26.22,74.2
X$2406 1804 109 150 2306 BUF_X1
* cell instance $2408 m0 *1 26.98,74.2
X$2408 2177 109 150 2288 BUF_X1
* cell instance $2409 m0 *1 27.55,74.2
X$2409 2307 109 150 2243 BUF_X1
* cell instance $2410 m0 *1 28.12,74.2
X$2410 2254 109 150 2287 BUF_X1
* cell instance $2412 m0 *1 28.88,74.2
X$2412 2309 109 150 2244 BUF_X1
* cell instance $2414 m0 *1 29.64,74.2
X$2414 2131 109 150 2286 BUF_X1
* cell instance $2416 m0 *1 30.4,74.2
X$2416 1946 109 150 2285 BUF_X1
* cell instance $2417 m0 *1 30.97,74.2
X$2417 2225 109 150 2226 BUF_X1
* cell instance $2418 m0 *1 31.54,74.2
X$2418 2170 109 150 2308 BUF_X1
* cell instance $2419 m0 *1 32.11,74.2
X$2419 2228 109 150 2249 BUF_X1
* cell instance $2420 m0 *1 32.68,74.2
X$2420 1749 109 150 2284 BUF_X1
* cell instance $2421 m0 *1 33.25,74.2
X$2421 1811 109 150 2283 BUF_X1
* cell instance $2422 m0 *1 33.82,74.2
X$2422 1890 109 150 2250 BUF_X1
* cell instance $2423 m0 *1 34.39,74.2
X$2423 2330 109 150 2282 BUF_X1
* cell instance $2425 m0 *1 35.15,74.2
X$2425 2310 109 150 2229 BUF_X1
* cell instance $2426 m0 *1 35.72,74.2
X$2426 1575 109 150 2280 BUF_X1
* cell instance $2427 m0 *1 36.29,74.2
X$2427 2173 109 150 2279 BUF_X1
* cell instance $2428 m0 *1 36.86,74.2
X$2428 2133 109 150 2311 BUF_X1
* cell instance $2429 m0 *1 37.43,74.2
X$2429 2182 109 150 2278 BUF_X1
* cell instance $2430 m0 *1 38,74.2
X$2430 1565 109 150 2277 BUF_X1
* cell instance $2431 m0 *1 38.57,74.2
X$2431 2095 109 150 2276 BUF_X1
* cell instance $2432 m0 *1 39.14,74.2
X$2432 2332 109 150 2275 BUF_X1
* cell instance $2433 m0 *1 39.71,74.2
X$2433 2312 109 150 2248 BUF_X1
* cell instance $2435 m0 *1 4.18,29.4
X$2435 895 109 150 894 BUF_X1
* cell instance $2439 m0 *1 11.02,29.4
X$2439 895 589 109 150 896 NOR2_X1
* cell instance $2440 m0 *1 11.59,29.4
X$2440 952 896 953 109 928 150 AOI21_X1
* cell instance $2442 m0 *1 13.87,29.4
X$2442 661 554 109 150 929 NOR2_X1
* cell instance $2443 m0 *1 14.44,29.4
X$2443 820 889 473 109 150 702 NAND3_X2
* cell instance $2444 m0 *1 15.77,29.4
X$2444 820 338 473 150 897 109 OAI21_X1
* cell instance $2445 m0 *1 16.53,29.4
X$2445 958 898 850 889 109 150 882 NOR4_X1
* cell instance $2446 m0 *1 17.48,29.4
X$2446 891 554 109 150 898 NOR2_X1
* cell instance $2449 m0 *1 19,29.4
X$2449 962 655 752 109 932 150 AOI21_X1
* cell instance $2451 m0 *1 20.52,29.4
X$2451 867 802 869 920 109 150 964 OR4_X1
* cell instance $2452 m0 *1 21.66,29.4
X$2452 866 222 109 150 920 NAND2_X1
* cell instance $2454 m0 *1 22.42,29.4
X$2454 870 802 866 150 109 933 HA_X1
* cell instance $2456 m0 *1 25.84,29.4
X$2456 295 109 150 934 INV_X1
* cell instance $2457 m0 *1 26.22,29.4
X$2457 903 554 109 150 921 NAND2_X1
* cell instance $2458 m0 *1 26.79,29.4
X$2458 903 980 921 150 922 109 OAI21_X1
* cell instance $2460 m0 *1 27.74,29.4
X$2460 933 497 109 150 966 NAND2_X1
* cell instance $2461 m0 *1 28.31,29.4
X$2461 901 109 150 935 BUF_X1
* cell instance $2462 m0 *1 28.88,29.4
X$2462 870 924 2337 150 109 925 HA_X1
* cell instance $2463 m0 *1 30.78,29.4
X$2463 902 924 2336 150 109 936 HA_X1
* cell instance $2464 m0 *1 32.68,29.4
X$2464 902 802 2334 150 109 937 HA_X1
* cell instance $2466 m0 *1 34.77,29.4
X$2466 109 332 903 280 981 222 150 AOI22_X4
* cell instance $2467 m0 *1 38,29.4
X$2467 982 938 984 150 109 870 OAI21_X2
* cell instance $2468 m0 *1 39.33,29.4
X$2468 872 940 939 150 109 869 OAI21_X2
* cell instance $2469 m0 *1 40.66,29.4
X$2469 109 941 911 904 938 150 NOR3_X4
* cell instance $2470 m0 *1 43.32,29.4
X$2470 458 150 618 109 BUF_X4
* cell instance $2471 m0 *1 44.65,29.4
X$2471 529 109 150 459 CLKBUF_X3
* cell instance $2472 m0 *1 45.6,29.4
X$2472 669 645 150 109 968 AND2_X1
* cell instance $2474 m0 *1 46.55,29.4
X$2474 968 150 690 109 BUF_X4
* cell instance $2476 m0 *1 52.06,29.4
X$2476 446 109 150 944 INV_X1
* cell instance $2477 m0 *1 53.58,29.4
X$2477 769 109 150 504 CLKBUF_X3
* cell instance $2484 r0 *1 1.33,29.4
X$2484 972 109 150 926 BUF_X1
* cell instance $2487 r0 *1 2.47,29.4
X$2487 976 109 150 969 BUF_X1
* cell instance $2495 r0 *1 8.17,29.4
X$2495 974 109 150 927 BUF_X1
* cell instance $2496 r0 *1 8.74,29.4
X$2496 930 109 150 971 BUF_X1
* cell instance $2499 r0 *1 10.26,29.4
X$2499 109 895 973 928 650 150 DFF_X1
* cell instance $2500 r0 *1 13.49,29.4
X$2500 993 661 929 975 364 953 150 109 AOI221_X2
* cell instance $2503 r0 *1 17.48,29.4
X$2503 891 995 150 109 958 AND2_X1
* cell instance $2504 r0 *1 18.24,29.4
X$2504 338 1016 669 150 109 962 AND3_X1
* cell instance $2505 r0 *1 19.19,29.4
X$2505 932 931 965 1182 109 150 972 NAND4_X1
* cell instance $2506 r0 *1 20.14,29.4
X$2506 610 752 933 868 109 150 1039 AOI22_X1
* cell instance $2508 r0 *1 21.47,29.4
X$2508 964 703 978 998 109 150 974 NAND4_X1
* cell instance $2509 r0 *1 22.42,29.4
X$2509 868 935 109 150 965 NAND2_X1
* cell instance $2513 r0 *1 25.65,29.4
X$2513 109 930 1002 1000 172 150 DFF_X1
* cell instance $2514 r0 *1 28.88,29.4
X$2514 901 222 546 109 1001 150 NAND3_X4
* cell instance $2515 r0 *1 31.35,29.4
X$2515 871 109 150 758 INV_X4
* cell instance $2517 r0 *1 32.68,29.4
X$2517 981 109 150 546 INV_X4
* cell instance $2520 r0 *1 34.2,29.4
X$2520 937 109 150 901 BUF_X1
* cell instance $2521 r0 *1 34.77,29.4
X$2521 645 889 109 150 1004 NOR2_X2
* cell instance $2522 r0 *1 35.72,29.4
X$2522 903 871 109 499 150 NAND2_X4
* cell instance $2523 r0 *1 37.43,29.4
X$2523 306 948 109 150 982 NOR2_X1
* cell instance $2524 r0 *1 38,29.4
X$2524 1006 938 940 150 109 981 OAI21_X4
* cell instance $2525 r0 *1 40.47,29.4
X$2525 109 306 911 904 941 802 150 NOR4_X4
* cell instance $2526 r0 *1 43.89,29.4
X$2526 645 150 891 109 BUF_X4
* cell instance $2530 r0 *1 46.55,29.4
X$2530 719 150 670 109 BUF_X4
* cell instance $2533 r0 *1 50.16,29.4
X$2533 531 150 1005 109 BUF_X4
* cell instance $2534 r0 *1 51.49,29.4
X$2534 942 944 840 109 150 967 NAND3_X1
* cell instance $2535 r0 *1 52.25,29.4
X$2535 459 148 109 150 945 NAND2_X1
* cell instance $2536 r0 *1 52.82,29.4
X$2536 945 943 967 946 109 150 961 AOI22_X1
* cell instance $2538 r0 *1 53.96,29.4
X$2538 757 109 150 760 INV_X2
* cell instance $2539 r0 *1 54.53,29.4
X$2539 592 150 814 109 BUF_X4
* cell instance $2541 m0 *1 54.91,29.4
X$2541 600 150 813 109 BUF_X4
* cell instance $2543 m0 *1 57.38,29.4
X$2543 905 919 918 150 915 109 OAI21_X1
* cell instance $2544 m0 *1 56.62,29.4
X$2544 270 464 504 150 919 109 OAI21_X1
* cell instance $2550 m0 *1 59.66,29.4
X$2550 322 947 906 150 917 109 OAI21_X1
* cell instance $2553 m0 *1 60.61,29.4
X$2553 270 947 906 150 877 109 OAI21_X1
* cell instance $2555 m0 *1 61.56,29.4
X$2555 322 907 963 150 916 109 OAI21_X1
* cell instance $2556 m0 *1 62.32,29.4
X$2556 270 907 963 150 883 109 OAI21_X1
* cell instance $2560 m0 *1 66.69,29.4
X$2560 908 150 708 109 BUF_X4
* cell instance $2561 m0 *1 63.46,29.4
X$2561 109 2390 908 914 725 150 DFF_X1
* cell instance $2562 m0 *1 68.02,29.4
X$2562 915 109 150 910 BUF_X1
* cell instance $2563 m0 *1 68.59,29.4
X$2563 909 109 150 948 CLKBUF_X3
* cell instance $2564 m0 *1 69.54,29.4
X$2564 955 109 150 960 BUF_X1
* cell instance $2568 r0 *1 65.36,29.4
X$2568 109 2473 909 959 725 150 DFF_X1
* cell instance $2569 r0 *1 68.59,29.4
X$2569 996 949 948 109 150 959 MUX2_X1
* cell instance $2570 r0 *1 69.92,29.4
X$2570 467 949 941 109 150 988 MUX2_X1
* cell instance $2571 m0 *1 70.68,29.4
X$2571 912 109 150 996 BUF_X1
* cell instance $2573 m0 *1 71.25,29.4
X$2573 954 949 911 109 150 950 MUX2_X1
* cell instance $2574 m0 *1 72.58,29.4
X$2574 956 109 150 957 BUF_X1
* cell instance $2576 m0 *1 73.34,29.4
X$2576 951 109 150 954 BUF_X1
* cell instance $2578 r0 *1 71.25,29.4
X$2578 109 2462 994 950 725 150 DFF_X1
* cell instance $2582 m0 *1 1.9,32.2
X$2582 1008 109 150 990 BUF_X1
* cell instance $2584 m0 *1 2.47,32.2
X$2584 1009 109 150 1010 BUF_X1
* cell instance $2597 r0 *1 3.8,32.2
X$2597 1010 1075 1012 109 150 1076 MUX2_X1
* cell instance $2598 r0 *1 5.13,32.2
X$2598 109 1076 650 1011 1012 150 DFF_X2
* cell instance $2599 m0 *1 6.27,32.2
X$2599 990 1075 1013 109 150 1033 MUX2_X1
* cell instance $2600 m0 *1 5.7,32.2
X$2600 970 109 150 803 BUF_X1
* cell instance $2601 m0 *1 7.6,32.2
X$2601 109 986 991 1033 650 150 DFF_X1
* cell instance $2602 m0 *1 10.83,32.2
X$2602 991 109 150 1013 BUF_X2
* cell instance $2606 r0 *1 8.93,32.2
X$2606 1013 109 150 1052 INV_X1
* cell instance $2610 r0 *1 11.4,32.2
X$2610 1053 1014 109 150 1054 NOR2_X1
* cell instance $2611 r0 *1 11.97,32.2
X$2611 1012 1054 411 109 150 1149 OR3_X2
* cell instance $2612 r0 *1 13.11,32.2
X$2612 1012 1078 1055 1013 150 109 975 OAI22_X2
* cell instance $2613 m0 *1 13.68,32.2
X$2613 973 109 150 977 CLKBUF_X3
* cell instance $2618 r0 *1 14.82,32.2
X$2618 364 1014 1015 150 109 745 OAI21_X4
* cell instance $2619 r0 *1 17.29,32.2
X$2619 803 109 150 1057 INV_X1
* cell instance $2621 m0 *1 17.29,32.2
X$2621 977 109 150 427 CLKBUF_X3
* cell instance $2623 m0 *1 22.8,32.2
X$2623 979 1017 221 109 150 931 NAND3_X1
* cell instance $2624 m0 *1 23.56,32.2
X$2624 1017 109 150 1085 INV_X1
* cell instance $2627 m0 *1 26.22,32.2
X$2627 758 930 109 150 999 OR2_X1
* cell instance $2628 m0 *1 26.98,32.2
X$2628 1050 922 1047 109 1000 150 AOI21_X1
* cell instance $2631 m0 *1 28.69,32.2
X$2631 497 901 546 150 109 1161 AND3_X1
* cell instance $2633 m0 *1 29.83,32.2
X$2633 903 109 150 805 INV_X2
* cell instance $2634 m0 *1 30.4,32.2
X$2634 1002 150 871 109 BUF_X4
* cell instance $2639 r0 *1 18.24,32.2
X$2639 1056 1016 338 109 150 1038 NAND3_X1
* cell instance $2641 r0 *1 19.38,32.2
X$2641 1083 1082 1038 1039 109 150 976 NAND4_X1
* cell instance $2642 r0 *1 20.33,32.2
X$2642 1059 803 109 150 1048 NAND2_X1
* cell instance $2643 r0 *1 20.9,32.2
X$2643 1060 1059 2340 150 109 1088 HA_X1
* cell instance $2644 r0 *1 22.8,32.2
X$2644 1061 1017 221 109 150 1083 NAND3_X1
* cell instance $2645 r0 *1 23.56,32.2
X$2645 1062 1085 758 109 150 1084 NOR3_X1
* cell instance $2647 r0 *1 24.51,32.2
X$2647 1044 1020 1018 1062 109 150 998 NAND4_X1
* cell instance $2649 r0 *1 25.65,32.2
X$2649 1017 1065 109 150 1044 NOR2_X1
* cell instance $2650 r0 *1 26.22,32.2
X$2650 1048 1087 999 1064 1019 1047 150 109 AOI221_X2
* cell instance $2651 r0 *1 28.31,32.2
X$2651 1088 805 1017 150 109 1090 HA_X1
* cell instance $2653 r0 *1 30.59,32.2
X$2653 249 758 1020 109 150 NOR2_X4
* cell instance $2654 r0 *1 32.3,32.2
X$2654 191 1063 1018 150 109 903 OAI21_X4
* cell instance $2655 m0 *1 33.06,32.2
X$2655 936 497 109 150 1089 NAND2_X1
* cell instance $2659 m0 *1 34.58,32.2
X$2659 937 497 109 150 1092 NAND2_X1
* cell instance $2660 m0 *1 35.15,32.2
X$2660 981 497 109 150 1021 NAND2_X1
* cell instance $2664 r0 *1 35.15,32.2
X$2664 1090 109 150 456 CLKBUF_X3
* cell instance $2666 m0 *1 38.19,32.2
X$2666 306 109 150 1006 INV_X1
* cell instance $2667 m0 *1 36.86,32.2
X$2667 520 150 367 109 BUF_X4
* cell instance $2669 m0 *1 38.76,32.2
X$2669 983 948 985 150 109 939 AND3_X1
* cell instance $2670 m0 *1 39.71,32.2
X$2670 109 983 948 985 940 150 NOR3_X4
* cell instance $2671 m0 *1 42.37,32.2
X$2671 985 109 150 904 INV_X2
* cell instance $2672 m0 *1 42.94,32.2
X$2672 986 623 109 150 1049 NOR2_X2
* cell instance $2673 m0 *1 43.89,32.2
X$2673 1022 1045 1046 1007 109 150 569 AOI22_X2
* cell instance $2675 r0 *1 36.86,32.2
X$2675 456 150 303 109 BUF_X4
* cell instance $2677 r0 *1 38.95,32.2
X$2677 985 1066 983 109 150 984 NOR3_X1
* cell instance $2679 r0 *1 39.9,32.2
X$2679 911 109 150 1066 INV_X2
* cell instance $2682 r0 *1 41.61,32.2
X$2682 1021 150 458 109 BUF_X4
* cell instance $2683 r0 *1 42.94,32.2
X$2683 1065 665 366 1049 109 150 1046 AOI22_X2
* cell instance $2684 r0 *1 44.65,32.2
X$2684 754 1110 1111 1065 458 1045 109 150 OAI221_X2
* cell instance $2686 m0 *1 45.98,32.2
X$2686 300 986 341 109 150 1023 NOR3_X1
* cell instance $2687 m0 *1 46.93,32.2
X$2687 600 150 1042 109 BUF_X4
* cell instance $2688 m0 *1 48.26,32.2
X$2688 267 754 109 150 1024 NOR2_X1
* cell instance $2692 r0 *1 46.74,32.2
X$2692 367 1023 1043 1098 109 150 1097 AOI22_X1
* cell instance $2695 r0 *1 48.26,32.2
X$2695 1113 1097 1024 303 302 109 150 1095 AOI221_X1
* cell instance $2696 r0 *1 49.4,32.2
X$2696 267 707 109 150 1145 NOR2_X1
* cell instance $2697 r0 *1 49.97,32.2
X$2697 1011 109 150 1025 INV_X1
* cell instance $2698 r0 *1 50.35,32.2
X$2698 942 1025 840 109 150 1037 NAND3_X1
* cell instance $2699 r0 *1 51.11,32.2
X$2699 1068 1067 1096 109 1041 150 AOI21_X1
* cell instance $2700 m0 *1 51.68,32.2
X$2700 1003 1040 1026 109 1034 150 AOI21_X1
* cell instance $2702 m0 *1 52.44,32.2
X$2702 225 985 109 150 1027 NOR2_X1
* cell instance $2703 m0 *1 53.01,32.2
X$2703 225 911 109 150 1003 NOR2_X1
* cell instance $2704 m0 *1 53.58,32.2
X$2704 459 948 109 150 1094 NAND2_X1
* cell instance $2706 m0 *1 54.91,32.2
X$2706 760 464 504 150 1028 109 OAI21_X1
* cell instance $2708 r0 *1 51.87,32.2
X$2708 1027 1040 1041 109 956 150 AOI21_X2
* cell instance $2709 r0 *1 53.2,32.2
X$2709 1094 1093 1189 1037 109 150 475 AOI22_X2
* cell instance $2710 r0 *1 54.91,32.2
X$2710 1091 1028 1029 150 1036 109 OAI21_X1
* cell instance $2712 m0 *1 1.33,46.2
X$2712 1342 109 150 1425 BUF_X1
* cell instance $2717 r0 *1 2.09,46.2
X$2717 1423 109 150 1426 BUF_X1
* cell instance $2718 m0 *1 5.89,46.2
X$2718 109 2367 1475 1473 1257 150 DFF_X1
* cell instance $2719 m0 *1 2.28,46.2
X$2719 109 1438 1257 2484 1401 150 DFF_X2
* cell instance $2720 m0 *1 9.12,46.2
X$2720 1475 109 150 1043 CLKBUF_X3
* cell instance $2723 r0 *1 2.66,46.2
X$2723 1453 109 150 1454 BUF_X1
* cell instance $2729 r0 *1 5.13,46.2
X$2729 1424 109 150 1455 BUF_X1
* cell instance $2732 r0 *1 7.6,46.2
X$2732 109 1456 1457 1404 1495 150 DFF_X2
* cell instance $2737 r0 *1 16.34,46.2
X$2737 1258 1496 2346 150 109 1458 HA_X1
* cell instance $2739 m0 *1 16.53,46.2
X$2739 1317 109 150 1496 INV_X1
* cell instance $2740 m0 *1 17.1,46.2
X$2740 1258 109 150 1427 INV_X1
* cell instance $2741 m0 *1 17.48,46.2
X$2741 1458 891 1016 150 109 1428 HA_X1
* cell instance $2744 m0 *1 20.33,46.2
X$2744 1428 836 150 420 109 AND2_X4
* cell instance $2745 m0 *1 22.04,46.2
X$2745 400 1289 1198 150 109 806 OAI21_X4
* cell instance $2746 m0 *1 24.51,46.2
X$2746 836 109 150 524 CLKBUF_X3
* cell instance $2748 m0 *1 26.22,46.2
X$2748 1376 1130 1375 109 150 1444 NOR3_X1
* cell instance $2749 m0 *1 26.98,46.2
X$2749 806 150 549 109 BUF_X4
* cell instance $2750 m0 *1 28.31,46.2
X$2750 420 150 1483 109 BUF_X4
* cell instance $2752 m0 *1 29.83,46.2
X$2752 1284 1318 592 109 150 NOR2_X4
* cell instance $2754 m0 *1 31.73,46.2
X$2754 1429 549 1430 1318 1284 1130 109 150 1461 OAI33_X1
* cell instance $2755 m0 *1 33.06,46.2
X$2755 1042 1461 1431 150 1489 109 OAI21_X1
* cell instance $2758 r0 *1 18.24,46.2
X$2758 1427 1496 2343 150 109 1497 HA_X1
* cell instance $2761 r0 *1 20.71,46.2
X$2761 669 1478 1289 1198 1499 109 150 OAI211_X2
* cell instance $2762 r0 *1 22.42,46.2
X$2762 524 669 1459 150 109 1498 AND3_X1
* cell instance $2763 r0 *1 23.37,46.2
X$2763 400 109 150 1477 BUF_X1
* cell instance $2764 r0 *1 23.94,46.2
X$2764 400 109 150 1459 BUF_X1
* cell instance $2766 r0 *1 24.89,46.2
X$2766 1373 109 150 1375 INV_X2
* cell instance $2767 r0 *1 25.46,46.2
X$2767 1459 109 150 1478 BUF_X1
* cell instance $2770 r0 *1 26.98,46.2
X$2770 755 109 150 1303 CLKBUF_X3
* cell instance $2773 r0 *1 29.07,46.2
X$2773 524 109 150 1460 CLKBUF_X3
* cell instance $2774 r0 *1 30.02,46.2
X$2774 1376 1375 109 150 719 NOR2_X2
* cell instance $2777 r0 *1 31.92,46.2
X$2777 1043 1460 109 150 1430 NAND2_X1
* cell instance $2778 r0 *1 32.49,46.2
X$2778 806 1429 667 109 150 NOR2_X4
* cell instance $2779 r0 *1 34.2,46.2
X$2779 806 1448 109 150 1500 NOR2_X2
* cell instance $2781 m0 *1 34.96,46.2
X$2781 549 150 1398 109 BUF_X4
* cell instance $2784 r0 *1 35.34,46.2
X$2784 392 150 1695 109 BUF_X4
* cell instance $2785 r0 *1 36.67,46.2
X$2785 871 150 302 109 BUF_X4
* cell instance $2786 m0 *1 39.14,46.2
X$2786 836 109 150 559 BUF_X2
* cell instance $2787 m0 *1 37.43,46.2
X$2787 1451 1489 1432 1066 109 150 1565 AOI22_X2
* cell instance $2788 m0 *1 39.9,46.2
X$2788 1433 1452 1462 1066 109 150 1490 AOI22_X2
* cell instance $2791 m0 *1 43.32,46.2
X$2791 742 109 150 1484 CLKBUF_X3
* cell instance $2792 m0 *1 44.27,46.2
X$2792 874 150 561 109 BUF_X4
* cell instance $2794 m0 *1 45.79,46.2
X$2794 1483 1404 1311 109 150 1488 NOR3_X1
* cell instance $2796 r0 *1 38,46.2
X$2796 719 150 1465 109 BUF_X4
* cell instance $2797 r0 *1 39.33,46.2
X$2797 1500 150 560 109 BUF_X4
* cell instance $2798 r0 *1 40.66,46.2
X$2798 615 150 1369 109 BUF_X4
* cell instance $2799 r0 *1 41.99,46.2
X$2799 588 109 150 1527 CLKBUF_X3
* cell instance $2802 r0 *1 43.51,46.2
X$2802 771 109 150 1524 CLKBUF_X3
* cell instance $2803 r0 *1 44.46,46.2
X$2803 721 109 150 1504 CLKBUF_X3
* cell instance $2806 r0 *1 46.36,46.2
X$2806 1483 1528 1311 109 150 1463 NOR3_X1
* cell instance $2807 m0 *1 47.12,46.2
X$2807 1168 1488 1098 1401 109 150 1487 AOI22_X2
* cell instance $2809 m0 *1 48.83,46.2
X$2809 1487 1113 1486 1143 302 1482 150 109 AOI221_X2
* cell instance $2810 m0 *1 50.92,46.2
X$2810 1202 1350 109 150 1486 NOR2_X1
* cell instance $2813 r0 *1 47.12,46.2
X$2813 1168 1463 1098 1494 109 150 1526 AOI22_X2
* cell instance $2814 r0 *1 48.83,46.2
X$2814 1526 1113 1485 1143 302 1525 150 109 AOI221_X2
* cell instance $2815 r0 *1 50.92,46.2
X$2815 1202 1464 109 150 1485 NOR2_X1
* cell instance $2817 r0 *1 51.87,46.2
X$2817 1506 1407 615 1502 1465 109 150 1466 AOI221_X1
* cell instance $2818 r0 *1 53.01,46.2
X$2818 1525 1503 1096 109 1467 150 AOI21_X1
* cell instance $2819 m0 *1 54.15,46.2
X$2819 1450 1481 1480 1479 109 150 1439 AOI22_X1
* cell instance $2820 m0 *1 53.39,46.2
X$2820 1482 1381 1096 109 1449 150 AOI21_X1
* cell instance $2821 m0 *1 55.1,46.2
X$2821 1381 1235 1236 1408 842 109 150 1479 AOI221_X1
* cell instance $2826 r0 *1 53.96,46.2
X$2826 1468 1040 1467 109 1476 150 AOI21_X1
* cell instance $2827 r0 *1 54.72,46.2
X$2827 1186 1469 109 150 1468 NOR2_X1
* cell instance $2829 r0 *1 55.67,46.2
X$2829 1503 1235 1236 1506 842 109 150 1505 AOI221_X1
* cell instance $2832 r0 *1 57.76,46.2
X$2832 1506 560 788 1502 561 109 150 1521 AOI221_X1
* cell instance $2834 m0 *1 59.09,46.2
X$2834 588 109 150 906 CLKBUF_X3
* cell instance $2838 m0 *1 60.99,46.2
X$2838 514 109 150 907 CLKBUF_X3
* cell instance $2845 r0 *1 59.09,46.2
X$2845 1503 1169 1469 1204 109 150 1566 AOI22_X1
* cell instance $2846 r0 *1 60.04,46.2
X$2846 1464 947 906 150 1507 109 OAI21_X1
* cell instance $2849 r0 *1 61.94,46.2
X$2849 1464 907 963 150 1508 109 OAI21_X1
* cell instance $2852 r0 *1 63.65,46.2
X$2852 109 2443 1516 1517 1206 150 DFF_X1
* cell instance $2854 m0 *1 66.12,46.2
X$2854 1440 109 150 1381 BUF_X2
* cell instance $2856 m0 *1 67.83,46.2
X$2856 1441 109 150 1435 BUF_X1
* cell instance $2857 m0 *1 68.4,46.2
X$2857 1395 109 150 1471 BUF_X1
* cell instance $2859 m0 *1 72.01,46.2
X$2859 1474 726 1350 109 150 1382 MUX2_X1
* cell instance $2860 m0 *1 73.34,46.2
X$2860 1437 109 150 1474 BUF_X1
* cell instance $2862 r0 *1 66.88,46.2
X$2862 1516 109 150 1503 BUF_X2
* cell instance $2865 r0 *1 68.59,46.2
X$2865 1509 949 1469 109 150 1558 MUX2_X1
* cell instance $2867 r0 *1 70.68,46.2
X$2867 1470 109 150 1469 CLKBUF_X2
* cell instance $2868 r0 *1 71.44,46.2
X$2868 1476 109 150 1472 BUF_X1
* cell instance $2869 r0 *1 72.01,46.2
X$2869 1514 726 1464 109 150 1510 MUX2_X1
* cell instance $2875 m0 *1 19.19,74.2
X$2875 2303 109 150 1784 BUF_X1
* cell instance $2877 m0 *1 19.76,74.2
X$2877 2301 109 150 2148 BUF_X1
* cell instance $2878 m0 *1 20.33,74.2
X$2878 1950 109 150 2237 BUF_X1
* cell instance $2879 m0 *1 20.9,74.2
X$2879 2167 109 150 2290 BUF_X1
* cell instance $2881 m0 *1 21.66,74.2
X$2881 2304 109 150 1694 BUF_X1
* cell instance $2882 m0 *1 22.23,74.2
X$2882 1704 109 150 2238 BUF_X1
* cell instance $2883 m0 *1 22.8,74.2
X$2883 2302 109 150 2128 BUF_X1
* cell instance $2884 m0 *1 23.37,74.2
X$2884 1977 109 150 2292 BUF_X1
* cell instance $2886 m0 *1 40.85,74.2
X$2886 1490 109 150 2274 BUF_X1
* cell instance $2888 m0 *1 41.42,74.2
X$2888 2105 109 150 2273 BUF_X1
* cell instance $2889 m0 *1 41.99,74.2
X$2889 2183 109 150 2272 BUF_X1
* cell instance $2891 m0 *1 42.75,74.2
X$2891 2184 109 150 2271 BUF_X1
* cell instance $2892 m0 *1 43.32,74.2
X$2892 1782 109 150 2270 BUF_X1
* cell instance $2893 m0 *1 43.89,74.2
X$2893 2313 109 150 2230 BUF_X1
* cell instance $2894 m0 *1 44.46,74.2
X$2894 1999 109 150 2269 BUF_X1
* cell instance $2895 m0 *1 45.03,74.2
X$2895 1825 109 150 2268 BUF_X1
* cell instance $2896 m0 *1 45.6,74.2
X$2896 1870 109 150 2267 BUF_X1
* cell instance $2897 m0 *1 46.17,74.2
X$2897 2109 109 150 2266 BUF_X1
* cell instance $2898 m0 *1 46.74,74.2
X$2898 1668 109 150 2264 BUF_X1
* cell instance $2899 m0 *1 47.31,74.2
X$2899 1783 109 150 2247 BUF_X1
* cell instance $2900 m0 *1 47.88,74.2
X$2900 2331 109 150 2067 BUF_X2
* cell instance $2901 m0 *1 48.64,74.2
X$2901 2153 109 150 2263 BUF_X1
* cell instance $2902 m0 *1 49.21,74.2
X$2902 1917 109 150 2262 BUF_X1
* cell instance $2903 m0 *1 49.78,74.2
X$2903 1980 109 150 2245 BUF_X1
* cell instance $2905 m0 *1 50.54,74.2
X$2905 2110 109 150 2261 BUF_X1
* cell instance $2906 m0 *1 51.11,74.2
X$2906 1753 109 150 2260 BUF_X1
* cell instance $2907 m0 *1 51.68,74.2
X$2907 2314 109 150 2231 BUF_X1
* cell instance $2909 m0 *1 52.44,74.2
X$2909 2055 109 150 2259 BUF_X1
* cell instance $2910 m0 *1 53.01,74.2
X$2910 2232 109 150 2088 CLKBUF_X2
* cell instance $2911 m0 *1 53.77,74.2
X$2911 1803 109 150 2258 BUF_X1
* cell instance $2912 m0 *1 54.34,74.2
X$2912 1945 109 150 2242 BUF_X1
* cell instance $2913 m0 *1 54.91,74.2
X$2913 2024 109 150 2241 BUF_X1
* cell instance $2914 m0 *1 55.48,74.2
X$2914 2316 109 150 2212 BUF_X1
* cell instance $2915 m0 *1 56.05,74.2
X$2915 2315 109 150 2159 BUF_X1
* cell instance $2916 m0 *1 56.62,74.2
X$2916 2318 109 150 2061 BUF_X1
* cell instance $2917 m0 *1 57.19,74.2
X$2917 1942 109 150 2257 BUF_X1
* cell instance $2918 m0 *1 57.76,74.2
X$2918 2317 109 150 2141 BUF_X1
* cell instance $2919 m0 *1 58.33,74.2
X$2919 2319 109 150 1930 BUF_X1
* cell instance $2920 m0 *1 58.9,74.2
X$2920 2320 109 150 2189 BUF_X1
* cell instance $2922 m0 *1 59.66,74.2
X$2922 2155 109 150 2322 BUF_X1
* cell instance $2923 m0 *1 60.23,74.2
X$2923 2323 109 150 2190 BUF_X1
* cell instance $2924 m0 *1 60.8,74.2
X$2924 2191 109 150 2325 BUF_X1
* cell instance $2926 m0 *1 61.56,74.2
X$2926 2324 109 150 2033 BUF_X1
* cell instance $2928 m0 *1 62.32,74.2
X$2928 2327 109 150 2056 BUF_X1
* cell instance $2929 m0 *1 62.89,74.2
X$2929 2185 109 150 2256 BUF_X1
* cell instance $2930 m0 *1 63.46,74.2
X$2930 2329 1799 2098 109 150 2234 MUX2_X1
* cell instance $2931 m0 *1 64.79,74.2
X$2931 2321 109 150 2329 BUF_X1
* cell instance $2932 m0 *1 65.36,74.2
X$2932 2187 109 150 2255 BUF_X1
* cell instance $2934 m0 *1 66.12,74.2
X$2934 2326 109 150 2233 BUF_X1
* cell instance $2942 m0 *1 1.33,49
X$2942 1492 109 150 1547 BUF_X1
* cell instance $2945 m0 *1 2.09,49
X$2945 1547 1314 1494 109 150 1531 MUX2_X1
* cell instance $2946 m0 *1 3.42,49
X$2946 1493 109 150 1548 BUF_X1
* cell instance $2947 m0 *1 3.99,49
X$2947 1529 109 150 1532 BUF_X1
* cell instance $2948 m0 *1 4.56,49
X$2948 1491 109 150 1515 BUF_X1
* cell instance $2950 m0 *1 6.65,49
X$2950 702 109 150 1314 CLKBUF_X3
* cell instance $2951 m0 *1 7.6,49
X$2951 1548 1075 1495 109 150 1456 MUX2_X1
* cell instance $2953 m0 *1 9.12,49
X$2953 1257 109 150 2350 INV_X4
* cell instance $2954 m0 *1 10.07,49
X$2954 673 109 150 1257 CLKBUF_X3
* cell instance $2955 m0 *1 11.02,49
X$2955 1515 1075 1554 109 150 1551 MUX2_X1
* cell instance $2958 r0 *1 1.33,49
X$2958 1530 109 150 1550 BUF_X1
* cell instance $2960 r0 *1 2.09,49
X$2960 109 1531 1457 2488 1494 150 DFF_X2
* cell instance $2964 r0 *1 5.7,49
X$2964 1532 1314 1533 109 150 1549 MUX2_X1
* cell instance $2965 r0 *1 7.03,49
X$2965 109 2480 1533 1549 1257 150 DFF_X1
* cell instance $2967 r0 *1 10.45,49
X$2967 1550 1075 1552 109 150 1553 MUX2_X1
* cell instance $2968 r0 *1 11.78,49
X$2968 109 1501 1552 1553 1457 150 DFF_X1
* cell instance $2969 m0 *1 16.34,49
X$2969 1427 1317 2333 150 109 1556 HA_X1
* cell instance $2970 m0 *1 12.73,49
X$2970 109 1551 1457 1528 1554 150 DFF_X2
* cell instance $2971 m0 *1 18.24,49
X$2971 1556 109 150 669 CLKBUF_X3
* cell instance $2975 m0 *1 19.57,49
X$2975 1497 109 150 873 BUF_X2
* cell instance $2977 m0 *1 22.04,49
X$2977 1498 1198 1289 150 109 1302 OAI21_X4
* cell instance $2979 m0 *1 26.03,49
X$2979 1533 338 109 150 1534 NAND2_X1
* cell instance $2980 m0 *1 26.6,49
X$2980 1534 1499 755 150 1522 109 OAI21_X1
* cell instance $2981 m0 *1 27.36,49
X$2981 1460 150 338 109 BUF_X4
* cell instance $2985 m0 *1 32.68,49
X$2985 871 109 150 221 CLKBUF_X3
* cell instance $2986 m0 *1 33.63,49
X$2986 873 109 150 1448 INV_X1
* cell instance $2988 m0 *1 34.77,49
X$2988 665 1403 1004 109 150 1632 NOR3_X1
* cell instance $2989 m0 *1 35.53,49
X$2989 592 150 1535 109 BUF_X4
* cell instance $2992 r0 *1 22.61,49
X$2992 109 589 150 623 BUF_X8
* cell instance $2994 r0 *1 25.46,49
X$2994 1588 977 109 150 1560 NAND2_X1
* cell instance $2996 r0 *1 26.41,49
X$2996 1376 1560 1367 1375 109 150 1571 NOR4_X1
* cell instance $2997 r0 *1 27.36,49
X$2997 1522 1559 1259 1543 1303 150 109 1572 OAI221_X1
* cell instance $2998 r0 *1 28.5,49
X$2998 1376 1537 1367 1375 109 150 1559 NOR4_X1
* cell instance $3002 r0 *1 30.78,49
X$3002 1560 1367 109 150 1573 NOR2_X1
* cell instance $3004 r0 *1 31.73,49
X$3004 1591 1429 109 150 1629 NOR2_X1
* cell instance $3005 r0 *1 32.3,49
X$3005 1535 1574 807 891 1593 1592 150 109 AOI221_X2
* cell instance $3007 r0 *1 35.15,49
X$3007 871 150 1594 109 BUF_X4
* cell instance $3008 r0 *1 36.48,49
X$3008 667 150 1681 109 BUF_X4
* cell instance $3010 m0 *1 37.24,49
X$3010 1500 150 1536 109 BUF_X4
* cell instance $3012 r0 *1 37.81,49
X$3012 1538 977 109 150 1537 NAND2_X1
* cell instance $3013 r0 *1 38.38,49
X$3013 1501 109 150 1538 INV_X1
* cell instance $3015 r0 *1 39.14,49
X$3015 1537 587 109 150 1577 NOR2_X2
* cell instance $3017 m0 *1 39.71,49
X$3017 666 150 1098 109 BUF_X4
* cell instance $3019 m0 *1 42.75,49
X$3019 388 150 1113 109 BUF_X4
* cell instance $3020 m0 *1 44.08,49
X$3020 388 150 1202 109 BUF_X4
* cell instance $3021 m0 *1 45.41,49
X$3021 769 109 150 1542 CLKBUF_X3
* cell instance $3024 m0 *1 48.07,49
X$3024 559 1494 150 109 1506 AND2_X1
* cell instance $3025 m0 *1 48.83,49
X$3025 667 150 643 109 BUF_X4
* cell instance $3027 m0 *1 50.35,49
X$3027 722 1528 1406 150 1502 109 NOR3_X2
* cell instance $3028 m0 *1 51.68,49
X$3028 942 1569 840 109 150 1523 NAND3_X1
* cell instance $3030 m0 *1 52.63,49
X$3030 1528 109 150 1569 INV_X1
* cell instance $3031 m0 *1 53.01,49
X$3031 1466 1541 1570 150 1519 109 OAI21_X1
* cell instance $3033 m0 *1 53.96,49
X$3033 1503 1504 1469 1524 109 150 1570 AOI22_X1
* cell instance $3034 m0 *1 54.91,49
X$3034 1287 1469 109 150 1568 NAND2_X1
* cell instance $3037 m0 *1 56.43,49
X$3037 814 1502 813 643 1506 1564 150 109 AOI221_X2
* cell instance $3039 r0 *1 40.09,49
X$3039 1460 1533 150 109 1540 AND2_X1
* cell instance $3041 r0 *1 41.04,49
X$3041 1202 1543 109 150 1631 NOR2_X1
* cell instance $3044 r0 *1 42.18,49
X$3044 524 1597 150 109 1595 AND2_X1
* cell instance $3045 r0 *1 42.94,49
X$3045 873 1595 150 109 1576 AND2_X1
* cell instance $3047 r0 *1 44.46,49
X$3047 942 1538 840 109 150 1628 NAND3_X1
* cell instance $3048 r0 *1 45.22,49
X$3048 1539 1111 1141 1543 1110 150 109 1627 OAI221_X1
* cell instance $3049 r0 *1 46.36,49
X$3049 1539 1235 1236 1540 842 109 150 1567 AOI221_X1
* cell instance $3053 r0 *1 52.82,49
X$3053 1464 1484 1542 150 1541 109 OAI21_X1
* cell instance $3054 r0 *1 53.58,49
X$3054 1503 1111 1141 1464 1110 150 109 1590 OAI221_X1
* cell instance $3057 r0 *1 55.29,49
X$3057 1568 1590 1523 1505 109 150 1544 AOI22_X1
* cell instance $3058 r0 *1 56.24,49
X$3058 814 1577 813 643 1540 1586 150 109 AOI221_X2
* cell instance $3061 m0 *1 58.9,49
X$3061 564 109 150 947 CLKBUF_X3
* cell instance $3062 m0 *1 60.04,49
X$3062 1521 1507 1566 150 1518 109 OAI21_X1
* cell instance $3065 m0 *1 61.75,49
X$3065 1564 1508 1563 150 1520 109 OAI21_X1
* cell instance $3066 m0 *1 62.51,49
X$3066 1503 1121 1469 1183 109 150 1563 AOI22_X1
* cell instance $3068 m0 *1 63.65,49
X$3068 1206 109 150 2358 INV_X2
* cell instance $3069 m0 *1 64.22,49
X$3069 673 109 150 1206 CLKBUF_X3
* cell instance $3070 m0 *1 65.17,49
X$3070 1364 109 150 1582 BUF_X1
* cell instance $3072 m0 *1 65.93,49
X$3072 1557 1070 1503 109 150 1517 MUX2_X1
* cell instance $3073 m0 *1 67.26,49
X$3073 1518 109 150 1545 BUF_X1
* cell instance $3074 m0 *1 67.83,49
X$3074 109 2422 1470 1558 1206 150 DFF_X1
* cell instance $3076 m0 *1 71.25,49
X$3076 109 2405 1555 1510 1206 150 DFF_X1
* cell instance $3081 r0 *1 59.85,49
X$3081 1578 947 906 150 1589 109 OAI21_X1
* cell instance $3083 r0 *1 60.99,49
X$3083 1543 947 906 150 1612 109 OAI21_X1
* cell instance $3084 r0 *1 61.75,49
X$3084 1578 907 963 150 1587 109 OAI21_X1
* cell instance $3085 r0 *1 62.51,49
X$3085 1579 109 150 2359 INV_X2
* cell instance $3086 r0 *1 63.08,49
X$3086 673 109 150 1579 CLKBUF_X3
* cell instance $3087 r0 *1 64.03,49
X$3087 1543 907 963 150 1613 109 OAI21_X1
* cell instance $3089 r0 *1 64.98,49
X$3089 109 2442 1561 1562 1579 150 DFF_X1
* cell instance $3090 r0 *1 68.21,49
X$3090 1561 109 150 1539 BUF_X2
* cell instance $3093 r0 *1 69.54,49
X$3093 1439 109 150 1513 BUF_X1
* cell instance $3095 r0 *1 70.3,49
X$3095 1511 109 150 1434 BUF_X1
* cell instance $3097 r0 *1 72.39,49
X$3097 1519 109 150 1546 BUF_X1
* cell instance $3098 r0 *1 72.96,49
X$3098 1555 109 150 1464 CLKBUF_X2
* cell instance $3100 r0 *1 73.91,49
X$3100 1544 109 150 1512 BUF_X1
* cell instance $3116 m0 *1 3.99,35
X$3116 1051 109 150 753 BUF_X1
* cell instance $3119 m0 *1 8.55,35
X$3119 1100 1052 1099 150 1053 109 NOR3_X2
* cell instance $3120 m0 *1 9.88,35
X$3120 109 1099 1012 1100 1015 150 NOR3_X4
* cell instance $3121 m0 *1 12.54,35
X$3121 1057 1053 1014 1081 109 150 1078 AOI22_X2
* cell instance $3122 m0 *1 14.25,35
X$3122 934 1012 150 109 1128 AND2_X1
* cell instance $3123 m0 *1 15.01,35
X$3123 659 109 150 1152 INV_X1
* cell instance $3124 m0 *1 15.39,35
X$3124 364 1049 1014 1015 1130 109 150 OAI211_X2
* cell instance $3125 m0 *1 17.1,35
X$3125 1133 1057 109 150 1178 NAND2_X1
* cell instance $3133 r0 *1 1.71,35
X$3133 1147 109 150 1172 BUF_X1
* cell instance $3139 r0 *1 5.51,35
X$3139 1172 1075 1100 109 150 1211 MUX2_X1
* cell instance $3142 r0 *1 9.12,35
X$3142 1148 109 150 1099 INV_X1
* cell instance $3143 r0 *1 9.5,35
X$3143 109 1148 1013 1174 1014 150 NOR3_X4
* cell instance $3144 r0 *1 12.16,35
X$3144 1100 109 150 1174 INV_X1
* cell instance $3145 r0 *1 12.54,35
X$3145 1174 1148 109 150 1150 NOR2_X1
* cell instance $3146 r0 *1 13.11,35
X$3146 411 1013 109 150 1151 NOR2_X1
* cell instance $3147 r0 *1 13.68,35
X$3147 1150 1128 1015 1152 109 150 1055 AOI22_X2
* cell instance $3149 r0 *1 15.77,35
X$3149 1058 1177 1153 1154 109 150 864 AOI22_X1
* cell instance $3150 r0 *1 16.72,35
X$3150 753 1136 1178 150 1177 109 OAI21_X1
* cell instance $3151 r0 *1 17.48,35
X$3151 365 1043 1153 109 150 NOR2_X4
* cell instance $3153 m0 *1 18.05,35
X$3153 365 1156 109 150 1058 NOR2_X1
* cell instance $3154 m0 *1 18.81,35
X$3154 753 109 150 1081 INV_X1
* cell instance $3157 m0 *1 20.9,35
X$3157 1059 109 150 1138 INV_X1
* cell instance $3158 m0 *1 21.28,35
X$3158 1060 1138 1062 150 109 1061 HA_X1
* cell instance $3159 m0 *1 23.18,35
X$3159 1103 109 150 1060 INV_X1
* cell instance $3163 r0 *1 19.38,35
X$3163 1180 1156 934 109 150 1157 NAND3_X1
* cell instance $3164 r0 *1 20.14,35
X$3164 659 1181 1157 150 1154 109 OAI21_X1
* cell instance $3166 r0 *1 21.09,35
X$3166 1103 1138 2342 150 109 1158 HA_X1
* cell instance $3167 r0 *1 22.99,35
X$3167 1158 109 150 979 BUF_X2
* cell instance $3168 r0 *1 23.75,35
X$3168 1103 1059 2344 150 109 1185 HA_X1
* cell instance $3169 m0 *1 24.89,35
X$3169 1063 1081 109 150 1140 NAND2_X1
* cell instance $3171 m0 *1 25.46,35
X$3171 1064 1101 109 150 1059 NAND2_X2
* cell instance $3173 m0 *1 26.6,35
X$3173 1102 1140 1105 109 1087 150 AOI21_X1
* cell instance $3174 m0 *1 27.36,35
X$3174 249 1065 109 150 1064 NOR2_X2
* cell instance $3175 m0 *1 28.31,35
X$3175 1101 1069 934 109 150 1104 NAND3_X1
* cell instance $3176 m0 *1 29.07,35
X$3176 1069 249 109 150 1102 OR2_X1
* cell instance $3177 m0 *1 29.83,35
X$3177 1142 1065 1134 109 150 1105 NAND3_X1
* cell instance $3179 m0 *1 32.11,35
X$3179 191 871 109 150 1106 NAND2_X2
* cell instance $3180 m0 *1 33.06,35
X$3180 1134 1131 1142 109 150 1160 OR3_X2
* cell instance $3182 m0 *1 35.72,35
X$3182 456 150 1146 109 BUF_X4
* cell instance $3183 m0 *1 37.05,35
X$3183 109 1108 1030 1067 1018 150 NOR3_X4
* cell instance $3184 m0 *1 39.71,35
X$3184 985 1066 983 109 150 1109 NAND3_X1
* cell instance $3185 m0 *1 40.47,35
X$3185 456 150 1143 109 BUF_X4
* cell instance $3187 m0 *1 41.99,35
X$3187 1021 150 1141 109 BUF_X4
* cell instance $3189 r0 *1 25.65,35
X$3189 1018 1101 1064 150 1184 109 OAI21_X1
* cell instance $3191 r0 *1 26.6,35
X$3191 1185 979 1061 1146 109 150 980 NOR4_X1
* cell instance $3192 r0 *1 27.55,35
X$3192 659 1159 1104 150 1019 109 OAI21_X1
* cell instance $3194 r0 *1 28.5,35
X$3194 1102 1160 1105 109 1103 150 AOI21_X2
* cell instance $3195 r0 *1 29.83,35
X$3195 1142 1134 109 150 1101 NOR2_X1
* cell instance $3197 r0 *1 30.78,35
X$3197 1020 1018 1063 150 109 1233 OAI21_X2
* cell instance $3199 r0 *1 32.3,35
X$3199 1106 1231 1159 1160 1188 150 109 AOI211_X2
* cell instance $3201 r0 *1 34.2,35
X$3201 109 1107 1131 1142 1063 150 NOR3_X4
* cell instance $3202 r0 *1 36.86,35
X$3202 1107 109 150 1108 INV_X1
* cell instance $3203 r0 *1 37.24,35
X$3203 1108 1069 1067 109 150 1159 OR3_X2
* cell instance $3204 r0 *1 38.38,35
X$3204 983 948 985 109 150 1162 OR3_X1
* cell instance $3205 r0 *1 39.33,35
X$3205 1109 1162 966 306 109 150 1163 AOI211_X4
* cell instance $3206 r0 *1 41.42,35
X$3206 1109 1162 1092 306 109 150 771 AOI211_X4
* cell instance $3209 m0 *1 43.7,35
X$3209 459 911 109 150 1022 NAND2_X1
* cell instance $3211 r0 *1 44.46,35
X$3211 459 985 109 150 1165 NAND2_X1
* cell instance $3213 m0 *1 44.65,35
X$3213 707 1110 1111 1067 458 1166 109 150 OAI221_X2
* cell instance $3214 r0 *1 45.03,35
X$3214 557 1067 556 1004 1167 1223 150 109 AOI221_X2
* cell instance $3216 m0 *1 47.12,35
X$3216 300 1011 341 109 150 1112 NOR3_X1
* cell instance $3218 m0 *1 48.83,35
X$3218 1113 1221 1145 1143 302 1068 150 109 AOI221_X2
* cell instance $3219 m0 *1 50.92,35
X$3219 722 1011 623 150 1114 109 NOR3_X2
* cell instance $3220 m0 *1 52.25,35
X$3220 1095 1065 1096 109 1026 150 AOI21_X1
* cell instance $3221 m0 *1 53.01,35
X$3221 708 1110 1111 1069 1141 1093 109 150 OAI221_X2
* cell instance $3223 m0 *1 55.29,35
X$3223 814 1114 813 643 1116 1137 150 109 AOI221_X2
* cell instance $3224 m0 *1 57.38,35
X$3224 1116 560 788 1114 561 109 150 1139 AOI221_X1
* cell instance $3225 m0 *1 58.52,35
X$3225 1086 1117 1118 150 1079 109 OAI21_X1
* cell instance $3228 m0 *1 60.23,35
X$3228 1139 1119 1120 150 1080 109 OAI21_X1
* cell instance $3230 r0 *1 47.12,35
X$3230 1168 1112 1098 1156 109 150 1144 AOI22_X2
* cell instance $3232 r0 *1 49.21,35
X$3232 1144 1113 1191 1143 302 1190 150 109 AOI221_X2
* cell instance $3235 r0 *1 51.87,35
X$3235 1190 1069 1096 109 1115 150 AOI21_X1
* cell instance $3238 r0 *1 53.2,35
X$3238 557 1069 1236 1116 842 1189 150 109 AOI221_X2
* cell instance $3240 r0 *1 55.67,35
X$3240 1187 1040 1115 109 1127 150 AOI21_X1
* cell instance $3242 r0 *1 56.62,35
X$3242 1186 948 109 150 1187 NOR2_X1
* cell instance $3246 r0 *1 58.52,35
X$3246 1069 536 948 466 109 150 1118 AOI22_X1
* cell instance $3251 r0 *1 60.23,35
X$3251 1069 1169 948 1204 109 150 1120 AOI22_X1
* cell instance $3252 r0 *1 61.18,35
X$3252 1107 109 150 1134 CLKBUF_X3
* cell instance $3253 m0 *1 61.56,35
X$3253 1131 150 1065 109 BUF_X4
* cell instance $3255 m0 *1 62.89,35
X$3255 1137 1135 1122 150 593 109 OAI21_X1
* cell instance $3256 m0 *1 63.65,35
X$3256 708 907 963 150 1135 109 OAI21_X1
* cell instance $3257 m0 *1 64.41,35
X$3257 1126 1070 1134 109 150 1170 MUX2_X1
* cell instance $3260 r0 *1 62.89,35
X$3260 1069 1121 948 1183 109 150 1122 AOI22_X1
* cell instance $3262 r0 *1 64.22,35
X$3262 109 1170 725 2487 1107 150 DFF_X2
* cell instance $3263 m0 *1 69.73,35
X$3263 1079 109 150 1073 BUF_X1
* cell instance $3264 m0 *1 66.12,35
X$3264 109 1132 725 2483 1131 150 DFF_X2
* cell instance $3265 m0 *1 70.3,35
X$3265 1129 109 150 1124 BUF_X1
* cell instance $3267 m0 *1 71.06,35
X$3267 1080 109 150 1077 BUF_X1
* cell instance $3268 m0 *1 71.63,35
X$3268 1071 949 985 109 150 1125 MUX2_X1
* cell instance $3271 r0 *1 68.21,35
X$3271 1175 1070 1067 109 150 1179 MUX2_X1
* cell instance $3274 r0 *1 70.11,35
X$3274 109 2450 1207 1125 725 150 DFF_X1
* cell instance $3275 m0 *1 73.53,35
X$3275 1123 109 150 1126 BUF_X1
* cell instance $3278 r0 *1 73.34,35
X$3278 1127 109 150 1171 BUF_X1
* cell instance $3279 r0 *1 73.91,35
X$3279 1173 109 150 1175 BUF_X1
* cell instance $3287 m0 *1 6.84,63
X$3287 1922 109 150 1969 BUF_X1
* cell instance $3289 m0 *1 8.93,63
X$3289 1969 1733 1971 109 150 1970 MUX2_X1
* cell instance $3290 m0 *1 10.26,63
X$3290 109 1970 1638 1958 1971 150 DFF_X2
* cell instance $3293 m0 *1 14.82,63
X$3293 2045 1659 1896 109 150 1923 MUX2_X1
* cell instance $3304 r0 *1 3.04,63
X$3304 2001 109 150 2027 BUF_X1
* cell instance $3309 r0 *1 4.94,63
X$3309 2027 1733 2028 109 150 2029 MUX2_X1
* cell instance $3310 r0 *1 6.27,63
X$3310 109 2029 1457 1959 2028 150 DFF_X2
* cell instance $3313 r0 *1 10.83,63
X$3313 109 2002 1457 1984 2032 150 DFF_X2
* cell instance $3315 r0 *1 15.2,63
X$3315 109 2461 2005 2004 1600 150 DFF_X1
* cell instance $3316 m0 *1 17.48,63
X$3316 109 2379 1975 1974 1600 150 DFF_X1
* cell instance $3321 r0 *1 20.71,63
X$3321 1987 1841 1849 109 150 2037 MUX2_X1
* cell instance $3322 m0 *1 21.28,63
X$3322 1975 109 150 1786 BUF_X2
* cell instance $3324 m0 *1 22.04,63
X$3324 1997 1841 1786 109 150 1974 MUX2_X1
* cell instance $3325 m0 *1 23.37,63
X$3325 1944 1915 1924 109 1977 150 AOI21_X1
* cell instance $3326 m0 *1 24.13,63
X$3326 666 150 1759 109 BUF_X4
* cell instance $3328 m0 *1 26.22,63
X$3328 1483 1959 336 109 150 1989 NOR3_X1
* cell instance $3330 m0 *1 27.74,63
X$3330 1959 109 150 2038 INV_X1
* cell instance $3335 r0 *1 22.61,63
X$3335 666 1958 336 109 150 2007 NOR3_X1
* cell instance $3336 r0 *1 23.37,63
X$3336 666 2008 336 109 150 2010 NOR3_X1
* cell instance $3337 r0 *1 24.13,63
X$3337 1460 2009 150 109 1991 AND2_X2
* cell instance $3338 r0 *1 25.08,63
X$3338 1460 2005 150 109 2015 AND2_X2
* cell instance $3339 r0 *1 26.03,63
X$3339 1361 1989 1759 2013 109 150 2012 AOI22_X2
* cell instance $3340 r0 *1 27.74,63
X$3340 1672 2038 1374 109 150 2048 NAND3_X1
* cell instance $3341 r0 *1 28.5,63
X$3341 2008 109 150 1990 INV_X1
* cell instance $3342 r0 *1 28.88,63
X$3342 1672 1990 1374 109 150 2039 NAND3_X1
* cell instance $3344 m0 *1 29.26,63
X$3344 1958 109 150 1960 INV_X1
* cell instance $3346 r0 *1 29.64,63
X$3346 1672 1960 1374 109 150 2014 NAND3_X1
* cell instance $3348 r0 *1 30.59,63
X$3348 1535 1981 1042 1681 1991 2076 150 109 AOI221_X2
* cell instance $3349 m0 *1 31.73,63
X$3349 109 589 1958 587 1981 150 NOR3_X4
* cell instance $3353 m0 *1 36.1,63
X$3353 1407 1991 1369 1981 1465 2052 150 109 AOI221_X2
* cell instance $3357 r0 *1 32.87,63
X$3357 109 1406 1959 587 2000 150 NOR3_X4
* cell instance $3359 r0 *1 35.91,63
X$3359 1536 1991 1005 1981 1622 2016 150 109 AOI221_X2
* cell instance $3360 r0 *1 38,63
X$3360 1407 2042 1369 2000 1465 1992 150 109 AOI221_X2
* cell instance $3361 m0 *1 39.52,63
X$3361 1483 1984 1311 109 150 1961 NOR3_X1
* cell instance $3363 m0 *1 40.28,63
X$3363 1483 1962 1311 109 150 1993 NOR3_X1
* cell instance $3365 m0 *1 41.23,63
X$3365 1956 1915 1985 109 2105 150 AOI21_X1
* cell instance $3369 r0 *1 40.28,63
X$3369 1361 1993 1759 2006 109 150 2041 AOI22_X2
* cell instance $3370 r0 *1 41.99,63
X$3370 1460 2006 150 109 2023 AND2_X2
* cell instance $3372 m0 *1 43.32,63
X$3372 1287 1900 109 150 1963 NAND2_X1
* cell instance $3374 m0 *1 43.89,63
X$3374 1963 1926 1983 1982 109 150 1999 AOI22_X1
* cell instance $3377 m0 *1 48.07,63
X$3377 1927 1535 1042 1681 1889 109 150 1964 AOI221_X1
* cell instance $3378 m0 *1 49.21,63
X$3378 1964 1979 1978 150 1980 109 OAI21_X1
* cell instance $3380 m0 *1 50.16,63
X$3380 1898 1750 1763 150 1979 109 OAI21_X1
* cell instance $3382 r0 *1 43.32,63
X$3382 1962 109 150 1998 INV_X1
* cell instance $3383 r0 *1 43.7,63
X$3383 1984 109 150 2040 INV_X1
* cell instance $3385 r0 *1 44.27,63
X$3385 1672 2040 1374 109 150 2019 NAND3_X1
* cell instance $3386 r0 *1 45.03,63
X$3386 1672 1998 1374 109 150 2020 NAND3_X1
* cell instance $3390 r0 *1 47.88,63
X$3390 109 1406 1962 722 1994 150 NOR3_X4
* cell instance $3391 r0 *1 50.54,63
X$3391 1536 2023 1005 1994 1622 2116 150 109 AOI221_X2
* cell instance $3392 m0 *1 52.44,63
X$3392 1898 1762 1527 150 1965 109 OAI21_X1
* cell instance $3393 m0 *1 51.3,63
X$3393 1889 1407 1369 1927 1465 109 150 1976 AOI221_X1
* cell instance $3394 m0 *1 53.2,63
X$3394 1897 1723 1900 1462 109 150 1966 AOI22_X1
* cell instance $3395 m0 *1 54.15,63
X$3395 1898 1484 1542 150 1973 109 OAI21_X1
* cell instance $3399 r0 *1 52.63,63
X$3399 1928 1965 1966 150 2055 109 OAI21_X1
* cell instance $3401 r0 *1 53.58,63
X$3401 1897 1504 1900 1524 109 150 2036 AOI22_X1
* cell instance $3402 r0 *1 54.53,63
X$3402 1976 1973 2036 150 2024 109 OAI21_X1
* cell instance $3412 r0 *1 59.47,63
X$3412 109 2440 1995 1996 1579 150 DFF_X1
* cell instance $3414 m0 *1 59.85,63
X$3414 2033 1799 1807 109 150 1996 MUX2_X1
* cell instance $3417 m0 *1 62.32,63
X$3417 1995 109 150 1807 BUF_X2
* cell instance $3420 m0 *1 70.11,63
X$3420 1968 109 150 1854 BUF_X1
* cell instance $3425 r0 *1 67.64,63
X$3425 1744 109 150 2025 BUF_X1
* cell instance $3428 m0 *1 71.06,63
X$3428 1972 109 150 1353 BUF_X1
* cell instance $3430 m0 *1 72.01,63
X$3430 1520 109 150 1967 BUF_X1
* cell instance $3440 m0 *1 2.66,12.6
X$3440 385 109 150 396 BUF_X1
* cell instance $3442 m0 *1 3.23,12.6
X$3442 362 109 150 370 BUF_X1
* cell instance $3447 m0 *1 4.37,12.6
X$3447 370 333 372 109 150 371 MUX2_X1
* cell instance $3449 m0 *1 5.7,12.6
X$3449 109 371 274 337 372 150 DFF_X2
* cell instance $3451 m0 *1 9.5,12.6
X$3451 396 333 363 109 150 334 MUX2_X1
* cell instance $3452 m0 *1 10.83,12.6
X$3452 109 372 287 289 363 364 150 NOR4_X4
* cell instance $3457 r0 *1 11.02,12.6
X$3457 372 287 289 363 109 150 411 OR4_X1
* cell instance $3461 r0 *1 14.25,12.6
X$3461 109 2453 398 399 274 150 DFF_X1
* cell instance $3462 m0 *1 14.82,12.6
X$3462 121 216 398 109 150 399 MUX2_X1
* cell instance $3465 m0 *1 17.29,12.6
X$3465 109 365 290 237 255 234 150 OR4_X4
* cell instance $3466 m0 *1 16.53,12.6
X$3466 377 109 150 255 BUF_X2
* cell instance $3467 m0 *1 19.76,12.6
X$3467 109 234 255 237 290 400 150 NOR4_X4
* cell instance $3468 m0 *1 23.18,12.6
X$3468 336 337 109 150 124 OR2_X1
* cell instance $3471 r0 *1 17.86,12.6
X$3471 437 216 408 109 150 476 MUX2_X1
* cell instance $3475 r0 *1 23.37,12.6
X$3475 414 402 413 109 412 150 AOI21_X1
* cell instance $3477 m0 *1 24.51,12.6
X$3477 124 109 150 378 INV_X1
* cell instance $3479 m0 *1 24.89,12.6
X$3479 296 378 294 234 338 297 150 109 AOI221_X2
* cell instance $3480 m0 *1 26.98,12.6
X$3480 366 356 294 255 338 382 150 109 AOI221_X2
* cell instance $3484 r0 *1 26.6,12.6
X$3484 415 440 204 109 402 150 AOI21_X1
* cell instance $3486 r0 *1 28.12,12.6
X$3486 451 173 150 109 415 AND2_X1
* cell instance $3487 r0 *1 28.88,12.6
X$3487 109 112 416 480 172 150 DFF_X1
* cell instance $3489 m0 *1 29.64,12.6
X$3489 296 150 366 109 BUF_X4
* cell instance $3493 m0 *1 32.3,12.6
X$3493 300 337 341 109 150 384 NOR3_X1
* cell instance $3495 m0 *1 33.06,12.6
X$3495 300 291 341 109 150 383 NOR3_X1
* cell instance $3496 m0 *1 33.82,12.6
X$3496 367 383 368 290 109 150 301 AOI22_X2
* cell instance $3497 m0 *1 35.53,12.6
X$3497 367 384 368 234 109 150 344 AOI22_X2
* cell instance $3498 m0 *1 37.24,12.6
X$3498 367 331 368 255 109 150 346 AOI22_X2
* cell instance $3502 r0 *1 33.44,12.6
X$3502 367 342 368 237 109 150 444 AOI22_X2
* cell instance $3503 r0 *1 35.15,12.6
X$3503 444 264 343 303 332 304 150 109 AOI221_X2
* cell instance $3512 r0 *1 40.09,12.6
X$3512 305 419 109 150 387 NOR2_X1
* cell instance $3514 r0 *1 41.04,12.6
X$3514 388 150 264 109 BUF_X4
* cell instance $3516 r0 *1 42.75,12.6
X$3516 367 389 398 368 109 150 390 AOI22_X1
* cell instance $3517 m0 *1 43.13,12.6
X$3517 264 390 381 303 332 109 150 406 AOI221_X1
* cell instance $3519 m0 *1 44.27,12.6
X$3519 388 312 109 150 381 NOR2_X1
* cell instance $3522 r0 *1 44.08,12.6
X$3522 367 421 408 368 109 150 404 AOI22_X1
* cell instance $3524 m0 *1 45.98,12.6
X$3524 305 393 109 150 380 NOR2_X1
* cell instance $3525 m0 *1 45.22,12.6
X$3525 406 353 223 109 361 150 AOI21_X1
* cell instance $3526 m0 *1 46.55,12.6
X$3526 367 405 368 379 109 150 360 AOI22_X2
* cell instance $3527 m0 *1 48.26,12.6
X$3527 264 404 369 303 332 109 150 309 AOI221_X1
* cell instance $3531 m0 *1 53.2,12.6
X$3531 109 2412 357 376 136 150 DFF_X1
* cell instance $3533 m0 *1 56.62,12.6
X$3533 109 2421 441 355 142 150 DFF_X1
* cell instance $3535 m0 *1 60.04,12.6
X$3535 109 2384 374 375 147 150 DFF_X1
* cell instance $3536 m0 *1 63.27,12.6
X$3536 374 109 150 353 BUF_X2
* cell instance $3537 m0 *1 64.03,12.6
X$3537 109 2361 373 397 147 150 DFF_X1
* cell instance $3538 m0 *1 67.26,12.6
X$3538 373 109 150 393 BUF_X2
* cell instance $3541 r0 *1 45.41,12.6
X$3541 367 445 407 368 109 150 307 AOI22_X1
* cell instance $3542 r0 *1 46.36,12.6
X$3542 300 446 341 109 150 405 NOR3_X1
* cell instance $3544 r0 *1 48.64,12.6
X$3544 264 426 401 303 332 109 150 443 AOI221_X1
* cell instance $3546 r0 *1 49.97,12.6
X$3546 443 271 223 109 403 150 AOI21_X1
* cell instance $3548 r0 *1 50.92,12.6
X$3548 267 322 109 150 401 NOR2_X1
* cell instance $3549 r0 *1 51.49,12.6
X$3549 225 442 109 150 391 NOR2_X1
* cell instance $3553 r0 *1 56.81,12.6
X$3553 392 109 150 158 CLKBUF_X3
* cell instance $3554 r0 *1 57.76,12.6
X$3554 441 109 150 349 CLKBUF_X2
* cell instance $3564 r0 *1 67.83,12.6
X$3564 109 2474 436 430 147 150 DFF_X1
* cell instance $3565 r0 *1 71.06,12.6
X$3565 436 109 150 419 BUF_X2
* cell instance $3569 r0 *1 73.91,12.6
X$3569 433 109 150 431 BUF_X1
* cell instance $3573 m0 *1 10.07,74.2
X$3573 2293 109 150 2222 BUF_X1
* cell instance $3575 m0 *1 11.59,74.2
X$3575 2294 109 150 2127 BUF_X1
* cell instance $3576 m0 *1 12.16,74.2
X$3576 2295 109 150 2174 BUF_X1
* cell instance $3577 m0 *1 12.73,74.2
X$3577 2296 109 150 2147 BUF_X1
* cell instance $3582 m0 *1 2.28,40.6
X$3582 1288 109 150 1256 BUF_X1
* cell instance $3586 m0 *1 5.32,40.6
X$3586 1358 1314 1167 109 150 1299 MUX2_X1
* cell instance $3587 m0 *1 6.65,40.6
X$3587 109 2415 1297 1299 1257 150 DFF_X1
* cell instance $3589 m0 *1 10.07,40.6
X$3589 1297 150 1167 109 BUF_X4
* cell instance $3592 m0 *1 17.67,40.6
X$3592 1058 1289 1133 150 109 1258 OAI21_X2
* cell instance $3596 r0 *1 1.33,40.6
X$3596 1425 1314 1227 109 150 1328 MUX2_X1
* cell instance $3597 r0 *1 2.66,40.6
X$3597 109 2467 1329 1328 1257 150 DFF_X1
* cell instance $3602 r0 *1 6.65,40.6
X$3602 1329 150 1227 109 BUF_X4
* cell instance $3607 r0 *1 12.35,40.6
X$3607 1149 109 150 1344 INV_X1
* cell instance $3608 r0 *1 12.73,40.6
X$3608 1315 1344 2341 150 109 1316 HA_X1
* cell instance $3609 r0 *1 14.63,40.6
X$3609 1316 1373 1253 1361 150 993 109 NOR4_X2
* cell instance $3610 r0 *1 16.34,40.6
X$3610 1258 1317 1225 150 109 1056 HA_X1
* cell instance $3611 r0 *1 18.24,40.6
X$3611 109 1199 1043 1227 1289 150 NOR3_X4
* cell instance $3612 m0 *1 20.33,40.6
X$3612 1167 109 150 1199 INV_X2
* cell instance $3618 m0 *1 2.09,43.4
X$3618 1313 109 150 1358 BUF_X1
* cell instance $3619 m0 *1 2.66,43.4
X$3619 109 1400 1257 2485 1343 150 DFF_X2
* cell instance $3623 r0 *1 1.33,43.4
X$3623 1371 109 150 1399 BUF_X1
* cell instance $3624 r0 *1 1.9,43.4
X$3624 1399 1314 1343 109 150 1400 MUX2_X1
* cell instance $3629 r0 *1 3.42,43.4
X$3629 1454 1314 1401 109 150 1438 MUX2_X1
* cell instance $3631 r0 *1 4.94,43.4
X$3631 1411 109 150 1370 BUF_X1
* cell instance $3632 r0 *1 5.51,43.4
X$3632 1455 1314 1043 109 150 1473 MUX2_X1
* cell instance $3634 r0 *1 7.22,43.4
X$3634 1426 1075 1386 109 150 1372 MUX2_X1
* cell instance $3635 m0 *1 7.6,43.4
X$3635 109 1372 1257 1319 1386 150 DFF_X2
* cell instance $3641 m0 *1 12.54,43.4
X$3641 1194 109 150 1315 INV_X1
* cell instance $3643 m0 *1 12.92,43.4
X$3643 1315 1149 2338 150 109 1389 HA_X1
* cell instance $3646 r0 *1 12.73,43.4
X$3646 1194 1344 2339 150 109 1414 HA_X1
* cell instance $3648 r0 *1 14.82,43.4
X$3648 1414 109 150 1373 BUF_X2
* cell instance $3649 m0 *1 15.39,43.4
X$3649 1389 661 1226 150 109 1390 HA_X1
* cell instance $3654 m0 *1 17.86,43.4
X$3654 1390 109 150 520 CLKBUF_X3
* cell instance $3658 r0 *1 18.24,43.4
X$3658 873 669 1056 1428 109 150 995 NOR4_X1
* cell instance $3660 m0 *1 19.19,43.4
X$3660 1373 1226 1374 109 150 1182 NAND3_X1
* cell instance $3662 r0 *1 19.38,43.4
X$3662 1056 109 150 1429 INV_X2
* cell instance $3663 r0 *1 19.95,43.4
X$3663 1477 1056 836 109 150 1392 NAND3_X2
* cell instance $3664 m0 *1 22.8,43.4
X$3664 1392 1136 1199 109 150 1394 NOR3_X1
* cell instance $3665 m0 *1 20.33,43.4
X$3665 109 1284 1392 1181 1136 150 AOI21_X4
* cell instance $3667 m0 *1 23.75,43.4
X$3667 109 1292 1365 1181 1136 150 AOI21_X4
* cell instance $3669 r0 *1 21.28,43.4
X$3669 400 109 150 1417 BUF_X1
* cell instance $3670 r0 *1 21.85,43.4
X$3670 400 669 836 109 150 1418 NAND3_X1
* cell instance $3671 r0 *1 22.61,43.4
X$3671 109 1376 1418 1181 1136 150 AOI21_X4
* cell instance $3672 r0 *1 25.08,43.4
X$3672 754 1303 1444 1443 1259 1446 109 150 OAI221_X2
* cell instance $3673 m0 *1 27.93,43.4
X$3673 1346 1367 1375 1376 150 1345 109 NOR4_X2
* cell instance $3674 m0 *1 26.6,43.4
X$3674 1260 1367 1375 150 1366 109 NOR3_X2
* cell instance $3676 r0 *1 27.17,43.4
X$3676 549 1402 755 150 1443 109 OAI21_X1
* cell instance $3677 r0 *1 27.93,43.4
X$3677 1276 669 109 150 1402 NAND2_X1
* cell instance $3679 r0 *1 28.88,43.4
X$3679 1447 1446 1229 1066 109 150 1411 AOI22_X2
* cell instance $3680 m0 *1 30.97,43.4
X$3680 1377 1284 1367 1318 109 150 1347 NOR4_X1
* cell instance $3681 m0 *1 30.02,43.4
X$3681 1376 1377 1367 1375 109 150 1320 NOR4_X1
* cell instance $3682 m0 *1 31.92,43.4
X$3682 1394 1347 1042 109 150 1274 NOR3_X1
* cell instance $3684 m0 *1 33.44,43.4
X$3684 754 109 150 827 INV_X2
* cell instance $3687 r0 *1 30.59,43.4
X$3687 1229 1065 1260 109 1447 150 AOI21_X1
* cell instance $3689 r0 *1 31.73,43.4
X$3689 1348 1130 1292 1448 1398 1430 109 150 1421 OAI33_X1
* cell instance $3690 r0 *1 33.06,43.4
X$3690 1188 827 807 109 1431 150 AOI21_X1
* cell instance $3691 r0 *1 33.82,43.4
X$3691 1285 827 740 109 1422 150 AOI21_X1
* cell instance $3693 r0 *1 34.77,43.4
X$3693 1005 1421 1422 150 1452 109 OAI21_X1
* cell instance $3694 m0 *1 35.34,43.4
X$3694 1292 1377 1367 1348 109 150 1349 NOR4_X1
* cell instance $3698 r0 *1 35.53,43.4
X$3698 1292 1348 874 109 150 NOR2_X4
* cell instance $3700 m0 *1 38.76,43.4
X$3700 520 150 1168 109 BUF_X4
* cell instance $3701 m0 *1 37.43,43.4
X$3701 520 150 1361 109 BUF_X4
* cell instance $3704 m0 *1 41.04,43.4
X$3704 556 150 1403 109 BUF_X4
* cell instance $3707 m0 *1 44.08,43.4
X$3707 771 1259 109 150 721 NOR2_X2
* cell instance $3709 m0 *1 45.22,43.4
X$3709 499 150 1111 109 BUF_X4
* cell instance $3711 r0 *1 38.76,43.4
X$3711 573 1065 1188 109 1451 150 AOI21_X1
* cell instance $3714 r0 *1 40.66,43.4
X$3714 558 1065 1285 109 1433 150 AOI21_X1
* cell instance $3715 r0 *1 41.42,43.4
X$3715 1403 1398 1276 109 1007 150 AOI21_X1
* cell instance $3717 r0 *1 42.37,43.4
X$3717 558 109 150 1462 CLKBUF_X3
* cell instance $3718 r0 *1 43.32,43.4
X$3718 771 1260 109 150 769 NOR2_X2
* cell instance $3719 r0 *1 44.27,43.4
X$3719 573 150 1432 109 BUF_X4
* cell instance $3721 r0 *1 45.79,43.4
X$3721 498 150 1110 109 BUF_X4
* cell instance $3723 m0 *1 46.93,43.4
X$3723 1168 1378 1098 1343 109 150 1368 AOI22_X2
* cell instance $3724 m0 *1 48.83,43.4
X$3724 690 150 1407 109 BUF_X4
* cell instance $3726 r0 *1 47.12,43.4
X$3726 366 150 942 109 BUF_X4
* cell instance $3729 r0 *1 49.02,43.4
X$3729 559 1401 150 109 1408 AND2_X1
* cell instance $3731 r0 *1 49.97,43.4
X$3731 722 1404 1406 150 1405 109 NOR3_X2
* cell instance $3733 m0 *1 50.54,43.4
X$3733 109 1406 1319 722 1324 150 NOR3_X4
* cell instance $3734 r0 *1 51.3,43.4
X$3734 1404 109 150 1397 INV_X1
* cell instance $3736 r0 *1 51.87,43.4
X$3736 942 1397 840 109 150 1480 NAND3_X1
* cell instance $3738 r0 *1 53.39,43.4
X$3738 1381 1111 1141 1350 1110 150 109 1481 OAI221_X1
* cell instance $3739 m0 *1 53.77,43.4
X$3739 1396 1040 1339 109 1395 150 AOI21_X1
* cell instance $3743 m0 *1 55.48,43.4
X$3743 1186 1379 109 150 1420 NOR2_X1
* cell instance $3745 m0 *1 56.24,43.4
X$3745 1408 690 615 1405 670 109 150 1380 AOI221_X1
* cell instance $3746 m0 *1 57.38,43.4
X$3746 1380 1363 1393 150 1355 109 OAI21_X1
* cell instance $3748 m0 *1 58.33,43.4
X$3748 1381 536 1379 466 109 150 1393 AOI22_X1
* cell instance $3750 m0 *1 60.8,43.4
X$3750 1350 947 906 150 1416 109 OAI21_X1
* cell instance $3753 r0 *1 54.53,43.4
X$3753 1287 1379 109 150 1450 NAND2_X1
* cell instance $3754 r0 *1 55.1,43.4
X$3754 1420 1040 1449 109 1413 150 AOI21_X1
* cell instance $3755 r0 *1 55.86,43.4
X$3755 814 1405 813 643 1408 1415 150 109 AOI221_X2
* cell instance $3756 r0 *1 57.95,43.4
X$3756 1408 560 788 1405 561 109 150 1419 AOI221_X1
* cell instance $3761 r0 *1 59.47,43.4
X$3761 1381 1169 1379 1204 109 150 1445 AOI22_X1
* cell instance $3763 r0 *1 60.61,43.4
X$3763 1419 1416 1445 150 1441 109 OAI21_X1
* cell instance $3764 r0 *1 61.37,43.4
X$3764 505 109 150 963 CLKBUF_X3
* cell instance $3765 r0 *1 62.32,43.4
X$3765 1381 1121 1379 1183 109 150 1442 AOI22_X1
* cell instance $3766 m0 *1 62.89,43.4
X$3766 1350 907 963 150 1351 109 OAI21_X1
* cell instance $3770 r0 *1 63.27,43.4
X$3770 1415 1351 1442 150 1412 109 OAI21_X1
* cell instance $3772 r0 *1 64.79,43.4
X$3772 109 2435 1440 1391 1206 150 DFF_X1
* cell instance $3773 m0 *1 66.88,43.4
X$3773 109 2417 1387 1388 1206 150 DFF_X1
* cell instance $3774 m0 *1 65.55,43.4
X$3774 1434 1070 1381 109 150 1391 MUX2_X1
* cell instance $3775 m0 *1 70.11,43.4
X$3775 1387 109 150 1379 CLKBUF_X2
* cell instance $3777 r0 *1 68.02,43.4
X$3777 1409 949 1379 109 150 1388 MUX2_X1
* cell instance $3778 r0 *1 69.35,43.4
X$3778 1413 109 150 1410 BUF_X1
* cell instance $3781 r0 *1 70.49,43.4
X$3781 1412 109 150 1436 BUF_X1
* cell instance $3782 r0 *1 71.06,43.4
X$3782 1357 109 150 1352 BUF_X1
* cell instance $3784 m0 *1 71.25,43.4
X$3784 109 2377 1383 1382 1206 150 DFF_X1
* cell instance $3785 r0 *1 71.63,43.4
X$3785 1308 109 150 1326 BUF_X1
* cell instance $3786 r0 *1 72.2,43.4
X$3786 1356 109 150 1384 BUF_X1
* cell instance $3788 r0 *1 72.96,43.4
X$3788 1355 109 150 1385 BUF_X1
* cell instance $3790 r0 *1 73.72,43.4
X$3790 1383 109 150 1350 CLKBUF_X2
* cell instance $3794 m0 *1 2.09,37.8
X$3794 1210 1314 1156 109 150 1193 MUX2_X1
* cell instance $3797 m0 *1 5.7,37.8
X$3797 109 1211 650 1201 1100 150 DFF_X2
* cell instance $3800 m0 *1 12.54,37.8
X$3800 1150 1151 150 109 1194 AND2_X1
* cell instance $3801 m0 *1 13.3,37.8
X$3801 1150 1015 1151 150 1176 109 OAI21_X1
* cell instance $3802 m0 *1 14.06,37.8
X$3802 427 1246 1247 1015 150 109 1195 AND4_X1
* cell instance $3803 m0 *1 15.2,37.8
X$3803 1151 1195 1153 1215 109 150 978 AOI22_X1
* cell instance $3805 m0 *1 16.91,37.8
X$3805 1225 1196 889 109 150 1155 NOR3_X1
* cell instance $3806 m0 *1 17.67,37.8
X$3806 1016 109 150 1196 INV_X1
* cell instance $3807 m0 *1 18.05,37.8
X$3807 109 1155 1197 899 1084 1184 1176 1213 150 AOI222_X2
* cell instance $3808 m0 *1 20.71,37.8
X$3808 1199 1227 109 150 1180 NOR2_X1
* cell instance $3811 r0 *1 1.33,37.8
X$3811 1192 109 150 1242 BUF_X1
* cell instance $3812 r0 *1 1.9,37.8
X$3812 1255 109 150 1210 BUF_X1
* cell instance $3813 r0 *1 2.47,37.8
X$3813 109 2445 1241 1193 1257 150 DFF_X1
* cell instance $3817 r0 *1 5.7,37.8
X$3817 1241 109 150 1156 CLKBUF_X3
* cell instance $3819 r0 *1 7.41,37.8
X$3819 1242 1075 1148 109 150 1243 MUX2_X1
* cell instance $3820 r0 *1 8.74,37.8
X$3820 109 1243 1257 1244 1148 150 DFF_X2
* cell instance $3821 r0 *1 12.35,37.8
X$3821 1194 1149 1246 150 109 1253 HA_X1
* cell instance $3823 r0 *1 14.44,37.8
X$3823 1247 1246 589 109 150 1213 NOR3_X1
* cell instance $3824 r0 *1 15.2,37.8
X$3824 1226 109 150 1247 INV_X1
* cell instance $3826 r0 *1 15.77,37.8
X$3826 1153 1180 150 1317 109 AND2_X4
* cell instance $3827 r0 *1 17.48,37.8
X$3827 338 1196 1225 1198 150 109 1215 AND4_X1
* cell instance $3829 r0 *1 19,37.8
X$3829 1253 1226 427 109 150 1082 NAND3_X1
* cell instance $3830 r0 *1 19.76,37.8
X$3830 1198 1180 1153 150 1197 109 OAI21_X1
* cell instance $3832 r0 *1 20.71,37.8
X$3832 1167 1228 1217 150 1133 109 NOR3_X2
* cell instance $3833 m0 *1 24.32,37.8
X$3833 109 979 1020 1018 1259 1063 150 OAI211_X4
* cell instance $3834 m0 *1 21.66,37.8
X$3834 109 1217 1156 1167 1198 150 NOR3_X4
* cell instance $3836 r0 *1 22.04,37.8
X$3836 1043 109 150 1228 INV_X2
* cell instance $3838 r0 *1 22.8,37.8
X$3838 1167 1156 1217 109 150 1181 OR3_X4
* cell instance $3839 r0 *1 24.89,37.8
X$3839 1227 109 150 1217 INV_X2
* cell instance $3842 r0 *1 26.41,37.8
X$3842 1228 889 109 150 1276 NOR2_X1
* cell instance $3844 r0 *1 27.74,37.8
X$3844 745 109 150 1367 CLKBUF_X3
* cell instance $3846 m0 *1 27.93,37.8
X$3846 979 109 150 1219 INV_X1
* cell instance $3847 r0 *1 28.69,37.8
X$3847 1161 109 150 1229 CLKBUF_X3
* cell instance $3849 m0 *1 28.69,37.8
X$3849 1061 109 150 1231 INV_X2
* cell instance $3850 m0 *1 29.45,37.8
X$3850 1160 1159 1106 1219 109 150 1260 AOI211_X4
* cell instance $3851 m0 *1 31.54,37.8
X$3851 1185 109 150 1220 INV_X1
* cell instance $3852 m0 *1 31.92,37.8
X$3852 1106 1220 1159 1160 1285 150 109 AOI211_X2
* cell instance $3853 m0 *1 33.63,37.8
X$3853 109 1185 1020 1018 1200 1063 150 OAI211_X4
* cell instance $3854 m0 *1 36.86,37.8
X$3854 1067 109 150 1142 INV_X2
* cell instance $3858 r0 *1 29.83,37.8
X$3858 514 1230 1233 1231 1232 1280 109 150 OAI221_X2
* cell instance $3860 r0 *1 32.11,37.8
X$3860 981 966 109 150 1232 OR2_X1
* cell instance $3862 r0 *1 33.06,37.8
X$3862 1230 564 1089 981 1200 1234 109 150 OAI221_X2
* cell instance $3864 r0 *1 35.34,37.8
X$3864 109 1231 1233 1163 542 150 NOR3_X4
* cell instance $3866 r0 *1 38.38,37.8
X$3866 1163 1188 505 109 150 NOR2_X4
* cell instance $3867 m0 *1 41.42,37.8
X$3867 1163 109 150 1183 CLKBUF_X3
* cell instance $3868 m0 *1 39.33,37.8
X$3868 1109 1162 1089 306 109 150 1261 AOI211_X4
* cell instance $3869 m0 *1 42.37,37.8
X$3869 1201 109 150 1164 INV_X1
* cell instance $3870 m0 *1 42.75,37.8
X$3870 300 1201 341 109 150 1222 NOR3_X1
* cell instance $3872 r0 *1 41.04,37.8
X$3872 1163 109 150 573 CLKBUF_X3
* cell instance $3873 r0 *1 41.99,37.8
X$3873 420 150 300 109 BUF_X4
* cell instance $3874 r0 *1 43.32,37.8
X$3874 529 109 150 1287 CLKBUF_X3
* cell instance $3875 m0 *1 44.46,37.8
X$3875 942 1164 840 109 150 1224 NAND3_X1
* cell instance $3876 m0 *1 43.89,37.8
X$3876 459 941 109 150 1262 NAND2_X1
* cell instance $3877 m0 *1 45.22,37.8
X$3877 1165 1166 1223 1224 109 150 1129 AOI22_X2
* cell instance $3878 m0 *1 46.93,37.8
X$3878 1168 1222 1167 1098 109 150 1221 AOI22_X1
* cell instance $3881 r0 *1 44.65,37.8
X$3881 1235 1134 1236 1004 1227 1312 150 109 AOI221_X2
* cell instance $3882 r0 *1 46.74,37.8
X$3882 757 1110 1111 1134 1141 1286 109 150 OAI221_X2
* cell instance $3884 m0 *1 48.26,37.8
X$3884 559 1156 150 109 1116 AND2_X1
* cell instance $3885 m0 *1 49.21,37.8
X$3885 1202 708 109 150 1191 NOR2_X1
* cell instance $3887 m0 *1 51.3,37.8
X$3887 557 150 1235 109 BUF_X4
* cell instance $3890 r0 *1 48.83,37.8
X$3890 1202 757 109 150 1309 NOR2_X1
* cell instance $3893 r0 *1 51.68,37.8
X$3893 556 150 1236 109 BUF_X4
* cell instance $3894 r0 *1 53.01,37.8
X$3894 742 109 150 464 CLKBUF_X3
* cell instance $3895 r0 *1 53.96,37.8
X$3895 1237 1110 1111 1239 1141 1238 109 150 OAI221_X2
* cell instance $3899 r0 *1 57.38,37.8
X$3899 1239 536 1254 466 109 150 1252 AOI22_X1
* cell instance $3900 r0 *1 58.33,37.8
X$3900 1237 464 504 150 1264 109 OAI21_X1
* cell instance $3905 m0 *1 59.28,37.8
X$3905 707 947 906 150 1203 109 OAI21_X1
* cell instance $3908 m0 *1 60.23,37.8
X$3908 1067 1169 983 1204 109 150 1218 AOI22_X1
* cell instance $3910 r0 *1 59.28,37.8
X$3910 1251 1203 1218 150 1212 109 OAI21_X1
* cell instance $3911 r0 *1 60.04,37.8
X$3911 1134 1169 941 1204 109 150 1248 AOI22_X1
* cell instance $3912 r0 *1 60.99,37.8
X$3912 757 947 906 150 1249 109 OAI21_X1
* cell instance $3913 m0 *1 62.51,37.8
X$3913 707 907 963 150 1205 109 OAI21_X1
* cell instance $3914 m0 *1 61.56,37.8
X$3914 1067 1121 983 1183 109 150 1216 AOI22_X1
* cell instance $3917 r0 *1 61.75,37.8
X$3917 1250 1249 1248 150 1273 109 OAI21_X1
* cell instance $3919 r0 *1 62.7,37.8
X$3919 1274 1205 1216 150 1245 109 OAI21_X1
* cell instance $3921 m0 *1 66.12,37.8
X$3921 109 2408 1214 1179 1206 150 DFF_X1
* cell instance $3922 m0 *1 65.17,37.8
X$3922 392 109 150 726 CLKBUF_X3
* cell instance $3923 m0 *1 69.35,37.8
X$3923 1214 150 1067 109 BUF_X4
* cell instance $3927 r0 *1 67.26,37.8
X$3927 1271 109 150 1239 BUF_X2
* cell instance $3929 r0 *1 68.4,37.8
X$3929 1245 109 150 1208 BUF_X1
* cell instance $3931 r0 *1 70.49,37.8
X$3931 1300 109 150 1237 BUF_X2
* cell instance $3932 r0 *1 71.25,37.8
X$3932 109 2428 1268 1325 1206 150 DFF_X1
* cell instance $3933 m0 *1 72.39,37.8
X$3933 1207 109 150 985 CLKBUF_X3
* cell instance $3934 m0 *1 71.82,37.8
X$3934 1212 109 150 1209 BUF_X1
* cell instance $3948 m0 *1 7.41,60.2
X$3948 1874 109 150 1906 BUF_X1
* cell instance $3956 r0 *1 3.61,60.2
X$3956 1921 109 150 1934 BUF_X1
* cell instance $3959 r0 *1 4.75,60.2
X$3959 1934 1733 1936 109 150 1935 MUX2_X1
* cell instance $3960 r0 *1 6.08,60.2
X$3960 109 1935 1638 1891 1936 150 DFF_X2
* cell instance $3962 m0 *1 8.36,60.2
X$3962 1906 1733 1883 109 150 1843 MUX2_X1
* cell instance $3967 m0 *1 12.35,60.2
X$3967 109 2375 1845 1844 1638 150 DFF_X1
* cell instance $3971 m0 *1 21.09,60.2
X$3971 1910 1915 1847 109 1886 150 AOI21_X1
* cell instance $3972 m0 *1 21.85,60.2
X$3972 1887 1786 1788 109 1892 150 AOI21_X1
* cell instance $3973 m0 *1 22.61,60.2
X$3973 1361 1848 1697 1759 109 150 1875 AOI22_X1
* cell instance $3974 m0 *1 23.56,60.2
X$3974 1810 1875 1888 1146 221 109 150 1939 AOI221_X1
* cell instance $3975 m0 *1 24.7,60.2
X$3975 763 1699 109 150 1888 NOR2_X1
* cell instance $3980 r0 *1 14.44,60.2
X$3980 109 2458 1896 1923 1638 150 DFF_X1
* cell instance $3984 r0 *1 21.66,60.2
X$3984 1938 1915 1892 109 1988 150 AOI21_X1
* cell instance $3987 r0 *1 23.37,60.2
X$3987 1939 1849 1788 109 1924 150 AOI21_X1
* cell instance $3990 r0 *1 25.84,60.2
X$3990 714 1807 109 150 1938 NOR2_X1
* cell instance $3992 m0 *1 26.41,60.2
X$3992 1460 1697 150 109 1876 AND2_X1
* cell instance $3993 m0 *1 27.93,60.2
X$3993 1672 1588 1374 109 150 1913 NAND3_X1
* cell instance $3996 m0 *1 29.64,60.2
X$3996 259 1872 109 150 1893 NAND2_X1
* cell instance $3998 m0 *1 30.4,60.2
X$3998 1849 665 1403 1876 1398 109 150 1894 AOI221_X1
* cell instance $4000 m0 *1 31.73,60.2
X$4000 1573 1535 1042 1681 1876 109 150 1947 AOI221_X1
* cell instance $4003 r0 *1 26.79,60.2
X$4003 714 1872 109 150 1944 NOR2_X1
* cell instance $4006 r0 *1 29.07,60.2
X$4006 1849 1642 618 1699 1760 150 109 1925 OAI221_X1
* cell instance $4007 r0 *1 30.21,60.2
X$4007 1893 1925 1913 1894 109 150 1946 AOI22_X1
* cell instance $4011 r0 *1 32.49,60.2
X$4011 1947 1949 1871 150 1948 109 OAI21_X1
* cell instance $4012 r0 *1 33.25,60.2
X$4012 1699 1750 1763 150 1949 109 OAI21_X1
* cell instance $4014 m0 *1 33.25,60.2
X$4014 1876 1536 1005 1573 1622 109 150 1951 AOI221_X1
* cell instance $4015 m0 *1 34.58,60.2
X$4015 1699 1762 1527 150 1895 109 OAI21_X1
* cell instance $4019 r0 *1 34.01,60.2
X$4019 1951 1895 1952 150 1950 109 OAI21_X1
* cell instance $4020 r0 *1 34.77,60.2
X$4020 1849 1723 1872 1462 109 150 1952 AOI22_X1
* cell instance $4023 r0 *1 37.62,60.2
X$4023 1361 1916 1896 1759 109 150 1953 AOI22_X1
* cell instance $4024 r0 *1 38.57,60.2
X$4024 1483 1891 1311 109 150 1916 NOR3_X1
* cell instance $4026 m0 *1 39.71,60.2
X$4026 559 1896 150 109 1889 AND2_X1
* cell instance $4030 r0 *1 39.71,60.2
X$4030 1810 1953 1954 1146 1594 109 150 1955 AOI221_X1
* cell instance $4031 r0 *1 40.85,60.2
X$4031 1202 1898 109 150 1954 NOR2_X1
* cell instance $4032 r0 *1 41.42,60.2
X$4032 1955 1897 1788 109 1985 150 AOI21_X1
* cell instance $4033 r0 *1 42.18,60.2
X$4033 1186 1900 109 150 1956 NOR2_X1
* cell instance $4034 m0 *1 42.56,60.2
X$4034 1920 1915 1851 109 1919 150 AOI21_X1
* cell instance $4037 r0 *1 42.75,60.2
X$4037 1897 1642 1141 1898 1760 150 109 1926 OAI221_X1
* cell instance $4039 m0 *1 43.7,60.2
X$4039 1186 1826 109 150 1920 NOR2_X1
* cell instance $4041 r0 *1 43.89,60.2
X$4041 1891 109 150 1957 INV_X1
* cell instance $4042 r0 *1 44.27,60.2
X$4042 1672 1957 1374 109 150 1983 NAND3_X1
* cell instance $4043 r0 *1 45.03,60.2
X$4043 1897 1235 1236 1889 1398 109 150 1982 AOI221_X1
* cell instance $4045 r0 *1 47.69,60.2
X$4045 722 1891 1406 150 1927 109 NOR3_X2
* cell instance $4046 m0 *1 47.88,60.2
X$4046 1877 1535 1042 1681 1850 109 150 1899 AOI221_X1
* cell instance $4048 m0 *1 49.02,60.2
X$4048 1899 1852 1918 150 1917 109 OAI21_X1
* cell instance $4050 m0 *1 49.97,60.2
X$4050 1850 1407 1369 1877 1465 109 150 1914 AOI221_X1
* cell instance $4051 m0 *1 51.11,60.2
X$4051 1850 1536 788 1877 1622 109 150 1901 AOI221_X1
* cell instance $4052 m0 *1 52.25,60.2
X$4052 1823 1762 1527 150 1902 109 OAI21_X1
* cell instance $4055 r0 *1 49.21,60.2
X$4055 1897 1780 1900 1432 109 150 1978 AOI22_X1
* cell instance $4058 r0 *1 51.11,60.2
X$4058 1889 1536 788 1927 1622 109 150 1928 AOI221_X1
* cell instance $4059 r0 *1 52.25,60.2
X$4059 1901 1902 1929 150 1942 109 OAI21_X1
* cell instance $4066 m0 *1 12.16,68.6
X$4066 2174 1659 2009 109 150 2114 MUX2_X1
* cell instance $4068 m0 *1 13.68,68.6
X$4068 109 2386 2009 2114 1638 150 DFF_X1
* cell instance $4079 r0 *1 13.87,68.6
X$4079 2195 1659 2018 109 150 2139 MUX2_X1
* cell instance $4080 r0 *1 15.2,68.6
X$4080 109 2434 2018 2139 1600 150 DFF_X1
* cell instance $4082 r0 *1 19.19,68.6
X$4082 109 2448 2142 2160 1600 150 DFF_X1
* cell instance $4083 m0 *1 19.76,68.6
X$4083 109 2401 2083 2119 1600 150 DFF_X1
* cell instance $4085 m0 *1 22.99,68.6
X$4085 2128 1695 1699 109 150 2119 MUX2_X1
* cell instance $4087 r0 *1 22.42,68.6
X$4087 2142 109 150 2049 BUF_X2
* cell instance $4089 m0 *1 24.89,68.6
X$4089 2121 2049 1788 109 2129 150 AOI21_X1
* cell instance $4091 m0 *1 25.65,68.6
X$4091 763 2099 109 150 2011 NOR2_X1
* cell instance $4093 m0 *1 26.41,68.6
X$4093 763 2096 109 150 2071 NOR2_X1
* cell instance $4095 m0 *1 27.17,68.6
X$4095 259 2100 109 150 2101 NAND2_X1
* cell instance $4097 m0 *1 27.93,68.6
X$4097 2066 1642 618 2099 1760 150 109 2085 OAI221_X1
* cell instance $4099 m0 *1 29.26,68.6
X$4099 2102 2090 2014 2074 109 150 2131 AOI22_X1
* cell instance $4100 m0 *1 30.21,68.6
X$4100 2049 1642 618 2047 1760 150 109 2090 OAI221_X1
* cell instance $4102 m0 *1 31.54,68.6
X$4102 2075 1642 618 2096 1760 150 109 2123 OAI221_X1
* cell instance $4105 r0 *1 26.98,68.6
X$4105 2072 2066 1788 109 2206 150 AOI21_X1
* cell instance $4106 r0 *1 27.74,68.6
X$4106 2101 2085 2048 2073 109 150 2254 AOI22_X1
* cell instance $4107 r0 *1 28.69,68.6
X$4107 259 2103 109 150 2102 NAND2_X1
* cell instance $4109 r0 *1 29.45,68.6
X$4109 2130 2123 2039 2094 109 150 2167 AOI22_X1
* cell instance $4111 r0 *1 30.78,68.6
X$4111 259 2098 109 150 2130 NAND2_X1
* cell instance $4114 r0 *1 33.06,68.6
X$4114 2049 1780 2103 1432 109 150 2172 AOI22_X1
* cell instance $4115 m0 *1 33.82,68.6
X$4115 2096 1762 1527 150 2126 109 OAI21_X1
* cell instance $4116 m0 *1 33.06,68.6
X$4116 2099 1762 1527 150 2145 109 OAI21_X1
* cell instance $4117 m0 *1 34.58,68.6
X$4117 2075 1723 2098 1462 109 150 2104 AOI22_X1
* cell instance $4119 m0 *1 35.72,68.6
X$4119 2066 1723 2100 1462 109 150 2132 AOI22_X1
* cell instance $4120 m0 *1 36.67,68.6
X$4120 2049 1723 2103 1462 109 150 2097 AOI22_X1
* cell instance $4121 m0 *1 37.62,68.6
X$4121 2075 1504 2098 1524 109 150 2124 AOI22_X1
* cell instance $4122 m0 *1 38.57,68.6
X$4122 2125 2146 2124 150 2095 109 OAI21_X1
* cell instance $4126 r0 *1 34.2,68.6
X$4126 2078 2126 2104 150 2173 109 OAI21_X1
* cell instance $4128 r0 *1 35.15,68.6
X$4128 2077 2145 2132 150 2214 109 OAI21_X1
* cell instance $4130 r0 *1 36.29,68.6
X$4130 2047 1484 1542 150 2171 109 OAI21_X1
* cell instance $4131 r0 *1 37.05,68.6
X$4131 2099 1484 1542 150 2150 109 OAI21_X1
* cell instance $4132 r0 *1 37.81,68.6
X$4132 2049 1504 2103 1524 109 150 2151 AOI22_X1
* cell instance $4133 r0 *1 38.76,68.6
X$4133 2096 1484 1542 150 2146 109 OAI21_X1
* cell instance $4135 r0 *1 39.71,68.6
X$4135 2066 1504 2100 1524 109 150 2169 AOI22_X1
* cell instance $4137 m0 *1 40.47,68.6
X$4137 763 2091 109 150 2093 NOR2_X1
* cell instance $4139 r0 *1 41.42,68.6
X$4139 2092 2087 1788 109 2168 150 AOI21_X1
* cell instance $4140 m0 *1 43.51,68.6
X$4140 2067 1642 618 2088 1760 150 109 2086 OAI221_X1
* cell instance $4141 m0 *1 41.42,68.6
X$4141 2091 1760 1642 2087 618 2122 109 150 OAI221_X2
* cell instance $4142 m0 *1 44.65,68.6
X$4142 1287 2108 109 150 2107 NAND2_X1
* cell instance $4143 m0 *1 45.22,68.6
X$4143 2107 2086 2020 2079 109 150 2109 AOI22_X1
* cell instance $4146 r0 *1 42.18,68.6
X$4146 2106 2067 1788 109 2152 150 AOI21_X1
* cell instance $4147 r0 *1 42.94,68.6
X$4147 714 2108 109 150 2220 NOR2_X1
* cell instance $4148 r0 *1 43.51,68.6
X$4148 2166 2122 2134 2019 109 150 2185 AOI22_X2
* cell instance $4149 r0 *1 45.22,68.6
X$4149 1287 2136 109 150 2166 NAND2_X1
* cell instance $4152 r0 *1 47.69,68.6
X$4152 2091 1484 1542 150 2163 109 OAI21_X1
* cell instance $4153 m0 *1 48.26,68.6
X$4153 2091 1762 1527 150 2084 109 OAI21_X1
* cell instance $4156 m0 *1 49.21,68.6
X$4156 2087 1723 2136 1462 109 150 2118 AOI22_X1
* cell instance $4157 m0 *1 50.16,68.6
X$4157 2120 2084 2118 150 2110 109 OAI21_X1
* cell instance $4158 m0 *1 50.92,68.6
X$4158 2067 1723 2108 1462 109 150 2117 AOI22_X1
* cell instance $4159 m0 *1 51.87,68.6
X$4159 2116 2115 2117 150 2082 109 OAI21_X1
* cell instance $4160 m0 *1 52.63,68.6
X$4160 2088 1762 1527 150 2115 109 OAI21_X1
* cell instance $4163 m0 *1 55.1,68.6
X$4163 109 2364 2113 2143 1778 150 DFF_X1
* cell instance $4166 r0 *1 48.45,68.6
X$4166 2080 2163 2154 150 2153 109 OAI21_X1
* cell instance $4167 r0 *1 49.21,68.6
X$4167 2087 1504 2136 1524 109 150 2154 AOI22_X1
* cell instance $4171 r0 *1 51.49,68.6
X$4171 2067 1504 2108 1524 109 150 2161 AOI22_X1
* cell instance $4172 r0 *1 52.44,68.6
X$4172 2111 2137 2161 150 2155 109 OAI21_X1
* cell instance $4174 r0 *1 53.39,68.6
X$4174 2088 1484 1542 150 2137 109 OAI21_X1
* cell instance $4175 r0 *1 54.15,68.6
X$4175 2144 109 150 1943 BUF_X1
* cell instance $4176 r0 *1 54.72,68.6
X$4176 2141 1841 2087 109 150 2143 MUX2_X1
* cell instance $4179 r0 *1 57.19,68.6
X$4179 2113 109 150 2087 BUF_X2
* cell instance $4182 r0 *1 58.52,68.6
X$4182 2189 1799 2100 109 150 2158 MUX2_X1
* cell instance $4186 m0 *1 59.66,68.6
X$4186 109 2397 2112 2140 1579 150 DFF_X1
* cell instance $4188 m0 *1 62.89,68.6
X$4188 2112 109 150 2103 BUF_X2
* cell instance $4194 r0 *1 59.85,68.6
X$4194 2190 1799 2103 109 150 2140 MUX2_X1
* cell instance $4197 r0 *1 61.75,68.6
X$4197 1831 109 150 2157 BUF_X1
* cell instance $4199 r0 *1 62.51,68.6
X$4199 109 2429 2138 2193 1579 150 DFF_X1
* cell instance $4200 r0 *1 65.74,68.6
X$4200 2138 109 150 2108 BUF_X2
* cell instance $4208 m0 *1 8.17,57.4
X$4208 1813 109 150 1792 BUF_X1
* cell instance $4215 r0 *1 2.47,57.4
X$4215 1842 109 150 1815 BUF_X1
* cell instance $4220 r0 *1 3.23,57.4
X$4220 1815 1733 1856 109 150 1857 MUX2_X1
* cell instance $4221 r0 *1 4.56,57.4
X$4221 109 1846 1856 1857 1457 150 DFF_X1
* cell instance $4222 r0 *1 7.79,57.4
X$4222 1814 109 150 1858 BUF_X1
* cell instance $4223 r0 *1 8.36,57.4
X$4223 109 1843 1638 1820 1883 150 DFF_X2
* cell instance $4224 m0 *1 11.59,57.4
X$4224 1792 1659 1697 109 150 1793 MUX2_X1
* cell instance $4226 m0 *1 12.92,57.4
X$4226 109 2382 1697 1793 1638 150 DFF_X1
* cell instance $4229 m0 *1 18.43,57.4
X$4229 1860 109 150 1758 BUF_X2
* cell instance $4230 m0 *1 19.19,57.4
X$4230 673 109 150 1600 CLKBUF_X3
* cell instance $4231 m0 *1 20.14,57.4
X$4231 1361 1773 1759 1599 109 150 1862 AOI22_X2
* cell instance $4233 m0 *1 22.04,57.4
X$4233 1832 1758 1788 109 1847 150 AOI21_X1
* cell instance $4234 m0 *1 22.8,57.4
X$4234 763 1715 109 150 1833 NOR2_X1
* cell instance $4235 m0 *1 23.37,57.4
X$4235 1810 1800 1774 1146 221 109 150 1832 AOI221_X1
* cell instance $4236 m0 *1 24.51,57.4
X$4236 1802 1801 1816 109 1835 150 AOI21_X1
* cell instance $4239 r0 *1 12.16,57.4
X$4239 1858 1659 1845 109 150 1844 MUX2_X1
* cell instance $4244 r0 *1 16.34,57.4
X$4244 109 2424 1860 1861 1600 150 DFF_X1
* cell instance $4245 r0 *1 19.57,57.4
X$4245 1986 1841 1758 109 150 1861 MUX2_X1
* cell instance $4248 r0 *1 21.47,57.4
X$4248 666 1846 336 109 150 1848 NOR3_X1
* cell instance $4249 r0 *1 22.23,57.4
X$4249 1862 1810 1833 1146 221 1887 150 109 AOI221_X2
* cell instance $4251 r0 *1 24.7,57.4
X$4251 1846 109 150 1588 INV_X1
* cell instance $4253 m0 *1 26.22,57.4
X$4253 1805 1718 1817 109 1804 150 AOI21_X1
* cell instance $4254 m0 *1 25.65,57.4
X$4254 1001 1807 109 150 1802 NOR2_X1
* cell instance $4255 m0 *1 26.98,57.4
X$4255 1229 1758 1260 109 1817 150 AOI21_X1
* cell instance $4257 m0 *1 27.93,57.4
X$4257 1229 1786 1260 109 1816 150 AOI21_X1
* cell instance $4259 r0 *1 25.84,57.4
X$4259 714 1671 109 150 1910 NOR2_X1
* cell instance $4260 r0 *1 26.41,57.4
X$4260 1867 1719 1866 109 1865 150 AOI21_X1
* cell instance $4261 r0 *1 27.17,57.4
X$4261 1229 1849 1260 109 1866 150 AOI21_X1
* cell instance $4262 r0 *1 27.93,57.4
X$4262 1001 1872 109 150 1867 NOR2_X1
* cell instance $4264 m0 *1 29.26,57.4
X$4264 259 1807 109 150 1818 NAND2_X1
* cell instance $4266 m0 *1 29.83,57.4
X$4266 1818 1785 1761 1819 109 150 1808 AOI22_X1
* cell instance $4267 m0 *1 30.78,57.4
X$4267 1703 1786 665 109 1819 150 AOI21_X1
* cell instance $4269 m0 *1 31.73,57.4
X$4269 1786 1642 618 1715 1760 150 109 1785 OAI221_X1
* cell instance $4270 m0 *1 32.87,57.4
X$4270 1592 1787 1812 150 1811 109 OAI21_X1
* cell instance $4271 m0 *1 33.63,57.4
X$4271 1715 1762 1527 150 1839 109 OAI21_X1
* cell instance $4272 m0 *1 34.39,57.4
X$4272 1786 1780 1807 1432 109 150 1812 AOI22_X1
* cell instance $4277 r0 *1 33.25,57.4
X$4277 1849 1780 1872 1432 109 150 1871 AOI22_X1
* cell instance $4278 r0 *1 34.2,57.4
X$4278 1630 1839 1873 150 1890 109 OAI21_X1
* cell instance $4280 r0 *1 35.34,57.4
X$4280 1786 1723 1807 1462 109 150 1873 AOI22_X1
* cell instance $4282 m0 *1 38.19,57.4
X$4282 517 150 1841 109 BUF_X4
* cell instance $4283 m0 *1 37.24,57.4
X$4283 305 109 150 1915 CLKBUF_X3
* cell instance $4286 r0 *1 39.71,57.4
X$4286 1483 1820 1311 109 150 1840 NOR3_X1
* cell instance $4287 m0 *1 40.09,57.4
X$4287 1168 1840 1845 1759 109 150 1809 AOI22_X1
* cell instance $4290 m0 *1 41.23,57.4
X$4290 1810 1809 1821 1143 1594 109 150 1838 AOI221_X1
* cell instance $4293 r0 *1 40.47,57.4
X$4293 559 1845 150 109 1850 AND2_X1
* cell instance $4295 r0 *1 41.61,57.4
X$4295 1202 1823 109 150 1821 NOR2_X1
* cell instance $4297 r0 *1 42.37,57.4
X$4297 1838 1822 1788 109 1851 150 AOI21_X1
* cell instance $4298 r0 *1 43.13,57.4
X$4298 1822 1642 1141 1823 1760 150 109 1869 OAI221_X1
* cell instance $4299 m0 *1 43.7,57.4
X$4299 1287 1826 109 150 1837 NAND2_X1
* cell instance $4301 m0 *1 44.27,57.4
X$4301 1672 1836 1374 109 150 1824 NAND3_X1
* cell instance $4302 m0 *1 45.03,57.4
X$4302 305 109 150 1186 CLKBUF_X3
* cell instance $4304 m0 *1 46.17,57.4
X$4304 1806 1040 1726 109 1825 150 AOI21_X1
* cell instance $4307 m0 *1 49.21,57.4
X$4307 1822 1780 1826 1183 109 150 1918 AOI22_X1
* cell instance $4311 m0 *1 52.63,57.4
X$4311 1766 1790 1827 150 1803 109 OAI21_X1
* cell instance $4312 m0 *1 53.39,57.4
X$4312 1678 1504 1680 1524 109 150 1827 AOI22_X1
* cell instance $4314 r0 *1 44.27,57.4
X$4314 1820 109 150 1836 INV_X1
* cell instance $4316 r0 *1 44.84,57.4
X$4316 1837 1869 1824 1868 109 150 1870 AOI22_X1
* cell instance $4317 r0 *1 45.79,57.4
X$4317 1235 1822 1236 1850 842 1868 150 109 AOI221_X2
* cell instance $4318 r0 *1 47.88,57.4
X$4318 722 1820 1406 150 1877 109 NOR3_X2
* cell instance $4321 r0 *1 49.78,57.4
X$4321 1823 1750 1763 150 1852 109 OAI21_X1
* cell instance $4324 r0 *1 52.44,57.4
X$4324 1822 1723 1826 1204 109 150 1929 AOI22_X1
* cell instance $4325 r0 *1 53.39,57.4
X$4325 1822 1504 1826 1524 109 150 1853 AOI22_X1
* cell instance $4328 m0 *1 54.72,57.4
X$4328 1751 1706 1834 1789 109 150 1831 AOI22_X2
* cell instance $4330 m0 *1 59.66,57.4
X$4330 109 2376 1797 1798 1778 150 DFF_X1
* cell instance $4331 m0 *1 58.33,57.4
X$4331 1884 1799 1671 109 150 1798 MUX2_X1
* cell instance $4332 m0 *1 62.89,57.4
X$4332 1797 109 150 1671 BUF_X2
* cell instance $4339 r0 *1 63.65,57.4
X$4339 109 2475 1864 1863 1579 150 DFF_X1
* cell instance $4340 m0 *1 64.22,57.4
X$4340 1795 1070 1648 109 150 1796 MUX2_X1
* cell instance $4344 m0 *1 67.45,57.4
X$4344 1705 109 150 1686 BUF_X1
* cell instance $4345 m0 *1 66.69,57.4
X$4345 1864 109 150 1678 BUF_X2
* cell instance $4347 r0 *1 66.88,57.4
X$4347 1859 1070 1678 109 150 1863 MUX2_X1
* cell instance $4350 m0 *1 68.4,57.4
X$4350 1791 109 150 1795 BUF_X1
* cell instance $4358 m0 *1 19.19,4.2
X$4358 167 170 109 150 185 NOR2_X1
* cell instance $4359 m0 *1 20.33,4.2
X$4359 124 168 109 150 152 NOR2_X1
* cell instance $4360 m0 *1 21.47,4.2
X$4360 126 170 109 150 125 NOR2_X1
* cell instance $4361 m0 *1 22.61,4.2
X$4361 126 169 109 150 127 NOR2_X1
* cell instance $4362 m0 *1 23.75,4.2
X$4362 126 129 109 150 128 NOR2_X1
* cell instance $4363 m0 *1 26.03,4.2
X$4363 131 158 215 109 150 171 MUX2_X1
* cell instance $4364 m0 *1 27.36,4.2
X$4364 133 158 164 109 150 190 MUX2_X1
* cell instance $4365 m0 *1 28.69,4.2
X$4365 109 2399 192 190 172 150 DFF_X1
* cell instance $4366 m0 *1 31.92,4.2
X$4366 192 109 150 164 BUF_X2
* cell instance $4367 m0 *1 32.68,4.2
X$4367 109 2378 176 165 172 150 DFF_X1
* cell instance $4368 m0 *1 35.91,4.2
X$4368 109 2374 177 135 136 150 DFF_X1
* cell instance $4369 m0 *1 39.14,4.2
X$4369 109 2409 161 163 136 150 DFF_X1
* cell instance $4371 m0 *1 42.56,4.2
X$4371 109 2420 157 160 136 150 DFF_X1
* cell instance $4382 r0 *1 20.52,4.2
X$4382 169 168 109 150 123 NOR2_X1
* cell instance $4386 r0 *1 25.27,4.2
X$4386 130 158 218 109 150 241 MUX2_X1
* cell instance $4387 r0 *1 26.6,4.2
X$4387 109 2444 188 171 172 150 DFF_X1
* cell instance $4388 r0 *1 29.83,4.2
X$4388 188 109 150 215 BUF_X2
* cell instance $4392 r0 *1 35.34,4.2
X$4392 176 109 150 193 BUF_X2
* cell instance $4396 r0 *1 38.76,4.2
X$4396 177 109 150 174 BUF_X2
* cell instance $4400 r0 *1 40.85,4.2
X$4400 161 109 150 175 BUF_X2
* cell instance $4405 r0 *1 44.65,4.2
X$4405 109 2471 243 199 136 150 DFF_X1
* cell instance $4406 m0 *1 49.4,4.2
X$4406 109 2403 140 156 136 150 DFF_X1
* cell instance $4407 m0 *1 52.63,4.2
X$4407 109 2416 198 155 136 150 DFF_X1
* cell instance $4408 m0 *1 56.43,4.2
X$4408 109 2385 144 154 142 150 DFF_X1
* cell instance $4409 m0 *1 59.66,4.2
X$4409 109 2400 187 189 147 150 DFF_X1
* cell instance $4410 m0 *1 63.65,4.2
X$4410 109 2362 184 149 147 150 DFF_X1
* cell instance $4411 m0 *1 66.88,4.2
X$4411 184 109 150 148 BUF_X2
* cell instance $4422 r0 *1 57.95,4.2
X$4422 144 109 150 182 BUF_X2
* cell instance $4427 r0 *1 61.94,4.2
X$4427 187 109 150 183 BUF_X2
* cell instance $4438 m0 *1 13.68,7
X$4438 166 216 234 109 150 235 MUX2_X1
* cell instance $4442 m0 *1 17.48,7
X$4442 236 216 237 109 150 278 MUX2_X1
* cell instance $4445 m0 *1 22.04,7
X$4445 109 2366 240 241 172 150 DFF_X1
* cell instance $4446 m0 *1 25.27,7
X$4446 240 109 150 218 BUF_X2
* cell instance $4449 m0 *1 26.98,7
X$4449 132 158 203 109 150 217 MUX2_X1
* cell instance $4463 r0 *1 13.3,7
X$4463 109 2455 275 235 274 150 DFF_X1
* cell instance $4464 r0 *1 16.53,7
X$4464 275 109 150 234 BUF_X2
* cell instance $4467 r0 *1 17.86,7
X$4467 109 2449 276 278 335 150 DFF_X1
* cell instance $4468 r0 *1 21.09,7
X$4468 276 109 150 237 BUF_X2
* cell instance $4473 r0 *1 26.98,7
X$4473 109 2476 219 217 172 150 DFF_X1
* cell instance $4475 m0 *1 30.21,7
X$4475 219 109 150 203 BUF_X2
* cell instance $4478 m0 *1 38.19,7
X$4478 225 180 109 150 206 NOR2_X1
* cell instance $4480 m0 *1 38.95,7
X$4480 225 140 109 150 253 NOR2_X1
* cell instance $4482 r0 *1 30.21,7
X$4482 218 220 280 150 257 109 OAI21_X1
* cell instance $4483 r0 *1 32.68,7
X$4483 193 221 109 150 261 NAND2_X1
* cell instance $4484 r0 *1 33.25,7
X$4484 175 221 109 150 262 NAND2_X1
* cell instance $4486 r0 *1 34.01,7
X$4486 180 222 109 150 284 NAND2_X1
* cell instance $4487 r0 *1 34.58,7
X$4487 243 222 109 150 285 NAND2_X1
* cell instance $4488 r0 *1 35.15,7
X$4488 140 222 109 150 250 NAND2_X1
* cell instance $4489 r0 *1 35.72,7
X$4489 330 193 223 109 283 150 AOI21_X1
* cell instance $4491 r0 *1 36.67,7
X$4491 286 175 223 109 251 150 AOI21_X1
* cell instance $4493 r0 *1 38.38,7
X$4493 265 205 283 109 224 150 AOI21_X1
* cell instance $4494 r0 *1 39.14,7
X$4494 225 243 109 150 265 NOR2_X1
* cell instance $4495 r0 *1 39.71,7
X$4495 207 205 282 109 248 150 AOI21_X1
* cell instance $4497 m0 *1 39.9,7
X$4497 225 226 109 150 207 NOR2_X1
* cell instance $4504 m0 *1 47.69,7
X$4504 109 2394 180 139 136 150 DFF_X1
* cell instance $4509 r0 *1 41.04,7
X$4509 243 226 140 180 150 266 109 OR4_X2
* cell instance $4512 r0 *1 44.08,7
X$4512 109 2469 226 245 136 150 DFF_X1
* cell instance $4516 r0 *1 48.64,7
X$4516 268 182 223 109 228 150 AOI21_X1
* cell instance $4518 r0 *1 49.78,7
X$4518 269 205 228 109 227 150 AOI21_X1
* cell instance $4519 r0 *1 50.54,7
X$4519 230 205 229 109 181 150 AOI21_X1
* cell instance $4522 r0 *1 51.87,7
X$4522 225 148 109 150 230 NOR2_X1
* cell instance $4527 r0 *1 53.39,7
X$4527 210 158 277 109 150 324 MUX2_X1
* cell instance $4529 m0 *1 55.29,7
X$4529 196 158 322 109 150 231 MUX2_X1
* cell instance $4532 r0 *1 55.48,7
X$4532 109 2439 320 231 142 150 DFF_X1
* cell instance $4533 m0 *1 58.9,7
X$4533 211 158 270 109 150 238 MUX2_X1
* cell instance $4537 r0 *1 58.71,7
X$4537 109 2456 272 238 147 150 DFF_X1
* cell instance $4547 r0 *1 62.32,7
X$4547 109 2425 273 233 147 150 DFF_X1
* cell instance $4548 r0 *1 65.55,7
X$4548 273 109 150 212 BUF_X2
* cell instance $4566 m0 *1 12.54,71.4
X$4566 2147 1659 2013 109 150 2194 MUX2_X1
* cell instance $4569 m0 *1 14.63,71.4
X$4569 109 2419 2013 2194 1600 150 DFF_X1
* cell instance $4570 m0 *1 17.86,71.4
X$4570 2236 109 150 1986 BUF_X1
* cell instance $4576 r0 *1 16.15,71.4
X$4576 2197 109 150 2223 BUF_X1
* cell instance $4577 r0 *1 16.72,71.4
X$4577 109 2426 2198 2224 1600 150 DFF_X1
* cell instance $4578 m0 *1 20.9,71.4
X$4578 1776 109 150 2200 BUF_X1
* cell instance $4579 m0 *1 19.57,71.4
X$4579 2148 1841 2049 109 150 2160 MUX2_X1
* cell instance $4581 m0 *1 21.66,71.4
X$4581 109 2418 2203 2201 1600 150 DFF_X1
* cell instance $4582 m0 *1 24.89,71.4
X$4582 2203 109 150 2099 CLKBUF_X2
* cell instance $4584 m0 *1 25.84,71.4
X$4584 2207 1915 2129 109 2177 150 AOI21_X1
* cell instance $4586 m0 *1 26.79,71.4
X$4586 2165 1915 2206 109 2307 150 AOI21_X1
* cell instance $4588 r0 *1 19.95,71.4
X$4588 2198 109 150 2047 CLKBUF_X2
* cell instance $4589 r0 *1 20.71,71.4
X$4589 1988 109 150 2239 BUF_X1
* cell instance $4590 r0 *1 21.28,71.4
X$4590 2175 109 150 2176 BUF_X1
* cell instance $4592 r0 *1 22.23,71.4
X$4592 2176 1695 2099 109 150 2201 MUX2_X1
* cell instance $4594 r0 *1 23.94,71.4
X$4594 2305 109 150 1997 BUF_X1
* cell instance $4595 r0 *1 24.51,71.4
X$4595 2204 109 150 2075 BUF_X2
* cell instance $4596 r0 *1 25.27,71.4
X$4596 1865 109 150 2240 BUF_X1
* cell instance $4597 r0 *1 25.84,71.4
X$4597 109 2466 2204 2205 1600 150 DFF_X1
* cell instance $4598 m0 *1 28.12,71.4
X$4598 714 2100 109 150 2165 NOR2_X1
* cell instance $4600 m0 *1 28.69,71.4
X$4600 714 2103 109 150 2207 NOR2_X1
* cell instance $4602 r0 *1 29.07,71.4
X$4602 2244 1841 2075 109 150 2205 MUX2_X1
* cell instance $4603 m0 *1 30.4,71.4
X$4603 2178 1915 2209 109 2225 150 AOI21_X1
* cell instance $4604 m0 *1 29.64,71.4
X$4604 2089 2075 1788 109 2209 150 AOI21_X1
* cell instance $4605 m0 *1 31.16,71.4
X$4605 714 2098 109 150 2178 NOR2_X1
* cell instance $4606 m0 *1 31.73,71.4
X$4606 2076 2149 2172 150 2170 109 OAI21_X1
* cell instance $4607 m0 *1 32.49,71.4
X$4607 2047 1750 1763 150 2149 109 OAI21_X1
* cell instance $4608 m0 *1 33.25,71.4
X$4608 2075 1780 2098 1432 109 150 2180 AOI22_X1
* cell instance $4609 m0 *1 34.2,71.4
X$4609 2066 1780 2100 1432 109 150 2210 AOI22_X1
* cell instance $4610 m0 *1 35.15,71.4
X$4610 2229 1695 2096 109 150 2181 MUX2_X1
* cell instance $4613 m0 *1 37.43,71.4
X$4613 2052 2171 2151 150 2182 109 OAI21_X1
* cell instance $4615 m0 *1 38.95,71.4
X$4615 1992 2150 2169 150 2332 109 OAI21_X1
* cell instance $4617 m0 *1 41.23,71.4
X$4617 714 2136 109 150 2218 NOR2_X1
* cell instance $4618 m0 *1 41.8,71.4
X$4618 2218 1915 2168 109 2183 150 AOI21_X1
* cell instance $4619 m0 *1 42.56,71.4
X$4619 2220 1915 2152 109 2184 150 AOI21_X1
* cell instance $4622 m0 *1 44.27,71.4
X$4622 2230 1841 2067 109 150 2186 MUX2_X1
* cell instance $4627 r0 *1 30.97,71.4
X$4627 1808 109 150 2227 BUF_X1
* cell instance $4628 r0 *1 31.54,71.4
X$4628 2050 2179 2180 150 2228 109 OAI21_X1
* cell instance $4629 r0 *1 32.3,71.4
X$4629 2096 1750 1763 150 2179 109 OAI21_X1
* cell instance $4630 r0 *1 33.06,71.4
X$4630 2099 1750 1763 150 2252 109 OAI21_X1
* cell instance $4632 r0 *1 34.01,71.4
X$4632 2051 2252 2210 150 2330 109 OAI21_X1
* cell instance $4633 r0 *1 34.77,71.4
X$4633 2214 109 150 2251 BUF_X1
* cell instance $4634 r0 *1 35.34,71.4
X$4634 109 2460 2215 2181 1600 150 DFF_X1
* cell instance $4635 r0 *1 38.57,71.4
X$4635 2215 109 150 2096 CLKBUF_X2
* cell instance $4636 r0 *1 39.33,71.4
X$4636 2248 1695 2091 109 150 2216 MUX2_X1
* cell instance $4637 r0 *1 40.66,71.4
X$4637 109 2477 2219 2216 1778 150 DFF_X1
* cell instance $4638 r0 *1 43.89,71.4
X$4638 2219 109 150 2091 BUF_X2
* cell instance $4640 r0 *1 44.84,71.4
X$4640 109 2465 2331 2186 1778 150 DFF_X1
* cell instance $4641 m0 *1 46.93,71.4
X$4641 2091 1750 1763 150 2164 109 OAI21_X1
* cell instance $4644 m0 *1 47.88,71.4
X$4644 2135 2164 2162 150 2187 109 OAI21_X1
* cell instance $4645 m0 *1 48.64,71.4
X$4645 2087 1780 2136 1432 109 150 2162 AOI22_X1
* cell instance $4646 m0 *1 49.59,71.4
X$4646 2067 1780 2108 1432 109 150 2221 AOI22_X1
* cell instance $4649 r0 *1 48.07,71.4
X$4649 1781 109 150 2246 BUF_X1
* cell instance $4650 r0 *1 48.64,71.4
X$4650 2088 1750 1763 150 2188 109 OAI21_X1
* cell instance $4651 r0 *1 49.4,71.4
X$4651 2081 2188 2221 150 2191 109 OAI21_X1
* cell instance $4652 r0 *1 50.16,71.4
X$4652 109 2459 2232 2217 1778 150 DFF_X1
* cell instance $4654 m0 *1 51.68,71.4
X$4654 2231 1695 2088 109 150 2217 MUX2_X1
* cell instance $4656 r0 *1 53.39,71.4
X$4656 109 2452 2213 2211 1778 150 DFF_X1
* cell instance $4657 m0 *1 55.48,71.4
X$4657 2082 109 150 2156 BUF_X1
* cell instance $4658 m0 *1 54.15,71.4
X$4658 2212 1841 2066 109 150 2211 MUX2_X1
* cell instance $4659 m0 *1 56.05,71.4
X$4659 109 2406 2208 2158 1778 150 DFF_X1
* cell instance $4660 m0 *1 59.28,71.4
X$4660 2208 109 150 2100 BUF_X2
* cell instance $4663 m0 *1 61.75,71.4
X$4663 1919 109 150 2328 BUF_X1
* cell instance $4664 m0 *1 62.32,71.4
X$4664 2235 109 150 2199 BUF_X1
* cell instance $4665 m0 *1 62.89,71.4
X$4665 2199 1799 2108 109 150 2193 MUX2_X1
* cell instance $4670 r0 *1 56.62,71.4
X$4670 2213 109 150 2066 BUF_X2
* cell instance $4672 r0 *1 57.76,71.4
X$4672 109 2464 2202 2234 1683 150 DFF_X1
* cell instance $4676 r0 *1 60.99,71.4
X$4676 2202 109 150 2098 BUF_X2
* cell instance $4678 r0 *1 62.13,71.4
X$4678 109 2472 2196 2192 1683 150 DFF_X1
* cell instance $4679 r0 *1 65.36,71.4
X$4679 2196 109 150 2136 BUF_X2
* cell instance $4681 r0 *1 66.31,71.4
X$4681 2233 1799 2136 109 150 2192 MUX2_X1
.ENDS mesh_router

* cell OR3_X1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 8 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 5 1 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 4 2 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 5 3 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR3_X1

* cell OAI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin A2
* pin ZN
* pin A1
* pin NWELL,VDD
.SUBCKT OAI22_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 B2
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 4 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 8 3 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 3 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 14 7 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 8 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 15 5 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 15 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 8 5 16 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 1 3 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 2 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI22_X4

* cell OAI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X2 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 2 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 1 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 12 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 4 12 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 11 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 6 3 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 7 1 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 5 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 8 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.12,0.2975 NMOS_VTL
M$14 5 4 8 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI22_X2

* cell NOR4_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin A4
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR4_X4 1 2 3 4 5 6 10
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 1.92,0.995 PMOS_VTL
M$1 8 4 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 2.68,0.995 PMOS_VTL
M$5 10 5 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.995 PMOS_VTL
M$9 6 2 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $13 r0 *1 0.93,0.995 PMOS_VTL
M$13 8 3 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.92,0.2975 NMOS_VTL
M$17 1 4 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.68,0.2975 NMOS_VTL
M$21 1 5 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.17,0.2975 NMOS_VTL
M$25 6 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.93,0.2975 NMOS_VTL
M$29 6 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NOR4_X4

* cell OR2_X2
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X2 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 3 2 4 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 4 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR2_X2

* cell NAND2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 4 1 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 5 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND2_X4

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell OR4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR4_X1 1 2 3 4 5 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 10 1 6 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 2 10 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 11 3 9 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 6 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 6 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 5 2 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 5 4 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 6 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR4_X1

* cell OR4_X4
* pin PWELL,VSS
* pin ZN
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT OR4_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 ZN
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 4 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 5 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 6 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 2 7 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 13 7 2 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 14 6 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 4 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 3 2 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 4 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 1 5 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 2 6 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 7 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 1.69,0.2975 NMOS_VTL
M$21 3 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS OR4_X4

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell OR4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OR4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 ZN
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 11 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 7 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 5 1 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 8 2 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 5 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 8 4 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 7 5 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR4_X2

* cell OAI33_X1
* pin B3
* pin B2
* pin B1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OAI33_X1 1 2 3 4 5 6 7 8 10
* net 1 B3
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 14 1 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 13 2 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 10 3 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 12 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 11 5 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 8 6 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.185,0.2975 NMOS_VTL
M$7 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.375,0.2975 NMOS_VTL
M$8 7 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.565,0.2975 NMOS_VTL
M$9 9 3 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.755,0.2975 NMOS_VTL
M$10 10 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.945,0.2975 NMOS_VTL
M$11 9 5 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.135,0.2975 NMOS_VTL
M$12 10 6 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI33_X1

* cell NAND4_X4
* pin PWELL,VSS
* pin A3
* pin A4
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X4 1 2 3 7 8 9 10
* net 1 PWELL,VSS
* net 2 A3
* net 3 A4
* net 7 A1
* net 8 A2
* net 9 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 10 7 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 10 8 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.22365P PS=3.08U PD=3.23U
* device instance $9 r0 *1 1.885,0.995 PMOS_VTL
M$9 10 2 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.22365P AD=0.1764P PS=3.23U PD=3.08U
* device instance $13 r0 *1 2.645,0.995 PMOS_VTL
M$13 10 3 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.885,0.2975 NMOS_VTL
M$17 5 2 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.645,0.2975 NMOS_VTL
M$21 1 3 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.215,0.2975 NMOS_VTL
M$25 9 7 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.975,0.2975 NMOS_VTL
M$29 5 8 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND4_X4

* cell AOI21_X4
* pin PWELL,VSS
* pin ZN
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
.SUBCKT AOI21_X4 1 2 3 4 5 11
* net 1 PWELL,VSS
* net 2 ZN
* net 3 A
* net 4 B2
* net 5 B1
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 11 3 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 2 4 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 10 5 2 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 2 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 8 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 2 5 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 9 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 6 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.895,0.2975 NMOS_VTL
M$22 2 5 6 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.085,0.2975 NMOS_VTL
M$23 7 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.275,0.2975 NMOS_VTL
M$24 1 4 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X4

* cell NAND3_X4
* pin A2
* pin A1
* pin A3
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND3_X4 1 2 3 4 5 6
* net 1 A2
* net 2 A1
* net 3 A3
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 3 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 6 1 5 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.21,0.2975 NMOS_VTL
M$13 13 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.4,0.2975 NMOS_VTL
M$14 12 1 13 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.59,0.2975 NMOS_VTL
M$15 5 2 12 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.78,0.2975 NMOS_VTL
M$16 10 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.97,0.2975 NMOS_VTL
M$17 8 1 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.16,0.2975 NMOS_VTL
M$18 4 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.35,0.2975 NMOS_VTL
M$19 9 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.54,0.2975 NMOS_VTL
M$20 7 1 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.73,0.2975 NMOS_VTL
M$21 5 2 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.92,0.2975 NMOS_VTL
M$22 14 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.11,0.2975 NMOS_VTL
M$23 11 1 14 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.3,0.2975 NMOS_VTL
M$24 4 3 11 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X4

* cell NAND3_X2
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 10 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 9 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 1 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X2

* cell OAI211_X2
* pin A
* pin B
* pin C2
* pin C1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI211_X2 1 2 3 4 6 7 8
* net 1 A
* net 2 B
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 6 1 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.111825P AD=0.0882P PS=2.245U PD=1.54U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 8 2 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.089775P PS=1.54U PD=1.545U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 9 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 8 3 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.205,0.2975 NMOS_VTL
M$9 12 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.395,0.2975 NMOS_VTL
M$10 7 2 12 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.585,0.2975 NMOS_VTL
M$11 11 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 5 1 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.02905P PS=0.56U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 6 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 5 4 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI211_X2

* cell AND3_X1
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 4 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 8 1 4 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 9 2 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 6 3 9 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND3_X1

* cell NOR4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 3 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 7 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 5 4 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR4_X1

* cell NOR4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 11 1 12 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 10 2 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 6 3 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 9 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 13 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 8 1 13 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 4 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 6 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 7 1 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 6 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 7 3 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR4_X2

* cell AOI21_X2
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X2 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 9 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X2

* cell NOR2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 4 1 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.21,0.2975 NMOS_VTL
M$5 5 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $6 r0 *1 0.4,0.2975 NMOS_VTL
M$6 3 2 5 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR2_X2

* cell AND2_X2
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X2 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 3 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND2_X2

* cell OAI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI221_X1 1 2 3 4 5 7 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 12 1 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 12 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 5 11 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 8 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 6 2 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 10 3 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 9 4 10 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 10 5 9 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI221_X1

* cell CLKBUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.17,0.1875 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $5 r0 *1 0.36,0.1875 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.39U AS=0.0273P AD=0.034125P PS=0.67U PD=0.935U
.ENDS CLKBUF_X2

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell DFF_X2
* pin PWELL,VSS
* pin D
* pin CK
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFF_X2 1 6 8 10 11 16
* net 1 PWELL,VSS
* net 6 D
* net 8 CK
* net 10 QN
* net 11 Q
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.855,0.995 PMOS_VTL
M$1 10 9 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.235,0.995 PMOS_VTL
M$3 11 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.2,0.9275 PMOS_VTL
M$5 16 7 3 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $6 r0 *1 0.39,1.04 PMOS_VTL
M$6 17 4 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $7 r0 *1 0.58,1.04 PMOS_VTL
M$7 17 7 5 16 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $8 r0 *1 0.77,0.975 PMOS_VTL
M$8 18 3 5 16 PMOS_VTL L=0.05U W=0.42U AS=0.01785P AD=0.0294P PS=0.56U PD=0.56U
* device instance $9 r0 *1 0.96,0.975 PMOS_VTL
M$9 16 6 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 1.15,1.0275 PMOS_VTL
M$10 4 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $11 r0 *1 2.135,0.915 PMOS_VTL
M$11 20 3 9 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $12 r0 *1 2.325,0.915 PMOS_VTL
M$12 20 2 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $13 r0 *1 1.565,1.0275 PMOS_VTL
M$13 16 8 7 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $14 r0 *1 1.755,1.0275 PMOS_VTL
M$14 19 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $15 r0 *1 1.945,1.0275 PMOS_VTL
M$15 9 7 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.515,0.995 PMOS_VTL
M$16 2 9 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 2.855,0.2975 NMOS_VTL
M$17 10 9 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $19 r0 *1 3.235,0.2975 NMOS_VTL
M$19 11 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $21 r0 *1 0.39,0.31 NMOS_VTL
M$21 12 4 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $22 r0 *1 0.58,0.31 NMOS_VTL
M$22 12 3 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $23 r0 *1 1.15,0.25 NMOS_VTL
M$23 4 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $24 r0 *1 0.77,0.2825 NMOS_VTL
M$24 13 7 5 1 NMOS_VTL L=0.05U W=0.275U AS=0.012775P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $25 r0 *1 0.96,0.2825 NMOS_VTL
M$25 1 6 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $26 r0 *1 0.2,0.37 NMOS_VTL
M$26 1 7 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $27 r0 *1 1.565,0.35 NMOS_VTL
M$27 1 8 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $28 r0 *1 1.755,0.35 NMOS_VTL
M$28 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $29 r0 *1 1.945,0.35 NMOS_VTL
M$29 9 3 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $30 r0 *1 2.135,0.41 NMOS_VTL
M$30 15 7 9 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $31 r0 *1 2.325,0.41 NMOS_VTL
M$31 15 2 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $32 r0 *1 2.515,0.2975 NMOS_VTL
M$32 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFF_X2

* cell DFF_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 8 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 2.125,0.345 NMOS_VTL
M$17 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $18 r0 *1 2.32,0.345 NMOS_VTL
M$18 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $19 r0 *1 1.555,0.36 NMOS_VTL
M$19 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $20 r0 *1 1.745,0.36 NMOS_VTL
M$20 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $21 r0 *1 1.935,0.36 NMOS_VTL
M$21 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $22 r0 *1 2.51,0.36 NMOS_VTL
M$22 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
* device instance $23 r0 *1 0.185,0.285 NMOS_VTL
M$23 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $24 r0 *1 0.375,0.345 NMOS_VTL
M$24 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 0.565,0.345 NMOS_VTL
M$25 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $26 r0 *1 1.14,0.285 NMOS_VTL
M$26 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.76,0.3175 NMOS_VTL
M$27 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $28 r0 *1 0.95,0.3175 NMOS_VTL
M$28 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
.ENDS DFF_X1

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell HA_X1
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin CO
.SUBCKT HA_X1 1 2 4 5 6 9
* net 1 A
* net 2 B
* net 4 S
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 9 CO
* device instance $1 r0 *1 0.785,1.0275 PMOS_VTL
M$1 10 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $2 r0 *1 0.975,1.0275 PMOS_VTL
M$2 7 1 10 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $3 r0 *1 0.21,0.995 PMOS_VTL
M$3 4 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $4 r0 *1 0.4,0.995 PMOS_VTL
M$4 3 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.59,0.995 PMOS_VTL
M$5 5 7 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0338625P PS=0.77U PD=0.775U
* device instance $6 r0 *1 1.345,1.0275 PMOS_VTL
M$6 8 1 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $7 r0 *1 1.535,1.0275 PMOS_VTL
M$7 8 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $8 r0 *1 1.725,0.995 PMOS_VTL
M$8 9 8 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.345,0.195 NMOS_VTL
M$9 12 1 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $10 r0 *1 1.535,0.195 NMOS_VTL
M$10 6 2 12 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $11 r0 *1 1.725,0.2975 NMOS_VTL
M$11 9 8 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $12 r0 *1 0.785,0.195 NMOS_VTL
M$12 7 2 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.0224P AD=0.0147P PS=0.56U PD=0.35U
* device instance $13 r0 *1 0.975,0.195 NMOS_VTL
M$13 6 1 7 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $14 r0 *1 0.21,0.2975 NMOS_VTL
M$14 11 2 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $15 r0 *1 0.4,0.2975 NMOS_VTL
M$15 4 1 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.59,0.2975 NMOS_VTL
M$16 6 7 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0224P PS=0.555U PD=0.56U
.ENDS HA_X1

* cell AOI222_X2
* pin PWELL,VSS
* pin C2
* pin C1
* pin ZN
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
.SUBCKT AOI222_X2 1 2 3 4 5 6 8 9 16
* net 1 PWELL,VSS
* net 2 C2
* net 3 C1
* net 4 ZN
* net 5 B2
* net 6 B1
* net 8 A1
* net 9 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 17 5 15 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 15 6 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 4 8 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $11 r0 *1 2.255,0.995 PMOS_VTL
M$11 4 9 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 10 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 4 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.31,0.2975 NMOS_VTL
M$19 14 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.5,0.2975 NMOS_VTL
M$20 1 5 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 4 8 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $22 r0 *1 2.065,0.2975 NMOS_VTL
M$22 11 8 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.255,0.2975 NMOS_VTL
M$23 1 9 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.445,0.2975 NMOS_VTL
M$24 7 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI222_X2

* cell AND4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X1 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 5 4 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 10 1 5 7 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 11 2 10 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 9 3 11 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 7 4 9 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 5 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND4_X1

* cell AOI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT AOI22_X4 1 2 3 4 5 6 16
* net 1 PWELL,VSS
* net 2 B2
* net 3 B1
* net 4 ZN
* net 5 A2
* net 6 A1
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.695,0.995 PMOS_VTL
M$9 4 5 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $10 r0 *1 1.885,0.995 PMOS_VTL
M$10 15 6 4 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $17 r0 *1 0.175,0.2975 NMOS_VTL
M$17 7 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.365,0.2975 NMOS_VTL
M$18 4 3 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.555,0.2975 NMOS_VTL
M$19 10 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.745,0.2975 NMOS_VTL
M$20 1 2 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.935,0.2975 NMOS_VTL
M$21 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.125,0.2975 NMOS_VTL
M$22 4 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.315,0.2975 NMOS_VTL
M$23 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.505,0.2975 NMOS_VTL
M$24 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.695,0.2975 NMOS_VTL
M$25 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $26 r0 *1 1.885,0.2975 NMOS_VTL
M$26 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $27 r0 *1 2.075,0.2975 NMOS_VTL
M$27 11 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $28 r0 *1 2.265,0.2975 NMOS_VTL
M$28 1 5 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $29 r0 *1 2.455,0.2975 NMOS_VTL
M$29 14 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $30 r0 *1 2.645,0.2975 NMOS_VTL
M$30 4 6 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $31 r0 *1 2.835,0.2975 NMOS_VTL
M$31 9 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $32 r0 *1 3.025,0.2975 NMOS_VTL
M$32 1 5 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X4

* cell OAI211_X4
* pin PWELL,VSS
* pin A
* pin B
* pin C2
* pin ZN
* pin C1
* pin NWELL,VDD
.SUBCKT OAI211_X4 1 3 4 5 6 7 12
* net 1 PWELL,VSS
* net 3 A
* net 4 B
* net 5 C2
* net 6 ZN
* net 7 C1
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 3 12 12 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 12 4 6 12 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 15 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 12 5 15 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 14 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 14 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 12 5 16 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 8 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 1 4 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.55,0.2975 NMOS_VTL
M$19 10 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.74,0.2975 NMOS_VTL
M$20 2 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.93,0.2975 NMOS_VTL
M$21 9 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.12,0.2975 NMOS_VTL
M$22 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.31,0.2975 NMOS_VTL
M$23 11 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.5,0.2975 NMOS_VTL
M$24 2 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI211_X4

* cell AOI211_X2
* pin B
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI211_X2 1 2 3 4 6 7 8
* net 1 B
* net 2 A
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 10 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 7 2 10 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 9 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 5 1 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.055125P PS=0.77U PD=0.805U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 6 3 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.099225P AD=0.11025P PS=1.575U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 5 4 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 6 1 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0653625P PS=1.595U
+ PD=1.145U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 6 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 11 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.0363125P AD=0.02905P PS=0.59U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 6 4 11 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 12 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 8 3 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI211_X2

* cell OAI221_X2
* pin C2
* pin C1
* pin B1
* pin B2
* pin A
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI221_X2 1 2 3 4 5 7 9 10
* net 1 C2
* net 2 C1
* net 3 B1
* net 4 B2
* net 5 A
* net 7 ZN
* net 9 PWELL,VSS
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 1 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 2 12 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 11 2 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 10 1 11 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 5 10 10 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 14 3 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 10 4 14 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 13 4 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.73,0.995 PMOS_VTL
M$9 7 3 13 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 0.21,0.2975 NMOS_VTL
M$11 7 1 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.4,0.2975 NMOS_VTL
M$12 6 2 7 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.97,0.2975 NMOS_VTL
M$15 8 5 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $16 r0 *1 1.16,0.2975 NMOS_VTL
M$16 9 3 8 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.35,0.2975 NMOS_VTL
M$17 8 4 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI221_X2

* cell AOI211_X4
* pin C1
* pin C2
* pin B
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI211_X4 1 2 3 4 8 9 10
* net 1 C1
* net 2 C2
* net 3 B
* net 4 A
* net 8 PWELL,VSS
* net 9 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 7 9 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 6 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 3 7 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 11 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 6 9 9 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 10 5 9 9 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 12 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 8 2 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 6 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 8 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 5 6 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.31,0.2975 NMOS_VTL
M$17 10 5 8 8 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U
+ PD=2.705U
.ENDS AOI211_X4

* cell AOI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X1 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 8 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 8 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 8 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 9 3 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X1

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell OR3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 11 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.585,0.995 PMOS_VTL
M$3 4 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.775,0.995 PMOS_VTL
M$4 9 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.965,0.995 PMOS_VTL
M$5 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.155,0.995 PMOS_VTL
M$6 6 1 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.345,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.177975P AD=0.200025P PS=3.085U
+ PD=3.785U
* device instance $11 r0 *1 0.205,0.2975 NMOS_VTL
M$11 4 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.395,0.2975 NMOS_VTL
M$12 5 2 4 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.585,0.2975 NMOS_VTL
M$13 4 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.345,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1172375P AD=0.1317625P PS=2.225U
+ PD=2.71U
.ENDS OR3_X4

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell AOI221_X2
* pin B1
* pin B2
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI221_X2 1 2 3 4 5 6 8 9
* net 1 B1
* net 2 B2
* net 3 A
* net 4 C2
* net 5 C1
* net 6 ZN
* net 8 NWELL,VDD
* net 9 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 3 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.09135P PS=2.24U PD=1.55U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 1 7 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.32,0.995 PMOS_VTL
M$7 6 4 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.09135P AD=0.11025P PS=1.55U PD=2.24U
* device instance $8 r0 *1 1.51,0.995 PMOS_VTL
M$8 10 5 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 6 3 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.060175P PS=1.595U
+ PD=1.12U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 14 1 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 9 2 14 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 13 2 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 6 1 13 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.32,0.2975 NMOS_VTL
M$17 12 4 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.031125P AD=0.02905P PS=0.565U
+ PD=0.555U
* device instance $18 r0 *1 1.51,0.2975 NMOS_VTL
M$18 6 5 12 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.7,0.2975 NMOS_VTL
M$19 11 5 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.89,0.2975 NMOS_VTL
M$20 9 4 11 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X2

* cell AOI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X2 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 8 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.125,0.995 PMOS_VTL
M$6 6 4 8 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 12 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.555,0.2975 NMOS_VTL
M$11 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.745,0.2975 NMOS_VTL
M$12 5 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.935,0.2975 NMOS_VTL
M$13 11 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.125,0.2975 NMOS_VTL
M$14 8 4 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.315,0.2975 NMOS_VTL
M$15 9 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.505,0.2975 NMOS_VTL
M$16 5 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X2

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell NOR3_X2
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 10 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 9 2 10 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 3 9 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 8 3 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 4 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 5 1 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 6 2 5 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 5 3 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR3_X2

* cell AND2_X4
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT AND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 3 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 8 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 3 2 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.55,0.2975 NMOS_VTL
M$11 7 2 3 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.74,0.2975 NMOS_VTL
M$12 6 1 7 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 5 3 6 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND2_X4

* cell NOR2_X4
* pin A2
* pin A1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT NOR2_X4 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 ZN
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 9 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 3 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 8 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 1 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 3 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 6 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 1 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 3 1 4 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 4 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS NOR2_X4

* cell OR3_X2
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 5 1 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 4 2 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 5 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR3_X2

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2

* cell OAI21_X2
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X2 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 3 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 5 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 6 1 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 7 2 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 4 3 7 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI21_X2

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X4 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell OAI21_X4
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X4 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 11 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 7 3 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 10 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 5 2 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 9 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 7 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 8 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 5 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 6 1 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 7 2 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 3 7 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI21_X4

* cell NOR3_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR3_X4 1 2 3 4 5 8
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 ZN
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 2 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 6 3 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 6 4 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 5 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 5 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 5 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS NOR3_X4

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X2 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell BUF_X8
* pin PWELL,VSS
* pin Z
* pin NWELL,VDD
* pin A
.SUBCKT BUF_X8 1 3 4 5
* net 1 PWELL,VSS
* net 3 Z
* net 4 NWELL,VDD
* net 5 A
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 5 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 3 2 4 4 PMOS_VTL L=0.05U W=5.04U AS=0.3528P AD=0.37485P PS=6.16U PD=6.86U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.2324P AD=0.246925P PS=4.44U PD=4.925U
.ENDS BUF_X8
