* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_serdes clk enable load mode parallel_in[0]
+ parallel_in[1] parallel_in[2] parallel_in[3] parallel_in[4]
+ parallel_in[5] parallel_in[6] parallel_in[7] parallel_out[0]
+ parallel_out[1] parallel_out[2] parallel_out[3] parallel_out[4]
+ parallel_out[5] parallel_out[6] parallel_out[7] rst_n rx_done
+ serial_in serial_out tx_done
X_167_ rst_n _122_ VDD VSS CLKBUF_X2
X_168_ _122_ _123_ VDD VSS BUF_X2
X_169_ _123_ _124_ VDD VSS BUF_X2
X_170_ net19 _125_ VDD VSS BUF_X2
X_171_ load _126_ VDD VSS BUF_X4
X_172_ _163_ _127_ VDD VSS BUF_X4
X_173_ rx_bit_counter\[3\] rx_bit_counter\[2\] _127_ _128_
+ VDD VSS AOI21_X4
X_174_ enable _129_ VDD VSS BUF_X4
X_175_ _129_ net1 _130_ VDD VSS NAND2_X2
X_176_ _125_ _126_ _128_ _130_ _131_ VDD VSS NOR4_X4
X_177_ net16 rx_shift_reg\[4\] _131_ _132_ VDD VSS MUX2_X1
X_178_ _124_ _132_ _003_ VDD VSS AND2_X1
X_179_ net17 rx_shift_reg\[5\] _131_ _036_ VDD VSS MUX2_X1
X_180_ _124_ _036_ _004_ VDD VSS AND2_X1
X_181_ net18 rx_shift_reg\[6\] _131_ _037_ VDD VSS MUX2_X1
X_182_ _124_ _037_ _005_ VDD VSS AND2_X1
X_183_ _123_ _038_ VDD VSS INV_X2
X_184_ rx_bit_counter\[0\] _039_ VDD VSS INV_X1
X_185_ rx_bit_counter\[2\] _127_ _040_ VDD VSS NAND2_X1
X_186_ _126_ _041_ VDD VSS INV_X2
X_187_ _130_ _041_ _125_ _042_ VDD VSS AOI21_X4
X_188_ _126_ rx_bit_counter\[3\] _043_ VDD VSS NOR2_X2
X_189_ _039_ _040_ _042_ _043_ _044_ VDD VSS NAND4_X1
X_190_ _129_ net1 _045_ VDD VSS AND2_X1
X_191_ _125_ _046_ VDD VSS INV_X1
X_192_ _045_ _126_ _046_ _047_ VDD VSS OAI21_X2
X_193_ rx_bit_counter\[0\] _047_ _048_ VDD VSS NAND2_X1
X_194_ _038_ _044_ _048_ _006_ VDD VSS AOI21_X1
X_195_ rx_bit_counter\[1\] _047_ _049_ VDD VSS NAND2_X1
X_196_ _164_ _040_ _042_ _043_ _050_ VDD VSS NAND4_X1
X_197_ _038_ _049_ _050_ _007_ VDD VSS AOI21_X1
X_198_ _126_ rx_bit_counter\[3\] _127_ _051_ VDD VSS NOR3_X1
X_199_ rx_bit_counter\[2\] _047_ _051_ _052_ VDD VSS OAI21_X1
X_200_ rx_bit_counter\[2\] _053_ VDD VSS INV_X1
X_201_ _053_ _127_ _042_ _043_ _054_ VDD VSS NAND4_X1
X_202_ _038_ _052_ _054_ _008_ VDD VSS AOI21_X1
X_203_ rx_bit_counter\[0\] rx_bit_counter\[1\] _043_ _055_
+ VDD VSS NAND3_X1
X_204_ _053_ _127_ _047_ _055_ _056_ VDD VSS OR4_X1
X_205_ rx_bit_counter\[3\] _047_ _057_ VDD VSS NAND2_X1
X_206_ _038_ _056_ _057_ _009_ VDD VSS AOI21_X1
X_207_ _125_ _130_ _058_ VDD VSS NAND2_X1
X_208_ _126_ _002_ _128_ _059_ VDD VSS AOI21_X1
X_209_ _045_ _059_ _060_ VDD VSS NAND2_X1
X_210_ _038_ _058_ _060_ _010_ VDD VSS AOI21_X1
X_211_ _041_ net10 _122_ _061_ VDD VSS AND3_X1
X_212_ rx_shift_reg\[0\] _123_ _062_ VDD VSS AND2_X1
X_213_ _041_ _002_ _063_ VDD VSS NAND2_X1
X_214_ _042_ _063_ _128_ _064_ VDD VSS OAI21_X4
X_215_ _061_ _062_ _064_ _011_ VDD VSS MUX2_X1
X_216_ _041_ rx_shift_reg\[0\] _122_ _065_ VDD VSS AND3_X1
X_217_ rx_shift_reg\[1\] _123_ _066_ VDD VSS AND2_X1
X_218_ _065_ _066_ _064_ _012_ VDD VSS MUX2_X1
X_219_ _041_ rx_shift_reg\[1\] _122_ _067_ VDD VSS AND3_X1
X_220_ rx_shift_reg\[2\] _123_ _068_ VDD VSS AND2_X1
X_221_ _067_ _068_ _064_ _013_ VDD VSS MUX2_X1
X_222_ _041_ rx_shift_reg\[2\] _122_ _069_ VDD VSS AND3_X1
X_223_ rx_shift_reg\[3\] _123_ _070_ VDD VSS AND2_X1
X_224_ _069_ _070_ _064_ _014_ VDD VSS MUX2_X1
X_225_ _041_ rx_shift_reg\[3\] _122_ _071_ VDD VSS AND3_X1
X_226_ rx_shift_reg\[4\] _123_ _072_ VDD VSS AND2_X1
X_227_ _071_ _072_ _064_ _015_ VDD VSS MUX2_X1
X_228_ _041_ rx_shift_reg\[4\] _122_ _073_ VDD VSS AND3_X1
X_229_ rx_shift_reg\[5\] _123_ _074_ VDD VSS AND2_X1
X_230_ _073_ _074_ _064_ _016_ VDD VSS MUX2_X1
X_231_ _041_ rx_shift_reg\[5\] _122_ _075_ VDD VSS AND3_X1
X_232_ rx_shift_reg\[6\] _123_ _076_ VDD VSS AND2_X1
X_233_ _075_ _076_ _064_ _017_ VDD VSS MUX2_X1
X_234_ net1 _077_ VDD VSS INV_X1
X_235_ net21 _078_ VDD VSS INV_X1
X_236_ tx_bit_counter\[2\] _079_ VDD VSS CLKBUF_X2
X_237_ _126_ tx_bit_counter\[3\] _079_ _165_ _080_ VDD VSS
+ AOI211_X2
X_238_ _129_ _077_ _078_ _080_ _081_ VDD VSS AND4_X1
X_239_ _129_ _077_ _126_ _078_ _082_ VDD VSS OAI211_X2
X_240_ tx_bit_counter\[0\] _083_ VDD VSS BUF_X1
X_241_ _081_ _082_ _083_ _084_ VDD VSS MUX2_X1
X_242_ _124_ _084_ _018_ VDD VSS AND2_X1
X_243_ tx_bit_counter\[1\] _085_ VDD VSS BUF_X2
X_244_ _085_ _082_ _081_ _166_ _086_ VDD VSS AOI22_X1
X_245_ _038_ _086_ _019_ VDD VSS NOR2_X1
X_246_ _079_ _082_ _087_ VDD VSS NAND2_X1
X_247_ _165_ _000_ _088_ VDD VSS XNOR2_X1
X_248_ _080_ _088_ _089_ VDD VSS NAND2_X1
X_249_ _082_ _089_ _090_ VDD VSS OR2_X1
X_250_ _038_ _087_ _090_ _020_ VDD VSS AOI21_X1
X_251_ _123_ _091_ VDD VSS BUF_X2
X_252_ _079_ _083_ _085_ _092_ VDD VSS NAND3_X1
X_253_ _001_ _092_ _093_ VDD VSS XOR2_X1
X_254_ _091_ _081_ _093_ _094_ VDD VSS NAND3_X1
X_255_ tx_bit_counter\[3\] _091_ _082_ _095_ VDD VSS NAND3_X1
X_256_ _094_ _095_ _021_ VDD VSS NAND2_X1
X_257_ _129_ _077_ _126_ _096_ VDD VSS NAND3_X4
X_258_ _091_ _096_ _097_ VDD VSS NAND2_X1
X_259_ _129_ _098_ VDD VSS INV_X1
X_260_ tx_bit_counter\[3\] _079_ _165_ _099_ VDD VSS AOI21_X1
X_261_ _098_ net1 _099_ _100_ VDD VSS OR3_X1
X_262_ _097_ _100_ _078_ _022_ VDD VSS AOI21_X1
X_263_ net2 tx_shift_reg\[0\] _096_ _101_ VDD VSS MUX2_X1
X_264_ _124_ _101_ _023_ VDD VSS AND2_X1
X_265_ net3 tx_shift_reg\[1\] _096_ _102_ VDD VSS MUX2_X1
X_266_ _124_ _102_ _024_ VDD VSS AND2_X1
X_267_ net4 tx_shift_reg\[2\] _096_ _103_ VDD VSS MUX2_X1
X_268_ _124_ _103_ _025_ VDD VSS AND2_X1
X_269_ net5 tx_shift_reg\[3\] _096_ _104_ VDD VSS MUX2_X1
X_270_ _124_ _104_ _026_ VDD VSS AND2_X1
X_271_ net6 tx_shift_reg\[4\] _096_ _105_ VDD VSS MUX2_X1
X_272_ _124_ _105_ _027_ VDD VSS AND2_X1
X_273_ net7 tx_shift_reg\[5\] _096_ _106_ VDD VSS MUX2_X1
X_274_ _124_ _106_ _028_ VDD VSS AND2_X1
X_275_ net8 tx_shift_reg\[6\] _096_ _107_ VDD VSS MUX2_X1
X_276_ _091_ _107_ _029_ VDD VSS AND2_X1
X_277_ net9 tx_shift_reg\[7\] _096_ _108_ VDD VSS MUX2_X1
X_278_ _091_ _108_ _030_ VDD VSS AND2_X1
X_279_ net11 net10 _131_ _109_ VDD VSS MUX2_X1
X_280_ _091_ _109_ _031_ VDD VSS AND2_X1
X_281_ net12 rx_shift_reg\[0\] _131_ _110_ VDD VSS MUX2_X1
X_282_ _091_ _110_ _032_ VDD VSS AND2_X1
X_283_ net13 rx_shift_reg\[1\] _131_ _111_ VDD VSS MUX2_X1
X_284_ _091_ _111_ _033_ VDD VSS AND2_X1
X_285_ net14 rx_shift_reg\[2\] _131_ _112_ VDD VSS MUX2_X1
X_286_ _091_ _112_ _034_ VDD VSS AND2_X1
X_287_ net15 rx_shift_reg\[3\] _131_ _113_ VDD VSS MUX2_X1
X_288_ _091_ _113_ _035_ VDD VSS AND2_X1
X_289_ tx_bit_counter\[3\] _114_ VDD VSS INV_X1
X_290_ tx_shift_reg\[7\] tx_shift_reg\[5\] _085_ _115_ VDD
+ VSS MUX2_X1
X_291_ tx_shift_reg\[6\] tx_shift_reg\[4\] _085_ _116_ VDD
+ VSS MUX2_X1
X_292_ _115_ _116_ _083_ _117_ VDD VSS MUX2_X1
X_293_ tx_shift_reg\[3\] tx_shift_reg\[1\] _085_ _118_ VDD
+ VSS MUX2_X1
X_294_ tx_shift_reg\[2\] tx_shift_reg\[0\] _085_ _119_ VDD
+ VSS MUX2_X1
X_295_ _118_ _119_ _083_ _120_ VDD VSS MUX2_X1
X_296_ _117_ _120_ _079_ _121_ VDD VSS MUX2_X1
X_297_ _114_ _001_ _121_ net20 VDD VSS AND3_X1
X_298_ rx_bit_counter\[0\] rx_bit_counter\[1\] _163_ _164_
+ VDD VSS HA_X1
X_299_ tx_bit_counter\[0\] tx_bit_counter\[1\] _165_ _166_
+ VDD VSS HA_X1
Xparallel_out\[0\]$_SDFFE_PN0P_ _031_ clknet_2_0__leaf_clk
+ net11 _162_ VDD VSS DFF_X1
Xparallel_out\[1\]$_SDFFE_PN0P_ _032_ clknet_2_0__leaf_clk
+ net12 _161_ VDD VSS DFF_X1
Xparallel_out\[2\]$_SDFFE_PN0P_ _033_ clknet_2_0__leaf_clk
+ net13 _160_ VDD VSS DFF_X1
Xparallel_out\[3\]$_SDFFE_PN0P_ _034_ clknet_2_0__leaf_clk
+ net14 _159_ VDD VSS DFF_X1
Xparallel_out\[4\]$_SDFFE_PN0P_ _035_ clknet_2_2__leaf_clk
+ net15 _158_ VDD VSS DFF_X1
Xparallel_out\[5\]$_SDFFE_PN0P_ _003_ clknet_2_2__leaf_clk
+ net16 _157_ VDD VSS DFF_X1
Xparallel_out\[6\]$_SDFFE_PN0P_ _004_ clknet_2_2__leaf_clk
+ net17 _156_ VDD VSS DFF_X1
Xparallel_out\[7\]$_SDFFE_PN0P_ _005_ clknet_2_2__leaf_clk
+ net18 _155_ VDD VSS DFF_X1
Xrx_bit_counter\[0\]$_SDFFE_PN0P_ _006_ clknet_2_1__leaf_clk
+ rx_bit_counter\[0\] _154_ VDD VSS DFF_X1
Xrx_bit_counter\[1\]$_SDFFE_PN0P_ _007_ clknet_2_1__leaf_clk
+ rx_bit_counter\[1\] _153_ VDD VSS DFF_X1
Xrx_bit_counter\[2\]$_SDFFE_PN0P_ _008_ clknet_2_1__leaf_clk
+ rx_bit_counter\[2\] _152_ VDD VSS DFF_X2
Xrx_bit_counter\[3\]$_SDFFE_PN0P_ _009_ clknet_2_1__leaf_clk
+ rx_bit_counter\[3\] _151_ VDD VSS DFF_X2
Xrx_done$_SDFFE_PN0P_ _010_ clknet_2_1__leaf_clk net19 _002_
+ VDD VSS DFF_X1
Xrx_shift_reg\[0\]$_SDFFE_PN0P_ _011_ clknet_2_0__leaf_clk
+ rx_shift_reg\[0\] _150_ VDD VSS DFF_X1
Xrx_shift_reg\[1\]$_SDFFE_PN0P_ _012_ clknet_2_0__leaf_clk
+ rx_shift_reg\[1\] _149_ VDD VSS DFF_X1
Xrx_shift_reg\[2\]$_SDFFE_PN0P_ _013_ clknet_2_0__leaf_clk
+ rx_shift_reg\[2\] _148_ VDD VSS DFF_X1
Xrx_shift_reg\[3\]$_SDFFE_PN0P_ _014_ clknet_2_2__leaf_clk
+ rx_shift_reg\[3\] _147_ VDD VSS DFF_X1
Xrx_shift_reg\[4\]$_SDFFE_PN0P_ _015_ clknet_2_2__leaf_clk
+ rx_shift_reg\[4\] _146_ VDD VSS DFF_X1
Xrx_shift_reg\[5\]$_SDFFE_PN0P_ _016_ clknet_2_2__leaf_clk
+ rx_shift_reg\[5\] _145_ VDD VSS DFF_X1
Xrx_shift_reg\[6\]$_SDFFE_PN0P_ _017_ clknet_2_2__leaf_clk
+ rx_shift_reg\[6\] _144_ VDD VSS DFF_X1
Xtx_bit_counter\[0\]$_SDFFE_PN0P_ _018_ clknet_2_3__leaf_clk
+ tx_bit_counter\[0\] _143_ VDD VSS DFF_X1
Xtx_bit_counter\[1\]$_SDFFE_PN0P_ _019_ clknet_2_3__leaf_clk
+ tx_bit_counter\[1\] _142_ VDD VSS DFF_X1
Xtx_bit_counter\[2\]$_SDFFE_PN0P_ _020_ clknet_2_1__leaf_clk
+ tx_bit_counter\[2\] _000_ VDD VSS DFF_X1
Xtx_bit_counter\[3\]$_SDFFE_PN0P_ _021_ clknet_2_3__leaf_clk
+ tx_bit_counter\[3\] _001_ VDD VSS DFF_X2
Xtx_done_reg$_SDFFE_PN0P_ _022_ clknet_2_1__leaf_clk net21
+ _141_ VDD VSS DFF_X1
Xtx_shift_reg\[0\]$_SDFFE_PN0P_ _023_ clknet_2_3__leaf_clk
+ tx_shift_reg\[0\] _140_ VDD VSS DFF_X1
Xtx_shift_reg\[1\]$_SDFFE_PN0P_ _024_ clknet_2_3__leaf_clk
+ tx_shift_reg\[1\] _139_ VDD VSS DFF_X1
Xtx_shift_reg\[2\]$_SDFFE_PN0P_ _025_ clknet_2_3__leaf_clk
+ tx_shift_reg\[2\] _138_ VDD VSS DFF_X1
Xtx_shift_reg\[3\]$_SDFFE_PN0P_ _026_ clknet_2_3__leaf_clk
+ tx_shift_reg\[3\] _137_ VDD VSS DFF_X1
Xtx_shift_reg\[4\]$_SDFFE_PN0P_ _027_ clknet_2_3__leaf_clk
+ tx_shift_reg\[4\] _136_ VDD VSS DFF_X1
Xtx_shift_reg\[5\]$_SDFFE_PN0P_ _028_ clknet_2_2__leaf_clk
+ tx_shift_reg\[5\] _135_ VDD VSS DFF_X1
Xtx_shift_reg\[6\]$_SDFFE_PN0P_ _029_ clknet_2_3__leaf_clk
+ tx_shift_reg\[6\] _134_ VDD VSS DFF_X1
Xtx_shift_reg\[7\]$_SDFFE_PN0P_ _030_ clknet_2_3__leaf_clk
+ tx_shift_reg\[7\] _133_ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_49 VDD VSS TAPCELL_X1
Xinput1 mode net1 VDD VSS BUF_X1
Xinput2 parallel_in[0] net2 VDD VSS BUF_X1
Xinput3 parallel_in[1] net3 VDD VSS BUF_X1
Xinput4 parallel_in[2] net4 VDD VSS BUF_X1
Xinput5 parallel_in[3] net5 VDD VSS BUF_X1
Xinput6 parallel_in[4] net6 VDD VSS BUF_X1
Xinput7 parallel_in[5] net7 VDD VSS BUF_X1
Xinput8 parallel_in[6] net8 VDD VSS BUF_X1
Xinput9 parallel_in[7] net9 VDD VSS BUF_X1
Xinput10 serial_in net10 VDD VSS BUF_X1
Xoutput11 net11 parallel_out[0] VDD VSS BUF_X1
Xoutput12 net12 parallel_out[1] VDD VSS BUF_X1
Xoutput13 net13 parallel_out[2] VDD VSS BUF_X1
Xoutput14 net14 parallel_out[3] VDD VSS BUF_X1
Xoutput15 net15 parallel_out[4] VDD VSS BUF_X1
Xoutput16 net16 parallel_out[5] VDD VSS BUF_X1
Xoutput17 net17 parallel_out[6] VDD VSS BUF_X1
Xoutput18 net18 parallel_out[7] VDD VSS BUF_X1
Xoutput19 net19 rx_done VDD VSS BUF_X1
Xoutput20 net20 serial_out VDD VSS BUF_X1
Xoutput21 net21 tx_done VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_2_0__f_clk clknet_0_clk clknet_2_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_2_1__f_clk clknet_0_clk clknet_2_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_2_2__f_clk clknet_0_clk clknet_2_2__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_2_3__f_clk clknet_0_clk clknet_2_3__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_2_0__leaf_clk _unconnected_0 VDD VSS INV_X2
Xclkload1 clknet_2_1__leaf_clk _unconnected_1 VDD VSS INV_X2
Xclkload2 clknet_2_2__leaf_clk _unconnected_2 VDD VSS CLKBUF_X1
.ENDS parameterized_serdes
