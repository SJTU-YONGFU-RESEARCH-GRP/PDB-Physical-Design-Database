* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT sequence_detector_fsm clk config_pattern[0] config_pattern[1]
+ config_pattern[2] config_pattern[3] enable load_pattern pattern_detected
+ rst_n serial_in
X_064_ _058_ _061_ VDD VSS INV_X1
X_065_ load_pattern _012_ VDD VSS BUF_X2
X_066_ net5 _013_ VDD VSS INV_X1
X_067_ _012_ _013_ _014_ VDD VSS NOR2_X2
X_068_ enable _015_ VDD VSS BUF_X4
X_069_ _014_ bit_count\[0\] _015_ _016_ VDD VSS OAI21_X1
X_070_ _015_ _017_ VDD VSS INV_X4
X_071_ _017_ bit_count\[2\] _018_ VDD VSS NOR2_X1
X_072_ bit_count\[2\] _018_ bit_count\[0\] _019_ VDD VSS MUX2_X1
X_073_ state _020_ VDD VSS CLKBUF_X2
X_074_ _016_ _019_ _020_ _000_ VDD VSS AOI21_X1
X_075_ _014_ _021_ VDD VSS INV_X1
X_076_ _020_ _059_ _018_ _022_ VDD VSS NAND3_X1
X_077_ _020_ bit_count\[2\] _023_ VDD VSS AND2_X1
X_078_ bit_count\[1\] _023_ _017_ _024_ VDD VSS OAI21_X1
X_079_ _021_ _022_ _024_ _001_ VDD VSS AOI21_X1
X_080_ _014_ _017_ _020_ _025_ VDD VSS OAI21_X1
X_081_ bit_count\[2\] _063_ _015_ _026_ VDD VSS AOI21_X1
X_082_ _025_ _026_ _002_ VDD VSS NOR2_X1
X_083_ pattern_reg\[3\] shift_reg\[2\] _027_ VDD VSS XNOR2_X1
X_084_ pattern_reg\[0\] net6 _028_ VDD VSS XNOR2_X1
X_085_ _027_ _028_ _029_ VDD VSS NAND2_X1
X_086_ _017_ _062_ _030_ VDD VSS NOR2_X1
X_087_ shift_reg\[0\] _031_ VDD VSS INV_X1
X_088_ pattern_reg\[2\] _032_ VDD VSS INV_X1
X_089_ pattern_reg\[1\] _031_ _032_ shift_reg\[1\] _033_ VDD
+ VSS AOI22_X1
X_090_ _020_ _030_ _033_ _034_ VDD VSS NAND3_X1
X_091_ pattern_reg\[1\] _031_ _032_ shift_reg\[1\] _035_ VDD
+ VSS OAI22_X1
X_092_ _021_ _029_ _034_ _035_ _003_ VDD VSS NOR4_X1
X_093_ _015_ net6 _036_ VDD VSS NAND2_X1
X_094_ _017_ shift_reg\[0\] _037_ VDD VSS NAND2_X1
X_095_ _021_ _036_ _037_ _008_ VDD VSS AOI21_X1
X_096_ _015_ shift_reg\[0\] _038_ VDD VSS NAND2_X1
X_097_ _017_ shift_reg\[1\] _039_ VDD VSS NAND2_X1
X_098_ _021_ _038_ _039_ _009_ VDD VSS AOI21_X1
X_099_ _015_ shift_reg\[1\] _040_ VDD VSS NAND2_X1
X_100_ _017_ shift_reg\[2\] _041_ VDD VSS NAND2_X1
X_101_ _021_ _040_ _041_ _010_ VDD VSS AOI21_X1
X_102_ _014_ _015_ _020_ _042_ VDD VSS OAI21_X1
X_103_ _042_ _011_ VDD VSS INV_X1
X_104_ pattern_reg\[0\] net1 _012_ _043_ VDD VSS MUX2_X1
X_105_ _013_ _043_ _004_ VDD VSS OR2_X1
X_106_ pattern_reg\[1\] net2 _012_ _044_ VDD VSS MUX2_X1
X_107_ _013_ _044_ _005_ VDD VSS OR2_X1
X_108_ pattern_reg\[2\] net3 _012_ _045_ VDD VSS MUX2_X1
X_109_ net5 _045_ _006_ VDD VSS AND2_X1
X_110_ pattern_reg\[3\] net4 _012_ _046_ VDD VSS MUX2_X1
X_111_ _013_ _046_ _007_ VDD VSS OR2_X1
X_112_ bit_count\[0\] bit_count\[1\] _058_ _059_ VDD VSS HA_X1
X_113_ _060_ _061_ _062_ _063_ VDD VSS HA_X1
Xbit_count\[0\]$_SDFFE_PP0P_ _000_ clknet_1_1__leaf_clk bit_count\[0\]
+ _057_ VDD VSS DFF_X1
Xbit_count\[1\]$_SDFFE_PP0P_ _001_ clknet_1_1__leaf_clk bit_count\[1\]
+ _056_ VDD VSS DFF_X1
Xbit_count\[2\]$_SDFFE_PP0P_ _002_ clknet_1_1__leaf_clk bit_count\[2\]
+ _060_ VDD VSS DFF_X1
Xpattern_detected$_SDFF_PP0_ _003_ clknet_1_1__leaf_clk net7
+ _055_ VDD VSS DFF_X1
Xpattern_reg\[0\]$_SDFFE_PN1P_ _004_ clknet_1_0__leaf_clk
+ pattern_reg\[0\] _054_ VDD VSS DFF_X1
Xpattern_reg\[1\]$_SDFFE_PN1P_ _005_ clknet_1_0__leaf_clk
+ pattern_reg\[1\] _053_ VDD VSS DFF_X1
Xpattern_reg\[2\]$_SDFFE_PN0P_ _006_ clknet_1_0__leaf_clk
+ pattern_reg\[2\] _052_ VDD VSS DFF_X1
Xpattern_reg\[3\]$_SDFFE_PN1P_ _007_ clknet_1_0__leaf_clk
+ pattern_reg\[3\] _051_ VDD VSS DFF_X1
Xshift_reg\[0\]$_SDFFE_PP0P_ _008_ clknet_1_1__leaf_clk shift_reg\[0\]
+ _050_ VDD VSS DFF_X1
Xshift_reg\[1\]$_SDFFE_PP0P_ _009_ clknet_1_0__leaf_clk shift_reg\[1\]
+ _049_ VDD VSS DFF_X1
Xshift_reg\[2\]$_SDFFE_PP0P_ _010_ clknet_1_0__leaf_clk shift_reg\[2\]
+ _048_ VDD VSS DFF_X1
Xstate$_SDFFE_PP0P_ _011_ clknet_1_0__leaf_clk state _047_
+ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Right_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Right_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Right_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Right_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Right_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Right_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Right_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Right_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Right_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Right_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Right_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_89 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_90 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_91 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_92 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_93 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_94 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_95 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_96 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_97 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_98 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_99 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_100 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Left_101 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Left_102 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Left_103 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Left_104 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Left_105 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Left_106 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Left_107 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Left_108 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Left_109 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Left_110 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Left_111 VDD VSS TAPCELL_X1
Xinput1 config_pattern[0] net1 VDD VSS BUF_X1
Xinput2 config_pattern[1] net2 VDD VSS BUF_X1
Xinput3 config_pattern[2] net3 VDD VSS BUF_X1
Xinput4 config_pattern[3] net4 VDD VSS BUF_X1
Xinput5 rst_n net5 VDD VSS BUF_X1
Xinput6 serial_in net6 VDD VSS BUF_X1
Xoutput7 net7 pattern_detected VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_1_1__leaf_clk _unconnected_0 VDD VSS INV_X1
.ENDS sequence_detector_fsm
