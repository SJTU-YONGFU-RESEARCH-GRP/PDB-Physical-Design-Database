* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT ibex_core alert_major_o alert_minor_o boot_addr_i[0]
+ boot_addr_i[10] boot_addr_i[11] boot_addr_i[12] boot_addr_i[13]
+ boot_addr_i[14] boot_addr_i[15] boot_addr_i[16] boot_addr_i[17]
+ boot_addr_i[18] boot_addr_i[19] boot_addr_i[1] boot_addr_i[20]
+ boot_addr_i[21] boot_addr_i[22] boot_addr_i[23] boot_addr_i[24]
+ boot_addr_i[25] boot_addr_i[26] boot_addr_i[27] boot_addr_i[28]
+ boot_addr_i[29] boot_addr_i[2] boot_addr_i[30] boot_addr_i[31]
+ boot_addr_i[3] boot_addr_i[4] boot_addr_i[5] boot_addr_i[6]
+ boot_addr_i[7] boot_addr_i[8] boot_addr_i[9] clk_i core_sleep_o
+ data_addr_o[0] data_addr_o[10] data_addr_o[11] data_addr_o[12]
+ data_addr_o[13] data_addr_o[14] data_addr_o[15] data_addr_o[16]
+ data_addr_o[17] data_addr_o[18] data_addr_o[19] data_addr_o[1]
+ data_addr_o[20] data_addr_o[21] data_addr_o[22] data_addr_o[23]
+ data_addr_o[24] data_addr_o[25] data_addr_o[26] data_addr_o[27]
+ data_addr_o[28] data_addr_o[29] data_addr_o[2] data_addr_o[30]
+ data_addr_o[31] data_addr_o[3] data_addr_o[4] data_addr_o[5]
+ data_addr_o[6] data_addr_o[7] data_addr_o[8] data_addr_o[9]
+ data_be_o[0] data_be_o[1] data_be_o[2] data_be_o[3] data_err_i
+ data_gnt_i data_rdata_i[0] data_rdata_i[10] data_rdata_i[11]
+ data_rdata_i[12] data_rdata_i[13] data_rdata_i[14] data_rdata_i[15]
+ data_rdata_i[16] data_rdata_i[17] data_rdata_i[18] data_rdata_i[19]
+ data_rdata_i[1] data_rdata_i[20] data_rdata_i[21] data_rdata_i[22]
+ data_rdata_i[23] data_rdata_i[24] data_rdata_i[25] data_rdata_i[26]
+ data_rdata_i[27] data_rdata_i[28] data_rdata_i[29] data_rdata_i[2]
+ data_rdata_i[30] data_rdata_i[31] data_rdata_i[3] data_rdata_i[4]
+ data_rdata_i[5] data_rdata_i[6] data_rdata_i[7] data_rdata_i[8]
+ data_rdata_i[9] data_req_o data_rvalid_i data_wdata_o[0] data_wdata_o[10]
+ data_wdata_o[11] data_wdata_o[12] data_wdata_o[13] data_wdata_o[14]
+ data_wdata_o[15] data_wdata_o[16] data_wdata_o[17] data_wdata_o[18]
+ data_wdata_o[19] data_wdata_o[1] data_wdata_o[20] data_wdata_o[21]
+ data_wdata_o[22] data_wdata_o[23] data_wdata_o[24] data_wdata_o[25]
+ data_wdata_o[26] data_wdata_o[27] data_wdata_o[28] data_wdata_o[29]
+ data_wdata_o[2] data_wdata_o[30] data_wdata_o[31] data_wdata_o[3]
+ data_wdata_o[4] data_wdata_o[5] data_wdata_o[6] data_wdata_o[7]
+ data_wdata_o[8] data_wdata_o[9] data_we_o debug_req_i fetch_enable_i
+ hart_id_i[0] hart_id_i[10] hart_id_i[11] hart_id_i[12] hart_id_i[13]
+ hart_id_i[14] hart_id_i[15] hart_id_i[16] hart_id_i[17] hart_id_i[18]
+ hart_id_i[19] hart_id_i[1] hart_id_i[20] hart_id_i[21] hart_id_i[22]
+ hart_id_i[23] hart_id_i[24] hart_id_i[25] hart_id_i[26] hart_id_i[27]
+ hart_id_i[28] hart_id_i[29] hart_id_i[2] hart_id_i[30] hart_id_i[31]
+ hart_id_i[3] hart_id_i[4] hart_id_i[5] hart_id_i[6] hart_id_i[7]
+ hart_id_i[8] hart_id_i[9] instr_addr_o[0] instr_addr_o[10]
+ instr_addr_o[11] instr_addr_o[12] instr_addr_o[13] instr_addr_o[14]
+ instr_addr_o[15] instr_addr_o[16] instr_addr_o[17] instr_addr_o[18]
+ instr_addr_o[19] instr_addr_o[1] instr_addr_o[20] instr_addr_o[21]
+ instr_addr_o[22] instr_addr_o[23] instr_addr_o[24] instr_addr_o[25]
+ instr_addr_o[26] instr_addr_o[27] instr_addr_o[28] instr_addr_o[29]
+ instr_addr_o[2] instr_addr_o[30] instr_addr_o[31] instr_addr_o[3]
+ instr_addr_o[4] instr_addr_o[5] instr_addr_o[6] instr_addr_o[7]
+ instr_addr_o[8] instr_addr_o[9] instr_err_i instr_gnt_i instr_rdata_i[0]
+ instr_rdata_i[10] instr_rdata_i[11] instr_rdata_i[12] instr_rdata_i[13]
+ instr_rdata_i[14] instr_rdata_i[15] instr_rdata_i[16] instr_rdata_i[17]
+ instr_rdata_i[18] instr_rdata_i[19] instr_rdata_i[1] instr_rdata_i[20]
+ instr_rdata_i[21] instr_rdata_i[22] instr_rdata_i[23] instr_rdata_i[24]
+ instr_rdata_i[25] instr_rdata_i[26] instr_rdata_i[27] instr_rdata_i[28]
+ instr_rdata_i[29] instr_rdata_i[2] instr_rdata_i[30] instr_rdata_i[31]
+ instr_rdata_i[3] instr_rdata_i[4] instr_rdata_i[5] instr_rdata_i[6]
+ instr_rdata_i[7] instr_rdata_i[8] instr_rdata_i[9] instr_req_o
+ instr_rvalid_i irq_external_i irq_fast_i[0] irq_fast_i[10]
+ irq_fast_i[11] irq_fast_i[12] irq_fast_i[13] irq_fast_i[14]
+ irq_fast_i[1] irq_fast_i[2] irq_fast_i[3] irq_fast_i[4] irq_fast_i[5]
+ irq_fast_i[6] irq_fast_i[7] irq_fast_i[8] irq_fast_i[9] irq_nm_i
+ irq_software_i irq_timer_i rst_ni test_en_i
X_16113_ id_stage_i.controller_i.instr_i\[5\] _10287_ VDD
+ VSS BUF_X4
X_16114_ _10287_ _10288_ VDD VSS INV_X2
X_16115_ _10288_ _10289_ VDD VSS BUF_X8
X_16116_ id_stage_i.controller_i.instr_i\[1\] _10290_ VDD
+ VSS BUF_X2
X_16117_ id_stage_i.controller_i.instr_i\[0\] _10291_ VDD
+ VSS BUF_X2
X_16118_ _10290_ _10291_ _10292_ VDD VSS NAND2_X4
X_16119_ id_stage_i.controller_i.instr_i\[3\] _10293_ VDD
+ VSS BUF_X8
Xrebuffer19 _11512_ net290 VDD VSS BUF_X1
X_16121_ id_stage_i.controller_i.instr_i\[2\] _10293_ _10295_
+ VDD VSS OR2_X4
X_16122_ _10295_ _10296_ VDD VSS BUF_X16
X_16123_ _10289_ _10292_ _10296_ _10297_ VDD VSS NOR3_X2
X_16124_ id_stage_i.controller_i.instr_i\[6\] _10298_ VDD
+ VSS BUF_X2
X_16125_ _10298_ _10299_ VDD VSS BUF_X4
X_16126_ id_stage_i.controller_i.instr_i\[4\] _10300_ VDD
+ VSS BUF_X8
X_16127_ _00172_ _10301_ VDD VSS BUF_X2
X_16128_ _10300_ _10301_ _10302_ VDD VSS NOR2_X4
X_16129_ _10299_ _10302_ _10303_ VDD VSS NOR2_X1
X_16130_ id_stage_i.controller_i.instr_valid_i _10304_ VDD
+ VSS BUF_X4
X_16131_ _10304_ _10305_ VDD VSS INV_X4
X_16132_ id_stage_i.id_fsm_q _10306_ VDD VSS BUF_X4
X_16133_ net308 _10301_ _10307_ VDD VSS OR2_X4
X_16134_ _10305_ _10306_ _10307_ _10308_ VDD VSS NOR3_X2
X_16135_ id_stage_i.controller_i.instr_i\[14\] _10309_ VDD
+ VSS BUF_X8
X_16136_ _10309_ _10310_ VDD VSS BUF_X16
X_16137_ _10290_ _10291_ _10311_ VDD VSS AND2_X1
X_16138_ _10311_ _10312_ VDD VSS BUF_X4
X_16139_ _10293_ id_stage_i.controller_i.instr_i\[2\] _10313_
+ VDD VSS NOR2_X4
X_16140_ _10300_ _10299_ _10314_ VDD VSS NOR2_X4
X_16141_ _10312_ _10313_ _10314_ _10315_ VDD VSS NAND3_X4
X_16142_ _10297_ _10303_ _10308_ _10310_ _10315_ _10316_ VDD
+ VSS OAI221_X2
X_16143_ _10316_ _10317_ VDD VSS BUF_X4
X_16144_ _16085_ _10318_ VDD VSS INV_X1
X_16145_ load_store_unit_i.ls_fsm_cs\[1\] _10319_ VDD VSS
+ BUF_X4
X_16146_ _00171_ _10320_ VDD VSS BUF_X2
X_16147_ _10319_ _10320_ _10321_ VDD VSS AND2_X1
X_16148_ load_store_unit_i.ls_fsm_cs\[2\] _10322_ VDD VSS
+ BUF_X1
X_16149_ _10322_ _10320_ _10319_ _10323_ VDD VSS MUX2_X1
X_16150_ load_store_unit_i.ls_fsm_cs\[0\] _10324_ VDD VSS
+ CLKBUF_X3
X_16151_ _10324_ _10325_ VDD VSS INV_X2
X_16152_ _10318_ _10321_ net324 _10325_ _10326_ VDD VSS AOI22_X4
X_16153_ _10293_ _10327_ VDD VSS INV_X2
X_16154_ _10298_ _10328_ VDD VSS INV_X2
X_16155_ _10290_ _10291_ id_stage_i.controller_i.instr_i\[2\]
+ _10329_ VDD VSS AND3_X1
X_16156_ _10329_ _10330_ VDD VSS BUF_X4
X_16157_ _10327_ net315 _10328_ _10330_ _10331_ VDD VSS NAND4_X4
X_16158_ _10312_ _10287_ _10313_ _10302_ _10332_ VDD VSS NAND4_X4
X_16159_ _10305_ _10306_ _10333_ VDD VSS NOR2_X4
X_16160_ _10326_ _10331_ net302 _10333_ _10334_ VDD VSS OAI211_X4
X_16161_ gen_regfile_ff.register_file_i.raddr_b_i\[1\] _10335_
+ VDD VSS BUF_X4
X_16162_ net334 _10336_ VDD VSS INV_X2
X_16163_ _10336_ _10337_ VDD VSS BUF_X4
X_16164_ id_stage_i.controller_i.instr_is_compressed_i _10338_
+ VDD VSS BUF_X4
X_16165_ _10290_ _10291_ id_stage_i.controller_i.instr_i\[2\]
+ _10339_ VDD VSS NAND3_X2
X_16166_ _10339_ _10340_ VDD VSS BUF_X4
X_16167_ _10293_ _10341_ VDD VSS CLKBUF_X3
X_16168_ _10341_ _10289_ _10314_ _10342_ VDD VSS AND3_X2
X_16169_ id_stage_i.controller_i.instr_i\[13\] _10343_ VDD
+ VSS BUF_X2
X_16170_ _10343_ _10344_ VDD VSS BUF_X4
X_16171_ id_stage_i.controller_i.instr_i\[12\] _10345_ VDD
+ VSS BUF_X2
X_16172_ _10345_ _10346_ VDD VSS INV_X4
X_16173_ _00173_ _10347_ VDD VSS BUF_X4
X_16174_ _10347_ _10348_ VDD VSS INV_X4
X_16175_ _10344_ _10346_ _10348_ _10349_ VDD VSS NOR3_X2
X_16176_ _10306_ _10350_ VDD VSS INV_X4
X_16177_ _10327_ _10304_ _10350_ _10351_ VDD VSS NAND3_X1
X_16178_ _10289_ _10307_ _10352_ VDD VSS NOR2_X2
X_16179_ _10342_ _10349_ _10351_ _10352_ _10353_ VDD VSS AOI22_X2
X_16180_ _10340_ _10353_ _10354_ VDD VSS NOR2_X1
X_16181_ _10338_ _10354_ _10355_ VDD VSS NAND2_X1
X_16182_ _10325_ _10323_ _10356_ VDD VSS AND2_X1
X_16183_ _10319_ _10320_ _10357_ VDD VSS NAND2_X1
X_16184_ _16085_ _10357_ _10358_ VDD VSS NOR2_X1
X_16185_ _10356_ _10358_ _10359_ VDD VSS OR2_X1
X_16186_ _10359_ _10360_ VDD VSS BUF_X4
X_16187_ _10360_ _10361_ VDD VSS BUF_X4
X_16188_ _10298_ _10301_ id_stage_i.controller_i.instr_i\[5\]
+ _10362_ VDD VSS MUX2_X1
X_16189_ net315 _10340_ _10362_ _10363_ VDD VSS NOR3_X1
X_16190_ id_stage_i.controller_i.instr_i\[2\] _10364_ VDD
+ VSS INV_X1
X_16191_ _10327_ _10364_ _10365_ VDD VSS NOR2_X1
X_16192_ _10341_ _10289_ _10301_ _10366_ VDD VSS NOR3_X2
X_16193_ _10312_ _10363_ _10365_ _10366_ _10367_ VDD VSS OAI211_X2
X_16194_ _10304_ _10350_ _10368_ VDD VSS NAND2_X4
X_16195_ _10368_ _10352_ _10342_ _10349_ _10369_ VDD VSS AOI22_X1
X_16196_ _10360_ _10367_ _10369_ _10370_ VDD VSS OR3_X1
X_16197_ _10370_ _10371_ VDD VSS BUF_X4
X_16198_ _10300_ _10372_ VDD VSS INV_X2
X_16199_ _10339_ _10372_ _10298_ _10293_ _10373_ VDD VSS NOR4_X4
X_16200_ _10289_ _10310_ _10315_ _10374_ VDD VSS NOR3_X4
X_16201_ _10373_ _10374_ _10375_ VDD VSS NOR2_X4
X_16202_ _10361_ _10371_ _10375_ _10376_ VDD VSS AOI21_X1
X_16203_ _10337_ _10355_ _10376_ _10377_ VDD VSS MUX2_X1
X_16204_ _10293_ _10288_ _10314_ _10378_ VDD VSS NAND3_X2
X_16205_ _10344_ _10379_ VDD VSS INV_X1
X_16206_ _10379_ _10380_ VDD VSS BUF_X4
X_16207_ _10345_ _10381_ VDD VSS BUF_X4
X_16208_ _10380_ _10381_ _10347_ _10382_ VDD VSS NAND3_X2
X_16209_ _10341_ _10305_ _10306_ _10383_ VDD VSS NOR3_X2
X_16210_ _10287_ _10302_ _10384_ VDD VSS NAND2_X2
X_16211_ _10378_ _10382_ _10383_ _10384_ _10385_ VDD VSS OAI22_X4
X_16212_ _10360_ _10330_ _10385_ _10386_ VDD VSS AOI21_X4
X_16213_ _10334_ _10371_ _10375_ _10387_ VDD VSS AOI21_X4
X_16214_ _10331_ _10332_ _10333_ _10388_ VDD VSS OAI21_X2
X_16215_ _10360_ _10388_ _10389_ VDD VSS NOR2_X4
X_16216_ net315 _10328_ _10390_ VDD VSS NAND2_X1
X_16217_ _10341_ _10390_ _10340_ _10360_ _10369_ _10367_ _10391_
+ VDD VSS OAI33_X1
X_16218_ _10389_ _10374_ net252 _10392_ VDD VSS NOR3_X4
X_16219_ _10386_ _10387_ _10392_ _10393_ VDD VSS OAI21_X2
X_16220_ gen_regfile_ff.register_file_i.waddr_a_i\[1\] _10394_
+ VDD VSS BUF_X4
X_16221_ _10394_ _10395_ VDD VSS INV_X1
X_16222_ _10317_ _10334_ _10377_ _10393_ _10395_ _10396_ VDD
+ VSS OAI221_X2
X_16223_ _10361_ _10397_ VDD VSS BUF_X4
X_16224_ _10397_ _10398_ VDD VSS BUF_X4
X_16225_ _10297_ _10303_ _10308_ _10399_ VDD VSS OAI21_X2
X_16226_ _10292_ _10296_ _10400_ VDD VSS NOR2_X1
X_16227_ _10400_ _10314_ _10401_ VDD VSS AND2_X2
X_16228_ _10309_ _10402_ VDD VSS INV_X4
X_16229_ _10399_ _10401_ _10402_ _10403_ VDD VSS AOI21_X4
X_16230_ _10335_ _10404_ VDD VSS BUF_X4
X_16231_ _10404_ _10405_ VDD VSS BUF_X8
X_16232_ _10405_ _10406_ VDD VSS BUF_X8
X_16233_ _00163_ _00165_ _10406_ _10407_ VDD VSS MUX2_X1
X_16234_ _10335_ _10408_ VDD VSS BUF_X8
X_16235_ _10408_ _10409_ VDD VSS BUF_X8
X_16236_ _10409_ _10410_ VDD VSS BUF_X4
X_16237_ _00164_ _00166_ _10410_ _10411_ VDD VSS MUX2_X1
X_16238_ gen_regfile_ff.register_file_i.raddr_b_i\[0\] _10412_
+ VDD VSS BUF_X8
X_16239_ _10412_ _10413_ VDD VSS BUF_X16
X_16240_ _10413_ _10414_ VDD VSS BUF_X4
X_16241_ _10407_ _10411_ _10414_ _10415_ VDD VSS MUX2_X1
X_16242_ _00155_ _00157_ _10410_ _10416_ VDD VSS MUX2_X1
X_16243_ _00156_ _00158_ _10410_ _10417_ VDD VSS MUX2_X1
X_16244_ _10416_ _10417_ _10414_ _10418_ VDD VSS MUX2_X1
X_16245_ gen_regfile_ff.register_file_i.raddr_b_i\[3\] _10419_
+ VDD VSS BUF_X4
X_16246_ _10419_ _10420_ VDD VSS INV_X2
X_16247_ _10420_ _10421_ VDD VSS BUF_X8
X_16248_ _10415_ _10418_ _10421_ _10422_ VDD VSS MUX2_X1
X_16249_ _00167_ _00169_ _10410_ _10423_ VDD VSS MUX2_X1
X_16250_ _00168_ _00170_ _10410_ _10424_ VDD VSS MUX2_X1
X_16251_ _10423_ _10424_ _10414_ _10425_ VDD VSS MUX2_X1
X_16252_ _00159_ _00161_ _10410_ _10426_ VDD VSS MUX2_X1
X_16253_ _00160_ _00162_ _10410_ _10427_ VDD VSS MUX2_X1
X_16254_ _10426_ _10427_ _10414_ _10428_ VDD VSS MUX2_X1
X_16255_ _10425_ _10428_ _10421_ _10429_ VDD VSS MUX2_X1
X_16256_ gen_regfile_ff.register_file_i.raddr_b_i\[2\] _10430_
+ VDD VSS BUF_X4
X_16257_ _10430_ _10431_ VDD VSS BUF_X4
X_16258_ _10431_ _10432_ VDD VSS BUF_X8
X_16259_ _10422_ _10429_ _10432_ _10433_ VDD VSS MUX2_X1
X_16260_ _10430_ _10434_ VDD VSS BUF_X4
X_16261_ _10434_ _10435_ VDD VSS INV_X4
X_16262_ _10435_ _10436_ VDD VSS BUF_X4
X_16263_ _10404_ _10437_ VDD VSS BUF_X4
X_16264_ _10437_ _10438_ VDD VSS BUF_X8
X_16265_ _10438_ _10439_ VDD VSS BUF_X4
X_16266_ _00151_ _00153_ _10439_ _10440_ VDD VSS MUX2_X1
X_16267_ _00152_ _00154_ _10439_ _10441_ VDD VSS MUX2_X1
X_16268_ _10412_ _10442_ VDD VSS BUF_X4
X_16269_ _10442_ _10443_ VDD VSS BUF_X4
X_16270_ _10443_ _10444_ VDD VSS BUF_X4
X_16271_ _10440_ _10441_ _10444_ _10445_ VDD VSS MUX2_X1
X_16272_ _00143_ _00145_ _10439_ _10446_ VDD VSS MUX2_X1
X_16273_ _00144_ _00146_ _10439_ _10447_ VDD VSS MUX2_X1
X_16274_ _10446_ _10447_ _10444_ _10448_ VDD VSS MUX2_X1
X_16275_ _10445_ _10448_ _10421_ _10449_ VDD VSS MUX2_X1
X_16276_ _10436_ _10449_ _10450_ VDD VSS NOR2_X1
X_16277_ _10419_ _10451_ VDD VSS BUF_X8
X_16278_ _10408_ _10452_ VDD VSS BUF_X4
X_16279_ _10452_ _10453_ VDD VSS BUF_X4
X_16280_ _10453_ _10454_ VDD VSS BUF_X4
X_16281_ gen_regfile_ff.register_file_i.rf_reg\[33\] _10454_
+ _10455_ VDD VSS NOR2_X1
X_16282_ net334 _10456_ VDD VSS BUF_X32
X_16283_ _10456_ _10457_ VDD VSS BUF_X32
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
X_16285_ _10457_ _10459_ VDD VSS BUF_X32
X_16286_ _10455_ net364 _00142_ _10460_ VDD VSS AOI21_X1
X_16287_ _10444_ _00141_ _10461_ VDD VSS NOR2_X1
X_16288_ _10451_ _10460_ _10444_ _10461_ net364 _10462_ VDD
+ VSS AOI221_X2
X_16289_ _00147_ _00149_ net364 _10463_ VDD VSS MUX2_X1
X_16290_ _00148_ _00150_ net364 _10464_ VDD VSS MUX2_X1
X_16291_ _10413_ _10465_ VDD VSS BUF_X16
X_16292_ _10465_ _10466_ VDD VSS BUF_X16
X_16293_ _10463_ _10464_ _10466_ _10467_ VDD VSS MUX2_X1
X_16294_ _10451_ _10468_ VDD VSS BUF_X8
X_16295_ _10462_ _10467_ _10468_ _10469_ VDD VSS AOI21_X1
X_16296_ _10450_ _10469_ _10436_ _10470_ VDD VSS AOI21_X2
X_16297_ gen_regfile_ff.register_file_i.raddr_b_i\[4\] _10471_
+ VDD VSS BUF_X4
X_16298_ _10471_ _10472_ VDD VSS INV_X8
X_16299_ _10472_ _10473_ VDD VSS BUF_X4
X_16300_ _10473_ _10474_ VDD VSS BUF_X8
X_16301_ _10433_ _10470_ _10474_ _10475_ VDD VSS MUX2_X2
X_16302_ _10398_ _10403_ _10475_ _10476_ VDD VSS AOI21_X4
X_16303_ _10396_ _10476_ _15834_ VDD VSS NAND2_X4
X_16304_ _15834_ _15846_ VDD VSS INV_X2
X_16305_ _10381_ _10477_ VDD VSS CLKBUF_X3
X_16306_ _10477_ _10348_ _10478_ VDD VSS NOR2_X1
X_16307_ _10368_ _10332_ _10479_ VDD VSS NOR2_X4
X_16308_ _10312_ _10313_ _10480_ VDD VSS NAND2_X4
X_16309_ _10300_ _10288_ _10328_ _10481_ VDD VSS NAND3_X4
X_16310_ _10309_ _10345_ _10482_ VDD VSS NAND2_X2
X_16311_ _10343_ _10347_ _10483_ VDD VSS NAND2_X1
X_16312_ _10482_ _10483_ _10484_ VDD VSS NOR2_X2
X_16313_ _00176_ _10485_ VDD VSS INV_X1
X_16314_ _10343_ _10485_ _10346_ _10309_ _10486_ VDD VSS AOI211_X2
X_16315_ _10481_ _10480_ _10484_ _10486_ _10487_ VDD VSS NOR4_X4
X_16316_ _10344_ _10488_ VDD VSS BUF_X4
X_16317_ _10479_ _10487_ _10488_ _10489_ VDD VSS MUX2_X1
X_16318_ _10344_ _10346_ _10490_ VDD VSS NAND2_X1
X_16319_ _10488_ _10368_ _10332_ _10481_ _10490_ _10480_ _10491_
+ VDD VSS OAI33_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
X_16321_ _10310_ _10493_ VDD VSS BUF_X16
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
X_16323_ _10493_ _10495_ VDD VSS BUF_X8
X_16324_ _10478_ _10489_ _10491_ _10495_ _10496_ VDD VSS AOI22_X1
X_16325_ id_stage_i.controller_i.instr_i\[30\] _10497_ VDD
+ VSS BUF_X2
X_16326_ _10497_ _10498_ VDD VSS BUF_X4
X_16327_ _10498_ _10499_ VDD VSS INV_X1
X_16328_ id_stage_i.controller_i.instr_i\[27\] _10500_ VDD
+ VSS BUF_X4
X_16329_ id_stage_i.controller_i.instr_i\[28\] _10501_ VDD
+ VSS BUF_X8
X_16330_ id_stage_i.controller_i.instr_i\[29\] _10502_ VDD
+ VSS BUF_X4
X_16331_ _00174_ _10503_ VDD VSS INV_X1
X_16332_ _10500_ _10501_ _10502_ _10503_ _10504_ VDD VSS NOR4_X2
X_16333_ _10310_ _10380_ _10381_ _10504_ _10505_ VDD VSS AND4_X1
X_16334_ _10499_ _10487_ _10505_ _10506_ VDD VSS NAND3_X1
X_16335_ id_stage_i.controller_i.instr_i\[25\] _10507_ VDD
+ VSS BUF_X2
X_16336_ _10507_ _10508_ VDD VSS INV_X4
X_16337_ id_stage_i.controller_i.instr_i\[31\] _10509_ VDD
+ VSS BUF_X4
X_16338_ _10509_ _10510_ VDD VSS INV_X2
X_16339_ _10500_ _10502_ _10501_ id_stage_i.controller_i.instr_i\[26\]
+ _10511_ VDD VSS NOR4_X4
X_16340_ _10508_ _10510_ net281 _10512_ VDD VSS NAND3_X2
X_16341_ _10300_ id_stage_i.controller_i.instr_i\[5\] _10513_
+ VDD VSS NAND2_X2
X_16342_ _10299_ _10292_ _10296_ _10513_ _10514_ VDD VSS NOR4_X4
X_16343_ _10498_ _10482_ _10515_ VDD VSS NOR2_X1
X_16344_ _10495_ _10381_ _10499_ _10516_ VDD VSS NOR3_X2
X_16345_ _10380_ _10515_ _10516_ _10517_ VDD VSS OAI21_X1
X_16346_ _10517_ _10490_ _10498_ _10518_ VDD VSS OAI21_X1
X_16347_ _10514_ _10518_ _10519_ VDD VSS NAND2_X1
X_16348_ _10519_ _10512_ _10520_ VDD VSS OR2_X2
X_16349_ _10496_ _10506_ _10520_ _15357_ VDD VSS AND3_X4
X_16350_ _15357_ _15364_ VDD VSS INV_X2
X_16351_ _10488_ _10348_ _10504_ _10521_ VDD VSS AOI21_X1
X_16352_ _10347_ _10522_ VDD VSS BUF_X4
X_16353_ _10477_ _10522_ _10488_ _10523_ VDD VSS OAI21_X1
X_16354_ _10523_ _10524_ VDD VSS INV_X1
X_16355_ net312 _10521_ _10482_ _10524_ _10495_ _10525_ VDD
+ VSS OAI221_X2
X_16356_ _10488_ _10346_ _10526_ VDD VSS NOR2_X2
X_16357_ _10490_ _10527_ VDD VSS INV_X1
X_16358_ _10495_ _10526_ _10527_ _10528_ VDD VSS OAI21_X1
X_16359_ _10382_ _10479_ _10528_ _10529_ VDD VSS NAND3_X1
X_16360_ _10327_ net315 _10340_ _10362_ _10530_ VDD VSS NOR4_X4
X_16361_ _10299_ _10292_ _10296_ _10531_ VDD VSS NOR3_X2
X_16362_ _10293_ _10288_ _10292_ _10307_ _10532_ VDD VSS NOR4_X4
X_16363_ _10373_ _10530_ _10531_ _10532_ _10533_ VDD VSS NOR4_X4
X_16364_ _10287_ _10299_ _10534_ VDD VSS NOR2_X2
X_16365_ _10341_ _10372_ _10330_ _10534_ _10535_ VDD VSS AND4_X2
X_16366_ _10380_ _10522_ _10536_ VDD VSS NAND2_X2
X_16367_ _10533_ _10535_ _10536_ _10537_ VDD VSS AOI21_X2
X_16368_ _00177_ _10538_ VDD VSS CLKBUF_X2
X_16369_ _10538_ _10539_ VDD VSS INV_X1
X_16370_ _10509_ _10497_ _10540_ VDD VSS NOR2_X2
X_16371_ _10511_ _10540_ _10541_ VDD VSS NAND2_X2
X_16372_ _10507_ _10346_ net313 _10542_ VDD VSS AOI21_X1
X_16373_ _10507_ _10509_ _10497_ _10343_ _10543_ VDD VSS AOI211_X2
X_16374_ _10543_ _10511_ _10544_ VDD VSS NAND2_X1
X_16375_ _10344_ _10497_ _10545_ VDD VSS NOR2_X1
X_16376_ _10309_ _10346_ _10545_ _10546_ VDD VSS NOR3_X1
X_16377_ _10538_ _10381_ _10402_ _10547_ VDD VSS OAI21_X1
X_16378_ _10541_ _10539_ _10542_ _10544_ _10546_ _10547_ _10548_
+ VDD VSS OAI33_X1
X_16379_ _10379_ _10381_ _10549_ VDD VSS NAND2_X2
X_16380_ _10381_ _10549_ _10402_ _10550_ VDD VSS MUX2_X1
X_16381_ _10508_ _10511_ _10540_ _10551_ VDD VSS NAND3_X1
X_16382_ _10548_ _10550_ _10551_ _10552_ VDD VSS OAI21_X1
X_16383_ _10514_ _10552_ _10553_ VDD VSS NAND2_X1
X_16384_ _10525_ _10529_ _10537_ _10553_ _15358_ VDD VSS NAND4_X4
X_16385_ _15358_ _15361_ VDD VSS INV_X4
X_16386_ _10344_ _10348_ _10554_ VDD VSS NOR2_X1
X_16387_ _10341_ _10372_ _10330_ _10534_ _10555_ VDD VSS NAND4_X4
X_16388_ net315 _10287_ _10299_ _10556_ VDD VSS NAND3_X2
X_16389_ _10292_ _10296_ _10556_ _10557_ VDD VSS OR3_X4
X_16390_ _10326_ _10554_ _10555_ _10557_ _10522_ _10558_ VDD
+ VSS OAI221_X2
X_16391_ _10327_ _10289_ _10307_ _10340_ _10559_ VDD VSS NOR4_X1
X_16392_ _10559_ _10373_ _10289_ _10560_ VDD VSS AOI21_X2
X_16393_ _10299_ _10513_ _10561_ VDD VSS NAND2_X1
X_16394_ _10532_ _10561_ _10400_ _10330_ _10342_ _10562_ VDD
+ VSS AOI221_X2
X_16395_ _10558_ _10560_ _10562_ _10563_ VDD VSS AOI21_X4
X_16396_ _10563_ _10564_ VDD VSS BUF_X2
X_16397_ _10564_ _10565_ VDD VSS BUF_X4
X_16398_ gen_regfile_ff.register_file_i.raddr_a_i\[3\] _10566_
+ VDD VSS BUF_X4
X_16399_ _10566_ _10567_ VDD VSS INV_X8
X_16400_ _10567_ _10568_ VDD VSS BUF_X4
X_16401_ _10568_ _10569_ VDD VSS BUF_X4
X_16402_ _10569_ _10570_ VDD VSS BUF_X4
X_16403_ _10570_ _10571_ VDD VSS BUF_X4
X_16404_ gen_regfile_ff.register_file_i.raddr_a_i\[4\] _10572_
+ VDD VSS BUF_X4
X_16405_ _10572_ _10573_ VDD VSS INV_X4
X_16406_ _10573_ _10574_ VDD VSS BUF_X8
X_16407_ _10574_ _10575_ VDD VSS BUF_X4
X_16408_ _10575_ _10576_ VDD VSS BUF_X4
X_16409_ gen_regfile_ff.register_file_i.raddr_a_i\[0\] _10577_
+ VDD VSS BUF_X4
X_16410_ _10577_ _10578_ VDD VSS INV_X1
X_16411_ _10578_ _10579_ VDD VSS BUF_X4
X_16412_ _10579_ _10580_ VDD VSS BUF_X8
X_16413_ _10580_ _10581_ VDD VSS BUF_X4
X_16414_ _10581_ _10582_ VDD VSS BUF_X4
X_16415_ gen_regfile_ff.register_file_i.raddr_a_i\[1\] _10583_
+ VDD VSS BUF_X8
X_16416_ _10583_ _10584_ VDD VSS BUF_X8
X_16417_ _10584_ _10585_ VDD VSS BUF_X8
Xrebuffer101 _12985_ net372 VDD VSS BUF_X4
X_16419_ _10585_ _10587_ VDD VSS BUF_X8
X_16420_ _10587_ _10588_ VDD VSS BUF_X4
X_16421_ _10588_ _10589_ VDD VSS BUF_X4
X_16422_ _00156_ _00158_ _10589_ _10590_ VDD VSS MUX2_X1
X_16423_ _10582_ _10590_ _10591_ VDD VSS NOR2_X1
X_16424_ _10577_ _10592_ VDD VSS BUF_X8
X_16425_ _10592_ _10593_ VDD VSS BUF_X4
X_16426_ _10593_ _10594_ VDD VSS BUF_X8
X_16427_ _10594_ _10595_ VDD VSS BUF_X8
X_16428_ _10595_ _10596_ VDD VSS BUF_X4
X_16429_ _10596_ _10597_ VDD VSS BUF_X4
X_16430_ _10584_ _10598_ VDD VSS BUF_X8
X_16431_ _10598_ _10599_ VDD VSS BUF_X8
X_16432_ _10599_ _10600_ VDD VSS BUF_X8
X_16433_ _10600_ _10601_ VDD VSS BUF_X8
X_16434_ _10601_ _10602_ VDD VSS BUF_X4
X_16435_ _00155_ _00157_ _10602_ _10603_ VDD VSS MUX2_X1
X_16436_ _10597_ _10603_ _10604_ VDD VSS NOR2_X1
X_16437_ _10576_ _10591_ _10604_ _10605_ VDD VSS NOR3_X1
X_16438_ gen_regfile_ff.register_file_i.raddr_a_i\[2\] _10606_
+ VDD VSS BUF_X4
X_16439_ _10606_ _10607_ VDD VSS INV_X4
X_16440_ _10607_ _10608_ VDD VSS BUF_X8
X_16441_ _10608_ _10609_ VDD VSS BUF_X8
X_16442_ _10609_ _10610_ VDD VSS BUF_X4
X_16443_ _10583_ _10611_ VDD VSS BUF_X4
X_16444_ _10611_ _10612_ VDD VSS BUF_X4
X_16445_ _10612_ _10613_ VDD VSS BUF_X8
X_16446_ _10613_ _10614_ VDD VSS BUF_X8
X_16447_ _10614_ _10615_ VDD VSS BUF_X4
X_16448_ _10615_ _10616_ VDD VSS BUF_X4
X_16449_ gen_regfile_ff.register_file_i.rf_reg\[33\] _10616_
+ _10617_ VDD VSS NOR2_X1
X_16450_ _10584_ _10618_ VDD VSS BUF_X4
X_16451_ _10618_ _10619_ VDD VSS BUF_X8
X_16452_ _10619_ _10620_ VDD VSS BUF_X4
X_16453_ _10620_ _10621_ VDD VSS BUF_X8
X_16454_ _10621_ _10622_ VDD VSS BUF_X4
X_16455_ _00142_ _10622_ _10623_ VDD VSS AND2_X1
X_16456_ _10582_ _10617_ _10623_ _10624_ VDD VSS NOR3_X1
X_16457_ _10577_ _10625_ VDD VSS BUF_X4
X_16458_ _10625_ _10626_ VDD VSS BUF_X8
X_16459_ _10626_ _10627_ VDD VSS BUF_X8
X_16460_ _10627_ _10628_ VDD VSS BUF_X4
X_16461_ _10628_ _10629_ VDD VSS BUF_X4
X_16462_ _00141_ _10629_ _10630_ VDD VSS OR2_X1
X_16463_ _10583_ _10631_ VDD VSS INV_X1
X_16464_ _10631_ _10632_ VDD VSS BUF_X4
X_16465_ _10576_ _10630_ _10632_ _10633_ VDD VSS OAI21_X1
X_16466_ _10610_ _10624_ _10633_ _10634_ VDD VSS OAI21_X1
X_16467_ _00159_ _00161_ _10588_ _10635_ VDD VSS MUX2_X1
X_16468_ _00160_ _00162_ _10588_ _10636_ VDD VSS MUX2_X1
X_16469_ _10635_ _10636_ _10629_ _10637_ VDD VSS MUX2_X1
X_16470_ _00143_ _00145_ _10588_ _10638_ VDD VSS MUX2_X1
X_16471_ _00144_ _00146_ _10588_ _10639_ VDD VSS MUX2_X1
X_16472_ _10638_ _10639_ _10629_ _10640_ VDD VSS MUX2_X1
X_16473_ _10637_ _10640_ _10576_ _10641_ VDD VSS MUX2_X1
X_16474_ _10571_ _10605_ _10634_ _10641_ _10610_ _10642_ VDD
+ VSS OAI221_X2
X_16475_ _10606_ _10567_ _10643_ VDD VSS NOR2_X4
X_16476_ _00163_ _00165_ _10588_ _10644_ VDD VSS MUX2_X1
X_16477_ _00164_ _00166_ _10621_ _10645_ VDD VSS MUX2_X1
X_16478_ _10644_ _10645_ _10629_ _10646_ VDD VSS MUX2_X1
X_16479_ _00147_ _00149_ _10621_ _10647_ VDD VSS MUX2_X1
X_16480_ _00148_ _00150_ _10621_ _10648_ VDD VSS MUX2_X1
X_16481_ _10647_ _10648_ _10629_ _10649_ VDD VSS MUX2_X1
X_16482_ _10646_ _10649_ _10576_ _10650_ VDD VSS MUX2_X1
X_16483_ _10607_ _10567_ _10651_ VDD VSS NOR2_X4
X_16484_ _00167_ _00169_ _10601_ _10652_ VDD VSS MUX2_X1
X_16485_ _00168_ _00170_ _10601_ _10653_ VDD VSS MUX2_X1
X_16486_ _10652_ _10653_ _10596_ _10654_ VDD VSS MUX2_X1
X_16487_ _00151_ _00153_ _10601_ _10655_ VDD VSS MUX2_X1
X_16488_ _00152_ _00154_ _10601_ _10656_ VDD VSS MUX2_X1
X_16489_ _10655_ _10656_ _10629_ _10657_ VDD VSS MUX2_X1
X_16490_ _10654_ _10657_ _10576_ _10658_ VDD VSS MUX2_X1
X_16491_ _10643_ _10650_ _10651_ _10658_ _10659_ VDD VSS AOI22_X4
X_16492_ _10565_ _10642_ _10659_ _10660_ VDD VSS NAND3_X2
X_16493_ _10292_ _10296_ _10556_ _10661_ VDD VSS NOR3_X4
X_16494_ _10536_ _10535_ _10661_ _10348_ _10662_ VDD VSS AOI22_X4
X_16495_ _10341_ _10287_ _10302_ _10330_ _10663_ VDD VSS NAND4_X1
X_16496_ _10663_ _10331_ _10287_ _10664_ VDD VSS OAI21_X2
X_16497_ _10299_ _10513_ _10665_ VDD VSS AND2_X1
X_16498_ _10327_ _10312_ _10666_ VDD VSS NAND2_X1
X_16499_ _10555_ _10665_ _10480_ _10384_ _10666_ _10667_ VDD
+ VSS OAI221_X2
X_16500_ _10326_ _10662_ _10664_ _10667_ _10668_ VDD VSS OAI211_X4
X_16501_ _10347_ _10555_ _10557_ _10669_ VDD VSS AOI21_X4
X_16502_ _10344_ _10381_ _10670_ VDD VSS NOR2_X4
X_16503_ _10666_ _10333_ _10384_ _10340_ _10378_ _10670_ _10671_
+ VDD VSS OAI33_X1
X_16504_ _10562_ _10669_ _10671_ _10672_ VDD VSS OR3_X4
X_16505_ _10326_ _10673_ VDD VSS BUF_X8
X_16506_ id_stage_i.controller_i.lsu_addr_last_i\[1\] _10668_
+ _10672_ _10673_ _10674_ VDD VSS AOI22_X4
X_16507_ cs_registers_i.pc_id_i\[1\] _10675_ VDD VSS CLKBUF_X2
X_16508_ _10675_ _10676_ VDD VSS INV_X1
X_16509_ _10380_ _10346_ _10677_ VDD VSS NAND2_X4
X_16510_ _10348_ _10677_ _10678_ VDD VSS NOR2_X4
X_16511_ _00183_ _10557_ _10678_ _10679_ VDD VSS OR3_X1
X_16512_ _10676_ _10679_ _10668_ _10680_ VDD VSS MUX2_X1
X_16513_ _10562_ _10669_ _10671_ _10681_ VDD VSS NOR3_X4
X_16514_ _10361_ _10681_ _10682_ VDD VSS NOR2_X4
X_16515_ _10682_ _10683_ VDD VSS BUF_X8
X_16516_ _10660_ _10674_ _10680_ _10683_ _15845_ VDD VSS AOI22_X4
X_16517_ _15845_ _15849_ VDD VSS INV_X1
X_16518_ _10430_ _10684_ VDD VSS BUF_X4
X_16519_ _10684_ _10685_ VDD VSS BUF_X4
X_16520_ _00208_ _00212_ _10685_ _10686_ VDD VSS MUX2_X1
X_16521_ _00210_ _00214_ _10685_ _10687_ VDD VSS MUX2_X1
X_16522_ _10686_ _10687_ _10454_ _10688_ VDD VSS MUX2_X1
X_16523_ _00192_ _00196_ _10685_ _10689_ VDD VSS MUX2_X1
X_16524_ _00194_ _00198_ _10685_ _10690_ VDD VSS MUX2_X1
X_16525_ _10689_ _10690_ net364 _10691_ VDD VSS MUX2_X1
X_16526_ _10688_ _10691_ _10473_ _10692_ VDD VSS MUX2_X1
X_16527_ _10466_ _10692_ _10693_ VDD VSS NOR2_X1
X_16528_ _10412_ _10694_ VDD VSS INV_X2
X_16529_ _10694_ _10695_ VDD VSS BUF_X4
X_16530_ _10695_ _10696_ VDD VSS BUF_X4
X_16531_ _10696_ _10697_ VDD VSS BUF_X4
X_16532_ _00209_ _00213_ _10431_ _10698_ VDD VSS MUX2_X1
X_16533_ _00211_ _00215_ _10685_ _10699_ VDD VSS MUX2_X1
X_16534_ _10698_ _10699_ _10454_ _10700_ VDD VSS MUX2_X1
X_16535_ _00193_ _00197_ _10685_ _10701_ VDD VSS MUX2_X1
X_16536_ _00195_ _00199_ _10685_ _10702_ VDD VSS MUX2_X1
X_16537_ _10701_ _10702_ _10454_ _10703_ VDD VSS MUX2_X1
X_16538_ _10700_ _10703_ _10473_ _10704_ VDD VSS MUX2_X1
X_16539_ _10697_ _10704_ _10705_ VDD VSS NOR2_X1
X_16540_ _10421_ _10693_ _10705_ _10706_ VDD VSS NOR3_X2
X_16541_ _10471_ _10707_ VDD VSS BUF_X4
X_16542_ _10707_ _10708_ VDD VSS BUF_X4
X_16543_ _10708_ _10709_ VDD VSS BUF_X4
X_16544_ _10452_ _10710_ VDD VSS BUF_X4
X_16545_ _00200_ _00202_ _10710_ _10711_ VDD VSS MUX2_X1
X_16546_ _00201_ _00203_ _10710_ _10712_ VDD VSS MUX2_X1
X_16547_ _10711_ _10712_ _10465_ _10713_ VDD VSS MUX2_X1
X_16548_ _10709_ _10713_ _10714_ VDD VSS NAND2_X1
X_16549_ _10695_ _10406_ _10715_ VDD VSS NAND2_X4
X_16550_ _10715_ _10716_ VDD VSS BUF_X4
X_16551_ net364 _00187_ _10717_ VDD VSS NAND2_X1
X_16552_ _10717_ gen_regfile_ff.register_file_i.rf_reg\[32\]
+ net364 _10718_ VDD VSS OAI21_X1
X_16553_ _10474_ _00186_ _10716_ _10718_ _10697_ _10719_ VDD
+ VSS OAI221_X1
X_16554_ _10436_ _10714_ _10719_ _10720_ VDD VSS AND3_X1
X_16555_ _00204_ _00206_ _10406_ _10721_ VDD VSS MUX2_X1
X_16556_ _00205_ _00207_ _10406_ _10722_ VDD VSS MUX2_X1
X_16557_ _10721_ _10722_ _10414_ _10723_ VDD VSS MUX2_X1
X_16558_ _00188_ _00190_ _10406_ _10724_ VDD VSS MUX2_X1
X_16559_ _00189_ _00191_ _10406_ _10725_ VDD VSS MUX2_X1
X_16560_ _10724_ _10725_ _10414_ _10726_ VDD VSS MUX2_X1
X_16561_ _10723_ _10726_ _10473_ _10727_ VDD VSS MUX2_X1
X_16562_ _10436_ _10727_ _10728_ VDD VSS NOR2_X1
X_16563_ _10468_ _10720_ _10728_ _10729_ VDD VSS NOR3_X2
X_16564_ _10317_ _10706_ _10729_ _10730_ VDD VSS NOR3_X4
X_16565_ _00216_ _10731_ VDD VSS INV_X1
X_16566_ _10731_ _10360_ _10371_ _10375_ _10732_ VDD VSS AOI211_X2
X_16567_ _10317_ _10389_ _10386_ _10733_ VDD VSS NAND3_X1
X_16568_ _10673_ _10374_ net250 _10734_ VDD VSS OAI21_X1
X_16569_ _10732_ _10733_ _10734_ _10697_ _10735_ VDD VSS AOI211_X2
X_16570_ _10673_ _10730_ _10735_ _10736_ VDD VSS OAI21_X4
X_16571_ _10736_ _10737_ VDD VSS INV_X1
X_16572_ _10737_ _10738_ VDD VSS BUF_X4
X_16573_ _10738_ _15841_ VDD VSS BUF_X4
X_16574_ _10736_ _10739_ VDD VSS BUF_X8
Xrebuffer9 net368 net280 VDD VSS BUF_X1
X_16576_ _10739_ _15835_ VDD VSS BUF_X4
X_16577_ _10361_ _10741_ VDD VSS BUF_X8
X_16578_ _10522_ _10670_ _10742_ VDD VSS NAND2_X2
X_16579_ _10661_ _10742_ _10743_ VDD VSS NAND2_X1
X_16580_ _10743_ _10744_ VDD VSS BUF_X4
X_16581_ _00184_ _10741_ _10681_ _10744_ _10745_ VDD VSS NOR4_X1
X_16582_ _10326_ _10672_ _10746_ VDD VSS NAND2_X2
X_16583_ _10746_ _10747_ VDD VSS BUF_X4
X_16584_ _10745_ _10747_ id_stage_i.controller_i.lsu_addr_last_i\[0\]
+ _10748_ VDD VSS AOI21_X2
X_16585_ _10572_ _10749_ VDD VSS BUF_X8
X_16586_ _10749_ _10750_ VDD VSS BUF_X8
X_16587_ _10606_ _10751_ VDD VSS BUF_X4
X_16588_ _10751_ _10752_ VDD VSS BUF_X8
X_16589_ _00188_ _00190_ _10589_ _10753_ VDD VSS MUX2_X1
X_16590_ _00189_ _00191_ _10589_ _10754_ VDD VSS MUX2_X1
X_16591_ _10753_ _10754_ _10597_ _10755_ VDD VSS MUX2_X1
X_16592_ _10752_ _10755_ _10756_ VDD VSS NAND2_X1
X_16593_ _10580_ _10601_ _10757_ VDD VSS NAND2_X4
X_16594_ _10757_ _10758_ VDD VSS BUF_X4
X_16595_ _10622_ _10759_ VDD VSS BUF_X8
X_16596_ _10759_ _00187_ _10760_ VDD VSS NAND2_X1
X_16597_ _10760_ gen_regfile_ff.register_file_i.rf_reg\[32\]
+ _10759_ _10761_ VDD VSS OAI21_X1
X_16598_ _10610_ _00186_ _10758_ _10761_ _10582_ _10762_ VDD
+ VSS OAI221_X1
X_16599_ _10571_ _10756_ _10762_ _10763_ VDD VSS NAND3_X1
X_16600_ _10566_ _10764_ VDD VSS BUF_X8
X_16601_ _10764_ _10765_ VDD VSS BUF_X4
X_16602_ _10765_ _10766_ VDD VSS BUF_X4
X_16603_ _10766_ _10767_ VDD VSS BUF_X4
X_16604_ _00194_ _00198_ _10751_ _10768_ VDD VSS MUX2_X1
X_16605_ _00195_ _00199_ _10751_ _10769_ VDD VSS MUX2_X1
X_16606_ _10768_ _10769_ _10597_ _10770_ VDD VSS MUX2_X1
X_16607_ _10759_ _10770_ _10771_ VDD VSS NAND2_X1
X_16608_ _00192_ _00196_ _10751_ _10772_ VDD VSS MUX2_X1
X_16609_ _00193_ _00197_ _10751_ _10773_ VDD VSS MUX2_X1
X_16610_ _10772_ _10773_ _10597_ _10774_ VDD VSS MUX2_X1
X_16611_ _10632_ _10774_ _10775_ VDD VSS NAND2_X1
X_16612_ _10767_ _10771_ _10775_ _10776_ VDD VSS NAND3_X1
X_16613_ _10750_ _10763_ _10776_ _10777_ VDD VSS AOI21_X2
X_16614_ _10607_ _10764_ _10778_ VDD VSS NOR2_X4
X_16615_ _00204_ _00206_ _10589_ _10779_ VDD VSS MUX2_X1
X_16616_ _00205_ _00207_ _10589_ _10780_ VDD VSS MUX2_X1
X_16617_ _10779_ _10780_ _10597_ _10781_ VDD VSS MUX2_X1
X_16618_ _10778_ _10781_ _10782_ VDD VSS NAND2_X1
X_16619_ _10574_ _10783_ VDD VSS BUF_X8
X_16620_ _10585_ gen_regfile_ff.register_file_i.raddr_a_i\[2\]
+ _10764_ _10784_ VDD VSS NOR3_X4
X_16621_ _10784_ _10785_ VDD VSS BUF_X8
X_16622_ _10625_ _10786_ VDD VSS BUF_X4
X_16623_ _10786_ _10787_ VDD VSS BUF_X4
X_16624_ _10787_ _10788_ VDD VSS BUF_X8
X_16625_ _00200_ _00201_ _10788_ _10789_ VDD VSS MUX2_X1
X_16626_ _10583_ _10790_ VDD VSS BUF_X4
X_16627_ _10790_ _10791_ VDD VSS BUF_X4
X_16628_ gen_regfile_ff.register_file_i.raddr_a_i\[2\] _10566_
+ _10792_ VDD VSS NOR2_X2
X_16629_ _10791_ _10792_ _10793_ VDD VSS AND2_X1
X_16630_ _10793_ _10794_ VDD VSS BUF_X8
X_16631_ _10625_ _10795_ VDD VSS BUF_X8
X_16632_ _10795_ _10796_ VDD VSS BUF_X4
X_16633_ _10796_ _10797_ VDD VSS BUF_X8
X_16634_ _00202_ _00203_ _10797_ _10798_ VDD VSS MUX2_X1
X_16635_ _10783_ _10785_ _10789_ _10794_ _10798_ _10799_ VDD
+ VSS AOI221_X2
X_16636_ _00214_ _00215_ _10797_ _10800_ VDD VSS MUX2_X1
X_16637_ _10609_ _10800_ _10616_ _10801_ VDD VSS AOI21_X1
X_16638_ _00210_ _00211_ _10788_ _10802_ VDD VSS MUX2_X1
X_16639_ _10752_ _10802_ _10616_ _10803_ VDD VSS AOI21_X1
X_16640_ _10759_ _10801_ _10803_ _10804_ VDD VSS OAI21_X1
X_16641_ _10582_ _00208_ _10805_ VDD VSS NAND2_X1
X_16642_ _10597_ _00209_ _10806_ VDD VSS NAND2_X1
X_16643_ _10803_ _10805_ _10806_ _10807_ VDD VSS NAND3_X1
X_16644_ _10582_ _00212_ _10808_ VDD VSS NAND2_X1
X_16645_ _10597_ _00213_ _10809_ VDD VSS NAND2_X1
X_16646_ _10801_ _10808_ _10809_ _10810_ VDD VSS NAND3_X1
X_16647_ _10767_ _10804_ _10807_ _10810_ _10811_ VDD VSS NAND4_X1
X_16648_ _10782_ _10799_ _10811_ _10812_ VDD VSS AND3_X1
X_16649_ _10777_ _10812_ _10813_ VDD VSS NOR2_X4
X_16650_ _10563_ _10746_ _10814_ VDD VSS NAND2_X4
X_16651_ _10565_ _10748_ _10813_ _10814_ _15842_ VDD VSS OAI22_X4
X_16652_ _15842_ _15838_ VDD VSS INV_X2
X_16653_ _15372_ _10815_ VDD VSS BUF_X4
X_16654_ _14067_ _10815_ alu_adder_result_ex\[1\] VDD VSS
+ XOR2_X2
X_16655_ net247 _16090_ VDD VSS INV_X4
X_16656_ _10668_ _10672_ _10673_ _10816_ VDD VSS AOI21_X4
X_16657_ _00224_ _00226_ _10619_ _10817_ VDD VSS MUX2_X1
X_16658_ _00225_ _00227_ _10619_ _10818_ VDD VSS MUX2_X1
X_16659_ _10817_ _10818_ _10796_ _10819_ VDD VSS MUX2_X1
X_16660_ _00218_ _10820_ VDD VSS INV_X1
X_16661_ _10577_ _10631_ _10821_ VDD VSS NOR2_X4
X_16662_ _10821_ _10822_ VDD VSS BUF_X4
X_16663_ _10599_ _10823_ VDD VSS BUF_X4
X_16664_ _10823_ gen_regfile_ff.register_file_i.rf_reg\[44\]
+ _10824_ VDD VSS NOR2_X1
X_16665_ _10824_ _00219_ _10614_ _10825_ VDD VSS AOI21_X1
X_16666_ _10820_ _10822_ _10825_ _10595_ _10826_ VDD VSS AOI22_X1
X_16667_ _10567_ _10827_ VDD VSS BUF_X4
X_16668_ _10827_ _10828_ VDD VSS BUF_X4
X_16669_ _10819_ _10826_ _10828_ _10829_ VDD VSS MUX2_X1
X_16670_ _10607_ _10573_ _10830_ VDD VSS NAND2_X1
X_16671_ _10830_ _10831_ VDD VSS BUF_X4
X_16672_ _10606_ _10832_ VDD VSS BUF_X4
X_16673_ _10592_ _10833_ VDD VSS BUF_X4
X_16674_ _00242_ _00243_ _10833_ _10834_ VDD VSS MUX2_X1
X_16675_ _00240_ _00241_ _10833_ _10835_ VDD VSS MUX2_X1
X_16676_ _10834_ _10835_ _10632_ _10836_ VDD VSS MUX2_X1
X_16677_ _10832_ _10836_ _10837_ VDD VSS NOR2_X1
X_16678_ _10601_ _10606_ _10838_ VDD VSS NAND2_X1
X_16679_ _10592_ _10839_ VDD VSS BUF_X4
Xclone94 _03780_ _03685_ net365 VDD VSS NOR2_X2
X_16681_ _00246_ _00247_ _10839_ _10841_ VDD VSS MUX2_X1
X_16682_ _10632_ _10606_ _10842_ VDD VSS NAND2_X1
X_16683_ _10625_ _10843_ VDD VSS BUF_X4
X_16684_ _00244_ _00245_ _10843_ _10844_ VDD VSS MUX2_X1
X_16685_ _10838_ _10841_ _10842_ _10844_ _10845_ VDD VSS OAI22_X1
X_16686_ _10570_ _10837_ _10845_ _10846_ VDD VSS NOR3_X1
X_16687_ _00236_ _00238_ _10619_ _10847_ VDD VSS MUX2_X1
X_16688_ _00237_ _00239_ _10619_ _10848_ VDD VSS MUX2_X1
X_16689_ _10847_ _10848_ _10787_ _10849_ VDD VSS MUX2_X1
X_16690_ _10778_ _10849_ _10850_ VDD VSS NAND2_X1
X_16691_ _00232_ _00233_ _10625_ _10851_ VDD VSS MUX2_X1
X_16692_ _00234_ _00235_ _10593_ _10852_ VDD VSS MUX2_X1
X_16693_ _10573_ _10784_ _10851_ _10852_ _10794_ _10853_ VDD
+ VSS AOI221_X1
X_16694_ _10850_ _10853_ _10854_ VDD VSS NAND2_X1
X_16695_ _10606_ _10573_ _10855_ VDD VSS NAND2_X4
X_16696_ _10583_ _10856_ VDD VSS BUF_X8
X_16697_ _10856_ _10857_ VDD VSS BUF_X8
X_16698_ _10857_ _10858_ VDD VSS BUF_X8
X_16699_ _00228_ _00230_ _10858_ _10859_ VDD VSS MUX2_X1
X_16700_ _00229_ _00231_ _10858_ _10860_ VDD VSS MUX2_X1
X_16701_ _10592_ _10861_ VDD VSS BUF_X8
X_16702_ _10861_ _10862_ VDD VSS BUF_X8
X_16703_ _10859_ _10860_ _10862_ _10863_ VDD VSS MUX2_X1
X_16704_ _00220_ _00222_ _10858_ _10864_ VDD VSS MUX2_X1
X_16705_ _00221_ _00223_ _10858_ _10865_ VDD VSS MUX2_X1
X_16706_ _10864_ _10865_ _10594_ _10866_ VDD VSS MUX2_X1
X_16707_ _10863_ _10866_ _10569_ _10867_ VDD VSS MUX2_X1
X_16708_ _10829_ _10831_ _10846_ _10854_ _10855_ _10867_ _10868_
+ VDD VSS OAI222_X2
X_16709_ cs_registers_i.pc_id_i\[12\] _10563_ _10869_ VDD
+ VSS AND2_X1
X_16710_ _10682_ _10870_ VDD VSS BUF_X4
X_16711_ id_stage_i.controller_i.lsu_addr_last_i\[12\] _10741_
+ _10816_ _10868_ _10869_ _10870_ _15936_ VDD VSS AOI222_X2
X_16712_ _10661_ _10670_ _10871_ VDD VSS NAND2_X1
X_16713_ _10707_ _10872_ VDD VSS BUF_X4
X_16714_ _10507_ _10873_ VDD VSS BUF_X4
X_16715_ id_stage_i.controller_i.instr_i\[26\] _10874_ VDD
+ VSS BUF_X4
X_16716_ _10872_ _10873_ _10500_ _10874_ _10875_ VDD VSS NOR4_X2
X_16717_ _10540_ _10875_ _10876_ VDD VSS NAND2_X4
X_16718_ _10502_ _10877_ VDD VSS INV_X1
X_16719_ net320 _10877_ _10878_ VDD VSS NAND2_X1
X_16720_ _10412_ _10879_ VDD VSS BUF_X4
X_16721_ _10879_ _10337_ _10880_ VDD VSS NAND2_X4
X_16722_ _10685_ _10421_ _10881_ VDD VSS NAND2_X4
X_16723_ _10876_ _10878_ _10880_ _10881_ _10882_ VDD VSS NOR4_X4
X_16724_ _10509_ _10498_ _10883_ VDD VSS OR2_X2
X_16725_ _10500_ _10874_ _10883_ _10884_ VDD VSS OR3_X1
X_16726_ net320 _10502_ _10885_ VDD VSS NAND2_X2
X_16727_ _10413_ _10337_ _10885_ _10886_ VDD VSS OR3_X4
X_16728_ _10510_ _10498_ _10887_ VDD VSS NAND2_X1
X_16729_ _10874_ _10888_ VDD VSS INV_X2
X_16730_ _10708_ _10873_ _10500_ _10888_ _10889_ VDD VSS NAND4_X4
X_16731_ _10709_ _10873_ _10884_ _10886_ _10887_ _10889_ _10890_
+ VDD VSS OAI33_X1
X_16732_ _10435_ _10420_ _10891_ VDD VSS NAND2_X4
X_16733_ net374 net320 _10502_ _10892_ VDD VSS OR3_X2
X_16734_ _10891_ _10886_ _10892_ _10893_ VDD VSS AOI21_X1
X_16735_ _10871_ _10882_ _10890_ _10893_ _10894_ VDD VSS AOI211_X2
X_16736_ _10289_ _10292_ _10296_ _10307_ _10895_ VDD VSS NOR4_X4
X_16737_ _10310_ _00175_ _10896_ VDD VSS NOR2_X1
X_16738_ id_stage_i.decoder_i.illegal_c_insn_i _10895_ _10896_
+ _10897_ VDD VSS AOI21_X1
X_16739_ _10580_ _00180_ _10784_ _10898_ VDD VSS NAND3_X4
X_16740_ gen_regfile_ff.register_file_i.waddr_a_i\[3\] _10899_
+ VDD VSS CLKBUF_X3
X_16741_ _10899_ _10900_ VDD VSS INV_X1
X_16742_ gen_regfile_ff.register_file_i.waddr_a_i\[2\] _10901_
+ VDD VSS INV_X2
X_16743_ gen_regfile_ff.register_file_i.waddr_a_i\[0\] _10902_
+ VDD VSS BUF_X4
X_16744_ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _10903_
+ VDD VSS BUF_X4
X_16745_ _10394_ _10902_ _10903_ _10904_ VDD VSS NOR3_X4
X_16746_ _10522_ _10900_ _10901_ _10904_ _10905_ VDD VSS NAND4_X1
X_16747_ _10898_ _10905_ _10906_ VDD VSS NOR2_X1
X_16748_ _10346_ _10402_ _10287_ _10907_ VDD VSS OAI21_X1
X_16749_ _10287_ _10348_ _10907_ _10344_ _10908_ VDD VSS AOI22_X1
X_16750_ _10315_ _10909_ VDD VSS BUF_X4
X_16751_ _10897_ _10871_ _10906_ _10908_ _10909_ _10910_ VDD
+ VSS OAI221_X2
X_16752_ _10296_ _10292_ _10298_ _10513_ _10911_ VDD VSS OR4_X4
X_16753_ _10911_ _10912_ VDD VSS BUF_X8
X_16754_ _10511_ _10543_ _10913_ VDD VSS AND2_X1
X_16755_ _10310_ _10381_ _10914_ VDD VSS XNOR2_X1
X_16756_ _10508_ _10914_ _10915_ VDD VSS NAND2_X1
X_16757_ _10500_ _10874_ _10501_ _10502_ _10916_ VDD VSS OR4_X2
X_16758_ _10916_ _10883_ _10917_ VDD VSS NOR2_X4
X_16759_ _10912_ _10913_ _10914_ _10915_ _10917_ _10918_ VDD
+ VSS AOI221_X2
X_16760_ _10744_ _10894_ _10910_ _10918_ _10919_ VDD VSS OR4_X4
X_16761_ _10919_ _10920_ VDD VSS BUF_X4
X_16762_ _15835_ _10920_ _15511_ VDD VSS NOR2_X2
X_16763_ _15511_ _15514_ VDD VSS INV_X1
X_16764_ _10744_ _10894_ _10910_ _10918_ _10921_ VDD VSS NOR4_X4
X_16765_ _10921_ _10922_ VDD VSS BUF_X4
X_16766_ _15846_ _10922_ _15510_ VDD VSS NAND2_X2
X_16767_ _15510_ _15517_ VDD VSS INV_X1
X_16768_ _10326_ _10316_ _10923_ VDD VSS NAND2_X2
X_16769_ _10432_ _10371_ _10375_ _10924_ VDD VSS NAND3_X1
X_16770_ _00278_ _10361_ _10354_ _10925_ VDD VSS OAI21_X1
X_16771_ _10374_ net307 _10926_ VDD VSS NOR2_X4
X_16772_ _10924_ _10925_ _10926_ _10927_ VDD VSS OAI21_X1
X_16773_ _10330_ _10385_ _10928_ VDD VSS NAND2_X4
X_16774_ _10326_ _10928_ _10929_ VDD VSS NAND2_X1
X_16775_ _10389_ _10374_ net250 _10930_ VDD VSS OAI21_X2
X_16776_ _10334_ _10371_ _10375_ _10931_ VDD VSS NAND3_X2
X_16777_ _10929_ _10930_ _10931_ _10932_ VDD VSS AOI21_X2
X_16778_ _10923_ _10927_ _10389_ gen_regfile_ff.register_file_i.waddr_a_i\[2\]
+ _10932_ _10933_ VDD VSS AOI221_X2
X_16779_ _10933_ _10934_ VDD VSS BUF_X8
X_16780_ _10435_ _10451_ _10935_ VDD VSS NOR2_X1
X_16781_ _00266_ _00268_ _10409_ _10936_ VDD VSS MUX2_X1
X_16782_ _00267_ _00269_ _10409_ _10937_ VDD VSS MUX2_X1
X_16783_ _10936_ _10937_ _10413_ _10938_ VDD VSS MUX2_X1
X_16784_ _00250_ _00252_ _10409_ _10939_ VDD VSS MUX2_X1
X_16785_ _00251_ _00253_ _10409_ _10940_ VDD VSS MUX2_X1
X_16786_ _10879_ _10941_ VDD VSS BUF_X4
X_16787_ _10939_ _10940_ _10941_ _10942_ VDD VSS MUX2_X1
X_16788_ _10938_ _10942_ _10473_ _10943_ VDD VSS MUX2_X1
X_16789_ _10419_ _10471_ _10944_ VDD VSS AND2_X2
X_16790_ _00271_ _00275_ _10434_ _10945_ VDD VSS MUX2_X1
X_16791_ _00273_ _00277_ _10434_ _10946_ VDD VSS MUX2_X1
X_16792_ _10945_ _10946_ _10453_ _10947_ VDD VSS MUX2_X1
X_16793_ _00270_ _00274_ _10434_ _10948_ VDD VSS MUX2_X1
X_16794_ _00272_ _00276_ _10434_ _10949_ VDD VSS MUX2_X1
X_16795_ _10948_ _10949_ _10453_ _10950_ VDD VSS MUX2_X1
X_16796_ _10947_ _10950_ _10696_ _10951_ VDD VSS MUX2_X1
X_16797_ _10935_ _10943_ _10944_ _10951_ _10952_ VDD VSS AOI22_X2
X_16798_ _00255_ _00257_ _10453_ _10953_ VDD VSS MUX2_X1
X_16799_ _10432_ _10953_ _10954_ VDD VSS NOR2_X1
X_16800_ _00259_ _00261_ _10410_ _10955_ VDD VSS MUX2_X1
X_16801_ _10435_ _10955_ _10956_ VDD VSS NOR2_X1
X_16802_ _10444_ _10954_ _10956_ _10957_ VDD VSS OAI21_X1
X_16803_ _00258_ _00260_ _10410_ _10958_ VDD VSS MUX2_X1
X_16804_ _00254_ _00256_ _10410_ _10959_ VDD VSS MUX2_X1
X_16805_ _10958_ _10959_ _10435_ _10960_ VDD VSS MUX2_X1
X_16806_ _10957_ _10960_ _10466_ _10961_ VDD VSS OAI21_X1
X_16807_ _10419_ _10472_ _10962_ VDD VSS NAND2_X4
X_16808_ _00248_ _10963_ VDD VSS INV_X1
X_16809_ _10412_ _10336_ _10964_ VDD VSS NOR2_X4
X_16810_ _10438_ gen_regfile_ff.register_file_i.rf_reg\[34\]
+ _10965_ VDD VSS NOR2_X1
X_16811_ _10965_ _00249_ _10710_ _10966_ VDD VSS AOI21_X1
X_16812_ _10708_ _10963_ _10964_ _10966_ _10443_ _10967_ VDD
+ VSS AOI221_X1
X_16813_ _00262_ _00264_ _10710_ _10968_ VDD VSS MUX2_X1
X_16814_ _00263_ _00265_ _10710_ _10969_ VDD VSS MUX2_X1
X_16815_ _10968_ _10969_ _10465_ _10970_ VDD VSS MUX2_X1
X_16816_ _10967_ _10970_ _10709_ _10971_ VDD VSS AOI21_X1
X_16817_ _10952_ _10961_ _10962_ _10891_ _10971_ _10972_ VDD
+ VSS OAI221_X2
X_16818_ _10972_ _10973_ VDD VSS INV_X4
X_16819_ _10673_ _10403_ _10974_ VDD VSS NAND2_X4
X_16820_ _10973_ _10974_ _10975_ VDD VSS NOR2_X4
X_16821_ _10934_ _10975_ _15853_ VDD VSS NOR2_X4
X_16822_ _15853_ _15857_ VDD VSS INV_X2
X_16823_ _10360_ _10316_ _10976_ VDD VSS NOR2_X4
X_16824_ _10442_ _10438_ _10977_ VDD VSS NAND2_X4
X_16825_ _10430_ _10978_ VDD VSS BUF_X4
X_16826_ _00304_ _00308_ _10978_ _10979_ VDD VSS MUX2_X1
X_16827_ _10879_ net411 _10980_ VDD VSS OR2_X4
X_16828_ _00301_ _00305_ _10684_ _10981_ VDD VSS MUX2_X1
X_16829_ _00302_ _00306_ _10684_ _10982_ VDD VSS MUX2_X1
X_16830_ _10977_ _10979_ _10980_ _10981_ _10982_ _10880_ _10983_
+ VDD VSS OAI222_X2
X_16831_ _10430_ _10984_ VDD VSS BUF_X4
X_16832_ _00303_ _00307_ _10984_ _10985_ VDD VSS MUX2_X1
X_16833_ _10944_ _10985_ _10715_ _10986_ VDD VSS OAI21_X1
X_16834_ _10983_ _10986_ _10987_ VDD VSS OR2_X1
X_16835_ _10709_ _10881_ _10988_ VDD VSS NOR2_X4
X_16836_ _00281_ _00283_ _10405_ _10989_ VDD VSS MUX2_X1
X_16837_ _00282_ _00284_ _10405_ _10990_ VDD VSS MUX2_X1
X_16838_ _10989_ _10990_ _10413_ _10991_ VDD VSS MUX2_X1
X_16839_ _00293_ _00295_ _10405_ _10992_ VDD VSS MUX2_X1
X_16840_ _00294_ _00296_ _10405_ _10993_ VDD VSS MUX2_X1
X_16841_ _10992_ _10993_ _10442_ _10994_ VDD VSS MUX2_X1
X_16842_ _10472_ _10891_ _10995_ VDD VSS NOR2_X4
X_16843_ _10988_ _10991_ _10994_ _10995_ _10996_ VDD VSS AOI22_X1
X_16844_ _10430_ _10419_ _10997_ VDD VSS NOR2_X4
X_16845_ _10472_ _10997_ _10998_ VDD VSS NAND2_X4
X_16846_ _10408_ gen_regfile_ff.register_file_i.rf_reg\[35\]
+ _10999_ VDD VSS NOR2_X1
X_16847_ _10999_ _00280_ _10437_ _11000_ VDD VSS AOI21_X1
X_16848_ _00279_ _11001_ VDD VSS INV_X1
X_16849_ _10998_ _11000_ _10412_ _11001_ _10964_ _11002_ VDD
+ VSS AOI221_X2
X_16850_ _00297_ _00299_ _10452_ _11003_ VDD VSS MUX2_X1
X_16851_ _00298_ _00300_ _10452_ _11004_ VDD VSS MUX2_X1
X_16852_ _11003_ _11004_ _10941_ _11005_ VDD VSS MUX2_X1
X_16853_ _10472_ _10881_ _11006_ VDD VSS NOR2_X4
X_16854_ _11002_ _11005_ _11006_ _11007_ VDD VSS AOI21_X1
X_16855_ _10465_ _10962_ _11008_ VDD VSS NOR2_X1
X_16856_ _00285_ _00289_ _10684_ _11009_ VDD VSS MUX2_X1
X_16857_ _00287_ _00291_ _10684_ _11010_ VDD VSS MUX2_X1
X_16858_ _11009_ _11010_ _10710_ _11011_ VDD VSS MUX2_X1
X_16859_ _00286_ _00290_ _10434_ _11012_ VDD VSS MUX2_X1
X_16860_ _00288_ _00292_ _10434_ _11013_ VDD VSS MUX2_X1
X_16861_ _11012_ _11013_ _10453_ _11014_ VDD VSS MUX2_X1
X_16862_ _10413_ _10451_ _11015_ VDD VSS NAND2_X2
X_16863_ _10708_ _11015_ _11016_ VDD VSS NOR2_X1
X_16864_ _11008_ _11011_ _11014_ _11016_ _11017_ VDD VSS AOI22_X1
X_16865_ _10987_ _10996_ _11007_ _11017_ _11018_ VDD VSS AND4_X1
X_16866_ _11018_ _11019_ VDD VSS BUF_X4
X_16867_ _10334_ _10374_ net276 _10923_ _11020_ VDD VSS NOR4_X2
X_16868_ _00139_ _11021_ VDD VSS INV_X1
X_16869_ _11021_ _10451_ _10386_ _11022_ VDD VSS MUX2_X1
X_16870_ _10976_ _11019_ _11020_ _11022_ _11023_ VDD VSS AOI22_X1
X_16871_ _10899_ _10386_ _10387_ _10392_ _11024_ VDD VSS OAI211_X2
X_16872_ _11023_ _11024_ _11025_ VDD VSS AND2_X2
X_16873_ _11025_ _15864_ VDD VSS INV_X4
X_16874_ _11025_ _15860_ VDD VSS BUF_X8
X_16875_ _10453_ gen_regfile_ff.register_file_i.rf_reg\[36\]
+ _11026_ VDD VSS NOR2_X1
X_16876_ _11026_ _00310_ _10439_ _11027_ VDD VSS AOI21_X1
X_16877_ _00309_ _11028_ VDD VSS INV_X1
X_16878_ _10998_ _11027_ _10465_ _11028_ _10964_ _11029_ VDD
+ VSS AOI221_X2
X_16879_ _00323_ _00325_ _10454_ _11030_ VDD VSS MUX2_X1
X_16880_ _00324_ _00326_ _10454_ _11031_ VDD VSS MUX2_X1
X_16881_ _11030_ _11031_ _10444_ _11032_ VDD VSS MUX2_X1
X_16882_ _11029_ _11032_ _10995_ _11033_ VDD VSS AOI21_X4
X_16883_ _10431_ _11034_ VDD VSS BUF_X4
X_16884_ _00315_ _00319_ _11034_ _11035_ VDD VSS MUX2_X1
X_16885_ _00318_ _00322_ _11034_ _11036_ VDD VSS MUX2_X1
X_16886_ _10980_ _11035_ _11036_ _10977_ _11037_ VDD VSS OAI22_X1
X_16887_ _00316_ _00320_ _11034_ _11038_ VDD VSS MUX2_X1
X_16888_ _00317_ _00321_ _11034_ _11039_ VDD VSS MUX2_X1
X_16889_ _10880_ _11038_ _11039_ _10716_ _11040_ VDD VSS OAI22_X1
X_16890_ _10962_ _11037_ _11040_ _11041_ VDD VSS OR3_X2
X_16891_ _10451_ _10708_ _11042_ VDD VSS NAND2_X2
X_16892_ _00334_ _00338_ _11034_ _11043_ VDD VSS MUX2_X1
X_16893_ _00332_ _00336_ _11034_ _11044_ VDD VSS MUX2_X1
X_16894_ _10977_ _11043_ _11044_ _10880_ _11045_ VDD VSS OAI22_X1
X_16895_ _00331_ _00335_ _11034_ _11046_ VDD VSS MUX2_X1
X_16896_ _00333_ _00337_ _11034_ _11047_ VDD VSS MUX2_X1
X_16897_ _10980_ _11046_ _11047_ _10715_ _11048_ VDD VSS OAI22_X1
X_16898_ _11042_ _11045_ _11048_ _11049_ VDD VSS OR3_X2
X_16899_ _00311_ _00313_ _10439_ _11050_ VDD VSS MUX2_X1
X_16900_ _00312_ _00314_ _10439_ _11051_ VDD VSS MUX2_X1
X_16901_ _11050_ _11051_ _10444_ _11052_ VDD VSS MUX2_X1
X_16902_ _00327_ _00329_ _10457_ _11053_ VDD VSS MUX2_X1
X_16903_ _00328_ _00330_ _10457_ _11054_ VDD VSS MUX2_X1
X_16904_ _11053_ _11054_ _10465_ _11055_ VDD VSS MUX2_X1
X_16905_ _10988_ _11052_ _11055_ _11006_ _11056_ VDD VSS AOI22_X4
X_16906_ _11033_ _11041_ _11049_ _11056_ _11057_ VDD VSS NAND4_X4
X_16907_ _00138_ _10474_ _10386_ _11058_ VDD VSS MUX2_X1
X_16908_ _10326_ _10316_ _11059_ VDD VSS AND2_X2
X_16909_ _10389_ _10371_ _10375_ _11059_ _11060_ VDD VSS NAND4_X4
X_16910_ _10974_ _11057_ _11058_ _11060_ _11061_ VDD VSS OAI22_X4
X_16911_ _10903_ _11062_ VDD VSS INV_X1
X_16912_ _11062_ _10929_ _10931_ _10930_ _11063_ VDD VSS AOI211_X2
X_16913_ _11061_ _11063_ _11064_ VDD VSS NOR2_X2
X_16914_ _11064_ _15869_ VDD VSS INV_X4
X_16915_ _11064_ _11065_ VDD VSS BUF_X4
X_16916_ _11065_ _15873_ VDD VSS BUF_X4
X_16917_ _10920_ _15873_ _15506_ VDD VSS NOR2_X1
X_16918_ _15515_ _11066_ VDD VSS BUF_X4
X_16919_ _10972_ _10976_ _11067_ VDD VSS NAND2_X4
X_16920_ _10925_ _10436_ _10926_ _11068_ VDD VSS MUX2_X1
X_16921_ _11059_ _11068_ _10334_ _10901_ _10393_ _11069_ VDD
+ VSS OAI221_X2
X_16922_ _11069_ _11070_ VDD VSS BUF_X4
X_16923_ _15864_ _11067_ _11070_ _11071_ VDD VSS AOI21_X4
X_16924_ _11066_ _10920_ _11071_ _11072_ VDD VSS OAI21_X4
X_16925_ _11072_ _15507_ VDD VSS INV_X1
X_16926_ _10373_ _10895_ _10368_ _11073_ VDD VSS AOI21_X4
X_16927_ _10371_ _10375_ _10928_ _11073_ _11074_ VDD VSS AOI22_X4
X_16928_ _10873_ _11059_ _11075_ VDD VSS NAND2_X1
X_16929_ _00353_ _00355_ _10406_ _11076_ VDD VSS MUX2_X1
X_16930_ _00354_ _00356_ _10406_ _11077_ VDD VSS MUX2_X1
X_16931_ _11076_ _11077_ _10414_ _11078_ VDD VSS MUX2_X1
X_16932_ _10891_ _11078_ _10709_ _11079_ VDD VSS AOI21_X1
X_16933_ _10454_ _00340_ _11080_ VDD VSS NAND2_X1
X_16934_ _11080_ gen_regfile_ff.register_file_i.rf_reg\[37\]
+ net364 _11081_ VDD VSS OAI21_X1
X_16935_ _00339_ _10716_ _11081_ _10696_ _11082_ VDD VSS OAI22_X2
X_16936_ _11079_ _11082_ _10709_ _11083_ VDD VSS OAI21_X2
X_16937_ _11034_ _10421_ _10472_ _11084_ VDD VSS NAND3_X4
X_16938_ _00341_ _00343_ _10438_ _11085_ VDD VSS MUX2_X1
X_16939_ _00342_ _00344_ _10438_ _11086_ VDD VSS MUX2_X1
X_16940_ _11085_ _11086_ _10443_ _11087_ VDD VSS MUX2_X1
X_16941_ _11084_ _11087_ _11088_ VDD VSS NOR2_X1
X_16942_ _00345_ _00349_ _10984_ _11089_ VDD VSS MUX2_X1
X_16943_ _00347_ _00351_ _10984_ _11090_ VDD VSS MUX2_X1
X_16944_ _11089_ _11090_ _10439_ _11091_ VDD VSS MUX2_X1
X_16945_ _10444_ _10962_ _11091_ _11092_ VDD VSS NOR3_X1
X_16946_ _11088_ _11092_ _11093_ VDD VSS NOR2_X2
X_16947_ _00362_ _00366_ _10431_ _11094_ VDD VSS MUX2_X1
X_16948_ _00364_ _00368_ _10431_ _11095_ VDD VSS MUX2_X1
X_16949_ _11094_ _11095_ _10454_ _11096_ VDD VSS MUX2_X1
X_16950_ _10443_ _10944_ _11097_ VDD VSS NAND2_X4
X_16951_ _11096_ _11097_ _11098_ VDD VSS NOR2_X1
X_16952_ _10431_ _10421_ _10872_ _11099_ VDD VSS NAND3_X4
X_16953_ _10437_ _11100_ VDD VSS BUF_X4
X_16954_ _00357_ _00359_ _11100_ _11101_ VDD VSS MUX2_X1
X_16955_ _00358_ _00360_ _11100_ _11102_ VDD VSS MUX2_X1
X_16956_ _11101_ _11102_ _10443_ _11103_ VDD VSS MUX2_X1
X_16957_ _11099_ _11103_ _11104_ VDD VSS NOR2_X1
X_16958_ _11098_ _11104_ _11105_ VDD VSS NOR2_X2
X_16959_ _00361_ _00365_ _10978_ _11106_ VDD VSS MUX2_X1
X_16960_ _00363_ _00367_ _10978_ _11107_ VDD VSS MUX2_X1
X_16961_ _11106_ _11107_ net411 _11108_ VDD VSS MUX2_X1
X_16962_ _10444_ _10473_ _11108_ _11109_ VDD VSS NOR3_X1
X_16963_ _00346_ _00350_ _10978_ _11110_ VDD VSS MUX2_X1
X_16964_ _00348_ _00352_ _10978_ _11111_ VDD VSS MUX2_X1
X_16965_ _11110_ _11111_ net374 _11112_ VDD VSS MUX2_X1
X_16966_ _10696_ _10709_ _11112_ _11113_ VDD VSS NOR3_X1
X_16967_ _10451_ _11109_ _11113_ _11114_ VDD VSS OAI21_X2
X_16968_ _11083_ _11093_ _11105_ _11114_ _11115_ VDD VSS AND4_X2
X_16969_ _11074_ _11075_ _11115_ _10974_ _11116_ VDD VSS OAI22_X4
X_16970_ _11116_ _15876_ VDD VSS BUF_X4
X_16971_ _15876_ _15880_ VDD VSS INV_X4
X_16972_ _10412_ _10471_ _11117_ VDD VSS OR2_X1
X_16973_ _00375_ _00377_ _10405_ _11118_ VDD VSS MUX2_X1
X_16974_ _11117_ _11118_ _11119_ VDD VSS NOR2_X1
X_16975_ _10879_ _10707_ _11120_ VDD VSS NAND2_X1
X_16976_ _00392_ _00394_ _10456_ _11121_ VDD VSS MUX2_X1
X_16977_ _10435_ _10419_ _11120_ _11121_ _11122_ VDD VSS OAI211_X2
X_16978_ _00376_ _00378_ _10408_ _11123_ VDD VSS MUX2_X1
X_16979_ _10695_ _10872_ _11123_ _11124_ VDD VSS NOR3_X2
X_16980_ _00391_ _00393_ _10408_ _11125_ VDD VSS MUX2_X1
X_16981_ _10442_ _10472_ _11125_ _11126_ VDD VSS NOR3_X2
X_16982_ _11119_ _11122_ _11124_ _11126_ _11127_ VDD VSS NOR4_X4
X_16983_ _00388_ _00390_ _10437_ _11128_ VDD VSS MUX2_X1
X_16984_ _11120_ _11128_ _11129_ VDD VSS NOR2_X1
X_16985_ _00387_ _00389_ _10404_ _11130_ VDD VSS MUX2_X1
X_16986_ _10879_ _10472_ _11130_ _11131_ VDD VSS NOR3_X1
X_16987_ _00372_ _00374_ _10404_ _11132_ VDD VSS MUX2_X1
X_16988_ _10694_ _10872_ _11132_ _11133_ VDD VSS NOR3_X1
X_16989_ _00371_ _00373_ _10404_ _11134_ VDD VSS MUX2_X1
X_16990_ _10984_ _10420_ _11117_ _11134_ _11135_ VDD VSS OAI211_X2
X_16991_ _11129_ _11131_ _11133_ _11135_ _11136_ VDD VSS NOR4_X2
X_16992_ _00379_ _00381_ _10456_ _11137_ VDD VSS MUX2_X1
X_16993_ _10442_ _11137_ _11138_ VDD VSS NOR2_X1
X_16994_ _00380_ _00382_ _10408_ _11139_ VDD VSS MUX2_X1
X_16995_ _10695_ _11139_ _11140_ VDD VSS NOR2_X1
X_16996_ _10431_ _10419_ _10472_ _11141_ VDD VSS NAND3_X1
X_16997_ _10984_ _10944_ _11142_ VDD VSS NAND2_X2
X_16998_ _00395_ _00397_ _10404_ _11143_ VDD VSS MUX2_X1
X_16999_ _10879_ _11143_ _11144_ VDD VSS NOR2_X1
X_17000_ _00396_ _00398_ _10404_ _11145_ VDD VSS MUX2_X1
X_17001_ _10694_ _11145_ _11146_ VDD VSS NOR2_X1
X_17002_ _11138_ _11140_ _11141_ _11142_ _11144_ _11146_ _11147_
+ VDD VSS OAI33_X1
X_17003_ _10708_ _10997_ _11148_ VDD VSS NAND2_X1
X_17004_ _00383_ _00385_ _10408_ _11149_ VDD VSS MUX2_X1
X_17005_ _10879_ _11149_ _11150_ VDD VSS NOR2_X1
X_17006_ _00384_ _00386_ _10404_ _11151_ VDD VSS MUX2_X1
X_17007_ _10694_ _11151_ _11152_ VDD VSS NOR2_X1
X_17008_ _10879_ _10336_ _00369_ _11153_ VDD VSS NOR3_X1
X_17009_ _10456_ gen_regfile_ff.register_file_i.rf_reg\[38\]
+ _11154_ VDD VSS NOR2_X1
X_17010_ _10408_ _00370_ _11155_ VDD VSS AND2_X1
X_17011_ _10694_ _11154_ _11155_ _11156_ VDD VSS NOR3_X1
X_17012_ _11148_ _11150_ _11152_ _11153_ _11156_ _10998_ _11157_
+ VDD VSS OAI33_X1
X_17013_ _11127_ _11136_ _11147_ _11157_ _11158_ VDD VSS NOR4_X2
X_17014_ _10976_ net345 _11159_ VDD VSS NAND2_X1
X_17015_ _10874_ _10386_ _11059_ _11160_ VDD VSS NAND3_X2
X_17016_ _10326_ _10334_ _11161_ VDD VSS NAND2_X1
X_17017_ _11161_ _10375_ _10371_ _11162_ VDD VSS AOI21_X4
X_17018_ _10538_ _10386_ _11163_ VDD VSS OR2_X1
X_17019_ _11159_ _11160_ _11162_ _11060_ _11163_ _11164_ VDD
+ VSS OAI221_X2
X_17020_ _11164_ _15884_ VDD VSS BUF_X4
X_17021_ _15884_ _15888_ VDD VSS INV_X2
X_17022_ _00413_ _00415_ _10710_ _11165_ VDD VSS MUX2_X1
X_17023_ _10444_ _11165_ _11166_ VDD VSS NOR2_X1
X_17024_ _00414_ _00416_ _10710_ _11167_ VDD VSS MUX2_X1
X_17025_ _10696_ _11167_ _11168_ VDD VSS NOR2_X1
X_17026_ _10465_ _10337_ _00399_ _11169_ VDD VSS NOR3_X1
X_17027_ _10439_ gen_regfile_ff.register_file_i.rf_reg\[39\]
+ _11170_ VDD VSS NOR2_X1
X_17028_ _10710_ _00400_ _11171_ VDD VSS AND2_X1
X_17029_ _10696_ _11170_ _11171_ _11172_ VDD VSS NOR3_X1
X_17030_ _11148_ _11166_ _11168_ _11169_ _11172_ _10998_ _11173_
+ VDD VSS OAI33_X1
X_17031_ _00406_ _00410_ _10431_ _11174_ VDD VSS MUX2_X1
X_17032_ _10696_ _10454_ _11174_ _11175_ VDD VSS NOR3_X2
X_17033_ _00408_ _00412_ _10431_ _11176_ VDD VSS MUX2_X1
X_17034_ _00405_ _00409_ _10984_ _11177_ VDD VSS MUX2_X1
X_17035_ _10977_ _11176_ _11177_ _10980_ _11178_ VDD VSS OAI22_X2
X_17036_ _00407_ _00411_ _10984_ _11179_ VDD VSS MUX2_X1
X_17037_ _10414_ _10337_ _11179_ _11180_ VDD VSS NOR3_X2
X_17038_ _10962_ _11175_ _11178_ _11180_ _11181_ VDD VSS NOR4_X4
X_17039_ _00418_ _00420_ _10406_ _11182_ VDD VSS MUX2_X1
X_17040_ _10696_ _11182_ _11183_ VDD VSS NOR2_X1
X_17041_ _00417_ _00419_ _10406_ _11184_ VDD VSS MUX2_X1
X_17042_ _10465_ _11184_ _11185_ VDD VSS NOR2_X1
X_17043_ _10695_ _11186_ VDD VSS BUF_X4
X_17044_ _00402_ _00404_ _11100_ _11187_ VDD VSS MUX2_X1
X_17045_ _11186_ _11187_ _11188_ VDD VSS NOR2_X1
X_17046_ _00401_ _00403_ _11100_ _11189_ VDD VSS MUX2_X1
X_17047_ _10414_ _11189_ _11190_ VDD VSS NOR2_X1
X_17048_ _11099_ _11183_ _11185_ _11188_ _11190_ _11084_ _11191_
+ VDD VSS OAI33_X1
X_17049_ _00425_ _00427_ _10438_ _11192_ VDD VSS MUX2_X1
X_17050_ _10465_ _11192_ _11193_ VDD VSS NOR2_X1
X_17051_ _00426_ _00428_ _10438_ _11194_ VDD VSS MUX2_X1
X_17052_ _11186_ _11194_ _11195_ VDD VSS NOR2_X1
X_17053_ _00421_ _00423_ _11100_ _11196_ VDD VSS MUX2_X1
X_17054_ _10414_ _11196_ _11197_ VDD VSS NOR2_X1
X_17055_ _00422_ _00424_ _10457_ _11198_ VDD VSS MUX2_X1
X_17056_ _11186_ _11198_ _11199_ VDD VSS NOR2_X1
X_17057_ _10435_ _10944_ _11200_ VDD VSS NAND2_X1
X_17058_ _11142_ _11193_ _11195_ _11197_ _11199_ _11200_ _11201_
+ VDD VSS OAI33_X1
X_17059_ _11173_ _11181_ _11191_ _11201_ _11202_ VDD VSS NOR4_X4
X_17060_ _10976_ _11202_ _11203_ VDD VSS NAND2_X1
X_17061_ _10500_ _11059_ _11204_ VDD VSS NAND2_X1
X_17062_ _11203_ _11204_ _11074_ _15892_ VDD VSS OAI21_X4
X_17063_ _15892_ _15896_ VDD VSS INV_X4
X_17064_ _00452_ _00456_ _10430_ _11205_ VDD VSS MUX2_X1
X_17065_ _00454_ _00458_ _10430_ _11206_ VDD VSS MUX2_X1
X_17066_ _11205_ _11206_ _11100_ _11207_ VDD VSS MUX2_X1
X_17067_ _00436_ _00440_ _10430_ _11208_ VDD VSS MUX2_X1
X_17068_ _00438_ _00442_ _10430_ _11209_ VDD VSS MUX2_X1
X_17069_ _11208_ _11209_ _11100_ _11210_ VDD VSS MUX2_X1
X_17070_ _11207_ _11210_ _10473_ _11211_ VDD VSS MUX2_X1
X_17071_ _00437_ _00453_ _10707_ _11212_ VDD VSS MUX2_X1
X_17072_ _00441_ _00457_ _10707_ _11213_ VDD VSS MUX2_X1
X_17073_ _11212_ _11213_ _10984_ _11214_ VDD VSS MUX2_X1
X_17074_ _00435_ _00451_ _10707_ _11215_ VDD VSS MUX2_X1
X_17075_ _00439_ _00455_ _10707_ _11216_ VDD VSS MUX2_X1
X_17076_ _11215_ _11216_ _10431_ _11217_ VDD VSS MUX2_X1
X_17077_ _11214_ _11217_ _10337_ _11218_ VDD VSS MUX2_X1
X_17078_ _10696_ _10451_ _11219_ VDD VSS NAND2_X1
X_17079_ _11015_ _11211_ _11218_ _11219_ _11220_ VDD VSS OAI22_X4
X_17080_ _00443_ _00445_ _10409_ _11221_ VDD VSS MUX2_X1
X_17081_ _10941_ _11221_ _11222_ VDD VSS NOR2_X1
X_17082_ _00444_ _00446_ _10405_ _11223_ VDD VSS MUX2_X1
X_17083_ _11186_ _11223_ _11224_ VDD VSS NOR2_X1
X_17084_ _10473_ _11222_ _11224_ _11225_ VDD VSS NOR3_X1
X_17085_ _00429_ _11226_ VDD VSS INV_X1
X_17086_ _10437_ gen_regfile_ff.register_file_i.rf_reg\[40\]
+ _11227_ VDD VSS NOR2_X1
X_17087_ _11227_ _00430_ net374 _11228_ VDD VSS AOI21_X1
X_17088_ _10708_ _11226_ _10964_ _11228_ _10442_ _11229_ VDD
+ VSS AOI221_X2
X_17089_ _00447_ _00449_ _10405_ _11230_ VDD VSS MUX2_X1
X_17090_ _10941_ _11230_ _11231_ VDD VSS NOR2_X1
X_17091_ _00448_ _00450_ _10437_ _11232_ VDD VSS MUX2_X1
X_17092_ _10695_ _11232_ _11233_ VDD VSS NOR2_X1
X_17093_ _10473_ _11231_ _11233_ _11234_ VDD VSS NOR3_X1
X_17094_ _00431_ _00433_ _10437_ _11235_ VDD VSS MUX2_X1
X_17095_ _10413_ _11235_ _11236_ VDD VSS NOR2_X1
X_17096_ _00432_ _00434_ _10437_ _11237_ VDD VSS MUX2_X1
X_17097_ _10695_ _11237_ _11238_ VDD VSS NOR2_X1
X_17098_ _10708_ _11236_ _11238_ _11239_ VDD VSS NOR3_X1
X_17099_ _10891_ _11225_ _11229_ _11234_ _11239_ _10881_ _11240_
+ VDD VSS OAI33_X1
X_17100_ _11220_ _11240_ _11241_ VDD VSS NOR2_X4
X_17101_ _10974_ _11241_ _11242_ VDD VSS NOR2_X1
X_17102_ _10923_ _11074_ _11243_ VDD VSS NOR2_X2
X_17103_ _11242_ _11243_ _10501_ _15904_ VDD VSS AOI21_X4
X_17104_ _10502_ _11243_ _11244_ VDD VSS NAND2_X1
X_17105_ _00465_ _00481_ _10872_ _11245_ VDD VSS MUX2_X1
X_17106_ _00469_ _00485_ _10872_ _11246_ VDD VSS MUX2_X1
X_17107_ _11245_ _11246_ _11034_ _11247_ VDD VSS MUX2_X1
X_17108_ _10696_ _10337_ _10451_ _11248_ VDD VSS NAND3_X4
X_17109_ _11186_ _10454_ _10451_ _11249_ VDD VSS NAND3_X4
X_17110_ _00467_ _00483_ _10707_ _11250_ VDD VSS MUX2_X1
X_17111_ _00471_ _00487_ _10707_ _11251_ VDD VSS MUX2_X1
X_17112_ _11250_ _11251_ _10685_ _11252_ VDD VSS MUX2_X1
X_17113_ _11247_ _11248_ _11249_ _11252_ _11253_ VDD VSS OAI22_X4
X_17114_ _00477_ _00479_ _10409_ _11254_ VDD VSS MUX2_X1
X_17115_ _00478_ _00480_ _10409_ _11255_ VDD VSS MUX2_X1
X_17116_ _11254_ _11255_ _10413_ _11256_ VDD VSS MUX2_X1
X_17117_ _00461_ _00463_ _10405_ _11257_ VDD VSS MUX2_X1
X_17118_ _00462_ _00464_ _10405_ _11258_ VDD VSS MUX2_X1
X_17119_ _11257_ _11258_ _10413_ _11259_ VDD VSS MUX2_X1
X_17120_ _11099_ _11256_ _11259_ _11084_ _11260_ VDD VSS OAI22_X4
X_17121_ _00482_ _00486_ _10684_ _11261_ VDD VSS MUX2_X1
X_17122_ _00484_ _00488_ _10684_ _11262_ VDD VSS MUX2_X1
X_17123_ _11261_ _11262_ _10710_ _11263_ VDD VSS MUX2_X1
X_17124_ _00466_ _00470_ _10434_ _11264_ VDD VSS MUX2_X1
X_17125_ _00468_ _00472_ _10434_ _11265_ VDD VSS MUX2_X1
X_17126_ _11264_ _11265_ _10453_ _11266_ VDD VSS MUX2_X1
X_17127_ _10421_ _10708_ _11267_ VDD VSS NOR2_X2
X_17128_ _10443_ _11267_ _11268_ VDD VSS NAND2_X2
X_17129_ _11097_ _11263_ _11266_ _11268_ _11269_ VDD VSS OAI22_X4
X_17130_ net371 gen_regfile_ff.register_file_i.rf_reg\[41\]
+ _11270_ VDD VSS NOR2_X1
X_17131_ _11270_ _00460_ _10409_ _11271_ VDD VSS AOI21_X1
X_17132_ _10442_ _11271_ _11272_ VDD VSS NAND2_X1
X_17133_ _00459_ _11273_ VDD VSS INV_X1
X_17134_ _10707_ _11273_ _10964_ _11274_ VDD VSS AOI21_X1
X_17135_ _00473_ _00475_ _10404_ _11275_ VDD VSS MUX2_X1
X_17136_ _00474_ _00476_ _10404_ _11276_ VDD VSS MUX2_X1
X_17137_ _11275_ _11276_ _10412_ _11277_ VDD VSS MUX2_X1
X_17138_ _10891_ _11272_ _11274_ _11277_ _10708_ _11278_ VDD
+ VSS AOI221_X2
X_17139_ _11253_ _11260_ _11269_ _11278_ _11279_ VDD VSS NOR4_X4
X_17140_ _11244_ _11279_ _10974_ _15908_ VDD VSS OAI21_X4
X_17141_ _15908_ _15912_ VDD VSS INV_X1
X_17142_ _10452_ gen_regfile_ff.register_file_i.rf_reg\[42\]
+ _11280_ VDD VSS NOR2_X1
X_17143_ _11280_ _00490_ _10438_ _11281_ VDD VSS AOI21_X1
X_17144_ _00489_ _11282_ VDD VSS INV_X1
X_17145_ _10998_ _11281_ _10413_ _11282_ _10964_ _11283_ VDD
+ VSS AOI221_X2
X_17146_ _00503_ _00505_ _10438_ _11284_ VDD VSS MUX2_X1
X_17147_ _00504_ _00506_ _10438_ _11285_ VDD VSS MUX2_X1
X_17148_ _11284_ _11285_ _10443_ _11286_ VDD VSS MUX2_X1
X_17149_ _00495_ _00499_ _10685_ _11287_ VDD VSS MUX2_X1
X_17150_ _10980_ _11287_ _11288_ VDD VSS NOR2_X1
X_17151_ _00496_ _00500_ _10984_ _11289_ VDD VSS MUX2_X1
X_17152_ _11186_ _10439_ _11289_ _11290_ VDD VSS NOR3_X1
X_17153_ _00498_ _00502_ _10984_ _11291_ VDD VSS MUX2_X1
X_17154_ _10977_ _11291_ _11292_ VDD VSS NOR2_X1
X_17155_ _00497_ _00501_ _10978_ _11293_ VDD VSS MUX2_X1
X_17156_ _10443_ _10337_ _11293_ _11294_ VDD VSS NOR3_X1
X_17157_ _11288_ _11290_ _11292_ _11294_ _11295_ VDD VSS NOR4_X2
X_17158_ _11283_ _11286_ _10995_ _11295_ _11267_ _11296_ VDD
+ VSS AOI221_X2
X_17159_ _00515_ _00517_ _11100_ _11297_ VDD VSS MUX2_X1
X_17160_ _10443_ _11297_ _11298_ VDD VSS NOR2_X1
X_17161_ _00516_ _00518_ net374 _11299_ VDD VSS MUX2_X1
X_17162_ _11186_ _11299_ _11300_ VDD VSS NOR2_X1
X_17163_ _00511_ _00513_ net374 _11301_ VDD VSS MUX2_X1
X_17164_ _10941_ _11301_ _11302_ VDD VSS NOR2_X1
X_17165_ _00512_ _00514_ _10409_ _11303_ VDD VSS MUX2_X1
X_17166_ _11186_ _11303_ _11304_ VDD VSS NOR2_X1
X_17167_ _11142_ _11298_ _11300_ _11302_ _11304_ _11200_ _11305_
+ VDD VSS OAI33_X1
X_17168_ _00507_ _00509_ _11100_ _11306_ VDD VSS MUX2_X1
X_17169_ _00508_ _00510_ _11100_ _11307_ VDD VSS MUX2_X1
X_17170_ _11306_ _11307_ _10443_ _11308_ VDD VSS MUX2_X1
X_17171_ _00491_ _00493_ _10453_ _11309_ VDD VSS MUX2_X1
X_17172_ _00492_ _00494_ _10453_ _11310_ VDD VSS MUX2_X1
X_17173_ _11309_ _11310_ _10465_ _11311_ VDD VSS MUX2_X1
X_17174_ _11305_ _11308_ _11006_ _11311_ _10988_ _11312_ VDD
+ VSS AOI221_X2
X_17175_ _11296_ _11312_ _11313_ VDD VSS NAND2_X4
X_17176_ _10498_ _11059_ _11314_ VDD VSS NAND2_X1
X_17177_ _10974_ _11313_ _11314_ _11074_ _15916_ VDD VSS OAI22_X4
X_17178_ _15916_ _15920_ VDD VSS INV_X4
X_17179_ _10902_ _11315_ VDD VSS INV_X4
X_17180_ _10509_ _10330_ _10385_ _11316_ VDD VSS AOI21_X1
X_17181_ _00140_ _10330_ _11317_ VDD VSS NAND2_X1
X_17182_ _11073_ _10353_ _11317_ _11318_ VDD VSS OAI21_X1
X_17183_ _11315_ _11073_ _11316_ _11318_ _11319_ VDD VSS OAI22_X2
X_17184_ _00174_ _10334_ _10371_ _10375_ _11320_ VDD VSS AOI211_X2
X_17185_ _10403_ _10926_ _11319_ _11320_ _10928_ _11321_ VDD
+ VSS AOI221_X2
X_17186_ _00527_ _00543_ _10872_ _11322_ VDD VSS MUX2_X1
X_17187_ _00531_ _00547_ _10872_ _11323_ VDD VSS MUX2_X1
X_17188_ _11322_ _11323_ _10432_ _11324_ VDD VSS MUX2_X1
X_17189_ _00525_ _00541_ _10872_ _11325_ VDD VSS MUX2_X1
X_17190_ _00529_ _00545_ _10872_ _11326_ VDD VSS MUX2_X1
X_17191_ _11325_ _11326_ _10432_ _11327_ VDD VSS MUX2_X1
X_17192_ _11249_ _11324_ _11327_ _11248_ _11328_ VDD VSS OAI22_X4
X_17193_ _00537_ _00539_ net374 _11329_ VDD VSS MUX2_X1
X_17194_ _00538_ _00540_ net411 _11330_ VDD VSS MUX2_X1
X_17195_ _11329_ _11330_ _10941_ _11331_ VDD VSS MUX2_X1
X_17196_ _00521_ _00523_ net411 _11332_ VDD VSS MUX2_X1
X_17197_ _00522_ _00524_ net411 _11333_ VDD VSS MUX2_X1
X_17198_ _11332_ _11333_ _10941_ _11334_ VDD VSS MUX2_X1
X_17199_ _11099_ _11331_ _11334_ _11084_ _11335_ VDD VSS OAI22_X4
X_17200_ _00542_ _00546_ _10978_ _11336_ VDD VSS MUX2_X1
X_17201_ _00544_ _00548_ _10978_ _11337_ VDD VSS MUX2_X1
X_17202_ _11336_ _11337_ net374 _11338_ VDD VSS MUX2_X1
X_17203_ _00526_ _00530_ _10684_ _11339_ VDD VSS MUX2_X1
X_17204_ _00528_ _00532_ _10978_ _11340_ VDD VSS MUX2_X1
X_17205_ _11339_ _11340_ net374 _11341_ VDD VSS MUX2_X1
X_17206_ _11097_ _11338_ _11341_ _11268_ _11342_ VDD VSS OAI22_X4
X_17207_ _10453_ _00520_ _11343_ VDD VSS NAND2_X1
X_17208_ _11343_ gen_regfile_ff.register_file_i.rf_reg\[43\]
+ net374 _11344_ VDD VSS OAI21_X1
X_17209_ _10473_ _00519_ _10715_ _11344_ _11186_ _11345_ VDD
+ VSS OAI221_X1
X_17210_ _00533_ _00535_ net371 _11346_ VDD VSS MUX2_X1
X_17211_ _00534_ _00536_ _10456_ _11347_ VDD VSS MUX2_X1
X_17212_ _11346_ _11347_ _10879_ _11348_ VDD VSS MUX2_X1
X_17213_ _10891_ _11348_ _10709_ _11349_ VDD VSS AOI21_X1
X_17214_ _11345_ _11349_ _11350_ VDD VSS AND2_X2
X_17215_ _11328_ _11335_ _11342_ _11350_ _11351_ VDD VSS OR4_X4
X_17216_ _10673_ _10317_ _11351_ _11352_ VDD VSS OAI21_X4
X_17217_ _11321_ _11352_ _11353_ VDD VSS OR2_X1
X_17218_ _11353_ _15929_ VDD VSS BUF_X4
X_17219_ _15929_ _15925_ VDD VSS INV_X2
X_17220_ _15936_ _15932_ VDD VSS INV_X2
X_17221_ _10380_ _10898_ _11354_ VDD VSS OR2_X1
X_17222_ _10477_ _10661_ _11354_ _15522_ VDD VSS NAND3_X2
X_17223_ _15522_ _15529_ VDD VSS INV_X1
X_17224_ _10488_ _10661_ _10898_ _11355_ VDD VSS NAND3_X4
X_17225_ _11355_ _11356_ VDD VSS BUF_X2
X_17226_ _11356_ _15526_ VDD VSS BUF_X2
X_17227_ _10567_ _11357_ VDD VSS BUF_X4
X_17228_ _11357_ _11358_ VDD VSS BUF_X4
X_17229_ _10621_ _00520_ _11359_ VDD VSS NAND2_X1
X_17230_ _11359_ gen_regfile_ff.register_file_i.rf_reg\[43\]
+ _10615_ _11360_ VDD VSS OAI21_X1
X_17231_ _11358_ _00519_ _10757_ _11360_ _10580_ _11361_ VDD
+ VSS OAI221_X1
X_17232_ _10790_ _11362_ VDD VSS BUF_X4
X_17233_ _11362_ _11363_ VDD VSS BUF_X4
X_17234_ _00525_ _00527_ _11363_ _11364_ VDD VSS MUX2_X1
X_17235_ _00526_ _00528_ _11363_ _11365_ VDD VSS MUX2_X1
X_17236_ _10862_ _11366_ VDD VSS BUF_X8
X_17237_ _11364_ _11365_ _11366_ _11367_ VDD VSS MUX2_X1
X_17238_ _10830_ _11367_ _10766_ _11368_ VDD VSS AOI21_X1
X_17239_ _11361_ _11368_ _11369_ VDD VSS NAND2_X1
X_17240_ _10572_ _11370_ VDD VSS BUF_X8
X_17241_ _10608_ _11370_ _11371_ VDD VSS NAND2_X4
X_17242_ _10598_ _11372_ VDD VSS BUF_X4
X_17243_ _00541_ _00543_ _11372_ _11373_ VDD VSS MUX2_X1
X_17244_ _00542_ _00544_ _11372_ _11374_ VDD VSS MUX2_X1
X_17245_ _10593_ _11375_ VDD VSS BUF_X4
X_17246_ _11373_ _11374_ _11375_ _11376_ VDD VSS MUX2_X1
X_17247_ _00533_ _00535_ _11372_ _11377_ VDD VSS MUX2_X1
X_17248_ _00534_ _00536_ _11372_ _11378_ VDD VSS MUX2_X1
X_17249_ _11377_ _11378_ _11375_ _11379_ VDD VSS MUX2_X1
X_17250_ _11376_ _11379_ _10569_ _11380_ VDD VSS MUX2_X1
X_17251_ _00545_ _00547_ _10598_ _11381_ VDD VSS MUX2_X1
X_17252_ _00546_ _00548_ _10598_ _11382_ VDD VSS MUX2_X1
X_17253_ _10592_ _11383_ VDD VSS BUF_X4
X_17254_ _11381_ _11382_ _11383_ _11384_ VDD VSS MUX2_X1
X_17255_ _10584_ _11385_ VDD VSS BUF_X4
X_17256_ _00537_ _00539_ _11385_ _11386_ VDD VSS MUX2_X1
X_17257_ _00538_ _00540_ _11385_ _11387_ VDD VSS MUX2_X1
X_17258_ _11386_ _11387_ _11383_ _11388_ VDD VSS MUX2_X1
X_17259_ _11384_ _11388_ _10568_ _11389_ VDD VSS MUX2_X1
X_17260_ _00529_ _00531_ _11385_ _11390_ VDD VSS MUX2_X1
X_17261_ _00530_ _00532_ _11385_ _11391_ VDD VSS MUX2_X1
X_17262_ _11390_ _11391_ _11383_ _11392_ VDD VSS MUX2_X1
X_17263_ _00521_ _00523_ _11385_ _11393_ VDD VSS MUX2_X1
X_17264_ _00522_ _00524_ _11385_ _11394_ VDD VSS MUX2_X1
X_17265_ _11393_ _11394_ _11383_ _11395_ VDD VSS MUX2_X1
X_17266_ _11392_ _11395_ _10568_ _11396_ VDD VSS MUX2_X1
X_17267_ _11389_ _11396_ _10574_ _11397_ VDD VSS MUX2_X1
X_17268_ _11369_ _11380_ _11371_ _11397_ _10609_ _11398_ VDD
+ VSS OAI221_X2
X_17269_ cs_registers_i.pc_id_i\[11\] _10563_ _11399_ VDD
+ VSS AND2_X1
X_17270_ id_stage_i.controller_i.lsu_addr_last_i\[11\] _10741_
+ _10816_ _11398_ _11399_ _10870_ _15928_ VDD VSS AOI222_X2
X_17271_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[1\]
+ _11400_ VDD VSS BUF_X1
X_17272_ _10508_ net288 _10541_ _11401_ VDD VSS NOR3_X4
X_17273_ _11401_ _10677_ _10310_ _11402_ VDD VSS OAI21_X2
X_17274_ _11400_ _11402_ _11403_ VDD VSS NAND2_X1
X_17275_ _00555_ _11403_ _11404_ VDD VSS NAND2_X1
X_17276_ _10873_ _10514_ _10917_ _11405_ VDD VSS NAND3_X2
X_17277_ _11405_ _11406_ VDD VSS BUF_X4
X_17278_ _11406_ _11407_ VDD VSS BUF_X4
X_17279_ _11407_ _11408_ VDD VSS BUF_X4
X_17280_ _11408_ _11409_ VDD VSS BUF_X4
X_17281_ _10373_ _10530_ _10531_ _10532_ _11410_ VDD VSS OR4_X1
X_17282_ _10508_ _10499_ _00174_ net281 _11411_ VDD VSS NAND4_X1
X_17283_ _10508_ _00174_ _10538_ net281 _11412_ VDD VSS NAND4_X1
X_17284_ _10522_ _11411_ _11412_ _10310_ _11413_ VDD VSS AOI22_X2
X_17285_ _10480_ _10549_ _10481_ _11414_ VDD VSS OR3_X1
X_17286_ _10341_ _10522_ _10670_ _11415_ VDD VSS AOI21_X1
X_17287_ _10342_ _10536_ _11415_ _10352_ _11416_ VDD VSS AOI22_X2
X_17288_ _11410_ _10661_ _11413_ _11414_ _11416_ _10340_ _11417_
+ VDD VSS OAI222_X2
X_17289_ _10894_ _10910_ _10918_ _11417_ _11418_ VDD VSS NOR4_X4
X_17290_ id_stage_i.controller_i.instr_fetch_err_i _11419_
+ VDD VSS CLKBUF_X3
X_17291_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _11420_
+ VDD VSS BUF_X4
X_17292_ id_stage_i.controller_i.ctrl_fsm_cs\[1\] _11421_
+ VDD VSS BUF_X4
X_17293_ id_stage_i.controller_i.ctrl_fsm_cs\[3\] _11422_
+ VDD VSS BUF_X4
X_17294_ id_stage_i.controller_i.ctrl_fsm_cs\[2\] _11423_
+ VDD VSS CLKBUF_X3
X_17295_ _11423_ _11424_ VDD VSS INV_X8
X_17296_ _11421_ _11422_ _11424_ _11425_ VDD VSS NOR3_X4
X_17297_ _11420_ _11425_ _11426_ VDD VSS NAND2_X4
X_17298_ _10305_ _11419_ _11426_ _11427_ VDD VSS NOR3_X4
X_17299_ _11418_ _11427_ _11428_ VDD VSS NAND2_X4
X_17300_ _10495_ _11409_ _11428_ _11429_ VDD VSS NOR3_X4
X_17301_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]
+ _11404_ _11429_ _00000_ VDD VSS MUX2_X1
X_17302_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[3\]
+ _11430_ VDD VSS BUF_X4
X_17303_ _11400_ _11431_ VDD VSS BUF_X4
X_17304_ _10402_ _11432_ VDD VSS BUF_X4
X_17305_ _11406_ _10670_ _11432_ _11433_ VDD VSS AOI21_X4
X_17306_ _11431_ _11433_ _11434_ VDD VSS AND2_X2
X_17307_ _11430_ _11434_ _11429_ _00001_ VDD VSS MUX2_X1
X_17308_ id_stage_i.controller_i.lsu_addr_last_i\[2\] _11435_
+ VDD VSS INV_X1
X_17309_ _11435_ _10565_ _10681_ _10397_ _11436_ VDD VSS OAI22_X1
X_17310_ _10792_ _11437_ VDD VSS INV_X4
X_17311_ _00262_ _00264_ _10621_ _11438_ VDD VSS MUX2_X1
X_17312_ _00263_ _00265_ _10621_ _11439_ VDD VSS MUX2_X1
X_17313_ _11438_ _11439_ _10629_ _11440_ VDD VSS MUX2_X1
X_17314_ _11437_ _11440_ _10749_ _11441_ VDD VSS AOI21_X1
X_17315_ _10616_ _00249_ _11442_ VDD VSS NAND2_X1
X_17316_ _11442_ gen_regfile_ff.register_file_i.rf_reg\[34\]
+ _10616_ _11443_ VDD VSS OAI21_X1
X_17317_ _00248_ _10758_ _11443_ _10582_ _11444_ VDD VSS OAI22_X1
X_17318_ _11441_ _11444_ _10750_ _11445_ VDD VSS OAI21_X1
X_17319_ _00270_ _00272_ _10614_ _11446_ VDD VSS MUX2_X1
X_17320_ _00271_ _00273_ _10614_ _11447_ VDD VSS MUX2_X1
X_17321_ _11446_ _11447_ _10797_ _11448_ VDD VSS MUX2_X1
X_17322_ _00254_ _00256_ _10614_ _11449_ VDD VSS MUX2_X1
X_17323_ _00255_ _00257_ _10614_ _11450_ VDD VSS MUX2_X1
X_17324_ _11449_ _11450_ _10596_ _11451_ VDD VSS MUX2_X1
X_17325_ _11448_ _11451_ _10576_ _11452_ VDD VSS MUX2_X1
X_17326_ _10608_ _10766_ _11453_ VDD VSS NAND2_X4
X_17327_ _10858_ _11454_ VDD VSS BUF_X8
X_17328_ _00274_ _00276_ _11454_ _11455_ VDD VSS MUX2_X1
X_17329_ _00275_ _00277_ _11454_ _11456_ VDD VSS MUX2_X1
X_17330_ _11455_ _11456_ _11366_ _11457_ VDD VSS MUX2_X1
X_17331_ _00258_ _00260_ _11454_ _11458_ VDD VSS MUX2_X1
X_17332_ _00259_ _00261_ _11454_ _11459_ VDD VSS MUX2_X1
X_17333_ _11458_ _11459_ _11366_ _11460_ VDD VSS MUX2_X1
X_17334_ _11457_ _11460_ _10575_ _11461_ VDD VSS MUX2_X1
X_17335_ _00266_ _00268_ _11454_ _11462_ VDD VSS MUX2_X1
X_17336_ _00267_ _00269_ _11454_ _11463_ VDD VSS MUX2_X1
X_17337_ _11462_ _11463_ _10595_ _11464_ VDD VSS MUX2_X1
X_17338_ _00250_ _00252_ _11454_ _11465_ VDD VSS MUX2_X1
X_17339_ _00251_ _00253_ _11454_ _11466_ VDD VSS MUX2_X1
X_17340_ _11465_ _11466_ _10595_ _11467_ VDD VSS MUX2_X1
X_17341_ _11464_ _11467_ _10575_ _11468_ VDD VSS MUX2_X1
X_17342_ _11461_ _11468_ _10571_ _11469_ VDD VSS MUX2_X1
X_17343_ _11445_ _11452_ _11453_ _10610_ _11469_ _11470_ VDD
+ VSS OAI221_X2
X_17344_ _11436_ net296 _10565_ _11471_ VDD VSS AOI21_X2
X_17345_ _00182_ _10565_ _10744_ _11472_ VDD VSS NOR3_X1
X_17346_ cs_registers_i.pc_id_i\[2\] _10565_ _11473_ VDD VSS
+ AND2_X1
X_17347_ _10747_ _11472_ _11473_ _11474_ VDD VSS NOR3_X2
X_17348_ _11471_ _11474_ _15852_ VDD VSS NOR2_X4
X_17349_ _15852_ _15856_ VDD VSS INV_X1
Xrebuffer14 _15365_ net285 VDD VSS BUF_X2
X_17351_ _15365_ _11476_ VDD VSS INV_X2
X_17352_ _10538_ _10499_ net313 _11477_ VDD VSS OAI21_X1
X_17353_ _10549_ _10512_ _10912_ _11477_ _11478_ VDD VSS NOR4_X2
X_17354_ _10480_ _10382_ _11479_ VDD VSS NOR2_X1
X_17355_ _10305_ _10306_ _10384_ _10481_ _10484_ _10486_ _11480_
+ VDD VSS OAI33_X1
X_17356_ _11478_ _11479_ _11480_ net311 _10505_ _11481_ VDD
+ VSS AOI221_X2
X_17357_ _11481_ _11482_ VDD VSS BUF_X4
X_17358_ _10402_ _10344_ _10348_ _11483_ VDD VSS OAI21_X2
X_17359_ _10479_ _11483_ _11484_ VDD VSS AND2_X1
X_17360_ _11476_ _11482_ _11484_ _11485_ VDD VSS NAND3_X1
X_17361_ _15362_ _11486_ VDD VSS BUF_X4
X_17362_ _10479_ _11483_ _11487_ VDD VSS NAND2_X4
X_17363_ _11486_ _11481_ _11487_ _11488_ VDD VSS OR3_X1
X_17364_ _10340_ _10378_ _10554_ _11483_ _10368_ _10332_ _11489_
+ VDD VSS OAI33_X1
X_17365_ _10344_ _10482_ _11490_ VDD VSS OR2_X1
X_17366_ _10483_ _10504_ _11490_ _11491_ VDD VSS OAI21_X1
X_17367_ _10533_ net253 _11491_ net310 _11492_ VDD VSS AOI211_X2
X_17368_ net313 _10347_ _10670_ _11493_ VDD VSS MUX2_X1
X_17369_ _10508_ net281 _11494_ VDD VSS NAND2_X1
X_17370_ _10347_ _10480_ _10481_ _10912_ _11494_ _10883_ _11495_
+ VDD VSS OAI33_X1
X_17371_ _10380_ _10482_ _11496_ VDD VSS NOR2_X2
X_17372_ _10479_ _11493_ _11496_ _11495_ _11497_ VDD VSS AOI22_X4
X_17373_ net313 _10490_ _10551_ _11498_ VDD VSS OR3_X2
X_17374_ net299 _11498_ _11499_ VDD VSS AND2_X1
X_17375_ _11492_ _11497_ net288 _11499_ _11500_ VDD VSS OAI211_X4
X_17376_ _11485_ _11488_ _11500_ _11501_ VDD VSS MUX2_X2
X_17377_ _11405_ _11487_ _11502_ VDD VSS NAND2_X1
X_17378_ _15360_ _11503_ VDD VSS INV_X1
X_17379_ _11503_ _11481_ _11504_ VDD VSS AND2_X1
X_17380_ _15367_ _11505_ VDD VSS BUF_X4
X_17381_ _10333_ _10895_ _11493_ _11506_ VDD VSS AND3_X1
X_17382_ _10347_ _10480_ _10481_ _10512_ _10912_ _10498_ _11507_
+ VDD VSS OAI33_X1
X_17383_ _11506_ _11507_ _11496_ _11508_ VDD VSS AOI21_X4
X_17384_ _11505_ _11481_ _11508_ _11509_ VDD VSS AND3_X1
X_17385_ net288 _11498_ net274 _11510_ VDD VSS AOI21_X4
X_17386_ net310 _11491_ _11511_ VDD VSS AND2_X1
X_17387_ _10533_ net253 _11511_ _11510_ _11512_ VDD VSS NOR4_X4
X_17388_ _11504_ _11509_ _11512_ _11513_ VDD VSS MUX2_X2
X_17389_ _11501_ _11502_ _11513_ _11514_ VDD VSS OAI21_X4
X_17390_ _11514_ _14064_ VDD VSS INV_X2
X_17391_ _00181_ _10565_ _10744_ _11515_ VDD VSS NOR3_X1
X_17392_ id_stage_i.controller_i.lsu_addr_last_i\[3\] _10397_
+ _10683_ _11515_ _11516_ VDD VSS AOI22_X2
X_17393_ cs_registers_i.pc_id_i\[3\] _11517_ VDD VSS BUF_X2
X_17394_ _10565_ _10747_ _11517_ _11518_ VDD VSS OAI21_X2
X_17395_ _00285_ _00287_ _10588_ _11519_ VDD VSS MUX2_X1
X_17396_ _00286_ _00288_ _10588_ _11520_ VDD VSS MUX2_X1
X_17397_ _11519_ _11520_ _10629_ _11521_ VDD VSS MUX2_X1
X_17398_ _10767_ _11521_ _11522_ VDD VSS NAND2_X1
X_17399_ _10616_ _00280_ _11523_ VDD VSS NAND2_X1
X_17400_ _11523_ gen_regfile_ff.register_file_i.rf_reg\[35\]
+ _10616_ _11524_ VDD VSS OAI21_X1
X_17401_ _10571_ _00279_ _10758_ _11524_ _10582_ _11525_ VDD
+ VSS OAI221_X1
X_17402_ _10610_ _10576_ _11522_ _11525_ _11526_ VDD VSS NAND4_X1
X_17403_ _00297_ _00299_ _10600_ _11527_ VDD VSS MUX2_X1
X_17404_ _00298_ _00300_ _10600_ _11528_ VDD VSS MUX2_X1
X_17405_ _11527_ _11528_ _10628_ _11529_ VDD VSS MUX2_X1
X_17406_ _00295_ _00296_ _10595_ _11530_ VDD VSS MUX2_X1
X_17407_ _00293_ _00294_ _11366_ _11531_ VDD VSS MUX2_X1
X_17408_ _11529_ _10778_ _11530_ _10794_ _11531_ _10785_ _11532_
+ VDD VSS AOI222_X2
X_17409_ _10766_ _11533_ VDD VSS BUF_X4
X_17410_ _11383_ _11534_ VDD VSS BUF_X8
X_17411_ _11534_ _11535_ VDD VSS BUF_X8
X_17412_ _00307_ _00308_ _11535_ _11536_ VDD VSS MUX2_X1
X_17413_ _00305_ _00306_ _10797_ _11537_ VDD VSS MUX2_X1
X_17414_ _11533_ _10838_ _11536_ _11537_ _10842_ _11538_ VDD
+ VSS OAI221_X1
X_17415_ _00303_ _00304_ _10627_ _11539_ VDD VSS MUX2_X1
X_17416_ _00301_ _00302_ _10787_ _11540_ VDD VSS MUX2_X1
X_17417_ _11539_ _11540_ _10632_ _11541_ VDD VSS MUX2_X1
X_17418_ _10752_ _11541_ _11542_ VDD VSS NOR2_X1
X_17419_ _11532_ _11538_ _11542_ _11543_ VDD VSS OAI21_X2
X_17420_ _00289_ _00291_ _10614_ _11544_ VDD VSS MUX2_X1
X_17421_ _10857_ _11545_ VDD VSS BUF_X4
X_17422_ _11545_ _11546_ VDD VSS BUF_X4
X_17423_ _11546_ _11547_ VDD VSS BUF_X4
X_17424_ _00290_ _00292_ _11547_ _11548_ VDD VSS MUX2_X1
X_17425_ _11544_ _11548_ _10596_ _11549_ VDD VSS MUX2_X1
X_17426_ _00281_ _00283_ _11547_ _11550_ VDD VSS MUX2_X1
X_17427_ _00282_ _00284_ _11547_ _11551_ VDD VSS MUX2_X1
X_17428_ _11550_ _11551_ _10596_ _11552_ VDD VSS MUX2_X1
X_17429_ _11549_ _11552_ _10570_ _11553_ VDD VSS MUX2_X1
X_17430_ _11526_ _10576_ _11543_ _11553_ _10855_ _11554_ VDD
+ VSS OAI221_X2
X_17431_ _10683_ _11554_ _11555_ VDD VSS NOR2_X1
X_17432_ _11516_ _11518_ _11555_ _15865_ VDD VSS OAI21_X4
X_17433_ _15865_ _15861_ VDD VSS INV_X2
X_17434_ id_stage_i.controller_i.lsu_addr_last_i\[4\] _11556_
+ VDD VSS INV_X1
X_17435_ _00180_ _10361_ _10743_ _11557_ VDD VSS OR3_X1
X_17436_ _11556_ _10673_ _10681_ _11557_ _11558_ VDD VSS OAI22_X2
X_17437_ _00323_ _00325_ _10600_ _11559_ VDD VSS MUX2_X1
X_17438_ _00324_ _00326_ _10600_ _11560_ VDD VSS MUX2_X1
X_17439_ _11559_ _11560_ _11535_ _11561_ VDD VSS MUX2_X1
X_17440_ _11437_ _11561_ _11370_ _11562_ VDD VSS AOI21_X1
X_17441_ _10621_ _00310_ _11563_ VDD VSS NAND2_X1
X_17442_ _11563_ gen_regfile_ff.register_file_i.rf_reg\[36\]
+ _10615_ _11564_ VDD VSS OAI21_X1
X_17443_ _00309_ _10757_ _11564_ _10580_ _11565_ VDD VSS OAI22_X1
X_17444_ _11562_ _11565_ _10749_ _11566_ VDD VSS OAI21_X2
X_17445_ _10611_ _11567_ VDD VSS BUF_X4
X_17446_ _11567_ _11568_ VDD VSS BUF_X4
X_17447_ _00331_ _00333_ _11568_ _11569_ VDD VSS MUX2_X1
X_17448_ _00332_ _00334_ _11568_ _11570_ VDD VSS MUX2_X1
X_17449_ _11569_ _11570_ _10796_ _11571_ VDD VSS MUX2_X1
X_17450_ _00315_ _00317_ _11568_ _11572_ VDD VSS MUX2_X1
X_17451_ _00316_ _00318_ _11568_ _11573_ VDD VSS MUX2_X1
X_17452_ _11572_ _11573_ _10796_ _11574_ VDD VSS MUX2_X1
X_17453_ _11571_ _11574_ _10574_ _11575_ VDD VSS MUX2_X1
X_17454_ _00335_ _00337_ _10618_ _11576_ VDD VSS MUX2_X1
X_17455_ _00336_ _00338_ _10618_ _11577_ VDD VSS MUX2_X1
X_17456_ _11576_ _11577_ _10795_ _11578_ VDD VSS MUX2_X1
X_17457_ _00319_ _00321_ _10618_ _11579_ VDD VSS MUX2_X1
X_17458_ _00320_ _00322_ _10618_ _11580_ VDD VSS MUX2_X1
X_17459_ _11579_ _11580_ _10795_ _11581_ VDD VSS MUX2_X1
X_17460_ _11578_ _11581_ _10573_ _11582_ VDD VSS MUX2_X1
X_17461_ _00327_ _00329_ _10618_ _11583_ VDD VSS MUX2_X1
X_17462_ _00328_ _00330_ _11567_ _11584_ VDD VSS MUX2_X1
X_17463_ _11583_ _11584_ _10795_ _11585_ VDD VSS MUX2_X1
X_17464_ _00311_ _00313_ _11567_ _11586_ VDD VSS MUX2_X1
X_17465_ _00312_ _00314_ _11567_ _11587_ VDD VSS MUX2_X1
X_17466_ _11586_ _11587_ _10795_ _11588_ VDD VSS MUX2_X1
X_17467_ _11585_ _11588_ _10574_ _11589_ VDD VSS MUX2_X1
X_17468_ _11582_ _11589_ _11358_ _11590_ VDD VSS MUX2_X1
X_17469_ _11566_ _11575_ _11453_ _11590_ _10609_ _11591_ VDD
+ VSS OAI221_X2
X_17470_ _10816_ _11591_ _11592_ VDD VSS AND2_X1
X_17471_ _10563_ _11593_ VDD VSS CLKBUF_X2
X_17472_ cs_registers_i.pc_id_i\[4\] _11593_ _11594_ VDD VSS
+ AND2_X1
X_17473_ _10683_ _11594_ _11595_ VDD VSS AND2_X1
X_17474_ _11558_ _11592_ _11595_ _15868_ VDD VSS OR3_X4
X_17475_ _15868_ _15872_ VDD VSS INV_X2
X_17476_ _10816_ _11596_ VDD VSS BUF_X4
X_17477_ _11568_ _11597_ VDD VSS BUF_X4
X_17478_ _00345_ _00347_ _11597_ _11598_ VDD VSS MUX2_X1
X_17479_ _00346_ _00348_ _11597_ _11599_ VDD VSS MUX2_X1
X_17480_ _11598_ _11599_ _10797_ _11600_ VDD VSS MUX2_X1
X_17481_ _10831_ _11600_ _11533_ _11601_ VDD VSS AOI21_X1
X_17482_ _10602_ _00340_ _11602_ VDD VSS NAND2_X1
X_17483_ _11602_ gen_regfile_ff.register_file_i.rf_reg\[37\]
+ _10622_ _11603_ VDD VSS OAI21_X1
X_17484_ _00339_ _10758_ _11603_ _10581_ _11604_ VDD VSS OAI22_X1
X_17485_ _11601_ _11604_ _10767_ _11605_ VDD VSS OAI21_X1
X_17486_ _00361_ _00363_ _11546_ _11606_ VDD VSS MUX2_X1
X_17487_ _00362_ _00364_ _10823_ _11607_ VDD VSS MUX2_X1
X_17488_ _11606_ _11607_ _11535_ _11608_ VDD VSS MUX2_X1
X_17489_ _00353_ _00355_ _10823_ _11609_ VDD VSS MUX2_X1
X_17490_ _00354_ _00356_ _10823_ _11610_ VDD VSS MUX2_X1
X_17491_ _11609_ _11610_ _11535_ _11611_ VDD VSS MUX2_X1
X_17492_ _11608_ _11611_ _11358_ _11612_ VDD VSS MUX2_X1
X_17493_ _00365_ _00367_ _11545_ _11613_ VDD VSS MUX2_X1
X_17494_ _10598_ _11614_ VDD VSS BUF_X4
X_17495_ _00366_ _00368_ _11614_ _11615_ VDD VSS MUX2_X1
X_17496_ _11613_ _11615_ _10594_ _11616_ VDD VSS MUX2_X1
X_17497_ _00357_ _00359_ _11614_ _11617_ VDD VSS MUX2_X1
X_17498_ _00358_ _00360_ _11614_ _11618_ VDD VSS MUX2_X1
X_17499_ _11617_ _11618_ _10594_ _11619_ VDD VSS MUX2_X1
X_17500_ _11616_ _11619_ _10569_ _11620_ VDD VSS MUX2_X1
X_17501_ _00349_ _00351_ _11614_ _11621_ VDD VSS MUX2_X1
X_17502_ _00350_ _00352_ _11614_ _11622_ VDD VSS MUX2_X1
X_17503_ _11621_ _11622_ _10594_ _11623_ VDD VSS MUX2_X1
X_17504_ _00341_ _00343_ _11614_ _11624_ VDD VSS MUX2_X1
X_17505_ _00342_ _00344_ _11372_ _11625_ VDD VSS MUX2_X1
X_17506_ _11624_ _11625_ _11375_ _11626_ VDD VSS MUX2_X1
X_17507_ _11623_ _11626_ _10569_ _11627_ VDD VSS MUX2_X1
X_17508_ _11620_ _11627_ _10783_ _11628_ VDD VSS MUX2_X1
X_17509_ _11605_ _11612_ _11371_ _11628_ _10609_ _11629_ VDD
+ VSS OAI221_X2
X_17510_ cs_registers_i.pc_id_i\[5\] _10564_ _11630_ VDD VSS
+ AND2_X1
X_17511_ id_stage_i.controller_i.lsu_addr_last_i\[5\] _10397_
+ _11596_ _11629_ _11630_ _10683_ _11631_ VDD VSS AOI222_X2
X_17512_ _11631_ _15881_ VDD VSS CLKBUF_X3
X_17513_ _10361_ _11632_ VDD VSS BUF_X4
X_17514_ _00375_ _00377_ _10618_ _11633_ VDD VSS MUX2_X1
X_17515_ _10839_ _11633_ _11634_ VDD VSS NOR2_X1
X_17516_ _00376_ _00378_ _10618_ _11635_ VDD VSS MUX2_X1
X_17517_ _10579_ _11635_ _11636_ VDD VSS NOR2_X1
X_17518_ _10568_ _11634_ _11636_ _11637_ VDD VSS NOR3_X1
X_17519_ _00369_ _11638_ VDD VSS INV_X1
X_17520_ _10584_ _11639_ VDD VSS BUF_X4
X_17521_ _11639_ gen_regfile_ff.register_file_i.rf_reg\[38\]
+ _11640_ VDD VSS NOR2_X1
X_17522_ _10856_ _11641_ VDD VSS BUF_X4
X_17523_ _11641_ _11642_ VDD VSS BUF_X4
X_17524_ _11640_ _00370_ _11642_ _11643_ VDD VSS AOI21_X1
X_17525_ _10764_ _11638_ _10821_ _11643_ _11383_ _11644_ VDD
+ VSS AOI221_X2
X_17526_ _10832_ _11637_ _11644_ _11645_ VDD VSS NOR3_X2
X_17527_ _00379_ _00381_ _10611_ _11646_ VDD VSS MUX2_X1
X_17528_ _00380_ _00382_ _10611_ _11647_ VDD VSS MUX2_X1
X_17529_ _11646_ _11647_ _10625_ _11648_ VDD VSS MUX2_X1
X_17530_ _00371_ _00373_ _10611_ _11649_ VDD VSS MUX2_X1
X_17531_ _00372_ _00374_ _10611_ _11650_ VDD VSS MUX2_X1
X_17532_ _11649_ _11650_ _10625_ _11651_ VDD VSS MUX2_X1
X_17533_ _11648_ _11651_ _10567_ _11652_ VDD VSS MUX2_X1
X_17534_ _10607_ _11652_ _11653_ VDD VSS NOR2_X1
X_17535_ _10572_ _11645_ _11653_ _11654_ VDD VSS NOR3_X2
X_17536_ _10583_ _11655_ VDD VSS BUF_X4
X_17537_ _00391_ _00393_ _11655_ _11656_ VDD VSS MUX2_X1
X_17538_ _00392_ _00394_ _11655_ _11657_ VDD VSS MUX2_X1
X_17539_ _11656_ _11657_ _10833_ _11658_ VDD VSS MUX2_X1
X_17540_ _00383_ _00385_ _11655_ _11659_ VDD VSS MUX2_X1
X_17541_ _00384_ _00386_ _11655_ _11660_ VDD VSS MUX2_X1
X_17542_ _11659_ _11660_ _10833_ _11661_ VDD VSS MUX2_X1
X_17543_ _10567_ _11662_ VDD VSS BUF_X4
X_17544_ _11658_ _11661_ _11662_ _11663_ VDD VSS MUX2_X1
X_17545_ _00395_ _00397_ _11655_ _11664_ VDD VSS MUX2_X1
X_17546_ _00396_ _00398_ _10790_ _11665_ VDD VSS MUX2_X1
X_17547_ _11664_ _11665_ _10833_ _11666_ VDD VSS MUX2_X1
X_17548_ _00387_ _00389_ _10790_ _11667_ VDD VSS MUX2_X1
X_17549_ _00388_ _00390_ _10790_ _11668_ VDD VSS MUX2_X1
X_17550_ _11667_ _11668_ _10833_ _11669_ VDD VSS MUX2_X1
X_17551_ _11666_ _11669_ _11662_ _11670_ VDD VSS MUX2_X1
X_17552_ _11663_ _11670_ _10832_ _11671_ VDD VSS MUX2_X1
X_17553_ _11654_ _11671_ _11370_ _11672_ VDD VSS AOI21_X4
X_17554_ cs_registers_i.pc_id_i\[6\] _11673_ VDD VSS INV_X1
X_17555_ _11673_ _10668_ _11674_ VDD VSS NOR2_X1
X_17556_ id_stage_i.controller_i.lsu_addr_last_i\[6\] _11632_
+ _10816_ _11672_ _11674_ _10682_ _15889_ VDD VSS AOI222_X2
X_17557_ id_stage_i.controller_i.lsu_addr_last_i\[7\] _11632_
+ _11675_ VDD VSS NAND2_X1
X_17558_ _10606_ _11676_ VDD VSS BUF_X4
X_17559_ _00421_ _00423_ _11639_ _11677_ VDD VSS MUX2_X1
X_17560_ _10584_ _11678_ VDD VSS BUF_X4
X_17561_ _00422_ _00424_ _11678_ _11679_ VDD VSS MUX2_X1
X_17562_ _11677_ _11679_ _10626_ _11680_ VDD VSS MUX2_X1
X_17563_ _00413_ _00415_ _11678_ _11681_ VDD VSS MUX2_X1
X_17564_ _00414_ _00416_ _11678_ _11682_ VDD VSS MUX2_X1
X_17565_ _11681_ _11682_ _10626_ _11683_ VDD VSS MUX2_X1
X_17566_ _11680_ _11683_ _10827_ _11684_ VDD VSS MUX2_X1
X_17567_ _11676_ _11684_ _11685_ VDD VSS NOR2_X1
X_17568_ _00425_ _00427_ _11639_ _11686_ VDD VSS MUX2_X1
X_17569_ _00426_ _00428_ _11639_ _11687_ VDD VSS MUX2_X1
X_17570_ _11686_ _11687_ _10626_ _11688_ VDD VSS MUX2_X1
X_17571_ _00417_ _00419_ _11639_ _11689_ VDD VSS MUX2_X1
X_17572_ _00418_ _00420_ _11639_ _11690_ VDD VSS MUX2_X1
X_17573_ _11689_ _11690_ _10626_ _11691_ VDD VSS MUX2_X1
X_17574_ _11688_ _11691_ _10568_ _11692_ VDD VSS MUX2_X1
X_17575_ _10608_ _11692_ _11693_ VDD VSS NOR2_X1
X_17576_ _10783_ _11685_ _11693_ _11694_ VDD VSS NOR3_X2
X_17577_ _00405_ _00407_ _10599_ _11695_ VDD VSS MUX2_X1
X_17578_ _10796_ _11695_ _11696_ VDD VSS NOR2_X1
X_17579_ _00406_ _00408_ _11372_ _11697_ VDD VSS MUX2_X1
X_17580_ _10579_ _11697_ _11698_ VDD VSS NOR2_X1
X_17581_ _11357_ _11696_ _11698_ _11699_ VDD VSS NOR3_X1
X_17582_ _00399_ _11700_ VDD VSS INV_X1
X_17583_ _11642_ gen_regfile_ff.register_file_i.rf_reg\[39\]
+ _11701_ VDD VSS NOR2_X1
X_17584_ _11701_ _00400_ _11568_ _11702_ VDD VSS AOI21_X1
X_17585_ _10765_ _11700_ _10822_ _11702_ _10839_ _11703_ VDD
+ VSS AOI221_X2
X_17586_ _11676_ _11699_ _11703_ _11704_ VDD VSS NOR3_X1
X_17587_ _00409_ _00411_ _10598_ _11705_ VDD VSS MUX2_X1
X_17588_ _00410_ _00412_ _10598_ _11706_ VDD VSS MUX2_X1
X_17589_ _11705_ _11706_ _11383_ _11707_ VDD VSS MUX2_X1
X_17590_ _00401_ _00403_ _10598_ _11708_ VDD VSS MUX2_X1
X_17591_ _00402_ _00404_ _10598_ _11709_ VDD VSS MUX2_X1
X_17592_ _11708_ _11709_ _11383_ _11710_ VDD VSS MUX2_X1
X_17593_ _11707_ _11710_ _10568_ _11711_ VDD VSS MUX2_X1
X_17594_ _10608_ _11711_ _11712_ VDD VSS NOR2_X1
X_17595_ _11370_ _11704_ _11712_ _11713_ VDD VSS NOR3_X2
X_17596_ _11694_ _11713_ _11714_ VDD VSS OR2_X2
X_17597_ cs_registers_i.pc_id_i\[7\] _10564_ _11715_ VDD VSS
+ NAND2_X1
X_17598_ _11675_ _11714_ _10814_ _11715_ _10747_ _11716_ VDD
+ VSS OAI221_X1
X_17599_ _11716_ _15893_ VDD VSS CLKBUF_X3
X_17600_ _15893_ _15897_ VDD VSS INV_X1
X_17601_ _15398_ _11717_ VDD VSS BUF_X2
X_17602_ _15385_ _11718_ VDD VSS INV_X1
X_17603_ _15371_ _14067_ _10815_ _11719_ VDD VSS AOI21_X2
X_17604_ _15378_ _11720_ VDD VSS BUF_X2
X_17605_ _15382_ _11721_ VDD VSS BUF_X4
X_17606_ _15386_ _11722_ VDD VSS BUF_X2
X_17607_ _11720_ _11721_ _11722_ _11723_ VDD VSS NAND3_X1
X_17608_ _15381_ _15377_ _11721_ _11724_ VDD VSS AOI21_X2
X_17609_ _11722_ _11725_ VDD VSS INV_X1
X_17610_ _11718_ _11723_ _11719_ _11724_ _11725_ _11726_ VDD
+ VSS OAI221_X2
X_17611_ _15390_ _11727_ VDD VSS BUF_X1
X_17612_ _15389_ _11726_ _11727_ _11728_ VDD VSS AOI21_X1
X_17613_ _11728_ _11729_ VDD VSS INV_X1
X_17614_ _15394_ _11730_ VDD VSS BUF_X2
X_17615_ _15393_ _11729_ _11730_ _11731_ VDD VSS AOI21_X2
X_17616_ _11717_ _11731_ alu_adder_result_ex\[7\] VDD VSS
+ XNOR2_X2
X_17617_ _15389_ _11732_ VDD VSS INV_X1
X_17618_ _11724_ _11733_ VDD VSS INV_X1
X_17619_ _15385_ _11733_ _11722_ _11734_ VDD VSS AOI21_X1
X_17620_ _11727_ _11735_ VDD VSS INV_X1
X_17621_ _11732_ _11734_ _11735_ _11736_ VDD VSS OAI21_X1
X_17622_ _11720_ _11721_ _11737_ VDD VSS NAND2_X1
X_17623_ _11722_ _11727_ _11738_ VDD VSS NAND2_X1
X_17624_ _15371_ _15373_ _10815_ _11739_ VDD VSS AOI21_X2
X_17625_ _11737_ _11738_ _11739_ _11740_ VDD VSS NOR3_X1
X_17626_ _11736_ _11740_ _11741_ VDD VSS NOR2_X1
X_17627_ _11730_ _11741_ _11742_ VDD VSS XNOR2_X1
X_17628_ _11737_ _11738_ _11743_ VDD VSS NOR2_X1
X_17629_ _15374_ _10815_ _11744_ VDD VSS NAND2_X2
X_17630_ _11739_ _11744_ _11745_ VDD VSS NAND2_X1
X_17631_ _11736_ _11743_ _11745_ _11746_ VDD VSS AOI21_X1
X_17632_ _11730_ _11746_ _11747_ VDD VSS XNOR2_X1
X_17633_ _11742_ _11747_ _14064_ _11748_ VDD VSS MUX2_X1
X_17634_ _11748_ alu_adder_result_ex\[6\] VDD VSS BUF_X4
X_17635_ id_stage_i.controller_i.lsu_addr_last_i\[8\] _11632_
+ _11749_ VDD VSS NAND2_X1
X_17636_ _00455_ _00457_ _10585_ _11750_ VDD VSS MUX2_X1
X_17637_ _00456_ _00458_ _10585_ _11751_ VDD VSS MUX2_X1
X_17638_ _11750_ _11751_ _10786_ _11752_ VDD VSS MUX2_X1
X_17639_ _00447_ _00449_ _10585_ _11753_ VDD VSS MUX2_X1
X_17640_ _00448_ _00450_ _10585_ _11754_ VDD VSS MUX2_X1
X_17641_ _11753_ _11754_ _10786_ _11755_ VDD VSS MUX2_X1
X_17642_ _11752_ _11755_ _10827_ _11756_ VDD VSS MUX2_X1
X_17643_ _11676_ _11756_ _11757_ VDD VSS NAND2_X1
X_17644_ _00451_ _00453_ _11545_ _11758_ VDD VSS MUX2_X1
X_17645_ _00452_ _00454_ _11545_ _11759_ VDD VSS MUX2_X1
X_17646_ _11758_ _11759_ _10594_ _11760_ VDD VSS MUX2_X1
X_17647_ _00445_ _00446_ _10843_ _11761_ VDD VSS MUX2_X1
X_17648_ _00443_ _00444_ _10795_ _11762_ VDD VSS MUX2_X1
X_17649_ _10643_ _11760_ _11761_ _10794_ _11762_ _10785_ _11763_
+ VDD VSS AOI222_X2
X_17650_ _10783_ _11757_ _11763_ _11764_ VDD VSS AOI21_X4
X_17651_ _00435_ _00437_ _11362_ _11765_ VDD VSS MUX2_X1
X_17652_ _11534_ _11765_ _11766_ VDD VSS NOR2_X1
X_17653_ _00436_ _00438_ _11362_ _11767_ VDD VSS MUX2_X1
X_17654_ _10579_ _11767_ _11768_ VDD VSS NOR2_X1
X_17655_ _10827_ _11766_ _11768_ _11769_ VDD VSS NOR3_X1
X_17656_ _11567_ gen_regfile_ff.register_file_i.rf_reg\[40\]
+ _11770_ VDD VSS NOR2_X1
X_17657_ _11639_ _11771_ VDD VSS BUF_X4
X_17658_ _11770_ _00430_ _11771_ _11772_ VDD VSS AOI21_X1
X_17659_ _10765_ _11226_ _10822_ _11772_ _10795_ _11773_ VDD
+ VSS AOI221_X2
X_17660_ _10832_ _11769_ _11773_ _11774_ VDD VSS NOR3_X2
X_17661_ _10607_ _11775_ VDD VSS BUF_X4
X_17662_ _10856_ _11776_ VDD VSS BUF_X4
X_17663_ _00439_ _00441_ _11776_ _11777_ VDD VSS MUX2_X1
X_17664_ _10856_ _11778_ VDD VSS BUF_X4
X_17665_ _00440_ _00442_ _11778_ _11779_ VDD VSS MUX2_X1
X_17666_ _11777_ _11779_ _10839_ _11780_ VDD VSS MUX2_X1
X_17667_ _00431_ _00433_ _11778_ _11781_ VDD VSS MUX2_X1
X_17668_ _00432_ _00434_ _11778_ _11782_ VDD VSS MUX2_X1
X_17669_ _11781_ _11782_ _10839_ _11783_ VDD VSS MUX2_X1
X_17670_ _11780_ _11783_ _11662_ _11784_ VDD VSS MUX2_X1
X_17671_ _11775_ _11784_ _11785_ VDD VSS NOR2_X1
X_17672_ _11370_ _11774_ _11785_ _11786_ VDD VSS NOR3_X4
X_17673_ _11764_ _11786_ _11787_ VDD VSS OR2_X2
X_17674_ cs_registers_i.pc_id_i\[8\] _11788_ VDD VSS CLKBUF_X2
X_17675_ _11788_ _10564_ _11789_ VDD VSS NAND2_X1
X_17676_ _11749_ _11787_ _10814_ _11789_ _10747_ _15901_ VDD
+ VSS OAI221_X2
X_17677_ _15901_ _15905_ VDD VSS INV_X2
X_17678_ id_stage_i.controller_i.lsu_addr_last_i\[9\] _11632_
+ _11790_ VDD VSS NAND2_X1
X_17679_ _00465_ _00467_ _11567_ _11791_ VDD VSS MUX2_X1
X_17680_ _10862_ _11791_ _11792_ VDD VSS NOR2_X1
X_17681_ _00466_ _00468_ _10618_ _11793_ VDD VSS MUX2_X1
X_17682_ _10579_ _11793_ _11794_ VDD VSS NOR2_X1
X_17683_ _10568_ _11792_ _11794_ _11795_ VDD VSS NOR3_X1
X_17684_ _11639_ gen_regfile_ff.register_file_i.rf_reg\[41\]
+ _11796_ VDD VSS NOR2_X1
X_17685_ _11796_ _00460_ _11642_ _11797_ VDD VSS AOI21_X1
X_17686_ _10764_ _11273_ _10821_ _11797_ _10626_ _11798_ VDD
+ VSS AOI221_X2
X_17687_ _10832_ _11795_ _11798_ _11799_ VDD VSS NOR3_X1
X_17688_ _00469_ _00471_ _10611_ _11800_ VDD VSS MUX2_X1
X_17689_ _00470_ _00472_ _10611_ _11801_ VDD VSS MUX2_X1
X_17690_ _11800_ _11801_ _10625_ _11802_ VDD VSS MUX2_X1
X_17691_ _00461_ _00463_ _10611_ _11803_ VDD VSS MUX2_X1
X_17692_ _00462_ _00464_ _10611_ _11804_ VDD VSS MUX2_X1
X_17693_ _11803_ _11804_ _10625_ _11805_ VDD VSS MUX2_X1
X_17694_ _11802_ _11805_ _10567_ _11806_ VDD VSS MUX2_X1
X_17695_ _11775_ _11806_ _11807_ VDD VSS NOR2_X1
X_17696_ _11370_ _11799_ _11807_ _11808_ VDD VSS NOR3_X2
X_17697_ _00481_ _00483_ _11776_ _11809_ VDD VSS MUX2_X1
X_17698_ _00482_ _00484_ _11776_ _11810_ VDD VSS MUX2_X1
X_17699_ _11809_ _11810_ _10839_ _11811_ VDD VSS MUX2_X1
X_17700_ _00473_ _00475_ _11776_ _11812_ VDD VSS MUX2_X1
X_17701_ _00474_ _00476_ _11776_ _11813_ VDD VSS MUX2_X1
X_17702_ _11812_ _11813_ _10839_ _11814_ VDD VSS MUX2_X1
X_17703_ _11811_ _11814_ _11662_ _11815_ VDD VSS MUX2_X1
X_17704_ _00485_ _00487_ _11776_ _11816_ VDD VSS MUX2_X1
X_17705_ _00486_ _00488_ _11778_ _11817_ VDD VSS MUX2_X1
X_17706_ _11816_ _11817_ _10839_ _11818_ VDD VSS MUX2_X1
X_17707_ _00477_ _00479_ _11776_ _11819_ VDD VSS MUX2_X1
X_17708_ _00478_ _00480_ _11778_ _11820_ VDD VSS MUX2_X1
X_17709_ _11819_ _11820_ _10839_ _11821_ VDD VSS MUX2_X1
X_17710_ _11818_ _11821_ _11662_ _11822_ VDD VSS MUX2_X1
X_17711_ _11815_ _11822_ _10832_ _11823_ VDD VSS MUX2_X1
X_17712_ _11808_ _11823_ _10749_ _11824_ VDD VSS AOI21_X4
X_17713_ _11824_ _11825_ VDD VSS INV_X1
X_17714_ cs_registers_i.pc_id_i\[9\] _11826_ VDD VSS BUF_X1
X_17715_ _11826_ _10564_ _11827_ VDD VSS NAND2_X1
X_17716_ _11790_ _11825_ _10814_ _11827_ _10747_ _15909_ VDD
+ VSS OAI221_X2
X_17717_ _15909_ _15913_ VDD VSS INV_X2
X_17718_ _15406_ _11828_ VDD VSS BUF_X2
X_17719_ _15401_ _11829_ VDD VSS INV_X1
X_17720_ _11717_ _11727_ _11730_ _11830_ VDD VSS AND3_X1
X_17721_ _15393_ _15389_ _11730_ _11831_ VDD VSS AOI21_X1
X_17722_ _11831_ _11832_ VDD VSS INV_X1
X_17723_ _15397_ _11726_ _11830_ _11832_ _11717_ _11833_ VDD
+ VSS AOI221_X2
X_17724_ _15402_ _11834_ VDD VSS BUF_X2
X_17725_ _11834_ _11835_ VDD VSS INV_X1
X_17726_ _11829_ _11833_ _11835_ _11836_ VDD VSS OAI21_X1
X_17727_ _11828_ _11836_ alu_adder_result_ex\[9\] VDD VSS
+ XOR2_X2
X_17728_ _11717_ _11730_ _11837_ VDD VSS AND2_X1
X_17729_ _11737_ _11744_ _11838_ VDD VSS NOR2_X4
X_17730_ _11722_ _11727_ _11837_ _11838_ _11839_ VDD VSS AND4_X4
X_17731_ _11834_ _11839_ _11840_ VDD VSS NOR2_X1
X_17732_ _15377_ _11841_ VDD VSS INV_X1
X_17733_ _11720_ _11842_ VDD VSS INV_X1
X_17734_ _11841_ _11739_ _11842_ _11843_ VDD VSS OAI21_X1
X_17735_ _15381_ _11843_ _11721_ _11844_ VDD VSS AOI21_X2
X_17736_ _10873_ _10514_ _10917_ _11838_ _11845_ VDD VSS NAND4_X1
X_17737_ _11738_ _11844_ _11845_ _11846_ VDD VSS AOI21_X2
X_17738_ _11732_ _11718_ _11735_ _11847_ VDD VSS OAI21_X2
X_17739_ _11837_ _11846_ _11847_ _11848_ VDD VSS OAI21_X4
X_17740_ _15397_ _15393_ _11717_ _11849_ VDD VSS AOI21_X2
X_17741_ _11848_ _11849_ _11850_ VDD VSS AND2_X1
X_17742_ _11834_ _11840_ _11850_ _11851_ VDD VSS MUX2_X1
X_17743_ _11476_ _11482_ _11484_ _11852_ VDD VSS AND3_X1
X_17744_ _11486_ _11482_ _11487_ _11853_ VDD VSS NOR3_X1
X_17745_ _11852_ _11853_ _11500_ _11854_ VDD VSS MUX2_X2
X_17746_ _11834_ _11839_ _11855_ VDD VSS NAND2_X1
X_17747_ _11503_ _11482_ _11856_ VDD VSS NAND2_X1
X_17748_ _11505_ _11482_ _11508_ _11857_ VDD VSS NAND3_X2
X_17749_ _11856_ _11857_ _11512_ _11858_ VDD VSS MUX2_X2
X_17750_ _11854_ _11855_ _11858_ _11487_ _11859_ VDD VSS AOI211_X2
X_17751_ _11848_ _11849_ _11860_ VDD VSS NAND2_X2
X_17752_ _11834_ _11860_ _11861_ VDD VSS NOR2_X1
X_17753_ _11484_ _11862_ VDD VSS BUF_X4
X_17754_ _11501_ _11862_ _11513_ _11863_ VDD VSS OAI21_X4
X_17755_ _11851_ _11859_ _11861_ _11863_ alu_adder_result_ex\[8\]
+ VDD VSS AOI211_X4
X_17756_ cs_registers_i.pc_id_i\[10\] _11593_ _11864_ VDD
+ VSS AND2_X1
X_17757_ id_stage_i.controller_i.lsu_addr_last_i\[10\] _10741_
+ _10870_ _11864_ _11865_ VDD VSS AOI22_X2
X_17758_ _00495_ _00497_ _10587_ _11866_ VDD VSS MUX2_X1
X_17759_ _00496_ _00498_ _10587_ _11867_ VDD VSS MUX2_X1
X_17760_ _11866_ _11867_ _10788_ _11868_ VDD VSS MUX2_X1
X_17761_ _10831_ _11868_ _10766_ _11869_ VDD VSS AOI21_X1
X_17762_ _10615_ _00490_ _11870_ VDD VSS NAND2_X1
X_17763_ _11870_ gen_regfile_ff.register_file_i.rf_reg\[42\]
+ _10589_ _11871_ VDD VSS OAI21_X1
X_17764_ _00489_ _10758_ _11871_ _10581_ _11872_ VDD VSS OAI22_X1
X_17765_ _11869_ _11872_ _11533_ _11873_ VDD VSS OAI21_X1
X_17766_ _11362_ _11874_ VDD VSS BUF_X4
X_17767_ _00511_ _00513_ _11874_ _11875_ VDD VSS MUX2_X1
X_17768_ _00512_ _00514_ _11363_ _11876_ VDD VSS MUX2_X1
X_17769_ _10843_ _11877_ VDD VSS BUF_X4
X_17770_ _11875_ _11876_ _11877_ _11878_ VDD VSS MUX2_X1
X_17771_ _00503_ _00505_ _11363_ _11879_ VDD VSS MUX2_X1
X_17772_ _00504_ _00506_ _11363_ _11880_ VDD VSS MUX2_X1
X_17773_ _11879_ _11880_ _11366_ _11881_ VDD VSS MUX2_X1
X_17774_ _11878_ _11881_ _11358_ _11882_ VDD VSS MUX2_X1
X_17775_ _00515_ _00517_ _10791_ _11883_ VDD VSS MUX2_X1
X_17776_ _00516_ _00518_ _10791_ _11884_ VDD VSS MUX2_X1
X_17777_ _11883_ _11884_ _10839_ _11885_ VDD VSS MUX2_X1
X_17778_ _00507_ _00509_ _10791_ _11886_ VDD VSS MUX2_X1
X_17779_ _00508_ _00510_ _10791_ _11887_ VDD VSS MUX2_X1
X_17780_ _11886_ _11887_ _10839_ _11888_ VDD VSS MUX2_X1
X_17781_ _11885_ _11888_ _11357_ _11889_ VDD VSS MUX2_X1
X_17782_ _00499_ _00501_ _10791_ _11890_ VDD VSS MUX2_X1
X_17783_ _00500_ _00502_ _10791_ _11891_ VDD VSS MUX2_X1
X_17784_ _11890_ _11891_ _10839_ _11892_ VDD VSS MUX2_X1
X_17785_ _00491_ _00493_ _10791_ _11893_ VDD VSS MUX2_X1
X_17786_ _00492_ _00494_ _10791_ _11894_ VDD VSS MUX2_X1
X_17787_ _11893_ _11894_ _10839_ _11895_ VDD VSS MUX2_X1
X_17788_ _11892_ _11895_ _11357_ _11896_ VDD VSS MUX2_X1
X_17789_ _11889_ _11896_ _10575_ _11897_ VDD VSS MUX2_X1
X_17790_ _11873_ _11882_ _11371_ _10609_ _11897_ _11898_ VDD
+ VSS OAI221_X2
X_17791_ _11898_ _11899_ VDD VSS INV_X1
X_17792_ _11865_ _11899_ _10814_ _15917_ VDD VSS OAI21_X2
X_17793_ _15917_ _15921_ VDD VSS INV_X2
X_17794_ _15414_ _11900_ VDD VSS BUF_X2
X_17795_ _15409_ _11901_ VDD VSS CLKBUF_X2
X_17796_ _15410_ _11902_ VDD VSS CLKBUF_X2
X_17797_ _11902_ _11903_ VDD VSS INV_X1
X_17798_ _15405_ _15401_ _11828_ _11904_ VDD VSS AOI21_X2
X_17799_ _11834_ _11828_ _11905_ VDD VSS NAND2_X2
X_17800_ _11903_ _11904_ _11905_ _11906_ VDD VSS AOI21_X1
X_17801_ _11900_ _11901_ _11906_ _11907_ VDD VSS OAI21_X2
X_17802_ _11901_ _11908_ VDD VSS INV_X1
X_17803_ _11908_ _11904_ _11909_ VDD VSS AND2_X1
X_17804_ _11907_ _11833_ _11909_ _11910_ VDD VSS AOI21_X4
X_17805_ _11900_ _11901_ _11911_ VDD VSS NOR2_X1
X_17806_ _11904_ _11905_ _11833_ _11912_ VDD VSS OAI21_X1
X_17807_ _11902_ _11912_ _11913_ VDD VSS NAND2_X1
X_17808_ _11910_ _11911_ _11913_ alu_adder_result_ex\[11\]
+ VDD VSS AOI21_X4
X_17809_ _11829_ _11849_ _11835_ _11914_ VDD VSS OAI21_X1
X_17810_ _15405_ _11914_ _11828_ _11915_ VDD VSS AOI21_X2
X_17811_ _11915_ _11905_ _11848_ _11916_ VDD VSS OAI21_X4
X_17812_ _11834_ _11828_ _11839_ _11917_ VDD VSS NAND3_X1
X_17813_ _11487_ _11918_ VDD VSS BUF_X4
X_17814_ _11854_ _11917_ _11858_ _11918_ _11919_ VDD VSS AOI211_X2
X_17815_ _11916_ _11919_ _11920_ VDD VSS NOR2_X1
X_17816_ _11920_ _11902_ alu_adder_result_ex\[10\] VDD VSS
+ XNOR2_X2
X_17817_ _10673_ _11921_ VDD VSS CLKBUF_X3
X_17818_ _11921_ _11922_ VDD VSS BUF_X4
X_17819_ _10510_ _10374_ net250 _11923_ VDD VSS NOR3_X2
X_17820_ _10386_ _11320_ _11923_ _11924_ VDD VSS OAI21_X2
X_17821_ _10317_ _11924_ _11925_ VDD VSS NAND2_X4
X_17822_ _11073_ _10928_ _10926_ _11926_ VDD VSS MUX2_X2
X_17823_ _10346_ _10398_ _11926_ _11927_ VDD VSS NOR3_X1
X_17824_ _10709_ _11928_ VDD VSS BUF_X8
X_17825_ _11928_ _11929_ VDD VSS BUF_X8
X_17826_ _10432_ _11930_ VDD VSS BUF_X4
X_17827_ _10421_ _11931_ VDD VSS BUF_X4
X_17828_ _11931_ _11932_ VDD VSS BUF_X4
X_17829_ _10466_ _11933_ VDD VSS BUF_X16
X_17830_ _11933_ _11934_ VDD VSS BUF_X16
X_17831_ _11934_ _11935_ VDD VSS BUF_X8
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
X_17833_ _10459_ _11937_ VDD VSS BUF_X32
X_17834_ net363 _11938_ VDD VSS BUF_X32
X_17835_ _11938_ _11939_ VDD VSS BUF_X4
X_17836_ _00224_ _00226_ _11939_ _11940_ VDD VSS MUX2_X1
X_17837_ _11935_ _11940_ _11941_ VDD VSS NOR2_X1
X_17838_ _10697_ _11942_ VDD VSS BUF_X4
X_17839_ _10459_ _11943_ VDD VSS BUF_X8
X_17840_ _11943_ _11944_ VDD VSS BUF_X4
X_17841_ _00225_ _00227_ _11944_ _11945_ VDD VSS MUX2_X1
X_17842_ _11942_ _11945_ _11946_ VDD VSS NOR2_X1
X_17843_ _11932_ _11941_ _11946_ _11947_ VDD VSS NOR3_X2
X_17844_ _10468_ _11948_ VDD VSS BUF_X4
X_17845_ _10964_ _11949_ VDD VSS BUF_X4
X_17846_ _11944_ gen_regfile_ff.register_file_i.rf_reg\[44\]
+ _11950_ VDD VSS NOR2_X1
X_17847_ _10459_ _11951_ VDD VSS BUF_X32
X_17848_ _11951_ _11952_ VDD VSS BUF_X8
X_17849_ _11952_ _11953_ VDD VSS BUF_X4
X_17850_ _11950_ _00219_ _11953_ _11954_ VDD VSS AOI21_X1
X_17851_ _10466_ _11955_ VDD VSS BUF_X4
X_17852_ _11955_ _11956_ VDD VSS BUF_X4
X_17853_ _11948_ _10820_ _11949_ _11954_ _11956_ _11957_ VDD
+ VSS AOI221_X2
X_17854_ _11930_ _11947_ _11957_ _11958_ VDD VSS NOR3_X2
X_17855_ _10436_ _11959_ VDD VSS BUF_X4
X_17856_ _10459_ _11960_ VDD VSS BUF_X4
X_17857_ _00228_ _00230_ _11960_ _11961_ VDD VSS MUX2_X1
X_17858_ _10459_ _11962_ VDD VSS BUF_X4
X_17859_ _00229_ _00231_ _11962_ _11963_ VDD VSS MUX2_X1
X_17860_ _10466_ _11964_ VDD VSS BUF_X4
X_17861_ _11961_ _11963_ _11964_ _11965_ VDD VSS MUX2_X1
X_17862_ _00220_ _00222_ _11962_ _11966_ VDD VSS MUX2_X1
X_17863_ _00221_ _00223_ _11962_ _11967_ VDD VSS MUX2_X1
X_17864_ _11966_ _11967_ _11964_ _11968_ VDD VSS MUX2_X1
X_17865_ _11931_ _11969_ VDD VSS BUF_X4
X_17866_ _11965_ _11968_ _11969_ _11970_ VDD VSS MUX2_X1
X_17867_ _11959_ _11970_ _11971_ VDD VSS NOR2_X1
X_17868_ _11929_ _11958_ _11971_ _11972_ VDD VSS NOR3_X4
X_17869_ _00240_ _00242_ _11952_ _11973_ VDD VSS MUX2_X1
X_17870_ _00241_ _00243_ _11952_ _11974_ VDD VSS MUX2_X1
X_17871_ _11933_ _11975_ VDD VSS BUF_X8
X_17872_ _11973_ _11974_ _11975_ _11976_ VDD VSS MUX2_X1
X_17873_ _00232_ _00234_ _11952_ _11977_ VDD VSS MUX2_X1
X_17874_ _11951_ _11978_ VDD VSS BUF_X4
X_17875_ _00233_ _00235_ _11978_ _11979_ VDD VSS MUX2_X1
X_17876_ _11977_ _11979_ _11975_ _11980_ VDD VSS MUX2_X1
X_17877_ _11976_ _11980_ _11932_ _11981_ VDD VSS MUX2_X1
X_17878_ _00244_ _00246_ _11952_ _11982_ VDD VSS MUX2_X1
X_17879_ _00245_ _00247_ _11978_ _11983_ VDD VSS MUX2_X1
X_17880_ _11982_ _11983_ _11975_ _11984_ VDD VSS MUX2_X1
X_17881_ _00236_ _00238_ _11978_ _11985_ VDD VSS MUX2_X1
X_17882_ _00237_ _00239_ _11978_ _11986_ VDD VSS MUX2_X1
X_17883_ _11985_ _11986_ _11975_ _11987_ VDD VSS MUX2_X1
X_17884_ _11984_ _11987_ _11932_ _11988_ VDD VSS MUX2_X1
X_17885_ _10432_ _11989_ VDD VSS BUF_X8
X_17886_ _11981_ _11988_ _11989_ _11990_ VDD VSS MUX2_X1
X_17887_ _11928_ _11991_ VDD VSS BUF_X8
X_17888_ _11991_ _11992_ VDD VSS BUF_X8
X_17889_ _11972_ _11992_ _11990_ _11993_ VDD VSS AOI21_X4
X_17890_ _10317_ _11994_ VDD VSS CLKBUF_X3
X_17891_ _11994_ _11995_ VDD VSS BUF_X4
X_17892_ _11922_ _11925_ _11927_ _11995_ _11993_ _15937_ VDD
+ VSS OAI221_X2
X_17893_ net301 _15933_ VDD VSS INV_X1
X_17894_ _10380_ _10398_ _11926_ _11996_ VDD VSS NOR3_X2
X_17895_ _11951_ _11997_ VDD VSS BUF_X8
X_17896_ _00589_ _00591_ _11997_ _11998_ VDD VSS MUX2_X1
X_17897_ _00590_ _00592_ _11997_ _11999_ VDD VSS MUX2_X1
X_17898_ _11933_ _12000_ VDD VSS BUF_X8
X_17899_ _11998_ _11999_ _12000_ _12001_ VDD VSS MUX2_X1
X_17900_ _00581_ _00583_ _11997_ _12002_ VDD VSS MUX2_X1
X_17901_ _00582_ _00584_ _11997_ _12003_ VDD VSS MUX2_X1
X_17902_ _12002_ _12003_ _12000_ _12004_ VDD VSS MUX2_X1
X_17903_ _11931_ _12005_ VDD VSS BUF_X4
X_17904_ _12001_ _12004_ _12005_ _12006_ VDD VSS MUX2_X1
X_17905_ _11989_ _12006_ _12007_ VDD VSS NOR2_X2
X_17906_ _11937_ _12008_ VDD VSS BUF_X8
X_17907_ _00593_ _00595_ _12008_ _12009_ VDD VSS MUX2_X1
X_17908_ _11937_ _12010_ VDD VSS BUF_X16
X_17909_ _00594_ _00596_ _12010_ _12011_ VDD VSS MUX2_X1
X_17910_ _11933_ _12012_ VDD VSS BUF_X16
X_17911_ _12009_ _12011_ _12012_ _12013_ VDD VSS MUX2_X1
X_17912_ _00585_ _00587_ _12010_ _12014_ VDD VSS MUX2_X1
X_17913_ _00586_ _00588_ _12010_ _12015_ VDD VSS MUX2_X1
X_17914_ _12014_ _12015_ _12012_ _12016_ VDD VSS MUX2_X1
X_17915_ _11931_ _12017_ VDD VSS BUF_X4
X_17916_ _12013_ _12016_ _12017_ _12018_ VDD VSS MUX2_X1
X_17917_ _11959_ _12018_ _12019_ VDD VSS NOR2_X2
X_17918_ _10474_ _12007_ _12019_ _12020_ VDD VSS NOR3_X2
X_17919_ _11951_ _12021_ VDD VSS BUF_X16
X_17920_ _00577_ _00579_ _12021_ _12022_ VDD VSS MUX2_X1
X_17921_ _11951_ _12023_ VDD VSS BUF_X8
X_17922_ _00578_ _00580_ _12023_ _12024_ VDD VSS MUX2_X1
X_17923_ _12022_ _12024_ _11934_ _12025_ VDD VSS MUX2_X1
X_17924_ _00569_ _00571_ _12023_ _12026_ VDD VSS MUX2_X1
X_17925_ _00570_ _00572_ _12023_ _12027_ VDD VSS MUX2_X1
X_17926_ _12026_ _12027_ _11934_ _12028_ VDD VSS MUX2_X1
X_17927_ _11931_ _12029_ VDD VSS BUF_X4
X_17928_ _12025_ _12028_ _12029_ _12030_ VDD VSS MUX2_X1
X_17929_ _11959_ _12030_ _12031_ VDD VSS NOR2_X1
X_17930_ _00567_ _12032_ VDD VSS INV_X1
X_17931_ _11953_ gen_regfile_ff.register_file_i.rf_reg\[45\]
+ _12033_ VDD VSS NOR2_X1
X_17932_ _11939_ _12034_ VDD VSS BUF_X4
X_17933_ _12033_ _00568_ _12034_ _12035_ VDD VSS AOI21_X1
X_17934_ _11948_ _12032_ _11949_ _12035_ _11956_ _12036_ VDD
+ VSS AOI221_X2
X_17935_ _11944_ _12037_ VDD VSS BUF_X4
X_17936_ _00573_ _00575_ _12037_ _12038_ VDD VSS MUX2_X1
X_17937_ _00574_ _00576_ _12037_ _12039_ VDD VSS MUX2_X1
X_17938_ _12038_ _12039_ _11935_ _12040_ VDD VSS MUX2_X1
X_17939_ _11948_ _12041_ VDD VSS BUF_X8
X_17940_ _12036_ _12040_ _12041_ _12042_ VDD VSS AOI21_X1
X_17941_ _12031_ _12042_ _11959_ _12043_ VDD VSS AOI21_X2
X_17942_ _12020_ _12043_ _10474_ _12044_ VDD VSS AOI21_X4
X_17943_ _11922_ _11925_ _11996_ _11995_ _12044_ _15945_ VDD
+ VSS OAI221_X2
X_17944_ _15945_ _15941_ VDD VSS INV_X1
X_17945_ _10621_ _00568_ _12045_ VDD VSS NAND2_X1
X_17946_ _12045_ gen_regfile_ff.register_file_i.rf_reg\[45\]
+ _10602_ _12046_ VDD VSS OAI21_X1
X_17947_ _10570_ _00567_ _10757_ _12046_ _10580_ _12047_ VDD
+ VSS OAI221_X1
X_17948_ _00573_ _00575_ _11546_ _12048_ VDD VSS MUX2_X1
X_17949_ _00574_ _00576_ _10823_ _12049_ VDD VSS MUX2_X1
X_17950_ _12048_ _12049_ _11535_ _12050_ VDD VSS MUX2_X1
X_17951_ _10831_ _12050_ _10766_ _12051_ VDD VSS AOI21_X1
X_17952_ _12047_ _12051_ _12052_ VDD VSS NAND2_X1
X_17953_ _00589_ _00591_ _10585_ _12053_ VDD VSS MUX2_X1
X_17954_ _00590_ _00592_ _10585_ _12054_ VDD VSS MUX2_X1
X_17955_ _12053_ _12054_ _10787_ _12055_ VDD VSS MUX2_X1
X_17956_ _00581_ _00583_ _10619_ _12056_ VDD VSS MUX2_X1
X_17957_ _00582_ _00584_ _10619_ _12057_ VDD VSS MUX2_X1
X_17958_ _12056_ _12057_ _10787_ _12058_ VDD VSS MUX2_X1
X_17959_ _12055_ _12058_ _10828_ _12059_ VDD VSS MUX2_X1
X_17960_ _00593_ _00595_ _11639_ _12060_ VDD VSS MUX2_X1
X_17961_ _00594_ _00596_ _11678_ _12061_ VDD VSS MUX2_X1
X_17962_ _12060_ _12061_ _10626_ _12062_ VDD VSS MUX2_X1
X_17963_ _00585_ _00587_ _11678_ _12063_ VDD VSS MUX2_X1
X_17964_ _00586_ _00588_ _11678_ _12064_ VDD VSS MUX2_X1
X_17965_ _12063_ _12064_ _10626_ _12065_ VDD VSS MUX2_X1
X_17966_ _12062_ _12065_ _10827_ _12066_ VDD VSS MUX2_X1
X_17967_ _00577_ _00579_ _11678_ _12067_ VDD VSS MUX2_X1
X_17968_ _00578_ _00580_ _11678_ _12068_ VDD VSS MUX2_X1
X_17969_ _12067_ _12068_ _10626_ _12069_ VDD VSS MUX2_X1
X_17970_ _00569_ _00571_ _11678_ _12070_ VDD VSS MUX2_X1
X_17971_ _00570_ _00572_ _11678_ _12071_ VDD VSS MUX2_X1
X_17972_ _12070_ _12071_ _10786_ _12072_ VDD VSS MUX2_X1
X_17973_ _12069_ _12072_ _10827_ _12073_ VDD VSS MUX2_X1
X_17974_ _12066_ _12073_ _10574_ _12074_ VDD VSS MUX2_X1
X_17975_ _12052_ _12059_ _11371_ _12074_ _10609_ _12075_ VDD
+ VSS OAI221_X2
X_17976_ cs_registers_i.pc_id_i\[13\] _12076_ VDD VSS BUF_X1
X_17977_ _12076_ _11593_ _12077_ VDD VSS AND2_X1
X_17978_ id_stage_i.controller_i.lsu_addr_last_i\[13\] _10397_
+ _10816_ _12075_ _12077_ _10870_ _12078_ VDD VSS AOI222_X2
X_17979_ _12078_ _15944_ VDD VSS BUF_X4
X_17980_ _15422_ _12079_ VDD VSS CLKBUF_X2
X_17981_ _12079_ _12080_ VDD VSS INV_X2
X_17982_ _15417_ _12081_ VDD VSS INV_X1
Xrebuffer111 _15418_ net382 VDD VSS BUF_X4
X_17984_ _15413_ _12083_ VDD VSS BUF_X1
X_17985_ _15418_ _12083_ _11910_ _12084_ VDD VSS OAI21_X1
X_17986_ _12081_ _12084_ _12085_ VDD VSS NAND2_X1
X_17987_ _12080_ _12085_ alu_adder_result_ex\[13\] VDD VSS
+ XNOR2_X2
X_17988_ _11902_ _11900_ _12086_ VDD VSS NAND2_X1
X_17989_ _11905_ _12086_ _12087_ VDD VSS NOR2_X2
X_17990_ net382 _11860_ _12087_ _12088_ VDD VSS NAND3_X1
X_17991_ _11908_ _11904_ _11903_ _12089_ VDD VSS OAI21_X1
X_17992_ _11900_ _12089_ _12090_ VDD VSS AND2_X1
X_17993_ _12083_ _12090_ _12091_ VDD VSS OR2_X1
X_17994_ net382 _11839_ _12091_ _12092_ VDD VSS OR3_X1
X_17995_ net382 _11839_ _12087_ _12093_ VDD VSS NAND3_X1
X_17996_ _12088_ _12092_ _11860_ _12093_ _11863_ _12094_ VDD
+ VSS OAI221_X2
X_17997_ net382 _12091_ _12087_ _12095_ VDD VSS NOR3_X1
X_17998_ _15418_ _12096_ VDD VSS INV_X1
X_17999_ _12083_ _12090_ _12097_ VDD VSS NOR2_X1
X_18000_ _12096_ _12097_ _12098_ VDD VSS NOR2_X1
X_18001_ _11854_ _11918_ _11858_ _12099_ VDD VSS AOI21_X4
X_18002_ net382 _12099_ _11860_ _12091_ _12100_ VDD VSS NOR4_X2
X_18003_ _12094_ _12095_ _12098_ _12100_ _12101_ VDD VSS NOR4_X2
X_18004_ _12101_ alu_adder_result_ex\[12\] VDD VSS BUF_X4
X_18005_ _11432_ _12102_ VDD VSS BUF_X4
X_18006_ _12102_ _12103_ VDD VSS BUF_X4
X_18007_ _12103_ _10398_ _11926_ _12104_ VDD VSS NOR3_X1
X_18008_ _00604_ _00606_ _11944_ _12105_ VDD VSS MUX2_X1
X_18009_ _11956_ _12105_ _12106_ VDD VSS NOR2_X1
X_18010_ _00605_ _00607_ _11944_ _12107_ VDD VSS MUX2_X1
X_18011_ _11942_ _12107_ _12108_ VDD VSS NOR2_X1
X_18012_ _11932_ _12106_ _12108_ _12109_ VDD VSS NOR3_X1
X_18013_ _00598_ _12110_ VDD VSS INV_X1
X_18014_ net370 _12111_ VDD VSS BUF_X4
X_18015_ _12111_ _12112_ VDD VSS BUF_X4
X_18016_ _12112_ gen_regfile_ff.register_file_i.rf_reg\[46\]
+ _12113_ VDD VSS NOR2_X1
X_18017_ _12113_ _00599_ _11939_ _12114_ VDD VSS AOI21_X1
X_18018_ _10468_ _12110_ _11949_ _12114_ _11975_ _12115_ VDD
+ VSS AOI221_X2
X_18019_ _11930_ _12109_ _12115_ _12116_ VDD VSS NOR3_X1
X_18020_ _10436_ _12117_ VDD VSS BUF_X4
X_18021_ _00608_ _00610_ _11943_ _12118_ VDD VSS MUX2_X1
X_18022_ _00609_ _00611_ _11943_ _12119_ VDD VSS MUX2_X1
X_18023_ _12118_ _12119_ _11955_ _12120_ VDD VSS MUX2_X1
X_18024_ _00600_ _00602_ _11943_ _12121_ VDD VSS MUX2_X1
X_18025_ _00601_ _00603_ _11943_ _12122_ VDD VSS MUX2_X1
X_18026_ _12121_ _12122_ _11955_ _12123_ VDD VSS MUX2_X1
X_18027_ _11931_ _12124_ VDD VSS BUF_X4
X_18028_ _12120_ _12123_ _12124_ _12125_ VDD VSS MUX2_X1
X_18029_ _12117_ _12125_ _12126_ VDD VSS NOR2_X1
X_18030_ _11991_ _12116_ _12126_ _12127_ VDD VSS NOR3_X2
X_18031_ _00620_ _00622_ _11997_ _12128_ VDD VSS MUX2_X1
X_18032_ _11951_ _12129_ VDD VSS BUF_X8
X_18033_ _00621_ _00623_ _12129_ _12130_ VDD VSS MUX2_X1
X_18034_ _12128_ _12130_ _12000_ _12131_ VDD VSS MUX2_X1
X_18035_ _00612_ _00614_ _11997_ _12132_ VDD VSS MUX2_X1
X_18036_ _00613_ _00615_ _12129_ _12133_ VDD VSS MUX2_X1
X_18037_ _12132_ _12133_ _12000_ _12134_ VDD VSS MUX2_X1
X_18038_ _12131_ _12134_ _12005_ _12135_ VDD VSS MUX2_X1
X_18039_ _00624_ _00626_ _12129_ _12136_ VDD VSS MUX2_X1
X_18040_ _00625_ _00627_ _12129_ _12137_ VDD VSS MUX2_X1
X_18041_ _12136_ _12137_ _12000_ _12138_ VDD VSS MUX2_X1
X_18042_ _00616_ _00618_ _12129_ _12139_ VDD VSS MUX2_X1
X_18043_ _00617_ _00619_ _12129_ _12140_ VDD VSS MUX2_X1
X_18044_ _12139_ _12140_ _12000_ _12141_ VDD VSS MUX2_X1
X_18045_ _12138_ _12141_ _12005_ _12142_ VDD VSS MUX2_X1
X_18046_ _12135_ _12142_ _11930_ _12143_ VDD VSS MUX2_X1
X_18047_ _12127_ _11992_ _12143_ _12144_ VDD VSS AOI21_X4
X_18048_ _11922_ _11925_ _12104_ _12144_ _11995_ _15953_ VDD
+ VSS OAI221_X2
X_18049_ _15953_ _15949_ VDD VSS INV_X1
X_18050_ _00604_ _00606_ _11363_ _12145_ VDD VSS MUX2_X1
X_18051_ _00605_ _00607_ _11363_ _12146_ VDD VSS MUX2_X1
X_18052_ _12145_ _12146_ _11366_ _12147_ VDD VSS MUX2_X1
X_18053_ _10620_ gen_regfile_ff.register_file_i.rf_reg\[46\]
+ _12148_ VDD VSS NOR2_X1
X_18054_ _12148_ _00599_ _10601_ _12149_ VDD VSS AOI21_X1
X_18055_ _12110_ _10822_ _12149_ _10788_ _12150_ VDD VSS AOI22_X1
X_18056_ _12147_ _12150_ _11358_ _12151_ VDD VSS MUX2_X1
X_18057_ _00616_ _00618_ _11546_ _12152_ VDD VSS MUX2_X1
X_18058_ _00617_ _00619_ _11546_ _12153_ VDD VSS MUX2_X1
X_18059_ _12152_ _12153_ _10595_ _12154_ VDD VSS MUX2_X1
X_18060_ _10778_ _12154_ _12155_ VDD VSS NAND2_X1
X_18061_ _00614_ _00615_ _10595_ _12156_ VDD VSS MUX2_X1
X_18062_ _10794_ _12156_ _12157_ VDD VSS NAND2_X1
X_18063_ _00612_ _00613_ _11877_ _12158_ VDD VSS MUX2_X1
X_18064_ _10575_ _10785_ _12158_ _12159_ VDD VSS AOI21_X1
X_18065_ _12155_ _12157_ _12159_ _12160_ VDD VSS NAND3_X1
X_18066_ _00620_ _00621_ _10787_ _12161_ VDD VSS MUX2_X1
X_18067_ _10622_ _11676_ _12161_ _12162_ VDD VSS NOR3_X1
X_18068_ _00622_ _00623_ _11534_ _12163_ VDD VSS MUX2_X1
X_18069_ _10632_ _10751_ _12163_ _12164_ VDD VSS NOR3_X1
X_18070_ _00624_ _00625_ _10593_ _12165_ VDD VSS MUX2_X1
X_18071_ _00626_ _00627_ _10593_ _12166_ VDD VSS MUX2_X1
X_18072_ _12165_ _12166_ _10614_ _12167_ VDD VSS MUX2_X1
X_18073_ _10765_ _12167_ _11775_ _12168_ VDD VSS OAI21_X1
X_18074_ _12162_ _12164_ _12168_ _12169_ VDD VSS NOR3_X1
X_18075_ _00608_ _00610_ _10613_ _12170_ VDD VSS MUX2_X1
X_18076_ _00609_ _00611_ _10613_ _12171_ VDD VSS MUX2_X1
X_18077_ _12170_ _12171_ _10796_ _12172_ VDD VSS MUX2_X1
X_18078_ _00600_ _00602_ _10613_ _12173_ VDD VSS MUX2_X1
X_18079_ _00601_ _00603_ _10613_ _12174_ VDD VSS MUX2_X1
X_18080_ _12173_ _12174_ _10796_ _12175_ VDD VSS MUX2_X1
X_18081_ _12172_ _12175_ _10828_ _12176_ VDD VSS MUX2_X1
X_18082_ _10831_ _12151_ _12160_ _12169_ _12176_ _10855_ _12177_
+ VDD VSS OAI222_X2
X_18083_ _11596_ _12177_ _12178_ VDD VSS NAND2_X1
X_18084_ cs_registers_i.pc_id_i\[14\] _12179_ VDD VSS CLKBUF_X2
X_18085_ _12179_ _11593_ _12180_ VDD VSS AND2_X1
X_18086_ id_stage_i.controller_i.lsu_addr_last_i\[14\] _10741_
+ _10870_ _12180_ _12181_ VDD VSS AOI22_X2
X_18087_ _12178_ _12181_ _15948_ VDD VSS NAND2_X1
X_18088_ _15948_ _15952_ VDD VSS INV_X2
X_18089_ _10582_ _10398_ _11926_ _12182_ VDD VSS NOR3_X1
X_18090_ _00635_ _00637_ _11944_ _12183_ VDD VSS MUX2_X1
X_18091_ _11935_ _12183_ _12184_ VDD VSS NOR2_X1
X_18092_ _00636_ _00638_ _11944_ _12185_ VDD VSS MUX2_X1
X_18093_ _11942_ _12185_ _12186_ VDD VSS NOR2_X1
X_18094_ _11932_ _12184_ _12186_ _12187_ VDD VSS NOR3_X1
X_18095_ _00629_ _12188_ VDD VSS INV_X1
X_18096_ _11944_ gen_regfile_ff.register_file_i.rf_reg\[47\]
+ _12189_ VDD VSS NOR2_X1
X_18097_ _12189_ _00630_ _11953_ _12190_ VDD VSS AOI21_X1
X_18098_ _11948_ _12188_ _11949_ _12190_ _11975_ _12191_ VDD
+ VSS AOI221_X1
X_18099_ _11930_ _12187_ _12191_ _12192_ VDD VSS NOR3_X1
X_18100_ _00639_ _00641_ _11943_ _12193_ VDD VSS MUX2_X1
X_18101_ net370 _12194_ VDD VSS BUF_X4
X_18102_ _00640_ _00642_ _12194_ _12195_ VDD VSS MUX2_X1
X_18103_ _12193_ _12195_ _11955_ _12196_ VDD VSS MUX2_X1
X_18104_ _00631_ _00633_ _12194_ _12197_ VDD VSS MUX2_X1
X_18105_ _00632_ _00634_ _12194_ _12198_ VDD VSS MUX2_X1
X_18106_ _12197_ _12198_ _11955_ _12199_ VDD VSS MUX2_X1
X_18107_ _11931_ _12200_ VDD VSS BUF_X4
X_18108_ _12196_ _12199_ _12200_ _12201_ VDD VSS MUX2_X1
X_18109_ _12117_ _12201_ _12202_ VDD VSS NOR2_X1
X_18110_ _11991_ _12192_ _12202_ _12203_ VDD VSS NOR3_X2
X_18111_ _11951_ _12204_ VDD VSS BUF_X16
X_18112_ _00651_ _00653_ _12204_ _12205_ VDD VSS MUX2_X1
X_18113_ _00652_ _00654_ _12204_ _12206_ VDD VSS MUX2_X1
X_18114_ _11933_ _12207_ VDD VSS BUF_X16
X_18115_ _12205_ _12206_ _12207_ _12208_ VDD VSS MUX2_X1
X_18116_ _00643_ _00645_ _12204_ _12209_ VDD VSS MUX2_X1
X_18117_ _00644_ _00646_ _12021_ _12210_ VDD VSS MUX2_X1
X_18118_ _12209_ _12210_ _11934_ _12211_ VDD VSS MUX2_X1
X_18119_ _12208_ _12211_ _12029_ _12212_ VDD VSS MUX2_X1
X_18120_ _00655_ _00657_ _12021_ _12213_ VDD VSS MUX2_X1
X_18121_ _00656_ _00658_ _12021_ _12214_ VDD VSS MUX2_X1
X_18122_ _12213_ _12214_ _11934_ _12215_ VDD VSS MUX2_X1
X_18123_ _00647_ _00649_ _12021_ _12216_ VDD VSS MUX2_X1
X_18124_ _00648_ _00650_ _12021_ _12217_ VDD VSS MUX2_X1
X_18125_ _12216_ _12217_ _11934_ _12218_ VDD VSS MUX2_X1
X_18126_ _12215_ _12218_ _12029_ _12219_ VDD VSS MUX2_X1
X_18127_ _12212_ _12219_ _11989_ _12220_ VDD VSS MUX2_X1
X_18128_ _12203_ _11992_ _12220_ _12221_ VDD VSS AOI21_X4
X_18129_ _11922_ _11925_ _12182_ _12221_ _11995_ _15956_ VDD
+ VSS OAI221_X2
X_18130_ _15956_ _15960_ VDD VSS INV_X1
X_18131_ _00655_ _00657_ _11372_ _12222_ VDD VSS MUX2_X1
X_18132_ _00656_ _00658_ _10599_ _12223_ VDD VSS MUX2_X1
X_18133_ _12222_ _12223_ _11375_ _12224_ VDD VSS MUX2_X1
X_18134_ _00647_ _00649_ _10599_ _12225_ VDD VSS MUX2_X1
X_18135_ _00648_ _00650_ _10599_ _12226_ VDD VSS MUX2_X1
X_18136_ _12225_ _12226_ _11375_ _12227_ VDD VSS MUX2_X1
X_18137_ _12224_ _12227_ _10569_ _12228_ VDD VSS MUX2_X1
X_18138_ _00651_ _00653_ _10599_ _12229_ VDD VSS MUX2_X1
X_18139_ _00652_ _00654_ _10599_ _12230_ VDD VSS MUX2_X1
X_18140_ _12229_ _12230_ _11375_ _12231_ VDD VSS MUX2_X1
X_18141_ _00643_ _00645_ _10599_ _12232_ VDD VSS MUX2_X1
X_18142_ _00644_ _00646_ _10599_ _12233_ VDD VSS MUX2_X1
X_18143_ _12232_ _12233_ _11534_ _12234_ VDD VSS MUX2_X1
X_18144_ _12231_ _12234_ _10569_ _12235_ VDD VSS MUX2_X1
X_18145_ _12228_ _12235_ _10608_ _12236_ VDD VSS MUX2_X1
X_18146_ _00639_ _00641_ _10620_ _12237_ VDD VSS MUX2_X1
X_18147_ _00640_ _00642_ _10620_ _12238_ VDD VSS MUX2_X1
X_18148_ _12237_ _12238_ _10788_ _12239_ VDD VSS MUX2_X1
X_18149_ _11533_ _12239_ _12240_ VDD VSS NAND2_X1
X_18150_ _00631_ _00633_ _10620_ _12241_ VDD VSS MUX2_X1
X_18151_ _00632_ _00634_ _10620_ _12242_ VDD VSS MUX2_X1
X_18152_ _12241_ _12242_ _10788_ _12243_ VDD VSS MUX2_X1
X_18153_ _10570_ _12243_ _12244_ VDD VSS NAND2_X1
X_18154_ _10752_ _12240_ _12244_ _12245_ VDD VSS NAND3_X2
X_18155_ _10615_ _00630_ _12246_ VDD VSS NAND2_X1
X_18156_ _12246_ gen_regfile_ff.register_file_i.rf_reg\[47\]
+ _10589_ _12247_ VDD VSS OAI21_X1
X_18157_ _10570_ _00629_ _10757_ _12247_ _10581_ _12248_ VDD
+ VSS OAI221_X2
X_18158_ _00635_ _00637_ _10823_ _12249_ VDD VSS MUX2_X1
X_18159_ _00636_ _00638_ _10600_ _12250_ VDD VSS MUX2_X1
X_18160_ _12249_ _12250_ _11535_ _12251_ VDD VSS MUX2_X1
X_18161_ _11676_ _10766_ _12251_ _12252_ VDD VSS AOI21_X1
X_18162_ _10749_ _12248_ _12252_ _12253_ VDD VSS AOI21_X2
X_18163_ _10750_ _12236_ _12245_ _12253_ _12254_ VDD VSS AOI22_X4
X_18164_ _11596_ _12254_ _12255_ VDD VSS NAND2_X1
X_18165_ cs_registers_i.pc_id_i\[15\] _11593_ _12256_ VDD
+ VSS AND2_X1
X_18166_ id_stage_i.controller_i.lsu_addr_last_i\[15\] _10741_
+ _10683_ _12256_ _12257_ VDD VSS AOI22_X4
X_18167_ _12255_ _12257_ _15961_ VDD VSS NAND2_X4
X_18168_ _15961_ _15957_ VDD VSS INV_X2
X_18169_ _15430_ _12258_ VDD VSS INV_X1
X_18170_ _15421_ _12259_ VDD VSS INV_X1
X_18171_ _15417_ _15418_ _12083_ _12260_ VDD VSS AOI21_X1
X_18172_ _12259_ _12260_ _12080_ _12261_ VDD VSS OAI21_X2
X_18173_ _15426_ _12262_ VDD VSS BUF_X2
X_18174_ _15425_ _12261_ _12262_ _12263_ VDD VSS AOI21_X2
X_18175_ _15418_ _12079_ _12262_ _12264_ VDD VSS NAND3_X1
X_18176_ _12258_ _12263_ _12264_ _12265_ VDD VSS NAND3_X1
X_18177_ _12265_ _12263_ _12258_ _12266_ VDD VSS OAI21_X2
X_18178_ _15418_ _12079_ _12267_ VDD VSS NAND2_X2
X_18179_ _12262_ _15430_ _12268_ VDD VSS NAND2_X2
X_18180_ _12267_ _12268_ _12269_ VDD VSS NOR2_X2
X_18181_ _11910_ _12269_ _12270_ VDD VSS AND2_X1
X_18182_ _12258_ _12263_ _12271_ VDD VSS NAND2_X1
X_18183_ _11910_ _12271_ _12272_ VDD VSS NOR2_X1
X_18184_ _12270_ _12272_ _12273_ VDD VSS OR2_X2
X_18185_ _12266_ _12273_ alu_adder_result_ex\[15\] VDD VSS
+ NOR2_X4
X_18186_ _12083_ _11901_ _11900_ _12274_ VDD VSS AOI21_X1
X_18187_ _12081_ _12274_ _12096_ _12275_ VDD VSS OAI21_X1
X_18188_ _15421_ _12275_ _12079_ _12276_ VDD VSS AOI21_X1
X_18189_ _12276_ _12267_ _12086_ _12277_ VDD VSS OAI21_X1
X_18190_ _12276_ _12278_ VDD VSS INV_X1
X_18191_ _11916_ _12278_ _12279_ VDD VSS OR2_X1
X_18192_ _12277_ _12279_ _11919_ _12280_ VDD VSS OAI21_X1
X_18193_ _12280_ _12262_ alu_adder_result_ex\[14\] VDD VSS
+ XNOR2_X2
X_18194_ _10632_ _10398_ _11926_ _12281_ VDD VSS NOR3_X1
X_18195_ _00666_ _00668_ _11944_ _12282_ VDD VSS MUX2_X1
X_18196_ _11935_ _12282_ _12283_ VDD VSS NOR2_X1
X_18197_ _00667_ _00669_ _11944_ _12284_ VDD VSS MUX2_X1
X_18198_ _11942_ _12284_ _12285_ VDD VSS NOR2_X1
X_18199_ _11932_ _12283_ _12285_ _12286_ VDD VSS NOR3_X1
X_18200_ _00660_ _12287_ VDD VSS INV_X1
X_18201_ _12112_ gen_regfile_ff.register_file_i.rf_reg\[48\]
+ _12288_ VDD VSS NOR2_X1
X_18202_ _12288_ _00661_ _11953_ _12289_ VDD VSS AOI21_X1
X_18203_ _11948_ _12287_ _11949_ _12289_ _11975_ _12290_ VDD
+ VSS AOI221_X1
X_18204_ _11930_ _12286_ _12290_ _12291_ VDD VSS NOR3_X1
X_18205_ _00670_ _00672_ _11943_ _12292_ VDD VSS MUX2_X1
X_18206_ _00671_ _00673_ _11943_ _12293_ VDD VSS MUX2_X1
X_18207_ _12292_ _12293_ _11955_ _12294_ VDD VSS MUX2_X1
X_18208_ _00662_ _00664_ _12194_ _12295_ VDD VSS MUX2_X1
X_18209_ _00663_ _00665_ _12194_ _12296_ VDD VSS MUX2_X1
X_18210_ _12295_ _12296_ _11955_ _12297_ VDD VSS MUX2_X1
X_18211_ _12294_ _12297_ _12200_ _12298_ VDD VSS MUX2_X1
X_18212_ _12117_ _12298_ _12299_ VDD VSS NOR2_X1
X_18213_ _11991_ _12291_ _12299_ _12300_ VDD VSS NOR3_X2
X_18214_ _00682_ _00684_ _12204_ _12301_ VDD VSS MUX2_X1
X_18215_ _00683_ _00685_ _12204_ _12302_ VDD VSS MUX2_X1
X_18216_ _12301_ _12302_ _12207_ _12303_ VDD VSS MUX2_X1
X_18217_ _00674_ _00676_ _12204_ _12304_ VDD VSS MUX2_X1
X_18218_ _00675_ _00677_ _12204_ _12305_ VDD VSS MUX2_X1
X_18219_ _12304_ _12305_ _12207_ _12306_ VDD VSS MUX2_X1
X_18220_ _12303_ _12306_ _12029_ _12307_ VDD VSS MUX2_X1
X_18221_ _00686_ _00688_ _12204_ _12308_ VDD VSS MUX2_X1
X_18222_ _00687_ _00689_ _12204_ _12309_ VDD VSS MUX2_X1
X_18223_ _12308_ _12309_ _12207_ _12310_ VDD VSS MUX2_X1
X_18224_ _00678_ _00680_ _12204_ _12311_ VDD VSS MUX2_X1
X_18225_ _00679_ _00681_ _12021_ _12312_ VDD VSS MUX2_X1
X_18226_ _12311_ _12312_ _12207_ _12313_ VDD VSS MUX2_X1
X_18227_ _12310_ _12313_ _12029_ _12314_ VDD VSS MUX2_X1
X_18228_ _12307_ _12314_ _11989_ _12315_ VDD VSS MUX2_X1
X_18229_ _12300_ _12315_ _11992_ _12316_ VDD VSS AOI21_X4
X_18230_ _11922_ _11925_ _12281_ _12316_ _11995_ _15969_ VDD
+ VSS OAI221_X2
X_18231_ _15969_ _15965_ VDD VSS INV_X1
X_18232_ _11639_ _12317_ VDD VSS BUF_X4
X_18233_ _00686_ _00688_ _12317_ _12318_ VDD VSS MUX2_X1
X_18234_ _00687_ _00689_ _12317_ _12319_ VDD VSS MUX2_X1
X_18235_ _12318_ _12319_ _10627_ _12320_ VDD VSS MUX2_X1
X_18236_ _00678_ _00680_ _12317_ _12321_ VDD VSS MUX2_X1
X_18237_ _00679_ _00681_ _12317_ _12322_ VDD VSS MUX2_X1
X_18238_ _12321_ _12322_ _10627_ _12323_ VDD VSS MUX2_X1
X_18239_ _12320_ _12323_ _10828_ _12324_ VDD VSS MUX2_X1
X_18240_ _00682_ _00684_ _12317_ _12325_ VDD VSS MUX2_X1
X_18241_ _00683_ _00685_ _12317_ _12326_ VDD VSS MUX2_X1
X_18242_ _12325_ _12326_ _10627_ _12327_ VDD VSS MUX2_X1
X_18243_ _00674_ _00676_ _12317_ _12328_ VDD VSS MUX2_X1
X_18244_ _00675_ _00677_ _12317_ _12329_ VDD VSS MUX2_X1
X_18245_ _12328_ _12329_ _10627_ _12330_ VDD VSS MUX2_X1
X_18246_ _12327_ _12330_ _10828_ _12331_ VDD VSS MUX2_X1
X_18247_ _12324_ _12331_ _10608_ _12332_ VDD VSS MUX2_X1
X_18248_ _00670_ _00672_ _11597_ _12333_ VDD VSS MUX2_X1
X_18249_ _00671_ _00673_ _11597_ _12334_ VDD VSS MUX2_X1
X_18250_ _12333_ _12334_ _10797_ _12335_ VDD VSS MUX2_X1
X_18251_ _11533_ _12335_ _12336_ VDD VSS NAND2_X1
X_18252_ _00662_ _00664_ _11597_ _12337_ VDD VSS MUX2_X1
X_18253_ _00663_ _00665_ _11597_ _12338_ VDD VSS MUX2_X1
X_18254_ _12337_ _12338_ _10797_ _12339_ VDD VSS MUX2_X1
X_18255_ _10570_ _12339_ _12340_ VDD VSS NAND2_X1
X_18256_ _10752_ _12336_ _12340_ _12341_ VDD VSS NAND3_X2
X_18257_ _10602_ _00661_ _12342_ VDD VSS NAND2_X1
X_18258_ _12342_ gen_regfile_ff.register_file_i.rf_reg\[48\]
+ _10589_ _12343_ VDD VSS OAI21_X1
X_18259_ _10570_ _00660_ _10757_ _12343_ _10581_ _12344_ VDD
+ VSS OAI221_X2
X_18260_ _00666_ _00668_ _10600_ _12345_ VDD VSS MUX2_X1
X_18261_ _00667_ _00669_ _10600_ _12346_ VDD VSS MUX2_X1
X_18262_ _12345_ _12346_ _10628_ _12347_ VDD VSS MUX2_X1
X_18263_ _11676_ _10766_ _12347_ _12348_ VDD VSS AOI21_X1
X_18264_ _10749_ _12344_ _12348_ _12349_ VDD VSS AOI21_X2
X_18265_ _10750_ _12332_ _12341_ _12349_ _12350_ VDD VSS AOI22_X4
X_18266_ _11596_ _12350_ _12351_ VDD VSS NAND2_X1
X_18267_ cs_registers_i.pc_id_i\[16\] _12352_ VDD VSS INV_X1
X_18268_ _12352_ _10668_ _12353_ VDD VSS NOR2_X1
X_18269_ id_stage_i.controller_i.lsu_addr_last_i\[16\] _10397_
+ _10683_ _12353_ _12354_ VDD VSS AOI22_X2
X_18270_ _12351_ _12354_ _15964_ VDD VSS NAND2_X2
X_18271_ _15964_ _15968_ VDD VSS INV_X4
X_18272_ _10610_ _10398_ _11926_ _12355_ VDD VSS NOR3_X1
X_18273_ _11937_ _12356_ VDD VSS BUF_X16
X_18274_ _00713_ _00715_ _12356_ _12357_ VDD VSS MUX2_X1
X_18275_ _00714_ _00716_ _12356_ _12358_ VDD VSS MUX2_X1
X_18276_ _11933_ _12359_ VDD VSS BUF_X16
X_18277_ _12357_ _12358_ net384 _12360_ VDD VSS MUX2_X1
X_18278_ _00705_ _00707_ _12356_ _12361_ VDD VSS MUX2_X1
X_18279_ _00706_ _00708_ _12356_ _12362_ VDD VSS MUX2_X1
X_18280_ _12361_ _12362_ _12359_ _12363_ VDD VSS MUX2_X1
X_18281_ _12360_ _12363_ _12005_ _12364_ VDD VSS MUX2_X1
X_18282_ _11989_ _12364_ _12365_ VDD VSS NOR2_X2
X_18283_ _00717_ _00719_ _11962_ _12366_ VDD VSS MUX2_X1
X_18284_ _00718_ _00720_ _11962_ _12367_ VDD VSS MUX2_X1
X_18285_ _12366_ _12367_ _11964_ _12368_ VDD VSS MUX2_X1
X_18286_ _00709_ _00711_ _11962_ _12369_ VDD VSS MUX2_X1
X_18287_ _00710_ _00712_ _11962_ _12370_ VDD VSS MUX2_X1
X_18288_ _12369_ _12370_ _11964_ _12371_ VDD VSS MUX2_X1
X_18289_ _12368_ _12371_ _11969_ _12372_ VDD VSS MUX2_X1
X_18290_ _11959_ _12372_ _12373_ VDD VSS NOR2_X1
X_18291_ _10474_ _12365_ _12373_ _12374_ VDD VSS NOR3_X2
X_18292_ _00701_ _00703_ _12129_ _12375_ VDD VSS MUX2_X1
X_18293_ _00702_ _00704_ _12129_ _12376_ VDD VSS MUX2_X1
X_18294_ _12375_ _12376_ _12000_ _12377_ VDD VSS MUX2_X1
X_18295_ _00693_ _00695_ _12129_ _12378_ VDD VSS MUX2_X1
X_18296_ _00694_ _00696_ _12129_ _12379_ VDD VSS MUX2_X1
X_18297_ _12378_ _12379_ _12207_ _12380_ VDD VSS MUX2_X1
X_18298_ _12377_ _12380_ _12029_ _12381_ VDD VSS MUX2_X1
X_18299_ _11959_ _12381_ _12382_ VDD VSS NOR2_X2
X_18300_ _00691_ _12383_ VDD VSS INV_X1
X_18301_ _11939_ gen_regfile_ff.register_file_i.rf_reg\[49\]
+ _12384_ VDD VSS NOR2_X1
X_18302_ _12384_ _00692_ _12037_ _12385_ VDD VSS AOI21_X1
X_18303_ _11948_ _12383_ _11949_ _12385_ _11956_ _12386_ VDD
+ VSS AOI221_X2
X_18304_ _00697_ _00699_ _12037_ _12387_ VDD VSS MUX2_X1
X_18305_ _00698_ _00700_ _12037_ _12388_ VDD VSS MUX2_X1
X_18306_ _12387_ _12388_ _11935_ _12389_ VDD VSS MUX2_X1
X_18307_ _12386_ _12389_ _12041_ _12390_ VDD VSS AOI21_X1
X_18308_ _12382_ _12390_ _11959_ _12391_ VDD VSS AOI21_X2
X_18309_ _12374_ _12391_ _10474_ _12392_ VDD VSS AOI21_X4
X_18310_ _11922_ _11925_ _12355_ net289 _11995_ _15977_ VDD
+ VSS OAI221_X2
X_18311_ _15977_ _15973_ VDD VSS INV_X1
X_18312_ _00697_ _00699_ _11874_ _12393_ VDD VSS MUX2_X1
X_18313_ _00698_ _00700_ _11874_ _12394_ VDD VSS MUX2_X1
X_18314_ _12393_ _12394_ _11877_ _12395_ VDD VSS MUX2_X1
X_18315_ _10587_ gen_regfile_ff.register_file_i.rf_reg\[49\]
+ _12396_ VDD VSS NOR2_X1
X_18316_ _12396_ _00692_ _11547_ _12397_ VDD VSS AOI21_X1
X_18317_ _12383_ _10822_ _12397_ _10628_ _12398_ VDD VSS AOI22_X1
X_18318_ _12395_ _12398_ _11358_ _12399_ VDD VSS MUX2_X1
X_18319_ _00709_ _00711_ _11363_ _12400_ VDD VSS MUX2_X1
X_18320_ _00710_ _00712_ _11363_ _12401_ VDD VSS MUX2_X1
X_18321_ _12400_ _12401_ _11366_ _12402_ VDD VSS MUX2_X1
X_18322_ _10778_ _12402_ _12403_ VDD VSS NAND2_X1
X_18323_ _00705_ _00706_ _11877_ _12404_ VDD VSS MUX2_X1
X_18324_ _10575_ _10785_ _12404_ _12405_ VDD VSS AOI21_X1
X_18325_ _00707_ _00708_ _11877_ _12406_ VDD VSS MUX2_X1
X_18326_ _10794_ _12406_ _12407_ VDD VSS NAND2_X1
X_18327_ _12403_ _12405_ _12407_ _12408_ VDD VSS NAND3_X1
X_18328_ _00713_ _00714_ _10627_ _12409_ VDD VSS MUX2_X1
X_18329_ _10589_ _10751_ _12409_ _12410_ VDD VSS NOR3_X1
X_18330_ _00715_ _00716_ _11375_ _12411_ VDD VSS MUX2_X1
X_18331_ _10632_ _10832_ _12411_ _12412_ VDD VSS NOR3_X1
X_18332_ _00717_ _00718_ _10861_ _12413_ VDD VSS MUX2_X1
X_18333_ _00719_ _00720_ _10861_ _12414_ VDD VSS MUX2_X1
X_18334_ _12413_ _12414_ _11597_ _12415_ VDD VSS MUX2_X1
X_18335_ _10765_ _12415_ _11775_ _12416_ VDD VSS OAI21_X1
X_18336_ _12410_ _12412_ _12416_ _12417_ VDD VSS NOR3_X1
X_18337_ _00701_ _00703_ _10619_ _12418_ VDD VSS MUX2_X1
X_18338_ _00702_ _00704_ _10619_ _12419_ VDD VSS MUX2_X1
X_18339_ _12418_ _12419_ _10796_ _12420_ VDD VSS MUX2_X1
X_18340_ _00693_ _00695_ _11568_ _12421_ VDD VSS MUX2_X1
X_18341_ _00694_ _00696_ _11568_ _12422_ VDD VSS MUX2_X1
X_18342_ _12421_ _12422_ _10796_ _12423_ VDD VSS MUX2_X1
X_18343_ _12420_ _12423_ _10828_ _12424_ VDD VSS MUX2_X1
X_18344_ _10831_ _12399_ _12408_ _12417_ _12424_ _10855_ _12425_
+ VDD VSS OAI222_X2
X_18345_ _10816_ _12425_ _12426_ VDD VSS NAND2_X1
X_18346_ cs_registers_i.pc_id_i\[17\] _10563_ _12427_ VDD
+ VSS AND2_X1
X_18347_ id_stage_i.controller_i.lsu_addr_last_i\[17\] _11632_
+ _10870_ _12427_ _12428_ VDD VSS AOI22_X2
X_18348_ _12426_ _12428_ _15972_ VDD VSS NAND2_X2
X_18349_ _15972_ _15976_ VDD VSS INV_X2
X_18350_ _15438_ _12429_ VDD VSS BUF_X2
X_18351_ _15433_ _12430_ VDD VSS INV_X1
X_18352_ _12268_ _12431_ VDD VSS INV_X1
X_18353_ _15429_ _12431_ _12261_ _15425_ _15430_ _12432_ VDD
+ VSS AOI221_X2
X_18354_ _15434_ _12433_ VDD VSS BUF_X1
X_18355_ _12433_ _12434_ VDD VSS INV_X1
X_18356_ _12430_ _12432_ _12434_ _12435_ VDD VSS OAI21_X2
X_18357_ _12434_ _12267_ _12268_ _12436_ VDD VSS NOR3_X2
X_18358_ _12435_ _11910_ _12436_ _12437_ VDD VSS AOI21_X4
X_18359_ _12429_ _12437_ alu_adder_result_ex\[17\] VDD VSS
+ XNOR2_X2
X_18360_ _15429_ _15425_ _15430_ _12438_ VDD VSS AOI21_X1
X_18361_ _12081_ _12097_ _12096_ _12439_ VDD VSS OAI21_X1
X_18362_ _15421_ _12439_ _12079_ _12440_ VDD VSS AOI21_X1
X_18363_ _12087_ _12269_ _12441_ VDD VSS NAND2_X1
X_18364_ _12438_ _12440_ _12268_ _12441_ _11850_ _12442_ VDD
+ VSS OAI221_X2
X_18365_ _11839_ _12087_ _12269_ _12443_ VDD VSS NAND3_X1
X_18366_ _11854_ _12443_ _11858_ _11918_ _12444_ VDD VSS AOI211_X2
X_18367_ _12433_ _12442_ _12444_ _12445_ VDD VSS OAI21_X1
X_18368_ _12433_ _12442_ _12444_ _12446_ VDD VSS OR3_X1
X_18369_ _12445_ _12446_ _12447_ VDD VSS AND2_X1
X_18370_ _12447_ alu_adder_result_ex\[16\] VDD VSS BUF_X4
X_18371_ _10571_ _10398_ _11926_ _12448_ VDD VSS NOR3_X1
X_18372_ _10436_ _12449_ VDD VSS CLKBUF_X3
X_18373_ _00728_ _00730_ _11952_ _12450_ VDD VSS MUX2_X1
X_18374_ _00729_ _00731_ _11952_ _12451_ VDD VSS MUX2_X1
X_18375_ _12450_ _12451_ _11975_ _12452_ VDD VSS MUX2_X1
X_18376_ _12041_ _12452_ _12453_ VDD VSS NAND2_X1
X_18377_ _12037_ _00723_ _12454_ VDD VSS NAND2_X1
X_18378_ _12454_ gen_regfile_ff.register_file_i.rf_reg\[50\]
+ _12034_ _12455_ VDD VSS OAI21_X1
X_18379_ _12005_ _00722_ _10716_ _12455_ _11942_ _12456_ VDD
+ VSS OAI221_X1
X_18380_ _12449_ _12453_ _12456_ _12457_ VDD VSS AND3_X1
X_18381_ _00732_ _00734_ _12194_ _12458_ VDD VSS MUX2_X1
X_18382_ _00733_ _00735_ _11960_ _12459_ VDD VSS MUX2_X1
X_18383_ _12458_ _12459_ _11964_ _12460_ VDD VSS MUX2_X1
X_18384_ _00724_ _00726_ _11960_ _12461_ VDD VSS MUX2_X1
X_18385_ _00725_ _00727_ _11960_ _12462_ VDD VSS MUX2_X1
X_18386_ _12461_ _12462_ _11964_ _12463_ VDD VSS MUX2_X1
X_18387_ _12460_ _12463_ _12200_ _12464_ VDD VSS MUX2_X1
X_18388_ _12117_ _12464_ _12465_ VDD VSS NOR2_X1
X_18389_ _11991_ _12457_ _12465_ _12466_ VDD VSS NOR3_X2
X_18390_ _00744_ _00746_ _12023_ _12467_ VDD VSS MUX2_X1
X_18391_ _00745_ _00747_ _12023_ _12468_ VDD VSS MUX2_X1
X_18392_ _12467_ _12468_ _11934_ _12469_ VDD VSS MUX2_X1
X_18393_ _00736_ _00738_ _12023_ _12470_ VDD VSS MUX2_X1
X_18394_ _00737_ _00739_ _12023_ _12471_ VDD VSS MUX2_X1
X_18395_ _12470_ _12471_ _11934_ _12472_ VDD VSS MUX2_X1
X_18396_ _12469_ _12472_ _12029_ _12473_ VDD VSS MUX2_X1
X_18397_ _00748_ _00750_ _12023_ _12474_ VDD VSS MUX2_X1
X_18398_ _00749_ _00751_ _11952_ _12475_ VDD VSS MUX2_X1
X_18399_ _12474_ _12475_ _11975_ _12476_ VDD VSS MUX2_X1
X_18400_ _00740_ _00742_ _12023_ _12477_ VDD VSS MUX2_X1
X_18401_ _00741_ _00743_ _11952_ _12478_ VDD VSS MUX2_X1
X_18402_ _12477_ _12478_ _11975_ _12479_ VDD VSS MUX2_X1
X_18403_ _12476_ _12479_ _12029_ _12480_ VDD VSS MUX2_X1
X_18404_ _12473_ _12480_ _11989_ _12481_ VDD VSS MUX2_X1
X_18405_ _12466_ _12481_ _11992_ _12482_ VDD VSS AOI21_X4
X_18406_ _11922_ _11925_ _12448_ _12482_ _11995_ _15980_ VDD
+ VSS OAI221_X2
X_18407_ _15980_ _15984_ VDD VSS INV_X1
X_18408_ _10602_ _00723_ _12483_ VDD VSS NAND2_X1
X_18409_ _12483_ gen_regfile_ff.register_file_i.rf_reg\[50\]
+ _10622_ _12484_ VDD VSS OAI21_X1
X_18410_ _10783_ _00722_ _10757_ _12484_ _10581_ _12485_ VDD
+ VSS OAI221_X1
X_18411_ _00736_ _00738_ _10620_ _12486_ VDD VSS MUX2_X1
X_18412_ _00737_ _00739_ _10620_ _12487_ VDD VSS MUX2_X1
X_18413_ _12486_ _12487_ _10788_ _12488_ VDD VSS MUX2_X1
X_18414_ _11437_ _12488_ _10749_ _12489_ VDD VSS AOI21_X1
X_18415_ _12485_ _12489_ _12490_ VDD VSS NAND2_X1
X_18416_ _00744_ _00746_ _11874_ _12491_ VDD VSS MUX2_X1
X_18417_ _00745_ _00747_ _11874_ _12492_ VDD VSS MUX2_X1
X_18418_ _12491_ _12492_ _11877_ _12493_ VDD VSS MUX2_X1
X_18419_ _00728_ _00730_ _11874_ _12494_ VDD VSS MUX2_X1
X_18420_ _00729_ _00731_ _11874_ _12495_ VDD VSS MUX2_X1
X_18421_ _12494_ _12495_ _11877_ _12496_ VDD VSS MUX2_X1
X_18422_ _12493_ _12496_ _10575_ _12497_ VDD VSS MUX2_X1
X_18423_ _11655_ _12498_ VDD VSS BUF_X4
X_18424_ _00748_ _00750_ _12498_ _12499_ VDD VSS MUX2_X1
X_18425_ _00749_ _00751_ _12498_ _12500_ VDD VSS MUX2_X1
X_18426_ _12499_ _12500_ _10843_ _12501_ VDD VSS MUX2_X1
X_18427_ _00732_ _00734_ _12498_ _12502_ VDD VSS MUX2_X1
X_18428_ _00733_ _00735_ _12498_ _12503_ VDD VSS MUX2_X1
X_18429_ _12502_ _12503_ _10843_ _12504_ VDD VSS MUX2_X1
X_18430_ _12501_ _12504_ _10574_ _12505_ VDD VSS MUX2_X1
X_18431_ _00740_ _00742_ _12498_ _12506_ VDD VSS MUX2_X1
X_18432_ _00741_ _00743_ _12498_ _12507_ VDD VSS MUX2_X1
X_18433_ _12506_ _12507_ _10839_ _12508_ VDD VSS MUX2_X1
X_18434_ _00724_ _00726_ _12498_ _12509_ VDD VSS MUX2_X1
X_18435_ _00725_ _00727_ _10791_ _12510_ VDD VSS MUX2_X1
X_18436_ _12509_ _12510_ _10839_ _12511_ VDD VSS MUX2_X1
X_18437_ _12508_ _12511_ _10574_ _12512_ VDD VSS MUX2_X1
X_18438_ _12505_ _12512_ _11358_ _12513_ VDD VSS MUX2_X1
X_18439_ _12490_ _12497_ _11453_ _12513_ _10609_ _12514_ VDD
+ VSS OAI221_X2
X_18440_ _11596_ _12514_ _12515_ VDD VSS NAND2_X1
X_18441_ cs_registers_i.pc_id_i\[18\] _11593_ _12516_ VDD
+ VSS AND2_X1
X_18442_ id_stage_i.controller_i.lsu_addr_last_i\[18\] _10741_
+ _10870_ _12516_ _12517_ VDD VSS AOI22_X4
X_18443_ _12515_ _12517_ _15985_ VDD VSS NAND2_X4
X_18444_ _15985_ _15981_ VDD VSS INV_X2
X_18445_ _10576_ _10398_ _11926_ _12518_ VDD VSS NOR3_X1
X_18446_ _00775_ _00777_ _11997_ _12519_ VDD VSS MUX2_X1
X_18447_ _00776_ _00778_ _11997_ _12520_ VDD VSS MUX2_X1
X_18448_ _12519_ _12520_ _12000_ _12521_ VDD VSS MUX2_X1
X_18449_ _00767_ _00769_ _11997_ _12522_ VDD VSS MUX2_X1
X_18450_ _00768_ _00770_ _11997_ _12523_ VDD VSS MUX2_X1
X_18451_ _12522_ _12523_ _12000_ _12524_ VDD VSS MUX2_X1
X_18452_ _12521_ _12524_ _12005_ _12525_ VDD VSS MUX2_X1
X_18453_ _11989_ _12525_ _12526_ VDD VSS NOR2_X4
X_18454_ _00779_ _00781_ _12008_ _12527_ VDD VSS MUX2_X1
X_18455_ _00780_ _00782_ _12008_ _12528_ VDD VSS MUX2_X1
X_18456_ _12527_ _12528_ _12012_ _12529_ VDD VSS MUX2_X1
X_18457_ _00771_ _00773_ _12008_ _12530_ VDD VSS MUX2_X1
X_18458_ _00772_ _00774_ _12010_ _12531_ VDD VSS MUX2_X1
X_18459_ _12530_ _12531_ _12012_ _12532_ VDD VSS MUX2_X1
X_18460_ _12529_ _12532_ _12017_ _12533_ VDD VSS MUX2_X1
X_18461_ _11959_ _12533_ _12534_ VDD VSS NOR2_X4
X_18462_ _10474_ _12526_ _12534_ _12535_ VDD VSS NOR3_X4
X_18463_ _00763_ _00765_ _12021_ _12536_ VDD VSS MUX2_X1
X_18464_ _00764_ _00766_ _12021_ _12537_ VDD VSS MUX2_X1
X_18465_ _12536_ _12537_ _11934_ _12538_ VDD VSS MUX2_X1
X_18466_ _00755_ _00757_ _12021_ _12539_ VDD VSS MUX2_X1
X_18467_ _00756_ _00758_ _12023_ _12540_ VDD VSS MUX2_X1
X_18468_ _12539_ _12540_ _11934_ _12541_ VDD VSS MUX2_X1
X_18469_ _12538_ _12541_ _12029_ _12542_ VDD VSS MUX2_X1
X_18470_ _11959_ _12542_ _12543_ VDD VSS NOR2_X1
X_18471_ _00753_ _12544_ VDD VSS INV_X1
X_18472_ _11939_ gen_regfile_ff.register_file_i.rf_reg\[51\]
+ _12545_ VDD VSS NOR2_X1
X_18473_ _12545_ _00754_ _12034_ _12546_ VDD VSS AOI21_X1
X_18474_ _11948_ _12544_ _11949_ _12546_ _11956_ _12547_ VDD
+ VSS AOI221_X1
X_18475_ _00759_ _00761_ _12037_ _12548_ VDD VSS MUX2_X1
X_18476_ _00760_ _00762_ _12037_ _12549_ VDD VSS MUX2_X1
X_18477_ _12548_ _12549_ _11935_ _12550_ VDD VSS MUX2_X1
X_18478_ _12547_ _12550_ _12041_ _12551_ VDD VSS AOI21_X1
X_18479_ _12543_ _12551_ _11959_ _12552_ VDD VSS AOI21_X2
X_18480_ _12535_ _12552_ _10474_ _12553_ VDD VSS AOI21_X4
X_18481_ _11922_ _11925_ _12518_ _12553_ _11995_ _15993_ VDD
+ VSS OAI221_X2
X_18482_ _15993_ _15989_ VDD VSS INV_X1
X_18483_ _00767_ _00768_ _10593_ _12554_ VDD VSS MUX2_X1
X_18484_ _10573_ _10785_ _12554_ _12555_ VDD VSS AOI21_X1
X_18485_ _00769_ _00770_ _10593_ _12556_ VDD VSS MUX2_X1
X_18486_ _10614_ _10792_ _12556_ _12557_ VDD VSS NAND3_X1
X_18487_ _12555_ _12557_ _12558_ VDD VSS NAND2_X1
X_18488_ _00771_ _00773_ _11545_ _12559_ VDD VSS MUX2_X1
X_18489_ _00772_ _00774_ _11545_ _12560_ VDD VSS MUX2_X1
X_18490_ _12559_ _12560_ _10594_ _12561_ VDD VSS MUX2_X1
X_18491_ _00777_ _00778_ _10577_ _12562_ VDD VSS MUX2_X1
X_18492_ _00775_ _00776_ _10577_ _12563_ VDD VSS MUX2_X1
X_18493_ _12562_ _12563_ _10632_ _12564_ VDD VSS MUX2_X1
X_18494_ _00781_ _00782_ _10577_ _12565_ VDD VSS MUX2_X1
X_18495_ _00779_ _00780_ _10577_ _12566_ VDD VSS MUX2_X1
X_18496_ _12565_ _12566_ _10632_ _12567_ VDD VSS MUX2_X1
X_18497_ _12564_ _12567_ _10606_ _12568_ VDD VSS MUX2_X1
X_18498_ _12558_ _12561_ _10778_ _10766_ _12568_ _12569_ VDD
+ VSS AOI221_X2
X_18499_ _00759_ _00761_ _11546_ _12570_ VDD VSS MUX2_X1
X_18500_ _10628_ _12570_ _12571_ VDD VSS NOR2_X1
X_18501_ _00760_ _00762_ _11454_ _12572_ VDD VSS MUX2_X1
X_18502_ _10580_ _12572_ _12573_ VDD VSS NOR2_X1
X_18503_ _11358_ _12571_ _12573_ _12574_ VDD VSS NOR3_X1
X_18504_ _11874_ gen_regfile_ff.register_file_i.rf_reg\[51\]
+ _12575_ VDD VSS NOR2_X1
X_18505_ _12575_ _00754_ _10587_ _12576_ VDD VSS AOI21_X1
X_18506_ _10765_ _12544_ _10822_ _12576_ _11877_ _12577_ VDD
+ VSS AOI221_X1
X_18507_ _00763_ _00765_ _11874_ _12578_ VDD VSS MUX2_X1
X_18508_ _11535_ _12578_ _12579_ VDD VSS NOR2_X1
X_18509_ _00764_ _00766_ _11874_ _12580_ VDD VSS MUX2_X1
X_18510_ _10580_ _12580_ _12581_ VDD VSS NOR2_X1
X_18511_ _10828_ _12579_ _12581_ _12582_ VDD VSS NOR3_X1
X_18512_ _00755_ _00757_ _11568_ _12583_ VDD VSS MUX2_X1
X_18513_ _10595_ _12583_ _12584_ VDD VSS NOR2_X1
X_18514_ _00756_ _00758_ _11568_ _12585_ VDD VSS MUX2_X1
X_18515_ _10580_ _12585_ _12586_ VDD VSS NOR2_X1
X_18516_ _10765_ _12584_ _12586_ _12587_ VDD VSS NOR3_X1
X_18517_ _10831_ _12574_ _12577_ _12582_ _12587_ _10855_ _12588_
+ VDD VSS OAI33_X1
X_18518_ _12569_ _12588_ _12589_ VDD VSS OR2_X4
X_18519_ cs_registers_i.pc_id_i\[19\] _12590_ VDD VSS BUF_X2
X_18520_ _12590_ _11593_ _12591_ VDD VSS AND2_X1
X_18521_ id_stage_i.controller_i.lsu_addr_last_i\[19\] _10741_
+ _10816_ _12589_ _12591_ _10870_ _15992_ VDD VSS AOI222_X2
X_18522_ _15446_ _12592_ VDD VSS BUF_X2
X_18523_ _15442_ _12593_ VDD VSS BUF_X2
X_18524_ _12593_ _12594_ VDD VSS INV_X1
X_18525_ _15437_ _12595_ VDD VSS INV_X1
X_18526_ _12429_ _15433_ _12433_ _12596_ VDD VSS OAI21_X1
X_18527_ _12594_ _12595_ _12596_ _12597_ VDD VSS AOI21_X2
X_18528_ _15441_ _15437_ _12593_ _12598_ VDD VSS AOI21_X2
X_18529_ _12430_ _12432_ _12598_ _12599_ VDD VSS NAND3_X2
X_18530_ _15441_ _12597_ _12599_ _12270_ _12600_ VDD VSS OAI22_X4
X_18531_ _12600_ _12592_ alu_adder_result_ex\[19\] VDD VSS
+ XNOR2_X2
X_18532_ _12433_ _12429_ _12269_ _12601_ VDD VSS AND3_X1
X_18533_ _11902_ _11900_ _12601_ _12602_ VDD VSS AND3_X1
X_18534_ _11916_ _12602_ _12603_ VDD VSS NAND2_X4
X_18535_ _11839_ _12087_ _12601_ _12604_ VDD VSS AND3_X2
X_18536_ _11501_ _12604_ _11513_ _11862_ _12605_ VDD VSS OAI211_X4
X_18537_ _11900_ _11901_ _12269_ _12606_ VDD VSS NAND3_X1
X_18538_ _12434_ _12432_ _12606_ _12607_ VDD VSS AOI21_X1
X_18539_ _12429_ _15433_ _12607_ _12608_ VDD VSS OAI21_X2
X_18540_ _12595_ _12608_ _12609_ VDD VSS AND2_X2
X_18541_ _12603_ _12605_ _12609_ _12610_ VDD VSS AND3_X4
X_18542_ _12610_ _12593_ alu_adder_result_ex\[18\] VDD VSS
+ XNOR2_X2
X_18543_ _11923_ _11320_ _10928_ _12611_ VDD VSS AOI21_X1
X_18544_ _10317_ _12611_ _10398_ _12612_ VDD VSS OAI21_X2
X_18545_ _12612_ _12613_ VDD VSS BUF_X2
X_18546_ _11162_ _12614_ VDD VSS BUF_X2
X_18547_ _12613_ _12614_ _11935_ _12615_ VDD VSS AOI21_X1
X_18548_ _00790_ _00792_ _11960_ _12616_ VDD VSS MUX2_X1
X_18549_ _00791_ _00793_ _11960_ _12617_ VDD VSS MUX2_X1
X_18550_ _12616_ _12617_ _11964_ _12618_ VDD VSS MUX2_X1
X_18551_ _11948_ _12618_ _12619_ VDD VSS NAND2_X1
X_18552_ _11953_ _00785_ _12620_ VDD VSS NAND2_X1
X_18553_ _12620_ gen_regfile_ff.register_file_i.rf_reg\[52\]
+ _12037_ _12621_ VDD VSS OAI21_X1
X_18554_ _12124_ _00784_ _10716_ _12621_ _10697_ _12622_ VDD
+ VSS OAI221_X1
X_18555_ _10436_ _12619_ _12622_ _12623_ VDD VSS AND3_X1
X_18556_ _00794_ _00796_ _11951_ _12624_ VDD VSS MUX2_X1
X_18557_ _00795_ _00797_ _11951_ _12625_ VDD VSS MUX2_X1
X_18558_ _12624_ _12625_ _11933_ _12626_ VDD VSS MUX2_X1
X_18559_ _00786_ _00788_ _11951_ _12627_ VDD VSS MUX2_X1
X_18560_ net364 _12628_ VDD VSS BUF_X4
X_18561_ _00787_ _00789_ _12628_ _12629_ VDD VSS MUX2_X1
X_18562_ _10466_ _12630_ VDD VSS BUF_X4
X_18563_ _12627_ _12629_ _12630_ _12631_ VDD VSS MUX2_X1
X_18564_ _12626_ _12631_ _11931_ _12632_ VDD VSS MUX2_X1
X_18565_ _12449_ _12632_ _12633_ VDD VSS NOR2_X1
X_18566_ _11928_ _12623_ _12633_ _12634_ VDD VSS NOR3_X2
X_18567_ _00806_ _00808_ _12194_ _12635_ VDD VSS MUX2_X1
X_18568_ _00807_ _00809_ _12194_ _12636_ VDD VSS MUX2_X1
X_18569_ _12635_ _12636_ _11955_ _12637_ VDD VSS MUX2_X1
X_18570_ _00798_ _00800_ _12194_ _12638_ VDD VSS MUX2_X1
X_18571_ _00799_ _00801_ _11960_ _12639_ VDD VSS MUX2_X1
X_18572_ _12638_ _12639_ _11955_ _12640_ VDD VSS MUX2_X1
X_18573_ _12637_ _12640_ _12200_ _12641_ VDD VSS MUX2_X1
X_18574_ _00810_ _00812_ _12194_ _12642_ VDD VSS MUX2_X1
X_18575_ _00811_ _00813_ _11960_ _12643_ VDD VSS MUX2_X1
X_18576_ _12642_ _12643_ _11964_ _12644_ VDD VSS MUX2_X1
X_18577_ _00802_ _00804_ _11960_ _12645_ VDD VSS MUX2_X1
X_18578_ _00803_ _00805_ _11960_ _12646_ VDD VSS MUX2_X1
X_18579_ _12645_ _12646_ _11964_ _12647_ VDD VSS MUX2_X1
X_18580_ _12644_ _12647_ _12200_ _12648_ VDD VSS MUX2_X1
X_18581_ _10432_ _12649_ VDD VSS BUF_X4
X_18582_ _12641_ _12648_ _12649_ _12650_ VDD VSS MUX2_X1
X_18583_ _12634_ _12650_ _11929_ _12651_ VDD VSS AOI21_X4
X_18584_ _11922_ _11995_ _12651_ _12652_ VDD VSS OAI21_X1
X_18585_ _12615_ _12652_ _16000_ VDD VSS NOR2_X2
X_18586_ _00790_ _00792_ _11597_ _12653_ VDD VSS MUX2_X1
X_18587_ _00791_ _00793_ _10614_ _12654_ VDD VSS MUX2_X1
X_18588_ _12653_ _12654_ _10797_ _12655_ VDD VSS MUX2_X1
X_18589_ _10831_ _12655_ _11533_ _12656_ VDD VSS AOI21_X1
X_18590_ _10589_ _00785_ _12657_ VDD VSS NAND2_X1
X_18591_ _12657_ gen_regfile_ff.register_file_i.rf_reg\[52\]
+ _10622_ _12658_ VDD VSS OAI21_X1
X_18592_ _00784_ _10758_ _12658_ _10581_ _12659_ VDD VSS OAI22_X1
X_18593_ _12656_ _12659_ _10767_ _12660_ VDD VSS OAI21_X1
X_18594_ _00806_ _00808_ _10823_ _12661_ VDD VSS MUX2_X1
X_18595_ _00807_ _00809_ _10823_ _12662_ VDD VSS MUX2_X1
X_18596_ _12661_ _12662_ _11535_ _12663_ VDD VSS MUX2_X1
X_18597_ _00798_ _00800_ _10823_ _12664_ VDD VSS MUX2_X1
X_18598_ _00799_ _00801_ _10823_ _12665_ VDD VSS MUX2_X1
X_18599_ _12664_ _12665_ _11535_ _12666_ VDD VSS MUX2_X1
X_18600_ _12663_ _12666_ _11358_ _12667_ VDD VSS MUX2_X1
X_18601_ _00810_ _00812_ _11545_ _12668_ VDD VSS MUX2_X1
X_18602_ _00811_ _00813_ _11614_ _12669_ VDD VSS MUX2_X1
X_18603_ _12668_ _12669_ _10594_ _12670_ VDD VSS MUX2_X1
X_18604_ _00802_ _00804_ _11614_ _12671_ VDD VSS MUX2_X1
X_18605_ _00803_ _00805_ _11614_ _12672_ VDD VSS MUX2_X1
X_18606_ _12671_ _12672_ _11375_ _12673_ VDD VSS MUX2_X1
X_18607_ _12670_ _12673_ _10569_ _12674_ VDD VSS MUX2_X1
X_18608_ _00794_ _00796_ _11614_ _12675_ VDD VSS MUX2_X1
X_18609_ _00795_ _00797_ _11372_ _12676_ VDD VSS MUX2_X1
X_18610_ _12675_ _12676_ _11375_ _12677_ VDD VSS MUX2_X1
X_18611_ _00786_ _00788_ _11372_ _12678_ VDD VSS MUX2_X1
X_18612_ _00787_ _00789_ _11372_ _12679_ VDD VSS MUX2_X1
X_18613_ _12678_ _12679_ _11375_ _12680_ VDD VSS MUX2_X1
X_18614_ _12677_ _12680_ _10569_ _12681_ VDD VSS MUX2_X1
X_18615_ _12674_ _12681_ _10783_ _12682_ VDD VSS MUX2_X1
X_18616_ _12660_ _12667_ _11371_ _10610_ _12682_ _12683_ VDD
+ VSS OAI221_X2
X_18617_ _11596_ net360 _12684_ VDD VSS NAND2_X1
X_18618_ cs_registers_i.pc_id_i\[20\] _12685_ VDD VSS BUF_X2
X_18619_ _12685_ _11593_ _12686_ VDD VSS AND2_X1
X_18620_ id_stage_i.controller_i.lsu_addr_last_i\[20\] _10741_
+ _10683_ _12686_ _12687_ VDD VSS AOI22_X4
X_18621_ _12684_ _12687_ _16001_ VDD VSS NAND2_X4
X_18622_ _16001_ _15997_ VDD VSS INV_X2
X_18623_ _12613_ _12614_ _12034_ _12688_ VDD VSS AOI21_X1
X_18624_ net363 _12689_ VDD VSS BUF_X32
X_18625_ _00821_ _00823_ _12689_ _12690_ VDD VSS MUX2_X1
X_18626_ net363 _12691_ VDD VSS BUF_X32
X_18627_ _00822_ _00824_ _12691_ _12692_ VDD VSS MUX2_X1
X_18628_ _10466_ _12693_ VDD VSS BUF_X4
X_18629_ _12690_ _12692_ _12693_ _12694_ VDD VSS MUX2_X1
X_18630_ _11948_ _12694_ _12695_ VDD VSS NAND2_X1
X_18631_ _11953_ _00816_ _12696_ VDD VSS NAND2_X1
X_18632_ _12696_ gen_regfile_ff.register_file_i.rf_reg\[53\]
+ _12037_ _12697_ VDD VSS OAI21_X1
X_18633_ _12200_ _00815_ _10716_ _12697_ _11942_ _12698_ VDD
+ VSS OAI221_X1
X_18634_ _10436_ _12695_ _12698_ _12699_ VDD VSS AND3_X1
X_18635_ _00825_ _00827_ _12628_ _12700_ VDD VSS MUX2_X1
X_18636_ _00826_ _00828_ _12628_ _12701_ VDD VSS MUX2_X1
X_18637_ _12700_ _12701_ _12630_ _12702_ VDD VSS MUX2_X1
X_18638_ _00817_ _00819_ _12628_ _12703_ VDD VSS MUX2_X1
X_18639_ net370 _12704_ VDD VSS BUF_X4
X_18640_ _00818_ _00820_ _12704_ _12705_ VDD VSS MUX2_X1
X_18641_ _12703_ _12705_ _12630_ _12706_ VDD VSS MUX2_X1
X_18642_ _12702_ _12706_ _11931_ _12707_ VDD VSS MUX2_X1
X_18643_ _12449_ _12707_ _12708_ VDD VSS NOR2_X1
X_18644_ _11928_ _12699_ _12708_ _12709_ VDD VSS NOR3_X2
X_18645_ _00837_ _00839_ _11962_ _12710_ VDD VSS MUX2_X1
X_18646_ _00838_ _00840_ _11938_ _12711_ VDD VSS MUX2_X1
X_18647_ _12710_ _12711_ _11964_ _12712_ VDD VSS MUX2_X1
X_18648_ _00829_ _00831_ _11962_ _12713_ VDD VSS MUX2_X1
X_18649_ _00830_ _00832_ _11938_ _12714_ VDD VSS MUX2_X1
X_18650_ _12713_ _12714_ _12693_ _12715_ VDD VSS MUX2_X1
X_18651_ _12712_ _12715_ _11969_ _12716_ VDD VSS MUX2_X1
X_18652_ _00841_ _00843_ _11938_ _12717_ VDD VSS MUX2_X1
X_18653_ _00842_ _00844_ _12689_ _12718_ VDD VSS MUX2_X1
X_18654_ _12717_ _12718_ _12693_ _12719_ VDD VSS MUX2_X1
X_18655_ _00833_ _00835_ _12689_ _12720_ VDD VSS MUX2_X1
X_18656_ _00834_ _00836_ _12691_ _12721_ VDD VSS MUX2_X1
X_18657_ _12720_ _12721_ _12693_ _12722_ VDD VSS MUX2_X1
X_18658_ _12719_ _12722_ _11969_ _12723_ VDD VSS MUX2_X1
X_18659_ _12716_ _12723_ _12649_ _12724_ VDD VSS MUX2_X1
X_18660_ _12709_ _12724_ _11929_ _12725_ VDD VSS AOI21_X4
X_18661_ _11922_ _11995_ _12725_ _12726_ VDD VSS OAI21_X1
X_18662_ _12688_ _12726_ _16008_ VDD VSS NOR2_X2
X_18663_ _00821_ _00823_ _11597_ _12727_ VDD VSS MUX2_X1
X_18664_ _00822_ _00824_ _11597_ _12728_ VDD VSS MUX2_X1
X_18665_ _12727_ _12728_ _10788_ _12729_ VDD VSS MUX2_X1
X_18666_ _10831_ _12729_ _11533_ _12730_ VDD VSS AOI21_X1
X_18667_ _10602_ _00816_ _12731_ VDD VSS NAND2_X1
X_18668_ _12731_ gen_regfile_ff.register_file_i.rf_reg\[53\]
+ _10622_ _12732_ VDD VSS OAI21_X1
X_18669_ _00815_ _10758_ _12732_ _10581_ _12733_ VDD VSS OAI22_X1
X_18670_ _12730_ _12733_ _11533_ _12734_ VDD VSS OAI21_X1
X_18671_ _00837_ _00839_ _11546_ _12735_ VDD VSS MUX2_X1
X_18672_ _00838_ _00840_ _11546_ _12736_ VDD VSS MUX2_X1
X_18673_ _12735_ _12736_ _10595_ _12737_ VDD VSS MUX2_X1
X_18674_ _00829_ _00831_ _11546_ _12738_ VDD VSS MUX2_X1
X_18675_ _00830_ _00832_ _11546_ _12739_ VDD VSS MUX2_X1
X_18676_ _12738_ _12739_ _10595_ _12740_ VDD VSS MUX2_X1
X_18677_ _12737_ _12740_ _11358_ _12741_ VDD VSS MUX2_X1
X_18678_ _00841_ _00843_ _11642_ _12742_ VDD VSS MUX2_X1
X_18679_ _00842_ _00844_ _11642_ _12743_ VDD VSS MUX2_X1
X_18680_ _12742_ _12743_ _10862_ _12744_ VDD VSS MUX2_X1
X_18681_ _00833_ _00835_ _11642_ _12745_ VDD VSS MUX2_X1
X_18682_ _00834_ _00836_ _10858_ _12746_ VDD VSS MUX2_X1
X_18683_ _12745_ _12746_ _10862_ _12747_ VDD VSS MUX2_X1
X_18684_ _12744_ _12747_ _11357_ _12748_ VDD VSS MUX2_X1
X_18685_ _00825_ _00827_ _10858_ _12749_ VDD VSS MUX2_X1
X_18686_ _00826_ _00828_ _10858_ _12750_ VDD VSS MUX2_X1
X_18687_ _12749_ _12750_ _10862_ _12751_ VDD VSS MUX2_X1
X_18688_ _00817_ _00819_ _10858_ _12752_ VDD VSS MUX2_X1
X_18689_ _00818_ _00820_ _10858_ _12753_ VDD VSS MUX2_X1
X_18690_ _12752_ _12753_ _10862_ _12754_ VDD VSS MUX2_X1
X_18691_ _12751_ _12754_ _11357_ _12755_ VDD VSS MUX2_X1
X_18692_ _12748_ _12755_ _10575_ _12756_ VDD VSS MUX2_X1
X_18693_ _12734_ _12741_ _11371_ _10609_ _12756_ _12757_ VDD
+ VSS OAI221_X2
X_18694_ _11596_ net376 _12758_ VDD VSS NAND2_X1
X_18695_ cs_registers_i.pc_id_i\[21\] _11593_ _12759_ VDD
+ VSS AND2_X1
X_18696_ id_stage_i.controller_i.lsu_addr_last_i\[21\] _10741_
+ _10683_ _12759_ _12760_ VDD VSS AOI22_X4
X_18697_ _12758_ _12760_ _16009_ VDD VSS NAND2_X4
X_18698_ _16009_ _16005_ VDD VSS INV_X2
X_18699_ _15454_ _12761_ VDD VSS BUF_X2
X_18700_ _12761_ _12762_ VDD VSS INV_X1
X_18701_ _15445_ _12763_ VDD VSS INV_X1
X_18702_ _12592_ _12764_ VDD VSS INV_X1
X_18703_ _12763_ _12598_ _12764_ _12765_ VDD VSS OAI21_X1
X_18704_ _15450_ _12766_ VDD VSS BUF_X2
X_18705_ _15449_ _12765_ _12766_ _12767_ VDD VSS AOI21_X2
X_18706_ _12766_ _12768_ VDD VSS INV_X1
X_18707_ _12594_ _12764_ _12768_ _12769_ VDD VSS NOR3_X2
X_18708_ _12429_ _12769_ _12770_ VDD VSS NAND2_X1
X_18709_ _12767_ _12770_ _12437_ _12771_ VDD VSS OAI21_X1
X_18710_ _12771_ _12762_ alu_adder_result_ex\[21\] VDD VSS
+ XNOR2_X2
X_18711_ _12595_ _12608_ _12772_ VDD VSS NAND2_X1
X_18712_ _15445_ _15441_ _12592_ _12773_ VDD VSS AOI21_X4
X_18713_ _12773_ _12774_ VDD VSS INV_X1
X_18714_ _12766_ _12772_ _12774_ _12775_ VDD VSS NOR3_X1
X_18715_ _12603_ _12605_ _12775_ _12776_ VDD VSS AND3_X2
X_18716_ _12769_ _12777_ VDD VSS INV_X1
X_18717_ _12777_ _12605_ _12603_ _12778_ VDD VSS AOI21_X4
X_18718_ _12766_ _12592_ _12593_ _12779_ VDD VSS AOI21_X1
X_18719_ _12773_ _12779_ _12780_ VDD VSS NAND2_X1
X_18720_ _12780_ _12777_ _12609_ _12768_ _12773_ _12781_ VDD
+ VSS OAI221_X2
X_18721_ _12776_ _12778_ _12781_ alu_adder_result_ex\[20\]
+ VDD VSS NOR3_X4
X_18722_ _12613_ _12614_ _11989_ _12782_ VDD VSS AOI21_X1
X_18723_ _00852_ _00854_ _12112_ _12783_ VDD VSS MUX2_X1
X_18724_ _11956_ _12783_ _12784_ VDD VSS NOR2_X1
X_18725_ _00853_ _00855_ _12112_ _12785_ VDD VSS MUX2_X1
X_18726_ _10697_ _12785_ _12786_ VDD VSS NOR2_X1
X_18727_ _11932_ _12784_ _12786_ _12787_ VDD VSS NOR3_X1
X_18728_ _00846_ _12788_ VDD VSS INV_X1
X_18729_ _11978_ gen_regfile_ff.register_file_i.rf_reg\[54\]
+ _12789_ VDD VSS NOR2_X1
X_18730_ _12789_ _00847_ _11939_ _12790_ VDD VSS AOI21_X1
X_18731_ _10468_ _12788_ _11949_ _12790_ _12207_ _12791_ VDD
+ VSS AOI221_X1
X_18732_ _12649_ _12787_ _12791_ _12792_ VDD VSS NOR3_X1
X_18733_ _00856_ _00858_ _12111_ _12793_ VDD VSS MUX2_X1
X_18734_ net370 _12794_ VDD VSS BUF_X4
X_18735_ _00857_ _00859_ _12794_ _12795_ VDD VSS MUX2_X1
X_18736_ _10466_ _12796_ VDD VSS BUF_X4
X_18737_ _12793_ _12795_ _12796_ _12797_ VDD VSS MUX2_X1
X_18738_ _00848_ _00850_ _12794_ _12798_ VDD VSS MUX2_X1
X_18739_ _00849_ _00851_ _11943_ _12799_ VDD VSS MUX2_X1
X_18740_ _12798_ _12799_ _12796_ _12800_ VDD VSS MUX2_X1
X_18741_ _12797_ _12800_ _12124_ _12801_ VDD VSS MUX2_X1
X_18742_ _12117_ _12801_ _12802_ VDD VSS NOR2_X2
X_18743_ _11991_ _12792_ _12802_ _12803_ VDD VSS NOR3_X2
X_18744_ net363 _12804_ VDD VSS BUF_X16
X_18745_ _00868_ _00870_ _12804_ _12805_ VDD VSS MUX2_X1
X_18746_ _11937_ _12806_ VDD VSS BUF_X8
X_18747_ _00869_ _00871_ _12806_ _12807_ VDD VSS MUX2_X1
X_18748_ _11933_ _12808_ VDD VSS BUF_X8
X_18749_ _12805_ _12807_ _12808_ _12809_ VDD VSS MUX2_X1
X_18750_ _00860_ _00862_ _12806_ _12810_ VDD VSS MUX2_X1
X_18751_ _11937_ _12811_ VDD VSS BUF_X16
X_18752_ _00861_ _00863_ _12811_ _12812_ VDD VSS MUX2_X1
X_18753_ _12810_ _12812_ _12808_ _12813_ VDD VSS MUX2_X1
X_18754_ _12809_ _12813_ _12017_ _12814_ VDD VSS MUX2_X1
X_18755_ _00872_ _00874_ _12806_ _12815_ VDD VSS MUX2_X1
X_18756_ _00873_ _00875_ _12811_ _12816_ VDD VSS MUX2_X1
X_18757_ _12815_ _12816_ _12359_ _12817_ VDD VSS MUX2_X1
X_18758_ _00864_ _00866_ _12811_ _12818_ VDD VSS MUX2_X1
X_18759_ _00865_ _00867_ _12356_ _12819_ VDD VSS MUX2_X1
X_18760_ _12818_ _12819_ _12359_ _12820_ VDD VSS MUX2_X1
X_18761_ _12817_ _12820_ _12005_ _12821_ VDD VSS MUX2_X1
X_18762_ _12814_ _12821_ _11930_ _12822_ VDD VSS MUX2_X2
X_18763_ _12803_ _11992_ _12822_ _12823_ VDD VSS AOI21_X4
X_18764_ _11921_ _11994_ _12823_ _12824_ VDD VSS OAI21_X1
X_18765_ _12782_ _12824_ _16016_ VDD VSS NOR2_X2
X_18766_ id_stage_i.controller_i.lsu_addr_last_i\[22\] _11632_
+ _12825_ VDD VSS NAND2_X1
X_18767_ _00872_ _00874_ _10585_ _12826_ VDD VSS MUX2_X1
X_18768_ _00873_ _00875_ _10585_ _12827_ VDD VSS MUX2_X1
X_18769_ _12826_ _12827_ _10786_ _12828_ VDD VSS MUX2_X1
X_18770_ _00864_ _00866_ _10585_ _12829_ VDD VSS MUX2_X1
X_18771_ _00865_ _00867_ _10585_ _12830_ VDD VSS MUX2_X1
X_18772_ _12829_ _12830_ _10786_ _12831_ VDD VSS MUX2_X1
X_18773_ _12828_ _12831_ _10827_ _12832_ VDD VSS MUX2_X1
X_18774_ _11676_ _12832_ _12833_ VDD VSS NAND2_X1
X_18775_ _00868_ _00870_ _11545_ _12834_ VDD VSS MUX2_X1
X_18776_ _00869_ _00871_ _11545_ _12835_ VDD VSS MUX2_X1
X_18777_ _12834_ _12835_ _10594_ _12836_ VDD VSS MUX2_X1
X_18778_ _00860_ _00861_ _10843_ _12837_ VDD VSS MUX2_X1
X_18779_ _00862_ _00863_ _10795_ _12838_ VDD VSS MUX2_X1
X_18780_ _10643_ _12836_ _12837_ _10785_ _12838_ _10794_ _12839_
+ VDD VSS AOI222_X2
X_18781_ _10783_ _12833_ _12839_ _12840_ VDD VSS AOI21_X4
X_18782_ _00852_ _00854_ _11362_ _12841_ VDD VSS MUX2_X1
X_18783_ _11534_ _12841_ _12842_ VDD VSS NOR2_X1
X_18784_ _00853_ _00855_ _11362_ _12843_ VDD VSS MUX2_X1
X_18785_ _10579_ _12843_ _12844_ VDD VSS NOR2_X1
X_18786_ _11357_ _12842_ _12844_ _12845_ VDD VSS NOR3_X1
X_18787_ _10612_ gen_regfile_ff.register_file_i.rf_reg\[54\]
+ _12846_ VDD VSS NOR2_X1
X_18788_ _12846_ _00847_ _11771_ _12847_ VDD VSS AOI21_X1
X_18789_ _10765_ _12788_ _10822_ _12847_ _10795_ _12848_ VDD
+ VSS AOI221_X2
X_18790_ _10751_ _12845_ _12848_ _12849_ VDD VSS NOR3_X2
X_18791_ _00856_ _00858_ _11778_ _12850_ VDD VSS MUX2_X1
X_18792_ _00857_ _00859_ _11778_ _12851_ VDD VSS MUX2_X1
X_18793_ _12850_ _12851_ _10839_ _12852_ VDD VSS MUX2_X1
X_18794_ _00848_ _00850_ _11778_ _12853_ VDD VSS MUX2_X1
X_18795_ _00849_ _00851_ _11778_ _12854_ VDD VSS MUX2_X1
X_18796_ _12853_ _12854_ _10861_ _12855_ VDD VSS MUX2_X1
X_18797_ _12852_ _12855_ _11662_ _12856_ VDD VSS MUX2_X1
X_18798_ _11775_ _12856_ _12857_ VDD VSS NOR2_X2
X_18799_ _11370_ _12849_ _12857_ _12858_ VDD VSS NOR3_X4
X_18800_ _12840_ _12858_ _12859_ VDD VSS OR2_X4
X_18801_ cs_registers_i.pc_id_i\[22\] _10564_ _12860_ VDD
+ VSS NAND2_X1
X_18802_ _12825_ _12859_ _10814_ _12860_ _10747_ _16017_ VDD
+ VSS OAI221_X2
X_18803_ _16017_ _16013_ VDD VSS INV_X2
X_18804_ _12613_ _12614_ _12041_ _12861_ VDD VSS AOI21_X1
X_18805_ _00883_ _00885_ _12112_ _12862_ VDD VSS MUX2_X1
X_18806_ _11956_ _12862_ _12863_ VDD VSS NOR2_X1
X_18807_ _00884_ _00886_ _12112_ _12864_ VDD VSS MUX2_X1
X_18808_ _10697_ _12864_ _12865_ VDD VSS NOR2_X1
X_18809_ _11932_ _12863_ _12865_ _12866_ VDD VSS NOR3_X1
X_18810_ _00877_ _12867_ VDD VSS INV_X1
X_18811_ _11978_ gen_regfile_ff.register_file_i.rf_reg\[55\]
+ _12868_ VDD VSS NOR2_X1
X_18812_ _12868_ _00878_ _11939_ _12869_ VDD VSS AOI21_X1
X_18813_ _10468_ _12867_ _11949_ _12869_ _12207_ _12870_ VDD
+ VSS AOI221_X1
X_18814_ _12649_ _12866_ _12870_ _12871_ VDD VSS NOR3_X1
X_18815_ _00887_ _00889_ _12111_ _12872_ VDD VSS MUX2_X1
X_18816_ _00888_ _00890_ _12794_ _12873_ VDD VSS MUX2_X1
X_18817_ _12872_ _12873_ _12796_ _12874_ VDD VSS MUX2_X1
X_18818_ _00879_ _00881_ _12794_ _12875_ VDD VSS MUX2_X1
X_18819_ _00880_ _00882_ _12794_ _12876_ VDD VSS MUX2_X1
X_18820_ _12875_ _12876_ _12796_ _12877_ VDD VSS MUX2_X1
X_18821_ _12874_ _12877_ _12124_ _12878_ VDD VSS MUX2_X1
X_18822_ _12117_ _12878_ _12879_ VDD VSS NOR2_X1
X_18823_ _11991_ _12871_ _12879_ _12880_ VDD VSS NOR3_X2
X_18824_ _00899_ _00901_ _12010_ _12881_ VDD VSS MUX2_X1
X_18825_ _00900_ _00902_ _12806_ _12882_ VDD VSS MUX2_X1
X_18826_ _12881_ _12882_ _12808_ _12883_ VDD VSS MUX2_X1
X_18827_ _00891_ _00893_ _12804_ _12884_ VDD VSS MUX2_X1
X_18828_ _00892_ _00894_ _12811_ _12885_ VDD VSS MUX2_X1
X_18829_ _12884_ _12885_ _12808_ _12886_ VDD VSS MUX2_X1
X_18830_ _12883_ _12886_ _12017_ _12887_ VDD VSS MUX2_X1
X_18831_ _00903_ _00905_ _12806_ _12888_ VDD VSS MUX2_X1
X_18832_ _00904_ _00906_ _12811_ _12889_ VDD VSS MUX2_X1
X_18833_ _12888_ _12889_ _12359_ _12890_ VDD VSS MUX2_X1
X_18834_ _00895_ _00897_ _12811_ _12891_ VDD VSS MUX2_X1
X_18835_ _00896_ _00898_ _12356_ _12892_ VDD VSS MUX2_X1
X_18836_ _12891_ _12892_ _12359_ _12893_ VDD VSS MUX2_X1
X_18837_ _12890_ _12893_ _12005_ _12894_ VDD VSS MUX2_X1
X_18838_ _12887_ _12894_ _11930_ _12895_ VDD VSS MUX2_X2
X_18839_ _12880_ _12895_ _11992_ _12896_ VDD VSS AOI21_X4
X_18840_ _11921_ _11994_ _12896_ _12897_ VDD VSS OAI21_X1
X_18841_ _12861_ _12897_ _16021_ VDD VSS NOR2_X2
X_18842_ id_stage_i.controller_i.lsu_addr_last_i\[23\] _11632_
+ _12898_ VDD VSS NAND2_X1
X_18843_ _00899_ _00901_ _11641_ _12899_ VDD VSS MUX2_X1
X_18844_ _00900_ _00902_ _11641_ _12900_ VDD VSS MUX2_X1
X_18845_ _12899_ _12900_ _10861_ _12901_ VDD VSS MUX2_X1
X_18846_ _00891_ _00893_ _10857_ _12902_ VDD VSS MUX2_X1
X_18847_ _00892_ _00894_ _10857_ _12903_ VDD VSS MUX2_X1
X_18848_ _12902_ _12903_ _10593_ _12904_ VDD VSS MUX2_X1
X_18849_ _12901_ _12904_ _10568_ _12905_ VDD VSS MUX2_X1
X_18850_ _10751_ _12905_ _12906_ VDD VSS NOR2_X1
X_18851_ _00903_ _00905_ _11778_ _12907_ VDD VSS MUX2_X1
X_18852_ _00904_ _00906_ _11641_ _12908_ VDD VSS MUX2_X1
X_18853_ _12907_ _12908_ _10861_ _12909_ VDD VSS MUX2_X1
X_18854_ _00895_ _00897_ _11641_ _12910_ VDD VSS MUX2_X1
X_18855_ _00896_ _00898_ _11641_ _12911_ VDD VSS MUX2_X1
X_18856_ _12910_ _12911_ _10861_ _12912_ VDD VSS MUX2_X1
X_18857_ _12909_ _12912_ _11662_ _12913_ VDD VSS MUX2_X1
X_18858_ _11775_ _12913_ _12914_ VDD VSS NOR2_X1
X_18859_ _10783_ _12906_ _12914_ _12915_ VDD VSS NOR3_X4
X_18860_ _00883_ _00885_ _11362_ _12916_ VDD VSS MUX2_X1
X_18861_ _11534_ _12916_ _12917_ VDD VSS NOR2_X1
X_18862_ _00884_ _00886_ _12498_ _12918_ VDD VSS MUX2_X1
X_18863_ _10579_ _12918_ _12919_ VDD VSS NOR2_X1
X_18864_ _10827_ _12917_ _12919_ _12920_ VDD VSS NOR3_X1
X_18865_ _11567_ gen_regfile_ff.register_file_i.rf_reg\[55\]
+ _12921_ VDD VSS NOR2_X1
X_18866_ _12921_ _00878_ _11771_ _12922_ VDD VSS AOI21_X1
X_18867_ _10764_ _12867_ _10822_ _12922_ _10786_ _12923_ VDD
+ VSS AOI221_X2
X_18868_ _10832_ _12920_ _12923_ _12924_ VDD VSS NOR3_X2
X_18869_ _00887_ _00889_ _10790_ _12925_ VDD VSS MUX2_X1
X_18870_ _00888_ _00890_ _10790_ _12926_ VDD VSS MUX2_X1
X_18871_ _12925_ _12926_ _10833_ _12927_ VDD VSS MUX2_X1
X_18872_ _00879_ _00881_ _10790_ _12928_ VDD VSS MUX2_X1
X_18873_ _00880_ _00882_ _10790_ _12929_ VDD VSS MUX2_X1
X_18874_ _12928_ _12929_ _10833_ _12930_ VDD VSS MUX2_X1
X_18875_ _12927_ _12930_ _11662_ _12931_ VDD VSS MUX2_X1
X_18876_ _11775_ _12931_ _12932_ VDD VSS NOR2_X1
X_18877_ _11370_ _12924_ _12932_ _12933_ VDD VSS NOR3_X4
X_18878_ _12915_ _12933_ _12934_ VDD VSS OR2_X2
X_18879_ cs_registers_i.pc_id_i\[23\] _12935_ VDD VSS CLKBUF_X2
X_18880_ _12935_ _10564_ _12936_ VDD VSS NAND2_X1
X_18881_ _12898_ _12934_ _10814_ _12936_ _10746_ _16020_ VDD
+ VSS OAI221_X2
X_18882_ _16020_ _16024_ VDD VSS INV_X2
X_18883_ _15462_ _12937_ VDD VSS INV_X1
X_18884_ _15457_ _12938_ VDD VSS INV_X1
X_18885_ _12592_ _12766_ _12761_ _15458_ _12939_ VDD VSS NAND4_X1
X_18886_ _15449_ _12940_ VDD VSS INV_X1
X_18887_ _12940_ _12763_ _12768_ _12941_ VDD VSS OAI21_X1
X_18888_ _15453_ _12941_ _12761_ _12942_ VDD VSS AOI21_X1
X_18889_ _15458_ _12943_ VDD VSS INV_X1
X_18890_ _12938_ _12600_ _12939_ _12942_ _12943_ _12944_ VDD
+ VSS OAI221_X2
X_18891_ _12944_ _12937_ alu_adder_result_ex\[23\] VDD VSS
+ XNOR2_X2
X_18892_ _12940_ _12773_ _12768_ _12945_ VDD VSS OAI21_X1
X_18893_ _15453_ _12945_ _12761_ _12946_ VDD VSS AOI21_X2
X_18894_ _12761_ _12769_ _12947_ VDD VSS NAND2_X1
X_18895_ _12946_ _12947_ _12610_ _12948_ VDD VSS OAI21_X1
X_18896_ _12943_ _12948_ _12949_ VDD VSS XNOR2_X2
X_18897_ _12949_ alu_adder_result_ex\[22\] VDD VSS BUF_X4
X_18898_ _12613_ _12614_ _11992_ _12950_ VDD VSS AOI21_X1
X_18899_ _00914_ _00916_ _12112_ _12951_ VDD VSS MUX2_X1
X_18900_ _11956_ _12951_ _12952_ VDD VSS NOR2_X1
X_18901_ _00915_ _00917_ _11978_ _12953_ VDD VSS MUX2_X1
X_18902_ _10697_ _12953_ _12954_ VDD VSS NOR2_X1
X_18903_ _11932_ _12952_ _12954_ _12955_ VDD VSS NOR3_X1
X_18904_ _00908_ _12956_ VDD VSS INV_X1
X_18905_ _11978_ gen_regfile_ff.register_file_i.rf_reg\[56\]
+ _12957_ VDD VSS NOR2_X1
X_18906_ _12957_ _00909_ _11939_ _12958_ VDD VSS AOI21_X1
X_18907_ _10468_ _12956_ _10964_ _12958_ _12207_ _12959_ VDD
+ VSS AOI221_X2
X_18908_ _12649_ _12955_ _12959_ _12960_ VDD VSS NOR3_X1
X_18909_ _00918_ _00920_ _12111_ _12961_ VDD VSS MUX2_X1
X_18910_ _00919_ _00921_ _12111_ _12962_ VDD VSS MUX2_X1
X_18911_ _12961_ _12962_ _12796_ _12963_ VDD VSS MUX2_X1
X_18912_ _00910_ _00912_ _12111_ _12964_ VDD VSS MUX2_X1
X_18913_ _00911_ _00913_ _12794_ _12965_ VDD VSS MUX2_X1
X_18914_ _12964_ _12965_ _12796_ _12966_ VDD VSS MUX2_X1
X_18915_ _12963_ _12966_ _12124_ _12967_ VDD VSS MUX2_X1
X_18916_ _12117_ _12967_ _12968_ VDD VSS NOR2_X1
X_18917_ _11991_ _12960_ _12968_ _12969_ VDD VSS NOR3_X2
X_18918_ _00930_ _00932_ _12010_ _12970_ VDD VSS MUX2_X1
X_18919_ _00931_ _00933_ _12010_ _12971_ VDD VSS MUX2_X1
X_18920_ _12970_ _12971_ net385 _12972_ VDD VSS MUX2_X1
X_18921_ _00922_ _00924_ _12010_ _12973_ VDD VSS MUX2_X1
X_18922_ _00923_ _00925_ _12804_ _12974_ VDD VSS MUX2_X1
X_18923_ _12973_ _12974_ _12012_ _12975_ VDD VSS MUX2_X1
X_18924_ _12972_ _12975_ _12017_ _12976_ VDD VSS MUX2_X1
X_18925_ _00934_ _00936_ _12010_ _12977_ VDD VSS MUX2_X1
X_18926_ _00935_ _00937_ _12804_ _12978_ VDD VSS MUX2_X1
X_18927_ _12977_ _12978_ _12808_ _12979_ VDD VSS MUX2_X1
X_18928_ _00926_ _00928_ _12804_ _12980_ VDD VSS MUX2_X1
X_18929_ _00927_ _00929_ _12811_ _12981_ VDD VSS MUX2_X1
X_18930_ _12980_ _12981_ _12808_ _12982_ VDD VSS MUX2_X1
X_18931_ _12979_ _12982_ _12017_ _12983_ VDD VSS MUX2_X1
X_18932_ _12976_ _12983_ _11930_ _12984_ VDD VSS MUX2_X2
X_18933_ _12969_ _11929_ _12984_ _12985_ VDD VSS AOI21_X4
X_18934_ _11921_ _11994_ _12985_ _12986_ VDD VSS OAI21_X1
X_18935_ _12950_ _12986_ _16032_ VDD VSS NOR2_X2
X_18936_ id_stage_i.controller_i.lsu_addr_last_i\[24\] _11632_
+ _12987_ VDD VSS NAND2_X1
X_18937_ _00930_ _00932_ _10857_ _12988_ VDD VSS MUX2_X1
X_18938_ _00931_ _00933_ _10857_ _12989_ VDD VSS MUX2_X1
X_18939_ _12988_ _12989_ _10593_ _12990_ VDD VSS MUX2_X1
X_18940_ _00922_ _00924_ _10857_ _12991_ VDD VSS MUX2_X1
X_18941_ _00923_ _00925_ _10857_ _12992_ VDD VSS MUX2_X1
X_18942_ _12991_ _12992_ _10593_ _12993_ VDD VSS MUX2_X1
X_18943_ _12990_ _12993_ _10568_ _12994_ VDD VSS MUX2_X1
X_18944_ _10751_ _12994_ _12995_ VDD VSS NOR2_X1
X_18945_ _00934_ _00936_ _11641_ _12996_ VDD VSS MUX2_X1
X_18946_ _00935_ _00937_ _11641_ _12997_ VDD VSS MUX2_X1
X_18947_ _12996_ _12997_ _10861_ _12998_ VDD VSS MUX2_X1
X_18948_ _00926_ _00928_ _11641_ _12999_ VDD VSS MUX2_X1
X_18949_ _00927_ _00929_ _11641_ _13000_ VDD VSS MUX2_X1
X_18950_ _12999_ _13000_ _10861_ _13001_ VDD VSS MUX2_X1
X_18951_ _12998_ _13001_ _11662_ _13002_ VDD VSS MUX2_X1
X_18952_ _10608_ _13002_ _13003_ VDD VSS NOR2_X1
X_18953_ _10783_ _12995_ _13003_ _13004_ VDD VSS NOR3_X4
X_18954_ _00914_ _00916_ _11362_ _13005_ VDD VSS MUX2_X1
X_18955_ _11534_ _13005_ _13006_ VDD VSS NOR2_X1
X_18956_ _00915_ _00917_ _12498_ _13007_ VDD VSS MUX2_X1
X_18957_ _10579_ _13007_ _13008_ VDD VSS NOR2_X1
X_18958_ _10827_ _13006_ _13008_ _13009_ VDD VSS NOR3_X1
X_18959_ _11567_ gen_regfile_ff.register_file_i.rf_reg\[56\]
+ _13010_ VDD VSS NOR2_X1
X_18960_ _13010_ _00909_ _11771_ _13011_ VDD VSS AOI21_X1
X_18961_ _10764_ _12956_ _10822_ _13011_ _10786_ _13012_ VDD
+ VSS AOI221_X2
X_18962_ _10832_ _13009_ _13012_ _13013_ VDD VSS NOR3_X2
X_18963_ _00918_ _00920_ _10790_ _13014_ VDD VSS MUX2_X1
X_18964_ _00919_ _00921_ _11776_ _13015_ VDD VSS MUX2_X1
X_18965_ _13014_ _13015_ _10839_ _13016_ VDD VSS MUX2_X1
X_18966_ _00910_ _00912_ _11776_ _13017_ VDD VSS MUX2_X1
X_18967_ _00911_ _00913_ _11776_ _13018_ VDD VSS MUX2_X1
X_18968_ _13017_ _13018_ _10839_ _13019_ VDD VSS MUX2_X1
X_18969_ _13016_ _13019_ _11662_ _13020_ VDD VSS MUX2_X1
X_18970_ _11775_ _13020_ _13021_ VDD VSS NOR2_X2
X_18971_ _11370_ _13013_ _13021_ _13022_ VDD VSS NOR3_X4
X_18972_ _13004_ _13022_ _13023_ VDD VSS OR2_X2
X_18973_ cs_registers_i.pc_id_i\[24\] _13024_ VDD VSS BUF_X1
X_18974_ _13024_ _10564_ _13025_ VDD VSS NAND2_X1
X_18975_ _12987_ _13023_ _10814_ _13025_ _10747_ _16033_ VDD
+ VSS OAI221_X2
X_18976_ _16033_ _16029_ VDD VSS INV_X2
X_18977_ _12613_ _12614_ _10873_ _13026_ VDD VSS AOI21_X1
X_18978_ _00945_ _00947_ _12112_ _13027_ VDD VSS MUX2_X1
X_18979_ _11956_ _13027_ _13028_ VDD VSS NOR2_X1
X_18980_ _00946_ _00948_ _12112_ _13029_ VDD VSS MUX2_X1
X_18981_ _10697_ _13029_ _13030_ VDD VSS NOR2_X1
X_18982_ _11932_ _13028_ _13030_ _13031_ VDD VSS NOR3_X1
X_18983_ _00939_ _13032_ VDD VSS INV_X1
X_18984_ _11978_ gen_regfile_ff.register_file_i.rf_reg\[57\]
+ _13033_ VDD VSS NOR2_X1
X_18985_ _13033_ _00940_ _11939_ _13034_ VDD VSS AOI21_X1
X_18986_ _10468_ _13032_ _11949_ _13034_ _12207_ _13035_ VDD
+ VSS AOI221_X2
X_18987_ _12649_ _13031_ _13035_ _13036_ VDD VSS NOR3_X1
X_18988_ _00949_ _00951_ _12111_ _13037_ VDD VSS MUX2_X1
X_18989_ _00950_ _00952_ _12794_ _13038_ VDD VSS MUX2_X1
X_18990_ _13037_ _13038_ _12796_ _13039_ VDD VSS MUX2_X1
X_18991_ _00941_ _00943_ _12794_ _13040_ VDD VSS MUX2_X1
X_18992_ _00942_ _00944_ _11943_ _13041_ VDD VSS MUX2_X1
X_18993_ _13040_ _13041_ _11955_ _13042_ VDD VSS MUX2_X1
X_18994_ _13039_ _13042_ _12124_ _13043_ VDD VSS MUX2_X1
X_18995_ _12117_ _13043_ _13044_ VDD VSS NOR2_X1
X_18996_ _11991_ _13036_ _13044_ _13045_ VDD VSS NOR3_X2
X_18997_ _00961_ _00963_ _12804_ _13046_ VDD VSS MUX2_X1
X_18998_ _00962_ _00964_ _12806_ _13047_ VDD VSS MUX2_X1
X_18999_ _13046_ _13047_ _12808_ _13048_ VDD VSS MUX2_X1
X_19000_ _00953_ _00955_ _12806_ _13049_ VDD VSS MUX2_X1
X_19001_ _00954_ _00956_ _12811_ _13050_ VDD VSS MUX2_X1
X_19002_ _13049_ _13050_ net384 _13051_ VDD VSS MUX2_X1
X_19003_ _13048_ _13051_ _12017_ _13052_ VDD VSS MUX2_X1
X_19004_ _00965_ _00967_ _12806_ _13053_ VDD VSS MUX2_X1
X_19005_ _00966_ _00968_ _12356_ _13054_ VDD VSS MUX2_X1
X_19006_ _13053_ _13054_ net384 _13055_ VDD VSS MUX2_X1
X_19007_ _00957_ _00959_ _12356_ _13056_ VDD VSS MUX2_X1
X_19008_ _00958_ _00960_ _12356_ _13057_ VDD VSS MUX2_X1
X_19009_ _13056_ _13057_ net384 _13058_ VDD VSS MUX2_X1
X_19010_ _13055_ _13058_ _12005_ _13059_ VDD VSS MUX2_X1
X_19011_ _13052_ _13059_ _11930_ _13060_ VDD VSS MUX2_X2
X_19012_ _13045_ _11992_ _13060_ _13061_ VDD VSS AOI21_X4
X_19013_ _11921_ _11994_ _13061_ _13062_ VDD VSS OAI21_X1
X_19014_ _13026_ _13062_ _16037_ VDD VSS NOR2_X2
X_19015_ cs_registers_i.pc_id_i\[25\] _10563_ _10682_ _13063_
+ VDD VSS AND3_X1
X_19016_ _00965_ _00967_ _11385_ _13064_ VDD VSS MUX2_X1
X_19017_ _00966_ _00968_ _11385_ _13065_ VDD VSS MUX2_X1
X_19018_ _13064_ _13065_ _11383_ _13066_ VDD VSS MUX2_X1
X_19019_ _00957_ _00959_ _11385_ _13067_ VDD VSS MUX2_X1
X_19020_ _00958_ _00960_ _11385_ _13068_ VDD VSS MUX2_X1
X_19021_ _13067_ _13068_ _11383_ _13069_ VDD VSS MUX2_X1
X_19022_ _13066_ _13069_ _10568_ _13070_ VDD VSS MUX2_X1
X_19023_ _11676_ _13070_ _13071_ VDD VSS NAND2_X1
X_19024_ _00961_ _00963_ _11362_ _13072_ VDD VSS MUX2_X1
X_19025_ _00962_ _00964_ _11362_ _13073_ VDD VSS MUX2_X1
X_19026_ _13072_ _13073_ _10839_ _13074_ VDD VSS MUX2_X1
X_19027_ _00955_ _00956_ _10795_ _13075_ VDD VSS MUX2_X1
X_19028_ _00953_ _00954_ _10786_ _13076_ VDD VSS MUX2_X1
X_19029_ _10643_ _13074_ _13075_ _10794_ _13076_ _10785_ _13077_
+ VDD VSS AOI222_X2
X_19030_ _10575_ _13071_ _13077_ _13078_ VDD VSS AOI21_X4
X_19031_ _00945_ _00947_ _12498_ _13079_ VDD VSS MUX2_X1
X_19032_ _10594_ _13079_ _13080_ VDD VSS NOR2_X1
X_19033_ _00946_ _00948_ _11567_ _13081_ VDD VSS MUX2_X1
X_19034_ _10579_ _13081_ _13082_ VDD VSS NOR2_X1
X_19035_ _10827_ _13080_ _13082_ _13083_ VDD VSS NOR3_X1
X_19036_ _10618_ gen_regfile_ff.register_file_i.rf_reg\[57\]
+ _13084_ VDD VSS NOR2_X1
X_19037_ _13084_ _00940_ _11545_ _13085_ VDD VSS AOI21_X1
X_19038_ _10764_ _13032_ _10821_ _13085_ _10626_ _13086_ VDD
+ VSS AOI221_X2
X_19039_ _10832_ _13083_ _13086_ _13087_ VDD VSS NOR3_X2
X_19040_ _00949_ _00951_ _11655_ _13088_ VDD VSS MUX2_X1
X_19041_ _00950_ _00952_ _11655_ _13089_ VDD VSS MUX2_X1
X_19042_ _13088_ _13089_ _10833_ _13090_ VDD VSS MUX2_X1
X_19043_ _00941_ _00943_ _11655_ _13091_ VDD VSS MUX2_X1
X_19044_ _00942_ _00944_ _11655_ _13092_ VDD VSS MUX2_X1
X_19045_ _13091_ _13092_ _10833_ _13093_ VDD VSS MUX2_X1
X_19046_ _13090_ _13093_ _10567_ _13094_ VDD VSS MUX2_X1
X_19047_ _11775_ _13094_ _13095_ VDD VSS NOR2_X1
X_19048_ _11370_ _13087_ _13095_ _13096_ VDD VSS NOR3_X4
X_19049_ _13078_ _13096_ _13097_ VDD VSS NOR2_X4
X_19050_ _13063_ _13097_ _10816_ id_stage_i.controller_i.lsu_addr_last_i\[25\]
+ _11632_ _13098_ VDD VSS AOI221_X2
X_19051_ _13098_ _16040_ VDD VSS BUF_X4
X_19052_ _15470_ _13099_ VDD VSS CLKBUF_X2
X_19053_ _15461_ _13100_ VDD VSS INV_X1
X_19054_ _15457_ _15453_ _15458_ _13101_ VDD VSS AOI21_X1
X_19055_ _13100_ _13101_ _12937_ _13102_ VDD VSS OAI21_X1
X_19056_ _15466_ _13103_ VDD VSS CLKBUF_X2
X_19057_ _15465_ _13102_ _13103_ _13104_ VDD VSS AOI21_X2
X_19058_ _15458_ _15462_ _13105_ VDD VSS NAND2_X1
X_19059_ _12762_ _13105_ _13106_ VDD VSS NOR2_X1
X_19060_ _13103_ _12769_ _13106_ _13107_ VDD VSS AND3_X1
X_19061_ _12429_ _13107_ _13108_ VDD VSS NAND2_X1
X_19062_ _13103_ _13106_ _13109_ VDD VSS NAND2_X1
X_19063_ _13104_ _12437_ _13108_ _12767_ _13109_ _13110_ VDD
+ VSS OAI221_X2
X_19064_ _13110_ _13099_ _13111_ VDD VSS XNOR2_X2
X_19065_ _13111_ alu_adder_result_ex\[25\] VDD VSS INV_X4
X_19066_ _15453_ _15449_ _12761_ _13112_ VDD VSS AOI21_X1
X_19067_ _12938_ _13112_ _12943_ _13113_ VDD VSS OAI21_X1
X_19068_ _15461_ _13113_ _15462_ _13114_ VDD VSS AOI21_X1
X_19069_ _12766_ _13106_ _13115_ VDD VSS NAND2_X1
X_19070_ _12774_ _12592_ _12593_ _13116_ VDD VSS AOI21_X1
X_19071_ _13114_ _13115_ _13116_ _13117_ VDD VSS OAI21_X1
X_19072_ _12773_ _13114_ _13118_ VDD VSS NAND2_X1
X_19073_ _12603_ _12605_ _12609_ _13119_ VDD VSS NAND3_X1
X_19074_ _13117_ _13118_ _13119_ _13120_ VDD VSS OAI21_X1
X_19075_ _13103_ _13120_ _13121_ VDD VSS XNOR2_X2
X_19076_ _13121_ alu_adder_result_ex\[24\] VDD VSS BUF_X4
X_19077_ _12613_ _12614_ _10874_ _13122_ VDD VSS AOI21_X1
X_19078_ _00976_ _00978_ _12804_ _13123_ VDD VSS MUX2_X1
X_19079_ _00977_ _00979_ _12806_ _13124_ VDD VSS MUX2_X1
X_19080_ _13123_ _13124_ _12808_ _13125_ VDD VSS MUX2_X1
X_19081_ _12041_ _13125_ _13126_ VDD VSS NAND2_X1
X_19082_ _11953_ _00971_ _13127_ VDD VSS NAND2_X1
X_19083_ _13127_ gen_regfile_ff.register_file_i.rf_reg\[58\]
+ _12034_ _13128_ VDD VSS OAI21_X1
X_19084_ _12200_ _00970_ _10716_ _13128_ _11942_ _13129_ VDD
+ VSS OAI221_X1
X_19085_ _12449_ _13126_ _13129_ _13130_ VDD VSS AND3_X1
X_19086_ _00980_ _00982_ _12111_ _13131_ VDD VSS MUX2_X1
X_19087_ _00981_ _00983_ _12111_ _13132_ VDD VSS MUX2_X1
X_19088_ _13131_ _13132_ _12796_ _13133_ VDD VSS MUX2_X1
X_19089_ _00972_ _00974_ _12794_ _13134_ VDD VSS MUX2_X1
X_19090_ _00973_ _00975_ _12794_ _13135_ VDD VSS MUX2_X1
X_19091_ _13134_ _13135_ _12796_ _13136_ VDD VSS MUX2_X1
X_19092_ _13133_ _13136_ _12124_ _13137_ VDD VSS MUX2_X1
X_19093_ _12117_ _13137_ _13138_ VDD VSS NOR2_X1
X_19094_ _11991_ _13130_ _13138_ _13139_ VDD VSS NOR3_X2
X_19095_ _00992_ _00994_ _12010_ _13140_ VDD VSS MUX2_X1
X_19096_ _00993_ _00995_ _12804_ _13141_ VDD VSS MUX2_X1
X_19097_ _13140_ _13141_ net385 _13142_ VDD VSS MUX2_X1
X_19098_ _00984_ _00986_ _12804_ _13143_ VDD VSS MUX2_X1
X_19099_ _00985_ _00987_ _12806_ _13144_ VDD VSS MUX2_X1
X_19100_ _13143_ _13144_ _12808_ _13145_ VDD VSS MUX2_X1
X_19101_ _13142_ _13145_ _12017_ _13146_ VDD VSS MUX2_X1
X_19102_ _00996_ _00998_ _12804_ _13147_ VDD VSS MUX2_X1
X_19103_ _00997_ _00999_ _12811_ _13148_ VDD VSS MUX2_X1
X_19104_ _13147_ _13148_ _12808_ _13149_ VDD VSS MUX2_X1
X_19105_ _00988_ _00990_ _12811_ _13150_ VDD VSS MUX2_X1
X_19106_ _00989_ _00991_ _12356_ _13151_ VDD VSS MUX2_X1
X_19107_ _13150_ _13151_ net384 _13152_ VDD VSS MUX2_X1
X_19108_ _13149_ _13152_ _12005_ _13153_ VDD VSS MUX2_X1
X_19109_ _13146_ _13153_ _11930_ _13154_ VDD VSS MUX2_X2
X_19110_ _13139_ _11929_ _13154_ _13155_ VDD VSS AOI21_X4
X_19111_ _11921_ _11994_ _13155_ _13156_ VDD VSS OAI21_X1
X_19112_ _13122_ _13156_ _16048_ VDD VSS NOR2_X2
X_19113_ _00976_ _00978_ _10600_ _13157_ VDD VSS MUX2_X1
X_19114_ _00977_ _00979_ _10600_ _13158_ VDD VSS MUX2_X1
X_19115_ _13157_ _13158_ _10628_ _13159_ VDD VSS MUX2_X1
X_19116_ _10831_ _13159_ _10766_ _13160_ VDD VSS AOI21_X1
X_19117_ _10615_ _00971_ _13161_ VDD VSS NAND2_X1
X_19118_ _13161_ gen_regfile_ff.register_file_i.rf_reg\[58\]
+ _10602_ _13162_ VDD VSS OAI21_X1
X_19119_ _00970_ _10757_ _13162_ _10581_ _13163_ VDD VSS OAI22_X1
X_19120_ _13160_ _13163_ _11533_ _13164_ VDD VSS OAI21_X1
X_19121_ _00992_ _00994_ _10613_ _13165_ VDD VSS MUX2_X1
X_19122_ _00993_ _00995_ _10613_ _13166_ VDD VSS MUX2_X1
X_19123_ _13165_ _13166_ _11877_ _13167_ VDD VSS MUX2_X1
X_19124_ _00984_ _00986_ _10613_ _13168_ VDD VSS MUX2_X1
X_19125_ _00985_ _00987_ _10613_ _13169_ VDD VSS MUX2_X1
X_19126_ _13168_ _13169_ _11877_ _13170_ VDD VSS MUX2_X1
X_19127_ _13167_ _13170_ _10828_ _13171_ VDD VSS MUX2_X2
X_19128_ _00996_ _00998_ _10612_ _13172_ VDD VSS MUX2_X1
X_19129_ _00997_ _00999_ _10612_ _13173_ VDD VSS MUX2_X1
X_19130_ _13172_ _13173_ _10843_ _13174_ VDD VSS MUX2_X1
X_19131_ _00988_ _00990_ _10612_ _13175_ VDD VSS MUX2_X1
X_19132_ _00989_ _00991_ _10612_ _13176_ VDD VSS MUX2_X1
X_19133_ _13175_ _13176_ _10843_ _13177_ VDD VSS MUX2_X1
X_19134_ _13174_ _13177_ _11357_ _13178_ VDD VSS MUX2_X1
X_19135_ _00980_ _00982_ _10612_ _13179_ VDD VSS MUX2_X1
X_19136_ _00981_ _00983_ _10612_ _13180_ VDD VSS MUX2_X1
X_19137_ _13179_ _13180_ _10843_ _13181_ VDD VSS MUX2_X1
X_19138_ _00972_ _00974_ _10612_ _13182_ VDD VSS MUX2_X1
X_19139_ _00973_ _00975_ _10612_ _13183_ VDD VSS MUX2_X1
X_19140_ _13182_ _13183_ _10843_ _13184_ VDD VSS MUX2_X1
X_19141_ _13181_ _13184_ _11357_ _13185_ VDD VSS MUX2_X1
X_19142_ _13178_ _13185_ _10575_ _13186_ VDD VSS MUX2_X1
X_19143_ _13164_ _13171_ _11371_ _10609_ _13186_ _13187_ VDD
+ VSS OAI221_X2
X_19144_ cs_registers_i.pc_id_i\[26\] _11593_ _13188_ VDD
+ VSS AND2_X1
X_19145_ id_stage_i.controller_i.lsu_addr_last_i\[26\] _10397_
+ _11596_ net355 _13188_ _10870_ _16045_ VDD VSS AOI222_X4
X_19146_ _12613_ _12614_ _10500_ _13189_ VDD VSS AOI21_X1
X_19147_ net363 _13190_ VDD VSS BUF_X4
X_19148_ _01007_ _01009_ _13190_ _13191_ VDD VSS MUX2_X1
X_19149_ _01008_ _01010_ _12008_ _13192_ VDD VSS MUX2_X1
X_19150_ _11933_ _13193_ VDD VSS BUF_X4
X_19151_ _13191_ _13192_ _13193_ _13194_ VDD VSS MUX2_X1
X_19152_ _12041_ _13194_ _13195_ VDD VSS NAND2_X1
X_19153_ _11953_ _01002_ _13196_ VDD VSS NAND2_X1
X_19154_ _13196_ gen_regfile_ff.register_file_i.rf_reg\[59\]
+ _12034_ _13197_ VDD VSS OAI21_X1
X_19155_ _12200_ _01001_ _10716_ _13197_ _11942_ _13198_ VDD
+ VSS OAI221_X1
X_19156_ _12449_ _13195_ _13198_ _13199_ VDD VSS AND3_X1
X_19157_ _01011_ _01013_ _12628_ _13200_ VDD VSS MUX2_X1
X_19158_ _01012_ _01014_ _12704_ _13201_ VDD VSS MUX2_X1
X_19159_ _13200_ _13201_ _12630_ _13202_ VDD VSS MUX2_X1
X_19160_ _01003_ _01005_ _12704_ _13203_ VDD VSS MUX2_X1
X_19161_ _01004_ _01006_ _12111_ _13204_ VDD VSS MUX2_X1
X_19162_ _13203_ _13204_ _12796_ _13205_ VDD VSS MUX2_X1
X_19163_ _13202_ _13205_ _12124_ _13206_ VDD VSS MUX2_X1
X_19164_ _12117_ _13206_ _13207_ VDD VSS NOR2_X1
X_19165_ _11928_ _13199_ _13207_ _13208_ VDD VSS NOR3_X2
X_19166_ _01023_ _01025_ net676 _13209_ VDD VSS MUX2_X1
X_19167_ _01024_ _01026_ net677 _13210_ VDD VSS MUX2_X1
X_19168_ _13209_ _13210_ _12693_ _13211_ VDD VSS MUX2_X1
X_19169_ _01015_ _01017_ _12691_ _13212_ VDD VSS MUX2_X1
X_19170_ _01016_ _01018_ _13190_ _13213_ VDD VSS MUX2_X1
X_19171_ _13212_ _13213_ _13193_ _13214_ VDD VSS MUX2_X1
X_19172_ _13211_ _13214_ _11969_ _13215_ VDD VSS MUX2_X1
X_19173_ _01027_ _01029_ _12691_ _13216_ VDD VSS MUX2_X1
X_19174_ _01028_ _01030_ _13190_ _13217_ VDD VSS MUX2_X1
X_19175_ _13216_ _13217_ _13193_ _13218_ VDD VSS MUX2_X1
X_19176_ _01019_ _01021_ _13190_ _13219_ VDD VSS MUX2_X1
X_19177_ _01020_ _01022_ _12008_ _13220_ VDD VSS MUX2_X1
X_19178_ _13219_ _13220_ net385 _13221_ VDD VSS MUX2_X1
X_19179_ _13218_ _13221_ _12017_ _13222_ VDD VSS MUX2_X1
X_19180_ _13215_ _13222_ _12649_ _13223_ VDD VSS MUX2_X1
X_19181_ _13208_ _11929_ _13223_ _13224_ VDD VSS AOI21_X4
X_19182_ _11921_ _11994_ _13224_ _13225_ VDD VSS OAI21_X1
X_19183_ _13189_ _13225_ _16053_ VDD VSS NOR2_X2
X_19184_ cs_registers_i.pc_id_i\[27\] _10564_ _13226_ VDD
+ VSS AND2_X1
X_19185_ id_stage_i.controller_i.lsu_addr_last_i\[27\] _10397_
+ _10683_ _13226_ _13227_ VDD VSS AOI22_X4
X_19186_ _10622_ _01002_ _13228_ VDD VSS NAND2_X1
X_19187_ _13228_ gen_regfile_ff.register_file_i.rf_reg\[59\]
+ _10616_ _13229_ VDD VSS OAI21_X1
X_19188_ _10576_ _01001_ _10758_ _13229_ _10582_ _13230_ VDD
+ VSS OAI221_X1
X_19189_ _01015_ _01017_ _11547_ _13231_ VDD VSS MUX2_X1
X_19190_ _01016_ _01018_ _11547_ _13232_ VDD VSS MUX2_X1
X_19191_ _13231_ _13232_ _10596_ _13233_ VDD VSS MUX2_X1
X_19192_ _11437_ _13233_ _10749_ _13234_ VDD VSS AOI21_X1
X_19193_ _13230_ _13234_ _13235_ VDD VSS NAND2_X1
X_19194_ _01023_ _01025_ _10587_ _13236_ VDD VSS MUX2_X1
X_19195_ _01024_ _01026_ _10587_ _13237_ VDD VSS MUX2_X1
X_19196_ _13236_ _13237_ _10788_ _13238_ VDD VSS MUX2_X1
X_19197_ _01007_ _01009_ _10620_ _13239_ VDD VSS MUX2_X1
X_19198_ _01008_ _01010_ _10620_ _13240_ VDD VSS MUX2_X1
X_19199_ _13239_ _13240_ _10788_ _13241_ VDD VSS MUX2_X1
X_19200_ _13238_ _13241_ _10783_ _13242_ VDD VSS MUX2_X1
X_19201_ _01027_ _01029_ _10585_ _13243_ VDD VSS MUX2_X1
X_19202_ _01028_ _01030_ _10585_ _13244_ VDD VSS MUX2_X1
X_19203_ _13243_ _13244_ _10787_ _13245_ VDD VSS MUX2_X1
X_19204_ _01011_ _01013_ _10585_ _13246_ VDD VSS MUX2_X1
X_19205_ _01012_ _01014_ _10585_ _13247_ VDD VSS MUX2_X1
X_19206_ _13246_ _13247_ _10787_ _13248_ VDD VSS MUX2_X1
X_19207_ _13245_ _13248_ _10574_ _13249_ VDD VSS MUX2_X1
X_19208_ _01019_ _01021_ _10585_ _13250_ VDD VSS MUX2_X1
X_19209_ _01020_ _01022_ _10585_ _13251_ VDD VSS MUX2_X1
X_19210_ _13250_ _13251_ _10787_ _13252_ VDD VSS MUX2_X1
X_19211_ _01003_ _01005_ _10585_ _13253_ VDD VSS MUX2_X1
X_19212_ _01004_ _01006_ _10619_ _13254_ VDD VSS MUX2_X1
X_19213_ _13253_ _13254_ _10787_ _13255_ VDD VSS MUX2_X1
X_19214_ _13252_ _13255_ _10574_ _13256_ VDD VSS MUX2_X1
X_19215_ _13249_ _13256_ _10570_ _13257_ VDD VSS MUX2_X1
X_19216_ _13235_ _11453_ _13242_ _13257_ _10610_ _13258_ VDD
+ VSS OAI221_X2
X_19217_ net349 _13259_ VDD VSS INV_X2
X_19218_ _13227_ _13259_ _10814_ _16052_ VDD VSS OAI21_X4
X_19219_ _16052_ _16056_ VDD VSS INV_X2
X_19220_ _15478_ _13260_ VDD VSS INV_X2
X_19221_ _13104_ _13109_ _12767_ _13261_ VDD VSS OAI21_X1
X_19222_ _15474_ _13262_ VDD VSS CLKBUF_X3
X_19223_ _13099_ _13262_ _13263_ VDD VSS AND2_X2
X_19224_ _15473_ _13261_ _13263_ _15469_ _13262_ _13264_ VDD
+ VSS AOI221_X2
X_19225_ _12429_ _13107_ _13263_ _13265_ VDD VSS NAND3_X2
X_19226_ _13264_ _12437_ _13265_ _13266_ VDD VSS OAI21_X4
X_19227_ _13266_ _13260_ alu_adder_result_ex\[27\] VDD VSS
+ XNOR2_X2
X_19228_ _13099_ _13107_ _13267_ VDD VSS AND2_X1
X_19229_ _13262_ _13267_ _13268_ VDD VSS NAND2_X1
X_19230_ _12609_ _13268_ _13269_ VDD VSS NOR2_X1
X_19231_ _13262_ _13267_ _13270_ VDD VSS NOR2_X1
X_19232_ _15469_ _15465_ _13099_ _13271_ VDD VSS AOI21_X1
X_19233_ _13271_ _13272_ VDD VSS INV_X1
X_19234_ _13103_ _13099_ _13273_ VDD VSS AND2_X1
X_19235_ _13100_ _12946_ _13105_ _12938_ _12937_ _13274_ VDD
+ VSS OAI221_X2
X_19236_ _13272_ _13273_ _13274_ _13275_ VDD VSS AOI21_X2
X_19237_ _13262_ _13270_ _13275_ _13276_ VDD VSS MUX2_X1
X_19238_ _13268_ _12605_ _12603_ _13277_ VDD VSS AOI21_X2
X_19239_ _13262_ _13278_ VDD VSS INV_X1
X_19240_ _13278_ _13275_ _13279_ VDD VSS AND2_X1
X_19241_ _12603_ _12605_ _12609_ _13279_ _13280_ VDD VSS AND4_X1
X_19242_ _13269_ _13280_ _13277_ _13276_ alu_adder_result_ex\[26\]
+ VDD VSS NOR4_X4
X_19243_ _12613_ _12614_ _10501_ _13281_ VDD VSS AOI21_X1
X_19244_ _01038_ _01040_ net677 _13282_ VDD VSS MUX2_X1
X_19245_ _01039_ _01041_ _12008_ _13283_ VDD VSS MUX2_X1
X_19246_ _13282_ _13283_ _13193_ _13284_ VDD VSS MUX2_X1
X_19247_ _12041_ _13284_ _13285_ VDD VSS NAND2_X1
X_19248_ _11953_ _01033_ _13286_ VDD VSS NAND2_X1
X_19249_ _13286_ gen_regfile_ff.register_file_i.rf_reg\[60\]
+ _12034_ _13287_ VDD VSS OAI21_X1
X_19250_ _12200_ _01032_ _10716_ _13287_ _11942_ _13288_ VDD
+ VSS OAI221_X1
X_19251_ _12449_ _13285_ _13288_ _13289_ VDD VSS AND3_X1
X_19252_ _01042_ _01044_ _12628_ _13290_ VDD VSS MUX2_X1
X_19253_ _01043_ _01045_ _12704_ _13291_ VDD VSS MUX2_X1
X_19254_ _13290_ _13291_ _12630_ _13292_ VDD VSS MUX2_X1
X_19255_ _01034_ _01036_ _12704_ _13293_ VDD VSS MUX2_X1
X_19256_ _01035_ _01037_ _12704_ _13294_ VDD VSS MUX2_X1
X_19257_ _13293_ _13294_ _12630_ _13295_ VDD VSS MUX2_X1
X_19258_ _13292_ _13295_ _12124_ _13296_ VDD VSS MUX2_X1
X_19259_ _12449_ _13296_ _13297_ VDD VSS NOR2_X1
X_19260_ _11928_ _13289_ _13297_ _13298_ VDD VSS NOR3_X2
X_19261_ _01054_ _01056_ net676 _13299_ VDD VSS MUX2_X1
X_19262_ _01055_ _01057_ net678 _13300_ VDD VSS MUX2_X1
X_19263_ _13299_ _13300_ _12693_ _13301_ VDD VSS MUX2_X1
X_19264_ _01046_ _01048_ net678 _13302_ VDD VSS MUX2_X1
X_19265_ _01047_ _01049_ _13190_ _13303_ VDD VSS MUX2_X1
X_19266_ _13302_ _13303_ _13193_ _13304_ VDD VSS MUX2_X1
X_19267_ _13301_ _13304_ _11969_ _13305_ VDD VSS MUX2_X1
X_19268_ _01058_ _01060_ net677 _13306_ VDD VSS MUX2_X1
X_19269_ _01059_ _01061_ _13190_ _13307_ VDD VSS MUX2_X1
X_19270_ _13306_ _13307_ _13193_ _13308_ VDD VSS MUX2_X1
X_19271_ _01050_ _01052_ _13190_ _13309_ VDD VSS MUX2_X1
X_19272_ _01051_ _01053_ _12008_ _13310_ VDD VSS MUX2_X1
X_19273_ _13309_ _13310_ net385 _13311_ VDD VSS MUX2_X1
X_19274_ _13308_ _13311_ _12017_ _13312_ VDD VSS MUX2_X1
X_19275_ _13305_ _13312_ _12649_ _13313_ VDD VSS MUX2_X2
X_19276_ _13298_ _13313_ _11929_ _13314_ VDD VSS AOI21_X4
X_19277_ _11921_ _11994_ _13314_ _03093_ VDD VSS OAI21_X1
X_19278_ _13281_ _03093_ _16061_ VDD VSS NOR2_X2
X_19279_ id_stage_i.controller_i.lsu_addr_last_i\[28\] _10397_
+ _03094_ VDD VSS NAND2_X1
X_19280_ _01038_ _01040_ _10601_ _03095_ VDD VSS MUX2_X1
X_19281_ _01039_ _01041_ _10601_ _03096_ VDD VSS MUX2_X1
X_19282_ _03095_ _03096_ _10596_ _03097_ VDD VSS MUX2_X1
X_19283_ _10767_ _03097_ _03098_ VDD VSS NAND2_X1
X_19284_ _10622_ _01033_ _03099_ VDD VSS NAND2_X1
X_19285_ _03099_ gen_regfile_ff.register_file_i.rf_reg\[60\]
+ _10616_ _03100_ VDD VSS OAI21_X1
X_19286_ _10571_ _01032_ _10758_ _03100_ _10581_ _03101_ VDD
+ VSS OAI221_X2
X_19287_ _10610_ _03098_ _03101_ _03102_ VDD VSS NAND3_X2
X_19288_ _01042_ _01044_ _11547_ _03103_ VDD VSS MUX2_X1
X_19289_ _01043_ _01045_ _11547_ _03104_ VDD VSS MUX2_X1
X_19290_ _03103_ _03104_ _10596_ _03105_ VDD VSS MUX2_X1
X_19291_ _11533_ _03105_ _03106_ VDD VSS NAND2_X1
X_19292_ _01034_ _01036_ _11547_ _03107_ VDD VSS MUX2_X1
X_19293_ _01035_ _01037_ _11547_ _03108_ VDD VSS MUX2_X1
X_19294_ _03107_ _03108_ _10596_ _03109_ VDD VSS MUX2_X1
X_19295_ _10571_ _03109_ _03110_ VDD VSS NAND2_X1
X_19296_ _10752_ _03106_ _03110_ _03111_ VDD VSS NAND3_X2
X_19297_ _10750_ _03102_ _03111_ _03112_ VDD VSS AOI21_X4
X_19298_ _01050_ _01052_ _10587_ _03113_ VDD VSS MUX2_X1
X_19299_ _01051_ _01053_ _10587_ _03114_ VDD VSS MUX2_X1
X_19300_ _03113_ _03114_ _10628_ _03115_ VDD VSS MUX2_X1
X_19301_ _01048_ _01049_ _11535_ _03116_ VDD VSS MUX2_X1
X_19302_ _01046_ _01047_ _11366_ _03117_ VDD VSS MUX2_X1
X_19303_ _10778_ _03115_ _03116_ _10794_ _03117_ _10785_ _03118_
+ VDD VSS AOI222_X2
X_19304_ _10749_ _03118_ _03119_ VDD VSS NAND2_X1
X_19305_ _01060_ _01061_ _11534_ _03120_ VDD VSS MUX2_X1
X_19306_ _11775_ _03120_ _10602_ _03121_ VDD VSS AOI21_X2
X_19307_ _01056_ _01057_ _10862_ _03122_ VDD VSS MUX2_X1
X_19308_ _10606_ _03122_ _10621_ _03123_ VDD VSS AOI21_X2
X_19309_ _10759_ _03121_ _03123_ _03124_ VDD VSS OAI21_X2
X_19310_ _01054_ _01055_ _10627_ _03125_ VDD VSS MUX2_X1
X_19311_ _03125_ _03126_ VDD VSS INV_X1
X_19312_ _01058_ _01059_ _11366_ _03127_ VDD VSS MUX2_X1
X_19313_ _03127_ _03128_ VDD VSS INV_X1
X_19314_ _10570_ _03123_ _03126_ _03128_ _03121_ _03129_ VDD
+ VSS AOI221_X2
X_19315_ _03119_ _03124_ _03129_ _03130_ VDD VSS AOI21_X4
X_19316_ _03112_ _03130_ _03131_ VDD VSS NOR2_X4
X_19317_ cs_registers_i.pc_id_i\[28\] _10565_ _03132_ VDD
+ VSS NAND2_X1
X_19318_ _03094_ _03131_ _10814_ _03132_ _10747_ _16060_ VDD
+ VSS OAI221_X2
X_19319_ _16060_ _16064_ VDD VSS INV_X4
X_19320_ _12613_ _12614_ _10502_ _03133_ VDD VSS AOI21_X1
X_19321_ _01069_ _01071_ net677 _03134_ VDD VSS MUX2_X1
X_19322_ _01070_ _01072_ _12008_ _03135_ VDD VSS MUX2_X1
X_19323_ _03134_ _03135_ _13193_ _03136_ VDD VSS MUX2_X1
X_19324_ _11948_ _03136_ _03137_ VDD VSS NAND2_X1
X_19325_ _11953_ _01064_ _03138_ VDD VSS NAND2_X1
X_19326_ _03138_ gen_regfile_ff.register_file_i.rf_reg\[61\]
+ _12034_ _03139_ VDD VSS OAI21_X1
X_19327_ _12200_ _01063_ _10716_ _03139_ _11942_ _03140_ VDD
+ VSS OAI221_X1
X_19328_ _12449_ _03137_ _03140_ _03141_ VDD VSS AND3_X1
X_19329_ _01073_ _01075_ _12628_ _03142_ VDD VSS MUX2_X1
X_19330_ _01074_ _01076_ _12704_ _03143_ VDD VSS MUX2_X1
X_19331_ _03142_ _03143_ _12630_ _03144_ VDD VSS MUX2_X1
X_19332_ _01065_ _01067_ _12704_ _03145_ VDD VSS MUX2_X1
X_19333_ _01066_ _01068_ _12704_ _03146_ VDD VSS MUX2_X1
X_19334_ _03145_ _03146_ _12630_ _03147_ VDD VSS MUX2_X1
X_19335_ _03144_ _03147_ _12124_ _03148_ VDD VSS MUX2_X1
X_19336_ _12449_ _03148_ _03149_ VDD VSS NOR2_X1
X_19337_ _11928_ _03141_ _03149_ _03150_ VDD VSS NOR3_X2
X_19338_ _01085_ _01087_ net676 _03151_ VDD VSS MUX2_X1
X_19339_ _01086_ _01088_ net678 _03152_ VDD VSS MUX2_X1
X_19340_ _03151_ _03152_ _12693_ _03153_ VDD VSS MUX2_X1
X_19341_ _01077_ _01079_ net678 _03154_ VDD VSS MUX2_X1
X_19342_ _01078_ _01080_ _13190_ _03155_ VDD VSS MUX2_X1
X_19343_ _03154_ _03155_ _13193_ _03156_ VDD VSS MUX2_X1
X_19344_ _03153_ _03156_ _11969_ _03157_ VDD VSS MUX2_X1
X_19345_ _01089_ _01091_ net677 _03158_ VDD VSS MUX2_X1
X_19346_ _01090_ _01092_ _13190_ _03159_ VDD VSS MUX2_X1
X_19347_ _03158_ _03159_ _13193_ _03160_ VDD VSS MUX2_X1
X_19348_ _01081_ _01083_ _13190_ _03161_ VDD VSS MUX2_X1
X_19349_ _01082_ _01084_ _12008_ _03162_ VDD VSS MUX2_X1
X_19350_ _03161_ _03162_ net385 _03163_ VDD VSS MUX2_X1
X_19351_ _03160_ _03163_ _11969_ _03164_ VDD VSS MUX2_X1
X_19352_ _03157_ _03164_ _12649_ _03165_ VDD VSS MUX2_X1
X_19353_ _03150_ _03165_ _11929_ _03166_ VDD VSS AOI21_X4
X_19354_ _11921_ _11994_ _03166_ _03167_ VDD VSS OAI21_X1
X_19355_ _03133_ _03167_ _16069_ VDD VSS NOR2_X2
X_19356_ _01069_ _01071_ _10602_ _03168_ VDD VSS MUX2_X1
X_19357_ _01070_ _01072_ _10602_ _03169_ VDD VSS MUX2_X1
X_19358_ _03168_ _03169_ _10597_ _03170_ VDD VSS MUX2_X1
X_19359_ _10767_ _03170_ _03171_ VDD VSS NAND2_X1
X_19360_ _10759_ _01064_ _03172_ VDD VSS NAND2_X1
X_19361_ _03172_ gen_regfile_ff.register_file_i.rf_reg\[61\]
+ _10759_ _03173_ VDD VSS OAI21_X1
X_19362_ _10571_ _01063_ _10758_ _03173_ _10582_ _03174_ VDD
+ VSS OAI221_X2
X_19363_ _10610_ _03171_ _03174_ _03175_ VDD VSS NAND3_X2
X_19364_ _01073_ _01075_ _10615_ _03176_ VDD VSS MUX2_X1
X_19365_ _01074_ _01076_ _10615_ _03177_ VDD VSS MUX2_X1
X_19366_ _03176_ _03177_ _10597_ _03178_ VDD VSS MUX2_X1
X_19367_ _10767_ _03178_ _03179_ VDD VSS NAND2_X1
X_19368_ _01065_ _01067_ _10615_ _03180_ VDD VSS MUX2_X1
X_19369_ _01066_ _01068_ _10615_ _03181_ VDD VSS MUX2_X1
X_19370_ _03180_ _03181_ _10629_ _03182_ VDD VSS MUX2_X1
X_19371_ _10571_ _03182_ _03183_ VDD VSS NAND2_X1
X_19372_ _10752_ _03179_ _03183_ _03184_ VDD VSS NAND3_X2
X_19373_ _10750_ _03175_ _03184_ _03185_ VDD VSS AOI21_X4
X_19374_ _01081_ _01083_ _10588_ _03186_ VDD VSS MUX2_X1
X_19375_ _01082_ _01084_ _10588_ _03187_ VDD VSS MUX2_X1
X_19376_ _03186_ _03187_ _10629_ _03188_ VDD VSS MUX2_X1
X_19377_ _01079_ _01080_ _10596_ _03189_ VDD VSS MUX2_X1
X_19378_ _01077_ _01078_ _10797_ _03190_ VDD VSS MUX2_X1
X_19379_ _10778_ _03188_ _03189_ _10794_ _03190_ _10785_ _03191_
+ VDD VSS AOI222_X2
X_19380_ _10750_ _03191_ _03192_ VDD VSS NAND2_X1
X_19381_ _01091_ _01092_ _10628_ _03193_ VDD VSS MUX2_X1
X_19382_ _10608_ _03193_ _10616_ _03194_ VDD VSS AOI21_X2
X_19383_ _01087_ _01088_ _11366_ _03195_ VDD VSS MUX2_X1
X_19384_ _11676_ _03195_ _10622_ _03196_ VDD VSS AOI21_X2
X_19385_ _10759_ _03194_ _03196_ _03197_ VDD VSS OAI21_X2
X_19386_ _01085_ _01086_ _10628_ _03198_ VDD VSS MUX2_X1
X_19387_ _03198_ _03199_ VDD VSS INV_X1
X_19388_ _01089_ _01090_ _10797_ _03200_ VDD VSS MUX2_X1
X_19389_ _03200_ _03201_ VDD VSS INV_X1
X_19390_ _10571_ _03196_ _03199_ _03201_ _03194_ _03202_ VDD
+ VSS AOI221_X2
X_19391_ _03192_ _03197_ _03202_ _03203_ VDD VSS AOI21_X4
X_19392_ _11596_ _03185_ _03203_ _03204_ VDD VSS OAI21_X2
X_19393_ cs_registers_i.pc_id_i\[29\] _10565_ _03205_ VDD
+ VSS NAND2_X1
X_19394_ id_stage_i.controller_i.lsu_addr_last_i\[29\] _03206_
+ VDD VSS INV_X1
X_19395_ _03204_ _03205_ _10747_ _10673_ _03206_ _16068_ VDD
+ VSS OAI221_X2
X_19396_ _16068_ _16072_ VDD VSS INV_X2
X_19397_ _15486_ _03207_ VDD VSS CLKBUF_X2
X_19398_ _03207_ _03208_ VDD VSS INV_X1
X_19399_ _15481_ _03209_ VDD VSS BUF_X2
X_19400_ _15477_ _03210_ VDD VSS INV_X1
X_19401_ _15473_ _15469_ _13262_ _03211_ VDD VSS AOI21_X1
X_19402_ _03210_ _03211_ _13260_ _03212_ VDD VSS OAI21_X1
X_19403_ _15482_ _03213_ VDD VSS BUF_X2
X_19404_ _03209_ _03212_ _03213_ _03214_ VDD VSS AOI21_X1
X_19405_ _03208_ _03214_ _03215_ VDD VSS NOR2_X1
X_19406_ _03213_ _03216_ VDD VSS INV_X1
X_19407_ _03216_ _03210_ _13260_ _03217_ VDD VSS AOI21_X1
X_19408_ _03207_ _03209_ _03217_ _03218_ VDD VSS NOR3_X2
X_19409_ _13260_ _03216_ _03208_ _03219_ VDD VSS NOR3_X2
X_19410_ net389 _13263_ _03219_ _03220_ VDD VSS AND3_X4
X_19411_ _03209_ _15477_ _03213_ _03221_ VDD VSS AOI21_X2
X_19412_ _03208_ _03211_ _03221_ _03222_ VDD VSS NAND3_X1
X_19413_ _03222_ _13263_ _13110_ _03223_ VDD VSS AOI21_X2
X_19414_ _03223_ _03218_ _03215_ _03220_ alu_adder_result_ex\[29\]
+ VDD VSS NOR4_X4
X_19415_ _15478_ _15473_ _13262_ _03224_ VDD VSS OAI21_X1
X_19416_ _03216_ _03210_ _03224_ _03225_ VDD VSS AND3_X1
X_19417_ _15473_ _03226_ VDD VSS INV_X1
X_19418_ _03210_ _03226_ _13260_ _03227_ VDD VSS OAI21_X2
X_19419_ _03225_ _03227_ _03213_ _03228_ VDD VSS AOI21_X2
X_19420_ _13262_ _15478_ _03213_ _03229_ VDD VSS NAND3_X2
X_19421_ _03228_ _03229_ _13275_ _03230_ VDD VSS OAI21_X1
X_19422_ _13272_ _03227_ _13274_ _13273_ _03231_ VDD VSS AOI211_X2
X_19423_ _03216_ _03231_ _03232_ VDD VSS AND2_X1
X_19424_ _12772_ _03230_ _03232_ _03233_ VDD VSS NOR3_X1
X_19425_ _12603_ _12605_ _03233_ _03234_ VDD VSS NAND3_X2
X_19426_ _13267_ _03230_ _03232_ _03235_ VDD VSS NOR3_X1
X_19427_ _12772_ _13267_ _03228_ _03229_ _03236_ VDD VSS AND4_X1
X_19428_ _03235_ _03236_ _03237_ VDD VSS NOR2_X1
X_19429_ _13267_ _03228_ _03229_ _03238_ VDD VSS NAND3_X2
X_19430_ _12602_ _11919_ _11916_ _03239_ VDD VSS OAI21_X2
X_19431_ _03234_ _03237_ _03238_ _03239_ alu_adder_result_ex\[28\]
+ VDD VSS OAI211_X4
X_19432_ _12612_ _11162_ _10498_ _03240_ VDD VSS AOI21_X1
X_19433_ _01100_ _01102_ _12112_ _03241_ VDD VSS MUX2_X1
X_19434_ _11956_ _03241_ _03242_ VDD VSS NOR2_X1
X_19435_ _01101_ _01103_ _11978_ _03243_ VDD VSS MUX2_X1
X_19436_ _10697_ _03243_ _03244_ VDD VSS NOR2_X1
X_19437_ _12029_ _03242_ _03244_ _03245_ VDD VSS NOR3_X1
X_19438_ _01094_ _03246_ VDD VSS INV_X1
X_19439_ _11952_ gen_regfile_ff.register_file_i.rf_reg\[62\]
+ _03247_ VDD VSS NOR2_X1
X_19440_ _03247_ _01095_ _11939_ _03248_ VDD VSS AOI21_X1
X_19441_ _10468_ _03246_ _10964_ _03248_ _12000_ _03249_ VDD
+ VSS AOI221_X2
X_19442_ _10432_ _03245_ _03249_ _03250_ VDD VSS NOR3_X1
X_19443_ _01104_ _01106_ _12628_ _03251_ VDD VSS MUX2_X1
X_19444_ _01105_ _01107_ _12628_ _03252_ VDD VSS MUX2_X1
X_19445_ _03251_ _03252_ _12630_ _03253_ VDD VSS MUX2_X1
X_19446_ _01096_ _01098_ _12628_ _03254_ VDD VSS MUX2_X1
X_19447_ _01097_ _01099_ _12704_ _03255_ VDD VSS MUX2_X1
X_19448_ _03254_ _03255_ _12630_ _03256_ VDD VSS MUX2_X1
X_19449_ _03253_ _03256_ _11931_ _03257_ VDD VSS MUX2_X1
X_19450_ _12449_ _03257_ _03258_ VDD VSS NOR2_X1
X_19451_ _11928_ _03250_ _03258_ _03259_ VDD VSS NOR3_X2
X_19452_ _01116_ _01118_ _11962_ _03260_ VDD VSS MUX2_X1
X_19453_ _01117_ _01119_ _11938_ _03261_ VDD VSS MUX2_X1
X_19454_ _03260_ _03261_ _12693_ _03262_ VDD VSS MUX2_X1
X_19455_ _01108_ _01110_ net676 _03263_ VDD VSS MUX2_X1
X_19456_ _01109_ _01111_ _12689_ _03264_ VDD VSS MUX2_X1
X_19457_ _03263_ _03264_ _12693_ _03265_ VDD VSS MUX2_X1
X_19458_ _03262_ _03265_ _11969_ _03266_ VDD VSS MUX2_X1
X_19459_ _01120_ _01122_ net676 _03267_ VDD VSS MUX2_X1
X_19460_ _01121_ _01123_ net678 _03268_ VDD VSS MUX2_X1
X_19461_ _03267_ _03268_ _12693_ _03269_ VDD VSS MUX2_X1
X_19462_ _01112_ _01114_ _12689_ _03270_ VDD VSS MUX2_X1
X_19463_ _01113_ _01115_ _12691_ _03271_ VDD VSS MUX2_X1
X_19464_ _03270_ _03271_ _13193_ _03272_ VDD VSS MUX2_X1
X_19465_ _03269_ _03272_ _11969_ _03273_ VDD VSS MUX2_X1
X_19466_ _03266_ _03273_ _12649_ _03274_ VDD VSS MUX2_X2
X_19467_ _03259_ _03274_ _11929_ _03275_ VDD VSS AOI21_X4
X_19468_ _11921_ _11994_ _03275_ _03276_ VDD VSS OAI21_X1
X_19469_ _03240_ _03276_ _16077_ VDD VSS NOR2_X2
X_19470_ cs_registers_i.pc_id_i\[30\] _10564_ _10870_ _03277_
+ VDD VSS AND3_X1
X_19471_ _01100_ _01102_ _11454_ _03278_ VDD VSS MUX2_X1
X_19472_ _10628_ _03278_ _03279_ VDD VSS NOR2_X1
X_19473_ _01101_ _01103_ _11363_ _03280_ VDD VSS MUX2_X1
X_19474_ _10580_ _03280_ _03281_ VDD VSS NOR2_X1
X_19475_ _10828_ _03279_ _03281_ _03282_ VDD VSS NOR3_X1
X_19476_ _10613_ gen_regfile_ff.register_file_i.rf_reg\[62\]
+ _03283_ VDD VSS NOR2_X1
X_19477_ _03283_ _01095_ _10587_ _03284_ VDD VSS AOI21_X1
X_19478_ _10765_ _03246_ _10822_ _03284_ _10796_ _03285_ VDD
+ VSS AOI221_X2
X_19479_ _11676_ _03282_ _03285_ _03286_ VDD VSS NOR3_X1
X_19480_ _01104_ _01106_ _11642_ _03287_ VDD VSS MUX2_X1
X_19481_ _01105_ _01107_ _11642_ _03288_ VDD VSS MUX2_X1
X_19482_ _03287_ _03288_ _10862_ _03289_ VDD VSS MUX2_X1
X_19483_ _01096_ _01098_ _11642_ _03290_ VDD VSS MUX2_X1
X_19484_ _01097_ _01099_ _11642_ _03291_ VDD VSS MUX2_X1
X_19485_ _03290_ _03291_ _10862_ _03292_ VDD VSS MUX2_X1
X_19486_ _03289_ _03292_ _11357_ _03293_ VDD VSS MUX2_X1
X_19487_ _10608_ _03293_ _03294_ VDD VSS NOR2_X1
X_19488_ _10749_ _03286_ _03294_ _03295_ VDD VSS NOR3_X2
X_19489_ _01116_ _01118_ _11771_ _03296_ VDD VSS MUX2_X1
X_19490_ _01117_ _01119_ _11771_ _03297_ VDD VSS MUX2_X1
X_19491_ _03296_ _03297_ _11534_ _03298_ VDD VSS MUX2_X1
X_19492_ _01108_ _01110_ _11771_ _03299_ VDD VSS MUX2_X1
X_19493_ _01109_ _01111_ _11771_ _03300_ VDD VSS MUX2_X1
X_19494_ _03299_ _03300_ _11534_ _03301_ VDD VSS MUX2_X1
X_19495_ _03298_ _03301_ _10569_ _03302_ VDD VSS MUX2_X1
X_19496_ _01120_ _01122_ _11771_ _03303_ VDD VSS MUX2_X1
X_19497_ _01121_ _01123_ _12317_ _03304_ VDD VSS MUX2_X1
X_19498_ _03303_ _03304_ _10627_ _03305_ VDD VSS MUX2_X1
X_19499_ _01112_ _01114_ _11771_ _03306_ VDD VSS MUX2_X1
X_19500_ _01113_ _01115_ _12317_ _03307_ VDD VSS MUX2_X1
X_19501_ _03306_ _03307_ _10627_ _03308_ VDD VSS MUX2_X1
X_19502_ _03305_ _03308_ _10828_ _03309_ VDD VSS MUX2_X1
X_19503_ _03302_ _03309_ _10752_ _03310_ VDD VSS MUX2_X2
X_19504_ _03295_ _03310_ _10750_ _03311_ VDD VSS AOI21_X4
X_19505_ _03277_ _03311_ _11596_ id_stage_i.controller_i.lsu_addr_last_i\[30\]
+ _10397_ _03312_ VDD VSS AOI221_X2
X_19506_ _03312_ _16080_ VDD VSS BUF_X4
X_19507_ _10403_ _10928_ _11320_ _10930_ _10509_ _03313_ VDD
+ VSS AOI221_X2
X_19508_ _01147_ _01149_ _10452_ _03314_ VDD VSS MUX2_X1
X_19509_ _01148_ _01150_ _10452_ _03315_ VDD VSS MUX2_X1
X_19510_ _03314_ _03315_ _10941_ _03316_ VDD VSS MUX2_X1
X_19511_ _01139_ _01141_ _10452_ _03317_ VDD VSS MUX2_X1
X_19512_ _01140_ _01142_ _10452_ _03318_ VDD VSS MUX2_X1
X_19513_ _03317_ _03318_ _10941_ _03319_ VDD VSS MUX2_X1
X_19514_ _03316_ _03319_ _10421_ _03320_ VDD VSS MUX2_X1
X_19515_ _10435_ _10709_ _03320_ _03321_ VDD VSS NAND3_X2
X_19516_ _01144_ _01146_ _10437_ _03322_ VDD VSS MUX2_X1
X_19517_ _10695_ _03322_ _03323_ VDD VSS NOR2_X1
X_19518_ _01143_ _01145_ net371 _03324_ VDD VSS MUX2_X1
X_19519_ _10442_ _03324_ _03325_ VDD VSS NOR2_X1
X_19520_ _10452_ gen_regfile_ff.register_file_i.rf_reg\[63\]
+ _03326_ VDD VSS NOR2_X1
X_19521_ _10437_ _01126_ _03327_ VDD VSS AND2_X1
X_19522_ _10695_ _03326_ _03327_ _03328_ VDD VSS NOR3_X1
X_19523_ _10879_ _10337_ _01125_ _03329_ VDD VSS NOR3_X1
X_19524_ _11099_ _03323_ _03325_ _03328_ _03329_ _10998_ _03330_
+ VDD VSS OAI33_X1
X_19525_ _01152_ _01154_ net371 _03331_ VDD VSS MUX2_X1
X_19526_ _10695_ _03331_ _03332_ VDD VSS NOR2_X1
X_19527_ _01151_ _01153_ net371 _03333_ VDD VSS MUX2_X1
X_19528_ _10442_ _03333_ _03334_ VDD VSS NOR2_X1
X_19529_ _01127_ _01129_ _10408_ _03335_ VDD VSS MUX2_X1
X_19530_ _10442_ _03335_ _03336_ VDD VSS NOR2_X1
X_19531_ _01128_ _01130_ _10408_ _03337_ VDD VSS MUX2_X1
X_19532_ _10694_ _03337_ _03338_ VDD VSS NOR2_X1
X_19533_ _10420_ _10472_ _03339_ VDD VSS NAND2_X1
X_19534_ _11042_ _03332_ _03334_ _03336_ _03338_ _03339_ _03340_
+ VDD VSS OAI33_X1
X_19535_ _01134_ _01138_ _10978_ _03341_ VDD VSS MUX2_X1
X_19536_ _10977_ _03341_ _03342_ VDD VSS NOR2_X1
X_19537_ _01132_ _01136_ _10434_ _03343_ VDD VSS MUX2_X1
X_19538_ _11186_ net374 _03343_ _03344_ VDD VSS NOR3_X1
X_19539_ _01131_ _01135_ _10684_ _03345_ VDD VSS MUX2_X1
X_19540_ _10980_ _03345_ _03346_ VDD VSS NOR2_X1
X_19541_ _03342_ _03344_ _03346_ _03347_ VDD VSS NOR3_X1
X_19542_ _01133_ _01137_ _10684_ _03348_ VDD VSS MUX2_X1
X_19543_ _10941_ _10337_ _03348_ _03349_ VDD VSS NOR3_X1
X_19544_ _10962_ _03349_ _03350_ VDD VSS NOR2_X1
X_19545_ _03330_ _03340_ _10432_ _03347_ _03350_ _03351_ VDD
+ VSS AOI221_X2
X_19546_ _10317_ _03321_ _03351_ _03352_ VDD VSS AOI21_X1
X_19547_ _10361_ _03352_ _03353_ VDD VSS OR2_X1
X_19548_ _03313_ _03353_ _15495_ VDD VSS NOR2_X1
X_19549_ id_stage_i.controller_i.lsu_addr_last_i\[31\] _10361_
+ _03354_ VDD VSS NAND2_X1
X_19550_ _01125_ _03355_ VDD VSS INV_X1
X_19551_ _10857_ gen_regfile_ff.register_file_i.rf_reg\[63\]
+ _03356_ VDD VSS NOR2_X1
X_19552_ _03356_ _01126_ _11567_ _03357_ VDD VSS AOI21_X1
X_19553_ _10764_ _03355_ _10821_ _03357_ _10861_ _03358_ VDD
+ VSS AOI221_X2
X_19554_ _01131_ _01133_ _10598_ _03359_ VDD VSS MUX2_X1
X_19555_ _10579_ _10765_ _03359_ _03360_ VDD VSS NAND3_X1
X_19556_ _01132_ _01134_ _10857_ _03361_ VDD VSS MUX2_X1
X_19557_ _10786_ _10764_ _03361_ _03362_ VDD VSS NAND3_X1
X_19558_ _10607_ _10573_ _03360_ _03362_ _03363_ VDD VSS NAND4_X2
X_19559_ _01135_ _01137_ _10856_ _03364_ VDD VSS MUX2_X1
X_19560_ _01136_ _01138_ _10856_ _03365_ VDD VSS MUX2_X1
X_19561_ _03364_ _03365_ _10592_ _03366_ VDD VSS MUX2_X1
X_19562_ _01127_ _01129_ _10856_ _03367_ VDD VSS MUX2_X1
X_19563_ _01128_ _01130_ _10856_ _03368_ VDD VSS MUX2_X1
X_19564_ _03367_ _03368_ _10592_ _03369_ VDD VSS MUX2_X1
X_19565_ _03366_ _03369_ _10567_ _03370_ VDD VSS MUX2_X1
X_19566_ _03358_ _03363_ _03370_ _10855_ _03371_ VDD VSS OAI22_X4
X_19567_ _01144_ _01146_ _10584_ _03372_ VDD VSS MUX2_X1
X_19568_ _01143_ _01145_ _10584_ _03373_ VDD VSS MUX2_X1
X_19569_ _03372_ _03373_ _10578_ _03374_ VDD VSS MUX2_X1
X_19570_ _01141_ _01142_ _10592_ _03375_ VDD VSS MUX2_X1
X_19571_ _10778_ _03374_ _03375_ _10793_ _03376_ VDD VSS AOI22_X1
X_19572_ _01139_ _01140_ _10625_ _03377_ VDD VSS MUX2_X1
X_19573_ _10573_ _10784_ _03377_ _03378_ VDD VSS AOI21_X1
X_19574_ _01151_ _01153_ _10584_ _03379_ VDD VSS MUX2_X1
X_19575_ _01152_ _01154_ _10584_ _03380_ VDD VSS MUX2_X1
X_19576_ _03379_ _03380_ _10592_ _03381_ VDD VSS MUX2_X1
X_19577_ _01147_ _01149_ _10856_ _03382_ VDD VSS MUX2_X1
X_19578_ _01148_ _01150_ _10856_ _03383_ VDD VSS MUX2_X1
X_19579_ _03382_ _03383_ _10592_ _03384_ VDD VSS MUX2_X1
X_19580_ _10651_ _03381_ _03384_ _10643_ _03385_ VDD VSS AOI22_X2
X_19581_ _03376_ _03378_ _03385_ _03386_ VDD VSS AND3_X4
X_19582_ _10563_ _03371_ _03386_ _10681_ _10361_ _03387_ VDD
+ VSS OAI221_X2
X_19583_ cs_registers_i.pc_id_i\[31\] _10326_ _10563_ _10672_
+ _03388_ VDD VSS NAND4_X2
X_19584_ _03354_ _03387_ _03388_ _15496_ VDD VSS NAND3_X4
X_19585_ _15496_ _15492_ VDD VSS INV_X2
X_19586_ _15490_ _03219_ _03389_ VDD VSS AND2_X1
X_19587_ _15485_ _03390_ VDD VSS INV_X1
X_19588_ _03390_ _03221_ _03208_ _03391_ VDD VSS OAI21_X2
X_19589_ _15489_ _13266_ _03389_ _03391_ _15490_ _03392_ VDD
+ VSS AOI221_X2
X_19590_ _11632_ _03352_ _03393_ VDD VSS NOR2_X1
X_19591_ _10503_ _10389_ _10928_ _03394_ VDD VSS NAND3_X1
X_19592_ _10317_ _10926_ _03394_ _10387_ _10510_ _03395_ VDD
+ VSS OAI221_X2
X_19593_ _15496_ _03393_ _03395_ _03396_ VDD VSS AOI21_X4
X_19594_ _03313_ _03353_ _15492_ _03397_ VDD VSS NOR3_X4
X_19595_ _11514_ _03396_ _03397_ _03398_ VDD VSS OAI21_X4
X_19596_ _11401_ _11863_ _03396_ _03397_ _03399_ VDD VSS OR4_X4
X_19597_ _03321_ _03351_ _03400_ VDD VSS NAND2_X4
X_19598_ _00179_ _03401_ VDD VSS BUF_X2
X_19599_ _00178_ _03402_ VDD VSS BUF_X4
X_19600_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[6\]
+ _03403_ VDD VSS BUF_X4
X_19601_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[1\]
+ _03404_ VDD VSS BUF_X4
X_19602_ _03403_ _03404_ _03405_ VDD VSS NOR2_X4
X_19603_ _03401_ _03402_ _03405_ _03406_ VDD VSS NAND3_X4
X_19604_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[5\]
+ _03407_ VDD VSS INV_X4
X_19605_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[63\]
+ _03408_ VDD VSS CLKBUF_X3
X_19606_ _03406_ _03405_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[31\]
+ _03407_ _03408_ _03409_ VDD VSS OAI221_X2
X_19607_ _03402_ _03371_ _03386_ _03410_ VDD VSS NOR3_X2
X_19608_ _03400_ _03406_ _03409_ _03410_ _03411_ VDD VSS OAI22_X4
X_19609_ _01155_ _03412_ VDD VSS CLKBUF_X3
X_19610_ _03412_ _03405_ _03413_ VDD VSS NOR2_X1
X_19611_ _03411_ _03413_ _03414_ VDD VSS XNOR2_X1
X_19612_ _11405_ _03414_ _03415_ VDD VSS OR2_X2
X_19613_ _03398_ _03399_ _03415_ _03416_ VDD VSS NAND3_X4
X_19614_ _03416_ _03392_ _03417_ VDD VSS XNOR2_X2
X_19615_ net277 alu_adder_result_ex\[31\] VDD VSS INV_X16
X_19616_ _15490_ _03418_ VDD VSS INV_X2
X_19617_ _03418_ _03209_ _15485_ _03419_ VDD VSS NOR3_X1
X_19618_ _13099_ _13107_ _03420_ VDD VSS NAND2_X1
X_19619_ _03231_ _03419_ _12610_ _03420_ _03421_ VDD VSS OAI211_X2
X_19620_ _03216_ _03210_ _03224_ _03422_ VDD VSS AOI21_X1
X_19621_ _03207_ _03209_ _03422_ _03423_ VDD VSS OAI21_X1
X_19622_ _03418_ _03390_ _03423_ _03424_ VDD VSS AOI21_X1
X_19623_ _15485_ _03209_ _03207_ _03425_ VDD VSS AOI21_X1
X_19624_ _03418_ _03425_ _03426_ VDD VSS AND2_X1
X_19625_ _03207_ _03418_ _03422_ _03427_ VDD VSS NAND3_X1
X_19626_ _03231_ _03428_ VDD VSS INV_X1
X_19627_ _03428_ _13267_ _13119_ _03429_ VDD VSS AOI21_X1
X_19628_ _03421_ _03424_ _03426_ _03429_ _03427_ _03430_ VDD
+ VSS OAI221_X2
X_19629_ _03430_ alu_adder_result_ex\[30\] VDD VSS BUF_X8
X_19630_ _03403_ _03431_ VDD VSS BUF_X4
X_19631_ _03431_ _03432_ VDD VSS INV_X2
X_19632_ _10894_ _10910_ _10918_ _11417_ _03433_ VDD VSS OR4_X2
X_19633_ _03433_ _03434_ VDD VSS BUF_X8
X_19634_ _11419_ _03435_ VDD VSS INV_X2
X_19635_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _03436_
+ VDD VSS INV_X4
X_19636_ _03436_ _11421_ _11422_ _11424_ _03437_ VDD VSS NOR4_X4
X_19637_ _10304_ _03435_ _03437_ _03438_ VDD VSS NAND3_X4
X_19638_ _03434_ _03438_ _03439_ VDD VSS NOR2_X4
X_19639_ _12103_ _11407_ _03440_ VDD VSS NOR2_X4
X_19640_ _03439_ _03440_ _03441_ VDD VSS NAND2_X4
X_19641_ _01158_ _03442_ VDD VSS BUF_X2
X_19642_ _03442_ _15546_ _03443_ VDD VSS AND2_X1
X_19643_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ _03444_ VDD VSS CLKBUF_X2
X_19644_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[2\]
+ _03445_ VDD VSS CLKBUF_X3
X_19645_ _03444_ _03445_ _03446_ VDD VSS NOR2_X1
X_19646_ _03443_ _03446_ _03447_ VDD VSS NAND2_X1
X_19647_ _03432_ _03441_ _03447_ _03448_ VDD VSS OR3_X1
X_19648_ _11401_ _03449_ VDD VSS BUF_X4
X_19649_ net305 _03449_ _03450_ VDD VSS NAND2_X4
X_19650_ _11428_ _03450_ _03451_ VDD VSS NOR2_X4
X_19651_ _03404_ _03452_ VDD VSS INV_X1
X_19652_ _03448_ _03451_ _03452_ _00002_ VDD VSS OAI21_X1
X_19653_ data_rvalid_i _03453_ VDD VSS CLKBUF_X3
X_19654_ _10324_ _10319_ _03454_ VDD VSS NOR2_X4
X_19655_ _10320_ _03454_ _03455_ VDD VSS AND2_X2
X_19656_ _03453_ _03455_ _03456_ VDD VSS NAND2_X2
X_19657_ net27 load_store_unit_i.lsu_err_q _03457_ VDD VSS
+ NOR2_X2
X_19658_ load_store_unit_i.data_we_q _03456_ _03457_ id_stage_i.controller_i.load_err_d
+ VDD VSS NOR3_X1
X_19659_ _01160_ _03456_ _03457_ id_stage_i.controller_i.store_err_d
+ VDD VSS NOR3_X1
X_19660_ _11421_ _03458_ VDD VSS INV_X4
X_19661_ _03458_ id_stage_i.controller_i.ctrl_fsm_cs\[3\]
+ _11424_ _03459_ VDD VSS NOR3_X4
X_19662_ _03436_ _03459_ _03460_ VDD VSS AND2_X1
X_19663_ _03460_ _03461_ VDD VSS BUF_X4
X_19664_ cs_registers_i.priv_lvl_q\[0\] _03462_ VDD VSS BUF_X1
X_19665_ cs_registers_i.priv_lvl_q\[1\] _03463_ VDD VSS BUF_X1
X_19666_ _03462_ _03463_ _03464_ VDD VSS AND2_X1
X_19667_ _10557_ _03465_ VDD VSS BUF_X4
X_19668_ _03465_ _10876_ _03466_ VDD VSS NOR2_X2
X_19669_ _10304_ _10522_ _10670_ _03467_ VDD VSS NAND3_X4
X_19670_ _10891_ _10886_ _03467_ _03468_ VDD VSS NOR3_X4
X_19671_ _03466_ _03468_ _03469_ VDD VSS AND2_X2
X_19672_ _10878_ _10880_ _10881_ _03470_ VDD VSS OR3_X2
X_19673_ _03465_ _10876_ _03471_ VDD VSS OR2_X2
X_19674_ _01161_ _10742_ _03470_ _03471_ _03472_ VDD VSS NOR4_X4
X_19675_ _03469_ _03472_ cs_registers_i.csr_mstatus_tw_o _03473_
+ VDD VSS AOI21_X1
X_19676_ _03464_ _03473_ _03474_ VDD VSS NOR2_X1
X_19677_ _10887_ _10889_ _03475_ VDD VSS NOR2_X2
X_19678_ _10661_ _03475_ _03468_ _03476_ VDD VSS AND3_X2
X_19679_ cs_registers_i.debug_mode_i _03477_ VDD VSS CLKBUF_X3
X_19680_ _03477_ _03478_ VDD VSS INV_X2
X_19681_ _03474_ _03476_ _03478_ _03479_ VDD VSS AOI21_X2
X_19682_ _03479_ _03480_ VDD VSS INV_X1
X_19683_ _15502_ _15505_ _03481_ VDD VSS NAND2_X1
X_19684_ _15502_ _03482_ VDD VSS INV_X1
X_19685_ _03482_ _15504_ _03483_ VDD VSS NOR2_X1
X_19686_ _03481_ _03483_ _15501_ _03484_ VDD VSS OAI21_X2
X_19687_ _15920_ _11321_ _11352_ _03485_ VDD VSS NOR3_X4
X_19688_ _10921_ _11427_ _03486_ VDD VSS NAND2_X1
X_19689_ _15527_ _03486_ _03487_ VDD VSS NOR2_X1
X_19690_ _03485_ _03487_ _03488_ VDD VSS NAND2_X1
X_19691_ _10744_ _03434_ _03489_ VDD VSS NOR2_X2
X_19692_ _10885_ _10923_ _11074_ _11241_ _11279_ _10974_ _03490_
+ VDD VSS OAI33_X1
X_19693_ _03490_ _03491_ VDD VSS BUF_X4
X_19694_ _03489_ _15916_ _15929_ _03491_ _03492_ VDD VSS AND4_X1
X_19695_ _03465_ _10678_ _03493_ VDD VSS NOR2_X4
X_19696_ _03493_ _11418_ _03494_ VDD VSS NAND2_X1
X_19697_ _03494_ _03495_ VDD VSS BUF_X4
X_19698_ _11065_ _03495_ _03496_ VDD VSS NOR2_X2
X_19699_ _15884_ _15896_ _03497_ VDD VSS NOR2_X1
X_19700_ _15876_ _03492_ _03496_ _03497_ _03498_ VDD VSS NAND4_X4
X_19701_ _03495_ _03499_ VDD VSS BUF_X4
X_19702_ _15515_ _03500_ VDD VSS INV_X4
X_19703_ _15512_ _03501_ VDD VSS BUF_X4
X_19704_ _03501_ _03502_ VDD VSS INV_X4
X_19705_ _15520_ _03503_ VDD VSS CLKBUF_X3
X_19706_ _03503_ _03504_ VDD VSS INV_X2
X_19707_ _03500_ _03502_ _03504_ _03505_ VDD VSS NAND3_X4
X_19708_ _15518_ _03506_ VDD VSS BUF_X4
X_19709_ _03478_ _11071_ _03499_ _03505_ _03506_ _03507_ VDD
+ VSS OAI221_X2
X_19710_ _03484_ _03488_ _03498_ _03507_ _03508_ VDD VSS OAI211_X4
X_19711_ _03434_ _03508_ _03493_ _03509_ VDD VSS AOI21_X2
X_19712_ _15518_ _03510_ VDD VSS INV_X2
X_19713_ _11066_ _03501_ _03503_ _03511_ VDD VSS NOR3_X1
X_19714_ _03510_ _03511_ _03512_ VDD VSS NAND2_X1
X_19715_ _15888_ _15896_ _03513_ VDD VSS NAND2_X2
X_19716_ _15876_ _03513_ _03514_ VDD VSS NOR2_X4
X_19717_ _15920_ _03491_ _03515_ VDD VSS NAND2_X2
X_19718_ _03495_ _15929_ _03515_ _03516_ VDD VSS NOR3_X1
X_19719_ _03512_ _03496_ _03514_ _03516_ _03517_ VDD VSS AND4_X1
X_19720_ _03489_ _03518_ VDD VSS BUF_X4
X_19721_ _11033_ _11041_ _11049_ _11056_ _03519_ VDD VSS AND4_X4
X_19722_ _00138_ _03520_ VDD VSS INV_X1
X_19723_ _03520_ _11928_ _10386_ _03521_ VDD VSS MUX2_X1
X_19724_ _10976_ _03519_ _03521_ _11020_ _03522_ VDD VSS AOI22_X2
X_19725_ _10903_ _10386_ _10387_ _10392_ _03523_ VDD VSS OAI211_X2
X_19726_ _03522_ _03523_ _15880_ _03524_ VDD VSS NAND3_X2
X_19727_ _03518_ _03513_ _03524_ _03525_ VDD VSS OAI21_X1
X_19728_ _03525_ _03516_ _03526_ VDD VSS AND2_X1
X_19729_ _11066_ _03506_ _03503_ _03527_ VDD VSS NOR3_X2
X_19730_ _03499_ _03527_ _03528_ VDD VSS NAND2_X1
X_19731_ _03512_ _03528_ _03529_ VDD VSS NAND2_X1
X_19732_ _11071_ _03530_ VDD VSS BUF_X4
X_19733_ _03529_ _03527_ _03530_ _03531_ VDD VSS AOI21_X2
X_19734_ _03517_ _03526_ _03531_ _03532_ VDD VSS AOI21_X4
X_19735_ _15929_ _03515_ _03533_ VDD VSS NOR2_X2
X_19736_ _11159_ _11160_ _11162_ _03534_ VDD VSS OAI21_X2
X_19737_ _03495_ _03534_ _15896_ _03535_ VDD VSS NOR3_X1
X_19738_ _03533_ _03535_ _03536_ VDD VSS NAND2_X1
X_19739_ _11061_ net294 _11116_ _03537_ VDD VSS NOR3_X4
X_19740_ _11066_ _03503_ _03495_ _03537_ _03538_ VDD VSS OAI22_X1
X_19741_ _11025_ _10975_ _10934_ _03539_ VDD VSS OAI21_X2
X_19742_ _03539_ _03540_ VDD VSS BUF_X4
X_19743_ _03538_ _03518_ _03540_ _03541_ VDD VSS AOI21_X1
X_19744_ _10919_ _15876_ _03542_ VDD VSS NOR2_X1
X_19745_ _15869_ _03542_ _03543_ VDD VSS NAND2_X1
X_19746_ _11066_ _03501_ _03503_ _10934_ _10975_ _15864_ _03544_
+ VDD VSS OAI33_X1
X_19747_ _03543_ _03511_ _11071_ _03510_ _03544_ _03545_ VDD
+ VSS AOI221_X1
X_19748_ _03489_ _03505_ _03546_ VDD VSS NAND2_X1
X_19749_ _03510_ _11071_ _03546_ _03547_ VDD VSS OAI21_X1
X_19750_ _10934_ _10975_ _11065_ _03505_ _03548_ VDD VSS NOR4_X1
X_19751_ _15880_ _11065_ _15860_ _03549_ VDD VSS OAI21_X1
X_19752_ _03518_ _03548_ _03549_ _03550_ VDD VSS OAI21_X1
X_19753_ _03541_ _03545_ _03547_ _03550_ _03551_ VDD VSS AOI211_X4
X_19754_ _03493_ _03532_ _03536_ _03551_ _03552_ VDD VSS OAI211_X2
X_19755_ _03495_ _15925_ _03515_ _03553_ VDD VSS NOR3_X4
X_19756_ _10919_ _15884_ _15896_ _03554_ VDD VSS NOR3_X4
X_19757_ _15518_ _03505_ _03555_ VDD VSS NOR2_X1
X_19758_ _15880_ _03555_ _03556_ VDD VSS NOR2_X1
X_19759_ _15869_ _03554_ _03556_ _03557_ VDD VSS NAND3_X1
X_19760_ _10920_ _03530_ _03557_ _03558_ VDD VSS NOR3_X1
X_19761_ _11061_ _11063_ _15876_ _15892_ _03559_ VDD VSS NOR4_X1
X_19762_ _11066_ _03499_ _03559_ _03560_ VDD VSS OAI21_X1
X_19763_ _03560_ _03518_ _03540_ _03561_ VDD VSS AOI21_X1
X_19764_ _03553_ _03558_ _03561_ _03562_ VDD VSS OAI21_X1
X_19765_ _11070_ _11067_ _15860_ _03563_ VDD VSS NAND3_X2
X_19766_ _15884_ _15892_ _03564_ VDD VSS NOR2_X2
X_19767_ _03564_ _03501_ _11066_ _03565_ VDD VSS OAI21_X1
X_19768_ _15888_ _15892_ _03566_ VDD VSS NOR2_X1
X_19769_ _03566_ _03495_ _15860_ _03501_ _03503_ _03567_ VDD
+ VSS OAI221_X2
X_19770_ _10934_ _10975_ _03499_ _03568_ VDD VSS NOR3_X1
X_19771_ _03563_ _03565_ _03567_ _03568_ _03569_ VDD VSS OAI22_X2
X_19772_ _03495_ _15876_ _03570_ VDD VSS NOR2_X1
X_19773_ _15873_ _03570_ _03553_ _03571_ VDD VSS AND3_X1
X_19774_ _11065_ _03570_ _03566_ _03572_ VDD VSS AND3_X1
X_19775_ _03553_ _03572_ _03573_ VDD VSS AND2_X1
X_19776_ _03500_ _10744_ _03434_ _03574_ VDD VSS NOR3_X4
X_19777_ _11070_ _11067_ _15860_ _03574_ _03575_ VDD VSS NAND4_X4
X_19778_ _03506_ _15860_ _10975_ _10934_ _03576_ VDD VSS OAI211_X4
X_19779_ _03506_ _03499_ _03577_ VDD VSS NAND2_X2
X_19780_ _03575_ _03576_ _03577_ _03578_ VDD VSS NAND3_X1
X_19781_ _03569_ _03571_ _03573_ _03578_ _03579_ VDD VSS AOI22_X2
X_19782_ _15860_ _11065_ _10934_ _10975_ _03580_ VDD VSS OAI211_X4
X_19783_ _15876_ _03574_ _03581_ VDD VSS NAND2_X2
X_19784_ _03513_ _03580_ _03581_ _03582_ VDD VSS NOR3_X2
X_19785_ _03494_ _03564_ _03537_ _03583_ VDD VSS AOI21_X1
X_19786_ _03502_ _03583_ _03539_ _10921_ _03584_ VDD VSS AOI211_X2
X_19787_ _03553_ _03582_ _03584_ _03585_ VDD VSS OAI21_X1
X_19788_ _03495_ _03534_ _03586_ VDD VSS NOR2_X1
X_19789_ _15892_ _15916_ _03587_ VDD VSS NOR2_X2
X_19790_ _15929_ _03491_ _03586_ _03587_ _03588_ VDD VSS AND4_X2
X_19791_ _03495_ _15880_ _03555_ _03589_ VDD VSS NOR3_X1
X_19792_ _03588_ _03589_ _03506_ _03580_ _03590_ VDD VSS OAI211_X2
X_19793_ _03556_ _03535_ _03591_ VDD VSS AND2_X1
X_19794_ _15869_ _03489_ _15929_ _03491_ _03592_ VDD VSS AND4_X1
X_19795_ _11071_ _03591_ _03592_ _03553_ _03593_ VDD VSS OAI211_X2
X_19796_ _10934_ _10975_ _15864_ _03594_ VDD VSS NOR3_X4
X_19797_ _15869_ _03491_ _03485_ _03595_ VDD VSS AND3_X2
X_19798_ _11066_ _03493_ _11418_ _03596_ VDD VSS NAND3_X2
X_19799_ _15876_ _03596_ _03597_ VDD VSS NOR2_X1
X_19800_ _03564_ _03594_ _03595_ _03597_ _03598_ VDD VSS NAND4_X1
X_19801_ _15896_ _03502_ _03500_ _03599_ VDD VSS AOI21_X1
X_19802_ _15884_ _03570_ _03599_ _03600_ VDD VSS AND3_X1
X_19803_ _11065_ _11071_ _03492_ _03600_ _03601_ VDD VSS NAND4_X1
X_19804_ _03590_ _03593_ _03598_ _03601_ _03602_ VDD VSS AND4_X1
X_19805_ _03562_ _03579_ _03585_ _03602_ _03603_ VDD VSS NAND4_X2
X_19806_ _03509_ _03552_ _03603_ _03604_ VDD VSS OAI21_X1
X_19807_ _01161_ _03605_ VDD VSS INV_X1
X_19808_ _03480_ _03604_ _03605_ _03606_ VDD VSS AOI21_X1
X_19809_ _03461_ _03606_ id_stage_i.controller_i.illegal_insn_d
+ VDD VSS NOR2_X1
X_19810_ _10305_ _03435_ _03607_ VDD VSS NOR2_X4
X_19811_ _10891_ _10892_ _03608_ VDD VSS OR2_X2
X_19812_ _03467_ _03471_ _03608_ _03609_ VDD VSS NOR3_X4
X_19813_ _03607_ _03609_ _03610_ VDD VSS NOR2_X2
X_19814_ _03461_ _03606_ _03610_ id_stage_i.controller_i.exc_req_d
+ VDD VSS AOI21_X1
X_19815_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[2\]
+ _03611_ VDD VSS BUF_X4
X_19816_ _03611_ _03451_ _03612_ VDD VSS NAND2_X4
X_19817_ _03612_ _03613_ VDD VSS CLKBUF_X3
X_19818_ _03431_ _03614_ VDD VSS BUF_X4
X_19819_ _03441_ _03615_ VDD VSS CLKBUF_X3
X_19820_ _03614_ _03615_ _03447_ _03616_ VDD VSS OAI21_X1
X_19821_ _03613_ _03616_ _00005_ VDD VSS NAND2_X1
X_19822_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[4\]
+ _03617_ VDD VSS BUF_X2
X_19823_ _03617_ _03615_ _03618_ VDD VSS NAND2_X1
X_19824_ _16105_ _03619_ VDD VSS BUF_X4
X_19825_ _03619_ _03620_ VDD VSS INV_X2
X_19826_ _11735_ _11726_ alu_adder_result_ex\[5\] VDD VSS
+ XNOR2_X2
X_19827_ _11841_ _11719_ _11842_ _03621_ VDD VSS OAI21_X1
X_19828_ _11721_ _03621_ alu_adder_result_ex\[3\] VDD VSS
+ XOR2_X2
X_19829_ _03620_ alu_adder_result_ex\[5\] alu_adder_result_ex\[3\]
+ _03622_ VDD VSS OR3_X1
X_19830_ alu_adder_result_ex\[7\] alu_adder_result_ex\[9\]
+ alu_adder_result_ex\[11\] _03622_ _03623_ VDD VSS OR4_X1
X_19831_ alu_adder_result_ex\[13\] alu_adder_result_ex\[15\]
+ _03623_ _03624_ VDD VSS OR3_X1
X_19832_ alu_adder_result_ex\[6\] alu_adder_result_ex\[8\]
+ _03624_ _03625_ VDD VSS OR3_X1
X_19833_ alu_adder_result_ex\[17\] alu_adder_result_ex\[21\]
+ _03626_ VDD VSS OR2_X1
X_19834_ alu_adder_result_ex\[10\] _12101_ _03625_ _03626_
+ _03627_ VDD VSS OR4_X2
X_19835_ _11744_ _03628_ VDD VSS INV_X1
X_19836_ _15371_ _14064_ _03628_ _15373_ _10815_ _03629_ VDD
+ VSS AOI221_X2
X_19837_ _11720_ _03629_ alu_adder_result_ex\[2\] VDD VSS
+ XNOR2_X2
X_19838_ _11722_ _11838_ _03630_ VDD VSS NOR2_X1
X_19839_ _11722_ _03630_ _11844_ _03631_ VDD VSS MUX2_X1
X_19840_ _11722_ _11838_ _03632_ VDD VSS NAND2_X1
X_19841_ _11401_ _11862_ _03633_ VDD VSS NOR2_X1
X_19842_ _11854_ _03632_ _03633_ _11858_ _03634_ VDD VSS AOI211_X2
X_19843_ _11725_ _11844_ _03635_ VDD VSS AND2_X1
X_19844_ _03631_ _03634_ _03635_ _11514_ alu_adder_result_ex\[4\]
+ VDD VSS AOI211_X4
X_19845_ alu_adder_result_ex\[19\] alu_adder_result_ex\[4\]
+ _03636_ VDD VSS OR2_X1
X_19846_ alu_adder_result_ex\[16\] alu_adder_result_ex\[23\]
+ alu_adder_result_ex\[2\] _03636_ _03637_ VDD VSS OR4_X2
X_19847_ _12593_ _13111_ _03638_ VDD VSS NAND2_X1
X_19848_ _12594_ _13111_ _03639_ VDD VSS NAND2_X1
X_19849_ _03638_ _03639_ _12610_ _03640_ VDD VSS MUX2_X1
X_19850_ alu_adder_result_ex\[27\] alu_adder_result_ex\[29\]
+ _03641_ VDD VSS OR2_X1
X_19851_ alu_adder_result_ex\[14\] net397 _03640_ _03641_
+ _03642_ VDD VSS OR4_X2
X_19852_ _03430_ _03627_ _03637_ _03642_ _03643_ VDD VSS OR4_X4
X_19853_ alu_adder_result_ex\[20\] alu_adder_result_ex\[28\]
+ _03644_ VDD VSS OR2_X1
X_19854_ alu_adder_result_ex\[22\] alu_adder_result_ex\[24\]
+ alu_adder_result_ex\[31\] _03644_ _03645_ VDD VSS OR4_X2
X_19855_ _03643_ _03645_ _03646_ VDD VSS NOR2_X2
X_19856_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[0\]
+ _03647_ VDD VSS CLKBUF_X3
X_19857_ _03647_ _03451_ _03648_ VDD VSS NAND2_X1
X_19858_ _03618_ _03646_ _03648_ _00004_ VDD VSS OAI21_X1
X_19859_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_valid
+ _03615_ _03649_ VDD VSS NAND2_X1
X_19860_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[5\]
+ _03650_ VDD VSS BUF_X4
X_19861_ _03650_ _03651_ VDD VSS BUF_X4
X_19862_ _03651_ _03652_ VDD VSS BUF_X4
X_19863_ _03652_ _03647_ _03646_ _03653_ VDD VSS AOI21_X1
X_19864_ _03649_ _03653_ _03615_ _00003_ VDD VSS OAI21_X1
X_19865_ _14068_ alu_adder_result_ex\[0\] VDD VSS INV_X4
X_19866_ _11430_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[2\]
+ _03654_ VDD VSS OR2_X1
X_19867_ _03654_ _03655_ VDD VSS CLKBUF_X3
X_19868_ _03655_ _03656_ VDD VSS BUF_X4
X_19869_ _12316_ _03656_ _03657_ VDD VSS NAND2_X4
X_19870_ _03656_ _03658_ VDD VSS BUF_X4
X_19871_ _10706_ _10729_ _03659_ VDD VSS OR2_X1
X_19872_ _03659_ _03660_ VDD VSS BUF_X4
X_19873_ _03657_ _03658_ _03660_ _03661_ VDD VSS OAI21_X4
X_19874_ _03661_ _03662_ VDD VSS INV_X4
X_19875_ _11400_ _11430_ _03663_ VDD VSS OR2_X2
X_19876_ _03663_ _03664_ VDD VSS BUF_X4
X_19877_ _10813_ _03664_ _03665_ VDD VSS NOR2_X1
X_19878_ _03663_ _03666_ VDD VSS BUF_X4
X_19879_ _03665_ _03666_ _12350_ _03667_ VDD VSS AOI21_X4
X_19880_ _03662_ _03667_ _15550_ VDD VSS NOR2_X1
X_19881_ _00217_ _11402_ _03668_ VDD VSS OR2_X1
X_19882_ _11433_ _03669_ VDD VSS CLKBUF_X3
X_19883_ _00690_ _03670_ VDD VSS BUF_X2
X_19884_ _03668_ _03669_ _03670_ _03671_ VDD VSS OAI21_X1
X_19885_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[48\]
+ _03658_ _03671_ _11431_ _03672_ VDD VSS AOI22_X1
X_19886_ _03672_ _15551_ VDD VSS INV_X1
X_19887_ _03667_ _03673_ VDD VSS INV_X1
X_19888_ _11928_ _10433_ _03674_ VDD VSS AND2_X1
X_19889_ _03674_ _10470_ _10474_ _03675_ VDD VSS AOI21_X4
X_19890_ _03675_ _12392_ _03656_ _03676_ VDD VSS MUX2_X2
X_19891_ _03673_ net362 _14069_ VDD VSS NAND2_X1
X_19892_ _03667_ _03677_ VDD VSS BUF_X4
X_19893_ _10972_ _03655_ _03678_ VDD VSS NOR2_X1
X_19894_ _03678_ _03656_ net367 _03679_ VDD VSS AOI21_X4
X_19895_ _03677_ _03679_ _15563_ VDD VSS NOR2_X1
X_19896_ _03676_ _03680_ VDD VSS BUF_X8
X_19897_ _10642_ _10659_ _03681_ VDD VSS AND2_X4
X_19898_ _03681_ _12425_ _03663_ _03682_ VDD VSS MUX2_X1
X_19899_ _03682_ _03683_ VDD VSS BUF_X4
X_19900_ net361 _03683_ _14076_ VDD VSS NAND2_X1
X_19901_ net368 _03655_ _03684_ VDD VSS AND2_X4
X_19902_ _11430_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[2\]
+ _03685_ VDD VSS NOR2_X4
X_19903_ _03684_ _03685_ _11019_ _03686_ VDD VSS AOI21_X4
X_19904_ _03677_ _03686_ _15567_ VDD VSS NOR2_X1
X_19905_ _03679_ _03687_ VDD VSS BUF_X4
X_19906_ _03683_ _03688_ VDD VSS INV_X2
X_19907_ _03687_ _03688_ _15566_ VDD VSS NOR2_X1
X_19908_ net296 _12514_ _03666_ _03689_ VDD VSS MUX2_X1
X_19909_ _03689_ _03690_ VDD VSS BUF_X4
X_19910_ net361 net366 _14080_ VDD VSS NAND2_X1
X_19911_ _11057_ _03656_ _03691_ VDD VSS NOR2_X1
X_19912_ _03691_ _03656_ _12651_ _03692_ VDD VSS AOI21_X4
X_19913_ _03677_ _03692_ _14084_ VDD VSS NOR2_X1
X_19914_ _03688_ _03686_ _14086_ VDD VSS NOR2_X1
X_19915_ _03689_ _03693_ VDD VSS INV_X2
X_19916_ _03687_ _03693_ _14085_ VDD VSS NOR2_X1
X_19917_ net317 _12589_ _03664_ _03694_ VDD VSS MUX2_X2
X_19918_ _03694_ _03695_ VDD VSS BUF_X8
X_19919_ net361 _03695_ _14091_ VDD VSS NAND2_X1
X_19920_ _11083_ _11093_ _11105_ _11114_ _03696_ VDD VSS NAND4_X4
X_19921_ _03696_ net410 _03656_ _03697_ VDD VSS MUX2_X2
X_19922_ _03697_ _03698_ VDD VSS INV_X1
X_19923_ _03677_ _03698_ _15589_ VDD VSS NOR2_X1
X_19924_ _03688_ _03692_ _14105_ VDD VSS NOR2_X1
X_19925_ _03686_ _03699_ VDD VSS BUF_X8
X_19926_ _03699_ _03693_ _14104_ VDD VSS NOR2_X1
X_19927_ _03694_ _03700_ VDD VSS INV_X2
X_19928_ _03687_ _03700_ _14106_ VDD VSS NOR2_X1
X_19929_ _11591_ net358 _03666_ _03701_ VDD VSS MUX2_X1
X_19930_ _03701_ _03702_ VDD VSS BUF_X4
X_19931_ net361 _03702_ _14110_ VDD VSS NAND2_X1
X_19932_ net345 net407 _03655_ _03703_ VDD VSS MUX2_X2
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
X_19934_ net340 _03705_ VDD VSS INV_X1
X_19935_ _03677_ _03705_ _15602_ VDD VSS NOR2_X1
X_19936_ _03688_ _03698_ _15601_ VDD VSS NOR2_X1
X_19937_ _03693_ _03692_ _14127_ VDD VSS NOR2_X1
X_19938_ _03699_ _03700_ _14129_ VDD VSS NOR2_X1
X_19939_ _03701_ _03706_ VDD VSS INV_X2
X_19940_ _03687_ _03706_ _14128_ VDD VSS NOR2_X1
X_19941_ _11629_ net375 _03666_ _03707_ VDD VSS MUX2_X1
X_19942_ _03707_ _03708_ VDD VSS BUF_X4
X_19943_ net361 _03708_ _14132_ VDD VSS NAND2_X1
X_19944_ _11202_ _12896_ _03655_ _03709_ VDD VSS MUX2_X2
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
X_19946_ _03673_ net337 _14146_ VDD VSS NAND2_X1
X_19947_ _03692_ _03711_ VDD VSS CLKBUF_X3
X_19948_ _03711_ _03700_ _14152_ VDD VSS NOR2_X1
X_19949_ _03699_ _03706_ _14151_ VDD VSS NOR2_X1
X_19950_ _03707_ _03712_ VDD VSS INV_X2
X_19951_ _03687_ _03712_ _14150_ VDD VSS NOR2_X1
X_19952_ _12840_ _12858_ _03713_ VDD VSS NOR2_X4
X_19953_ _11672_ _03713_ _03666_ _03714_ VDD VSS MUX2_X1
X_19954_ _03714_ _03715_ VDD VSS BUF_X4
X_19955_ _03680_ _03715_ _14161_ VDD VSS NAND2_X1
X_19956_ net372 _03656_ _03716_ VDD VSS NAND2_X4
X_19957_ _03716_ _03658_ _11241_ _03717_ VDD VSS OAI21_X4
X_19958_ _03717_ _03718_ VDD VSS INV_X1
X_19959_ _03677_ _03718_ _15635_ VDD VSS NOR2_X1
X_19960_ _03683_ net337 _14178_ VDD VSS NAND2_X1
X_19961_ _03711_ _03706_ _14183_ VDD VSS NOR2_X1
X_19962_ _03699_ _03712_ _14182_ VDD VSS NOR2_X1
X_19963_ _11431_ _11430_ _03719_ VDD VSS NOR2_X2
X_19964_ _03719_ _03720_ VDD VSS BUF_X4
X_19965_ _12859_ _03720_ _03721_ VDD VSS NOR2_X1
X_19966_ _03721_ _03720_ _11672_ _03722_ VDD VSS AOI21_X4
X_19967_ _03687_ _03722_ _14184_ VDD VSS NOR2_X1
X_19968_ _11694_ _11713_ _03723_ VDD VSS NOR2_X4
X_19969_ _12915_ _12933_ _03724_ VDD VSS NOR2_X4
X_19970_ _03723_ _03724_ _03666_ _03725_ VDD VSS MUX2_X1
X_19971_ _03725_ _03726_ VDD VSS BUF_X4
X_19972_ _03680_ _03726_ _14190_ VDD VSS NAND2_X1
X_19973_ _11253_ _11260_ _11269_ _11278_ _03727_ VDD VSS OR4_X4
X_19974_ _03727_ _13061_ _03655_ _03728_ VDD VSS MUX2_X1
X_19975_ _03728_ _03729_ VDD VSS BUF_X4
X_19976_ _03729_ _03730_ VDD VSS INV_X1
X_19977_ _03677_ _03730_ _15645_ VDD VSS NOR2_X1
X_19978_ _03688_ _03718_ _15646_ VDD VSS NOR2_X1
X_19979_ _03690_ net383 _14208_ VDD VSS NAND2_X1
X_19980_ _03711_ _03712_ _14215_ VDD VSS NOR2_X1
X_19981_ _03699_ _03722_ _14214_ VDD VSS NOR2_X2
X_19982_ _11714_ _12934_ _03666_ _03731_ VDD VSS MUX2_X2
X_19983_ _03687_ _03731_ _14213_ VDD VSS NOR2_X2
X_19984_ _11764_ _11786_ _03732_ VDD VSS NOR2_X4
X_19985_ _13004_ _13022_ _03733_ VDD VSS NOR2_X4
X_19986_ _03732_ _03733_ _03666_ _03734_ VDD VSS MUX2_X1
X_19987_ _03734_ _03735_ VDD VSS BUF_X4
X_19988_ _03680_ _03735_ _14221_ VDD VSS NAND2_X1
X_19989_ _11296_ _11312_ _03736_ VDD VSS AND2_X2
X_19990_ _03736_ _13155_ _03655_ _03737_ VDD VSS MUX2_X1
X_19991_ _03737_ _03738_ VDD VSS BUF_X4
X_19992_ _03738_ _03739_ VDD VSS CLKBUF_X3
X_19993_ _03673_ _03739_ _14243_ VDD VSS NAND2_X1
X_19994_ _03695_ net383 _14248_ VDD VSS NAND2_X1
X_19995_ _03711_ _03722_ _14255_ VDD VSS NOR2_X1
X_19996_ _03699_ _03731_ _14254_ VDD VSS NOR2_X1
X_19997_ _11787_ _13023_ _03666_ _03740_ VDD VSS MUX2_X2
X_19998_ _03687_ _03740_ _14253_ VDD VSS NOR2_X1
X_19999_ _11824_ _13097_ _03666_ _03741_ VDD VSS MUX2_X1
X_20000_ _03741_ _03742_ VDD VSS BUF_X4
X_20001_ _03680_ _03742_ _14261_ VDD VSS NAND2_X1
X_20002_ _11328_ _11335_ _11342_ _11350_ _03743_ VDD VSS NOR4_X4
X_20003_ _03743_ _03655_ _03744_ VDD VSS NOR2_X1
X_20004_ _03744_ _03656_ _13224_ _03745_ VDD VSS AOI21_X4
X_20005_ _03745_ _03746_ VDD VSS CLKBUF_X3
X_20006_ _03677_ _03746_ _15677_ VDD VSS NOR2_X1
X_20007_ _03683_ _03739_ _14283_ VDD VSS NAND2_X1
X_20008_ _03702_ net383 _14288_ VDD VSS NAND2_X1
X_20009_ _03711_ _03731_ _14295_ VDD VSS NOR2_X1
X_20010_ _03699_ _03740_ _14294_ VDD VSS NOR2_X2
X_20011_ _13078_ _13096_ _03720_ _03747_ VDD VSS NOR3_X2
X_20012_ _03747_ _03720_ _11824_ _03748_ VDD VSS AOI21_X4
X_20013_ _03687_ _03748_ _14293_ VDD VSS NOR2_X1
X_20014_ _11898_ _13187_ _03664_ _03749_ VDD VSS MUX2_X2
X_20015_ _03749_ _03750_ VDD VSS CLKBUF_X3
X_20016_ _03680_ _03750_ _14304_ VDD VSS NAND2_X1
X_20017_ net329 _03685_ _03751_ VDD VSS AND2_X1
X_20018_ _03751_ _03656_ _13314_ _03752_ VDD VSS AOI21_X2
X_20019_ _03752_ _03753_ VDD VSS BUF_X4
X_20020_ _03677_ _03753_ _15688_ VDD VSS NOR2_X1
X_20021_ _03688_ _03746_ _15687_ VDD VSS NOR2_X1
X_20022_ _03690_ _03739_ _14327_ VDD VSS NAND2_X1
X_20023_ _03708_ net383 _14331_ VDD VSS NAND2_X1
X_20024_ _03711_ _03740_ _14338_ VDD VSS NOR2_X1
X_20025_ _03699_ _03748_ _14337_ VDD VSS NOR2_X1
X_20026_ _03749_ _03754_ VDD VSS INV_X2
X_20027_ _03687_ _03754_ _14336_ VDD VSS NOR2_X2
X_20028_ _11398_ net348 _03664_ _03755_ VDD VSS MUX2_X2
X_20029_ _03755_ _03756_ VDD VSS CLKBUF_X3
X_20030_ net362 _03756_ _14354_ VDD VSS NAND2_X1
X_20031_ net341 _03685_ _03757_ VDD VSS AND2_X1
X_20032_ _03757_ _03658_ _03166_ _03758_ VDD VSS AOI21_X2
X_20033_ _03758_ _03759_ VDD VSS BUF_X4
X_20034_ _03667_ _03759_ _14374_ VDD VSS NOR2_X1
X_20035_ _03688_ _03753_ _14373_ VDD VSS NOR2_X1
X_20036_ _03693_ _03746_ _14372_ VDD VSS NOR2_X1
X_20037_ _03695_ _03738_ _14377_ VDD VSS NAND2_X1
X_20038_ _03709_ _03760_ VDD VSS BUF_X8
X_20039_ _03760_ _03715_ _14386_ VDD VSS NAND2_X1
X_20040_ _03711_ _03748_ _14390_ VDD VSS NOR2_X1
X_20041_ _03699_ _03754_ _14392_ VDD VSS NOR2_X1
X_20042_ _03755_ _03761_ VDD VSS INV_X2
X_20043_ _03679_ _03761_ _14391_ VDD VSS NOR2_X1
X_20044_ _03112_ _03130_ _03762_ VDD VSS OR2_X4
X_20045_ _10868_ _03762_ _03664_ _03763_ VDD VSS MUX2_X2
X_20046_ _03763_ _03764_ VDD VSS CLKBUF_X3
X_20047_ _03676_ _03764_ _14406_ VDD VSS NAND2_X1
X_20048_ _12144_ _03275_ _03655_ _03765_ VDD VSS MUX2_X2
X_20049_ _03765_ _03766_ VDD VSS INV_X1
X_20050_ _03667_ _03766_ _15708_ VDD VSS NOR2_X1
X_20051_ _03758_ _03767_ VDD VSS INV_X2
X_20052_ _03683_ _03767_ _14430_ VDD VSS NAND2_X1
X_20053_ _03702_ _03738_ _14434_ VDD VSS NAND2_X1
X_20054_ _03760_ _03726_ _14442_ VDD VSS NAND2_X1
X_20055_ _03711_ _03754_ _14446_ VDD VSS NOR2_X1
X_20056_ _03699_ _03761_ _14448_ VDD VSS NOR2_X1
X_20057_ _03763_ _03768_ VDD VSS INV_X1
X_20058_ _03679_ _03768_ _14447_ VDD VSS NOR2_X1
X_20059_ _03185_ _03203_ _03769_ VDD VSS OR2_X4
X_20060_ _12075_ _03769_ _03664_ _03770_ VDD VSS MUX2_X2
X_20061_ _03770_ _03771_ VDD VSS CLKBUF_X3
X_20062_ _03676_ _03771_ _14461_ VDD VSS NAND2_X1
X_20063_ _03400_ _03772_ VDD VSS INV_X2
X_20064_ _12221_ _03772_ _03655_ _03773_ VDD VSS MUX2_X1
X_20065_ _03773_ _03774_ VDD VSS BUF_X4
X_20066_ _03673_ _03774_ _15719_ VDD VSS AND2_X1
X_20067_ _03688_ _03766_ _15718_ VDD VSS NOR2_X1
X_20068_ _03693_ _03759_ _14484_ VDD VSS NOR2_X1
X_20069_ _03700_ _03753_ _14483_ VDD VSS NOR2_X1
X_20070_ _03706_ _03746_ _14482_ VDD VSS NOR2_X1
X_20071_ _03708_ _03738_ _14489_ VDD VSS NAND2_X1
X_20072_ _03760_ _03735_ _14500_ VDD VSS NAND2_X1
X_20073_ _03711_ _03761_ _14505_ VDD VSS NOR2_X1
X_20074_ _03686_ _03768_ _14504_ VDD VSS NOR2_X1
X_20075_ _03770_ _03775_ VDD VSS INV_X1
X_20076_ _03679_ _03775_ _14506_ VDD VSS NOR2_X1
X_20077_ _12177_ _03311_ _03664_ _03776_ VDD VSS MUX2_X2
X_20078_ _03776_ _03777_ VDD VSS CLKBUF_X3
X_20079_ net362 _03777_ _14520_ VDD VSS NAND2_X1
X_20080_ _10550_ _11405_ _03400_ _03778_ VDD VSS OR3_X1
X_20081_ _03778_ _03779_ VDD VSS CLKBUF_X3
X_20082_ _03779_ _03780_ VDD VSS BUF_X4
X_20083_ _03780_ _03685_ _03781_ VDD VSS NOR2_X4
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
X_20085_ _03677_ _03781_ _14539_ VDD VSS NAND2_X1
X_20086_ _03700_ _03759_ _14545_ VDD VSS NOR2_X2
X_20087_ _03706_ _03753_ _14544_ VDD VSS NOR2_X2
X_20088_ _03712_ _03746_ _14546_ VDD VSS NOR2_X1
X_20089_ _03715_ _03738_ _14554_ VDD VSS NAND2_X1
X_20090_ _03760_ _03742_ _14565_ VDD VSS NAND2_X1
X_20091_ _03711_ _03768_ _14572_ VDD VSS NOR2_X1
X_20092_ _03686_ _03775_ _14571_ VDD VSS NOR2_X1
X_20093_ _03776_ _03782_ VDD VSS INV_X1
X_20094_ _03679_ _03782_ _14570_ VDD VSS NOR2_X1
X_20095_ _03371_ _03386_ _03783_ VDD VSS OR2_X1
X_20096_ _12254_ _03783_ _03664_ _03784_ VDD VSS MUX2_X2
X_20097_ _03676_ _03784_ _14584_ VDD VSS AND2_X1
X_20098_ _03664_ _03785_ VDD VSS BUF_X2
X_20099_ _03783_ _03786_ VDD VSS INV_X1
X_20100_ _10310_ _10488_ _10346_ _10874_ _03787_ VDD VSS NOR4_X4
X_20101_ _10381_ _10380_ _10402_ _03788_ VDD VSS AOI21_X2
X_20102_ _11401_ _03787_ _03788_ _03789_ VDD VSS OAI21_X4
X_20103_ _03786_ _03789_ _03790_ VDD VSS NOR2_X4
X_20104_ _03790_ _03791_ VDD VSS BUF_X4
X_20105_ _03785_ _03791_ _03792_ VDD VSS NAND2_X4
X_20106_ _03662_ _03792_ _14586_ VDD VSS NOR2_X4
X_20107_ _11430_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.imd_val_q_i\[66\]
+ _03793_ VDD VSS NAND2_X1
X_20108_ _11400_ _11433_ _03794_ VDD VSS NAND2_X1
X_20109_ _03794_ _03795_ VDD VSS CLKBUF_X3
X_20110_ _03793_ _03795_ _03670_ _14585_ VDD VSS OAI21_X1
X_20111_ _03688_ _03781_ _14610_ VDD VSS NAND2_X1
X_20112_ _03706_ _03759_ _14614_ VDD VSS NOR2_X1
X_20113_ _03712_ _03753_ _14616_ VDD VSS NOR2_X1
X_20114_ _03722_ _03746_ _14615_ VDD VSS NOR2_X1
X_20115_ _03726_ _03738_ _14624_ VDD VSS NAND2_X1
X_20116_ _03760_ _03750_ _14634_ VDD VSS NAND2_X1
X_20117_ _03692_ _03775_ _14638_ VDD VSS NOR2_X1
X_20118_ _03686_ _03782_ _14640_ VDD VSS NOR2_X1
X_20119_ _03784_ _03796_ VDD VSS INV_X1
X_20120_ _03679_ _03796_ _14639_ VDD VSS NOR2_X1
X_20121_ _03786_ _03719_ _03789_ _03797_ VDD VSS NOR3_X2
X_20122_ _03797_ _03798_ VDD VSS BUF_X4
X_20123_ net362 _03798_ _14651_ VDD VSS AND2_X4
X_20124_ _11430_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.imd_val_q_i\[67\]
+ _03799_ VDD VSS NAND2_X1
X_20125_ _00721_ _03800_ VDD VSS BUF_X2
X_20126_ _03799_ _03795_ _03800_ _14652_ VDD VSS OAI21_X1
X_20127_ _03693_ _03781_ _14671_ VDD VSS NAND2_X1
X_20128_ _03712_ _03759_ _14675_ VDD VSS NOR2_X1
X_20129_ _03722_ _03753_ _14674_ VDD VSS NOR2_X1
X_20130_ _03731_ _03746_ _14676_ VDD VSS NOR2_X1
X_20131_ _03735_ _03738_ _14683_ VDD VSS NAND2_X1
X_20132_ net336 _03756_ _14694_ VDD VSS NAND2_X1
X_20133_ _03692_ _03782_ _14698_ VDD VSS NOR2_X1
X_20134_ _03686_ _03796_ _14697_ VDD VSS NOR2_X1
X_20135_ _03679_ _03792_ _14757_ VDD VSS OR2_X1
X_20136_ _14757_ _14699_ VDD VSS INV_X1
X_20137_ _00555_ _00132_ _03789_ _03801_ VDD VSS OR3_X1
X_20138_ _03801_ _03802_ VDD VSS BUF_X2
X_20139_ _03802_ _03803_ VDD VSS CLKBUF_X3
X_20140_ _00752_ _03804_ VDD VSS BUF_X2
X_20141_ _03803_ _03795_ _03804_ _03805_ VDD VSS OAI21_X1
X_20142_ _03785_ _03805_ _14709_ VDD VSS AND2_X1
X_20143_ _03700_ _03781_ _14729_ VDD VSS NAND2_X1
X_20144_ _03722_ _03759_ _14733_ VDD VSS NOR2_X1
X_20145_ _03731_ _03753_ _14732_ VDD VSS NOR2_X1
X_20146_ _03740_ _03746_ _14734_ VDD VSS NOR2_X1
X_20147_ _03739_ _03742_ _14741_ VDD VSS NAND2_X1
X_20148_ net336 _03764_ _14752_ VDD VSS NAND2_X1
X_20149_ _03692_ _03796_ _14756_ VDD VSS OR2_X1
X_20150_ _03686_ _03792_ _14755_ VDD VSS OR2_X1
X_20151_ _14755_ _14814_ VDD VSS INV_X1
X_20152_ _00783_ _03806_ VDD VSS INV_X2
X_20153_ _03806_ _11434_ _03807_ VDD VSS NAND2_X1
X_20154_ _03720_ _03803_ _03807_ _14766_ VDD VSS AOI21_X1
X_20155_ _03706_ _03781_ _14786_ VDD VSS NAND2_X1
X_20156_ _03731_ _03759_ _14790_ VDD VSS NOR2_X1
X_20157_ _03740_ _03753_ _14792_ VDD VSS NOR2_X1
X_20158_ _03748_ _03745_ _14791_ VDD VSS NOR2_X1
X_20159_ _03739_ _03750_ _14800_ VDD VSS NAND2_X1
X_20160_ net336 _03771_ _14809_ VDD VSS NAND2_X1
X_20161_ _03692_ _03792_ _14813_ VDD VSS NOR2_X1
X_20162_ _00814_ _03808_ VDD VSS BUF_X2
X_20163_ _03803_ _03795_ _03808_ _03809_ VDD VSS OAI21_X1
X_20164_ _03785_ _03809_ _14824_ VDD VSS AND2_X1
X_20165_ _03712_ _03781_ _14842_ VDD VSS NAND2_X1
X_20166_ _03740_ _03759_ _14849_ VDD VSS NOR2_X1
X_20167_ _03748_ _03753_ _14848_ VDD VSS NOR2_X1
X_20168_ _03746_ _03754_ _14847_ VDD VSS NOR2_X1
X_20169_ _03739_ _03756_ _14856_ VDD VSS NAND2_X1
X_20170_ net336 _03777_ _14865_ VDD VSS NAND2_X1
X_20171_ _03697_ _03798_ _14866_ VDD VSS NAND2_X2
X_20172_ _14866_ _14971_ VDD VSS INV_X1
X_20173_ _00845_ _03810_ VDD VSS INV_X1
X_20174_ _03810_ _11434_ _03811_ VDD VSS NAND2_X1
X_20175_ _03720_ _03803_ _03811_ _14876_ VDD VSS AOI21_X1
X_20176_ _03722_ _03781_ _14897_ VDD VSS NAND2_X1
X_20177_ _03748_ _03759_ _14901_ VDD VSS NOR2_X1
X_20178_ _03754_ _03753_ _14900_ VDD VSS NOR2_X1
X_20179_ _03746_ _03761_ _14902_ VDD VSS NOR2_X1
X_20180_ _03739_ _03764_ _14909_ VDD VSS NAND2_X1
X_20181_ _03784_ _03812_ VDD VSS BUF_X4
X_20182_ net336 _03812_ _14919_ VDD VSS NAND2_X1
X_20183_ net340 _03798_ _14918_ VDD VSS NAND2_X1
X_20184_ _14918_ _14972_ VDD VSS INV_X1
X_20185_ _00876_ _03813_ VDD VSS BUF_X2
X_20186_ _03803_ _03795_ _03813_ _03814_ VDD VSS OAI21_X1
X_20187_ _03785_ _03814_ _14931_ VDD VSS AND2_X1
X_20188_ _03731_ _03781_ _14950_ VDD VSS NAND2_X1
X_20189_ _03750_ _03767_ _14954_ VDD VSS NAND2_X1
X_20190_ _03739_ _03771_ _14963_ VDD VSS NAND2_X1
X_20191_ net337 _03798_ _14973_ VDD VSS AND2_X1
X_20192_ _00907_ _03815_ VDD VSS BUF_X2
X_20193_ _03803_ _03795_ _03815_ _03816_ VDD VSS OAI21_X1
X_20194_ _03785_ _03816_ _14984_ VDD VSS AND2_X1
X_20195_ _03740_ net365 _15002_ VDD VSS NAND2_X1
X_20196_ _03756_ _03767_ _15009_ VDD VSS NAND2_X1
X_20197_ _03739_ _03777_ _15015_ VDD VSS NAND2_X1
X_20198_ _03717_ _03798_ _15016_ VDD VSS NAND2_X1
X_20199_ _15016_ _15105_ VDD VSS INV_X1
X_20200_ _00938_ _03817_ VDD VSS BUF_X2
X_20201_ _03802_ _03795_ _03817_ _03818_ VDD VSS OAI21_X1
X_20202_ _03785_ _03818_ _15030_ VDD VSS AND2_X1
X_20203_ _03748_ _03781_ _15050_ VDD VSS NAND2_X1
X_20204_ _03767_ _03764_ _15053_ VDD VSS NAND2_X1
X_20205_ _03739_ _03812_ _15061_ VDD VSS NAND2_X1
X_20206_ _03729_ _03798_ _15060_ VDD VSS NAND2_X1
X_20207_ _15060_ _15103_ VDD VSS INV_X1
X_20208_ _00969_ _03819_ VDD VSS BUF_X2
X_20209_ _03802_ _03795_ _03819_ _03820_ VDD VSS OAI21_X1
X_20210_ _03785_ _03820_ _15073_ VDD VSS AND2_X1
X_20211_ _03754_ net365 _15093_ VDD VSS NAND2_X1
X_20212_ _03767_ _03771_ _15098_ VDD VSS NAND2_X1
X_20213_ _03738_ _03798_ _15104_ VDD VSS AND2_X1
X_20214_ _01000_ _03821_ VDD VSS INV_X1
X_20215_ _03821_ _11434_ _03822_ VDD VSS NAND2_X1
X_20216_ _03720_ _03803_ _03822_ _15117_ VDD VSS AOI21_X2
X_20217_ _03761_ net365 _15136_ VDD VSS NAND2_X1
X_20218_ _03767_ _03777_ _15141_ VDD VSS NAND2_X1
X_20219_ _03745_ _03823_ VDD VSS INV_X2
X_20220_ _03823_ _03798_ _15142_ VDD VSS NAND2_X1
X_20221_ _15142_ _15218_ VDD VSS INV_X1
X_20222_ _01031_ _03824_ VDD VSS BUF_X2
X_20223_ _03802_ _03795_ _03824_ _03825_ VDD VSS OAI21_X1
X_20224_ _03785_ _03825_ _15156_ VDD VSS AND2_X1
X_20225_ _03768_ net365 _15175_ VDD VSS NAND2_X1
X_20226_ _03767_ _03812_ _15179_ VDD VSS NAND2_X1
X_20227_ _03752_ _03826_ VDD VSS INV_X2
X_20228_ _03826_ _03797_ _15180_ VDD VSS NAND2_X1
X_20229_ _15180_ _15217_ VDD VSS INV_X1
X_20230_ _01062_ _03827_ VDD VSS BUF_X2
X_20231_ _03802_ _03795_ _03827_ _03828_ VDD VSS OAI21_X1
X_20232_ _03785_ _03828_ _15193_ VDD VSS AND2_X1
X_20233_ _03775_ net328 _15212_ VDD VSS NAND2_X1
X_20234_ _03759_ _03792_ _15216_ VDD VSS NOR2_X1
X_20235_ _01093_ _03829_ VDD VSS INV_X1
X_20236_ _03829_ _11434_ _03830_ VDD VSS NAND2_X1
X_20237_ _03720_ _03803_ _03830_ _15232_ VDD VSS AOI21_X1
X_20238_ _03782_ net365 _15250_ VDD VSS NAND2_X1
X_20239_ _01124_ _03831_ VDD VSS INV_X1
X_20240_ _03831_ _11434_ _03832_ VDD VSS NAND2_X1
X_20241_ _03720_ _03803_ _03832_ _15272_ VDD VSS AOI21_X2
X_20242_ net365 _03796_ _15290_ VDD VSS NAND2_X1
X_20243_ _03802_ _03794_ _03412_ _03833_ VDD VSS OAI21_X1
X_20244_ _03785_ _03833_ _15308_ VDD VSS AND2_X1
X_20245_ net365 _03792_ _15325_ VDD VSS NAND2_X1
X_20246_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.imd_val_q_i\[66\]
+ _11434_ _03834_ VDD VSS NAND2_X1
X_20247_ _03720_ _03803_ _03834_ _15337_ VDD VSS AOI21_X2
X_20248_ _15327_ _15328_ VDD VSS INV_X1
X_20249_ _15220_ _15221_ VDD VSS INV_X1
X_20250_ _14815_ _14880_ VDD VSS INV_X4
X_20251_ _10304_ _10522_ _10670_ _10997_ _03835_ VDD VSS NAND4_X2
X_20252_ _03465_ _10886_ _10876_ _03835_ _03836_ VDD VSS OR4_X2
X_20253_ id_stage_i.controller_i.store_err_q id_stage_i.controller_i.load_err_q
+ _03837_ VDD VSS OR2_X2
X_20254_ id_stage_i.controller_i.exc_req_q _03837_ _03838_
+ VDD VSS NOR2_X4
X_20255_ _10886_ _10887_ _10889_ _03835_ _03839_ VDD VSS OR4_X2
X_20256_ _03836_ _03838_ _03465_ _03839_ _03840_ VDD VSS OAI211_X2
X_20257_ _03465_ _10892_ _10876_ _03841_ VDD VSS OR3_X1
X_20258_ _01157_ _03842_ VDD VSS BUF_X2
X_20259_ _10304_ _11419_ _03843_ VDD VSS NAND2_X2
X_20260_ _01156_ _03844_ VDD VSS BUF_X4
X_20261_ _03462_ _03463_ _03845_ VDD VSS NAND2_X1
X_20262_ cs_registers_i.dcsr_q\[15\] _03846_ VDD VSS INV_X1
X_20263_ _03462_ _03463_ _03847_ VDD VSS OR2_X1
X_20264_ cs_registers_i.dcsr_q\[12\] _03848_ VDD VSS INV_X1
X_20265_ _03844_ _03845_ _03846_ _03847_ _03848_ _03849_ VDD
+ VSS OAI221_X2
X_20266_ _03842_ _03843_ _03849_ _03850_ VDD VSS NAND3_X1
X_20267_ _11419_ id_stage_i.controller_i.illegal_insn_q _03851_
+ VDD VSS NOR2_X1
X_20268_ _10466_ _03851_ _03852_ VDD VSS NAND2_X1
X_20269_ _03835_ _03852_ _03853_ VDD VSS OR2_X1
X_20270_ _03841_ _03838_ _03850_ _03853_ _03854_ VDD VSS OR4_X2
X_20271_ _03461_ _03840_ _03854_ _03855_ VDD VSS NAND3_X2
X_20272_ cs_registers_i.mie_q\[4\] net136 cs_registers_i.mie_q\[5\]
+ net137 _03856_ VDD VSS AOI22_X4
X_20273_ cs_registers_i.mie_q\[6\] net138 cs_registers_i.mie_q\[7\]
+ net139 _03857_ VDD VSS AOI22_X4
X_20274_ cs_registers_i.mie_q\[2\] net134 cs_registers_i.mie_q\[3\]
+ net135 _03858_ VDD VSS AOI22_X4
X_20275_ cs_registers_i.mie_q\[0\] net127 cs_registers_i.mie_q\[1\]
+ net133 _03859_ VDD VSS AOI22_X2
X_20276_ _03856_ _03857_ _03858_ _03859_ _03860_ VDD VSS AND4_X2
X_20277_ cs_registers_i.mie_q\[10\] net128 cs_registers_i.mie_q\[11\]
+ net129 _03861_ VDD VSS AOI22_X2
X_20278_ cs_registers_i.mie_q\[8\] net140 cs_registers_i.mie_q\[9\]
+ net141 _03862_ VDD VSS AOI22_X2
X_20279_ cs_registers_i.mie_q\[12\] net130 cs_registers_i.mie_q\[13\]
+ net131 _03863_ VDD VSS AOI22_X4
X_20280_ cs_registers_i.mie_q\[14\] net132 _03864_ VDD VSS
+ NAND2_X2
X_20281_ _03861_ _03862_ _03863_ _03864_ _03865_ VDD VSS AND4_X1
X_20282_ net126 cs_registers_i.mie_q\[15\] cs_registers_i.mie_q\[17\]
+ net142 _03866_ VDD VSS AOI22_X4
X_20283_ irq_nm_i _03867_ VDD VSS CLKBUF_X3
X_20284_ _03867_ cs_registers_i.mie_q\[16\] net143 _03868_
+ VDD VSS AOI21_X2
X_20285_ _03860_ _03865_ _03866_ _03868_ _03869_ VDD VSS NAND4_X4
X_20286_ cs_registers_i.nmi_mode_i _03870_ VDD VSS CLKBUF_X3
X_20287_ _03867_ cs_registers_i.csr_mstatus_mie_o _03871_
+ VDD VSS NOR2_X1
X_20288_ _03477_ _03870_ _03871_ _03872_ VDD VSS NOR3_X4
X_20289_ _11420_ _03459_ _03869_ _03872_ _03873_ VDD VSS NAND4_X4
X_20290_ id_stage_i.branch_set net254 _03843_ _03874_ VDD
+ VSS NAND3_X1
X_20291_ _11422_ _03875_ VDD VSS INV_X2
X_20292_ _03458_ _03875_ _11424_ _03876_ VDD VSS NAND3_X4
X_20293_ _03458_ _11424_ _03877_ VDD VSS NAND2_X4
X_20294_ _03875_ _03877_ _03878_ VDD VSS NOR2_X4
X_20295_ cs_registers_i.dcsr_q\[2\] _03879_ VDD VSS CLKBUF_X2
X_20296_ _03879_ net60 _03880_ VDD VSS OR2_X2
X_20297_ _03878_ _03880_ _11420_ _03881_ VDD VSS OAI21_X2
X_20298_ _03873_ _03874_ _03876_ _03881_ _03882_ VDD VSS AND4_X2
X_20299_ _03855_ _03882_ _03883_ VDD VSS NAND2_X2
X_20300_ _10352_ _10342_ _10349_ _03884_ VDD VSS AOI21_X2
X_20301_ _10340_ _03884_ _03885_ VDD VSS NOR2_X2
X_20302_ _10306_ _10401_ _03438_ _03886_ VDD VSS NOR3_X4
X_20303_ net254 _03843_ _03885_ _03886_ _03887_ VDD VSS NAND4_X4
X_20304_ _03434_ _03887_ _03888_ VDD VSS NOR2_X2
X_20305_ _03883_ _03888_ _03889_ VDD VSS NOR2_X1
X_20306_ _03458_ _11422_ _11424_ _03890_ VDD VSS NAND3_X4
X_20307_ id_stage_i.controller_i.exc_req_q _03837_ _03891_
+ VDD VSS OR2_X2
X_20308_ _03459_ _03891_ _11420_ _03892_ VDD VSS OAI21_X2
X_20309_ _03890_ _03892_ _03893_ VDD VSS NAND2_X4
X_20310_ _03466_ _03468_ _03894_ VDD VSS NAND2_X4
X_20311_ _10661_ _03475_ _03468_ _03895_ VDD VSS NAND3_X4
X_20312_ _03894_ _03895_ _03891_ _03896_ VDD VSS OAI21_X2
X_20313_ _03893_ _03896_ _03461_ _11425_ _11420_ _03897_ VDD
+ VSS AOI221_X2
X_20314_ _03889_ _03897_ _03898_ VDD VSS NOR2_X1
X_20315_ _03856_ _03857_ _03858_ _03859_ _03899_ VDD VSS NAND4_X2
X_20316_ _03861_ _03862_ _03900_ VDD VSS AND2_X1
X_20317_ _03900_ _03863_ _03864_ _03901_ VDD VSS NAND3_X2
X_20318_ _03899_ _03901_ _03902_ VDD VSS NOR2_X2
X_20319_ cs_registers_i.mie_q\[13\] net131 _03903_ VDD VSS
+ NAND2_X1
X_20320_ cs_registers_i.mie_q\[12\] net130 _03904_ VDD VSS
+ AND2_X1
X_20321_ cs_registers_i.mie_q\[7\] net139 _03905_ VDD VSS
+ NAND2_X1
X_20322_ cs_registers_i.mie_q\[6\] net138 _03906_ VDD VSS
+ NAND2_X1
X_20323_ cs_registers_i.mie_q\[3\] net135 _03907_ VDD VSS
+ NAND2_X1
X_20324_ cs_registers_i.mie_q\[2\] net134 _03908_ VDD VSS
+ NAND2_X1
X_20325_ cs_registers_i.mie_q\[1\] net133 _03908_ _03909_
+ VDD VSS NAND3_X1
X_20326_ cs_registers_i.mie_q\[4\] net136 _03907_ _03909_
+ _03910_ VDD VSS AOI22_X1
X_20327_ cs_registers_i.mie_q\[5\] net137 _03911_ VDD VSS
+ AND2_X1
X_20328_ _03906_ _03910_ _03911_ _03912_ VDD VSS OAI21_X1
X_20329_ cs_registers_i.mie_q\[8\] net140 _03905_ _03912_
+ _03913_ VDD VSS AOI22_X1
X_20330_ _03913_ net141 cs_registers_i.mie_q\[9\] _03914_
+ VDD VSS AOI21_X1
X_20331_ _03914_ net128 cs_registers_i.mie_q\[10\] _03915_
+ VDD VSS AOI21_X1
X_20332_ _03915_ net129 cs_registers_i.mie_q\[11\] _03916_
+ VDD VSS AOI21_X1
X_20333_ _03903_ _03904_ _03916_ _03917_ VDD VSS OAI21_X1
X_20334_ _03870_ _03918_ VDD VSS INV_X2
X_20335_ _03902_ _03917_ _03864_ _03867_ _03918_ _03919_ VDD
+ VSS AOI221_X2
X_20336_ _03873_ _03919_ _03920_ VDD VSS NOR2_X2
X_20337_ _03461_ _03838_ _03921_ VDD VSS NAND2_X4
X_20338_ _03894_ _03921_ _03922_ VDD VSS NOR2_X4
X_20339_ _03922_ _03923_ VDD VSS BUF_X4
X_20340_ _03923_ _03924_ VDD VSS BUF_X4
X_20341_ _03895_ _03921_ _03925_ VDD VSS NOR2_X4
X_20342_ _03925_ _03926_ VDD VSS BUF_X4
X_20343_ _03926_ _03927_ VDD VSS BUF_X4
X_20344_ _03920_ _03924_ cs_registers_i.csr_mepc_o\[2\] _03927_
+ cs_registers_i.csr_depc_o\[2\] _03928_ VDD VSS AOI221_X2
X_20345_ net254 _03929_ VDD VSS BUF_X4
X_20346_ _03929_ _03930_ VDD VSS BUF_X4
X_20347_ _03930_ _03931_ VDD VSS BUF_X4
X_20348_ _03931_ alu_adder_result_ex\[2\] _03932_ VDD VSS
+ NAND2_X1
X_20349_ _03928_ _03932_ _03933_ VDD VSS NAND2_X1
X_20350_ _03898_ _03933_ _03934_ VDD VSS NAND2_X1
X_20351_ _03855_ _03882_ _03887_ _03434_ _03935_ VDD VSS OAI211_X4
X_20352_ _03935_ _03936_ VDD VSS BUF_X4
X_20353_ _03936_ _03937_ VDD VSS BUF_X4
X_20354_ _03937_ _03938_ VDD VSS BUF_X4
X_20355_ _03938_ _03939_ VDD VSS BUF_X4
X_20356_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[2\]
+ _03940_ VDD VSS INV_X1
X_20357_ _03934_ _03939_ _03940_ _16108_ VDD VSS OAI21_X2
X_20358_ _03873_ _03941_ VDD VSS INV_X1
X_20359_ _03863_ _03942_ VDD VSS INV_X1
X_20360_ _03856_ _03943_ VDD VSS INV_X1
X_20361_ _03857_ _03858_ _03943_ _03944_ VDD VSS OAI21_X1
X_20362_ _03862_ _03944_ _03945_ VDD VSS NAND2_X1
X_20363_ _03942_ _03945_ _03861_ _03946_ VDD VSS AOI21_X1
X_20364_ _03867_ _03947_ VDD VSS INV_X1
X_20365_ _03864_ _03901_ _03899_ _03947_ _03870_ _03948_ VDD
+ VSS OAI221_X2
X_20366_ _03941_ _03946_ _03948_ _03949_ VDD VSS OAI21_X2
X_20367_ _01163_ _03950_ VDD VSS INV_X1
X_20368_ net254 alu_adder_result_ex\[3\] _03925_ _03950_ _03951_
+ VDD VSS AOI22_X1
X_20369_ _03436_ _03459_ _03952_ VDD VSS NAND2_X2
X_20370_ _03952_ _03838_ _03953_ VDD VSS NOR2_X4
X_20371_ _03844_ _03954_ VDD VSS INV_X2
X_20372_ cs_registers_i.csr_mepc_o\[3\] _03922_ _03953_ _03954_
+ _03955_ VDD VSS AOI22_X1
X_20373_ _03935_ _03949_ _03951_ _03955_ _03956_ VDD VSS AND4_X2
X_20374_ _03889_ _03957_ VDD VSS BUF_X4
X_20375_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[3\]
+ _03958_ VDD VSS INV_X1
X_20376_ _03956_ _03957_ _03958_ _16110_ VDD VSS AOI21_X4
X_20377_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_q
+ _03959_ VDD VSS BUF_X4
X_20378_ _03959_ _03939_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_q
+ _03960_ VDD VSS OAI21_X1
X_20379_ _03960_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_d
+ VDD VSS INV_X1
X_20380_ cs_registers_i.pc_if_i\[1\] _03961_ VDD VSS CLKBUF_X3
X_20381_ _03961_ _03962_ VDD VSS CLKBUF_X3
X_20382_ _03962_ _03963_ VDD VSS BUF_X4
X_20383_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[0\]
+ _03964_ VDD VSS BUF_X2
X_20384_ _03964_ _03965_ VDD VSS INV_X4
X_20385_ instr_err_i _03966_ VDD VSS BUF_X2
X_20386_ instr_rdata_i[17] _03967_ VDD VSS BUF_X2
X_20387_ instr_rdata_i[16] _03968_ VDD VSS CLKBUF_X2
X_20388_ _03966_ _03967_ _03968_ _03969_ VDD VSS AOI21_X1
X_20389_ _03965_ _03969_ _03970_ VDD VSS AND2_X1
X_20390_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[0\]
+ _03971_ VDD VSS BUF_X2
X_20391_ _03971_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[16\]
+ _03972_ VDD VSS AOI21_X2
X_20392_ _03964_ _03973_ VDD VSS BUF_X4
X_20393_ _03970_ _03972_ _03973_ _03974_ VDD VSS AOI21_X4
X_20394_ _03963_ _03974_ _03975_ VDD VSS NAND2_X2
X_20395_ _03966_ net104 net95 _03976_ VDD VSS AOI21_X1
X_20396_ _03971_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[1\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[0\]
+ _03977_ VDD VSS AOI21_X1
X_20397_ _03973_ _03978_ VDD VSS CLKBUF_X3
X_20398_ _03978_ _03979_ VDD VSS CLKBUF_X3
X_20399_ _03976_ _03977_ _03979_ _03980_ VDD VSS MUX2_X2
X_20400_ _03963_ _03981_ VDD VSS BUF_X4
X_20401_ _03975_ _03980_ _03981_ _15831_ VDD VSS OAI21_X4
X_20402_ _15831_ _15353_ VDD VSS INV_X1
X_20403_ net145 _03982_ VDD VSS INV_X1
X_20404_ net60 core_busy_q _03983_ VDD VSS OR2_X1
X_20405_ fetch_enable_q _03869_ _03983_ net146 VDD VSS OAI21_X1
X_20406_ _03982_ net146 _03984_ VDD VSS AND2_X1
X_20407_ _03984_ _00006_ VDD VSS INV_X1
X_20408_ _03661_ _03985_ VDD VSS BUF_X8
X_20409_ net352 _03689_ _14074_ VDD VSS NAND2_X1
X_20410_ _03658_ _03986_ VDD VSS BUF_X4
X_20411_ _03806_ _03669_ _03987_ VDD VSS NOR2_X1
X_20412_ _11433_ _03988_ VDD VSS CLKBUF_X3
X_20413_ _03987_ _03988_ _00557_ _03989_ VDD VSS AOI21_X1
X_20414_ _11431_ _03990_ VDD VSS BUF_X4
X_20415_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[51\]
+ _03986_ _03989_ _03990_ _14079_ VDD VSS AOI22_X2
X_20416_ net352 _03702_ _14089_ VDD VSS NAND2_X1
X_20417_ _15577_ _14099_ VDD VSS INV_X1
X_20418_ _03810_ _03669_ _03991_ VDD VSS NOR2_X1
X_20419_ _03991_ _03988_ _00559_ _03992_ VDD VSS AOI21_X1
X_20420_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[53\]
+ _03986_ _03992_ _03990_ _14109_ VDD VSS AOI22_X2
X_20421_ _15585_ _14117_ VDD VSS INV_X1
X_20422_ _03683_ net340 _14145_ VDD VSS NAND2_X1
X_20423_ _03985_ _03726_ _14159_ VDD VSS NAND2_X1
X_20424_ _15614_ _14172_ VDD VSS INV_X1
X_20425_ _03690_ _03703_ _14177_ VDD VSS NAND2_X1
X_20426_ _15633_ _14229_ VDD VSS INV_X1
X_20427_ _15651_ _14269_ VDD VSS INV_X1
X_20428_ _15664_ _14312_ VDD VSS INV_X1
X_20429_ _03729_ _03993_ VDD VSS BUF_X4
X_20430_ _03695_ _03993_ _14326_ VDD VSS NAND2_X1
X_20431_ net352 _03764_ _14352_ VDD VSS NAND2_X1
X_20432_ _03703_ _03994_ VDD VSS BUF_X8
X_20433_ _03994_ _03726_ _14385_ VDD VSS NAND2_X1
X_20434_ _03695_ _03823_ _14428_ VDD VSS NAND2_X1
X_20435_ _03708_ _03993_ _14433_ VDD VSS NAND2_X1
X_20436_ _03994_ _03735_ _14441_ VDD VSS NAND2_X2
X_20437_ _03717_ _03995_ VDD VSS BUF_X8
X_20438_ _03995_ _03726_ _14487_ VDD VSS NAND2_X1
X_20439_ _03994_ _03742_ _14499_ VDD VSS NAND2_X1
X_20440_ _03985_ _03812_ _14518_ VDD VSS NAND2_X1
X_20441_ _03726_ _03729_ _14553_ VDD VSS NAND2_X1
X_20442_ _03774_ _03996_ VDD VSS BUF_X4
X_20443_ net366 _03996_ _14609_ VDD VSS NAND2_X1
X_20444_ _03995_ _03742_ _14622_ VDD VSS NAND2_X1
X_20445_ net339 _03756_ _14633_ VDD VSS NAND2_X1
Xclone2 _03792_ _03662_ net2 VDD VSS NOR2_X4
X_20447_ _03702_ _03765_ _14669_ VDD VSS NAND2_X1
X_20448_ _03993_ _03742_ _14682_ VDD VSS NAND2_X1
X_20449_ _03697_ _03998_ VDD VSS BUF_X8
X_20450_ net343 _03771_ _14692_ VDD VSS NAND2_X1
X_20451_ _03708_ _03765_ _14727_ VDD VSS NAND2_X1
X_20452_ _03993_ _03750_ _14740_ VDD VSS NAND2_X1
X_20453_ net343 _03777_ _14750_ VDD VSS NAND2_X1
X_20454_ _03708_ _03996_ _14785_ VDD VSS NAND2_X1
X_20455_ net353 _03764_ _14798_ VDD VSS NAND2_X1
X_20456_ net339 _03777_ _14808_ VDD VSS NAND2_X1
X_20457_ _03993_ _03764_ _14855_ VDD VSS NAND2_X1
X_20458_ _03735_ _03765_ _14895_ VDD VSS NAND2_X1
X_20459_ _03993_ _03771_ _14908_ VDD VSS NAND2_X1
X_20460_ _03735_ _03996_ _14949_ VDD VSS NAND2_X1
X_20461_ net353 _03812_ _14961_ VDD VSS NAND2_X1
X_20462_ _03823_ _03771_ _15007_ VDD VSS NAND2_X1
X_20463_ _03993_ _03812_ _15014_ VDD VSS NAND2_X1
X_20464_ _14975_ _14976_ VDD VSS INV_X1
X_20465_ _03756_ net300 _15048_ VDD VSS NAND2_X1
X_20466_ _03764_ net300 _15091_ VDD VSS NAND2_X1
X_20467_ _03823_ _03812_ _15096_ VDD VSS NAND2_X1
X_20468_ _03764_ _03996_ _15135_ VDD VSS NAND2_X1
X_20469_ _03826_ _03812_ _15140_ VDD VSS NAND2_X1
X_20470_ _03771_ _03996_ _15174_ VDD VSS NAND2_X1
X_20471_ _03996_ _03777_ _15211_ VDD VSS NAND2_X1
X_20472_ _15024_ _15025_ VDD VSS INV_X4
X_20473_ net300 _03798_ _15251_ VDD VSS NAND2_X2
X_20474_ net352 _03683_ _14070_ VDD VSS NAND2_X1
X_20475_ _11402_ _03999_ VDD VSS CLKBUF_X2
X_20476_ _00556_ _03999_ _04000_ VDD VSS OR2_X1
X_20477_ _04000_ _03988_ _03804_ _04001_ VDD VSS OAI21_X1
X_20478_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[50\]
+ _03986_ _04001_ _03990_ _14075_ VDD VSS AOI22_X2
X_20479_ _00558_ _03999_ _04002_ VDD VSS OR2_X1
X_20480_ _04002_ _03988_ _03808_ _04003_ VDD VSS OAI21_X1
X_20481_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[52\]
+ _03986_ _04003_ _03990_ _14090_ VDD VSS AOI22_X2
X_20482_ net352 _03715_ _14133_ VDD VSS NAND2_X1
X_20483_ _15595_ _14141_ VDD VSS INV_X1
X_20484_ _00561_ _03999_ _04004_ VDD VSS OR2_X1
X_20485_ _04004_ _03988_ _03815_ _04005_ VDD VSS OAI21_X1
X_20486_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[55\]
+ _03986_ _04005_ _03990_ _14160_ VDD VSS AOI22_X2
X_20487_ _15606_ _14168_ VDD VSS INV_X1
X_20488_ _03985_ _03735_ _14191_ VDD VSS NAND2_X1
X_20489_ _15620_ _14199_ VDD VSS INV_X1
X_20490_ _03998_ _03702_ _14209_ VDD VSS NAND2_X2
X_20491_ _03985_ _03742_ _14222_ VDD VSS NAND2_X1
X_20492_ _15639_ _14230_ VDD VSS INV_X1
X_20493_ net366 _03995_ _14244_ VDD VSS NAND2_X1
X_20494_ _03998_ _03708_ _14249_ VDD VSS NAND2_X1
X_20495_ _03985_ _03750_ _14262_ VDD VSS NAND2_X2
X_20496_ _15655_ _14270_ VDD VSS INV_X1
X_20497_ _03695_ _03717_ _14284_ VDD VSS NAND2_X1
X_20498_ _03998_ _03715_ _14289_ VDD VSS NAND2_X1
X_20499_ _03661_ _03756_ _14305_ VDD VSS NAND2_X1
X_20500_ _15668_ _14313_ VDD VSS INV_X1
X_20501_ _03998_ _03726_ _14332_ VDD VSS NAND2_X1
X_20502_ _00566_ _03999_ _04006_ VDD VSS OR2_X1
X_20503_ _04006_ _03988_ _03827_ _04007_ VDD VSS OAI21_X1
X_20504_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[60\]
+ _03986_ _04007_ _03990_ _14353_ VDD VSS AOI22_X2
X_20505_ _03708_ _03717_ _14378_ VDD VSS NAND2_X1
X_20506_ _03661_ _03771_ _14407_ VDD VSS NAND2_X1
X_20507_ _03690_ _03826_ _14429_ VDD VSS NAND2_X1
X_20508_ _03661_ _03777_ _14462_ VDD VSS NAND2_X1
X_20509_ _03715_ _03729_ _14488_ VDD VSS NAND2_X1
X_20510_ _00659_ _03999_ _04008_ VDD VSS OR2_X1
X_20511_ _04008_ _03988_ _03412_ _04009_ VDD VSS OAI21_X1
X_20512_ _03408_ _03986_ _04009_ _03990_ _14519_ VDD VSS AOI22_X2
X_20513_ _03690_ _03765_ _14540_ VDD VSS NAND2_X1
X_20514_ net343 _03756_ _14566_ VDD VSS NAND2_X1
X_20515_ _03993_ _03735_ _14623_ VDD VSS NAND2_X1
X_20516_ _03695_ _03996_ _14670_ VDD VSS NAND2_X1
X_20517_ net339 _03764_ _14693_ VDD VSS NAND2_X1
X_20518_ _03702_ _03996_ _14728_ VDD VSS NAND2_X1
X_20519_ net339 _03771_ _14751_ VDD VSS NAND2_X1
X_20520_ _03993_ _03756_ _14799_ VDD VSS NAND2_X1
X_20521_ _03726_ _03765_ _14843_ VDD VSS NAND2_X1
X_20522_ _03726_ _03774_ _14896_ VDD VSS NAND2_X1
X_20523_ _03823_ _03763_ _14955_ VDD VSS NAND2_X1
X_20524_ _03993_ _03777_ _14962_ VDD VSS NAND2_X1
X_20525_ _03750_ net300 _15003_ VDD VSS NAND2_X1
X_20526_ _03826_ _03763_ _15008_ VDD VSS NAND2_X1
X_20527_ _03750_ _03774_ _15049_ VDD VSS NAND2_X1
X_20528_ _03823_ _03777_ _15054_ VDD VSS NAND2_X1
X_20529_ _03756_ _03774_ _15092_ VDD VSS NAND2_X1
X_20530_ _03826_ _03776_ _15097_ VDD VSS NAND2_X1
X_20531_ _00185_ _03999_ _04010_ VDD VSS OR2_X1
X_20532_ _04010_ _03669_ _03800_ _04011_ VDD VSS OAI21_X1
X_20533_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[49\]
+ _03986_ _04011_ _03990_ _14071_ VDD VSS AOI22_X1
X_20534_ _03661_ _03694_ _14081_ VDD VSS NAND2_X1
X_20535_ _15575_ _14101_ VDD VSS INV_X1
X_20536_ _03661_ _03708_ _14111_ VDD VSS NAND2_X1
X_20537_ _15583_ _14119_ VDD VSS INV_X1
X_20538_ _00560_ _03999_ _04012_ VDD VSS OR2_X1
X_20539_ _04012_ _03669_ _03813_ _04013_ VDD VSS OAI21_X1
X_20540_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[54\]
+ _03986_ _04013_ _03990_ _14134_ VDD VSS AOI22_X2
X_20541_ _15597_ _14142_ VDD VSS INV_X1
X_20542_ net366 _03697_ _14147_ VDD VSS NAND2_X1
X_20543_ _15610_ _14169_ VDD VSS INV_X1
X_20544_ _15612_ _14174_ VDD VSS INV_X1
X_20545_ _03695_ _03697_ _14179_ VDD VSS NAND2_X1
X_20546_ _00562_ _03999_ _04014_ VDD VSS OR2_X1
X_20547_ _04014_ _03669_ _03817_ _04015_ VDD VSS OAI21_X1
X_20548_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[56\]
+ _03986_ _04015_ _03990_ _14192_ VDD VSS AOI22_X2
X_20549_ _15624_ _14200_ VDD VSS INV_X1
X_20550_ _03695_ _03703_ _14210_ VDD VSS NAND2_X1
X_20551_ _00563_ _03999_ _04016_ VDD VSS OR2_X1
X_20552_ _04016_ _03669_ _03819_ _04017_ VDD VSS OAI21_X1
X_20553_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[57\]
+ _03658_ _04017_ _11431_ _14223_ VDD VSS AOI22_X2
X_20554_ _03683_ _03729_ _14245_ VDD VSS NAND2_X1
X_20555_ _03702_ _03703_ _14250_ VDD VSS NAND2_X1
X_20556_ _03821_ _03669_ _04018_ VDD VSS NOR2_X1
X_20557_ _04018_ _03988_ _00564_ _04019_ VDD VSS AOI21_X1
X_20558_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[58\]
+ _03658_ _04019_ _11431_ _14263_ VDD VSS AOI22_X2
X_20559_ net366 _03729_ _14285_ VDD VSS NAND2_X1
X_20560_ _03994_ _03708_ _14290_ VDD VSS NAND2_X2
X_20561_ _00565_ _03999_ _04020_ VDD VSS OR2_X1
X_20562_ _04020_ _03669_ _03824_ _04021_ VDD VSS OAI21_X1
X_20563_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[59\]
+ _03658_ _04021_ _11431_ _14306_ VDD VSS AOI22_X2
X_20564_ _03702_ _03717_ _14328_ VDD VSS NAND2_X1
X_20565_ _03994_ _03715_ _14333_ VDD VSS NAND2_X1
X_20566_ _03702_ _03729_ _14379_ VDD VSS NAND2_X1
X_20567_ net343 _03735_ _14387_ VDD VSS NAND2_X1
X_20568_ _03829_ _03669_ _04022_ VDD VSS NOR2_X1
X_20569_ _00597_ _04023_ VDD VSS BUF_X2
X_20570_ _04022_ _03988_ _04023_ _04024_ VDD VSS AOI21_X1
X_20571_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[61\]
+ _03658_ _04024_ _11431_ _14408_ VDD VSS AOI22_X2
X_20572_ _03715_ _03717_ _14435_ VDD VSS NAND2_X1
X_20573_ _03998_ _03742_ _14443_ VDD VSS NAND2_X4
X_20574_ _03831_ _11433_ _04025_ VDD VSS NOR2_X1
X_20575_ _00628_ _04026_ VDD VSS BUF_X2
X_20576_ _04025_ _03988_ _04026_ _04027_ VDD VSS AOI21_X1
X_20577_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[62\]
+ _03658_ _04027_ _11431_ _14463_ VDD VSS AOI22_X2
X_20578_ net343 _03750_ _14501_ VDD VSS NAND2_X2
X_20579_ _03683_ _03774_ _14541_ VDD VSS NAND2_X1
X_20580_ _03995_ _03735_ _14555_ VDD VSS NAND2_X2
X_20581_ net339 _03750_ _14567_ VDD VSS NAND2_X1
X_20582_ _03695_ _03765_ _14611_ VDD VSS NAND2_X1
X_20583_ _03697_ _03763_ _14635_ VDD VSS NAND2_X1
X_20584_ _03995_ _03749_ _14684_ VDD VSS NAND2_X1
X_20585_ net353 _03755_ _14742_ VDD VSS NAND2_X1
X_20586_ _03715_ _03765_ _14787_ VDD VSS NAND2_X1
X_20587_ _03697_ _03812_ _14810_ VDD VSS NAND2_X1
X_20588_ _03715_ _03774_ _14844_ VDD VSS NAND2_X1
X_20589_ net353 _03770_ _14857_ VDD VSS NAND2_X1
X_20590_ net340 _03812_ _14867_ VDD VSS NAND2_X1
X_20591_ net353 _03776_ _14910_ VDD VSS NAND2_X1
X_20592_ _03742_ net300 _14951_ VDD VSS NAND2_X1
X_20593_ _03826_ _03755_ _14956_ VDD VSS NAND2_X1
X_20594_ _03742_ _03774_ _15004_ VDD VSS NAND2_X1
X_20595_ _14816_ _14817_ VDD VSS INV_X1
X_20596_ _03826_ _03770_ _15055_ VDD VSS NAND2_X1
X_20597_ net300 _03770_ _15137_ VDD VSS NAND2_X1
X_20598_ net300 _03776_ _15176_ VDD VSS NAND2_X1
X_20599_ net300 _03784_ _15213_ VDD VSS NAND2_X1
X_20600_ _03996_ _03784_ _15252_ VDD VSS NAND2_X1
X_20601_ _15023_ _15068_ VDD VSS INV_X2
X_20602_ _03996_ _03798_ _15291_ VDD VSS NAND2_X1
X_20603_ _00137_ _03974_ _15354_ VDD VSS OR2_X2
X_20604_ _14186_ _14187_ VDD VSS INV_X1
X_20605_ _14217_ _14218_ VDD VSS INV_X1
X_20606_ _14257_ _14258_ VDD VSS INV_X1
X_20607_ _14278_ _14280_ VDD VSS INV_X1
X_20608_ _14297_ _14298_ VDD VSS INV_X1
X_20609_ _14321_ _14323_ VDD VSS INV_X1
X_20610_ _14340_ _14341_ VDD VSS INV_X1
X_20611_ _14367_ _14368_ VDD VSS INV_X1
X_20612_ _14394_ _14395_ VDD VSS INV_X1
X_20613_ _14405_ _14419_ VDD VSS INV_X1
X_20614_ _14418_ _14420_ VDD VSS INV_X1
X_20615_ _14450_ _14451_ VDD VSS INV_X1
X_20616_ _14460_ _14474_ VDD VSS INV_X2
X_20617_ _14473_ _14475_ VDD VSS INV_X1
X_20618_ _14508_ _14509_ VDD VSS INV_X1
X_20619_ _14517_ _14531_ VDD VSS INV_X1
X_20620_ _14530_ _14532_ VDD VSS INV_X1
X_20621_ _14564_ _14580_ VDD VSS INV_X1
X_20622_ _14574_ _14575_ VDD VSS INV_X1
X_20623_ _14588_ _14590_ VDD VSS INV_X2
X_20624_ _14601_ _14603_ VDD VSS INV_X1
X_20625_ _14618_ _14619_ VDD VSS INV_X1
X_20626_ _14642_ _14643_ VDD VSS INV_X1
X_20627_ _14654_ _14656_ VDD VSS INV_X1
X_20628_ _14678_ _14679_ VDD VSS INV_X1
X_20629_ _14701_ _14702_ VDD VSS INV_X1
X_20630_ _14711_ _14712_ VDD VSS INV_X1
X_20631_ _14721_ _14722_ VDD VSS INV_X1
X_20632_ _14736_ _14737_ VDD VSS INV_X1
X_20633_ _14768_ _14769_ VDD VSS INV_X1
X_20634_ _14778_ _14779_ VDD VSS INV_X1
X_20635_ _14794_ _14795_ VDD VSS INV_X1
X_20636_ _14826_ _14827_ VDD VSS INV_X1
X_20637_ _14835_ _14836_ VDD VSS INV_X1
X_20638_ _14851_ _14852_ VDD VSS INV_X1
X_20639_ _14878_ _14879_ VDD VSS INV_X1
X_20640_ _14888_ _14889_ VDD VSS INV_X1
X_20641_ _14904_ _14905_ VDD VSS INV_X1
X_20642_ _14925_ _14926_ VDD VSS INV_X1
X_20643_ _14933_ _14934_ VDD VSS INV_X1
X_20644_ _14942_ _14943_ VDD VSS INV_X1
X_20645_ _14986_ _14988_ VDD VSS INV_X1
X_20646_ _14995_ _14996_ VDD VSS INV_X1
X_20647_ _15032_ _15034_ VDD VSS INV_X1
X_20648_ _15041_ _15042_ VDD VSS INV_X1
X_20649_ _15075_ _15077_ VDD VSS INV_X1
X_20650_ _15084_ _15085_ VDD VSS INV_X1
X_20651_ _15107_ _15108_ VDD VSS INV_X2
X_20652_ _15119_ _15120_ VDD VSS INV_X1
X_20653_ _15128_ _15129_ VDD VSS INV_X1
X_20654_ _15158_ _15159_ VDD VSS INV_X1
X_20655_ _15167_ _15168_ VDD VSS INV_X1
X_20656_ _15195_ _15196_ VDD VSS INV_X1
X_20657_ _15204_ _15205_ VDD VSS INV_X1
X_20658_ _15234_ _15235_ VDD VSS INV_X1
X_20659_ _15243_ _15244_ VDD VSS INV_X1
X_20660_ _15258_ _15262_ VDD VSS INV_X1
X_20661_ _15268_ _15269_ VDD VSS INV_X1
X_20662_ _15274_ _15275_ VDD VSS INV_X1
X_20663_ _15283_ _15284_ VDD VSS INV_X1
X_20664_ _15297_ _15298_ VDD VSS INV_X1
X_20665_ _15304_ _15305_ VDD VSS INV_X1
X_20666_ _15310_ _15311_ VDD VSS INV_X1
X_20667_ _15318_ _15319_ VDD VSS INV_X1
X_20668_ _15333_ _15334_ VDD VSS INV_X1
X_20669_ _15341_ _15824_ VDD VSS INV_X1
X_20670_ _15345_ _15346_ VDD VSS INV_X1
X_20671_ _14087_ _14114_ VDD VSS INV_X1
X_20672_ _14107_ _14137_ VDD VSS INV_X1
X_20673_ _14130_ _14164_ VDD VSS INV_X1
X_20674_ _14153_ _14195_ VDD VSS INV_X1
X_20675_ _14185_ _14226_ VDD VSS INV_X1
X_20676_ _14216_ _14266_ VDD VSS INV_X1
X_20677_ _14237_ _14279_ VDD VSS INV_X1
X_20678_ _14256_ _14309_ VDD VSS INV_X1
X_20679_ _14277_ _14322_ VDD VSS INV_X1
X_20680_ _14296_ _14357_ VDD VSS INV_X1
X_20681_ _14320_ _14369_ VDD VSS INV_X1
X_20682_ _14339_ _14411_ VDD VSS INV_X1
X_20683_ _14350_ _14421_ VDD VSS INV_X1
X_20684_ _14363_ _14425_ VDD VSS INV_X1
X_20685_ _14366_ _14424_ VDD VSS INV_X1
X_20686_ _14375_ _14438_ VDD VSS INV_X1
X_20687_ _14393_ _14466_ VDD VSS INV_X1
X_20688_ _14404_ _14476_ VDD VSS INV_X1
X_20689_ _14417_ _14479_ VDD VSS INV_X1
X_20690_ _14449_ _14523_ VDD VSS INV_X1
X_20691_ _14459_ _14533_ VDD VSS INV_X1
X_20692_ _14472_ _14536_ VDD VSS INV_X1
X_20693_ _14485_ _14558_ VDD VSS INV_X1
X_20694_ _14497_ _14581_ VDD VSS INV_X1
X_20695_ _14507_ _14589_ VDD VSS INV_X1
X_20696_ _14516_ _14602_ VDD VSS INV_X1
X_20697_ _14529_ _14606_ VDD VSS INV_X1
X_20698_ _14547_ _14627_ VDD VSS INV_X1
X_20699_ _14551_ _14630_ VDD VSS INV_X1
X_20700_ _14563_ _14648_ VDD VSS INV_X1
X_20701_ _14573_ _14655_ VDD VSS INV_X1
X_20702_ _14587_ _14657_ VDD VSS INV_X1
X_20703_ _14596_ _14661_ VDD VSS INV_X1
X_20704_ _14600_ _14666_ VDD VSS INV_X1
X_20705_ _14617_ _14687_ VDD VSS INV_X1
X_20706_ _14641_ _14714_ VDD VSS INV_X1
X_20707_ _14653_ _14713_ VDD VSS INV_X1
X_20708_ _14677_ _14745_ VDD VSS INV_X1
X_20709_ _14700_ _14770_ VDD VSS INV_X1
X_20710_ _14710_ _14771_ VDD VSS INV_X1
X_20711_ _14720_ _14782_ VDD VSS INV_X1
X_20712_ _14735_ _14803_ VDD VSS INV_X1
X_20713_ _14767_ _14828_ VDD VSS INV_X1
X_20714_ _14777_ _14839_ VDD VSS INV_X1
X_20715_ _14793_ _14860_ VDD VSS INV_X1
X_20716_ _14825_ _14881_ VDD VSS INV_X1
X_20717_ _14834_ _14892_ VDD VSS INV_X1
X_20718_ _14850_ _14913_ VDD VSS INV_X1
X_20719_ _14877_ _14935_ VDD VSS INV_X1
X_20720_ _14887_ _14946_ VDD VSS INV_X1
X_20721_ _14903_ _14966_ VDD VSS INV_X1
X_20722_ _14924_ _14979_ VDD VSS INV_X1
X_20723_ _14932_ _14987_ VDD VSS INV_X1
X_20724_ _14941_ _14999_ VDD VSS INV_X1
X_20725_ _14985_ _15033_ VDD VSS INV_X1
X_20726_ _14994_ _15045_ VDD VSS INV_X1
X_20727_ _15031_ _15076_ VDD VSS INV_X1
X_20728_ _15040_ _15088_ VDD VSS INV_X1
X_20729_ _15074_ _15121_ VDD VSS INV_X1
X_20730_ _15083_ _15132_ VDD VSS INV_X1
X_20731_ _15106_ _15147_ VDD VSS INV_X2
X_20732_ _15118_ _15160_ VDD VSS INV_X1
X_20733_ _15127_ _15171_ VDD VSS INV_X1
X_20734_ _15157_ _15197_ VDD VSS INV_X1
X_20735_ _15166_ _15208_ VDD VSS INV_X1
X_20736_ _15194_ _15236_ VDD VSS INV_X1
X_20737_ _15203_ _15247_ VDD VSS INV_X1
X_20738_ _15219_ _15259_ VDD VSS INV_X1
X_20739_ _15233_ _15276_ VDD VSS INV_X1
X_20740_ _15242_ _15287_ VDD VSS INV_X1
X_20741_ _15257_ _15299_ VDD VSS INV_X1
X_20742_ _15273_ _15312_ VDD VSS INV_X1
X_20743_ _15282_ _15322_ VDD VSS INV_X1
X_20744_ _15317_ _15349_ VDD VSS INV_X1
X_20745_ _03449_ _04028_ VDD VSS CLKBUF_X3
X_20746_ _04028_ _04029_ VDD VSS CLKBUF_X3
X_20747_ _12099_ _04030_ VDD VSS BUF_X8
X_20748_ _15834_ _04030_ _04031_ VDD VSS XNOR2_X1
X_20749_ _04029_ _04031_ _04032_ VDD VSS NOR2_X1
X_20750_ _03405_ _04033_ VDD VSS BUF_X4
X_20751_ _04033_ _04034_ VDD VSS CLKBUF_X3
X_20752_ _03406_ _04035_ VDD VSS CLKBUF_X3
X_20753_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[1\]
+ _04034_ _04035_ _03675_ _04036_ VDD VSS OAI22_X1
X_20754_ _03407_ _04037_ VDD VSS BUF_X4
X_20755_ _03402_ _04038_ VDD VSS CLKBUF_X3
X_20756_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[33\]
+ _04037_ _03681_ _04038_ _04039_ VDD VSS OAI22_X1
X_20757_ _03406_ _04040_ VDD VSS CLKBUF_X3
X_20758_ _04040_ _04041_ VDD VSS CLKBUF_X3
X_20759_ _04036_ _04039_ _04041_ _04042_ VDD VSS AOI21_X1
X_20760_ _04028_ _04043_ VDD VSS BUF_X4
X_20761_ _04032_ _04042_ _04043_ _15369_ VDD VSS AOI21_X1
X_20762_ _03407_ _04044_ VDD VSS BUF_X4
X_20763_ _10777_ _10812_ _04045_ VDD VSS OR2_X2
X_20764_ _03406_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[32\]
+ _04044_ _04038_ _04045_ _04046_ VDD VSS OAI221_X1
X_20765_ _04046_ _04040_ _03660_ _04047_ VDD VSS OAI21_X1
X_20766_ _04034_ _04048_ VDD VSS BUF_X2
X_20767_ _04047_ _04048_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[0\]
+ _04049_ VDD VSS OAI21_X1
X_20768_ _04030_ _04050_ VDD VSS BUF_X16
X_20769_ _04050_ _15835_ _04051_ VDD VSS XNOR2_X2
X_20770_ _11409_ _04052_ VDD VSS BUF_X2
X_20771_ _04049_ _04051_ _04052_ _14065_ VDD VSS MUX2_X1
X_20772_ _15857_ _04050_ _04053_ VDD VSS XNOR2_X1
X_20773_ _04033_ _04054_ VDD VSS BUF_X4
X_20774_ _03402_ _04055_ VDD VSS BUF_X4
X_20775_ _04044_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[34\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[2\] _04054_
+ net296 _04055_ _04056_ VDD VSS OAI222_X2
X_20776_ _10972_ _04056_ _04040_ _04057_ VDD VSS MUX2_X1
X_20777_ _04028_ _04058_ VDD VSS CLKBUF_X3
X_20778_ _04053_ _04057_ _04058_ _15375_ VDD VSS MUX2_X1
X_20779_ _15860_ _04030_ _04059_ VDD VSS XNOR2_X1
X_20780_ _04029_ _04059_ _04060_ VDD VSS NOR2_X1
X_20781_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[3\]
+ _04034_ _04035_ _11019_ _04061_ VDD VSS OAI22_X1
X_20782_ _04037_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[35\]
+ net317 _04038_ _04062_ VDD VSS OAI22_X1
X_20783_ _04061_ _04062_ _04041_ _04063_ VDD VSS AOI21_X1
X_20784_ _04060_ _04063_ _04043_ _15379_ VDD VSS AOI21_X1
X_20785_ _15873_ _04050_ _04064_ VDD VSS XNOR2_X1
X_20786_ _04044_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[36\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[4\] _04054_
+ _11591_ _04055_ _04065_ VDD VSS OAI222_X2
X_20787_ _11057_ _04065_ _04040_ _04066_ VDD VSS MUX2_X1
X_20788_ _04064_ _04066_ _04058_ _15383_ VDD VSS MUX2_X1
X_20789_ _15880_ _04030_ _04067_ VDD VSS XNOR2_X1
X_20790_ _04044_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[37\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[5\] _04033_
+ _11629_ _04055_ _04068_ VDD VSS OAI222_X2
X_20791_ _11115_ _04068_ _04040_ _04069_ VDD VSS MUX2_X1
X_20792_ _04067_ _04069_ _04058_ _15387_ VDD VSS MUX2_X1
X_20793_ _15888_ net287 _04070_ VDD VSS XNOR2_X1
X_20794_ _03401_ _03402_ _04033_ _04071_ VDD VSS AND3_X1
X_20795_ _04044_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[38\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[6\] _04033_
+ _11672_ _03402_ _04072_ VDD VSS OAI222_X2
X_20796_ _04071_ _04072_ _04073_ VDD VSS NOR2_X1
X_20797_ _04073_ _04071_ net345 _04074_ VDD VSS AOI21_X1
X_20798_ _04070_ _04074_ _04058_ _15391_ VDD VSS MUX2_X1
X_20799_ _00561_ _04052_ _04048_ _04075_ VDD VSS OR3_X1
X_20800_ _04075_ _15897_ _04043_ _15395_ VDD VSS OAI21_X1
X_20801_ _03406_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[40\]
+ _03407_ _04038_ _03732_ _04076_ VDD VSS OAI221_X1
X_20802_ _04076_ _04040_ _11241_ _04077_ VDD VSS OAI21_X1
X_20803_ _04077_ _04048_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[8\]
+ _04078_ VDD VSS OAI21_X1
X_20804_ _15904_ net322 _04079_ VDD VSS XNOR2_X1
X_20805_ _04078_ _04079_ _04052_ _15399_ VDD VSS MUX2_X1
X_20806_ _15908_ _11863_ _04080_ VDD VSS XNOR2_X1
X_20807_ _04044_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[41\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[9\] _04033_
+ _11824_ _04055_ _04081_ VDD VSS OAI222_X2
X_20808_ _11279_ _04081_ _03406_ _04082_ VDD VSS MUX2_X1
X_20809_ _04080_ _04082_ _04058_ _15403_ VDD VSS MUX2_X1
X_20810_ _03406_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[42\]
+ _03407_ _04038_ _11898_ _04083_ VDD VSS OAI221_X1
X_20811_ _04083_ _04040_ _11313_ _04084_ VDD VSS OAI21_X1
X_20812_ _04084_ _04048_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[10\]
+ _04085_ VDD VSS OAI21_X1
X_20813_ _15920_ net322 _04086_ VDD VSS XNOR2_X1
X_20814_ _04085_ _04086_ _04052_ _15407_ VDD VSS MUX2_X1
X_20815_ _00565_ _04052_ _04048_ _04087_ VDD VSS OR3_X1
X_20816_ _04087_ _04043_ _15928_ _15411_ VDD VSS OAI21_X1
X_20817_ _00566_ _04052_ _04048_ _04088_ VDD VSS OR3_X1
X_20818_ _04088_ _04043_ _15936_ _15415_ VDD VSS OAI21_X1
X_20819_ _04023_ _04052_ _04048_ _04089_ VDD VSS OR3_X1
X_20820_ _04028_ _04090_ VDD VSS CLKBUF_X3
X_20821_ _04089_ _15944_ _04090_ _15419_ VDD VSS OAI21_X1
X_20822_ net287 _15953_ _04091_ VDD VSS XNOR2_X1
X_20823_ _04029_ _04091_ _04092_ VDD VSS NOR2_X1
X_20824_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[14\]
+ _04034_ _04035_ _12144_ _04093_ VDD VSS OAI22_X1
X_20825_ _04037_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[46\]
+ _12177_ _04038_ _04094_ VDD VSS OAI22_X1
X_20826_ _04093_ _04094_ _04041_ _04095_ VDD VSS AOI21_X1
X_20827_ _04092_ _04095_ _04043_ _15423_ VDD VSS AOI21_X2
X_20828_ net287 _15956_ _04096_ VDD VSS XNOR2_X1
X_20829_ _04029_ _04096_ _04097_ VDD VSS NOR2_X1
X_20830_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[15\]
+ _04034_ _04035_ _12221_ _04098_ VDD VSS OAI22_X1
X_20831_ _04037_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[47\]
+ _12254_ _04038_ _04099_ VDD VSS OAI22_X1
X_20832_ _04098_ _04099_ _04041_ _04100_ VDD VSS AOI21_X1
X_20833_ _04097_ _04100_ _04043_ _15427_ VDD VSS AOI21_X2
X_20834_ net287 _15969_ _04101_ VDD VSS XNOR2_X1
X_20835_ _04058_ _04101_ _04102_ VDD VSS NOR2_X1
X_20836_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[16\]
+ _04034_ _04035_ _12316_ _04103_ VDD VSS OAI22_X2
X_20837_ _04037_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[48\]
+ _12350_ _04038_ _04104_ VDD VSS OAI22_X1
X_20838_ _04103_ _04104_ _04041_ _04105_ VDD VSS AOI21_X2
X_20839_ _04102_ _04105_ _04043_ _15431_ VDD VSS AOI21_X2
X_20840_ net322 _15977_ _04106_ VDD VSS XNOR2_X1
X_20841_ _04033_ _04107_ VDD VSS BUF_X4
X_20842_ _04037_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[49\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[17\] _04107_
+ _12425_ _04038_ _04108_ VDD VSS OAI222_X2
X_20843_ _04035_ _04108_ _04109_ VDD VSS NAND2_X1
X_20844_ _04109_ _04041_ _12392_ _04110_ VDD VSS OAI21_X1
X_20845_ _04106_ _04110_ _04058_ _15435_ VDD VSS MUX2_X1
X_20846_ net322 _15980_ _04111_ VDD VSS XNOR2_X1
X_20847_ _03402_ _04112_ VDD VSS BUF_X4
X_20848_ _04037_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[50\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[18\] _04107_
+ _12514_ _04112_ _04113_ VDD VSS OAI222_X2
X_20849_ _04035_ _04113_ _04114_ VDD VSS NAND2_X1
X_20850_ _04114_ _04041_ net367 _04115_ VDD VSS OAI21_X1
X_20851_ _04111_ _04115_ _04058_ _15439_ VDD VSS MUX2_X1
X_20852_ _00783_ _04052_ _04048_ _04116_ VDD VSS OR3_X1
X_20853_ _04116_ _15992_ _04090_ _15443_ VDD VSS OAI21_X1
X_20854_ _11863_ _04117_ VDD VSS CLKBUF_X3
X_20855_ _04117_ _16000_ _04118_ VDD VSS XNOR2_X1
X_20856_ _04037_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[52\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[20\] _04107_
+ net358 _04112_ _04119_ VDD VSS OAI222_X2
X_20857_ _04035_ _04119_ _04120_ VDD VSS NAND2_X1
X_20858_ _04120_ _04041_ _12651_ _04121_ VDD VSS OAI21_X1
X_20859_ _04118_ _04121_ _04058_ _15447_ VDD VSS MUX2_X1
X_20860_ _00845_ _04052_ _04048_ _04122_ VDD VSS OR3_X1
X_20861_ _04122_ _16005_ _04090_ _15451_ VDD VSS OAI21_X1
X_20862_ _04117_ _16016_ _04123_ VDD VSS XNOR2_X1
X_20863_ _04037_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[54\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[22\] _04107_
+ _03713_ _04112_ _04124_ VDD VSS OAI222_X2
X_20864_ _04035_ _04124_ _04125_ VDD VSS NAND2_X1
X_20865_ _04125_ _04041_ net407 _04126_ VDD VSS OAI21_X1
X_20866_ _04123_ _04126_ _04058_ _15455_ VDD VSS MUX2_X1
X_20867_ _04117_ _16021_ _04127_ VDD VSS XNOR2_X1
X_20868_ _03406_ _04128_ VDD VSS BUF_X2
X_20869_ _04037_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[55\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[23\] _04107_
+ _03724_ _04112_ _04129_ VDD VSS OAI222_X2
X_20870_ _04128_ _04129_ _04130_ VDD VSS NAND2_X1
X_20871_ _04130_ _04041_ _12896_ _04131_ VDD VSS OAI21_X1
X_20872_ _04028_ _04132_ VDD VSS CLKBUF_X3
X_20873_ _04127_ _04131_ _04132_ _15459_ VDD VSS MUX2_X1
X_20874_ _03817_ _04052_ _04048_ _04133_ VDD VSS OR3_X1
X_20875_ _04133_ _16029_ _04090_ _15463_ VDD VSS OAI21_X1
X_20876_ _11409_ _04134_ VDD VSS CLKBUF_X2
X_20877_ _04107_ _04135_ VDD VSS CLKBUF_X2
X_20878_ _03819_ _04134_ _04135_ _04136_ VDD VSS OR3_X1
X_20879_ _04136_ _16040_ _04090_ _15467_ VDD VSS OAI21_X1
X_20880_ _04117_ _16048_ _04137_ VDD VSS XNOR2_X1
X_20881_ _03407_ _04138_ VDD VSS BUF_X4
X_20882_ _04138_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[58\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[26\] _04107_
+ net356 _04112_ _04139_ VDD VSS OAI222_X2
X_20883_ _04128_ _04139_ _04140_ VDD VSS NAND2_X1
X_20884_ _04040_ _04141_ VDD VSS BUF_X2
X_20885_ _04140_ _04141_ _13155_ _04142_ VDD VSS OAI21_X1
X_20886_ _04137_ _04142_ _04132_ _15471_ VDD VSS MUX2_X1
X_20887_ _04117_ _16053_ _04143_ VDD VSS XNOR2_X1
X_20888_ _04138_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[59\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[27\] _04107_
+ net350 _04112_ _04144_ VDD VSS OAI222_X2
X_20889_ _04128_ _04144_ _04145_ VDD VSS NAND2_X1
X_20890_ _04145_ _04141_ _13224_ _04146_ VDD VSS OAI21_X1
X_20891_ _04143_ _04146_ _04132_ _15475_ VDD VSS MUX2_X1
X_20892_ _03827_ _04134_ _04135_ _04147_ VDD VSS OR3_X1
X_20893_ _04147_ _16064_ _04090_ _15479_ VDD VSS OAI21_X1
X_20894_ _04117_ _16069_ _04148_ VDD VSS XNOR2_X1
X_20895_ _04138_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[61\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[29\] _04107_
+ _03769_ _04112_ _04149_ VDD VSS OAI222_X2
X_20896_ _04128_ _04149_ _04150_ VDD VSS NAND2_X1
X_20897_ _04150_ _04141_ _03166_ _04151_ VDD VSS OAI21_X1
X_20898_ _04148_ _04151_ _04132_ _15483_ VDD VSS MUX2_X1
X_20899_ _01124_ _04134_ _04135_ _04152_ VDD VSS OR3_X1
X_20900_ _04152_ _16080_ _04090_ _15487_ VDD VSS OAI21_X1
X_20901_ _15495_ _15491_ VDD VSS INV_X1
X_20902_ _10920_ _15912_ _15499_ VDD VSS NOR2_X1
X_20903_ _15904_ _15900_ VDD VSS INV_X1
X_20904_ _10922_ _15900_ _15503_ VDD VSS NAND2_X1
X_20905_ _14078_ _15557_ VDD VSS INV_X1
X_20906_ _14116_ _15592_ VDD VSS INV_X1
X_20907_ _14121_ _14122_ VDD VSS INV_X1
X_20908_ _14139_ _15608_ VDD VSS INV_X1
X_20909_ _14115_ _15609_ VDD VSS INV_X1
X_20910_ _14144_ _15616_ VDD VSS INV_X1
X_20911_ _14166_ _15622_ VDD VSS INV_X1
X_20912_ _14171_ _15626_ VDD VSS INV_X1
X_20913_ _14176_ _15628_ VDD VSS INV_X1
X_20914_ _14189_ _15632_ VDD VSS INV_X1
X_20915_ _14197_ _15637_ VDD VSS INV_X1
X_20916_ _14202_ _15641_ VDD VSS INV_X1
X_20917_ _14220_ _15649_ VDD VSS INV_X2
X_20918_ _14228_ _15653_ VDD VSS INV_X2
X_20919_ _14196_ _15654_ VDD VSS INV_X1
X_20920_ _14233_ _14235_ VDD VSS INV_X1
X_20921_ _14247_ _15659_ VDD VSS INV_X1
X_20922_ _14260_ _15662_ VDD VSS INV_X2
X_20923_ _14268_ _15666_ VDD VSS INV_X2
X_20924_ _14227_ _15667_ VDD VSS INV_X1
X_20925_ _14273_ _14275_ VDD VSS INV_X1
X_20926_ _14287_ _15673_ VDD VSS INV_X1
X_20927_ _14303_ _15679_ VDD VSS INV_X1
X_20928_ _14311_ _15680_ VDD VSS INV_X2
X_20929_ _14267_ _15681_ VDD VSS INV_X1
X_20930_ _14316_ _14318_ VDD VSS INV_X1
X_20931_ _14281_ _15683_ VDD VSS INV_X1
X_20932_ _14330_ _15691_ VDD VSS INV_X1
X_20933_ _14346_ _14349_ VDD VSS INV_X1
X_20934_ _14359_ _15695_ VDD VSS INV_X1
X_20935_ _14371_ _15697_ VDD VSS INV_X2
X_20936_ _14400_ _14403_ VDD VSS INV_X1
X_20937_ _14413_ _15702_ VDD VSS INV_X1
X_20938_ _14427_ _15704_ VDD VSS INV_X1
X_20939_ _14440_ _15711_ VDD VSS INV_X1
X_20940_ _14468_ _15712_ VDD VSS INV_X1
X_20941_ _14481_ _15714_ VDD VSS INV_X2
X_20942_ _14493_ _14496_ VDD VSS INV_X1
X_20943_ _14525_ _15721_ VDD VSS INV_X1
X_20944_ _14538_ _15723_ VDD VSS INV_X2
X_20945_ _14543_ _14549_ VDD VSS INV_X1
X_20946_ _14560_ _14561_ VDD VSS INV_X1
X_20947_ _14592_ _14594_ VDD VSS INV_X2
X_20948_ _14512_ _14598_ VDD VSS INV_X1
X_20949_ _14608_ _15727_ VDD VSS INV_X2
X_20950_ _14659_ _15733_ VDD VSS INV_X1
X_20951_ _14668_ _15736_ VDD VSS INV_X1
X_20952_ _14716_ _15740_ VDD VSS INV_X1
X_20953_ _14646_ _14717_ VDD VSS INV_X1
X_20954_ _14726_ _15742_ VDD VSS INV_X1
X_20955_ _14773_ _15746_ VDD VSS INV_X1
X_20956_ _14784_ _15748_ VDD VSS INV_X1
X_20957_ _14830_ _15752_ VDD VSS INV_X1
X_20958_ _14772_ _15753_ VDD VSS INV_X1
X_20959_ _14762_ _14831_ VDD VSS INV_X1
X_20960_ _14783_ _15754_ VDD VSS INV_X1
X_20961_ _14883_ _15758_ VDD VSS INV_X1
X_20962_ _14894_ _15760_ VDD VSS INV_X1
X_20963_ _14868_ _14922_ VDD VSS INV_X1
X_20964_ _14937_ _15764_ VDD VSS INV_X1
X_20965_ _14882_ _15765_ VDD VSS INV_X1
X_20966_ _14872_ _14938_ VDD VSS INV_X1
X_20967_ _14893_ _15766_ VDD VSS INV_X1
X_20968_ _14990_ _15770_ VDD VSS INV_X1
X_20969_ _14927_ _14991_ VDD VSS INV_X1
X_20970_ _15001_ _15772_ VDD VSS INV_X1
X_20971_ _15036_ _15776_ VDD VSS INV_X1
X_20972_ _14989_ _15777_ VDD VSS INV_X1
X_20973_ _15000_ _15778_ VDD VSS INV_X1
X_20974_ _15035_ _15782_ VDD VSS INV_X1
X_20975_ _15026_ _15081_ VDD VSS INV_X1
X_20976_ _15090_ _15784_ VDD VSS INV_X1
X_20977_ _15123_ _15788_ VDD VSS INV_X1
X_20978_ _15069_ _15125_ VDD VSS INV_X1
X_20979_ _15134_ _15790_ VDD VSS INV_X1
X_20980_ _15162_ _15794_ VDD VSS INV_X1
X_20981_ _15122_ _15795_ VDD VSS INV_X1
X_20982_ _15113_ _15163_ VDD VSS INV_X1
X_20983_ _15133_ _15796_ VDD VSS INV_X1
X_20984_ _15199_ _15800_ VDD VSS INV_X1
X_20985_ _15161_ _15801_ VDD VSS INV_X1
X_20986_ _15152_ _15200_ VDD VSS INV_X1
X_20987_ _15172_ _15802_ VDD VSS INV_X1
X_20988_ _15238_ _15806_ VDD VSS INV_X1
X_20989_ _15249_ _15808_ VDD VSS INV_X1
X_20990_ _15254_ _15255_ VDD VSS INV_X1
X_20991_ _15261_ _15265_ VDD VSS INV_X1
X_20992_ _15278_ _15812_ VDD VSS INV_X1
X_20993_ _15228_ _15279_ VDD VSS INV_X1
X_20994_ _15289_ _15814_ VDD VSS INV_X1
X_20995_ _15293_ _15294_ VDD VSS INV_X1
X_20996_ _15324_ _15820_ VDD VSS INV_X1
X_20997_ _15351_ _15827_ VDD VSS INV_X1
X_20998_ _15928_ _15924_ VDD VSS INV_X1
X_20999_ _15944_ _15940_ VDD VSS INV_X1
X_21000_ _15992_ _15988_ VDD VSS INV_X2
X_21001_ _16000_ _15996_ VDD VSS INV_X1
X_21002_ _16008_ _16004_ VDD VSS INV_X1
X_21003_ _16016_ _16012_ VDD VSS INV_X1
X_21004_ _16032_ _16028_ VDD VSS INV_X1
X_21005_ _16040_ _16036_ VDD VSS INV_X1
X_21006_ _16048_ _16044_ VDD VSS INV_X1
X_21007_ _16080_ _16076_ VDD VSS INV_X1
X_21008_ _03620_ _04153_ VDD VSS BUF_X4
X_21009_ _04153_ _16084_ VDD VSS BUF_X4
X_21010_ _03957_ _04154_ VDD VSS BUF_X4
X_21011_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ _04155_ VDD VSS BUF_X2
X_21012_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[1\]
+ _04156_ VDD VSS BUF_X4
X_21013_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[0\]
+ _04157_ VDD VSS BUF_X4
X_21014_ _04157_ _04158_ VDD VSS BUF_X4
X_21015_ _04154_ _04155_ _04156_ _04158_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]
+ _04159_ VDD VSS OAI221_X2
X_21016_ _11420_ _11422_ _04160_ VDD VSS NOR2_X2
X_21017_ _11422_ _11424_ _03877_ _04160_ _04161_ VDD VSS OAI22_X2
X_21018_ _00134_ _04159_ _04161_ _04162_ VDD VSS NAND3_X2
X_21019_ _04162_ _04163_ VDD VSS INV_X1
X_21020_ _00133_ _04163_ _04164_ VDD VSS NAND2_X4
X_21021_ _04164_ _16107_ VDD VSS INV_X2
X_21022_ _00185_ _04134_ _04135_ _04165_ VDD VSS OR3_X1
X_21023_ _04165_ _04043_ _15849_ _15370_ VDD VSS OAI21_X1
X_21024_ _00217_ _04134_ _04135_ _04166_ VDD VSS OR3_X1
X_21025_ _04166_ _04043_ _15838_ _14066_ VDD VSS OAI21_X2
X_21026_ _00556_ _04134_ _04135_ _04167_ VDD VSS OR3_X1
X_21027_ _04167_ _15856_ _04090_ _15376_ VDD VSS OAI21_X1
X_21028_ _00557_ _04134_ _04135_ _04168_ VDD VSS OR3_X1
X_21029_ _04168_ _15861_ _04090_ _15380_ VDD VSS OAI21_X1
X_21030_ _00558_ _04134_ _04135_ _04169_ VDD VSS OR3_X1
X_21031_ _04169_ _15872_ _04090_ _15384_ VDD VSS OAI21_X1
X_21032_ _00559_ _04134_ _04135_ _04170_ VDD VSS OR3_X1
X_21033_ _04028_ _04171_ VDD VSS BUF_X2
X_21034_ _04170_ _15881_ _04171_ _15388_ VDD VSS OAI21_X1
X_21035_ _00560_ _04134_ _04135_ _04172_ VDD VSS OR3_X1
X_21036_ _04172_ _15889_ _04171_ _15392_ VDD VSS OAI21_X1
X_21037_ _15896_ _04030_ _04173_ VDD VSS XNOR2_X1
X_21038_ _04044_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[39\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[7\] _04033_
+ _03723_ _03402_ _04174_ VDD VSS OAI222_X2
X_21039_ _04071_ _04174_ _04175_ VDD VSS NOR2_X1
X_21040_ _04175_ _04071_ _11202_ _04176_ VDD VSS AOI21_X1
X_21041_ _04173_ _04176_ _04132_ _15396_ VDD VSS MUX2_X1
X_21042_ _11409_ _04177_ VDD VSS CLKBUF_X2
X_21043_ _04107_ _04178_ VDD VSS CLKBUF_X2
X_21044_ _00562_ _04177_ _04178_ _04179_ VDD VSS OR3_X1
X_21045_ _04179_ _15905_ _04171_ _15400_ VDD VSS OAI21_X1
X_21046_ _00563_ _04177_ _04178_ _04180_ VDD VSS OR3_X1
X_21047_ _04180_ _15913_ _04171_ _15404_ VDD VSS OAI21_X1
X_21048_ _00564_ _04177_ _04178_ _04181_ VDD VSS OR3_X1
X_21049_ _04181_ _15921_ _04171_ _15408_ VDD VSS OAI21_X1
X_21050_ _15929_ net287 _04182_ VDD VSS XNOR2_X1
X_21051_ _04044_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[43\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[11\] _04033_
+ _11398_ _04055_ _04183_ VDD VSS OAI222_X2
X_21052_ _03743_ _04183_ _03406_ _04184_ VDD VSS MUX2_X1
X_21053_ _04182_ _04184_ _04132_ _15412_ VDD VSS MUX2_X1
X_21054_ _04050_ _15937_ _04185_ VDD VSS XNOR2_X1
X_21055_ _04138_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[44\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[12\] _04054_
+ _10868_ _04112_ _04186_ VDD VSS OAI222_X2
X_21056_ _04128_ _04186_ _04187_ VDD VSS NAND2_X1
X_21057_ _04187_ _04141_ net329 _04188_ VDD VSS OAI21_X1
X_21058_ _04185_ _04188_ _04132_ _15416_ VDD VSS MUX2_X1
X_21059_ _04050_ _15945_ _04189_ VDD VSS XNOR2_X1
X_21060_ _04138_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[45\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[13\] _04054_
+ _12075_ _04112_ _04190_ VDD VSS OAI222_X2
X_21061_ _04128_ _04190_ _04191_ VDD VSS NAND2_X1
X_21062_ _04191_ _04141_ net341 _04192_ VDD VSS OAI21_X1
X_21063_ _04189_ _04192_ _04132_ _15420_ VDD VSS MUX2_X1
X_21064_ _04026_ _04177_ _04178_ _04193_ VDD VSS OR3_X1
X_21065_ _04193_ _15952_ _04171_ _15424_ VDD VSS OAI21_X1
X_21066_ _00659_ _04177_ _04178_ _04194_ VDD VSS OR3_X1
X_21067_ _04194_ _15957_ _04171_ _15428_ VDD VSS OAI21_X1
X_21068_ _03670_ _04177_ _04178_ _04195_ VDD VSS OR3_X1
X_21069_ _04195_ _15968_ _04171_ _15432_ VDD VSS OAI21_X1
X_21070_ _03800_ _04177_ _04178_ _04196_ VDD VSS OR3_X1
X_21071_ _04196_ _15976_ _04171_ _15436_ VDD VSS OAI21_X1
X_21072_ _03804_ _04177_ _04178_ _04197_ VDD VSS OR3_X1
X_21073_ _04197_ _15981_ _04171_ _15440_ VDD VSS OAI21_X1
X_21074_ net322 _15993_ _04198_ VDD VSS XNOR2_X1
X_21075_ _04138_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[51\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[19\] _04054_
+ _12589_ _04112_ _04199_ VDD VSS OAI222_X2
X_21076_ _04128_ _04199_ _04200_ VDD VSS NAND2_X1
X_21077_ _04200_ _04141_ net368 _04201_ VDD VSS OAI21_X1
X_21078_ _04198_ _04201_ _04132_ _15444_ VDD VSS MUX2_X1
X_21079_ _03808_ _04177_ _04178_ _04202_ VDD VSS OR3_X1
X_21080_ _04202_ _15997_ _04029_ _15448_ VDD VSS OAI21_X1
X_21081_ _04117_ _16008_ _04203_ VDD VSS XNOR2_X1
X_21082_ _04138_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[53\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[21\] _04054_
+ net375 _04055_ _04204_ VDD VSS OAI222_X2
X_21083_ _04128_ _04204_ _04205_ VDD VSS NAND2_X1
X_21084_ _04205_ _04141_ _12725_ _04206_ VDD VSS OAI21_X1
X_21085_ _04203_ _04206_ _04132_ _15452_ VDD VSS MUX2_X1
X_21086_ _03813_ _04177_ _04178_ _04207_ VDD VSS OR3_X1
X_21087_ _04207_ _16013_ _04029_ _15456_ VDD VSS OAI21_X1
X_21088_ _03815_ _11409_ _04034_ _04208_ VDD VSS OR3_X1
X_21089_ _04208_ _16024_ _04029_ _15460_ VDD VSS OAI21_X1
X_21090_ _04117_ _16032_ _04209_ VDD VSS XNOR2_X1
X_21091_ _04138_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[56\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[24\] _04054_
+ _03733_ _04055_ _04210_ VDD VSS OAI222_X2
X_21092_ _04128_ _04210_ _04211_ VDD VSS NAND2_X1
X_21093_ _04211_ _04141_ net372 _04212_ VDD VSS OAI21_X1
X_21094_ _04209_ _04212_ _04028_ _15464_ VDD VSS MUX2_X1
X_21095_ _04117_ _16037_ _04213_ VDD VSS XNOR2_X1
X_21096_ _04138_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[57\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[25\] _04054_
+ _13097_ _04055_ _04214_ VDD VSS OAI222_X2
X_21097_ _04128_ _04214_ _04215_ VDD VSS NAND2_X1
X_21098_ _04215_ _04141_ _13061_ _04216_ VDD VSS OAI21_X1
X_21099_ _04213_ _04216_ _04028_ _15468_ VDD VSS MUX2_X1
X_21100_ _01000_ _11409_ _04034_ _04217_ VDD VSS OR3_X1
X_21101_ _04217_ _16045_ _04029_ _15472_ VDD VSS OAI21_X1
X_21102_ _03824_ _11409_ _04034_ _04218_ VDD VSS OR3_X1
X_21103_ _04218_ _16056_ _04029_ _15476_ VDD VSS OAI21_X2
X_21104_ _04117_ _16061_ _04219_ VDD VSS XNOR2_X1
X_21105_ _04138_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[60\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[28\] _04054_
+ _03762_ _04055_ _04220_ VDD VSS OAI222_X2
X_21106_ _04040_ _04220_ _04221_ VDD VSS NAND2_X1
X_21107_ _04221_ _04141_ _13314_ _04222_ VDD VSS OAI21_X1
X_21108_ _04219_ _04222_ _04028_ _15480_ VDD VSS MUX2_X1
X_21109_ _01093_ _11409_ _04034_ _04223_ VDD VSS OR3_X1
X_21110_ _04223_ _16072_ _04029_ _15484_ VDD VSS OAI21_X2
X_21111_ _11863_ _16077_ _04224_ VDD VSS XNOR2_X1
X_21112_ _04044_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[62\]
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[30\] _04054_
+ _03311_ _04055_ _04225_ VDD VSS OAI222_X2
X_21113_ _04040_ _04225_ _04226_ VDD VSS NAND2_X1
X_21114_ _04226_ _04035_ _03275_ _04227_ VDD VSS OAI21_X1
X_21115_ _04224_ _04227_ _04028_ _15488_ VDD VSS MUX2_X1
X_21116_ _15526_ _15523_ VDD VSS INV_X1
X_21117_ _14073_ _15554_ VDD VSS INV_X1
X_21118_ _14072_ _15558_ VDD VSS INV_X1
X_21119_ _14083_ _15570_ VDD VSS INV_X1
X_21120_ _14077_ _15569_ VDD VSS INV_X1
X_21121_ _14093_ _14095_ VDD VSS INV_X1
X_21122_ _14082_ _14096_ VDD VSS INV_X1
X_21123_ _14103_ _15587_ VDD VSS INV_X1
X_21124_ _14102_ _14123_ VDD VSS INV_X1
X_21125_ _14120_ _15617_ VDD VSS INV_X1
X_21126_ _14149_ _14156_ VDD VSS INV_X1
X_21127_ _14138_ _15623_ VDD VSS INV_X1
X_21128_ _14143_ _15629_ VDD VSS INV_X1
X_21129_ _14165_ _15638_ VDD VSS INV_X1
X_21130_ _14170_ _14205_ VDD VSS INV_X1
X_21131_ _14175_ _15642_ VDD VSS INV_X1
X_21132_ _14188_ _15650_ VDD VSS INV_X1
X_21133_ _14201_ _14240_ VDD VSS INV_X1
X_21134_ _14219_ _15663_ VDD VSS INV_X1
X_21135_ _14282_ _15670_ VDD VSS INV_X1
X_21136_ _14246_ _15674_ VDD VSS INV_X1
X_21137_ _14325_ _15684_ VDD VSS INV_X1
X_21138_ _14286_ _15692_ VDD VSS INV_X1
X_21139_ _14310_ _15696_ VDD VSS INV_X1
X_21140_ _14302_ _14361_ VDD VSS INV_X1
X_21141_ _14324_ _15698_ VDD VSS INV_X1
X_21142_ _14384_ _15701_ VDD VSS INV_X1
X_21143_ _14358_ _15703_ VDD VSS INV_X1
X_21144_ _14345_ _14415_ VDD VSS INV_X1
X_21145_ _14370_ _15705_ VDD VSS INV_X1
X_21146_ _14432_ _15709_ VDD VSS INV_X1
X_21147_ _14455_ _14457_ VDD VSS INV_X2
X_21148_ _14412_ _15713_ VDD VSS INV_X1
X_21149_ _14399_ _14470_ VDD VSS INV_X1
X_21150_ _14426_ _15715_ VDD VSS INV_X1
X_21151_ _14513_ _14515_ VDD VSS INV_X1
X_21152_ _14467_ _15722_ VDD VSS INV_X1
X_21153_ _14454_ _14527_ VDD VSS INV_X1
X_21154_ _14480_ _15724_ VDD VSS INV_X1
X_21155_ _14524_ _14595_ VDD VSS INV_X1
X_21156_ _14537_ _15728_ VDD VSS INV_X1
X_21157_ _14591_ _15734_ VDD VSS INV_X1
X_21158_ _14607_ _15737_ VDD VSS INV_X1
X_21159_ _14658_ _15741_ VDD VSS INV_X1
X_21160_ _14667_ _15743_ VDD VSS INV_X1
X_21161_ _14715_ _15747_ VDD VSS INV_X1
X_21162_ _14705_ _14775_ VDD VSS INV_X1
X_21163_ _14725_ _15749_ VDD VSS INV_X1
X_21164_ _14841_ _15755_ VDD VSS INV_X1
X_21165_ _14829_ _15759_ VDD VSS INV_X1
X_21166_ _14820_ _14885_ VDD VSS INV_X1
X_21167_ _14840_ _15761_ VDD VSS INV_X1
X_21168_ _14921_ _14923_ VDD VSS INV_X1
X_21169_ _14948_ _15767_ VDD VSS INV_X1
X_21170_ _14936_ _15771_ VDD VSS INV_X1
X_21171_ _14947_ _15773_ VDD VSS INV_X1
X_21172_ _14980_ _15039_ VDD VSS INV_X1
X_21173_ _15047_ _15779_ VDD VSS INV_X1
X_21174_ _15079_ _15783_ VDD VSS INV_X1
X_21175_ _15046_ _15785_ VDD VSS INV_X1
X_21176_ _15078_ _15789_ VDD VSS INV_X1
X_21177_ _15089_ _15791_ VDD VSS INV_X1
X_21178_ _15173_ _15797_ VDD VSS INV_X1
X_21179_ _15210_ _15803_ VDD VSS INV_X1
X_21180_ _15198_ _15807_ VDD VSS INV_X1
X_21181_ _15189_ _15240_ VDD VSS INV_X1
X_21182_ _15209_ _15809_ VDD VSS INV_X1
X_21183_ _15214_ _15256_ VDD VSS INV_X1
X_21184_ _15224_ _15266_ VDD VSS INV_X1
X_21185_ _15237_ _15813_ VDD VSS INV_X1
X_21186_ _15248_ _15815_ VDD VSS INV_X1
X_21187_ _15253_ _15295_ VDD VSS INV_X1
X_21188_ _15260_ _15302_ VDD VSS INV_X1
X_21189_ _15314_ _15819_ VDD VSS INV_X1
X_21190_ _15277_ _15818_ VDD VSS INV_X1
X_21191_ _15288_ _15821_ VDD VSS INV_X1
X_21192_ _15292_ _15329_ VDD VSS INV_X1
X_21193_ _15313_ _15825_ VDD VSS INV_X1
X_21194_ _15323_ _15828_ VDD VSS INV_X1
X_21195_ _15881_ _15877_ VDD VSS INV_X1
X_21196_ _15889_ _15885_ VDD VSS INV_X1
X_21197_ _16021_ _16025_ VDD VSS INV_X1
X_21198_ _16037_ _16041_ VDD VSS INV_X1
X_21199_ _16045_ _16049_ VDD VSS INV_X2
X_21200_ _16053_ _16057_ VDD VSS INV_X1
X_21201_ _16061_ _16065_ VDD VSS INV_X1
X_21202_ _16069_ _16073_ VDD VSS INV_X1
X_21203_ _16077_ _16081_ VDD VSS INV_X1
X_21204_ _15586_ _14100_ VDD VSS INV_X1
X_21205_ _15598_ _14118_ VDD VSS INV_X1
X_21206_ _15615_ _14140_ VDD VSS INV_X1
X_21207_ _15625_ _14167_ VDD VSS INV_X1
X_21208_ _15627_ _14173_ VDD VSS INV_X1
X_21209_ _15640_ _14198_ VDD VSS INV_X1
X_21210_ _15656_ _14231_ VDD VSS INV_X1
X_21211_ _15669_ _14271_ VDD VSS INV_X1
X_21212_ _15682_ _14314_ VDD VSS INV_X1
X_21213_ _15735_ _14660_ VDD VSS INV_X1
X_21214_ _15660_ _14301_ VDD VSS INV_X1
X_21215_ _15675_ _14344_ VDD VSS INV_X1
X_21216_ _15689_ _14382_ VDD VSS INV_X1
X_21217_ _15693_ _14398_ VDD VSS INV_X1
X_21218_ _11430_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_valid
+ _11406_ _04228_ VDD VSS NOR3_X1
X_21219_ _11403_ _04228_ _04229_ VDD VSS AND2_X4
X_21220_ _10341_ _10372_ _10299_ _10333_ _10384_ _10364_ _04230_
+ VDD VSS OAI33_X1
X_21221_ _03493_ _04230_ _10312_ _04231_ VDD VSS AOI21_X4
X_21222_ _04229_ _04231_ _04232_ VDD VSS NOR2_X2
X_21223_ _10921_ _03533_ _03514_ _04233_ VDD VSS AND3_X1
X_21224_ _03527_ _11071_ _10920_ _04234_ VDD VSS OAI21_X1
X_21225_ _04233_ _04234_ _15869_ _03506_ _03505_ _04235_ VDD
+ VSS OAI221_X2
X_21226_ _03554_ _03533_ _04236_ VDD VSS NAND2_X4
X_21227_ _04235_ _03551_ _04236_ _04237_ VDD VSS OAI21_X2
X_21228_ _10921_ _03491_ _11352_ _11321_ _04238_ VDD VSS OAI211_X4
X_21229_ _15916_ _04238_ _04239_ VDD VSS NOR2_X2
X_21230_ _04239_ _03558_ _03561_ _04240_ VDD VSS OAI21_X1
X_21231_ _03537_ _04239_ _03569_ _04241_ VDD VSS NAND3_X1
X_21232_ _04240_ _04241_ _04242_ VDD VSS NAND2_X1
X_21233_ _15884_ _15896_ _04243_ VDD VSS NAND2_X1
X_21234_ _15916_ _04238_ _03524_ _04243_ _04244_ VDD VSS OR4_X4
X_21235_ _03506_ _03530_ _03499_ _04245_ VDD VSS OAI21_X2
X_21236_ _04244_ _04245_ _03575_ _04246_ VDD VSS AOI21_X2
X_21237_ _04239_ _03584_ _03582_ _04247_ VDD VSS OAI21_X4
X_21238_ _10919_ _15884_ _04248_ VDD VSS NOR2_X2
X_21239_ _15929_ _03491_ _04248_ _03587_ _04249_ VDD VSS AND4_X2
X_21240_ _10919_ _15880_ _03555_ _04250_ VDD VSS NOR3_X1
X_21241_ _04249_ _04250_ _03506_ _03580_ _04251_ VDD VSS OAI211_X2
X_21242_ _04238_ _15916_ _11065_ _04252_ VDD VSS AOI21_X1
X_21243_ _03530_ _03554_ _03556_ _04252_ _04253_ VDD VSS NAND4_X1
X_21244_ _04251_ _04253_ _04254_ VDD VSS AND2_X1
X_21245_ _10934_ _10975_ _15864_ _03596_ _04255_ VDD VSS NOR4_X4
X_21246_ _03514_ _04255_ _03595_ _04256_ VDD VSS NAND3_X2
X_21247_ _15884_ _03542_ _03599_ _04257_ VDD VSS NAND3_X1
X_21248_ _15920_ _04238_ _03580_ _04257_ _04258_ VDD VSS OR4_X1
X_21249_ _04247_ _04254_ _04256_ _04258_ _04259_ VDD VSS NAND4_X2
X_21250_ _04237_ _04242_ _04246_ _04259_ _04260_ VDD VSS NOR4_X4
X_21251_ _10922_ _03508_ _04260_ _04261_ VDD VSS OAI21_X4
X_21252_ _03439_ _04232_ _04261_ _04262_ VDD VSS AND3_X1
X_21253_ _04262_ _04263_ VDD VSS BUF_X4
X_21254_ _11482_ _04264_ VDD VSS BUF_X4
X_21255_ net292 _11918_ _04265_ VDD VSS NAND2_X4
X_21256_ _11492_ _11508_ _04266_ VDD VSS NAND2_X2
X_21257_ _11510_ _04266_ _04267_ VDD VSS NOR2_X4
X_21258_ _11505_ _04268_ VDD VSS INV_X1
X_21259_ _11476_ _04268_ _04269_ VDD VSS NAND2_X2
X_21260_ net309 _04267_ _04269_ _04270_ VDD VSS AOI21_X4
X_21261_ _15359_ _04271_ VDD VSS CLKBUF_X3
X_21262_ _04271_ _04272_ VDD VSS INV_X1
X_21263_ _11500_ _04273_ VDD VSS BUF_X4
X_21264_ _04272_ _04273_ _04274_ VDD VSS NOR2_X2
X_21265_ _04264_ _04265_ _04270_ _04274_ _04275_ VDD VSS NOR4_X4
X_21266_ _04275_ _04276_ VDD VSS BUF_X4
X_21267_ _15836_ _04277_ VDD VSS INV_X1
X_21268_ _04277_ _15864_ _11067_ _11070_ _04278_ VDD VSS AOI211_X2
X_21269_ _15873_ _04278_ _10333_ _04279_ VDD VSS OAI21_X4
X_21270_ _10333_ _11065_ _04278_ _04280_ VDD VSS OR3_X4
X_21271_ _04279_ _04280_ _04281_ VDD VSS AND2_X2
X_21272_ _04281_ _04282_ VDD VSS BUF_X4
X_21273_ _10737_ _10476_ _10396_ _04283_ VDD VSS AOI21_X2
X_21274_ _10333_ _15860_ _11071_ _04283_ _04284_ VDD VSS AOI22_X4
X_21275_ _10673_ _10317_ _03675_ _04285_ VDD VSS OAI21_X2
X_21276_ id_stage_i.controller_i.instr_is_compressed_i _10354_
+ _04286_ VDD VSS AND2_X1
X_21277_ net364 _04286_ _10376_ _04287_ VDD VSS MUX2_X1
X_21278_ _10403_ _10389_ _04287_ _10932_ _10394_ _04288_ VDD
+ VSS AOI221_X2
X_21279_ _10736_ _04285_ _04288_ _04289_ VDD VSS OAI21_X2
X_21280_ _15864_ _04289_ _15853_ _10306_ _10305_ _04290_ VDD
+ VSS OAI221_X2
X_21281_ _04284_ _04290_ _04291_ VDD VSS AND2_X1
X_21282_ _04291_ _04292_ VDD VSS CLKBUF_X3
X_21283_ _04292_ _04293_ VDD VSS CLKBUF_X3
X_21284_ _15837_ _10368_ _04294_ VDD VSS NAND2_X2
X_21285_ _04294_ _04295_ VDD VSS CLKBUF_X3
X_21286_ _04277_ _10368_ _11070_ _11067_ _04296_ VDD VSS AOI22_X4
X_21287_ _15836_ _10333_ _10934_ _10975_ _04297_ VDD VSS NOR4_X4
X_21288_ _04295_ _04296_ _04297_ _10368_ _15834_ _04298_ VDD
+ VSS OAI221_X2
X_21289_ _04282_ _04293_ _04298_ _04299_ VDD VSS AOI21_X2
X_21290_ _04264_ _04300_ VDD VSS INV_X4
X_21291_ _11510_ _11862_ _04266_ _04301_ VDD VSS NOR3_X4
X_21292_ _04271_ _04300_ _04301_ _04302_ VDD VSS NAND3_X4
X_21293_ _15842_ _15496_ _04302_ _04303_ VDD VSS MUX2_X2
X_21294_ _11486_ _04300_ _04304_ VDD VSS NAND2_X2
X_21295_ _04273_ _04304_ _04265_ _04305_ VDD VSS NOR3_X2
X_21296_ _04303_ _04305_ _04306_ VDD VSS AND2_X2
X_21297_ _04306_ _04307_ VDD VSS CLKBUF_X3
X_21298_ _04282_ _04308_ VDD VSS CLKBUF_X3
X_21299_ _15835_ _04297_ _04296_ _04309_ VDD VSS NOR3_X1
X_21300_ _04272_ _11482_ _11484_ _04310_ VDD VSS OR3_X2
X_21301_ net279 _04310_ _04311_ VDD VSS OR2_X1
X_21302_ _04311_ _04312_ VDD VSS BUF_X4
X_21303_ _04312_ _04313_ VDD VSS BUF_X4
X_21304_ _15856_ _16072_ _04313_ _04314_ VDD VSS MUX2_X1
X_21305_ _10333_ _10396_ _10476_ _04315_ VDD VSS NAND3_X2
X_21306_ _04315_ _04316_ VDD VSS BUF_X2
X_21307_ _04314_ _04295_ _04316_ _04317_ VDD VSS AOI21_X2
X_21308_ _10368_ _04288_ _04285_ _04318_ VDD VSS NOR3_X4
X_21309_ _15837_ _10368_ _04319_ VDD VSS AND2_X1
X_21310_ _04319_ _04320_ VDD VSS CLKBUF_X3
X_21311_ _15872_ _16056_ _04313_ _04321_ VDD VSS MUX2_X1
X_21312_ _04318_ _04320_ _04321_ _04322_ VDD VSS NOR3_X1
X_21313_ _04309_ _04317_ _04322_ _04323_ VDD VSS OAI21_X1
X_21314_ _15905_ _16024_ _04312_ _04324_ VDD VSS MUX2_X1
X_21315_ _15913_ _16013_ _04312_ _04325_ VDD VSS MUX2_X1
X_21316_ _04324_ _04325_ _10736_ _04326_ VDD VSS MUX2_X1
X_21317_ _15889_ _16040_ _04312_ _04327_ VDD VSS MUX2_X1
X_21318_ _15897_ _16029_ _04312_ _04328_ VDD VSS MUX2_X1
X_21319_ _04327_ _04328_ _10736_ _04329_ VDD VSS MUX2_X1
X_21320_ _04315_ _04294_ _04330_ VDD VSS NAND2_X4
X_21321_ _04326_ _04329_ _04330_ _04331_ VDD VSS MUX2_X1
X_21322_ _04297_ _04296_ _04332_ VDD VSS NOR2_X4
X_21323_ _04332_ _04333_ VDD VSS BUF_X4
X_21324_ _15881_ _16045_ _04313_ _04334_ VDD VSS MUX2_X1
X_21325_ _04318_ _04320_ _04334_ _04335_ VDD VSS NOR3_X1
X_21326_ _15861_ _16064_ _04302_ _04336_ VDD VSS MUX2_X1
X_21327_ _04336_ _04294_ _04315_ _04337_ VDD VSS AOI21_X1
X_21328_ _04335_ _04337_ _04338_ VDD VSS NOR2_X1
X_21329_ _15835_ _04333_ _04339_ VDD VSS NAND2_X1
X_21330_ _04323_ _04331_ _04333_ _04338_ _04339_ _04340_ VDD
+ VSS OAI221_X2
X_21331_ _15845_ _04313_ _04341_ VDD VSS NOR2_X1
X_21332_ _04313_ _04342_ VDD VSS BUF_X4
X_21333_ _04341_ _04342_ _16080_ _04343_ VDD VSS AOI21_X2
X_21334_ _04303_ _04343_ _10739_ _04344_ VDD VSS MUX2_X1
X_21335_ _04298_ _04344_ _04345_ VDD VSS OR2_X1
X_21336_ _04340_ _04345_ _04293_ _04346_ VDD VSS MUX2_X1
X_21337_ _04276_ _04299_ _04307_ _04308_ _04346_ _04347_ VDD
+ VSS OAI221_X2
X_21338_ _04300_ _04265_ _04348_ VDD VSS NOR2_X2
X_21339_ net285 _04271_ _04273_ _04349_ VDD VSS MUX2_X1
X_21340_ _04348_ _04349_ _04350_ VDD VSS AND2_X2
X_21341_ _04350_ _04351_ VDD VSS BUF_X4
X_21342_ _04351_ _04352_ VDD VSS CLKBUF_X3
X_21343_ _04352_ _04353_ VDD VSS CLKBUF_X3
X_21344_ _04264_ net293 _11918_ _04354_ VDD VSS NAND3_X4
X_21345_ _04271_ _04267_ _04355_ VDD VSS NAND2_X1
X_21346_ net285 net309 _04356_ VDD VSS NOR2_X2
X_21347_ _11505_ _04273_ _04356_ _04357_ VDD VSS NAND3_X2
X_21348_ _04354_ _04355_ _04357_ _04358_ VDD VSS AOI21_X4
X_21349_ _04358_ _04359_ VDD VSS BUF_X4
X_21350_ _04359_ _04360_ VDD VSS CLKBUF_X3
X_21351_ _04267_ _04354_ _04356_ _04361_ VDD VSS NOR3_X4
X_21352_ _04361_ _04362_ VDD VSS CLKBUF_X3
X_21353_ _04362_ _04363_ VDD VSS CLKBUF_X3
X_21354_ _16015_ _04360_ _04363_ _16018_ _04364_ VDD VSS AOI22_X1
X_21355_ _04353_ _04364_ _04365_ VDD VSS NOR2_X1
X_21356_ net309 _11505_ _04366_ VDD VSS NOR2_X2
X_21357_ _04273_ _04354_ _04366_ _04367_ VDD VSS NOR3_X4
X_21358_ _04367_ _04368_ VDD VSS CLKBUF_X3
X_21359_ _04368_ _04369_ VDD VSS BUF_X4
X_21360_ _04352_ _04370_ VDD VSS CLKBUF_X3
X_21361_ _16014_ _04371_ VDD VSS INV_X1
X_21362_ _04365_ _04369_ alu_adder_result_ex\[22\] _04370_
+ _04371_ _04372_ VDD VSS AOI221_X2
X_21363_ _15365_ _11482_ _11862_ _04373_ VDD VSS AND3_X1
X_21364_ _11486_ _04264_ _11862_ _04374_ VDD VSS AND3_X1
X_21365_ _04373_ _04374_ _11500_ _04375_ VDD VSS MUX2_X2
X_21366_ _04264_ _04273_ _04376_ VDD VSS NAND2_X1
X_21367_ _04271_ _04269_ _04377_ VDD VSS NOR2_X1
X_21368_ _04273_ _04304_ _04376_ _04377_ _04378_ VDD VSS OAI22_X1
X_21369_ _04272_ _04268_ _04379_ VDD VSS NAND2_X1
X_21370_ _04300_ net291 _04380_ VDD VSS NOR2_X1
X_21371_ _04375_ _04378_ _11862_ _04379_ _04380_ _04381_ VDD
+ VSS AOI221_X2
X_21372_ _04268_ _04264_ _11476_ _04382_ VDD VSS OAI21_X1
X_21373_ _11486_ _04376_ _04382_ _04267_ _04383_ VDD VSS AOI22_X1
X_21374_ _04265_ _04383_ _04384_ VDD VSS OR2_X1
X_21375_ net286 _04271_ _04385_ VDD VSS NOR2_X1
X_21376_ _04385_ _04366_ _04267_ _04386_ VDD VSS OAI21_X1
X_21377_ _04348_ _04386_ _04387_ VDD VSS NAND2_X2
X_21378_ _04381_ _04384_ _04387_ _04342_ _04388_ VDD VSS NAND4_X1
X_21379_ _11406_ _04388_ _04389_ VDD VSS NAND2_X1
X_21380_ _04389_ _04390_ VDD VSS BUF_X4
X_21381_ _04390_ _04391_ VDD VSS BUF_X4
X_21382_ _04347_ _04372_ _04391_ _04392_ VDD VSS OAI21_X2
X_21383_ _10744_ _04393_ VDD VSS BUF_X4
X_21384_ _04316_ _04295_ _04343_ _04394_ VDD VSS NAND3_X1
X_21385_ _04305_ _04320_ _04318_ _04395_ VDD VSS OAI21_X1
X_21386_ _15841_ _04394_ _04395_ _04396_ VDD VSS NAND3_X2
X_21387_ _10739_ _04397_ VDD VSS CLKBUF_X3
X_21388_ _04397_ _04316_ _04295_ _04314_ _04398_ VDD VSS NAND4_X1
X_21389_ _15838_ _15492_ _04302_ _04399_ VDD VSS MUX2_X2
X_21390_ _04399_ _04320_ _04318_ _04400_ VDD VSS OAI21_X1
X_21391_ _04332_ _04398_ _04400_ _04401_ VDD VSS AND3_X1
X_21392_ _10738_ _04321_ _04402_ VDD VSS OR2_X1
X_21393_ _04402_ _04336_ _10739_ _04403_ VDD VSS OAI21_X1
X_21394_ _10739_ _04334_ _04404_ VDD VSS OR2_X1
X_21395_ _04404_ _04327_ _15841_ _04405_ VDD VSS OAI21_X1
X_21396_ _04318_ _04320_ _04406_ VDD VSS NOR2_X4
X_21397_ _04403_ _04405_ _04406_ _04407_ VDD VSS MUX2_X2
X_21398_ _04297_ _04296_ _04408_ VDD VSS OR2_X1
X_21399_ _04408_ _04409_ VDD VSS BUF_X4
X_21400_ _04409_ _04410_ VDD VSS BUF_X4
X_21401_ _04396_ _04401_ _04407_ _04410_ _04411_ VDD VSS AOI22_X4
X_21402_ _04279_ _04280_ _04412_ VDD VSS NAND2_X4
X_21403_ _04412_ _04292_ _04413_ VDD VSS NOR2_X1
X_21404_ _04411_ _04413_ _04414_ VDD VSS NAND2_X1
X_21405_ _15921_ _16005_ _04312_ _04415_ VDD VSS MUX2_X1
X_21406_ _10738_ _04415_ _04416_ VDD VSS OR2_X1
X_21407_ _04416_ _04325_ _10739_ _04417_ VDD VSS OAI21_X1
X_21408_ _15901_ _16020_ _04313_ _04418_ VDD VSS MUX2_X1
X_21409_ _15893_ _16033_ _04313_ _04419_ VDD VSS MUX2_X1
X_21410_ _04418_ _04419_ _10738_ _04420_ VDD VSS MUX2_X1
X_21411_ _04417_ _04420_ _04330_ _04421_ VDD VSS MUX2_X1
X_21412_ _15944_ _15981_ _04312_ _04422_ VDD VSS MUX2_X1
X_21413_ _15952_ _15976_ _04312_ _04423_ VDD VSS MUX2_X1
X_21414_ _04422_ _04423_ _10736_ _04424_ VDD VSS MUX2_X1
X_21415_ _04315_ _04294_ _04424_ _04425_ VDD VSS AND3_X1
X_21416_ _15928_ _15997_ _04312_ _04426_ VDD VSS MUX2_X1
X_21417_ _15936_ _15992_ _04312_ _04427_ VDD VSS MUX2_X1
X_21418_ _04426_ _04427_ _10739_ _04428_ VDD VSS MUX2_X1
X_21419_ _04330_ _04429_ VDD VSS BUF_X4
X_21420_ _04425_ _04428_ _04429_ _04430_ VDD VSS AOI21_X1
X_21421_ _04409_ _04431_ VDD VSS BUF_X4
X_21422_ _04421_ _04430_ _04431_ _04432_ VDD VSS MUX2_X1
X_21423_ net279 _04310_ _04433_ VDD VSS NOR2_X4
X_21424_ _04433_ _04434_ VDD VSS CLKBUF_X3
X_21425_ _10739_ _04434_ _04435_ VDD VSS XNOR2_X1
X_21426_ _15961_ _15964_ _04435_ _04436_ VDD VSS MUX2_X1
X_21427_ _15952_ _15976_ _04433_ _04437_ VDD VSS MUX2_X1
X_21428_ _15944_ _15981_ _04433_ _04438_ VDD VSS MUX2_X1
X_21429_ _04437_ _04438_ _10739_ _04439_ VDD VSS MUX2_X1
X_21430_ _04439_ _04440_ VDD VSS INV_X1
X_21431_ _04436_ _04440_ _04406_ _04441_ VDD VSS MUX2_X1
X_21432_ _15921_ _16005_ _04433_ _04442_ VDD VSS MUX2_X1
X_21433_ _04397_ _04442_ _04443_ VDD VSS OR2_X1
X_21434_ _15913_ _16013_ _04434_ _04444_ VDD VSS MUX2_X1
X_21435_ _04443_ _04444_ _15841_ _04445_ VDD VSS OAI21_X1
X_21436_ _15936_ _15992_ _04433_ _04446_ VDD VSS MUX2_X1
X_21437_ _15928_ _15997_ _04433_ _04447_ VDD VSS MUX2_X1
X_21438_ _04446_ _04447_ _10739_ _04448_ VDD VSS MUX2_X1
X_21439_ _04448_ _04449_ VDD VSS INV_X1
X_21440_ _04445_ _04449_ _04429_ _04450_ VDD VSS MUX2_X1
X_21441_ _04441_ _04450_ _04431_ _04451_ VDD VSS MUX2_X1
X_21442_ _04284_ _04290_ _04452_ VDD VSS NAND2_X4
X_21443_ _04452_ _04453_ VDD VSS BUF_X4
X_21444_ _04432_ _04451_ _04453_ _04454_ VDD VSS MUX2_X1
X_21445_ _04414_ _04454_ _04308_ _04455_ VDD VSS OAI21_X1
X_21446_ _04271_ _04300_ _04301_ _04456_ VDD VSS AND3_X2
X_21447_ _04456_ _04457_ VDD VSS CLKBUF_X3
X_21448_ _04452_ _04306_ _04458_ VDD VSS NOR2_X2
X_21449_ _04281_ _04458_ _04459_ VDD VSS NAND2_X1
X_21450_ _04457_ _04459_ _04460_ VDD VSS NAND2_X1
X_21451_ _14125_ _15619_ _04461_ VDD VSS XNOR2_X2
X_21452_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]
+ _11430_ _11433_ _04462_ VDD VSS OR3_X1
X_21453_ _04462_ _04463_ VDD VSS CLKBUF_X3
X_21454_ _04461_ _04463_ _04464_ VDD VSS NOR2_X1
X_21455_ _15757_ _04465_ VDD VSS INV_X1
X_21456_ _15745_ _15744_ _04466_ VDD VSS NOR2_X1
X_21457_ _04466_ _04467_ VDD VSS INV_X1
X_21458_ _15750_ _04467_ _15751_ _04468_ VDD VSS AOI21_X1
X_21459_ _04465_ _04468_ _04469_ VDD VSS NOR2_X1
X_21460_ _15763_ _15756_ _04469_ _04470_ VDD VSS OAI21_X1
X_21461_ _15738_ _15744_ _15750_ _15756_ _04471_ VDD VSS NOR4_X2
X_21462_ _15739_ _04472_ VDD VSS BUF_X4
X_21463_ _15730_ net326 _04472_ _04473_ VDD VSS AND3_X4
X_21464_ _15716_ _15706_ _15699_ _04474_ VDD VSS OR3_X4
Xclone81 _03661_ net352 VDD VSS BUF_X4
X_21466_ _15657_ _15671_ _15685_ _04476_ VDD VSS OR3_X4
X_21467_ _15630_ _04477_ VDD VSS INV_X1
X_21468_ _15618_ _15619_ _14125_ _04478_ VDD VSS AOI21_X1
X_21469_ _15631_ _04479_ VDD VSS INV_X1
X_21470_ _04477_ _04478_ _04479_ _04480_ VDD VSS OAI21_X2
X_21471_ _15644_ _04481_ VDD VSS BUF_X2
X_21472_ _15643_ _04476_ _04480_ _04481_ _04482_ VDD VSS AOI211_X2
Xrebuffer64 _12144_ net335 VDD VSS BUF_X1
X_21474_ _15686_ _04484_ VDD VSS INV_X1
X_21475_ _15671_ _04485_ VDD VSS INV_X1
X_21476_ _15672_ _04486_ VDD VSS BUF_X2
X_21477_ _04486_ _15657_ _15658_ _04487_ VDD VSS OAI21_X1
X_21478_ _04484_ _04485_ _04487_ _04488_ VDD VSS AOI21_X2
X_21479_ _15700_ _15685_ _04488_ _04489_ VDD VSS OAI21_X2
X_21480_ _04489_ _04482_ _04490_ VDD VSS NOR2_X2
X_21481_ _15707_ _04491_ VDD VSS BUF_X2
X_21482_ _15717_ _15706_ _04491_ _04492_ VDD VSS OAI21_X4
X_21483_ _04492_ _04493_ VDD VSS INV_X2
X_21484_ _04473_ _04490_ _04474_ _15716_ _04493_ _04494_ VDD
+ VSS OAI221_X2
X_21485_ _15729_ _15725_ _15730_ _04495_ VDD VSS AOI21_X2
X_21486_ _04495_ _04496_ VDD VSS INV_X1
X_21487_ _04472_ _04496_ _04497_ VDD VSS NAND2_X1
X_21488_ _04497_ _04494_ _04498_ VDD VSS AND2_X4
X_21489_ _04470_ _04498_ _04471_ _04499_ VDD VSS AOI21_X4
X_21490_ _15762_ _04499_ _04500_ VDD VSS NOR2_X1
X_21491_ _15769_ _04500_ _04501_ VDD VSS XNOR2_X1
X_21492_ _04463_ _04502_ VDD VSS CLKBUF_X3
X_21493_ _04464_ _04501_ _04502_ _04503_ VDD VSS AOI21_X1
X_21494_ _03813_ _04503_ _12102_ _04504_ VDD VSS MUX2_X2
X_21495_ _04393_ _04455_ _04460_ _04504_ _11408_ _04505_ VDD
+ VSS OAI221_X2
X_21496_ _10921_ _15888_ _15892_ _04506_ VDD VSS NAND3_X2
X_21497_ _11116_ _11063_ _11061_ _04507_ VDD VSS OAI21_X2
X_21498_ _15920_ _04238_ _04506_ _04507_ _04508_ VDD VSS OR4_X1
X_21499_ _04508_ _04509_ VDD VSS BUF_X4
X_21500_ _03504_ _04509_ _03540_ _10921_ _04510_ VDD VSS AOI211_X2
X_21501_ net248 _04511_ VDD VSS BUF_X4
X_21502_ _15929_ _03491_ _04248_ _03587_ _04512_ VDD VSS NAND4_X4
X_21503_ _10920_ _03537_ _04513_ VDD VSS NOR2_X1
X_21504_ _03575_ _04512_ _04513_ _04514_ VDD VSS NOR3_X4
X_21505_ _04514_ _04515_ VDD VSS BUF_X4
X_21506_ cs_registers_i.dscratch0_q\[22\] _04511_ _04515_
+ cs_registers_i.mie_q\[6\] _04516_ VDD VSS AOI22_X1
X_21507_ _03575_ _04244_ _04517_ VDD VSS NOR2_X4
X_21508_ _04517_ _04518_ VDD VSS BUF_X4
X_21509_ _04244_ _03577_ _03576_ _04519_ VDD VSS AOI21_X2
X_21510_ _04519_ _04520_ VDD VSS BUF_X4
X_21511_ _04520_ _04521_ VDD VSS BUF_X4
X_21512_ _03500_ _04244_ _03518_ _03540_ _04522_ VDD VSS AOI211_X2
X_21513_ _04522_ _04523_ VDD VSS BUF_X4
X_21514_ _04523_ _04524_ VDD VSS BUF_X4
X_21515_ net138 _04518_ _04521_ cs_registers_i.mtval_q\[22\]
+ cs_registers_i.mscratch_q\[22\] _04524_ _04525_ VDD VSS AOI222_X2
X_21516_ _03514_ _04255_ _03595_ _04526_ VDD VSS AND3_X4
X_21517_ _04526_ _04527_ VDD VSS BUF_X4
X_21518_ _04527_ _04528_ VDD VSS BUF_X4
X_21519_ _04509_ _03576_ _03577_ _04529_ VDD VSS AOI21_X4
X_21520_ _04529_ _04530_ VDD VSS BUF_X4
X_21521_ net76 _04528_ _04530_ cs_registers_i.dscratch1_q\[22\]
+ _04531_ VDD VSS AOI22_X1
X_21522_ _03580_ _03581_ _04512_ _04532_ VDD VSS OR3_X1
X_21523_ _04532_ _04533_ VDD VSS CLKBUF_X3
X_21524_ _04533_ _04534_ VDD VSS BUF_X4
X_21525_ _03502_ _10919_ _15876_ _04535_ VDD VSS NOR3_X4
X_21526_ _15873_ _03594_ _04249_ _04535_ _04536_ VDD VSS NAND4_X4
X_21527_ _04536_ _04537_ VDD VSS BUF_X4
X_21528_ _15920_ _04238_ _04506_ _04507_ _04538_ VDD VSS NOR4_X4
X_21529_ _03501_ _04538_ _03530_ _10920_ _04539_ VDD VSS OAI211_X4
X_21530_ cs_registers_i.csr_depc_o\[22\] _04540_ VDD VSS INV_X1
X_21531_ _04534_ _04537_ _01179_ _04539_ _04540_ _04541_ VDD
+ VSS OAI221_X2
X_21532_ _03502_ _04244_ _03540_ _10922_ _04542_ VDD VSS AOI211_X2
X_21533_ _04542_ _04543_ VDD VSS BUF_X4
X_21534_ _04543_ _04544_ VDD VSS BUF_X4
X_21535_ _04541_ _04544_ cs_registers_i.csr_mepc_o\[22\] _04545_
+ VDD VSS AOI21_X2
X_21536_ _04516_ _04525_ _04531_ _04545_ _04546_ VDD VSS AND4_X1
X_21537_ cs_registers_i.mcycle_counter_i.counter\[54\] _04547_
+ VDD VSS BUF_X2
X_21538_ _15508_ _03501_ _03506_ _03503_ _04548_ VDD VSS OR4_X2
X_21539_ _04548_ _03574_ _03540_ _04549_ VDD VSS AOI21_X4
X_21540_ _04549_ _04550_ VDD VSS BUF_X8
X_21541_ _04550_ _04551_ VDD VSS BUF_X4
X_21542_ _03504_ _10922_ _03580_ _04552_ VDD VSS AOI21_X4
X_21543_ _04552_ _04553_ VDD VSS BUF_X4
X_21544_ _04553_ _04554_ VDD VSS BUF_X4
X_21545_ _04547_ _04551_ _04554_ cs_registers_i.mhpmcounter\[2\]\[54\]
+ _04555_ VDD VSS AOI22_X2
X_21546_ _03551_ _04236_ _04556_ VDD VSS OR2_X1
X_21547_ _04556_ _04557_ VDD VSS BUF_X4
X_21548_ _04557_ _04558_ VDD VSS BUF_X4
X_21549_ _04235_ _04559_ VDD VSS CLKBUF_X3
X_21550_ _04559_ _04560_ VDD VSS BUF_X4
X_21551_ cs_registers_i.mcycle_counter_i.counter\[22\] _04551_
+ _04554_ cs_registers_i.mhpmcounter\[2\]\[22\] _04561_ VDD
+ VSS AOI22_X2
X_21552_ _04546_ _04555_ _04558_ _04560_ _04561_ _04562_ VDD
+ VSS OAI221_X2
X_21553_ _04393_ _04563_ VDD VSS BUF_X4
X_21554_ _04263_ _04392_ _04505_ _04562_ _04563_ _04564_ VDD
+ VSS OAI221_X2
X_21555_ load_store_unit_i.data_type_q\[1\] _04565_ VDD VSS
+ BUF_X4
X_21556_ load_store_unit_i.rdata_offset_q\[0\] _04566_ VDD
+ VSS BUF_X2
X_21557_ net57 net35 _04566_ _04567_ VDD VSS MUX2_X1
X_21558_ data_rdata_i[23] _04568_ VDD VSS BUF_X1
X_21559_ _04568_ net52 _04566_ _04569_ VDD VSS MUX2_X1
X_21560_ load_store_unit_i.rdata_offset_q\[1\] _04570_ VDD
+ VSS BUF_X4
X_21561_ _04567_ _04569_ _04570_ _04571_ VDD VSS MUX2_X1
X_21562_ _04565_ load_store_unit_i.data_sign_ext_q _04571_
+ _04572_ VDD VSS NAND3_X4
X_21563_ load_store_unit_i.data_type_q\[2\] _04573_ VDD VSS
+ BUF_X2
X_21564_ _04573_ _04574_ VDD VSS CLKBUF_X3
X_21565_ net52 net57 _04566_ _04575_ VDD VSS MUX2_X1
X_21566_ net35 _04568_ _04566_ _04576_ VDD VSS MUX2_X1
X_21567_ load_store_unit_i.rdata_offset_q\[1\] _04577_ VDD
+ VSS INV_X2
X_21568_ _04575_ _04576_ _04577_ _04578_ VDD VSS MUX2_X1
X_21569_ _04574_ load_store_unit_i.data_sign_ext_q _04578_
+ _04579_ VDD VSS NAND3_X1
X_21570_ _04572_ _04579_ _04580_ VDD VSS NAND2_X2
X_21571_ _04573_ _04565_ _04581_ VDD VSS NOR2_X4
X_21572_ _04581_ _04582_ VDD VSS BUF_X4
X_21573_ _04582_ _04583_ VDD VSS BUF_X4
X_21574_ _04566_ _04584_ VDD VSS BUF_X4
X_21575_ _04584_ _04585_ VDD VSS CLKBUF_X3
X_21576_ _04585_ _04586_ VDD VSS CLKBUF_X3
X_21577_ _04586_ net56 _04587_ VDD VSS NOR2_X1
X_21578_ _04566_ _04588_ VDD VSS INV_X1
X_21579_ _04588_ _04589_ VDD VSS CLKBUF_X3
X_21580_ _04589_ net34 _04590_ VDD VSS NOR2_X1
X_21581_ _04577_ _04587_ _04590_ _04591_ VDD VSS OR3_X1
X_21582_ _04588_ net43 _04592_ VDD VSS AND2_X1
X_21583_ _04584_ _04593_ VDD VSS CLKBUF_X3
X_21584_ _04593_ _04594_ VDD VSS CLKBUF_X3
X_21585_ _04592_ load_store_unit_i.rdata_q\[30\] _04594_ _04595_
+ VDD VSS AOI21_X1
X_21586_ _04570_ _04596_ VDD VSS CLKBUF_X3
X_21587_ _04596_ _04597_ VDD VSS BUF_X4
X_21588_ _04591_ _04595_ _04597_ _04598_ VDD VSS OAI21_X1
X_21589_ _04580_ _04583_ _04598_ _04599_ VDD VSS AOI21_X2
X_21590_ _04263_ _04600_ VDD VSS BUF_X8
X_21591_ _04564_ _04599_ _04600_ _04601_ VDD VSS OAI21_X4
X_21592_ _04601_ _04602_ VDD VSS BUF_X2
X_21593_ _00039_ _04603_ VDD VSS BUF_X4
X_21594_ _10394_ _11315_ _04603_ _04604_ VDD VSS NOR3_X4
X_21595_ _03453_ _01160_ _03455_ _03457_ _04605_ VDD VSS NAND4_X4
X_21596_ _03518_ _11428_ _04229_ _04231_ _04606_ VDD VSS NOR4_X2
X_21597_ _11428_ _03508_ _04229_ _04231_ _04607_ VDD VSS NOR4_X4
X_21598_ _03532_ _03536_ _03551_ _04608_ VDD VSS OAI21_X1
X_21599_ _03603_ _04608_ _04609_ VDD VSS OR2_X1
X_21600_ _04606_ _04607_ _04609_ _04610_ VDD VSS AOI21_X4
X_21601_ _04610_ _04611_ VDD VSS BUF_X4
X_21602_ _10900_ _10901_ _04605_ _04611_ _04612_ VDD VSS AOI211_X2
X_21603_ _04612_ _04613_ VDD VSS BUF_X8
X_21604_ _04604_ _04613_ _04614_ VDD VSS NAND2_X4
X_21605_ _04614_ _04615_ VDD VSS BUF_X4
X_21606_ _04602_ gen_regfile_ff.register_file_i.rf_reg\[950\]
+ _04615_ _01185_ VDD VSS MUX2_X1
X_21607_ _04580_ _04616_ VDD VSS INV_X1
X_21608_ _04611_ _04616_ _04617_ VDD VSS NAND2_X4
X_21609_ _04568_ load_store_unit_i.rdata_q\[31\] _04593_ _04618_
+ VDD VSS MUX2_X1
X_21610_ _04577_ _04619_ VDD VSS CLKBUF_X3
X_21611_ _04567_ _04618_ _04619_ _04620_ VDD VSS MUX2_X1
X_21612_ _04617_ _04620_ _04583_ _04621_ VDD VSS AOI21_X2
X_21613_ _10493_ _04622_ VDD VSS BUF_X4
X_21614_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]
+ _11430_ _11433_ _04623_ VDD VSS NOR3_X2
X_21615_ _04623_ _04624_ VDD VSS CLKBUF_X3
X_21616_ _04624_ _04625_ VDD VSS CLKBUF_X3
X_21617_ _04625_ _04626_ VDD VSS CLKBUF_X3
X_21618_ _15618_ _04627_ VDD VSS INV_X1
X_21619_ _15599_ _15600_ _14124_ _04628_ VDD VSS AOI21_X2
X_21620_ _15619_ _04629_ VDD VSS INV_X1
X_21621_ _04627_ _04628_ _04629_ _04630_ VDD VSS OAI21_X4
X_21622_ _04479_ _04630_ _04631_ VDD VSS XNOR2_X2
X_21623_ _04622_ _04626_ _04631_ _04632_ VDD VSS AOI21_X1
X_21624_ _15763_ _04633_ VDD VSS INV_X1
X_21625_ _15756_ _04634_ VDD VSS INV_X1
X_21626_ _15750_ _04635_ VDD VSS INV_X1
X_21627_ _15738_ _15744_ _04636_ VDD VSS NOR2_X1
X_21628_ _04635_ _04636_ _04637_ VDD VSS NAND2_X1
X_21629_ _15730_ _15726_ _04638_ VDD VSS NAND2_X2
X_21630_ _15716_ _04639_ VDD VSS INV_X1
X_21631_ _04638_ _04492_ _04639_ _04640_ VDD VSS AOI21_X4
X_21632_ _15700_ _15685_ _04641_ VDD VSS AND2_X1
X_21633_ _04474_ _04641_ _04642_ VDD VSS OR2_X4
X_21634_ _04472_ _04640_ _04642_ _04643_ VDD VSS NAND3_X2
X_21635_ _04643_ _04497_ _04644_ VDD VSS NAND2_X2
X_21636_ _15700_ _04472_ _04640_ _04645_ VDD VSS AND3_X4
X_21637_ _04486_ _04646_ VDD VSS INV_X2
X_21638_ _15657_ _15643_ _15658_ _04647_ VDD VSS AOI21_X1
X_21639_ _04646_ _04647_ _04648_ VDD VSS NOR2_X1
X_21640_ _15686_ _04648_ _15671_ _04649_ VDD VSS OAI21_X2
X_21641_ _15630_ _04630_ _15631_ _04650_ VDD VSS AOI21_X4
X_21642_ _04481_ _15658_ _04486_ _15686_ _04651_ VDD VSS NAND4_X1
X_21643_ _04649_ _04650_ _04651_ _04652_ VDD VSS OAI21_X2
X_21644_ _04637_ _04644_ _04645_ _04652_ _04653_ VDD VSS AOI211_X2
X_21645_ _04465_ _04468_ _04653_ _04654_ VDD VSS OR3_X4
X_21646_ _04633_ _04654_ _04634_ _04655_ VDD VSS AOI21_X4
X_21647_ _04655_ _15762_ _04656_ VDD VSS OR2_X4
X_21648_ _15768_ _04656_ _15769_ _04657_ VDD VSS AOI21_X4
X_21649_ _15775_ _04657_ _04658_ VDD VSS XOR2_X2
X_21650_ _04632_ _04626_ _04658_ _04659_ VDD VSS OAI21_X4
X_21651_ _11408_ _03815_ net305 _04660_ VDD VSS AOI21_X1
X_21652_ _04659_ _04660_ _04661_ VDD VSS AND2_X4
X_21653_ _03493_ _04662_ VDD VSS BUF_X8
X_21654_ _16023_ _04360_ _04363_ _16022_ _04663_ VDD VSS AOI22_X1
X_21655_ _04348_ _04349_ _04664_ VDD VSS NAND2_X4
X_21656_ _04664_ _04665_ VDD VSS CLKBUF_X3
X_21657_ _16026_ _04663_ _04665_ _04666_ VDD VSS MUX2_X1
X_21658_ alu_adder_result_ex\[23\] _04369_ _04667_ VDD VSS
+ NAND2_X1
X_21659_ _04390_ _04666_ _04667_ _04668_ VDD VSS AOI21_X1
X_21660_ _04662_ _04668_ _04669_ VDD VSS NOR2_X1
X_21661_ _04412_ _04292_ _04670_ VDD VSS NAND2_X2
X_21662_ _11497_ _04671_ VDD VSS INV_X1
X_21663_ _04671_ _04304_ _04265_ _04399_ _04672_ VDD VSS OR4_X1
X_21664_ _04409_ _04672_ _04673_ VDD VSS NOR2_X2
X_21665_ _04303_ _04305_ _04674_ VDD VSS NAND2_X2
X_21666_ _04397_ _04316_ _04295_ _04675_ VDD VSS NAND3_X1
X_21667_ _04674_ _04675_ _04399_ _04676_ VDD VSS OAI21_X2
X_21668_ _04673_ _04676_ _04431_ _04677_ VDD VSS AOI21_X2
X_21669_ _04670_ _04677_ _04678_ VDD VSS NOR2_X2
X_21670_ _04322_ _04317_ _04679_ VDD VSS OR2_X1
X_21671_ _15865_ _16060_ _04302_ _04680_ VDD VSS MUX2_X1
X_21672_ _04680_ _04343_ _04330_ _04681_ VDD VSS MUX2_X1
X_21673_ _04679_ _04681_ _15841_ _04682_ VDD VSS MUX2_X1
X_21674_ _04420_ _04405_ _04429_ _04683_ VDD VSS MUX2_X1
X_21675_ _04682_ _04683_ _04410_ _04684_ VDD VSS MUX2_X2
X_21676_ _04279_ _04280_ _04284_ _04290_ _04685_ VDD VSS AOI22_X4
X_21677_ _04678_ _04684_ _04685_ _04282_ _04307_ _04686_ VDD
+ VSS AOI221_X2
X_21678_ _04264_ _04265_ _04270_ _04274_ _04687_ VDD VSS OR4_X4
X_21679_ _04687_ _04688_ VDD VSS BUF_X4
X_21680_ _15852_ _16068_ _04313_ _04689_ VDD VSS MUX2_X1
X_21681_ _04689_ _04680_ _10739_ _04690_ VDD VSS MUX2_X1
X_21682_ _04344_ _04690_ _04406_ _04691_ VDD VSS MUX2_X2
X_21683_ _04406_ _04329_ _04692_ VDD VSS NAND2_X2
X_21684_ _04321_ _04334_ _10739_ _04693_ VDD VSS MUX2_X1
X_21685_ _04332_ _04429_ _04693_ _04694_ VDD VSS AOI21_X2
X_21686_ _04333_ _04691_ _04692_ _04694_ _04695_ VDD VSS AOI22_X4
X_21687_ _04412_ _04458_ _04695_ _04453_ _04696_ VDD VSS AOI211_X2
X_21688_ _04415_ _04426_ _10739_ _04697_ VDD VSS MUX2_X1
X_21689_ _04316_ _04295_ _04697_ _04698_ VDD VSS AND3_X1
X_21690_ _04698_ _04326_ _04429_ _04699_ VDD VSS AOI21_X2
X_21691_ _15957_ _15968_ _04313_ _04700_ VDD VSS MUX2_X1
X_21692_ _04423_ _04700_ _04397_ _04701_ VDD VSS MUX2_X1
X_21693_ _04316_ _04295_ _04701_ _04702_ VDD VSS NAND3_X1
X_21694_ _04422_ _04427_ _10738_ _04703_ VDD VSS MUX2_X1
X_21695_ _04703_ _04320_ _04318_ _04704_ VDD VSS OAI21_X1
X_21696_ _04702_ _04704_ _04705_ VDD VSS AND2_X1
X_21697_ _04699_ _04705_ _04431_ _04706_ VDD VSS MUX2_X1
X_21698_ _04410_ _04707_ VDD VSS CLKBUF_X3
X_21699_ _04438_ _04446_ _10739_ _04708_ VDD VSS MUX2_X1
X_21700_ _15957_ _15968_ _04433_ _04709_ VDD VSS MUX2_X1
X_21701_ _04437_ _04709_ _10738_ _04710_ VDD VSS MUX2_X1
X_21702_ _04708_ _04710_ _04429_ _04711_ VDD VSS MUX2_X1
X_21703_ _04406_ _04712_ VDD VSS CLKBUF_X3
X_21704_ _15905_ _16024_ _04434_ _04713_ VDD VSS MUX2_X1
X_21705_ _04444_ _04713_ _04397_ _04714_ VDD VSS MUX2_X1
X_21706_ _04712_ _04714_ _04715_ VDD VSS AND2_X1
X_21707_ _04442_ _04447_ _10738_ _04716_ VDD VSS MUX2_X1
X_21708_ _04716_ _04320_ _04318_ _04717_ VDD VSS OAI21_X1
X_21709_ _04431_ _04717_ _04718_ VDD VSS NAND2_X1
X_21710_ _04707_ _04711_ _04715_ _04718_ _04719_ VDD VSS OAI22_X1
X_21711_ _04453_ _04720_ VDD VSS CLKBUF_X3
X_21712_ _04706_ _04719_ _04720_ _04721_ VDD VSS MUX2_X1
X_21713_ _04412_ _04722_ VDD VSS CLKBUF_X3
X_21714_ _04722_ _04723_ VDD VSS BUF_X4
X_21715_ _04696_ _04721_ _04723_ _04724_ VDD VSS AOI21_X2
X_21716_ _04302_ _04725_ VDD VSS BUF_X4
X_21717_ _04669_ _04686_ _04688_ _04724_ _04725_ _04726_ VDD
+ VSS OAI221_X2
X_21718_ _03501_ _15873_ _03570_ _04727_ VDD VSS AND3_X1
X_21719_ _03594_ _03588_ _04727_ _04728_ VDD VSS NAND3_X2
X_21720_ _01180_ _04728_ _04729_ VDD VSS NOR2_X1
X_21721_ _03503_ _03530_ _03499_ _04730_ VDD VSS OAI21_X2
X_21722_ _03498_ _04730_ _04731_ VDD VSS NOR2_X4
X_21723_ _03588_ _03537_ _03499_ _04732_ VDD VSS OAI21_X2
X_21724_ _03575_ _04732_ _04733_ VDD VSS NOR2_X4
X_21725_ _04729_ _04731_ cs_registers_i.dscratch0_q\[23\]
+ cs_registers_i.mie_q\[7\] _04733_ _04734_ VDD VSS AOI221_X2
X_21726_ _03501_ _10920_ _03530_ _04735_ VDD VSS OAI21_X4
X_21727_ _03498_ _04735_ _04736_ VDD VSS NOR2_X4
X_21728_ _03553_ _03572_ _04737_ VDD VSS NAND2_X4
X_21729_ _11072_ _04737_ _04738_ VDD VSS NOR2_X4
X_21730_ cs_registers_i.csr_depc_o\[23\] _04736_ _04738_ cs_registers_i.mscratch_q\[23\]
+ _04739_ VDD VSS AOI22_X2
X_21731_ _03580_ _03581_ _04740_ VDD VSS NOR2_X1
X_21732_ _04740_ _03588_ _04741_ VDD VSS AND2_X2
X_21733_ _03575_ _04737_ _04742_ VDD VSS NOR2_X4
X_21734_ _03564_ _03594_ _03595_ _03597_ _04743_ VDD VSS AND4_X2
X_21735_ _04741_ _04742_ net139 net77 _04743_ _04744_ VDD
+ VSS AOI221_X2
X_21736_ _04734_ _04739_ _04744_ _04745_ VDD VSS NAND3_X2
X_21737_ _03530_ _03499_ _04746_ VDD VSS NOR2_X1
X_21738_ _03510_ _04746_ _04737_ _04747_ VDD VSS NOR3_X4
X_21739_ _04735_ _04737_ _04748_ VDD VSS NOR2_X2
X_21740_ _03498_ _04245_ _04749_ VDD VSS NOR2_X2
X_21741_ cs_registers_i.mtval_q\[23\] _04747_ _04748_ cs_registers_i.csr_mepc_o\[23\]
+ _04749_ cs_registers_i.dscratch1_q\[23\] _04750_ VDD VSS AOI222_X2
X_21742_ cs_registers_i.mcycle_counter_i.counter\[55\] _04751_
+ VDD VSS CLKBUF_X2
X_21743_ _04549_ _04752_ VDD VSS BUF_X4
X_21744_ _04552_ _04753_ VDD VSS BUF_X4
X_21745_ cs_registers_i.mhpmcounter\[2\]\[55\] _04754_ VDD
+ VSS BUF_X2
X_21746_ _04751_ _04752_ _04753_ _04754_ _04755_ VDD VSS AOI22_X2
X_21747_ _03551_ _03536_ _04756_ VDD VSS OR2_X2
X_21748_ _04750_ _04755_ _04756_ _04757_ VDD VSS OAI21_X1
X_21749_ cs_registers_i.mcycle_counter_i.counter\[23\] _04758_
+ VDD VSS BUF_X2
X_21750_ cs_registers_i.mhpmcounter\[2\]\[23\] _04759_ VDD
+ VSS BUF_X2
X_21751_ _04758_ _04752_ _04753_ _04759_ _04760_ VDD VSS AOI22_X2
X_21752_ _03532_ _04760_ _04761_ VDD VSS NOR2_X1
X_21753_ _04745_ _04757_ _04761_ _04762_ VDD VSS OR3_X4
X_21754_ _04726_ _04661_ _04762_ _04563_ _04763_ VDD VSS OAI22_X4
X_21755_ _04263_ _04764_ VDD VSS BUF_X8
X_21756_ _04621_ _04764_ _04763_ _04765_ VDD VSS AOI21_X4
X_21757_ _04765_ _04766_ VDD VSS BUF_X8
X_21758_ _04766_ gen_regfile_ff.register_file_i.rf_reg\[951\]
+ _04615_ _01186_ VDD VSS MUX2_X1
X_21759_ net31 net39 _04584_ _04767_ VDD VSS MUX2_X1
X_21760_ net47 net53 _04584_ _04768_ VDD VSS MUX2_X1
X_21761_ _04767_ _04768_ _04577_ _04769_ VDD VSS MUX2_X1
X_21762_ _04580_ _04581_ _04769_ _04770_ VDD VSS AOI21_X2
X_21763_ net248 _04771_ VDD VSS BUF_X4
X_21764_ _03502_ _04509_ _03540_ _10922_ _04772_ VDD VSS AOI211_X2
X_21765_ _04772_ _04773_ VDD VSS BUF_X4
X_21766_ cs_registers_i.dscratch0_q\[27\] _04771_ _04773_
+ cs_registers_i.csr_depc_o\[27\] _04774_ VDD VSS AOI22_X1
X_21767_ _04529_ _04775_ VDD VSS BUF_X4
X_21768_ cs_registers_i.mie_q\[11\] _04514_ _04775_ cs_registers_i.dscratch1_q\[27\]
+ _04776_ VDD VSS AOI22_X1
X_21769_ net129 _04517_ _04520_ cs_registers_i.mtval_q\[27\]
+ cs_registers_i.mscratch_q\[27\] _04523_ _04777_ VDD VSS AOI222_X2
X_21770_ _04533_ _04536_ _00007_ _04778_ VDD VSS OAI21_X1
X_21771_ _04778_ _04526_ net81 cs_registers_i.csr_mepc_o\[27\]
+ _04543_ _04779_ VDD VSS AOI221_X2
X_21772_ _04774_ _04776_ _04777_ _04779_ _04780_ VDD VSS AND4_X1
X_21773_ cs_registers_i.mhpmcounter\[2\]\[59\] _04781_ VDD
+ VSS BUF_X2
X_21774_ cs_registers_i.mcycle_counter_i.counter\[59\] _04550_
+ _04553_ _04781_ _04782_ VDD VSS AOI22_X4
X_21775_ _04559_ _04783_ VDD VSS BUF_X4
X_21776_ _04752_ _04784_ VDD VSS BUF_X4
X_21777_ _04753_ _04785_ VDD VSS BUF_X4
X_21778_ cs_registers_i.mcycle_counter_i.counter\[27\] _04784_
+ _04785_ cs_registers_i.mhpmcounter\[2\]\[27\] _04786_ VDD
+ VSS AOI22_X2
X_21779_ _04780_ _04782_ _04557_ _04783_ _04786_ _04787_ VDD
+ VSS OAI221_X2
X_21780_ _04393_ _04787_ _04788_ VDD VSS NOR2_X1
X_21781_ _04770_ _04788_ _04263_ _04789_ VDD VSS MUX2_X2
X_21782_ _11408_ _03824_ net305 _04790_ VDD VSS AOI21_X1
X_21783_ _04502_ _04791_ VDD VSS BUF_X4
X_21784_ _15793_ _04792_ VDD VSS INV_X1
X_21785_ _15787_ _04793_ VDD VSS BUF_X1
X_21786_ _15786_ _15780_ _04793_ _04794_ VDD VSS AOI21_X1
X_21787_ _04792_ _04794_ _04795_ VDD VSS OR2_X1
X_21788_ _15781_ _04793_ _15793_ _04796_ VDD VSS NAND3_X2
X_21789_ _15774_ _04797_ VDD VSS INV_X1
X_21790_ _15775_ _15768_ _15769_ _04798_ VDD VSS OAI21_X1
X_21791_ _04797_ _04798_ _04799_ VDD VSS NAND2_X1
X_21792_ _15762_ _15768_ _15774_ _04800_ VDD VSS OR3_X1
X_21793_ _04799_ _04800_ _04655_ _04801_ VDD VSS OAI21_X4
X_21794_ _04795_ _04796_ _04801_ _04802_ VDD VSS OAI21_X4
X_21795_ _15799_ _15792_ _04802_ _04803_ VDD VSS OAI21_X2
X_21796_ _15799_ _04802_ _15792_ _04804_ VDD VSS OR3_X4
X_21797_ _04791_ _04803_ _04804_ _04805_ VDD VSS NAND3_X4
X_21798_ _04481_ _04806_ VDD VSS INV_X1
X_21799_ _15658_ _04807_ VDD VSS INV_X1
X_21800_ _04806_ _04807_ _04646_ _04650_ _04808_ VDD VSS NOR4_X2
X_21801_ _15671_ _04648_ _04808_ _04809_ VDD VSS NOR3_X2
X_21802_ _04484_ _04809_ _04810_ VDD VSS XNOR2_X2
X_21803_ _04805_ _04810_ _04791_ _04811_ VDD VSS OAI21_X4
X_21804_ _04790_ _04811_ net305 _04812_ VDD VSS OAI21_X4
X_21805_ _04812_ _03439_ _04232_ _04563_ _04813_ VDD VSS AND4_X4
X_21806_ _11406_ _04388_ _04814_ VDD VSS AND2_X1
X_21807_ _04814_ _04815_ VDD VSS BUF_X4
X_21808_ _04306_ _04685_ _04816_ VDD VSS OR2_X1
X_21809_ _04275_ _04816_ _04817_ VDD VSS AND2_X1
X_21810_ _15841_ _04297_ _04296_ _04818_ VDD VSS OAI21_X1
X_21811_ _10739_ _04297_ _04296_ _04819_ VDD VSS OAI21_X1
X_21812_ _04409_ _04676_ _04818_ _04681_ _04819_ _04679_ _04820_
+ VDD VSS OAI222_X2
X_21813_ _04685_ _04820_ _04821_ VDD VSS NAND2_X1
X_21814_ _04817_ _04821_ _04822_ VDD VSS NAND2_X1
X_21815_ _04353_ _04360_ _16055_ _04363_ _16054_ _04823_ VDD
+ VSS AOI221_X1
X_21816_ _04823_ _04370_ _16058_ _04824_ VDD VSS AOI21_X1
X_21817_ _04368_ _04825_ VDD VSS CLKBUF_X3
X_21818_ _04824_ _04825_ alu_adder_result_ex\[27\] _04826_
+ VDD VSS AOI21_X1
X_21819_ _04822_ _04826_ _04827_ VDD VSS NAND2_X1
X_21820_ _04408_ _04330_ _04693_ _04828_ VDD VSS AOI21_X2
X_21821_ _04292_ _04692_ _04828_ _04699_ _04409_ _04829_ VDD
+ VSS AOI221_X2
X_21822_ _04673_ _04691_ _04410_ _04830_ VDD VSS AOI21_X4
X_21823_ _04829_ _04830_ _04292_ _04831_ VDD VSS AOI21_X2
X_21824_ _04332_ _04702_ _04704_ _04832_ VDD VSS NAND3_X1
X_21825_ _04832_ _04711_ _04333_ _04833_ VDD VSS OAI21_X1
X_21826_ _04332_ _04717_ _04834_ VDD VSS NAND2_X1
X_21827_ _15897_ _16029_ _04434_ _04835_ VDD VSS MUX2_X1
X_21828_ _15889_ _16040_ _04434_ _04836_ VDD VSS MUX2_X1
X_21829_ _04835_ _04836_ _10739_ _04837_ VDD VSS MUX2_X1
X_21830_ _15881_ _16045_ _04434_ _04838_ VDD VSS MUX2_X1
X_21831_ _04397_ _04838_ _04839_ VDD VSS NOR2_X1
X_21832_ _04434_ _04840_ VDD VSS CLKBUF_X3
X_21833_ _15868_ _16052_ _04840_ _04841_ VDD VSS MUX2_X1
X_21834_ _04839_ _04841_ _04397_ _04842_ VDD VSS AOI21_X1
X_21835_ _04837_ _04842_ _04406_ _04843_ VDD VSS MUX2_X1
X_21836_ _04715_ _04834_ _04843_ _04333_ _04844_ VDD VSS OAI22_X1
X_21837_ _04833_ _04844_ _04452_ _04845_ VDD VSS MUX2_X1
X_21838_ _04831_ _04845_ _04412_ _04846_ VDD VSS MUX2_X1
X_21839_ _04457_ _04846_ _04847_ VDD VSS AND2_X1
X_21840_ _04815_ _04827_ _04847_ _04848_ VDD VSS OAI21_X2
X_21841_ _04789_ _04848_ _04813_ _04849_ VDD VSS AOI21_X4
X_21842_ _04849_ _04850_ VDD VSS BUF_X4
X_21843_ _10394_ _10902_ _04851_ VDD VSS NAND2_X2
X_21844_ _10903_ _04851_ _04852_ VDD VSS NOR2_X4
X_21845_ _10900_ _10901_ _04853_ VDD VSS NAND2_X1
X_21846_ _04853_ _04605_ _04611_ _04854_ VDD VSS AOI21_X4
X_21847_ _04852_ _04854_ _04855_ VDD VSS NAND2_X4
X_21848_ _04850_ gen_regfile_ff.register_file_i.rf_reg\[123\]
+ _04855_ _01187_ VDD VSS MUX2_X1
X_21849_ _04614_ _04856_ VDD VSS BUF_X4
X_21850_ gen_regfile_ff.register_file_i.rf_reg\[952\] _04856_
+ _04857_ VDD VSS NAND2_X1
X_21851_ _04573_ _04565_ _04858_ VDD VSS OR2_X2
X_21852_ _04858_ _04859_ VDD VSS CLKBUF_X3
X_21853_ net58 net36 _04585_ _04860_ VDD VSS MUX2_X1
X_21854_ _04597_ _04860_ _04861_ VDD VSS NAND2_X1
X_21855_ net44 net29 _04585_ _04862_ VDD VSS MUX2_X1
X_21856_ _04619_ _04862_ _04863_ VDD VSS NAND2_X1
X_21857_ _04859_ _04861_ _04863_ _04864_ VDD VSS AOI21_X2
X_21858_ _04351_ _04358_ _16031_ _04362_ _16034_ _04865_ VDD
+ VSS AOI221_X1
X_21859_ _04865_ _04353_ _16030_ _04866_ VDD VSS AOI21_X1
X_21860_ _04685_ _04695_ _04867_ VDD VSS NAND2_X1
X_21861_ _04866_ _04867_ _04817_ _04369_ alu_adder_result_ex\[24\]
+ _04868_ VDD VSS AOI221_X1
X_21862_ _04391_ _04868_ _04869_ VDD VSS NOR2_X1
X_21863_ _04439_ _04448_ _04712_ _04870_ VDD VSS MUX2_X1
X_21864_ _04442_ _04444_ _15835_ _04871_ VDD VSS MUX2_X1
X_21865_ _04713_ _04835_ _15835_ _04872_ VDD VSS MUX2_X1
X_21866_ _04871_ _04872_ _04712_ _04873_ VDD VSS MUX2_X1
X_21867_ _04870_ _04873_ _04707_ _04874_ VDD VSS MUX2_X1
X_21868_ _04293_ _04874_ _04722_ _04875_ VDD VSS AOI21_X1
X_21869_ _04875_ _04684_ _04722_ _04876_ VDD VSS OAI21_X1
X_21870_ _04720_ _04677_ _04282_ _04877_ VDD VSS AOI21_X1
X_21871_ _04325_ _04415_ _10739_ _04878_ VDD VSS MUX2_X1
X_21872_ _04878_ _04428_ _04406_ _04879_ VDD VSS MUX2_X1
X_21873_ _04431_ _04879_ _04880_ VDD VSS OR2_X1
X_21874_ _04424_ _04320_ _04318_ _04881_ VDD VSS OAI21_X1
X_21875_ _04881_ _04436_ _04429_ _04882_ VDD VSS OAI21_X1
X_21876_ _04880_ _04882_ _04333_ _04883_ VDD VSS OAI21_X1
X_21877_ _04877_ _04883_ _04282_ _04884_ VDD VSS OAI21_X2
X_21878_ _04725_ _04876_ _04884_ _04885_ VDD VSS AOI21_X1
X_21879_ _04481_ _04480_ _04886_ VDD VSS XNOR2_X2
X_21880_ _15781_ _04887_ VDD VSS INV_X1
X_21881_ _04799_ _04499_ _04800_ _04888_ VDD VSS OAI21_X4
X_21882_ _04887_ _04888_ _04889_ VDD VSS XNOR2_X1
X_21883_ _04886_ _04889_ _04463_ _04890_ VDD VSS MUX2_X1
X_21884_ _03817_ _04890_ _12102_ _04891_ VDD VSS MUX2_X1
X_21885_ _11408_ _04891_ _04892_ VDD VSS NOR2_X2
X_21886_ cs_registers_i.dscratch0_q\[24\] _04771_ _04773_
+ cs_registers_i.csr_depc_o\[24\] _04893_ VDD VSS AOI22_X1
X_21887_ cs_registers_i.mie_q\[8\] _04514_ _04775_ cs_registers_i.dscratch1_q\[24\]
+ _04894_ VDD VSS AOI22_X1
X_21888_ net140 _04517_ _04520_ cs_registers_i.mtval_q\[24\]
+ cs_registers_i.mscratch_q\[24\] _04523_ _04895_ VDD VSS AOI222_X2
X_21889_ _04533_ _04536_ _01181_ _04896_ VDD VSS OAI21_X1
X_21890_ _04896_ _04526_ net78 cs_registers_i.csr_mepc_o\[24\]
+ _04543_ _04897_ VDD VSS AOI221_X2
X_21891_ _04893_ _04894_ _04895_ _04897_ _04898_ VDD VSS AND4_X1
X_21892_ cs_registers_i.mhpmcounter\[2\]\[56\] _04899_ VDD
+ VSS BUF_X2
X_21893_ cs_registers_i.mcycle_counter_i.counter\[56\] _04550_
+ _04553_ _04899_ _04900_ VDD VSS AOI22_X4
X_21894_ cs_registers_i.mhpmcounter\[2\]\[24\] _04901_ VDD
+ VSS BUF_X2
X_21895_ cs_registers_i.mcycle_counter_i.counter\[24\] _04784_
+ _04785_ _04901_ _04902_ VDD VSS AOI22_X2
X_21896_ _04898_ _04900_ _04557_ _04783_ _04902_ _04903_ VDD
+ VSS OAI221_X2
X_21897_ _04869_ _04885_ _04892_ _04903_ _04904_ VDD VSS OR4_X4
X_21898_ _03439_ _04232_ _04261_ _04905_ VDD VSS NAND3_X4
X_21899_ _04905_ _04906_ VDD VSS BUF_X8
X_21900_ _04617_ _04864_ _04904_ _04906_ _04907_ VDD VSS OAI22_X4
X_21901_ _04907_ _04908_ VDD VSS CLKBUF_X3
X_21902_ _04614_ _04909_ VDD VSS BUF_X4
X_21903_ _04857_ _04908_ _04909_ _01188_ VDD VSS OAI21_X1
X_21904_ gen_regfile_ff.register_file_i.rf_reg\[953\] _04856_
+ _04910_ VDD VSS NAND2_X1
X_21905_ _04584_ _04911_ VDD VSS CLKBUF_X3
X_21906_ net59 net37 _04911_ _04912_ VDD VSS MUX2_X1
X_21907_ net45 net40 _04911_ _04913_ VDD VSS MUX2_X1
X_21908_ _04912_ _04913_ _04619_ _04914_ VDD VSS MUX2_X1
X_21909_ _04580_ _04583_ _04914_ _04915_ VDD VSS AOI21_X1
X_21910_ _04316_ _04295_ _04703_ _04916_ VDD VSS NAND3_X1
X_21911_ _04697_ _04320_ _04318_ _04917_ VDD VSS OAI21_X1
X_21912_ _04916_ _04917_ _04918_ VDD VSS NAND2_X1
X_21913_ _04316_ _04294_ _04710_ _04919_ VDD VSS AND3_X1
X_21914_ _10738_ _04423_ _04920_ VDD VSS NAND2_X1
X_21915_ _10739_ _04700_ _04921_ VDD VSS NAND2_X1
X_21916_ _04316_ _04295_ _04920_ _04921_ _04922_ VDD VSS AOI22_X1
X_21917_ _04919_ _04922_ _04923_ VDD VSS OR2_X1
X_21918_ _04918_ _04923_ _04707_ _04924_ VDD VSS MUX2_X1
X_21919_ _04723_ _04924_ _04925_ VDD VSS NAND2_X1
X_21920_ _04672_ _04712_ _04707_ _04926_ VDD VSS AOI21_X1
X_21921_ _10738_ _04341_ _04313_ _16080_ _04927_ VDD VSS AOI211_X2
X_21922_ _04927_ _04303_ _10738_ _04928_ VDD VSS AOI21_X2
X_21923_ _04298_ _04928_ _04929_ VDD VSS NOR2_X1
X_21924_ _04722_ _04926_ _04929_ _04930_ VDD VSS NOR3_X1
X_21925_ _04720_ _04930_ _04931_ VDD VSS NOR2_X2
X_21926_ _04722_ _04340_ _04932_ VDD VSS OR2_X1
X_21927_ _04714_ _04837_ _04712_ _04933_ VDD VSS MUX2_X1
X_21928_ _04333_ _04933_ _04934_ VDD VSS OR2_X1
X_21929_ _04316_ _04295_ _04716_ _04935_ VDD VSS AND3_X1
X_21930_ _04935_ _04708_ _04330_ _04936_ VDD VSS AOI21_X1
X_21931_ _04282_ _04333_ _04936_ _04937_ VDD VSS AOI21_X1
X_21932_ _04293_ _04934_ _04937_ _04938_ VDD VSS AOI21_X2
X_21933_ _04925_ _04931_ _04932_ _04938_ _04939_ VDD VSS AOI22_X4
X_21934_ _04342_ _04939_ _04940_ VDD VSS NOR2_X2
X_21935_ _04806_ _04650_ _04941_ VDD VSS NOR2_X1
X_21936_ _15643_ _04941_ _04942_ VDD VSS NOR2_X1
X_21937_ _04807_ _04942_ _04943_ VDD VSS XNOR2_X2
X_21938_ _04502_ _04943_ _04944_ VDD VSS NOR2_X1
X_21939_ _04622_ _04944_ _04945_ VDD VSS NOR2_X1
X_21940_ _15780_ _04946_ VDD VSS INV_X1
X_21941_ _04946_ _04801_ _04887_ _04947_ VDD VSS OAI21_X4
X_21942_ _04947_ _04793_ _04948_ VDD VSS XNOR2_X2
X_21943_ _04945_ _04626_ _04948_ _04949_ VDD VSS OAI21_X4
X_21944_ _11407_ _03819_ net306 _04950_ VDD VSS AOI21_X1
X_21945_ _04662_ _04950_ _04949_ _04951_ VDD VSS AOI21_X4
X_21946_ _04685_ _04411_ _04952_ VDD VSS AND2_X1
X_21947_ _04276_ _04816_ _04953_ VDD VSS NAND2_X1
X_21948_ _16039_ _04360_ _04363_ _16038_ _04954_ VDD VSS AOI22_X1
X_21949_ _04370_ _04954_ _04955_ VDD VSS NOR2_X1
X_21950_ _16042_ _04956_ VDD VSS INV_X1
X_21951_ _04955_ _04369_ alu_adder_result_ex\[25\] _04956_
+ _04370_ _04957_ VDD VSS AOI221_X2
X_21952_ _04951_ _04952_ _04953_ _04391_ _04957_ _04958_ VDD
+ VSS OAI221_X2
X_21953_ _04550_ _04959_ VDD VSS BUF_X8
X_21954_ _04553_ _04960_ VDD VSS BUF_X4
X_21955_ cs_registers_i.mcycle_counter_i.counter\[57\] _04959_
+ _04960_ cs_registers_i.mhpmcounter\[2\]\[57\] _04961_ VDD
+ VSS AOI22_X4
X_21956_ _04558_ _04961_ _04962_ VDD VSS NOR2_X2
X_21957_ _04752_ _04963_ VDD VSS BUF_X4
X_21958_ _04753_ _04964_ VDD VSS BUF_X4
X_21959_ cs_registers_i.mcycle_counter_i.counter\[25\] _04963_
+ _04964_ cs_registers_i.mhpmcounter\[2\]\[25\] _04965_ VDD
+ VSS AOI22_X2
X_21960_ _04783_ _04965_ _04966_ VDD VSS NOR2_X2
X_21961_ net141 _04518_ _04521_ cs_registers_i.mtval_q\[25\]
+ _04544_ cs_registers_i.csr_mepc_o\[25\] _04967_ VDD VSS AOI222_X2
X_21962_ _04773_ _04968_ VDD VSS BUF_X4
X_21963_ cs_registers_i.dscratch0_q\[25\] _04511_ _04968_
+ cs_registers_i.csr_depc_o\[25\] _04969_ VDD VSS AOI22_X2
X_21964_ cs_registers_i.mie_q\[9\] _04515_ _04530_ cs_registers_i.dscratch1_q\[25\]
+ _04970_ VDD VSS AOI22_X4
X_21965_ _04534_ _04537_ _01182_ _04971_ VDD VSS OAI21_X1
X_21966_ _04523_ _04972_ VDD VSS BUF_X4
X_21967_ _04971_ _04527_ net79 cs_registers_i.mscratch_q\[25\]
+ _04972_ _04973_ VDD VSS AOI221_X2
X_21968_ _04967_ _04969_ _04970_ _04973_ _04974_ VDD VSS NAND4_X4
X_21969_ _04962_ _04966_ _04974_ _04975_ VDD VSS OR3_X2
X_21970_ _04958_ _04940_ _04975_ _04563_ _04976_ VDD VSS OAI22_X4
X_21971_ _04915_ _04976_ _04600_ _04977_ VDD VSS MUX2_X2
X_21972_ _04977_ _04978_ VDD VSS BUF_X4
X_21973_ _04910_ _04978_ _04909_ _01189_ VDD VSS OAI21_X1
X_21974_ net30 net38 _04911_ _04979_ VDD VSS MUX2_X1
X_21975_ net46 net50 _04911_ _04980_ VDD VSS MUX2_X1
X_21976_ _04979_ _04980_ _04619_ _04981_ VDD VSS MUX2_X1
X_21977_ _04617_ _04981_ _04583_ _04982_ VDD VSS AOI21_X2
X_21978_ _04362_ _04983_ VDD VSS CLKBUF_X3
X_21979_ _04352_ _04359_ _16047_ _04983_ _16050_ _04984_ VDD
+ VSS AOI221_X1
X_21980_ _04984_ _04370_ _16046_ _04985_ VDD VSS AOI21_X1
X_21981_ _04985_ _04825_ net398 _04986_ VDD VSS AOI21_X1
X_21982_ _04412_ _04452_ _04987_ VDD VSS NAND2_X2
X_21983_ _04322_ _04317_ _04818_ _04819_ _04335_ _04337_ _04988_
+ VDD VSS OAI33_X1
X_21984_ _04928_ _04674_ _04330_ _04989_ VDD VSS MUX2_X1
X_21985_ _04988_ _04989_ _04332_ _04990_ VDD VSS AOI21_X2
X_21986_ _04987_ _04990_ _04991_ VDD VSS NOR2_X1
X_21987_ _04986_ _04991_ _04953_ _04992_ VDD VSS OAI21_X1
X_21988_ _04815_ _04992_ _04993_ VDD VSS AND2_X1
X_21989_ _15657_ _04994_ VDD VSS INV_X1
X_21990_ _15643_ _04480_ _04481_ _04995_ VDD VSS AOI21_X1
X_21991_ _04994_ _04995_ _04807_ _04996_ VDD VSS OAI21_X1
X_21992_ _04486_ _04996_ _04997_ VDD VSS XNOR2_X2
X_21993_ _04502_ _04997_ _04998_ VDD VSS NOR2_X1
X_21994_ _04946_ _04888_ _04887_ _04999_ VDD VSS OAI21_X1
X_21995_ _15786_ _04999_ _04793_ _05000_ VDD VSS AOI21_X1
X_21996_ _15793_ _05000_ _05001_ VDD VSS XNOR2_X1
X_21997_ _04998_ _04502_ _05001_ _05002_ VDD VSS AOI21_X2
X_21998_ _01000_ _05002_ _12103_ _05003_ VDD VSS MUX2_X1
X_21999_ _11408_ _05003_ _05004_ VDD VSS NOR2_X2
X_22000_ _15841_ _04394_ _04395_ _05005_ VDD VSS AND3_X1
X_22001_ _04409_ _04398_ _04400_ _05006_ VDD VSS NAND3_X2
X_22002_ _04409_ _04674_ _05005_ _05006_ _05007_ VDD VSS OAI22_X4
X_22003_ _04421_ _04407_ _04332_ _05008_ VDD VSS MUX2_X1
X_22004_ _05007_ _05008_ _04452_ _05009_ VDD VSS MUX2_X2
X_22005_ _04430_ _04441_ _04410_ _05010_ VDD VSS MUX2_X1
X_22006_ _15901_ _16020_ _04434_ _05011_ VDD VSS MUX2_X1
X_22007_ _15893_ _16033_ _04840_ _05012_ VDD VSS MUX2_X1
X_22008_ _05011_ _05012_ _04397_ _05013_ VDD VSS MUX2_X1
X_22009_ _15841_ _04838_ _05014_ VDD VSS OR2_X1
X_22010_ _05014_ _04836_ _04397_ _05015_ VDD VSS OAI21_X1
X_22011_ _05013_ _05015_ _04712_ _05016_ VDD VSS MUX2_X1
X_22012_ _04450_ _05016_ _04410_ _05017_ VDD VSS MUX2_X1
X_22013_ _05010_ _05017_ _04453_ _05018_ VDD VSS MUX2_X1
X_22014_ _05009_ _05018_ _04722_ _05019_ VDD VSS MUX2_X1
X_22015_ _04457_ _05019_ _05020_ VDD VSS AND2_X1
X_22016_ cs_registers_i.dscratch0_q\[26\] _04511_ _04515_
+ cs_registers_i.mie_q\[10\] _05021_ VDD VSS AOI22_X1
X_22017_ _04520_ _05022_ VDD VSS BUF_X4
X_22018_ net128 _04518_ _05022_ cs_registers_i.mtval_q\[26\]
+ cs_registers_i.mscratch_q\[26\] _04972_ _05023_ VDD VSS AOI222_X2
X_22019_ net80 _04528_ _04530_ cs_registers_i.dscratch1_q\[26\]
+ _05024_ VDD VSS AOI22_X1
X_22020_ cs_registers_i.csr_depc_o\[26\] _05025_ VDD VSS INV_X1
X_22021_ _04534_ _04537_ _01183_ _04539_ _05025_ _05026_ VDD
+ VSS OAI221_X2
X_22022_ _05026_ _04544_ cs_registers_i.csr_mepc_o\[26\] _05027_
+ VDD VSS AOI21_X2
X_22023_ _05021_ _05023_ _05024_ _05027_ _05028_ VDD VSS AND4_X1
X_22024_ cs_registers_i.mhpmcounter\[2\]\[58\] _05029_ VDD
+ VSS BUF_X2
X_22025_ cs_registers_i.mcycle_counter_i.counter\[58\] _04959_
+ _04960_ _05029_ _05030_ VDD VSS AOI22_X4
X_22026_ _04557_ _05031_ VDD VSS BUF_X4
X_22027_ cs_registers_i.mcycle_counter_i.counter\[26\] _05032_
+ VDD VSS BUF_X2
X_22028_ _05032_ _04551_ _04554_ cs_registers_i.mhpmcounter\[2\]\[26\]
+ _05033_ VDD VSS AOI22_X2
X_22029_ _05028_ _05030_ _05031_ _04560_ _05033_ _05034_ VDD
+ VSS OAI221_X2
X_22030_ _04993_ _05004_ _05020_ _05034_ _05035_ VDD VSS NOR4_X4
X_22031_ _04982_ _04764_ _05035_ _05036_ VDD VSS AOI21_X4
X_22032_ _05036_ _05037_ VDD VSS BUF_X4
X_22033_ _05037_ gen_regfile_ff.register_file_i.rf_reg\[954\]
+ _04615_ _01190_ VDD VSS MUX2_X1
X_22034_ _04850_ gen_regfile_ff.register_file_i.rf_reg\[955\]
+ _04615_ _01191_ VDD VSS MUX2_X1
X_22035_ net32 net41 _04593_ _05038_ VDD VSS MUX2_X1
X_22036_ net48 net54 _04593_ _05039_ VDD VSS MUX2_X1
X_22037_ _05038_ _05039_ _04619_ _05040_ VDD VSS MUX2_X1
X_22038_ _04617_ _05040_ _04583_ _05041_ VDD VSS AOI21_X2
X_22039_ _04707_ _04873_ _05042_ VDD VSS NOR2_X1
X_22040_ _15865_ _16060_ _04840_ _05043_ VDD VSS MUX2_X1
X_22041_ _04841_ _05043_ _15835_ _05044_ VDD VSS MUX2_X1
X_22042_ _04429_ _05044_ _05045_ VDD VSS NOR2_X1
X_22043_ _04712_ _05015_ _05046_ VDD VSS NOR2_X1
X_22044_ _04333_ _05045_ _05046_ _05047_ VDD VSS NOR3_X1
X_22045_ _04987_ _05042_ _05047_ _05048_ VDD VSS NOR3_X2
X_22046_ _04882_ _04870_ _04410_ _05049_ VDD VSS MUX2_X1
X_22047_ _04670_ _05050_ VDD VSS INV_X1
X_22048_ _04324_ _04328_ _15841_ _05051_ VDD VSS MUX2_X1
X_22049_ _04334_ _04327_ _10739_ _05052_ VDD VSS MUX2_X1
X_22050_ _05051_ _05052_ _04330_ _05053_ VDD VSS MUX2_X1
X_22051_ _05053_ _04879_ _04409_ _05054_ VDD VSS MUX2_X1
X_22052_ _04820_ _05054_ _04452_ _05055_ VDD VSS MUX2_X2
X_22053_ _05048_ _05049_ _05050_ _04282_ _05055_ _05056_ VDD
+ VSS AOI221_X2
X_22054_ _04457_ _05056_ _05057_ VDD VSS NAND2_X1
X_22055_ _04953_ _04830_ _04685_ _05058_ VDD VSS AOI21_X1
X_22056_ _04352_ _04359_ _16063_ _04983_ _16062_ _05059_ VDD
+ VSS AOI221_X1
X_22057_ _05059_ _04370_ _16066_ _05060_ VDD VSS AOI21_X1
X_22058_ _05060_ _04825_ alu_adder_result_ex\[28\] _05061_
+ VDD VSS AOI21_X1
X_22059_ _05061_ _05062_ VDD VSS INV_X1
X_22060_ _04815_ _05058_ _05062_ _05063_ VDD VSS OAI21_X1
X_22061_ cs_registers_i.mcycle_counter_i.counter\[60\] _04963_
+ _04964_ cs_registers_i.mhpmcounter\[2\]\[60\] _05064_ VDD
+ VSS AOI22_X2
X_22062_ _05031_ _05064_ _05065_ VDD VSS NOR2_X1
X_22063_ cs_registers_i.mcycle_counter_i.counter\[28\] _05066_
+ VDD VSS CLKBUF_X3
X_22064_ cs_registers_i.mhpmcounter\[2\]\[28\] _05067_ VDD
+ VSS BUF_X2
X_22065_ _05066_ _04784_ _04785_ _05067_ _05068_ VDD VSS AOI22_X2
X_22066_ _04783_ _05068_ _05069_ VDD VSS NOR2_X1
X_22067_ cs_registers_i.dscratch0_q\[28\] _04511_ _04968_
+ cs_registers_i.csr_depc_o\[28\] _05070_ VDD VSS AOI22_X2
X_22068_ cs_registers_i.mie_q\[12\] _04515_ _04530_ cs_registers_i.dscratch1_q\[28\]
+ _05071_ VDD VSS AOI22_X2
X_22069_ net130 _04518_ _05022_ cs_registers_i.mtval_q\[28\]
+ cs_registers_i.mscratch_q\[28\] _04972_ _05072_ VDD VSS AOI222_X2
X_22070_ _04533_ _04536_ _00008_ _05073_ VDD VSS OAI21_X1
X_22071_ _04543_ _05074_ VDD VSS BUF_X4
X_22072_ _05073_ _04527_ net82 cs_registers_i.csr_mepc_o\[28\]
+ _05074_ _05075_ VDD VSS AOI221_X2
X_22073_ _05070_ _05071_ _05072_ _05075_ _05076_ VDD VSS NAND4_X4
X_22074_ _05065_ _05069_ _05076_ _05077_ VDD VSS NOR3_X4
X_22075_ net305 _03827_ _05078_ VDD VSS NAND2_X1
X_22076_ _04625_ _05079_ VDD VSS CLKBUF_X3
X_22077_ _15685_ _04488_ _05080_ VDD VSS NOR2_X1
X_22078_ _04482_ _05080_ _05081_ VDD VSS NOR2_X1
X_22079_ net338 _05081_ _05082_ VDD VSS XOR2_X2
X_22080_ _05079_ _05082_ _05083_ VDD VSS NAND2_X1
X_22081_ _15792_ _05084_ VDD VSS INV_X1
X_22082_ _05084_ _04795_ _05085_ VDD VSS AND2_X1
X_22083_ _05085_ _04888_ _04796_ _05086_ VDD VSS OAI21_X1
X_22084_ _15798_ _05086_ _15799_ _05087_ VDD VSS AOI21_X1
X_22085_ _15805_ _05087_ _05088_ VDD VSS XOR2_X1
X_22086_ _05083_ _05088_ _05079_ _05089_ VDD VSS OAI21_X1
X_22087_ _05078_ _05089_ _04622_ _05090_ VDD VSS OAI21_X1
X_22088_ _11408_ _05090_ _05091_ VDD VSS OR2_X1
X_22089_ _05057_ _05063_ _05077_ _05091_ _05092_ VDD VSS AND4_X2
X_22090_ _05041_ _05092_ _04764_ _05093_ VDD VSS AOI21_X4
X_22091_ _05093_ _05094_ VDD VSS BUF_X2
X_22092_ _05094_ gen_regfile_ff.register_file_i.rf_reg\[956\]
+ _04615_ _01192_ VDD VSS MUX2_X1
X_22093_ gen_regfile_ff.register_file_i.rf_reg\[957\] _04856_
+ _05095_ VDD VSS NAND2_X1
X_22094_ net33 net42 _04585_ _05096_ VDD VSS MUX2_X1
X_22095_ net49 net55 _04585_ _05097_ VDD VSS MUX2_X1
X_22096_ _05096_ _05097_ _04619_ _05098_ VDD VSS MUX2_X1
X_22097_ _04617_ _05098_ _04583_ _05099_ VDD VSS AOI21_X1
X_22098_ net305 _01093_ _05100_ VDD VSS NAND2_X1
X_22099_ _15699_ _05101_ VDD VSS INV_X1
X_22100_ _15700_ _15685_ _04652_ _05102_ VDD VSS OAI21_X2
X_22101_ _05102_ _05101_ _05103_ VDD VSS NAND2_X2
X_22102_ _04491_ _05103_ _05104_ VDD VSS XOR2_X2
X_22103_ _15799_ _15798_ _15804_ _05105_ VDD VSS NOR3_X1
X_22104_ _15805_ _15804_ _05106_ VDD VSS NOR2_X1
X_22105_ _05105_ _05106_ _05107_ VDD VSS NOR2_X1
X_22106_ _15792_ _15798_ _15804_ _05108_ VDD VSS OR3_X1
X_22107_ _05107_ _04802_ _05108_ _05109_ VDD VSS OAI21_X4
X_22108_ _15811_ _05109_ _05110_ VDD VSS XNOR2_X1
X_22109_ _05104_ _05110_ _04502_ _05111_ VDD VSS MUX2_X1
X_22110_ _05100_ _05111_ net305 _05112_ VDD VSS OAI21_X4
X_22111_ _05112_ _11409_ _05113_ VDD VSS NOR2_X4
X_22112_ _16071_ _04359_ _04362_ _16070_ _05114_ VDD VSS AOI22_X1
X_22113_ _16074_ _05114_ _04664_ _05115_ VDD VSS MUX2_X1
X_22114_ _04281_ _04307_ _04275_ _05116_ VDD VSS NAND3_X1
X_22115_ alu_adder_result_ex\[29\] _04368_ _05117_ VDD VSS
+ NAND2_X1
X_22116_ _05115_ _05116_ _05117_ _05118_ VDD VSS NAND3_X1
X_22117_ _04307_ _05007_ _04452_ _05119_ VDD VSS MUX2_X2
X_22118_ _04282_ _04687_ _05120_ VDD VSS NOR2_X4
X_22119_ _05118_ _05119_ _05120_ _05121_ VDD VSS AOI21_X2
X_22120_ _04331_ _04918_ _04408_ _05122_ VDD VSS MUX2_X1
X_22121_ _15861_ _16064_ _04434_ _05123_ VDD VSS MUX2_X1
X_22122_ _15856_ _16072_ _04434_ _05124_ VDD VSS MUX2_X1
X_22123_ _05123_ _05124_ _04397_ _05125_ VDD VSS MUX2_X1
X_22124_ _04842_ _05125_ _04712_ _05126_ VDD VSS MUX2_X1
X_22125_ _04933_ _05126_ _04410_ _05127_ VDD VSS MUX2_X1
X_22126_ _04413_ _05122_ _05127_ _04685_ _05128_ VDD VSS AOI22_X2
X_22127_ _04409_ _04919_ _04922_ _05129_ VDD VSS NOR3_X1
X_22128_ _05129_ _04936_ _04409_ _05130_ VDD VSS AOI21_X1
X_22129_ _04412_ _04293_ _05130_ _05131_ VDD VSS NAND3_X1
X_22130_ _04412_ _04452_ _04990_ _05132_ VDD VSS OR3_X1
X_22131_ _04456_ _05128_ _05131_ _05132_ _05133_ VDD VSS NAND4_X2
X_22132_ _04390_ _05121_ _05133_ _10742_ _10661_ _05134_ VDD
+ VSS AOI221_X2
X_22133_ cs_registers_i.mie_q\[13\] _04515_ _04968_ cs_registers_i.csr_depc_o\[29\]
+ _05135_ VDD VSS AOI22_X1
X_22134_ net131 _04518_ _05022_ cs_registers_i.mtval_q\[29\]
+ _05074_ cs_registers_i.csr_mepc_o\[29\] _05136_ VDD VSS AOI222_X2
X_22135_ net83 _04528_ _04530_ cs_registers_i.dscratch1_q\[29\]
+ _05137_ VDD VSS AOI22_X1
X_22136_ _04534_ _04537_ _00009_ _05138_ VDD VSS OAI21_X1
X_22137_ _05138_ _04523_ cs_registers_i.mscratch_q\[29\] cs_registers_i.dscratch0_q\[29\]
+ _04771_ _05139_ VDD VSS AOI221_X1
X_22138_ _05135_ _05136_ _05137_ _05139_ _05140_ VDD VSS AND4_X1
X_22139_ cs_registers_i.mcycle_counter_i.counter\[61\] _04551_
+ _04554_ cs_registers_i.mhpmcounter\[2\]\[61\] _05141_ VDD
+ VSS AOI22_X2
X_22140_ cs_registers_i.mcycle_counter_i.counter\[29\] _05142_
+ VDD VSS BUF_X2
X_22141_ cs_registers_i.mhpmcounter\[2\]\[29\] _05143_ VDD
+ VSS CLKBUF_X2
X_22142_ _05142_ _04551_ _04554_ _05143_ _05144_ VDD VSS AOI22_X2
X_22143_ _05140_ _05141_ _04558_ _04560_ _05144_ _05145_ VDD
+ VSS OAI221_X2
X_22144_ _05113_ _04906_ _05134_ _05145_ _05146_ VDD VSS NOR4_X4
X_22145_ _05146_ _05099_ _05147_ VDD VSS OR2_X4
X_22146_ _05147_ _05148_ VDD VSS BUF_X8
X_22147_ _05095_ _05148_ _04909_ _01193_ VDD VSS OAI21_X1
X_22148_ alu_adder_result_ex\[30\] _04369_ _05149_ VDD VSS
+ NAND2_X1
X_22149_ _16079_ _04360_ _04363_ _16078_ _05150_ VDD VSS AOI22_X1
X_22150_ _16082_ _05150_ _04665_ _05151_ VDD VSS MUX2_X1
X_22151_ _04298_ _04290_ _04284_ _04279_ _04280_ _05152_ VDD
+ VSS AOI221_X2
X_22152_ _04674_ _04928_ _05152_ _05153_ VDD VSS MUX2_X1
X_22153_ _05149_ _05151_ _05153_ _04687_ _05154_ VDD VSS OAI211_X2
X_22154_ _11407_ _01124_ _04622_ _05155_ VDD VSS AOI21_X2
X_22155_ _05101_ _04482_ _04489_ _05156_ VDD VSS OAI21_X1
X_22156_ _15706_ _05156_ _04491_ _05157_ VDD VSS AOI21_X2
X_22157_ _15717_ _05157_ _05158_ VDD VSS XNOR2_X2
X_22158_ _04625_ _05158_ _05159_ VDD VSS AND2_X1
X_22159_ _05108_ _05160_ VDD VSS INV_X1
X_22160_ _05160_ _04888_ _04796_ _04792_ _04794_ _05161_ VDD
+ VSS OAI221_X2
X_22161_ _15811_ _05162_ VDD VSS INV_X1
X_22162_ _15817_ _05163_ VDD VSS CLKBUF_X2
X_22163_ _05162_ _05163_ _04624_ _05164_ VDD VSS NOR3_X1
X_22164_ _05107_ _05164_ net478 _05165_ VDD VSS AND3_X4
X_22165_ _15810_ _05166_ VDD VSS INV_X1
X_22166_ _05163_ _05166_ _04463_ _05167_ VDD VSS NAND3_X1
X_22167_ _05167_ _05107_ _05161_ _05168_ VDD VSS AOI21_X2
X_22168_ _05162_ _05163_ _05166_ _05169_ VDD VSS NAND3_X1
X_22169_ _05163_ _05170_ VDD VSS INV_X1
X_22170_ _05170_ _15810_ _05171_ VDD VSS NAND2_X1
X_22171_ _04624_ _05169_ _05171_ _05172_ VDD VSS AOI21_X1
X_22172_ _05165_ _05159_ _05168_ _05172_ _05173_ VDD VSS NOR4_X4
X_22173_ _05173_ _12103_ _05174_ VDD VSS NAND2_X2
X_22174_ _04815_ _05154_ _05174_ _05155_ _05175_ VDD VSS AOI22_X4
X_22175_ _04332_ _04425_ _04428_ _04330_ _05176_ VDD VSS AOI211_X2
X_22176_ _05176_ _04290_ _04284_ _04332_ _04421_ _05177_ VDD
+ VSS AOI221_X2
X_22177_ _04412_ _05177_ _04411_ _04293_ _05178_ VDD VSS AOI211_X2
X_22178_ _15852_ _16068_ _04840_ _05179_ VDD VSS MUX2_X1
X_22179_ _15845_ _04342_ _05180_ VDD VSS NAND2_X1
X_22180_ _05180_ _04342_ _16080_ _05181_ VDD VSS OAI21_X1
X_22181_ _05179_ _05181_ _15835_ _05182_ VDD VSS MUX2_X1
X_22182_ _05044_ _05182_ _04712_ _05183_ VDD VSS MUX2_X1
X_22183_ _05016_ _05183_ _04707_ _05184_ VDD VSS MUX2_X1
X_22184_ _04451_ _05184_ _04453_ _05185_ VDD VSS MUX2_X1
X_22185_ _05178_ _05185_ _04723_ _05186_ VDD VSS AOI21_X2
X_22186_ _05175_ _05186_ _04342_ _03465_ _10678_ _05187_ VDD
+ VSS OAI221_X2
X_22187_ cs_registers_i.mhpmcounter\[2\]\[62\] _05188_ VDD
+ VSS BUF_X2
X_22188_ cs_registers_i.mcycle_counter_i.counter\[62\] _04550_
+ _04553_ _05188_ _05189_ VDD VSS AOI22_X4
X_22189_ _03551_ _04236_ _05189_ _05190_ VDD VSS NOR3_X2
X_22190_ cs_registers_i.mcycle_counter_i.counter\[30\] _04550_
+ _04553_ cs_registers_i.mhpmcounter\[2\]\[30\] _05191_ VDD
+ VSS AOI22_X1
X_22191_ _04559_ _05191_ _05192_ VDD VSS NOR2_X1
X_22192_ net132 _04518_ _04521_ cs_registers_i.mtval_q\[30\]
+ _05193_ VDD VSS AOI22_X2
X_22193_ cs_registers_i.mscratch_q\[30\] _04524_ _04544_ cs_registers_i.csr_mepc_o\[30\]
+ _05194_ VDD VSS AOI22_X2
X_22194_ _05193_ _05194_ _05195_ VDD VSS NAND2_X2
X_22195_ cs_registers_i.mie_q\[14\] _04515_ _04775_ cs_registers_i.dscratch1_q\[30\]
+ _05196_ VDD VSS AOI22_X2
X_22196_ net85 _04528_ _04771_ cs_registers_i.dscratch0_q\[30\]
+ _05197_ VDD VSS AOI22_X2
X_22197_ _03500_ _04509_ _03518_ _03540_ _05198_ VDD VSS AOI211_X2
X_22198_ _11065_ _03594_ _04249_ _04535_ _05199_ VDD VSS AND4_X4
X_22199_ _00010_ _05200_ VDD VSS INV_X1
X_22200_ net249 _05199_ _05200_ cs_registers_i.csr_depc_o\[30\]
+ _04772_ _05201_ VDD VSS AOI221_X2
X_22201_ _04247_ _05196_ _05197_ _05201_ _05202_ VDD VSS NAND4_X4
X_22202_ _05190_ _05192_ _05195_ _05202_ _05203_ VDD VSS NOR4_X4
X_22203_ _04662_ _05203_ _05204_ VDD VSS NAND2_X1
X_22204_ _04906_ _05204_ _05187_ _05205_ VDD VSS AOI21_X4
X_22205_ net34 net43 _04584_ _05206_ VDD VSS MUX2_X1
X_22206_ net51 net56 _04584_ _05207_ VDD VSS MUX2_X1
X_22207_ _05206_ _05207_ _04619_ _05208_ VDD VSS MUX2_X1
X_22208_ _04580_ _04583_ _05208_ _05209_ VDD VSS AOI21_X2
X_22209_ _05205_ _05209_ _04906_ _05210_ VDD VSS AOI21_X4
X_22210_ _05210_ _05211_ VDD VSS BUF_X4
X_22211_ _05211_ gen_regfile_ff.register_file_i.rf_reg\[958\]
+ _04615_ _01194_ VDD VSS MUX2_X1
X_22212_ gen_regfile_ff.register_file_i.rf_reg\[959\] _04856_
+ _05212_ VDD VSS NAND2_X1
X_22213_ _04597_ _04575_ _05213_ VDD VSS NOR2_X1
X_22214_ _04619_ _04576_ _05214_ VDD VSS NOR2_X1
X_22215_ _04859_ _05213_ _05214_ _05215_ VDD VSS NOR3_X2
X_22216_ _15706_ _05103_ _04491_ _05216_ VDD VSS AOI21_X2
X_22217_ _15717_ _05217_ VDD VSS INV_X1
X_22218_ _04639_ _05216_ _05217_ _05218_ VDD VSS OAI21_X2
X_22219_ net327 _05218_ _05219_ VDD VSS XNOR2_X2
X_22220_ _12103_ _04791_ _05219_ _05220_ VDD VSS OAI21_X1
X_22221_ _05166_ _05109_ _05162_ _05221_ VDD VSS OAI21_X4
X_22222_ _15816_ _05221_ _05163_ _05222_ VDD VSS AOI21_X4
X_22223_ _05222_ _15823_ _05223_ VDD VSS XNOR2_X2
X_22224_ _05220_ _04791_ _05223_ _05224_ VDD VSS AOI21_X2
X_22225_ net305 _03412_ _05225_ VDD VSS AND2_X1
X_22226_ _11409_ _05224_ _05225_ _05226_ VDD VSS NOR3_X4
X_22227_ cs_registers_i.csr_mepc_o\[31\] _04542_ _05227_ VDD
+ VSS NAND2_X1
X_22228_ _03504_ _04244_ _03518_ _03540_ _05228_ VDD VSS AOI211_X2
X_22229_ cs_registers_i.mtval_q\[31\] _04519_ _05228_ cs_registers_i.mcause_q\[5\]
+ cs_registers_i.mscratch_q\[31\] _04522_ _05229_ VDD VSS AOI222_X2
X_22230_ cs_registers_i.dscratch1_q\[31\] _04529_ _04772_
+ cs_registers_i.csr_depc_o\[31\] net86 _04526_ _05230_ VDD
+ VSS AOI222_X2
X_22231_ _03580_ _03581_ _04512_ _05231_ VDD VSS NOR3_X4
X_22232_ _00011_ _05232_ VDD VSS INV_X1
X_22233_ _05231_ _05199_ _05232_ _04510_ cs_registers_i.dscratch0_q\[31\]
+ _05233_ VDD VSS AOI221_X1
X_22234_ _05227_ _05229_ _05230_ _05233_ _05234_ VDD VSS AND4_X1
X_22235_ cs_registers_i.mcycle_counter_i.counter\[63\] _04549_
+ _04552_ cs_registers_i.mhpmcounter\[2\]\[63\] _05235_ VDD
+ VSS AOI22_X4
X_22236_ cs_registers_i.mcycle_counter_i.counter\[31\] _05236_
+ VDD VSS BUF_X2
X_22237_ _05236_ _04549_ _04552_ cs_registers_i.mhpmcounter\[2\]\[31\]
+ _05237_ VDD VSS AOI22_X2
X_22238_ _05234_ _05235_ _04556_ _04235_ _05237_ _05238_ VDD
+ VSS OAI221_X2
X_22239_ _04410_ _04685_ _05239_ VDD VSS NAND2_X1
X_22240_ _04676_ _04306_ _05239_ _05240_ VDD VSS MUX2_X1
X_22241_ _15494_ _05241_ VDD VSS CLKBUF_X3
X_22242_ _04350_ _04358_ _05241_ _04361_ _15497_ _05242_ VDD
+ VSS AOI221_X1
X_22243_ _05242_ _04352_ _15493_ _05243_ VDD VSS AOI21_X1
X_22244_ alu_adder_result_ex\[31\] _04367_ _05244_ VDD VSS
+ AND2_X1
X_22245_ _05243_ _05244_ _05245_ VDD VSS OR2_X1
X_22246_ _05238_ _05240_ _04276_ _04815_ _05245_ _05246_ VDD
+ VSS AOI221_X1
X_22247_ _04282_ _04453_ _05247_ VDD VSS NAND2_X1
X_22248_ _15842_ _15496_ _04840_ _05248_ VDD VSS MUX2_X1
X_22249_ _05181_ _05248_ _15835_ _05249_ VDD VSS MUX2_X1
X_22250_ _04431_ _04712_ _05249_ _05250_ VDD VSS NAND3_X1
X_22251_ _04431_ _04429_ _05251_ VDD VSS NAND2_X1
X_22252_ _05250_ _05251_ _05125_ _04843_ _04707_ _05252_ VDD
+ VSS OAI221_X2
X_22253_ _05247_ _04706_ _05252_ _04987_ _05253_ VDD VSS OAI22_X1
X_22254_ _04670_ _04719_ _05254_ VDD VSS NOR2_X1
X_22255_ _04282_ _04293_ _04695_ _05255_ VDD VSS AND3_X1
X_22256_ _05253_ _05254_ _05255_ _05256_ VDD VSS OR3_X1
X_22257_ _05246_ _05256_ _04725_ _05257_ VDD VSS OAI21_X1
X_22258_ _04905_ _05257_ _05258_ VDD VSS OR2_X1
X_22259_ _04617_ _05215_ _05258_ _05226_ _05259_ VDD VSS OAI22_X4
X_22260_ _05259_ _05260_ VDD VSS BUF_X8
X_22261_ _05212_ _04909_ net681 _01195_ VDD VSS OAI21_X4
X_22262_ _04589_ _05261_ VDD VSS CLKBUF_X3
X_22263_ _04570_ _04588_ _05262_ VDD VSS NOR2_X4
X_22264_ _04589_ net36 _05263_ VDD VSS AND2_X1
X_22265_ _04581_ _05262_ net58 _05263_ _04570_ _05264_ VDD
+ VSS AOI221_X2
X_22266_ _04577_ _04584_ _05265_ VDD VSS NOR2_X4
X_22267_ _04858_ _05262_ load_store_unit_i.rdata_q\[8\] _05265_
+ load_store_unit_i.rdata_q\[16\] _05266_ VDD VSS AOI221_X2
X_22268_ _05261_ _05264_ _05266_ _05267_ VDD VSS NOR3_X1
X_22269_ _04570_ _05268_ VDD VSS CLKBUF_X3
X_22270_ _05268_ _04586_ _05269_ VDD VSS NOR2_X1
X_22271_ _04565_ _05270_ VDD VSS BUF_X4
X_22272_ _04573_ _05271_ VDD VSS INV_X1
X_22273_ _05271_ _04565_ _05272_ VDD VSS NAND2_X4
X_22274_ _05270_ net44 _05272_ load_store_unit_i.rdata_q\[24\]
+ _05273_ VDD VSS AOI22_X2
X_22275_ _05264_ _05266_ _05273_ _04589_ _05274_ VDD VSS OAI22_X2
X_22276_ _05267_ _05269_ net29 _04596_ _05274_ _05275_ VDD
+ VSS AOI221_X2
X_22277_ _11486_ _05276_ VDD VSS INV_X1
X_22278_ _11476_ _05276_ _11500_ _05277_ VDD VSS MUX2_X1
X_22279_ _04271_ _11505_ _05278_ VDD VSS NOR2_X1
X_22280_ _04264_ _05277_ _04376_ _05278_ _05279_ VDD VSS OAI22_X1
X_22281_ _11862_ _05279_ _05280_ VDD VSS AND2_X1
X_22282_ _15494_ net272 _05281_ VDD VSS NOR2_X1
X_22283_ _03398_ _03399_ _03415_ _05281_ _05282_ VDD VSS NAND4_X2
X_22284_ _05241_ _05283_ VDD VSS INV_X1
X_22285_ _11482_ _11918_ _05278_ _05284_ VDD VSS OR3_X1
X_22286_ _04300_ _11512_ _05278_ _05284_ _04266_ _11510_ _05285_
+ VDD VSS OAI33_X1
X_22287_ _04375_ _05285_ _05286_ VDD VSS NOR2_X2
X_22288_ _05283_ net272 _05286_ _05287_ VDD VSS NAND3_X1
X_22289_ _05280_ _05282_ _05287_ _03416_ _05288_ VDD VSS OAI22_X2
X_22290_ _03398_ _03399_ _05289_ VDD VSS AND2_X1
X_22291_ _15489_ _05290_ VDD VSS INV_X1
X_22292_ _03391_ _03219_ _13266_ _05291_ VDD VSS AOI21_X2
X_22293_ _05290_ _05291_ _03418_ _05292_ VDD VSS OAI21_X4
X_22294_ _04264_ _11862_ _04379_ _05293_ VDD VSS AND3_X1
X_22295_ _05276_ _04264_ _11918_ _05294_ VDD VSS NOR3_X1
X_22296_ _04273_ _05293_ _05294_ _05295_ VDD VSS OAI21_X1
X_22297_ net285 _04300_ _11862_ _05296_ VDD VSS NAND3_X1
X_22298_ _05295_ _05296_ _04273_ _05297_ VDD VSS OAI21_X1
X_22299_ _05241_ _05292_ _05297_ _05298_ VDD VSS OR3_X1
X_22300_ _05283_ _05292_ _05286_ _05299_ VDD VSS NAND3_X1
X_22301_ _05289_ _05298_ _05299_ _05300_ VDD VSS AOI21_X1
X_22302_ _03412_ _11406_ _03405_ _03411_ _05301_ VDD VSS NOR4_X1
X_22303_ _11406_ _03413_ _05302_ VDD VSS NOR2_X1
X_22304_ _05301_ _05302_ _03411_ _05303_ VDD VSS AOI21_X2
X_22305_ _04375_ _05285_ _05304_ VDD VSS OR2_X1
X_22306_ _05304_ _05297_ net272 _05305_ VDD VSS MUX2_X1
X_22307_ _05241_ _05303_ _05305_ _05306_ VDD VSS OR3_X1
X_22308_ _11476_ _11918_ _11500_ _05307_ VDD VSS NOR3_X1
X_22309_ _11482_ _11508_ _05308_ VDD VSS XNOR2_X1
X_22310_ _04300_ net290 _11918_ _05308_ _05309_ VDD VSS OAI22_X2
X_22311_ _05307_ _05309_ _11505_ _05310_ VDD VSS AOI21_X2
X_22312_ _15492_ _05310_ _05311_ VDD VSS XNOR2_X2
X_22313_ _05280_ _05304_ _05311_ _05312_ VDD VSS MUX2_X1
X_22314_ _05306_ _05312_ _05283_ _05313_ VDD VSS OAI21_X1
X_22315_ _05288_ _05300_ _05313_ _05314_ VDD VSS OR3_X4
X_22316_ _11918_ _04273_ _04304_ _05315_ VDD VSS NOR3_X2
X_22317_ _05315_ _05316_ VDD VSS INV_X2
X_22318_ _05304_ _05280_ _05311_ _05317_ VDD VSS MUX2_X1
X_22319_ _03398_ _03399_ _03415_ _05281_ _05318_ VDD VSS AND4_X1
X_22320_ _05315_ _05317_ _15494_ _05304_ _05318_ _05319_ VDD
+ VSS AOI221_X2
X_22321_ _05241_ _05292_ _05320_ VDD VSS NOR2_X1
X_22322_ _03415_ _05286_ _05321_ VDD VSS NOR2_X1
X_22323_ _03398_ _03399_ _03415_ _05280_ _05322_ VDD VSS AND4_X1
X_22324_ _05320_ _05321_ _05322_ _05323_ VDD VSS OAI21_X2
X_22325_ _05286_ _03399_ _03398_ _05324_ VDD VSS AOI21_X1
X_22326_ _05292_ _05280_ _05325_ VDD VSS AND2_X1
X_22327_ net272 _05324_ _05325_ _03416_ _05326_ VDD VSS AOI22_X2
X_22328_ _05319_ _05323_ _05326_ _05241_ _05327_ VDD VSS OAI211_X4
X_22329_ alu_adder_result_ex\[10\] _05328_ VDD VSS INV_X1
X_22330_ alu_adder_result_ex\[16\] net380 alu_adder_result_ex\[2\]
+ alu_adder_result_ex\[4\] _05329_ VDD VSS NOR4_X1
X_22331_ _05328_ net277 _05329_ _05330_ VDD VSS NAND3_X1
X_22332_ alu_adder_result_ex\[20\] _12949_ _13121_ net397
+ _05331_ VDD VSS OR4_X2
X_22333_ alu_adder_result_ex\[13\] alu_adder_result_ex\[17\]
+ net402 _05332_ VDD VSS OR3_X1
X_22334_ alu_adder_result_ex\[23\] net390 _03623_ _05332_
+ _05333_ VDD VSS OR4_X1
X_22335_ alu_adder_result_ex\[15\] alu_adder_result_ex\[21\]
+ alu_adder_result_ex\[25\] net246 _05334_ VDD VSS OR4_X1
X_22336_ alu_adder_result_ex\[6\] alu_adder_result_ex\[8\]
+ _05333_ _05334_ _05335_ VDD VSS OR4_X1
X_22337_ alu_adder_result_ex\[12\] alu_adder_result_ex\[14\]
+ alu_adder_result_ex\[28\] _05335_ _05336_ VDD VSS OR4_X1
X_22338_ alu_adder_result_ex\[30\] _05330_ _05331_ _05336_
+ _05337_ VDD VSS NOR4_X2
X_22339_ _05316_ _05327_ _05337_ _05338_ VDD VSS MUX2_X2
X_22340_ _04381_ _05314_ _05338_ _05339_ VDD VSS AOI21_X2
X_22341_ _15839_ _05340_ VDD VSS INV_X1
X_22342_ _05340_ _04353_ _04368_ alu_adder_result_ex\[0\]
+ _05341_ VDD VSS AOI22_X1
X_22343_ _15840_ _04360_ _04363_ _15843_ _05342_ VDD VSS AOI22_X1
X_22344_ _05341_ _05342_ _04370_ _05343_ VDD VSS OAI21_X1
X_22345_ _05343_ _05240_ _04840_ _05344_ VDD VSS AOI21_X1
X_22346_ _05344_ _05256_ _04688_ _05345_ VDD VSS OAI21_X1
X_22347_ _04815_ _05339_ _05345_ _10678_ _03465_ _05346_ VDD
+ VSS OAI221_X2
X_22348_ _15553_ _04625_ _05347_ VDD VSS NOR2_X1
X_22349_ _05347_ _04626_ _00217_ _05348_ VDD VSS AOI21_X1
X_22350_ _04622_ _05348_ _05349_ VDD VSS NOR2_X2
X_22351_ _12103_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[32\]
+ _05350_ VDD VSS NOR2_X1
X_22352_ _11408_ _05349_ _05350_ _05351_ VDD VSS NOR3_X4
X_22353_ cs_registers_i.mhpmcounter\[2\]\[32\] _05352_ VDD
+ VSS BUF_X2
X_22354_ cs_registers_i.mcycle_counter_i.counter\[32\] _04752_
+ _04753_ _05352_ _05353_ VDD VSS AOI22_X2
X_22355_ _04557_ _05353_ _05354_ VDD VSS NOR2_X1
X_22356_ _00551_ _05355_ VDD VSS INV_X1
X_22357_ _00552_ _05356_ VDD VSS INV_X1
X_22358_ _05355_ _04752_ _04753_ _05356_ _05357_ VDD VSS AOI22_X2
X_22359_ _04559_ _05357_ _05358_ VDD VSS NOR2_X1
X_22360_ cs_registers_i.csr_mepc_o\[0\] _05074_ _05228_ cs_registers_i.mcause_q\[0\]
+ _05359_ VDD VSS AOI22_X2
X_22361_ cs_registers_i.mscratch_q\[0\] _04972_ _05022_ cs_registers_i.mtval_q\[0\]
+ _05360_ VDD VSS AOI22_X1
X_22362_ _05359_ _05360_ _05361_ VDD VSS NAND2_X1
X_22363_ _00553_ _05362_ VDD VSS INV_X1
X_22364_ _05362_ _05231_ _05198_ cs_registers_i.dcsr_q\[0\]
+ _05363_ VDD VSS AOI22_X1
X_22365_ _03530_ _03596_ _05364_ VDD VSS NOR2_X1
X_22366_ _04251_ _04548_ _05364_ _05365_ VDD VSS NOR3_X1
X_22367_ _05365_ _04526_ net62 cs_registers_i.dscratch1_q\[0\]
+ _04529_ _05366_ VDD VSS AOI221_X1
X_22368_ _05199_ _04771_ cs_registers_i.dscratch0_q\[0\] _05367_
+ VDD VSS AOI21_X1
X_22369_ _05363_ _05366_ _05367_ _05368_ VDD VSS NAND3_X1
X_22370_ _05354_ _05358_ _05361_ _05368_ _05369_ VDD VSS OR4_X4
X_22371_ _04905_ _05351_ _05369_ _05370_ VDD VSS NOR3_X4
X_22372_ _04611_ _05275_ _05346_ _05370_ _05371_ VDD VSS AOI22_X4
X_22373_ _05371_ _05372_ VDD VSS BUF_X2
X_22374_ _10394_ _11315_ _05373_ VDD VSS NAND2_X2
X_22375_ _04603_ _05373_ _05374_ VDD VSS NOR2_X4
X_22376_ _04613_ _05374_ _05375_ VDD VSS NAND2_X4
X_22377_ _05375_ _05376_ VDD VSS BUF_X4
X_22378_ _05372_ gen_regfile_ff.register_file_i.rf_reg\[960\]
+ _05376_ _01196_ VDD VSS MUX2_X1
X_22379_ _05268_ _05261_ net37 _05377_ VDD VSS NAND3_X1
X_22380_ _04594_ net59 _05378_ VDD VSS NAND2_X1
X_22381_ _05377_ _05378_ _04596_ _05379_ VDD VSS OAI21_X1
X_22382_ _04859_ _05379_ _05380_ VDD VSS NAND2_X1
X_22383_ load_store_unit_i.rdata_q\[9\] _05262_ _05265_ load_store_unit_i.rdata_q\[17\]
+ _05381_ VDD VSS AOI22_X1
X_22384_ _05380_ _05381_ _04859_ _05382_ VDD VSS OAI21_X1
X_22385_ _05261_ net40 _05383_ VDD VSS NAND2_X1
X_22386_ _05268_ _04594_ _05384_ VDD VSS NAND2_X2
X_22387_ _05270_ net45 _05272_ load_store_unit_i.rdata_q\[25\]
+ _05385_ VDD VSS AOI22_X2
X_22388_ _04597_ _05383_ _05384_ _05385_ _05386_ VDD VSS OAI22_X2
X_22389_ _04611_ _05382_ _05386_ _05387_ VDD VSS OAI21_X2
X_22390_ _15556_ _04624_ _05388_ VDD VSS NOR2_X1
X_22391_ _05388_ _04624_ _00185_ _05389_ VDD VSS AOI21_X2
X_22392_ _10310_ _05389_ _05390_ VDD VSS NOR2_X1
X_22393_ _11401_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[33\]
+ _11432_ _05391_ VDD VSS OAI21_X1
X_22394_ _10744_ _05390_ _05391_ _05392_ VDD VSS OAI21_X2
X_22395_ _15850_ _04353_ _05393_ VDD VSS NAND2_X1
X_22396_ _04351_ _04359_ _15848_ _04983_ _15847_ _05394_ VDD
+ VSS AOI221_X1
X_22397_ _05394_ _05395_ VDD VSS INV_X1
X_22398_ _05392_ _05393_ _05395_ _04369_ net247 _05396_ VDD
+ VSS AOI221_X1
X_22399_ _05396_ _05153_ _04725_ _05397_ VDD VSS OAI21_X1
X_22400_ _04688_ _05186_ _05398_ VDD VSS NOR2_X1
X_22401_ _00554_ _04539_ _05399_ VDD VSS NOR2_X1
X_22402_ _05399_ net248 cs_registers_i.dscratch0_q\[1\] cs_registers_i.dscratch1_q\[1\]
+ _04775_ _05400_ VDD VSS AOI221_X2
X_22403_ cs_registers_i.mtval_q\[1\] _05022_ _05074_ cs_registers_i.csr_mepc_o\[1\]
+ cs_registers_i.mscratch_q\[1\] _04972_ _05401_ VDD VSS AOI222_X2
X_22404_ cs_registers_i.dcsr_q\[1\] _05198_ _05228_ cs_registers_i.mcause_q\[1\]
+ net73 _04527_ _05402_ VDD VSS AOI222_X2
X_22405_ _05400_ _05401_ _05402_ _05403_ VDD VSS AND3_X1
X_22406_ cs_registers_i.mcycle_counter_i.counter\[33\] _05404_
+ VDD VSS CLKBUF_X3
X_22407_ _05404_ _04959_ _04960_ cs_registers_i.mhpmcounter\[2\]\[33\]
+ _05405_ VDD VSS AOI22_X2
X_22408_ cs_registers_i.mcycle_counter_i.counter\[1\] _04551_
+ _04554_ cs_registers_i.mhpmcounter\[2\]\[1\] _05406_ VDD VSS
+ AOI22_X2
X_22409_ _05403_ _05405_ _05031_ _04560_ _05406_ _05407_ VDD
+ VSS OAI221_X2
X_22410_ _04815_ _05392_ _05397_ _05398_ _05407_ _04393_ _05408_
+ VDD VSS OAI222_X2
X_22411_ _05387_ _05408_ _04906_ _05409_ VDD VSS OAI21_X2
X_22412_ _05409_ _05410_ VDD VSS BUF_X2
X_22413_ _05410_ gen_regfile_ff.register_file_i.rf_reg\[961\]
+ _05376_ _01197_ VDD VSS MUX2_X1
X_22414_ _05093_ _05411_ VDD VSS BUF_X2
X_22415_ gen_regfile_ff.register_file_i.waddr_a_i\[2\] _05412_
+ VDD VSS BUF_X4
X_22416_ _10899_ _05412_ _04605_ _04611_ _05413_ VDD VSS AOI211_X2
X_22417_ _04852_ _05413_ _05414_ VDD VSS AND2_X1
X_22418_ _05414_ _05415_ VDD VSS BUF_X4
X_22419_ gen_regfile_ff.register_file_i.rf_reg\[124\] _05411_
+ _05415_ _01198_ VDD VSS MUX2_X1
X_22420_ _05375_ _05416_ VDD VSS BUF_X4
X_22421_ gen_regfile_ff.register_file_i.rf_reg\[962\] _05416_
+ _05417_ VDD VSS NAND2_X1
X_22422_ _05270_ net46 _05272_ load_store_unit_i.rdata_q\[26\]
+ _05418_ VDD VSS AOI22_X1
X_22423_ _05261_ net50 _05419_ VDD VSS NAND2_X1
X_22424_ _05384_ _05418_ _05419_ _04597_ _05420_ VDD VSS OAI22_X1
X_22425_ _05268_ _05421_ VDD VSS CLKBUF_X3
X_22426_ _05421_ _05261_ net38 _05422_ VDD VSS NAND3_X1
X_22427_ _04594_ net30 _05423_ VDD VSS NAND2_X1
X_22428_ _05422_ _05423_ _05421_ _04574_ _05270_ _05424_ VDD
+ VSS OAI221_X1
X_22429_ load_store_unit_i.rdata_q\[10\] _05262_ _05265_ load_store_unit_i.rdata_q\[18\]
+ _05425_ VDD VSS AOI22_X1
X_22430_ _04582_ _05425_ _05426_ VDD VSS NAND2_X1
X_22431_ _05420_ _05424_ _05426_ _05427_ VDD VSS AOI21_X1
X_22432_ _00556_ _04463_ _05428_ VDD VSS OR2_X1
X_22433_ _15565_ _04463_ _05429_ VDD VSS NAND2_X1
X_22434_ _12102_ _05428_ _05429_ _05430_ VDD VSS NAND3_X2
X_22435_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[34\]
+ _05431_ VDD VSS INV_X1
X_22436_ _11407_ _05431_ net306 _05432_ VDD VSS AOI21_X2
X_22437_ _15855_ _04360_ _04983_ _15854_ _05433_ VDD VSS AOI22_X1
X_22438_ _15858_ _05433_ _04664_ _05434_ VDD VSS MUX2_X1
X_22439_ alu_adder_result_ex\[2\] _04368_ _05435_ VDD VSS
+ NAND2_X1
X_22440_ _05434_ _05435_ _05436_ VDD VSS NAND2_X1
X_22441_ _04662_ _05430_ _05432_ _05436_ _04815_ _05437_ VDD
+ VSS AOI221_X2
X_22442_ _04987_ _05007_ _05438_ VDD VSS NOR2_X1
X_22443_ _04840_ _04816_ _05439_ VDD VSS NAND2_X1
X_22444_ _05128_ _05131_ _05132_ _05440_ VDD VSS NAND3_X1
X_22445_ _05437_ _05438_ _05439_ _05440_ _04688_ _05441_ VDD
+ VSS OAI221_X2
X_22446_ cs_registers_i.mtval_q\[2\] _05022_ _05228_ cs_registers_i.mcause_q\[2\]
+ _05442_ VDD VSS AOI22_X1
X_22447_ cs_registers_i.mscratch_q\[2\] _04972_ _05074_ cs_registers_i.csr_mepc_o\[2\]
+ _05443_ VDD VSS AOI22_X1
X_22448_ cs_registers_i.csr_depc_o\[2\] _04773_ _05444_ VDD
+ VSS NAND2_X1
X_22449_ _03496_ _04251_ _04730_ _05445_ VDD VSS OR3_X1
X_22450_ _01162_ _05446_ VDD VSS INV_X1
X_22451_ cs_registers_i.dscratch0_q\[2\] _04510_ net249 _05446_
+ _05447_ VDD VSS AOI22_X1
X_22452_ _05444_ _05445_ _05447_ _05448_ VDD VSS AND3_X1
X_22453_ cs_registers_i.dscratch1_q\[2\] _05449_ VDD VSS INV_X1
X_22454_ _03506_ _04538_ _03530_ _10920_ _05450_ VDD VSS OAI211_X2
X_22455_ _10922_ _03513_ _03524_ _05451_ VDD VSS OAI21_X1
X_22456_ _04239_ _05451_ _05452_ VDD VSS NAND2_X2
X_22457_ _05449_ _05450_ _05452_ _04735_ _05453_ VDD VSS OAI22_X1
X_22458_ _01159_ _05454_ VDD VSS INV_X1
X_22459_ _05453_ _04527_ net84 _05454_ _05231_ _05455_ VDD
+ VSS AOI221_X1
X_22460_ _05442_ _05443_ _05448_ _05455_ _05456_ VDD VSS AND4_X1
X_22461_ cs_registers_i.mcycle_counter_i.counter\[34\] _05457_
+ VDD VSS CLKBUF_X3
X_22462_ _05457_ _04784_ _04785_ cs_registers_i.mhpmcounter\[2\]\[34\]
+ _05458_ VDD VSS AOI22_X2
X_22463_ cs_registers_i.mcycle_counter_i.counter\[2\] _05459_
+ VDD VSS BUF_X2
X_22464_ _05459_ _04963_ _04964_ cs_registers_i.mhpmcounter\[2\]\[2\]
+ _05460_ VDD VSS AOI22_X2
X_22465_ _05456_ _05458_ _04557_ _04783_ _05460_ _05461_ VDD
+ VSS OAI221_X2
X_22466_ _05441_ _05461_ _04563_ _05462_ VDD VSS OAI21_X2
X_22467_ _05427_ _05462_ _04600_ _05463_ VDD VSS MUX2_X2
X_22468_ _05463_ _05464_ VDD VSS CLKBUF_X3
X_22469_ _05375_ _05465_ VDD VSS BUF_X4
X_22470_ _05417_ _05464_ _05465_ _01199_ VDD VSS OAI21_X1
X_22471_ gen_regfile_ff.register_file_i.rf_reg\[963\] _05416_
+ _05466_ VDD VSS NAND2_X1
X_22472_ _15580_ _04624_ _05467_ VDD VSS NOR2_X1
X_22473_ _05467_ _04625_ _00557_ _05468_ VDD VSS AOI21_X1
X_22474_ _10310_ _05468_ _05469_ VDD VSS NOR2_X2
X_22475_ _11401_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[35\]
+ _11432_ _05470_ VDD VSS OAI21_X1
X_22476_ _04350_ _04358_ _15863_ _04361_ _15866_ _05471_ VDD
+ VSS AOI221_X1
X_22477_ _05471_ _04352_ _15862_ _05472_ VDD VSS AOI21_X1
X_22478_ _05472_ _04368_ alu_adder_result_ex\[3\] _05473_
+ VDD VSS AOI21_X1
X_22479_ _05469_ _05470_ _05473_ _04389_ _05474_ VDD VSS OAI22_X1
X_22480_ _04279_ _04280_ _04306_ _05475_ VDD VSS AND3_X2
X_22481_ _04456_ _05475_ _05476_ VDD VSS NAND2_X1
X_22482_ _04393_ _05476_ _05477_ VDD VSS NAND2_X1
X_22483_ _05474_ _05477_ _05478_ VDD VSS OR2_X1
X_22484_ _04458_ _04830_ _04720_ _05479_ VDD VSS AOI21_X1
X_22485_ _04342_ _04281_ _05480_ VDD VSS NOR2_X2
X_22486_ _05478_ _05479_ _05480_ _05056_ _04276_ _05481_ VDD
+ VSS AOI221_X2
X_22487_ cs_registers_i.mcycle_counter_i.counter\[35\] _05482_
+ VDD VSS CLKBUF_X3
X_22488_ cs_registers_i.mhpmcounter\[2\]\[35\] _05483_ VDD
+ VSS BUF_X2
X_22489_ _05482_ _04752_ _04753_ _05483_ _05484_ VDD VSS AOI22_X2
X_22490_ _04557_ _05484_ _05485_ VDD VSS NOR2_X1
X_22491_ cs_registers_i.csr_mepc_o\[3\] _05074_ _05228_ cs_registers_i.mcause_q\[3\]
+ _05486_ VDD VSS AOI22_X2
X_22492_ _11072_ _05452_ _05487_ VDD VSS NOR2_X4
X_22493_ cs_registers_i.dscratch0_q\[3\] _04510_ _04529_ cs_registers_i.dscratch1_q\[3\]
+ cs_registers_i.csr_mstatus_mie_o _05487_ _05488_ VDD VSS AOI222_X2
X_22494_ _15869_ _03491_ _03485_ _03514_ _05489_ VDD VSS NAND4_X2
X_22495_ _03575_ _05489_ _05490_ VDD VSS NOR2_X2
X_22496_ cs_registers_i.mie_q\[17\] _04514_ _04773_ _03950_
+ net87 _05490_ _05491_ VDD VSS AOI222_X2
X_22497_ _04534_ _05486_ _05488_ _05491_ _05492_ VDD VSS NAND4_X2
X_22498_ net142 _04517_ _04520_ cs_registers_i.mtval_q\[3\]
+ cs_registers_i.mscratch_q\[3\] _04523_ _05493_ VDD VSS AOI222_X2
X_22499_ cs_registers_i.mcycle_counter_i.counter\[3\] _05494_
+ VDD VSS BUF_X2
X_22500_ _05494_ _04752_ _04753_ cs_registers_i.mhpmcounter\[2\]\[3\]
+ _05495_ VDD VSS AOI22_X2
X_22501_ _05493_ _05495_ _04559_ _05496_ VDD VSS OAI21_X1
X_22502_ _05485_ _05492_ _05496_ _05497_ VDD VSS OR3_X2
X_22503_ _04563_ _05497_ _05498_ VDD VSS NOR2_X1
X_22504_ _04764_ _05481_ _05498_ _05499_ VDD VSS OAI21_X1
X_22505_ load_store_unit_i.rdata_q\[11\] _05262_ _05265_ load_store_unit_i.rdata_q\[19\]
+ _05500_ VDD VSS AOI22_X1
X_22506_ _04859_ _05500_ _05501_ VDD VSS NOR2_X1
X_22507_ _04596_ _05261_ net39 _05502_ VDD VSS NAND3_X1
X_22508_ _04594_ net31 _05503_ VDD VSS NAND2_X1
X_22509_ _05502_ _05503_ _04596_ _05504_ VDD VSS OAI21_X1
X_22510_ _05501_ _05504_ _04859_ _05505_ VDD VSS AOI21_X1
X_22511_ _05270_ net47 _05272_ load_store_unit_i.rdata_q\[27\]
+ _05506_ VDD VSS AOI22_X2
X_22512_ _05261_ net53 _05507_ VDD VSS NAND2_X1
X_22513_ _05505_ _05506_ _05384_ _05507_ _04597_ _05508_ VDD
+ VSS OAI221_X2
X_22514_ _05499_ _05508_ _04764_ _05509_ VDD VSS OAI21_X2
X_22515_ _05509_ _05510_ VDD VSS CLKBUF_X3
X_22516_ _05466_ _05510_ _05465_ _01200_ VDD VSS OAI21_X1
X_22517_ load_store_unit_i.rdata_q\[12\] _05262_ _05265_ load_store_unit_i.rdata_q\[20\]
+ _05511_ VDD VSS AOI22_X1
X_22518_ _04859_ _05511_ _05512_ VDD VSS NOR2_X1
X_22519_ _04570_ _05513_ VDD VSS CLKBUF_X3
X_22520_ _05513_ _04589_ net41 _05514_ VDD VSS NAND3_X1
X_22521_ _04586_ net32 _05515_ VDD VSS NAND2_X1
X_22522_ _05514_ _05515_ _05268_ _05516_ VDD VSS OAI21_X1
X_22523_ _05512_ _05516_ _04859_ _05517_ VDD VSS AOI21_X1
X_22524_ _05270_ net48 _05272_ load_store_unit_i.rdata_q\[28\]
+ _05518_ VDD VSS AOI22_X2
X_22525_ _05261_ net54 _05519_ VDD VSS NAND2_X1
X_22526_ _05517_ _05518_ _05384_ _05519_ _04597_ _05520_ VDD
+ VSS OAI221_X2
X_22527_ _15588_ _04624_ _05521_ VDD VSS NOR2_X1
X_22528_ _05521_ _04624_ _00558_ _05522_ VDD VSS AOI21_X1
X_22529_ _10310_ _05522_ _05523_ VDD VSS NOR2_X2
X_22530_ _11401_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[36\]
+ _11432_ _05524_ VDD VSS OAI21_X1
X_22531_ _04350_ _04358_ _15871_ _04361_ _15870_ _05525_ VDD
+ VSS AOI221_X2
X_22532_ _05525_ _04352_ _15874_ _05526_ VDD VSS AOI21_X1
X_22533_ _05526_ _04368_ alu_adder_result_ex\[4\] _05527_
+ VDD VSS AOI21_X1
X_22534_ _10744_ _05523_ _05524_ _05527_ _04390_ _05528_ VDD
+ VSS OAI221_X2
X_22535_ _04840_ _04816_ _05529_ VDD VSS AND2_X1
X_22536_ _05528_ _05529_ _04821_ _04276_ _04846_ _05530_ VDD
+ VSS AOI221_X2
X_22537_ cs_registers_i.mtval_q\[4\] _05022_ _05074_ cs_registers_i.csr_mepc_o\[4\]
+ _05228_ cs_registers_i.mcause_q\[4\] _05531_ VDD VSS AOI222_X2
X_22538_ _01164_ _04539_ _05532_ VDD VSS NOR2_X1
X_22539_ _05532_ net248 cs_registers_i.dscratch0_q\[4\] cs_registers_i.dscratch1_q\[4\]
+ _04529_ _05533_ VDD VSS AOI221_X1
X_22540_ _05231_ _04527_ net88 cs_registers_i.mscratch_q\[4\]
+ _04523_ _05534_ VDD VSS AOI221_X1
X_22541_ _05531_ _05533_ _05534_ _05535_ VDD VSS AND3_X1
X_22542_ cs_registers_i.mcycle_counter_i.counter\[36\] _05536_
+ VDD VSS BUF_X2
X_22543_ _05536_ _04784_ _04785_ cs_registers_i.mhpmcounter\[2\]\[36\]
+ _05537_ VDD VSS AOI22_X2
X_22544_ cs_registers_i.mhpmcounter\[2\]\[4\] _05538_ VDD
+ VSS BUF_X1
X_22545_ cs_registers_i.mcycle_counter_i.counter\[4\] _04963_
+ _04964_ _05538_ _05539_ VDD VSS AOI22_X2
X_22546_ _05535_ _05537_ _05031_ _04783_ _05539_ _05540_ VDD
+ VSS OAI221_X2
X_22547_ _04393_ _05540_ _05541_ VDD VSS NOR2_X1
X_22548_ _05530_ _05541_ _05542_ VDD VSS NOR2_X2
X_22549_ _05520_ _05542_ _04263_ _05543_ VDD VSS MUX2_X2
X_22550_ _05543_ _05544_ VDD VSS BUF_X2
X_22551_ _05544_ gen_regfile_ff.register_file_i.rf_reg\[964\]
+ _05376_ _01201_ VDD VSS MUX2_X1
X_22552_ load_store_unit_i.rdata_q\[13\] _05262_ _05265_ load_store_unit_i.rdata_q\[21\]
+ _05545_ VDD VSS AOI22_X1
X_22553_ _04858_ _05545_ _05546_ VDD VSS NOR2_X1
X_22554_ _05513_ _04589_ net42 _05547_ VDD VSS NAND3_X1
X_22555_ _04586_ net33 _05548_ VDD VSS NAND2_X1
X_22556_ _05547_ _05548_ _05268_ _05549_ VDD VSS OAI21_X1
X_22557_ _05546_ _05549_ _04859_ _05550_ VDD VSS AOI21_X1
X_22558_ _05270_ net49 _05272_ load_store_unit_i.rdata_q\[29\]
+ _05551_ VDD VSS AOI22_X2
X_22559_ _05261_ net55 _05552_ VDD VSS NAND2_X1
X_22560_ _05550_ _05551_ _05384_ _05552_ _04597_ _05553_ VDD
+ VSS OAI221_X2
X_22561_ _14126_ _04625_ _05554_ VDD VSS NOR2_X1
X_22562_ _05554_ _05079_ _00559_ _05555_ VDD VSS AOI21_X1
X_22563_ _04622_ _05555_ _05556_ VDD VSS NOR2_X2
X_22564_ _03449_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[37\]
+ _12102_ _05557_ VDD VSS OAI21_X1
X_22565_ _04393_ _05556_ _05557_ _05558_ VDD VSS OAI21_X2
X_22566_ _15879_ _15878_ _04983_ _05559_ VDD VSS MUX2_X1
X_22567_ _04665_ _05559_ _05560_ VDD VSS NAND2_X1
X_22568_ _05560_ _04665_ _15882_ _05561_ VDD VSS OAI21_X1
X_22569_ _04387_ _05562_ VDD VSS INV_X2
X_22570_ alu_adder_result_ex\[5\] _04825_ _05561_ _05562_
+ _05563_ VDD VSS AOI22_X1
X_22571_ _04457_ _04816_ _05564_ VDD VSS NAND2_X1
X_22572_ _05563_ _05564_ _04991_ _05565_ VDD VSS OAI21_X1
X_22573_ _05558_ _05565_ _04815_ _05566_ VDD VSS AOI21_X2
X_22574_ _04276_ _05019_ _05567_ VDD VSS NAND2_X1
X_22575_ cs_registers_i.mcycle_counter_i.counter\[37\] _04784_
+ _04785_ cs_registers_i.mhpmcounter\[2\]\[37\] _05568_ VDD
+ VSS AOI22_X2
X_22576_ _05031_ _05568_ _05569_ VDD VSS NOR2_X1
X_22577_ cs_registers_i.mcycle_counter_i.counter\[5\] _04550_
+ _04553_ cs_registers_i.mhpmcounter\[2\]\[5\] _05570_ VDD VSS
+ AOI22_X1
X_22578_ _04559_ _05570_ _05571_ VDD VSS NOR2_X1
X_22579_ cs_registers_i.mscratch_q\[5\] _04524_ _04521_ cs_registers_i.mtval_q\[5\]
+ _05572_ VDD VSS AOI22_X1
X_22580_ _05231_ _04543_ cs_registers_i.csr_mepc_o\[5\] cs_registers_i.dscratch0_q\[5\]
+ net248 _05573_ VDD VSS AOI221_X2
X_22581_ _01165_ _04539_ _05574_ VDD VSS NOR2_X1
X_22582_ _05574_ _04527_ net89 cs_registers_i.dscratch1_q\[5\]
+ _04529_ _05575_ VDD VSS AOI221_X2
X_22583_ _05572_ _05573_ _05575_ _05576_ VDD VSS NAND3_X2
X_22584_ _05569_ _05571_ _05576_ _05577_ VDD VSS NOR3_X4
X_22585_ _05566_ _05567_ _05577_ _04662_ _05578_ VDD VSS AOI22_X4
X_22586_ _05553_ _05578_ _04263_ _05579_ VDD VSS MUX2_X2
X_22587_ _05579_ _05580_ VDD VSS BUF_X2
X_22588_ _05580_ gen_regfile_ff.register_file_i.rf_reg\[965\]
+ _05376_ _01202_ VDD VSS MUX2_X1
X_22589_ _04581_ _04592_ _04570_ _05262_ net34 _05581_ VDD
+ VSS AOI221_X1
X_22590_ _04858_ _05262_ load_store_unit_i.rdata_q\[14\] _05265_
+ load_store_unit_i.rdata_q\[22\] _05582_ VDD VSS AOI221_X1
X_22591_ _05581_ _05582_ _05583_ VDD VSS OR2_X1
X_22592_ _05270_ net51 _05272_ load_store_unit_i.rdata_q\[30\]
+ _05584_ VDD VSS AOI22_X1
X_22593_ _05583_ _05584_ _05261_ _05585_ VDD VSS OAI21_X1
X_22594_ _04587_ _05583_ _04594_ _05586_ VDD VSS AOI21_X1
X_22595_ _05585_ _05586_ _04619_ _05587_ VDD VSS MUX2_X1
X_22596_ _04611_ _05587_ _05588_ VDD VSS NAND2_X1
X_22597_ _00560_ _05079_ _05589_ VDD VSS NAND2_X1
X_22598_ _04461_ _04502_ _05590_ VDD VSS NAND2_X1
X_22599_ _10493_ _05589_ _05590_ _05591_ VDD VSS AOI21_X2
X_22600_ _03449_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[38\]
+ _12102_ _05592_ VDD VSS OAI21_X1
X_22601_ _04351_ _04359_ _15887_ _04983_ _15886_ _05593_ VDD
+ VSS AOI221_X2
X_22602_ _05593_ _04370_ _15890_ _05594_ VDD VSS AOI21_X1
X_22603_ _05594_ _04825_ alu_adder_result_ex\[6\] _05595_
+ VDD VSS AOI21_X1
X_22604_ _04393_ _05591_ _05592_ _05595_ _04390_ _05596_ VDD
+ VSS OAI221_X1
X_22605_ _05596_ _05597_ VDD VSS INV_X1
X_22606_ _05597_ _05439_ _04952_ _04688_ _04939_ _05598_ VDD
+ VSS OAI221_X2
X_22607_ _04741_ _04743_ net90 cs_registers_i.mtval_q\[6\]
+ _04747_ _05599_ VDD VSS AOI221_X1
X_22608_ cs_registers_i.mscratch_q\[6\] _04738_ _04749_ cs_registers_i.dscratch1_q\[6\]
+ _05600_ VDD VSS AOI22_X1
X_22609_ _01166_ _05601_ VDD VSS INV_X1
X_22610_ _11072_ _03498_ _05602_ VDD VSS NOR2_X1
X_22611_ _05601_ _04736_ _05602_ cs_registers_i.dcsr_q\[6\]
+ _05603_ VDD VSS AOI22_X1
X_22612_ cs_registers_i.dscratch0_q\[6\] _04731_ _04748_ cs_registers_i.csr_mepc_o\[6\]
+ _05604_ VDD VSS AOI22_X1
X_22613_ _05599_ _05600_ _05603_ _05604_ _05605_ VDD VSS AND4_X1
X_22614_ cs_registers_i.mcycle_counter_i.counter\[6\] _05606_
+ VDD VSS CLKBUF_X2
X_22615_ cs_registers_i.mhpmcounter\[2\]\[6\] _05607_ VDD
+ VSS BUF_X2
X_22616_ _05606_ _04551_ _04554_ _05607_ _05608_ VDD VSS AOI22_X2
X_22617_ cs_registers_i.mcycle_counter_i.counter\[38\] _05609_
+ VDD VSS BUF_X2
X_22618_ _05609_ _04551_ _04554_ cs_registers_i.mhpmcounter\[2\]\[38\]
+ _05610_ VDD VSS AOI22_X4
X_22619_ _05605_ _05608_ _03532_ _04756_ _05610_ _05611_ VDD
+ VSS OAI221_X2
X_22620_ _05598_ _05611_ _04563_ _05612_ VDD VSS OAI21_X2
X_22621_ _05588_ _05612_ _04906_ _05613_ VDD VSS OAI21_X4
X_22622_ _05613_ _05614_ VDD VSS BUF_X2
X_22623_ _05614_ gen_regfile_ff.register_file_i.rf_reg\[966\]
+ _05376_ _01203_ VDD VSS MUX2_X1
X_22624_ _04585_ _04573_ _05615_ VDD VSS NOR2_X1
X_22625_ _04593_ load_store_unit_i.rdata_q\[31\] load_store_unit_i.rdata_q\[23\]
+ _05615_ _05616_ VDD VSS AOI22_X1
X_22626_ _04589_ _04573_ load_store_unit_i.rdata_q\[31\] net52
+ _04565_ _05617_ VDD VSS AOI221_X1
X_22627_ _04593_ _04568_ _04858_ _05618_ VDD VSS AOI21_X1
X_22628_ _05270_ _05616_ _05617_ _05618_ _05619_ VDD VSS OAI22_X1
X_22629_ load_store_unit_i.rdata_q\[15\] net35 _04858_ _05620_
+ VDD VSS MUX2_X1
X_22630_ net57 _05620_ _04593_ _05621_ VDD VSS MUX2_X1
X_22631_ _05619_ _05621_ _04619_ _05622_ VDD VSS MUX2_X1
X_22632_ _04263_ _05622_ _05623_ VDD VSS NOR2_X2
X_22633_ _04688_ _04876_ _04884_ _05624_ VDD VSS AOI21_X2
X_22634_ cs_registers_i.mcycle_counter_i.counter\[39\] _05625_
+ VDD VSS BUF_X2
X_22635_ _05625_ _04550_ _04553_ cs_registers_i.mhpmcounter\[2\]\[39\]
+ _05626_ VDD VSS AOI22_X2
X_22636_ _04557_ _05626_ _05627_ VDD VSS NOR2_X1
X_22637_ cs_registers_i.mcycle_counter_i.counter\[7\] _05628_
+ VDD VSS CLKBUF_X2
X_22638_ _05628_ _04752_ _04753_ cs_registers_i.mhpmcounter\[2\]\[7\]
+ _05629_ VDD VSS AOI22_X2
X_22639_ _04559_ _05629_ _05630_ VDD VSS NOR2_X1
X_22640_ net143 _04518_ _05022_ cs_registers_i.mtval_q\[7\]
+ _05631_ VDD VSS AOI22_X2
X_22641_ cs_registers_i.mscratch_q\[7\] _04524_ _05074_ cs_registers_i.csr_mepc_o\[7\]
+ _05632_ VDD VSS AOI22_X1
X_22642_ _05631_ _05632_ _05633_ VDD VSS NAND2_X1
X_22643_ cs_registers_i.dscratch0_q\[7\] _04771_ net249 cs_registers_i.dcsr_q\[7\]
+ _05634_ VDD VSS AOI22_X1
X_22644_ _05231_ _04775_ cs_registers_i.dscratch1_q\[7\] _05635_
+ VDD VSS AOI21_X1
X_22645_ cs_registers_i.csr_depc_o\[7\] _04773_ _05636_ VDD
+ VSS NAND2_X1
X_22646_ cs_registers_i.mie_q\[16\] _04514_ _05487_ cs_registers_i.mstack_d\[2\]
+ net91 _05490_ _05637_ VDD VSS AOI222_X2
X_22647_ _05634_ _05635_ _05636_ _05637_ _05638_ VDD VSS NAND4_X2
X_22648_ _05627_ _05630_ _05633_ _05638_ _05639_ VDD VSS OR4_X4
X_22649_ _15895_ _15894_ _04363_ _05640_ VDD VSS MUX2_X1
X_22650_ _04665_ _05640_ _05641_ VDD VSS NAND2_X1
X_22651_ _05641_ _04665_ _15898_ _05642_ VDD VSS OAI21_X1
X_22652_ alu_adder_result_ex\[7\] _04825_ _05642_ _05562_
+ _05643_ VDD VSS AOI22_X1
X_22653_ _04867_ _05529_ _05644_ VDD VSS NAND2_X1
X_22654_ _04391_ _05643_ _05644_ _05645_ VDD VSS AOI21_X2
X_22655_ _05079_ _04631_ _05646_ VDD VSS NOR2_X1
X_22656_ _05646_ _04626_ _00561_ _05647_ VDD VSS AOI21_X1
X_22657_ net306 _05647_ _05648_ VDD VSS NOR2_X1
X_22658_ _03449_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[39\]
+ _12103_ _05649_ VDD VSS OAI21_X1
X_22659_ _05648_ _05649_ _05650_ VDD VSS NOR2_X2
X_22660_ _05624_ _05639_ _05645_ _05650_ _05651_ VDD VSS NOR4_X4
X_22661_ _05623_ _05651_ _04600_ _05652_ VDD VSS AOI21_X4
X_22662_ _05652_ _05653_ VDD VSS BUF_X2
X_22663_ _05653_ gen_regfile_ff.register_file_i.rf_reg\[967\]
+ _05376_ _01204_ VDD VSS MUX2_X1
X_22664_ gen_regfile_ff.register_file_i.rf_reg\[968\] _05416_
+ _05654_ VDD VSS NAND2_X1
X_22665_ _04860_ _04862_ _05268_ _05655_ VDD VSS MUX2_X1
X_22666_ net58 load_store_unit_i.rdata_q\[16\] _04585_ _05656_
+ VDD VSS MUX2_X1
X_22667_ load_store_unit_i.rdata_q\[24\] net29 _04585_ _05657_
+ VDD VSS MUX2_X1
X_22668_ _05656_ _05657_ _05268_ _05658_ VDD VSS MUX2_X1
X_22669_ _04574_ _05655_ _05658_ _04582_ _05659_ VDD VSS AOI22_X2
X_22670_ _04263_ _04572_ _05659_ _05660_ VDD VSS AOI21_X2
X_22671_ _03493_ _04456_ _05475_ _05661_ VDD VSS AOI21_X4
X_22672_ _00562_ _04463_ _05662_ VDD VSS NOR2_X1
X_22673_ _04624_ _04886_ _05663_ VDD VSS NOR2_X1
X_22674_ _10310_ _05662_ _05663_ _05664_ VDD VSS NOR3_X4
X_22675_ _03449_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[40\]
+ _11432_ _05665_ VDD VSS OAI21_X1
X_22676_ _15903_ _15902_ _04362_ _05666_ VDD VSS MUX2_X1
X_22677_ _04664_ _05666_ _05667_ VDD VSS NAND2_X1
X_22678_ _05667_ _04664_ _15906_ _05668_ VDD VSS OAI21_X1
X_22679_ alu_adder_result_ex\[8\] _04368_ _05668_ _05562_
+ _05669_ VDD VSS AOI22_X1
X_22680_ _05661_ _05664_ _05665_ _05669_ _04390_ _05670_ VDD
+ VSS OAI221_X2
X_22681_ _04725_ _04987_ _05671_ VDD VSS NOR2_X1
X_22682_ _05670_ _05671_ _04684_ _04457_ _04678_ _05672_ VDD
+ VSS AOI221_X2
X_22683_ _04688_ _04724_ _05673_ VDD VSS OR2_X1
X_22684_ cs_registers_i.mtval_q\[8\] _04521_ _04544_ cs_registers_i.csr_mepc_o\[8\]
+ cs_registers_i.mscratch_q\[8\] _04524_ _05674_ VDD VSS AOI222_X2
X_22685_ _05674_ _05675_ VDD VSS INV_X1
X_22686_ cs_registers_i.mcycle_counter_i.counter\[40\] _04784_
+ _04785_ cs_registers_i.mhpmcounter\[2\]\[40\] _05676_ VDD
+ VSS AOI22_X2
X_22687_ _05031_ _05676_ _05677_ VDD VSS NOR2_X2
X_22688_ cs_registers_i.mcycle_counter_i.counter\[8\] _04550_
+ _04553_ cs_registers_i.mhpmcounter\[2\]\[8\] _05678_ VDD VSS
+ AOI22_X2
X_22689_ _04559_ _05678_ _05679_ VDD VSS NOR2_X1
X_22690_ cs_registers_i.dscratch0_q\[8\] _04511_ _04530_ cs_registers_i.dscratch1_q\[8\]
+ _05680_ VDD VSS AOI22_X4
X_22691_ net92 _04528_ _04968_ cs_registers_i.csr_depc_o\[8\]
+ _05681_ VDD VSS AOI22_X2
X_22692_ _01167_ _05682_ VDD VSS INV_X1
X_22693_ _05682_ _05199_ net249 cs_registers_i.dcsr_q\[8\]
+ _05683_ VDD VSS AOI22_X4
X_22694_ _04247_ _05680_ _05681_ _05683_ _05684_ VDD VSS NAND4_X4
X_22695_ _05675_ _05677_ _05679_ _05684_ _05685_ VDD VSS NOR4_X4
X_22696_ _05672_ _05673_ _05685_ _04662_ _05686_ VDD VSS AOI22_X4
X_22697_ _05660_ _05686_ _04764_ _05687_ VDD VSS AOI21_X4
X_22698_ _05687_ _05688_ VDD VSS CLKBUF_X3
X_22699_ _05654_ _05688_ _05465_ _01205_ VDD VSS OAI21_X1
X_22700_ _04912_ _04913_ _05513_ _05689_ VDD VSS MUX2_X1
X_22701_ net59 load_store_unit_i.rdata_q\[17\] _04911_ _05690_
+ VDD VSS MUX2_X1
X_22702_ load_store_unit_i.rdata_q\[25\] net40 _04911_ _05691_
+ VDD VSS MUX2_X1
X_22703_ _05690_ _05691_ _05513_ _05692_ VDD VSS MUX2_X1
X_22704_ _04574_ _05689_ _05692_ _04581_ _05693_ VDD VSS AOI22_X1
X_22705_ _04572_ _05693_ _05694_ VDD VSS NAND2_X1
X_22706_ _04276_ _04459_ _05695_ VDD VSS NAND2_X1
X_22707_ _04455_ _05695_ _05696_ VDD VSS OR2_X1
X_22708_ _04457_ _04308_ _04346_ _04307_ _04299_ _05697_ VDD
+ VSS OAI221_X1
X_22709_ _00563_ _04463_ _05698_ VDD VSS NOR2_X1
X_22710_ _04625_ _04943_ _05699_ VDD VSS NOR2_X1
X_22711_ _10493_ _05698_ _05699_ _05700_ VDD VSS NOR3_X2
X_22712_ _03449_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[41\]
+ _11432_ _05701_ VDD VSS OAI21_X1
X_22713_ _04351_ _04358_ _15911_ _04362_ _15910_ _05702_ VDD
+ VSS AOI221_X1
X_22714_ _05702_ _04353_ _15914_ _05703_ VDD VSS AOI21_X1
X_22715_ _05703_ _04369_ alu_adder_result_ex\[9\] _05704_
+ VDD VSS AOI21_X1
X_22716_ _04393_ _05700_ _05701_ _05704_ _04390_ _05705_ VDD
+ VSS OAI221_X1
X_22717_ _05705_ _05706_ VDD VSS INV_X1
X_22718_ _05697_ _05706_ _05707_ VDD VSS AND2_X1
X_22719_ cs_registers_i.mhpmcounter\[2\]\[41\] _05708_ VDD
+ VSS BUF_X2
X_22720_ cs_registers_i.mcycle_counter_i.counter\[41\] _04959_
+ _04960_ _05708_ _05709_ VDD VSS AOI22_X2
X_22721_ _04558_ _05709_ _05710_ VDD VSS NOR2_X2
X_22722_ cs_registers_i.mcycle_counter_i.counter\[9\] _04752_
+ _04753_ cs_registers_i.mhpmcounter\[2\]\[9\] _05711_ VDD VSS
+ AOI22_X1
X_22723_ _04559_ _05711_ _05712_ VDD VSS OR2_X1
X_22724_ cs_registers_i.mtval_q\[9\] _04521_ _04544_ cs_registers_i.csr_mepc_o\[9\]
+ _05713_ VDD VSS AOI22_X2
X_22725_ cs_registers_i.dscratch0_q\[9\] _04511_ _04968_ cs_registers_i.csr_depc_o\[9\]
+ _04775_ cs_registers_i.dscratch1_q\[9\] _05714_ VDD VSS AOI222_X2
X_22726_ _04534_ _04537_ _01168_ _05715_ VDD VSS OAI21_X2
X_22727_ _05715_ _04527_ net93 cs_registers_i.mscratch_q\[9\]
+ _04972_ _05716_ VDD VSS AOI221_X2
X_22728_ _05712_ _05713_ _05714_ _05716_ _05717_ VDD VSS NAND4_X2
X_22729_ _05710_ _05717_ _05718_ VDD VSS NOR2_X4
X_22730_ _05696_ _05707_ _05718_ _04662_ _05719_ VDD VSS AOI22_X4
X_22731_ _05694_ _05719_ _04263_ _05720_ VDD VSS MUX2_X2
X_22732_ _05720_ _05721_ VDD VSS BUF_X2
X_22733_ _05721_ gen_regfile_ff.register_file_i.rf_reg\[969\]
+ _05376_ _01206_ VDD VSS MUX2_X1
X_22734_ _00564_ _04997_ _04463_ _05722_ VDD VSS MUX2_X1
X_22735_ _11432_ _05722_ _05723_ VDD VSS NAND2_X1
X_22736_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[42\]
+ _05724_ VDD VSS INV_X1
X_22737_ _11406_ _05724_ _10310_ _05725_ VDD VSS AOI21_X1
X_22738_ _03493_ _05723_ _05725_ _05726_ VDD VSS AOI21_X2
X_22739_ _15919_ _04358_ _04361_ _15918_ _05727_ VDD VSS AOI22_X1
X_22740_ _15922_ _05727_ _04664_ _05728_ VDD VSS MUX2_X1
X_22741_ alu_adder_result_ex\[10\] _04367_ _05475_ _04456_
+ _05729_ VDD VSS AOI22_X1
X_22742_ _05726_ _05728_ _05729_ _05730_ VDD VSS NAND3_X1
X_22743_ _04281_ _04292_ _04990_ _05731_ VDD VSS OAI21_X1
X_22744_ _05122_ _05130_ _04452_ _05732_ VDD VSS MUX2_X1
X_22745_ _05731_ _05732_ _04281_ _05733_ VDD VSS OAI21_X1
X_22746_ _04275_ _04459_ _05734_ VDD VSS AND2_X1
X_22747_ _05730_ _05733_ _05734_ _05480_ _05009_ _05735_ VDD
+ VSS AOI221_X2
X_22748_ cs_registers_i.mtval_q\[10\] _04520_ _04542_ cs_registers_i.csr_mepc_o\[10\]
+ _05736_ VDD VSS AOI22_X2
X_22749_ cs_registers_i.mscratch_q\[10\] _04523_ _05737_ VDD
+ VSS NAND2_X1
X_22750_ cs_registers_i.dscratch0_q\[10\] net248 _04772_ cs_registers_i.csr_depc_o\[10\]
+ _04529_ cs_registers_i.dscratch1_q\[10\] _05738_ VDD VSS AOI222_X2
X_22751_ _01169_ _05739_ VDD VSS INV_X1
X_22752_ _05231_ _05199_ _05739_ net63 _04526_ _05740_ VDD
+ VSS AOI221_X2
X_22753_ _05736_ _05737_ _05738_ _05740_ _05741_ VDD VSS NAND4_X2
X_22754_ cs_registers_i.mcycle_counter_i.counter\[42\] _05742_
+ VDD VSS BUF_X2
X_22755_ _05742_ _04549_ _04552_ cs_registers_i.mhpmcounter\[2\]\[42\]
+ _05743_ VDD VSS AOI22_X2
X_22756_ _05743_ _05744_ VDD VSS INV_X1
X_22757_ _03551_ _04236_ _05745_ VDD VSS NOR2_X4
X_22758_ _03512_ _04234_ _15869_ _05746_ VDD VSS OAI21_X1
X_22759_ _10922_ _03533_ _03514_ _05747_ VDD VSS NAND3_X1
X_22760_ _05746_ _05747_ _05748_ VDD VSS NOR2_X2
X_22761_ cs_registers_i.mcycle_counter_i.counter\[10\] _05749_
+ VDD VSS BUF_X2
X_22762_ cs_registers_i.mhpmcounter\[2\]\[10\] _05750_ VDD
+ VSS BUF_X1
X_22763_ _05749_ _04549_ _04552_ _05750_ _05751_ VDD VSS AOI22_X1
X_22764_ _05751_ _05752_ VDD VSS INV_X1
X_22765_ _05741_ _05744_ _05745_ _05748_ _05752_ _05753_ VDD
+ VSS AOI221_X2
X_22766_ _05735_ _05753_ _04662_ _04391_ _05726_ _05754_ VDD
+ VSS AOI221_X2
X_22767_ _04979_ _04980_ _05513_ _05755_ VDD VSS MUX2_X1
X_22768_ net30 load_store_unit_i.rdata_q\[18\] _04911_ _05756_
+ VDD VSS MUX2_X1
X_22769_ load_store_unit_i.rdata_q\[26\] net50 _04911_ _05757_
+ VDD VSS MUX2_X1
X_22770_ _05756_ _05757_ _05513_ _05758_ VDD VSS MUX2_X1
X_22771_ _04574_ _05755_ _05758_ _04582_ _05759_ VDD VSS AOI22_X1
X_22772_ _04572_ _05759_ _05760_ VDD VSS NAND2_X1
X_22773_ _05754_ _05760_ _04906_ _05761_ VDD VSS MUX2_X2
X_22774_ _05761_ _05762_ VDD VSS BUF_X2
X_22775_ _05762_ gen_regfile_ff.register_file_i.rf_reg\[970\]
+ _05376_ _01207_ VDD VSS MUX2_X1
X_22776_ net31 load_store_unit_i.rdata_q\[19\] _04584_ _05763_
+ VDD VSS MUX2_X1
X_22777_ load_store_unit_i.rdata_q\[27\] net53 _04911_ _05764_
+ VDD VSS MUX2_X1
X_22778_ _05763_ _05764_ _05513_ _05765_ VDD VSS MUX2_X1
X_22779_ _04767_ _04768_ _04570_ _05766_ VDD VSS MUX2_X1
X_22780_ _04582_ _05765_ _05766_ _04574_ _05767_ VDD VSS AOI22_X1
X_22781_ _04611_ _04572_ _05767_ _05768_ VDD VSS AND3_X1
X_22782_ _00565_ _04502_ _05769_ VDD VSS NOR2_X1
X_22783_ _05079_ _04810_ _05770_ VDD VSS NOR2_X1
X_22784_ _10493_ _05769_ _05770_ _05771_ VDD VSS NOR3_X2
X_22785_ _03449_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[43\]
+ _12102_ _05772_ VDD VSS OAI21_X1
X_22786_ _05771_ _05772_ _05773_ VDD VSS NOR2_X1
X_22787_ _04351_ _04359_ _15927_ _04362_ _15926_ _05774_ VDD
+ VSS AOI221_X2
X_22788_ _05774_ _04353_ _15930_ _05775_ VDD VSS AOI21_X1
X_22789_ _05775_ _04369_ alu_adder_result_ex\[11\] _05776_
+ VDD VSS AOI21_X1
X_22790_ _04390_ _05476_ _05776_ _05777_ VDD VSS AOI21_X1
X_22791_ _00550_ _04728_ _05778_ VDD VSS NOR2_X1
X_22792_ _05778_ _04738_ cs_registers_i.mscratch_q\[11\] net126
+ _04742_ _05779_ VDD VSS AOI221_X2
X_22793_ _04741_ _04733_ cs_registers_i.mie_q\[15\] net64
+ _04743_ _05780_ VDD VSS AOI221_X2
X_22794_ cs_registers_i.csr_mepc_o\[11\] _04748_ _04749_ cs_registers_i.dscratch1_q\[11\]
+ _05781_ VDD VSS AOI22_X2
X_22795_ cs_registers_i.csr_depc_o\[11\] _04736_ _04747_ cs_registers_i.mtval_q\[11\]
+ _05782_ VDD VSS AOI22_X2
X_22796_ _05779_ _05780_ _05781_ _05782_ _05783_ VDD VSS NAND4_X2
X_22797_ cs_registers_i.mstack_d\[0\] _15507_ _03525_ _03553_
+ _05784_ VDD VSS AND4_X1
X_22798_ _05784_ _05602_ cs_registers_i.dcsr_q\[11\] cs_registers_i.dscratch0_q\[11\]
+ _04731_ _05785_ VDD VSS AOI221_X2
X_22799_ cs_registers_i.mcycle_counter_i.counter\[43\] _05786_
+ VDD VSS BUF_X2
X_22800_ _05786_ _04549_ _04552_ cs_registers_i.mhpmcounter\[2\]\[43\]
+ _05787_ VDD VSS AOI22_X2
X_22801_ _05785_ _05787_ _04756_ _05788_ VDD VSS OAI21_X1
X_22802_ cs_registers_i.mhpmcounter\[2\]\[11\] _05789_ VDD
+ VSS BUF_X1
X_22803_ cs_registers_i.mcycle_counter_i.counter\[11\] _04549_
+ _04552_ _05789_ _05790_ VDD VSS AOI22_X1
X_22804_ _03532_ _05790_ _05791_ VDD VSS NOR2_X1
X_22805_ _05783_ _05788_ _05791_ _05792_ VDD VSS OR3_X4
X_22806_ _04840_ _04722_ _04831_ _05793_ VDD VSS AND3_X1
X_22807_ _05773_ _05777_ _05792_ _05793_ _05794_ VDD VSS OR4_X1
X_22808_ _04458_ _04820_ _04720_ _05795_ VDD VSS AOI21_X1
X_22809_ _04723_ _05795_ _05796_ VDD VSS NOR2_X1
X_22810_ _05054_ _05049_ _04453_ _05797_ VDD VSS MUX2_X1
X_22811_ _04723_ _05797_ _05798_ VDD VSS AND2_X1
X_22812_ _04688_ _05796_ _05798_ _05799_ VDD VSS NOR3_X1
X_22813_ _05794_ _05799_ _05800_ VDD VSS NOR2_X2
X_22814_ _05768_ _05800_ _04764_ _05801_ VDD VSS AOI21_X4
X_22815_ _05801_ _05802_ VDD VSS BUF_X2
X_22816_ _05802_ gen_regfile_ff.register_file_i.rf_reg\[971\]
+ _05376_ _01208_ VDD VSS MUX2_X1
X_22817_ _04855_ _05803_ VDD VSS CLKBUF_X3
X_22818_ gen_regfile_ff.register_file_i.rf_reg\[125\] _05803_
+ _05804_ VDD VSS NAND2_X1
X_22819_ _05413_ _05805_ VDD VSS BUF_X4
X_22820_ _04852_ _05805_ _05806_ VDD VSS NAND2_X1
X_22821_ _05804_ _05148_ _05806_ _01209_ VDD VSS OAI21_X1
X_22822_ gen_regfile_ff.register_file_i.rf_reg\[972\] _05416_
+ _05807_ VDD VSS NAND2_X1
X_22823_ _05038_ _05039_ _04596_ _05808_ VDD VSS MUX2_X1
X_22824_ net32 load_store_unit_i.rdata_q\[20\] _04593_ _05809_
+ VDD VSS MUX2_X1
X_22825_ load_store_unit_i.rdata_q\[28\] net54 _04593_ _05810_
+ VDD VSS MUX2_X1
X_22826_ _05809_ _05810_ _05268_ _05811_ VDD VSS MUX2_X1
X_22827_ _04574_ _05808_ _05811_ _04582_ _05812_ VDD VSS AOI22_X2
X_22828_ _04600_ _04572_ _05812_ _05813_ VDD VSS AOI21_X2
X_22829_ _00566_ _04625_ _05814_ VDD VSS NAND2_X1
X_22830_ _05814_ _05082_ _05079_ _05815_ VDD VSS OAI21_X1
X_22831_ _12102_ _05815_ _05816_ VDD VSS NAND2_X1
X_22832_ _05816_ _05817_ VDD VSS INV_X1
X_22833_ _03449_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[44\]
+ _12102_ _05818_ VDD VSS OAI21_X2
X_22834_ _04457_ _04723_ _05819_ VDD VSS NAND2_X1
X_22835_ _05661_ _05817_ _05818_ _05819_ _05055_ _05820_ VDD
+ VSS OAI221_X2
X_22836_ _15935_ _15934_ _04363_ _05821_ VDD VSS MUX2_X1
X_22837_ _04665_ _05821_ _05822_ VDD VSS NAND2_X1
X_22838_ _05822_ _04665_ _15938_ _05823_ VDD VSS OAI21_X1
X_22839_ alu_adder_result_ex\[12\] _04825_ _05823_ _05562_
+ _05824_ VDD VSS AOI22_X2
X_22840_ _04707_ _04699_ _04828_ _04692_ _05825_ VDD VSS AOI22_X1
X_22841_ _04702_ _04704_ _05826_ VDD VSS NAND2_X1
X_22842_ _05826_ _04711_ _04707_ _05827_ VDD VSS MUX2_X1
X_22843_ _05825_ _05827_ _04720_ _05828_ VDD VSS MUX2_X1
X_22844_ _05120_ _05829_ VDD VSS INV_X1
X_22845_ _04674_ _04830_ _04720_ _05830_ VDD VSS MUX2_X1
X_22846_ _04308_ _04276_ _05831_ VDD VSS NAND2_X1
X_22847_ _05824_ _05828_ _05829_ _05830_ _05831_ _05832_ VDD
+ VSS OAI221_X1
X_22848_ _05820_ _05832_ _04815_ _05833_ VDD VSS AOI21_X1
X_22849_ cs_registers_i.mscratch_q\[12\] _04972_ _04543_ cs_registers_i.csr_mepc_o\[12\]
+ _05834_ VDD VSS AOI22_X1
X_22850_ cs_registers_i.mtval_q\[12\] _04520_ _05835_ VDD
+ VSS NAND2_X1
X_22851_ _04247_ _05834_ _05835_ _05836_ VDD VSS AND3_X1
X_22852_ cs_registers_i.dscratch1_q\[12\] _04775_ _04773_
+ cs_registers_i.csr_depc_o\[12\] _05487_ cs_registers_i.mstack_d\[1\]
+ _05837_ VDD VSS AOI222_X2
X_22853_ net65 _05490_ net249 cs_registers_i.dcsr_q\[12\]
+ _05838_ VDD VSS AOI22_X1
X_22854_ _03501_ _15873_ _03542_ _05839_ VDD VSS NAND3_X1
X_22855_ _03563_ _04512_ _05839_ _05840_ VDD VSS NOR3_X2
X_22856_ _00549_ _05841_ VDD VSS INV_X1
X_22857_ cs_registers_i.dscratch0_q\[12\] _04771_ _05840_
+ _05841_ _05842_ VDD VSS AOI22_X1
X_22858_ _05836_ _05837_ _05838_ _05842_ _05843_ VDD VSS AND4_X1
X_22859_ cs_registers_i.mcycle_counter_i.counter\[44\] _04959_
+ _04960_ cs_registers_i.mhpmcounter\[2\]\[44\] _05844_ VDD
+ VSS AOI22_X4
X_22860_ cs_registers_i.mcycle_counter_i.counter\[12\] _04959_
+ _04960_ cs_registers_i.mhpmcounter\[2\]\[12\] _05845_ VDD
+ VSS AOI22_X2
X_22861_ _05843_ _05844_ _05031_ _04560_ _05845_ _05846_ VDD
+ VSS OAI221_X2
X_22862_ _04563_ _05846_ _05847_ VDD VSS NOR2_X2
X_22863_ _04906_ _05833_ _05847_ _05848_ VDD VSS NOR3_X2
X_22864_ _05813_ _05848_ _05849_ VDD VSS NOR2_X2
X_22865_ _05849_ _05850_ VDD VSS CLKBUF_X3
X_22866_ _05807_ _05850_ _05465_ _01210_ VDD VSS OAI21_X1
X_22867_ _05096_ _05097_ _05513_ _05851_ VDD VSS MUX2_X1
X_22868_ net33 load_store_unit_i.rdata_q\[21\] _04585_ _05852_
+ VDD VSS MUX2_X1
X_22869_ load_store_unit_i.rdata_q\[29\] net55 _04585_ _05853_
+ VDD VSS MUX2_X1
X_22870_ _05852_ _05853_ _05513_ _05854_ VDD VSS MUX2_X1
X_22871_ _04574_ _05851_ _05854_ _04582_ _05855_ VDD VSS AOI22_X2
X_22872_ _04572_ _05855_ _05856_ VDD VSS NAND2_X1
X_22873_ _04611_ _05856_ _05857_ VDD VSS NAND2_X1
X_22874_ _10310_ _04623_ _05858_ VDD VSS NOR2_X2
X_22875_ _05104_ _05858_ _05859_ VDD VSS NAND2_X1
X_22876_ _05859_ _05858_ _04023_ _05860_ VDD VSS OAI21_X2
X_22877_ _15946_ _05861_ VDD VSS INV_X1
X_22878_ _05861_ _04351_ _04367_ alu_adder_result_ex\[13\]
+ _05862_ VDD VSS AOI22_X1
X_22879_ _15943_ _04359_ _04362_ _15942_ _05863_ VDD VSS AOI22_X1
X_22880_ _05862_ _05863_ _04351_ _05864_ VDD VSS OAI21_X1
X_22881_ _03493_ _11401_ _05860_ _05864_ _04814_ _05865_ VDD
+ VSS AOI221_X2
X_22882_ _05865_ _05866_ VDD VSS INV_X1
X_22883_ _05008_ _05010_ _04453_ _05867_ VDD VSS MUX2_X1
X_22884_ _04412_ _04687_ _05868_ VDD VSS NOR2_X1
X_22885_ _05866_ _05867_ _05120_ _05119_ _05868_ _05869_ VDD
+ VSS AOI221_X2
X_22886_ _04410_ _04916_ _04917_ _05870_ VDD VSS NAND3_X1
X_22887_ _05870_ _04331_ _04431_ _05871_ VDD VSS OAI21_X1
X_22888_ _04990_ _05871_ _04453_ _05872_ VDD VSS MUX2_X1
X_22889_ _05475_ _05872_ _04723_ _05873_ VDD VSS AOI21_X1
X_22890_ _05869_ _05873_ _04725_ _05874_ VDD VSS OAI21_X2
X_22891_ cs_registers_i.mcycle_counter_i.counter\[45\] _05875_
+ VDD VSS BUF_X2
X_22892_ _05875_ _04959_ _04960_ cs_registers_i.mhpmcounter\[2\]\[45\]
+ _05876_ VDD VSS AOI22_X2
X_22893_ _04558_ _05876_ _05877_ VDD VSS NOR2_X1
X_22894_ cs_registers_i.mhpmcounter\[2\]\[13\] _05878_ VDD
+ VSS BUF_X1
X_22895_ cs_registers_i.mcycle_counter_i.counter\[13\] _04963_
+ _04964_ _05878_ _05879_ VDD VSS AOI22_X1
X_22896_ _04783_ _05879_ _05880_ VDD VSS NOR2_X1
X_22897_ cs_registers_i.mscratch_q\[13\] _04524_ _04521_ cs_registers_i.mtval_q\[13\]
+ _05881_ VDD VSS AOI22_X2
X_22898_ cs_registers_i.dscratch1_q\[13\] _04530_ _04968_
+ cs_registers_i.csr_depc_o\[13\] _05882_ VDD VSS AOI22_X2
X_22899_ net66 _04528_ net249 cs_registers_i.dcsr_q\[13\]
+ _05883_ VDD VSS AOI22_X2
X_22900_ _04534_ _04537_ _01170_ _05884_ VDD VSS OAI21_X1
X_22901_ _05884_ _04543_ cs_registers_i.csr_mepc_o\[13\] cs_registers_i.dscratch0_q\[13\]
+ _04771_ _05885_ VDD VSS AOI221_X2
X_22902_ _05881_ _05882_ _05883_ _05885_ _05886_ VDD VSS NAND4_X2
X_22903_ _05877_ _05880_ _05886_ _05887_ VDD VSS OR3_X2
X_22904_ _05874_ _05887_ _04563_ _05888_ VDD VSS OAI21_X2
X_22905_ _05857_ _05888_ _04906_ _05889_ VDD VSS OAI21_X4
X_22906_ _05889_ _05890_ VDD VSS BUF_X2
X_22907_ _05890_ gen_regfile_ff.register_file_i.rf_reg\[973\]
+ _05376_ _01211_ VDD VSS MUX2_X1
X_22908_ net34 load_store_unit_i.rdata_q\[22\] _04584_ _05891_
+ VDD VSS MUX2_X1
X_22909_ load_store_unit_i.rdata_q\[30\] net56 _04911_ _05892_
+ VDD VSS MUX2_X1
X_22910_ _05891_ _05892_ _04570_ _05893_ VDD VSS MUX2_X1
X_22911_ _05206_ _05207_ _04570_ _05894_ VDD VSS MUX2_X1
X_22912_ _04582_ _05893_ _05894_ _04574_ _05895_ VDD VSS AOI22_X1
X_22913_ _04905_ _04572_ _05895_ _05896_ VDD VSS AND3_X1
X_22914_ _04026_ _05858_ _05897_ VDD VSS NOR2_X1
X_22915_ _05897_ _05858_ _05158_ _05898_ VDD VSS AOI21_X1
X_22916_ _11407_ _05898_ _05899_ VDD VSS NOR2_X2
X_22917_ _04725_ _04411_ _04670_ _05900_ VDD VSS NOR3_X1
X_22918_ _04457_ _04685_ _04432_ _05901_ VDD VSS AND3_X1
X_22919_ _05477_ _05899_ _05900_ _05901_ _05902_ VDD VSS NOR4_X2
X_22920_ _04293_ _04298_ _04928_ _05903_ VDD VSS OR3_X1
X_22921_ _04307_ _04298_ _04293_ _05904_ VDD VSS OAI21_X1
X_22922_ _04722_ _05903_ _05904_ _05905_ VDD VSS AOI21_X1
X_22923_ _04308_ _04720_ _04924_ _05906_ VDD VSS AOI21_X1
X_22924_ _04340_ _04720_ _05907_ VDD VSS OR2_X1
X_22925_ _05905_ _05906_ _05907_ _05908_ VDD VSS AOI21_X2
X_22926_ _15951_ _15950_ _04363_ _05909_ VDD VSS MUX2_X1
X_22927_ _04665_ _05909_ _05910_ VDD VSS NAND2_X1
X_22928_ _05910_ _04665_ _15954_ _05911_ VDD VSS OAI21_X1
X_22929_ alu_adder_result_ex\[14\] _04825_ _05911_ _05562_
+ _05912_ VDD VSS AOI22_X2
X_22930_ _05902_ _05908_ _04688_ _05912_ _04391_ _05913_ VDD
+ VSS OAI221_X2
X_22931_ cs_registers_i.mhpmcounter\[2\]\[46\] _05914_ VDD
+ VSS CLKBUF_X3
X_22932_ cs_registers_i.mcycle_counter_i.counter\[46\] _04959_
+ _04960_ _05914_ _05915_ VDD VSS AOI22_X4
X_22933_ _05031_ _05915_ _05916_ VDD VSS NOR2_X2
X_22934_ cs_registers_i.mcycle_counter_i.counter\[14\] _04963_
+ _04964_ cs_registers_i.mhpmcounter\[2\]\[14\] _05917_ VDD
+ VSS AOI22_X1
X_22935_ _04783_ _05917_ _05918_ VDD VSS NOR2_X1
X_22936_ cs_registers_i.mtval_q\[14\] _04521_ _04544_ cs_registers_i.csr_mepc_o\[14\]
+ _05919_ VDD VSS AOI22_X1
X_22937_ cs_registers_i.dscratch0_q\[14\] _04511_ _04968_
+ cs_registers_i.csr_depc_o\[14\] _04775_ cs_registers_i.dscratch1_q\[14\]
+ _05920_ VDD VSS AOI222_X2
X_22938_ _04534_ _04537_ _01171_ _05921_ VDD VSS OAI21_X1
X_22939_ _05921_ _04527_ net67 cs_registers_i.mscratch_q\[14\]
+ _04972_ _05922_ VDD VSS AOI221_X2
X_22940_ _05919_ _05920_ _05922_ _05923_ VDD VSS NAND3_X2
X_22941_ _05916_ _05918_ _05923_ _05924_ VDD VSS NOR3_X4
X_22942_ _05924_ _05925_ VDD VSS INV_X1
X_22943_ _05913_ _05925_ _04563_ _05926_ VDD VSS OAI21_X2
X_22944_ _05896_ _05926_ _04600_ _05927_ VDD VSS AOI21_X4
X_22945_ _05927_ _05928_ VDD VSS BUF_X2
X_22946_ _05375_ _05929_ VDD VSS BUF_X4
X_22947_ _05928_ gen_regfile_ff.register_file_i.rf_reg\[974\]
+ _05929_ _01212_ VDD VSS MUX2_X1
X_22948_ _05513_ _04589_ net52 _05930_ VDD VSS NAND3_X1
X_22949_ _04577_ _04586_ _04568_ _05931_ VDD VSS NAND3_X1
X_22950_ _05271_ _05930_ _05931_ _05932_ VDD VSS AOI21_X1
X_22951_ _04577_ load_store_unit_i.rdata_q\[23\] _04581_ _05933_
+ VDD VSS AND3_X1
X_22952_ _04594_ _05932_ _05933_ _05934_ VDD VSS OAI21_X1
X_22953_ _05268_ _04586_ net57 _05935_ VDD VSS AND3_X1
X_22954_ _04577_ _04589_ net35 _05936_ VDD VSS AND3_X1
X_22955_ _05272_ _05935_ _05936_ _05937_ VDD VSS OAI21_X1
X_22956_ _04589_ load_store_unit_i.rdata_q\[31\] _04581_ _05938_
+ VDD VSS AND3_X1
X_22957_ _05421_ _05932_ _05938_ _05939_ VDD VSS OAI21_X1
X_22958_ _04572_ _05934_ _05937_ _05939_ _05940_ VDD VSS NAND4_X1
X_22959_ _15958_ _05941_ VDD VSS INV_X1
X_22960_ _05941_ _04352_ _04367_ alu_adder_result_ex\[15\]
+ _05942_ VDD VSS AOI22_X1
X_22961_ _15959_ _04360_ _04983_ _15962_ _05943_ VDD VSS AOI22_X1
X_22962_ _05942_ _05943_ _04353_ _05944_ VDD VSS OAI21_X1
X_22963_ _04814_ _05944_ _05945_ VDD VSS NAND2_X1
X_22964_ _00659_ _05219_ _05858_ _05946_ VDD VSS MUX2_X1
X_22965_ _11407_ _05946_ _05947_ VDD VSS OR2_X2
X_22966_ _05661_ _05945_ _05947_ _05948_ VDD VSS AND3_X2
X_22967_ _04840_ _04722_ _05949_ VDD VSS NAND2_X1
X_22968_ _04429_ _04326_ _05950_ VDD VSS NAND2_X1
X_22969_ _04431_ _04698_ _05951_ VDD VSS NOR2_X1
X_22970_ _05950_ _05951_ _04705_ _04707_ _05952_ VDD VSS AOI22_X1
X_22971_ _04695_ _05952_ _04453_ _05953_ VDD VSS MUX2_X1
X_22972_ _04399_ _04675_ _05954_ VDD VSS NOR2_X1
X_22973_ _04333_ _04292_ _05955_ VDD VSS NOR2_X1
X_22974_ _04307_ _05954_ _05955_ _05956_ VDD VSS AOI21_X1
X_22975_ _05948_ _05949_ _05953_ _05831_ _05956_ _05957_ VDD
+ VSS OAI221_X1
X_22976_ _04684_ _04883_ _04720_ _05958_ VDD VSS MUX2_X1
X_22977_ _05957_ _05958_ _05120_ _05959_ VDD VSS AOI21_X2
X_22978_ cs_registers_i.mscratch_q\[15\] _04524_ _05022_ cs_registers_i.mtval_q\[15\]
+ _05960_ VDD VSS AOI22_X1
X_22979_ cs_registers_i.dscratch1_q\[15\] _04775_ net249 cs_registers_i.dcsr_q\[15\]
+ _05961_ VDD VSS AOI22_X1
X_22980_ net68 _04528_ _04773_ cs_registers_i.csr_depc_o\[15\]
+ _05962_ VDD VSS AOI22_X1
X_22981_ _04533_ _04536_ _01172_ _05963_ VDD VSS OAI21_X1
X_22982_ _05963_ _04543_ cs_registers_i.csr_mepc_o\[15\] cs_registers_i.dscratch0_q\[15\]
+ _04510_ _05964_ VDD VSS AOI221_X2
X_22983_ _05960_ _05961_ _05962_ _05964_ _05965_ VDD VSS AND4_X1
X_22984_ cs_registers_i.mcycle_counter_i.counter\[47\] _05966_
+ VDD VSS BUF_X2
X_22985_ cs_registers_i.mhpmcounter\[2\]\[47\] _05967_ VDD
+ VSS BUF_X2
X_22986_ _05966_ _04784_ _04785_ _05967_ _05968_ VDD VSS AOI22_X4
X_22987_ cs_registers_i.mcycle_counter_i.counter\[15\] _04963_
+ _04964_ cs_registers_i.mhpmcounter\[2\]\[15\] _05969_ VDD
+ VSS AOI22_X2
X_22988_ _05965_ _05968_ _04557_ _04783_ _05969_ _05970_ VDD
+ VSS OAI221_X2
X_22989_ _04393_ _05970_ _05971_ VDD VSS NOR2_X1
X_22990_ _05959_ _05971_ _05972_ VDD VSS NOR2_X1
X_22991_ _05940_ _05972_ _04263_ _05973_ VDD VSS MUX2_X2
X_22992_ _05973_ _05974_ VDD VSS BUF_X4
X_22993_ _05974_ gen_regfile_ff.register_file_i.rf_reg\[975\]
+ _05929_ _01213_ VDD VSS MUX2_X1
X_22994_ gen_regfile_ff.register_file_i.rf_reg\[976\] _05416_
+ _05975_ VDD VSS NAND2_X1
X_22995_ net29 net58 _04593_ _05976_ VDD VSS MUX2_X1
X_22996_ _04596_ _05976_ _05977_ VDD VSS NAND2_X1
X_22997_ _05263_ load_store_unit_i.rdata_q\[24\] _04594_ _05978_
+ VDD VSS AOI21_X1
X_22998_ _05977_ _05978_ _05421_ _05979_ VDD VSS OAI21_X1
X_22999_ _04580_ _04582_ _05979_ _05980_ VDD VSS AOI21_X1
X_23000_ _04600_ _05980_ _05981_ VDD VSS NOR2_X2
X_23001_ _04308_ _04307_ _05982_ VDD VSS NAND2_X1
X_23002_ _05982_ _05953_ _04308_ _05983_ VDD VSS OAI21_X1
X_23003_ _04276_ _05983_ _05984_ VDD VSS NAND2_X1
X_23004_ _15553_ _04624_ _05985_ VDD VSS NAND2_X1
X_23005_ _04490_ _04474_ _05986_ VDD VSS NOR2_X1
X_23006_ _05986_ _04492_ _04639_ _05987_ VDD VSS AOI21_X1
X_23007_ _15725_ _05987_ net326 _05988_ VDD VSS AOI21_X2
X_23008_ _15730_ _05988_ _05989_ VDD VSS XNOR2_X2
X_23009_ _04463_ _05989_ _05990_ VDD VSS NAND2_X1
X_23010_ _11432_ _05985_ _05990_ _05991_ VDD VSS NAND3_X2
X_23011_ _11406_ _03670_ _10310_ _05992_ VDD VSS AOI21_X1
X_23012_ _04662_ _05991_ _05992_ _05993_ VDD VSS AOI21_X2
X_23013_ _04351_ _04358_ _15967_ _04362_ _15966_ _05994_ VDD
+ VSS AOI221_X1
X_23014_ _05994_ _04353_ _15970_ _05995_ VDD VSS AOI21_X1
X_23015_ _05995_ _04368_ alu_adder_result_ex\[16\] _05996_
+ VDD VSS AOI21_X1
X_23016_ _05993_ _05996_ _04390_ _05997_ VDD VSS OAI21_X2
X_23017_ _04725_ _04722_ _05998_ VDD VSS NOR2_X1
X_23018_ _04307_ _04676_ _05955_ _05999_ VDD VSS MUX2_X1
X_23019_ _04725_ _04308_ _06000_ VDD VSS NOR2_X1
X_23020_ _05997_ _05998_ _05999_ _05958_ _06000_ _06001_ VDD
+ VSS AOI221_X2
X_23021_ cs_registers_i.mcycle_counter_i.counter\[48\] _04551_
+ _04554_ cs_registers_i.mhpmcounter\[2\]\[48\] _06002_ VDD
+ VSS AOI22_X2
X_23022_ _04558_ _06002_ _06003_ VDD VSS NOR2_X1
X_23023_ cs_registers_i.mcycle_counter_i.counter\[16\] _06004_
+ VDD VSS BUF_X2
X_23024_ _06004_ _04959_ _04960_ cs_registers_i.mhpmcounter\[2\]\[16\]
+ _06005_ VDD VSS AOI22_X1
X_23025_ _04560_ _06005_ _06006_ VDD VSS NOR2_X1
X_23026_ cs_registers_i.mie_q\[0\] _04515_ _04968_ cs_registers_i.csr_depc_o\[16\]
+ _06007_ VDD VSS AOI22_X2
X_23027_ cs_registers_i.dscratch0_q\[16\] _04511_ _04530_
+ cs_registers_i.dscratch1_q\[16\] _06008_ VDD VSS AOI22_X4
X_23028_ net127 _04518_ _05022_ cs_registers_i.mtval_q\[16\]
+ cs_registers_i.mscratch_q\[16\] _04524_ _06009_ VDD VSS AOI222_X2
X_23029_ _04534_ _04537_ _01173_ _06010_ VDD VSS OAI21_X1
X_23030_ _06010_ _04527_ net69 cs_registers_i.csr_mepc_o\[16\]
+ _05074_ _06011_ VDD VSS AOI221_X2
X_23031_ _06007_ _06008_ _06009_ _06011_ _06012_ VDD VSS NAND4_X4
X_23032_ _06003_ _06006_ _06012_ _06013_ VDD VSS NOR3_X4
X_23033_ _05984_ _06001_ _06013_ _04662_ _06014_ VDD VSS AOI22_X4
X_23034_ _05981_ _06014_ _04764_ _06015_ VDD VSS AOI21_X4
X_23035_ _06015_ _06016_ VDD VSS CLKBUF_X3
X_23036_ _05975_ _06016_ _05465_ _01214_ VDD VSS OAI21_X1
X_23037_ _05421_ _05378_ _05383_ _06017_ VDD VSS NAND3_X1
X_23038_ net37 load_store_unit_i.rdata_q\[25\] _04586_ _06018_
+ VDD VSS MUX2_X1
X_23039_ _06017_ _06018_ _05421_ _06019_ VDD VSS OAI21_X1
X_23040_ _06019_ _06020_ VDD VSS INV_X1
X_23041_ _04617_ _06020_ _04583_ _06021_ VDD VSS AOI21_X4
X_23042_ _10310_ _15556_ _04625_ _06022_ VDD VSS AOI21_X1
X_23043_ _04640_ _04642_ _06023_ VDD VSS NAND2_X1
X_23044_ _15700_ _04640_ _04652_ _06024_ VDD VSS NAND3_X1
X_23045_ _04495_ _06023_ _06024_ _06025_ VDD VSS NAND3_X2
X_23046_ _04472_ _06025_ _06026_ VDD VSS XNOR2_X1
X_23047_ _06022_ _06026_ _04626_ _06027_ VDD VSS OAI21_X1
X_23048_ _11407_ _03800_ net305 _06028_ VDD VSS AOI21_X1
X_23049_ _06027_ _06028_ _06029_ VDD VSS NAND2_X1
X_23050_ _04351_ _04359_ _15975_ _04983_ _15974_ _06030_ VDD
+ VSS AOI221_X1
X_23051_ _06030_ _04370_ _15978_ _06031_ VDD VSS AOI21_X1
X_23052_ _06031_ _04825_ alu_adder_result_ex\[17\] _06032_
+ VDD VSS AOI21_X1
X_23053_ _06029_ _06032_ _04390_ _06033_ VDD VSS OAI21_X1
X_23054_ cs_registers_i.mcycle_counter_i.counter\[49\] _06034_
+ VDD VSS BUF_X2
X_23055_ _06034_ _04549_ _04552_ cs_registers_i.mhpmcounter\[2\]\[49\]
+ _06035_ VDD VSS AOI22_X2
X_23056_ _03551_ _04236_ _06035_ _06036_ VDD VSS NOR3_X1
X_23057_ cs_registers_i.mcycle_counter_i.counter\[17\] _06037_
+ VDD VSS BUF_X2
X_23058_ cs_registers_i.mhpmcounter\[2\]\[17\] _06038_ VDD
+ VSS BUF_X2
X_23059_ _06037_ _04549_ _04552_ _06038_ _06039_ VDD VSS AOI22_X2
X_23060_ _04559_ _06039_ _06040_ VDD VSS NOR2_X1
X_23061_ net133 _04517_ _04543_ cs_registers_i.csr_mepc_o\[17\]
+ _06041_ VDD VSS AOI22_X1
X_23062_ cs_registers_i.mscratch_q\[17\] _04972_ _04520_ cs_registers_i.mtval_q\[17\]
+ _06042_ VDD VSS AOI22_X1
X_23063_ _06041_ _06042_ _06043_ VDD VSS NAND2_X1
X_23064_ cs_registers_i.mie_q\[1\] _04514_ _06044_ VDD VSS
+ AND2_X1
X_23065_ cs_registers_i.dscratch0_q\[17\] _06045_ VDD VSS
+ INV_X1
X_23066_ cs_registers_i.mstatus_q\[1\] _06046_ VDD VSS INV_X1
X_23067_ _06045_ _04509_ _04730_ _05452_ _11072_ _06046_ _06047_
+ VDD VSS OAI33_X1
X_23068_ cs_registers_i.dscratch1_q\[17\] _06048_ VDD VSS
+ INV_X1
X_23069_ _04533_ _04536_ _01174_ _05450_ _06048_ _06049_ VDD
+ VSS OAI221_X1
X_23070_ net70 _06050_ VDD VSS INV_X1
X_23071_ cs_registers_i.csr_depc_o\[17\] _06051_ VDD VSS INV_X1
X_23072_ _06050_ _04256_ _04539_ _06051_ _06052_ VDD VSS OAI22_X1
X_23073_ _06044_ _06047_ _06049_ _06052_ _06053_ VDD VSS OR4_X2
X_23074_ _06036_ _06040_ _06043_ _06053_ _06054_ VDD VSS OR4_X4
X_23075_ _06033_ _06054_ _06055_ VDD VSS NOR2_X1
X_23076_ _06055_ _05908_ _04342_ _06056_ VDD VSS OAI21_X2
X_23077_ _05177_ _04411_ _04293_ _06057_ VDD VSS AOI21_X1
X_23078_ _04723_ _06057_ _06058_ VDD VSS NAND2_X1
X_23079_ _04688_ _05982_ _06058_ _06059_ VDD VSS AOI21_X2
X_23080_ _04906_ _06056_ _06059_ _06060_ VDD VSS NOR3_X4
X_23081_ _06021_ _06060_ _06061_ VDD VSS NOR2_X4
X_23082_ _06061_ _06062_ VDD VSS BUF_X2
X_23083_ _06062_ gen_regfile_ff.register_file_i.rf_reg\[977\]
+ _05929_ _01215_ VDD VSS MUX2_X1
X_23084_ _04596_ _05423_ _05419_ _06063_ VDD VSS NAND3_X1
X_23085_ net38 load_store_unit_i.rdata_q\[26\] _04586_ _06064_
+ VDD VSS MUX2_X1
X_23086_ _06063_ _06064_ _05421_ _06065_ VDD VSS OAI21_X1
X_23087_ _06065_ _06066_ VDD VSS INV_X1
X_23088_ _04617_ _06066_ _04583_ _06067_ VDD VSS AOI21_X4
X_23089_ _15983_ _04359_ _04983_ _15986_ _06068_ VDD VSS AOI22_X1
X_23090_ _15982_ _06068_ _04664_ _06069_ VDD VSS MUX2_X1
X_23091_ _05116_ _06069_ _06070_ VDD VSS NAND2_X1
X_23092_ _06070_ _05872_ _05120_ net378 _04369_ _06071_ VDD
+ VSS AOI221_X2
X_23093_ _04391_ _06071_ _06072_ VDD VSS NOR2_X2
X_23094_ _04308_ _05119_ _06073_ VDD VSS NAND2_X1
X_23095_ _04723_ _05867_ _06074_ VDD VSS NAND2_X1
X_23096_ _04342_ _06073_ _06074_ _06075_ VDD VSS AOI21_X2
X_23097_ _15565_ _05079_ _06076_ VDD VSS AND2_X1
X_23098_ _15738_ _06077_ VDD VSS INV_X1
X_23099_ _06077_ _04498_ _06078_ VDD VSS NAND2_X4
X_23100_ _15745_ _06078_ _06079_ VDD VSS AND2_X4
X_23101_ _15745_ _06078_ _06080_ VDD VSS NOR2_X1
X_23102_ _05079_ _06079_ _06080_ _06081_ VDD VSS NOR3_X2
X_23103_ _04622_ _06076_ _06081_ _06082_ VDD VSS NOR3_X4
X_23104_ _04622_ _03804_ _06083_ VDD VSS AND2_X1
X_23105_ _11408_ _06082_ _06083_ _06084_ VDD VSS NOR3_X4
X_23106_ net134 _04518_ _05074_ cs_registers_i.csr_mepc_o\[18\]
+ cs_registers_i.mscratch_q\[18\] _04523_ _06085_ VDD VSS AOI222_X2
X_23107_ cs_registers_i.dscratch0_q\[18\] _04771_ _04514_
+ cs_registers_i.mie_q\[2\] _06086_ VDD VSS AOI22_X1
X_23108_ net71 _04528_ _04773_ cs_registers_i.csr_depc_o\[18\]
+ _06087_ VDD VSS AOI22_X1
X_23109_ _04533_ _04536_ _01175_ _06088_ VDD VSS OAI21_X1
X_23110_ _06088_ _04520_ cs_registers_i.mtval_q\[18\] cs_registers_i.dscratch1_q\[18\]
+ _04529_ _06089_ VDD VSS AOI221_X1
X_23111_ _06085_ _06086_ _06087_ _06089_ _06090_ VDD VSS AND4_X1
X_23112_ cs_registers_i.mcycle_counter_i.counter\[50\] _06091_
+ VDD VSS BUF_X2
X_23113_ cs_registers_i.mhpmcounter\[2\]\[50\] _06092_ VDD
+ VSS BUF_X2
X_23114_ _06091_ _04963_ _04964_ _06092_ _06093_ VDD VSS AOI22_X2
X_23115_ cs_registers_i.mcycle_counter_i.counter\[18\] _06094_
+ VDD VSS BUF_X2
X_23116_ cs_registers_i.mhpmcounter\[2\]\[18\] _06095_ VDD
+ VSS CLKBUF_X2
X_23117_ _06094_ _04963_ _04964_ _06095_ _06096_ VDD VSS AOI22_X2
X_23118_ _06090_ _06093_ _05031_ _04560_ _06096_ _06097_ VDD
+ VSS OAI221_X2
X_23119_ _06072_ _06075_ _06084_ _06097_ _06098_ VDD VSS NOR4_X4
X_23120_ _06067_ _06098_ _04764_ _06099_ VDD VSS AOI21_X4
X_23121_ _06099_ _06100_ VDD VSS BUF_X2
X_23122_ _06100_ gen_regfile_ff.register_file_i.rf_reg\[978\]
+ _05929_ _01216_ VDD VSS MUX2_X1
X_23123_ gen_regfile_ff.register_file_i.rf_reg\[979\] _05416_
+ _06101_ VDD VSS NAND2_X1
X_23124_ _05949_ _05828_ _06102_ VDD VSS OR2_X1
X_23125_ _04352_ _04360_ _15991_ _04363_ _15990_ _06103_ VDD
+ VSS AOI221_X1
X_23126_ _06103_ _04370_ _15994_ _06104_ VDD VSS AOI21_X1
X_23127_ _06104_ _04825_ alu_adder_result_ex\[19\] _06105_
+ VDD VSS AOI21_X1
X_23128_ _15580_ _06106_ VDD VSS INV_X1
X_23129_ _12102_ _06106_ _04502_ _06107_ VDD VSS OAI21_X2
X_23130_ _04472_ _06025_ _06108_ VDD VSS NAND2_X1
X_23131_ _04466_ _04636_ _06108_ _06109_ VDD VSS AOI21_X2
X_23132_ _15751_ _06109_ _06110_ VDD VSS XOR2_X2
X_23133_ _06107_ _06110_ _04791_ _06111_ VDD VSS AOI21_X4
X_23134_ _03449_ _03806_ _12103_ _06112_ VDD VSS OAI21_X1
X_23135_ _04391_ _06105_ _06111_ _06112_ _06113_ VDD VSS OAI22_X2
X_23136_ _01176_ _04728_ _06114_ VDD VSS NOR2_X1
X_23137_ _06114_ _04731_ cs_registers_i.dscratch0_q\[19\]
+ cs_registers_i.mie_q\[3\] _04733_ _06115_ VDD VSS AOI221_X2
X_23138_ cs_registers_i.csr_depc_o\[19\] _04736_ _04738_ cs_registers_i.mscratch_q\[19\]
+ _06116_ VDD VSS AOI22_X2
X_23139_ _04741_ _04742_ net135 net72 _04743_ _06117_ VDD
+ VSS AOI221_X2
X_23140_ _06115_ _06116_ _06117_ _06118_ VDD VSS NAND3_X2
X_23141_ cs_registers_i.mtval_q\[19\] _04747_ _04748_ cs_registers_i.csr_mepc_o\[19\]
+ _04749_ cs_registers_i.dscratch1_q\[19\] _06119_ VDD VSS AOI222_X2
X_23142_ cs_registers_i.mcycle_counter_i.counter\[51\] _06120_
+ VDD VSS BUF_X2
X_23143_ _06120_ _04784_ _04785_ cs_registers_i.mhpmcounter\[2\]\[51\]
+ _06121_ VDD VSS AOI22_X2
X_23144_ _06119_ _06121_ _04756_ _06122_ VDD VSS OAI21_X1
X_23145_ cs_registers_i.mcycle_counter_i.counter\[19\] _06123_
+ VDD VSS BUF_X2
X_23146_ cs_registers_i.mhpmcounter\[2\]\[19\] _06124_ VDD
+ VSS CLKBUF_X2
X_23147_ _06123_ _04550_ _04553_ _06124_ _06125_ VDD VSS AOI22_X2
X_23148_ _03532_ _06125_ _06126_ VDD VSS NOR2_X1
X_23149_ _06118_ _06122_ _06126_ _06127_ VDD VSS OR3_X4
X_23150_ _04342_ _04723_ _05830_ _06128_ VDD VSS NOR3_X2
X_23151_ _06113_ _06127_ _06128_ _06129_ VDD VSS NOR3_X2
X_23152_ _05982_ _05055_ _04308_ _06130_ VDD VSS OAI21_X1
X_23153_ _04276_ _06130_ _06131_ VDD VSS NAND2_X1
X_23154_ _04600_ _06102_ _06129_ _06131_ _06132_ VDD VSS NAND4_X4
X_23155_ _05421_ _05503_ _05507_ _06133_ VDD VSS NAND3_X1
X_23156_ net39 load_store_unit_i.rdata_q\[27\] _04594_ _06134_
+ VDD VSS MUX2_X1
X_23157_ _06133_ _06134_ _04597_ _06135_ VDD VSS OAI21_X1
X_23158_ _04616_ _04859_ _06135_ _06136_ VDD VSS OAI21_X1
X_23159_ _06132_ _06136_ _04764_ _06137_ VDD VSS OAI21_X2
X_23160_ _06137_ _06138_ VDD VSS CLKBUF_X3
X_23161_ _06101_ _06138_ _05465_ _01217_ VDD VSS OAI21_X1
X_23162_ _04596_ _05515_ _05519_ _06139_ VDD VSS NAND3_X1
X_23163_ net41 load_store_unit_i.rdata_q\[28\] _04586_ _06140_
+ VDD VSS MUX2_X1
X_23164_ _06139_ _06140_ _05421_ _06141_ VDD VSS OAI21_X1
X_23165_ _06141_ _06142_ VDD VSS INV_X1
X_23166_ _04617_ _06142_ _04583_ _06143_ VDD VSS AOI21_X4
X_23167_ _15998_ _04664_ _06144_ VDD VSS NOR2_X1
X_23168_ _15999_ _16002_ _04362_ _06145_ VDD VSS MUX2_X1
X_23169_ _06144_ _06145_ _04664_ _06146_ VDD VSS AOI21_X1
X_23170_ _05116_ _06146_ _04387_ _06147_ VDD VSS OAI21_X1
X_23171_ _06147_ _05120_ _04831_ alu_adder_result_ex\[20\]
+ _04369_ _06148_ VDD VSS AOI221_X1
X_23172_ _04391_ _06148_ _06149_ VDD VSS NOR2_X1
X_23173_ _11407_ _03808_ _04622_ _06150_ VDD VSS AOI21_X1
X_23174_ _15751_ _15744_ _06079_ _06151_ VDD VSS OAI21_X4
X_23175_ _06151_ _04635_ _06152_ VDD VSS NAND2_X2
X_23176_ _06152_ _04465_ _06153_ VDD VSS XNOR2_X2
X_23177_ _15588_ _06153_ _04502_ _06154_ VDD VSS MUX2_X1
X_23178_ _06150_ net306 _06154_ _06155_ VDD VSS OAI21_X4
X_23179_ _06155_ _06156_ VDD VSS INV_X4
X_23180_ cs_registers_i.mscratch_q\[20\] _04524_ _04521_ cs_registers_i.mtval_q\[20\]
+ _06157_ VDD VSS AOI22_X1
X_23181_ net136 _04518_ _04544_ cs_registers_i.csr_mepc_o\[20\]
+ _06158_ VDD VSS AOI22_X1
X_23182_ _06157_ _06158_ _06159_ VDD VSS NAND2_X1
X_23183_ cs_registers_i.mie_q\[4\] _04515_ _04530_ cs_registers_i.dscratch1_q\[20\]
+ _06160_ VDD VSS AOI22_X1
X_23184_ net74 _04528_ _04968_ cs_registers_i.csr_depc_o\[20\]
+ _06161_ VDD VSS AOI22_X2
X_23185_ _06160_ _06161_ _06162_ VDD VSS NAND2_X1
X_23186_ cs_registers_i.dscratch0_q\[20\] _04511_ _06163_
+ VDD VSS NAND2_X1
X_23187_ _01177_ _04537_ _06164_ VDD VSS OR2_X1
X_23188_ _04247_ _06163_ _06164_ _06165_ VDD VSS NAND3_X1
X_23189_ _06159_ _06162_ _06165_ _06166_ VDD VSS NOR3_X2
X_23190_ cs_registers_i.mcycle_counter_i.counter\[52\] _04959_
+ _04960_ cs_registers_i.mhpmcounter\[2\]\[52\] _06167_ VDD
+ VSS AOI22_X2
X_23191_ cs_registers_i.mcycle_counter_i.counter\[20\] _06168_
+ VDD VSS BUF_X2
X_23192_ _06168_ _04551_ _04554_ cs_registers_i.mhpmcounter\[2\]\[20\]
+ _06169_ VDD VSS AOI22_X2
X_23193_ _06166_ _06167_ _05031_ _04560_ _06169_ _06170_ VDD
+ VSS OAI221_X2
X_23194_ _04725_ _05796_ _05798_ _06171_ VDD VSS NOR3_X2
X_23195_ _06149_ _06156_ _06170_ _06171_ _06172_ VDD VSS NOR4_X4
X_23196_ _06143_ _04600_ _06172_ _06173_ VDD VSS AOI21_X4
X_23197_ _06173_ _06174_ VDD VSS BUF_X4
X_23198_ net668 gen_regfile_ff.register_file_i.rf_reg\[980\]
+ _05929_ _01218_ VDD VSS MUX2_X1
X_23199_ _04596_ _05548_ _05552_ _06175_ VDD VSS NAND3_X1
X_23200_ net42 load_store_unit_i.rdata_q\[29\] _04586_ _06176_
+ VDD VSS MUX2_X1
X_23201_ _06175_ _06176_ _05421_ _06177_ VDD VSS OAI21_X1
X_23202_ _06177_ _06178_ VDD VSS INV_X1
X_23203_ _04617_ _06178_ _04582_ _06179_ VDD VSS AOI21_X4
X_23204_ _04633_ _04634_ _04654_ _06180_ VDD VSS NAND3_X1
X_23205_ _04625_ _04655_ _06181_ VDD VSS NOR2_X1
X_23206_ _06180_ _06181_ _06182_ VDD VSS NAND2_X1
X_23207_ net306 _14126_ _05079_ _06183_ VDD VSS AOI21_X1
X_23208_ _11407_ _06182_ _06183_ _00845_ _04622_ _06184_ VDD
+ VSS AOI221_X2
X_23209_ cs_registers_i.mscratch_q\[21\] _04523_ _04543_ cs_registers_i.csr_mepc_o\[21\]
+ _06185_ VDD VSS AOI22_X1
X_23210_ net137 _04517_ _04520_ cs_registers_i.mtval_q\[21\]
+ _06186_ VDD VSS AOI22_X1
X_23211_ _06185_ _06186_ _06187_ VDD VSS AND2_X1
X_23212_ cs_registers_i.dscratch0_q\[21\] _04771_ _04775_
+ cs_registers_i.dscratch1_q\[21\] cs_registers_i.csr_mstatus_tw_o
+ _05487_ _06188_ VDD VSS AOI222_X2
X_23213_ _04534_ _04537_ _01178_ _06189_ VDD VSS OAI21_X1
X_23214_ _06189_ _04515_ cs_registers_i.mie_q\[5\] _06190_
+ VDD VSS AOI21_X1
X_23215_ net75 _04528_ _04773_ cs_registers_i.csr_depc_o\[21\]
+ _06191_ VDD VSS AOI22_X1
X_23216_ _06187_ _06188_ _06190_ _06191_ _06192_ VDD VSS AND4_X1
X_23217_ cs_registers_i.mcycle_counter_i.counter\[53\] _06193_
+ VDD VSS BUF_X2
X_23218_ cs_registers_i.mhpmcounter\[2\]\[53\] _06194_ VDD
+ VSS BUF_X2
X_23219_ _06193_ _04784_ _04785_ _06194_ _06195_ VDD VSS AOI22_X4
X_23220_ cs_registers_i.mcycle_counter_i.counter\[21\] _04963_
+ _04964_ cs_registers_i.mhpmcounter\[2\]\[21\] _06196_ VDD
+ VSS AOI22_X2
X_23221_ _06192_ _06195_ _04557_ _04783_ _06196_ _06197_ VDD
+ VSS OAI221_X2
X_23222_ _16006_ _06198_ VDD VSS INV_X1
X_23223_ _06198_ _04352_ _04368_ alu_adder_result_ex\[21\]
+ _06199_ VDD VSS AOI22_X1
X_23224_ _16007_ _04360_ _04983_ _16010_ _06200_ VDD VSS AOI22_X1
X_23225_ _06199_ _06200_ _04353_ _06201_ VDD VSS OAI21_X1
X_23226_ _06201_ _05120_ _05009_ _04307_ _05868_ _06202_ VDD
+ VSS AOI221_X1
X_23227_ _04391_ _06202_ _06203_ VDD VSS NOR2_X1
X_23228_ _04457_ _04459_ _05733_ _06204_ VDD VSS AND3_X1
X_23229_ _06184_ _06197_ _06203_ _06204_ _06205_ VDD VSS NOR4_X4
X_23230_ _06179_ _06205_ _04600_ _06206_ VDD VSS AOI21_X4
X_23231_ _06206_ _06207_ VDD VSS BUF_X2
X_23232_ _06207_ gen_regfile_ff.register_file_i.rf_reg\[981\]
+ _05929_ _01219_ VDD VSS MUX2_X1
X_23233_ _05210_ _06208_ VDD VSS BUF_X4
X_23234_ gen_regfile_ff.register_file_i.rf_reg\[126\] net675
+ _05415_ _01220_ VDD VSS MUX2_X1
X_23235_ _04602_ gen_regfile_ff.register_file_i.rf_reg\[982\]
+ _05929_ _01221_ VDD VSS MUX2_X1
X_23236_ _04766_ gen_regfile_ff.register_file_i.rf_reg\[983\]
+ _05929_ _01222_ VDD VSS MUX2_X1
X_23237_ gen_regfile_ff.register_file_i.rf_reg\[984\] _05416_
+ _06209_ VDD VSS NAND2_X1
X_23238_ _06209_ _05465_ _04908_ _01223_ VDD VSS OAI21_X1
X_23239_ gen_regfile_ff.register_file_i.rf_reg\[985\] _05416_
+ _06210_ VDD VSS NAND2_X1
X_23240_ _06210_ _05465_ _04978_ _01224_ VDD VSS OAI21_X1
X_23241_ net687 gen_regfile_ff.register_file_i.rf_reg\[986\]
+ _05929_ _01225_ VDD VSS MUX2_X1
X_23242_ _04850_ gen_regfile_ff.register_file_i.rf_reg\[987\]
+ _05929_ _01226_ VDD VSS MUX2_X1
X_23243_ _05094_ gen_regfile_ff.register_file_i.rf_reg\[988\]
+ _05375_ _01227_ VDD VSS MUX2_X1
X_23244_ gen_regfile_ff.register_file_i.rf_reg\[989\] _05416_
+ _06211_ VDD VSS NAND2_X1
X_23245_ _06211_ _05465_ _05148_ _01228_ VDD VSS OAI21_X1
X_23246_ _05211_ gen_regfile_ff.register_file_i.rf_reg\[990\]
+ _05375_ _01229_ VDD VSS MUX2_X1
X_23247_ gen_regfile_ff.register_file_i.rf_reg\[991\] _05416_
+ _06212_ VDD VSS NAND2_X1
X_23248_ _06212_ _05260_ _05465_ _01230_ VDD VSS OAI21_X4
X_23249_ gen_regfile_ff.register_file_i.rf_reg\[127\] _05803_
+ _06213_ VDD VSS NAND2_X1
X_23250_ _06213_ net681 _05806_ _01231_ VDD VSS OAI21_X4
X_23251_ _04603_ _04851_ _06214_ VDD VSS NOR2_X4
X_23252_ _04613_ _06214_ _06215_ VDD VSS NAND2_X4
X_23253_ _06215_ _06216_ VDD VSS BUF_X4
X_23254_ _05372_ gen_regfile_ff.register_file_i.rf_reg\[992\]
+ _06216_ _01232_ VDD VSS MUX2_X1
X_23255_ _05410_ gen_regfile_ff.register_file_i.rf_reg\[993\]
+ _06216_ _01233_ VDD VSS MUX2_X1
X_23256_ _06215_ _06217_ VDD VSS BUF_X4
X_23257_ gen_regfile_ff.register_file_i.rf_reg\[994\] _06217_
+ _06218_ VDD VSS NAND2_X1
X_23258_ _06215_ _06219_ VDD VSS BUF_X4
X_23259_ _06218_ _06219_ _05464_ _01234_ VDD VSS OAI21_X1
X_23260_ gen_regfile_ff.register_file_i.rf_reg\[995\] _06217_
+ _06220_ VDD VSS NAND2_X1
X_23261_ _06220_ _06219_ _05510_ _01235_ VDD VSS OAI21_X1
X_23262_ _05544_ gen_regfile_ff.register_file_i.rf_reg\[996\]
+ _06216_ _01236_ VDD VSS MUX2_X1
X_23263_ _05580_ gen_regfile_ff.register_file_i.rf_reg\[997\]
+ _06216_ _01237_ VDD VSS MUX2_X1
X_23264_ _05614_ gen_regfile_ff.register_file_i.rf_reg\[998\]
+ _06216_ _01238_ VDD VSS MUX2_X1
X_23265_ _05653_ gen_regfile_ff.register_file_i.rf_reg\[999\]
+ _06216_ _01239_ VDD VSS MUX2_X1
X_23266_ gen_regfile_ff.register_file_i.rf_reg\[1000\] _06217_
+ _06221_ VDD VSS NAND2_X1
X_23267_ _05687_ _06222_ VDD VSS BUF_X4
X_23268_ _06221_ _06219_ _06222_ _01240_ VDD VSS OAI21_X1
X_23269_ _05721_ gen_regfile_ff.register_file_i.rf_reg\[1001\]
+ _06216_ _01241_ VDD VSS MUX2_X1
X_23270_ _05371_ _06223_ VDD VSS BUF_X2
X_23271_ _05412_ _06224_ VDD VSS BUF_X8
X_23272_ _10899_ _04605_ _04611_ _06225_ VDD VSS AOI21_X4
X_23273_ _06225_ _06226_ VDD VSS BUF_X8
X_23274_ _06224_ _10904_ _06226_ _06227_ VDD VSS AND3_X1
X_23275_ _06227_ _06228_ VDD VSS BUF_X4
X_23276_ _06228_ _06229_ VDD VSS BUF_X4
X_23277_ gen_regfile_ff.register_file_i.rf_reg\[128\] _06223_
+ _06229_ _01242_ VDD VSS MUX2_X1
X_23278_ _05762_ gen_regfile_ff.register_file_i.rf_reg\[1002\]
+ _06216_ _01243_ VDD VSS MUX2_X1
X_23279_ _05802_ gen_regfile_ff.register_file_i.rf_reg\[1003\]
+ _06216_ _01244_ VDD VSS MUX2_X1
X_23280_ gen_regfile_ff.register_file_i.rf_reg\[1004\] _06217_
+ _06230_ VDD VSS NAND2_X1
X_23281_ _05849_ _06231_ VDD VSS CLKBUF_X3
X_23282_ _06230_ _06219_ _06231_ _01245_ VDD VSS OAI21_X1
X_23283_ _05890_ gen_regfile_ff.register_file_i.rf_reg\[1005\]
+ _06216_ _01246_ VDD VSS MUX2_X1
X_23284_ _06215_ _06232_ VDD VSS BUF_X4
X_23285_ _05928_ gen_regfile_ff.register_file_i.rf_reg\[1006\]
+ _06232_ _01247_ VDD VSS MUX2_X1
X_23286_ _05974_ gen_regfile_ff.register_file_i.rf_reg\[1007\]
+ _06232_ _01248_ VDD VSS MUX2_X1
X_23287_ gen_regfile_ff.register_file_i.rf_reg\[1008\] _06217_
+ _06233_ VDD VSS NAND2_X1
X_23288_ _06015_ _06234_ VDD VSS CLKBUF_X3
X_23289_ _06233_ _06219_ _06234_ _01249_ VDD VSS OAI21_X1
X_23290_ _06062_ gen_regfile_ff.register_file_i.rf_reg\[1009\]
+ _06232_ _01250_ VDD VSS MUX2_X1
X_23291_ _06100_ gen_regfile_ff.register_file_i.rf_reg\[1010\]
+ _06232_ _01251_ VDD VSS MUX2_X1
X_23292_ gen_regfile_ff.register_file_i.rf_reg\[1011\] _06217_
+ _06235_ VDD VSS NAND2_X1
X_23293_ _06235_ _06219_ _06138_ _01252_ VDD VSS OAI21_X1
X_23294_ _05409_ _06236_ VDD VSS BUF_X2
X_23295_ gen_regfile_ff.register_file_i.rf_reg\[129\] _06236_
+ _06229_ _01253_ VDD VSS MUX2_X1
X_23296_ net668 gen_regfile_ff.register_file_i.rf_reg\[1012\]
+ _06232_ _01254_ VDD VSS MUX2_X1
X_23297_ _06207_ gen_regfile_ff.register_file_i.rf_reg\[1013\]
+ _06232_ _01255_ VDD VSS MUX2_X1
X_23298_ _04602_ gen_regfile_ff.register_file_i.rf_reg\[1014\]
+ _06232_ _01256_ VDD VSS MUX2_X1
X_23299_ net684 gen_regfile_ff.register_file_i.rf_reg\[1015\]
+ _06232_ _01257_ VDD VSS MUX2_X1
X_23300_ gen_regfile_ff.register_file_i.rf_reg\[1016\] _06217_
+ _06237_ VDD VSS NAND2_X1
X_23301_ _06237_ _06219_ _04908_ _01258_ VDD VSS OAI21_X1
X_23302_ gen_regfile_ff.register_file_i.rf_reg\[1017\] _06217_
+ _06238_ VDD VSS NAND2_X1
X_23303_ _06238_ _06219_ _04978_ _01259_ VDD VSS OAI21_X1
X_23304_ _05037_ gen_regfile_ff.register_file_i.rf_reg\[1018\]
+ _06232_ _01260_ VDD VSS MUX2_X1
X_23305_ _04850_ gen_regfile_ff.register_file_i.rf_reg\[1019\]
+ _06232_ _01261_ VDD VSS MUX2_X1
X_23306_ _05094_ gen_regfile_ff.register_file_i.rf_reg\[1020\]
+ _06215_ _01262_ VDD VSS MUX2_X1
X_23307_ gen_regfile_ff.register_file_i.rf_reg\[1021\] _06217_
+ _06239_ VDD VSS NAND2_X1
X_23308_ _06239_ _06219_ _05148_ _01263_ VDD VSS OAI21_X1
X_23309_ _06224_ _10904_ _06226_ _06240_ VDD VSS NAND3_X4
X_23310_ _06240_ _06241_ VDD VSS BUF_X4
X_23311_ gen_regfile_ff.register_file_i.rf_reg\[130\] _06241_
+ _06242_ VDD VSS NAND2_X1
X_23312_ _06242_ _06241_ _05464_ _01264_ VDD VSS OAI21_X1
X_23313_ _05211_ gen_regfile_ff.register_file_i.rf_reg\[1022\]
+ _06215_ _01265_ VDD VSS MUX2_X1
X_23314_ gen_regfile_ff.register_file_i.rf_reg\[1023\] _06217_
+ _06243_ VDD VSS NAND2_X1
X_23315_ _06243_ _05260_ _06219_ _01266_ VDD VSS OAI21_X4
X_23316_ gen_regfile_ff.register_file_i.rf_reg\[131\] _06241_
+ _06244_ VDD VSS NAND2_X1
X_23317_ _06244_ _06241_ _05510_ _01267_ VDD VSS OAI21_X1
X_23318_ _10394_ _11315_ _10903_ _06245_ VDD VSS NOR3_X4
X_23319_ _04854_ _06245_ _06246_ VDD VSS NAND2_X4
X_23320_ _05721_ gen_regfile_ff.register_file_i.rf_reg\[41\]
+ _06246_ _01268_ VDD VSS MUX2_X1
X_23321_ _05314_ _05316_ _06247_ VDD VSS NAND2_X1
X_23322_ alu_adder_result_ex\[30\] _03627_ _03637_ _03642_
+ _06248_ VDD VSS NOR4_X4
X_23323_ alu_adder_result_ex\[22\] alu_adder_result_ex\[24\]
+ alu_adder_result_ex\[31\] _03644_ _06249_ VDD VSS NOR4_X4
X_23324_ _06248_ _06249_ _05314_ _06250_ VDD VSS NAND3_X2
X_23325_ _10350_ _10909_ _11427_ _06251_ VDD VSS NAND3_X4
X_23326_ net303 _03434_ _06251_ _06252_ VDD VSS NOR3_X4
X_23327_ _06247_ _06250_ _06252_ _06253_ VDD VSS NAND3_X4
X_23328_ _10305_ _10909_ _06254_ VDD VSS NOR2_X1
X_23329_ _06254_ _03456_ _10350_ _06255_ VDD VSS OAI21_X1
X_23330_ _10909_ _03434_ _06256_ VDD VSS NOR2_X2
X_23331_ _04229_ _06256_ _03456_ _06257_ VDD VSS AOI21_X2
X_23332_ _10350_ _03438_ _06258_ VDD VSS NOR2_X1
X_23333_ _10332_ _10340_ _03884_ _06259_ VDD VSS OAI21_X1
X_23334_ _06258_ _06259_ _11401_ _06260_ VDD VSS OAI21_X1
X_23335_ _03885_ _04229_ _06261_ VDD VSS NOR2_X1
X_23336_ _06255_ _06257_ _06260_ _06261_ _06251_ _06262_ VDD
+ VSS OAI221_X2
X_23337_ _03643_ _03645_ _05327_ _06263_ VDD VSS NOR3_X4
X_23338_ _11418_ _06262_ _06252_ _06263_ _06264_ VDD VSS AOI22_X4
X_23339_ _06253_ _06264_ _06265_ VDD VSS NAND2_X4
X_23340_ _03869_ _03872_ _06266_ VDD VSS AND2_X1
X_23341_ net60 _03879_ _10304_ _06267_ VDD VSS AOI21_X1
X_23342_ _03954_ _06267_ _06268_ VDD VSS OR2_X2
X_23343_ _03458_ _11423_ _06268_ _06269_ VDD VSS NAND3_X1
X_23344_ _11420_ _06266_ _06269_ _06270_ VDD VSS NOR3_X1
X_23345_ _03894_ _03895_ _06271_ VDD VSS NAND2_X1
X_23346_ id_stage_i.controller_i.load_err_d id_stage_i.controller_i.store_err_d
+ _06272_ VDD VSS OR2_X2
X_23347_ _10468_ _15525_ _10876_ _10980_ _06273_ VDD VSS NOR4_X1
X_23348_ _15525_ _06274_ VDD VSS INV_X1
X_23349_ _15527_ _06274_ _10891_ _06275_ VDD VSS NOR3_X1
X_23350_ _06273_ _06275_ _03475_ _06276_ VDD VSS AOI21_X1
X_23351_ _10885_ _03486_ _06276_ _06277_ VDD VSS NOR3_X1
X_23352_ _03472_ _06271_ _06272_ _06277_ _06278_ VDD VSS NOR4_X1
X_23353_ _03479_ _03610_ _06278_ _06279_ VDD VSS AND3_X1
X_23354_ _03509_ _06279_ _03603_ _03552_ _06280_ VDD VSS OAI211_X2
X_23355_ _01161_ _03479_ _03610_ _06281_ VDD VSS AND3_X1
X_23356_ _06278_ _06281_ _03461_ _06282_ VDD VSS OAI21_X1
X_23357_ _06280_ _06282_ _06283_ VDD VSS AND2_X1
X_23358_ _11426_ _06283_ _06284_ VDD VSS NOR2_X1
X_23359_ _06284_ _06268_ _06265_ _06285_ VDD VSS OAI21_X1
X_23360_ _03477_ _03869_ _03880_ _06286_ VDD VSS NOR3_X2
X_23361_ _11421_ _03875_ _11424_ _06287_ VDD VSS NAND3_X2
X_23362_ _03436_ _06287_ _06288_ VDD VSS NOR2_X1
X_23363_ _06286_ _06288_ _06289_ VDD VSS AND2_X1
X_23364_ _03954_ _06267_ _06290_ VDD VSS NOR2_X1
X_23365_ _11933_ _03609_ _03851_ _06291_ VDD VSS NAND3_X2
X_23366_ _03848_ _03847_ _06292_ VDD VSS NOR2_X1
X_23367_ _06292_ _03464_ cs_registers_i.dcsr_q\[15\] _06293_
+ VDD VSS AOI21_X2
X_23368_ _06290_ _06291_ _06293_ _06294_ VDD VSS OAI21_X1
X_23369_ _03461_ _06294_ _06295_ VDD VSS NAND2_X1
X_23370_ _03891_ _06271_ _06296_ VDD VSS NOR2_X1
X_23371_ _06295_ _06296_ _03472_ _06297_ VDD VSS AOI21_X2
X_23372_ _03436_ _03458_ _11424_ _06298_ VDD VSS NOR3_X1
X_23373_ _11423_ _06290_ _11421_ _06299_ VDD VSS OAI21_X1
X_23374_ _06298_ _06299_ _03436_ _06300_ VDD VSS AOI21_X1
X_23375_ _03890_ _06300_ _11422_ _06301_ VDD VSS OAI21_X1
X_23376_ _06289_ _06297_ _06301_ _06302_ VDD VSS NOR3_X1
X_23377_ _11422_ _03877_ _06265_ _06270_ _06285_ _06302_ _01269_
+ VDD VSS AOI222_X2
X_23378_ _03869_ _03872_ _06303_ VDD VSS NAND2_X1
X_23379_ _06265_ _06303_ _06304_ VDD VSS NOR2_X1
X_23380_ _03931_ _06265_ _06268_ _06304_ _11421_ _06305_ VDD
+ VSS OAI221_X1
X_23381_ _03931_ _06280_ _06282_ _06306_ VDD VSS NAND3_X2
X_23382_ _03840_ _06295_ _06307_ VDD VSS NOR2_X1
X_23383_ _10304_ _06266_ _06277_ _06308_ VDD VSS NAND3_X1
X_23384_ _03605_ _10678_ _10882_ _06309_ VDD VSS NAND3_X1
X_23385_ _06308_ _06309_ _03465_ _06310_ VDD VSS OAI21_X1
X_23386_ _03458_ _11423_ _06303_ _06269_ _06311_ VDD VSS OAI22_X1
X_23387_ _06289_ _06307_ _06310_ _06311_ _04160_ _06312_ VDD
+ VSS AOI221_X2
X_23388_ _06305_ _06306_ _06312_ _01270_ VDD VSS NAND3_X1
X_23389_ _11423_ _04160_ _06268_ _06313_ VDD VSS NAND3_X1
X_23390_ _06313_ _11423_ _03875_ _06314_ VDD VSS OAI21_X1
X_23391_ _11421_ _03875_ _06315_ VDD VSS NAND2_X1
X_23392_ _06315_ _03877_ _06316_ VDD VSS NAND2_X1
X_23393_ _03854_ _06297_ _06314_ _03458_ _11420_ _06316_ _06317_
+ VDD VSS AOI222_X2
X_23394_ _06265_ _06283_ _06318_ VDD VSS OR2_X1
X_23395_ _03931_ _06268_ _06318_ _06319_ VDD VSS OAI21_X1
X_23396_ _06289_ _06317_ _06319_ _03877_ _11422_ _01271_ VDD
+ VSS AOI221_X2
X_23397_ _11425_ _06290_ _06320_ VDD VSS NAND2_X1
X_23398_ _06320_ _06318_ _11420_ _06321_ VDD VSS AOI21_X1
X_23399_ _03952_ _03854_ _06294_ _06322_ VDD VSS AOI21_X1
X_23400_ _06321_ _06322_ _01272_ VDD VSS OR2_X1
X_23401_ _03927_ _03881_ _03478_ _01273_ VDD VSS AOI21_X1
X_23402_ _03947_ _03873_ _03924_ _03918_ _01274_ VDD VSS OAI22_X1
X_23403_ net304 _05314_ _05338_ _06323_ VDD VSS AOI21_X1
X_23404_ _10909_ _06261_ _06324_ VDD VSS NAND2_X1
X_23405_ _03439_ _06323_ _06324_ _06325_ VDD VSS OAI21_X1
X_23406_ _06257_ _06258_ _06325_ _10350_ _01275_ VDD VSS AOI22_X1
X_23407_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[0\]
+ _03613_ _06326_ VDD VSS NAND2_X1
X_23408_ _14068_ _03660_ _03780_ _06327_ VDD VSS MUX2_X1
X_23409_ _06326_ _06327_ _03613_ _01276_ VDD VSS OAI21_X1
X_23410_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[10\]
+ _03613_ _06328_ VDD VSS NAND2_X1
X_23411_ _05328_ _11313_ _03780_ _06329_ VDD VSS MUX2_X1
X_23412_ _06328_ _06329_ _03613_ _01277_ VDD VSS OAI21_X1
X_23413_ alu_adder_result_ex\[11\] _11351_ _03780_ _06330_
+ VDD VSS MUX2_X1
X_23414_ _06330_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[11\]
+ _03613_ _01278_ VDD VSS MUX2_X1
X_23415_ alu_adder_result_ex\[12\] net329 _03780_ _06331_
+ VDD VSS MUX2_X1
X_23416_ _03612_ _06332_ VDD VSS CLKBUF_X3
X_23417_ _06331_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[12\]
+ _06332_ _01279_ VDD VSS MUX2_X1
X_23418_ alu_adder_result_ex\[13\] net342 _03780_ _06333_
+ VDD VSS MUX2_X1
X_23419_ _06333_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[13\]
+ _06332_ _01280_ VDD VSS MUX2_X1
X_23420_ net395 _12144_ _03780_ _06334_ VDD VSS MUX2_X1
X_23421_ _06334_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[14\]
+ _06332_ _01281_ VDD VSS MUX2_X1
X_23422_ _03779_ _06335_ VDD VSS CLKBUF_X3
X_23423_ alu_adder_result_ex\[15\] _12221_ _06335_ _06336_
+ VDD VSS MUX2_X1
X_23424_ _06336_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[15\]
+ _06332_ _01282_ VDD VSS MUX2_X1
X_23425_ alu_adder_result_ex\[16\] _12316_ _06335_ _06337_
+ VDD VSS MUX2_X1
X_23426_ _06337_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[16\]
+ _06332_ _01283_ VDD VSS MUX2_X1
X_23427_ alu_adder_result_ex\[17\] _12392_ _06335_ _06338_
+ VDD VSS MUX2_X1
X_23428_ _06338_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[17\]
+ _06332_ _01284_ VDD VSS MUX2_X1
X_23429_ net380 net367 _06335_ _06339_ VDD VSS MUX2_X1
X_23430_ _06339_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[18\]
+ _06332_ _01285_ VDD VSS MUX2_X1
X_23431_ net403 net368 _06335_ _06340_ VDD VSS MUX2_X1
X_23432_ _06340_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[19\]
+ _06332_ _01286_ VDD VSS MUX2_X1
X_23433_ alu_adder_result_ex\[1\] _03675_ _06335_ _06341_
+ VDD VSS MUX2_X1
X_23434_ _06341_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[1\]
+ _06332_ _01287_ VDD VSS MUX2_X1
X_23435_ alu_adder_result_ex\[20\] _12651_ _06335_ _06342_
+ VDD VSS MUX2_X1
X_23436_ _06342_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[20\]
+ _06332_ _01288_ VDD VSS MUX2_X1
X_23437_ net386 net410 _06335_ _06343_ VDD VSS MUX2_X1
X_23438_ _03612_ _06344_ VDD VSS CLKBUF_X3
X_23439_ _06343_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[21\]
+ _06344_ _01289_ VDD VSS MUX2_X1
X_23440_ net396 net407 _06335_ _06345_ VDD VSS MUX2_X1
X_23441_ _06345_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[22\]
+ _06344_ _01290_ VDD VSS MUX2_X1
X_23442_ net392 _12896_ _06335_ _06346_ VDD VSS MUX2_X1
X_23443_ _06346_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[23\]
+ _06344_ _01291_ VDD VSS MUX2_X1
X_23444_ _03779_ _06347_ VDD VSS CLKBUF_X3
X_23445_ alu_adder_result_ex\[24\] net373 _06347_ _06348_
+ VDD VSS MUX2_X1
X_23446_ _06348_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[24\]
+ _06344_ _01292_ VDD VSS MUX2_X1
X_23447_ net387 _13061_ _06347_ _06349_ VDD VSS MUX2_X1
X_23448_ _06349_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[25\]
+ _06344_ _01293_ VDD VSS MUX2_X1
X_23449_ net399 net331 _06347_ _06350_ VDD VSS MUX2_X1
X_23450_ _06350_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[26\]
+ _06344_ _01294_ VDD VSS MUX2_X1
X_23451_ net391 net344 _06347_ _06351_ VDD VSS MUX2_X1
X_23452_ _06351_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[27\]
+ _06344_ _01295_ VDD VSS MUX2_X1
X_23453_ alu_adder_result_ex\[28\] _13314_ _06347_ _06352_
+ VDD VSS MUX2_X1
X_23454_ _06352_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[28\]
+ _06344_ _01296_ VDD VSS MUX2_X1
X_23455_ net246 _03166_ _06347_ _06353_ VDD VSS MUX2_X1
X_23456_ _06353_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[29\]
+ _06344_ _01297_ VDD VSS MUX2_X1
X_23457_ alu_adder_result_ex\[2\] _10973_ _06347_ _06354_
+ VDD VSS MUX2_X1
X_23458_ _06354_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[2\]
+ _06344_ _01298_ VDD VSS MUX2_X1
X_23459_ alu_adder_result_ex\[30\] _03275_ _06347_ _06355_
+ VDD VSS MUX2_X1
X_23460_ _06355_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[30\]
+ _03612_ _01299_ VDD VSS MUX2_X1
X_23461_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[31\]
+ _03613_ _06356_ VDD VSS NAND2_X1
X_23462_ _03772_ net323 _03780_ _06357_ VDD VSS OAI21_X1
X_23463_ _06356_ _06357_ _03613_ _01300_ VDD VSS OAI21_X1
X_23464_ _10310_ _10380_ _10873_ _10917_ _06358_ VDD VSS NAND4_X2
X_23465_ _03790_ _06358_ _06359_ VDD VSS NAND2_X1
X_23466_ _03650_ _06359_ _06360_ VDD VSS NAND2_X1
X_23467_ _03779_ _03790_ _06358_ _06361_ VDD VSS NOR3_X1
X_23468_ _06361_ _03790_ _03779_ _06362_ VDD VSS AOI21_X1
X_23469_ net288 _10526_ _10874_ _06363_ VDD VSS AOI21_X4
X_23470_ _06362_ _06363_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_by_zero_q
+ _06364_ VDD VSS AOI21_X1
X_23471_ _03611_ _06365_ VDD VSS INV_X1
X_23472_ _03407_ _06365_ _04033_ _06366_ VDD VSS NAND3_X4
X_23473_ _06360_ _06364_ _06366_ _03647_ _06367_ VDD VSS OAI22_X1
X_23474_ _10310_ _06367_ _06368_ VDD VSS AND2_X1
X_23475_ _11408_ _11428_ _06368_ _06369_ VDD VSS NOR3_X1
X_23476_ _06369_ _06370_ VDD VSS CLKBUF_X3
X_23477_ _06370_ _06371_ VDD VSS CLKBUF_X3
X_23478_ _05349_ _06371_ _06372_ VDD VSS NAND2_X1
X_23479_ _11406_ _11428_ _06368_ _06373_ VDD VSS OR3_X1
X_23480_ _06373_ _06374_ VDD VSS CLKBUF_X3
X_23481_ _03450_ _06374_ _06375_ VDD VSS NOR2_X2
X_23482_ _11432_ _10488_ _10508_ _10541_ _06376_ VDD VSS NOR4_X4
X_23483_ _06376_ _06363_ _06377_ VDD VSS AND2_X1
X_23484_ _06377_ _06378_ VDD VSS CLKBUF_X3
X_23485_ _06366_ _06378_ _06379_ VDD VSS NOR2_X2
X_23486_ _06375_ _06379_ _06380_ VDD VSS NAND2_X1
X_23487_ _06380_ _06381_ VDD VSS CLKBUF_X3
X_23488_ _06381_ _06382_ VDD VSS CLKBUF_X3
X_23489_ _06370_ _06383_ VDD VSS CLKBUF_X3
X_23490_ _06372_ _06382_ _04045_ _06383_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[32\]
+ _06384_ VDD VSS OAI221_X1
X_23491_ _03404_ _06385_ VDD VSS BUF_X2
X_23492_ _06385_ _06386_ VDD VSS CLKBUF_X3
X_23493_ _06378_ _06387_ VDD VSS CLKBUF_X3
X_23494_ _03408_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[31\]
+ _06388_ VDD VSS XOR2_X2
X_23495_ _03412_ _06388_ _06389_ VDD VSS NAND2_X2
X_23496_ _06389_ _06388_ net278 _06390_ VDD VSS OAI21_X4
X_23497_ _06390_ _06391_ VDD VSS CLKBUF_X3
X_23498_ _06391_ _06392_ VDD VSS BUF_X4
X_23499_ _14068_ _00217_ _06392_ _06393_ VDD VSS MUX2_X1
X_23500_ _06387_ _06393_ _06394_ VDD VSS NOR2_X1
X_23501_ _06376_ _06363_ _06395_ VDD VSS NAND2_X4
X_23502_ _06395_ _06396_ VDD VSS CLKBUF_X3
X_23503_ _06396_ _06397_ VDD VSS CLKBUF_X3
X_23504_ _03442_ _15540_ _06398_ VDD VSS NAND2_X1
X_23505_ _06390_ _06399_ VDD VSS CLKBUF_X3
X_23506_ _03444_ _03445_ _06399_ _06400_ VDD VSS OR3_X2
X_23507_ _06398_ _06400_ _06401_ VDD VSS OR2_X1
X_23508_ _00068_ _06401_ _06402_ VDD VSS AND2_X1
X_23509_ _06397_ _06402_ _06403_ VDD VSS NOR2_X1
X_23510_ _06386_ _06394_ _06403_ _06404_ VDD VSS OAI21_X1
X_23511_ _06366_ _06375_ _06405_ VDD VSS NAND2_X2
X_23512_ _06405_ _06406_ VDD VSS BUF_X4
X_23513_ _06406_ _06407_ VDD VSS BUF_X4
X_23514_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[31\]
+ _06408_ VDD VSS INV_X1
X_23515_ _15541_ _06409_ VDD VSS CLKBUF_X3
X_23516_ _00118_ _00116_ _06409_ _06410_ VDD VSS MUX2_X1
X_23517_ _00119_ _00117_ _06409_ _06411_ VDD VSS MUX2_X1
X_23518_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]
+ _06412_ VDD VSS BUF_X4
X_23519_ _06410_ _06411_ _06412_ _06413_ VDD VSS MUX2_X1
X_23520_ _00126_ _00124_ _06409_ _06414_ VDD VSS MUX2_X1
X_23521_ _00127_ _00125_ _06409_ _06415_ VDD VSS MUX2_X1
X_23522_ _06414_ _06415_ _06412_ _06416_ VDD VSS MUX2_X1
X_23523_ _03445_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]
+ _06412_ _06417_ VDD VSS NOR3_X2
X_23524_ _00067_ _06417_ _06418_ VDD VSS XNOR2_X2
X_23525_ _06413_ _06416_ _06418_ _06419_ VDD VSS MUX2_X1
X_23526_ _00122_ _00120_ _06409_ _06420_ VDD VSS MUX2_X1
X_23527_ _06409_ _06421_ VDD VSS BUF_X4
X_23528_ _00123_ _00121_ _06421_ _06422_ VDD VSS MUX2_X1
X_23529_ _06420_ _06422_ _06412_ _06423_ VDD VSS MUX2_X1
X_23530_ _00130_ _00128_ _06409_ _06424_ VDD VSS MUX2_X1
X_23531_ _00131_ _00129_ _06421_ _06425_ VDD VSS MUX2_X1
X_23532_ _06424_ _06425_ _06412_ _06426_ VDD VSS MUX2_X1
X_23533_ _06423_ _06426_ _06418_ _06427_ VDD VSS MUX2_X1
X_23534_ _15542_ _00066_ _06428_ VDD VSS XNOR2_X2
X_23535_ _06419_ _06427_ _06428_ _06429_ VDD VSS MUX2_X1
X_23536_ _00102_ _00100_ _06409_ _06430_ VDD VSS MUX2_X1
X_23537_ _00103_ _00101_ _06421_ _06431_ VDD VSS MUX2_X1
X_23538_ _06430_ _06431_ _06412_ _06432_ VDD VSS MUX2_X1
X_23539_ _00110_ _00108_ _06421_ _06433_ VDD VSS MUX2_X1
X_23540_ _00111_ _00109_ _06421_ _06434_ VDD VSS MUX2_X1
X_23541_ _06433_ _06434_ _06412_ _06435_ VDD VSS MUX2_X1
X_23542_ _06432_ _06435_ _06418_ _06436_ VDD VSS MUX2_X1
X_23543_ _00106_ _00104_ _06421_ _06437_ VDD VSS MUX2_X1
X_23544_ _00107_ _00105_ _06421_ _06438_ VDD VSS MUX2_X1
X_23545_ _06437_ _06438_ _06412_ _06439_ VDD VSS MUX2_X1
X_23546_ _00114_ _00112_ _06421_ _06440_ VDD VSS MUX2_X1
X_23547_ _00115_ _00113_ _06421_ _06441_ VDD VSS MUX2_X1
X_23548_ _06440_ _06441_ _06412_ _06442_ VDD VSS MUX2_X1
X_23549_ _06439_ _06442_ _06418_ _06443_ VDD VSS MUX2_X1
X_23550_ _06436_ _06443_ _06428_ _06444_ VDD VSS MUX2_X1
X_23551_ _15542_ _03446_ _06445_ VDD VSS NAND2_X1
X_23552_ _03442_ _06445_ _06446_ VDD VSS XNOR2_X2
X_23553_ _06429_ _06444_ _06446_ _06447_ VDD VSS MUX2_X1
X_23554_ _03401_ _14068_ _06408_ _06365_ _06447_ _03432_ _06448_
+ VDD VSS OAI222_X2
X_23555_ _06407_ _06448_ _06449_ VDD VSS NOR2_X1
X_23556_ _06384_ _06404_ _06449_ _01301_ VDD VSS AOI21_X1
X_23557_ _06374_ _06450_ VDD VSS CLKBUF_X3
X_23558_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[33\]
+ _06450_ _06451_ VDD VSS NAND2_X1
X_23559_ _03403_ _03404_ _03650_ _03611_ _06452_ VDD VSS NOR4_X4
X_23560_ _06452_ _06453_ VDD VSS BUF_X4
X_23561_ _03450_ _06453_ _06454_ VDD VSS NOR2_X1
X_23562_ _06454_ _16090_ _03401_ _03432_ _06393_ _06455_ VDD
+ VSS OAI221_X1
X_23563_ _06391_ _06456_ VDD VSS CLKBUF_X3
X_23564_ alu_adder_result_ex\[1\] _06456_ _06457_ VDD VSS
+ NOR2_X1
X_23565_ _06457_ _06392_ _00185_ _06458_ VDD VSS AOI21_X2
X_23566_ _06387_ _06458_ _06459_ VDD VSS NOR2_X1
X_23567_ _00069_ _06460_ VDD VSS INV_X1
X_23568_ _03444_ _03445_ _06392_ _06461_ VDD VSS NOR3_X2
X_23569_ _06460_ _03443_ _06461_ _06462_ VDD VSS AOI21_X2
X_23570_ _06459_ _06462_ _06387_ _06463_ VDD VSS AOI21_X1
X_23571_ _06455_ _06463_ _06386_ _06464_ VDD VSS AOI21_X1
X_23572_ _03440_ _06379_ _06465_ VDD VSS NAND2_X1
X_23573_ _06383_ _06465_ _03681_ _05389_ _10495_ _06466_ VDD
+ VSS OAI221_X1
X_23574_ _06451_ _06464_ _06466_ _01302_ VDD VSS OAI21_X1
X_23575_ _05431_ _06374_ _06467_ VDD VSS NAND2_X1
X_23576_ _06467_ _06450_ _05430_ net296 _06382_ _06468_ VDD
+ VSS OAI221_X1
X_23577_ _06385_ _06469_ VDD VSS CLKBUF_X3
X_23578_ _03442_ _15544_ _06470_ VDD VSS NAND2_X1
X_23579_ _00070_ _06400_ _06470_ _06471_ VDD VSS OAI21_X1
X_23580_ alu_adder_result_ex\[2\] _06456_ _06472_ VDD VSS
+ NOR2_X1
X_23581_ _06399_ _06473_ VDD VSS CLKBUF_X3
X_23582_ _06473_ _06474_ VDD VSS CLKBUF_X3
X_23583_ _06472_ _06474_ _00556_ _06475_ VDD VSS AOI21_X1
X_23584_ _06471_ _06475_ _06397_ _06476_ VDD VSS MUX2_X1
X_23585_ _06469_ _06476_ _06477_ VDD VSS NAND2_X1
X_23586_ _03431_ _06478_ VDD VSS BUF_X4
X_23587_ _03401_ _06479_ VDD VSS INV_X2
X_23588_ _06407_ _06458_ _06478_ _06479_ alu_adder_result_ex\[2\]
+ _06480_ VDD VSS AOI221_X2
X_23589_ _06468_ _06477_ _06480_ _01303_ VDD VSS AOI21_X1
X_23590_ _05469_ _06371_ _06481_ VDD VSS NAND2_X1
X_23591_ _06370_ _06482_ VDD VSS CLKBUF_X3
X_23592_ _06481_ _06382_ net319 ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[35\]
+ _06482_ _06483_ VDD VSS OAI221_X1
X_23593_ _03442_ _15548_ _06484_ VDD VSS NAND2_X2
X_23594_ _00071_ _06400_ _06484_ _06485_ VDD VSS OAI21_X1
X_23595_ alu_adder_result_ex\[3\] _06392_ _06486_ VDD VSS
+ NOR2_X1
X_23596_ _06486_ _06474_ _00557_ _06487_ VDD VSS AOI21_X1
X_23597_ _06485_ _06487_ _06397_ _06488_ VDD VSS MUX2_X1
X_23598_ _06469_ _06488_ _06489_ VDD VSS NAND2_X1
X_23599_ _06407_ _06475_ _06478_ _06479_ alu_adder_result_ex\[3\]
+ _06490_ VDD VSS AOI221_X1
X_23600_ _06483_ _06489_ _06490_ _01304_ VDD VSS AOI21_X1
X_23601_ _05523_ _06371_ _06491_ VDD VSS NAND2_X1
X_23602_ _06491_ _06382_ _11591_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[36\]
+ _06482_ _06492_ VDD VSS OAI221_X1
X_23603_ _06407_ _06487_ _03614_ _06479_ alu_adder_result_ex\[4\]
+ _06493_ VDD VSS AOI221_X2
X_23604_ _03444_ _00066_ _06390_ _06494_ VDD VSS OR3_X1
X_23605_ _06494_ _06495_ VDD VSS BUF_X2
X_23606_ _00072_ _06398_ _06495_ _06496_ VDD VSS OAI21_X1
X_23607_ alu_adder_result_ex\[4\] _06392_ _06497_ VDD VSS
+ NOR2_X1
X_23608_ _06497_ _06474_ _00558_ _06498_ VDD VSS AOI21_X1
X_23609_ _06496_ _06498_ _06396_ _06499_ VDD VSS MUX2_X1
X_23610_ _06386_ _06499_ _06500_ VDD VSS NAND2_X1
X_23611_ _06492_ _06493_ _06500_ _01305_ VDD VSS AOI21_X1
X_23612_ _06369_ _06501_ VDD VSS CLKBUF_X3
X_23613_ _05556_ _06501_ _06502_ VDD VSS NAND2_X1
X_23614_ _06502_ _06382_ _11629_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[37\]
+ _06482_ _06503_ VDD VSS OAI221_X2
X_23615_ _06407_ _06498_ _03614_ _06479_ alu_adder_result_ex\[5\]
+ _06504_ VDD VSS AOI221_X2
X_23616_ _03442_ _15546_ _06505_ VDD VSS NAND2_X1
X_23617_ _00073_ _06505_ _06495_ _06506_ VDD VSS OAI21_X1
X_23618_ alu_adder_result_ex\[5\] _06456_ _06507_ VDD VSS
+ NOR2_X1
X_23619_ _06507_ _06474_ _00559_ _06508_ VDD VSS AOI21_X1
X_23620_ _06506_ _06508_ _06396_ _06509_ VDD VSS MUX2_X1
X_23621_ _06386_ _06509_ _06510_ VDD VSS NAND2_X1
X_23622_ _06503_ _06504_ _06510_ _01306_ VDD VSS AOI21_X1
X_23623_ alu_adder_result_ex\[3\] _11019_ _06347_ _06511_
+ VDD VSS MUX2_X1
X_23624_ _06511_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[3\]
+ _03612_ _01307_ VDD VSS MUX2_X1
X_23625_ _05591_ _06501_ _06512_ VDD VSS NAND2_X1
X_23626_ _06512_ _06382_ _11672_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[38\]
+ _06482_ _06513_ VDD VSS OAI221_X1
X_23627_ _06407_ _06508_ _03614_ _06479_ alu_adder_result_ex\[6\]
+ _06514_ VDD VSS AOI221_X1
X_23628_ _00074_ _06470_ _06495_ _06515_ VDD VSS OAI21_X1
X_23629_ alu_adder_result_ex\[6\] _06456_ _06516_ VDD VSS
+ NOR2_X1
X_23630_ _06516_ _06474_ _00560_ _06517_ VDD VSS AOI21_X1
X_23631_ _06515_ _06517_ _06396_ _06518_ VDD VSS MUX2_X1
X_23632_ _06386_ _06518_ _06519_ VDD VSS NAND2_X1
X_23633_ _06513_ _06514_ _06519_ _01308_ VDD VSS AOI21_X1
X_23634_ _05648_ _06501_ _06520_ VDD VSS NAND2_X1
X_23635_ _06520_ _06382_ _03723_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[39\]
+ _06482_ _06521_ VDD VSS OAI221_X2
X_23636_ _06407_ _06517_ _03614_ _03652_ alu_adder_result_ex\[7\]
+ _06522_ VDD VSS AOI221_X2
X_23637_ _00075_ _06484_ _06495_ _06523_ VDD VSS OAI21_X1
X_23638_ alu_adder_result_ex\[7\] _06456_ _06524_ VDD VSS
+ NOR2_X1
X_23639_ _06524_ _06474_ _00561_ _06525_ VDD VSS AOI21_X1
X_23640_ _06523_ _06525_ _06396_ _06526_ VDD VSS MUX2_X1
X_23641_ _06386_ _06526_ _06527_ VDD VSS NAND2_X1
X_23642_ _06521_ _06522_ _06527_ _01309_ VDD VSS AOI21_X1
X_23643_ _05664_ _06501_ _06528_ VDD VSS NAND2_X1
X_23644_ _06528_ _06381_ _03732_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[40\]
+ _06482_ _06529_ VDD VSS OAI221_X1
X_23645_ _03445_ _00067_ _06530_ VDD VSS NOR2_X2
X_23646_ _06389_ _06530_ net277 _06388_ _06531_ VDD VSS OAI211_X4
X_23647_ _00076_ _06398_ _06531_ _06532_ VDD VSS OAI21_X1
X_23648_ alu_adder_result_ex\[8\] _06456_ _06533_ VDD VSS
+ NOR2_X1
X_23649_ _06533_ _06474_ _00562_ _06534_ VDD VSS AOI21_X1
X_23650_ _06532_ _06534_ _06397_ _06535_ VDD VSS MUX2_X1
X_23651_ _06469_ _06535_ _06536_ VDD VSS NAND2_X1
X_23652_ _06407_ _06525_ _06478_ _03652_ alu_adder_result_ex\[8\]
+ _06537_ VDD VSS AOI221_X2
X_23653_ _06529_ _06536_ _06537_ _01310_ VDD VSS AOI21_X1
X_23654_ _05700_ _06501_ _06538_ VDD VSS NAND2_X1
X_23655_ _06538_ _06381_ _11824_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[41\]
+ _06482_ _06539_ VDD VSS OAI221_X1
X_23656_ alu_adder_result_ex\[9\] _06473_ _06540_ VDD VSS
+ NOR2_X1
X_23657_ _06540_ _06392_ _00563_ _06541_ VDD VSS AOI21_X2
X_23658_ _06387_ _06541_ _06542_ VDD VSS NOR2_X1
X_23659_ _00077_ _06543_ VDD VSS INV_X1
X_23660_ _03445_ _00067_ _06392_ _06544_ VDD VSS NOR3_X2
X_23661_ _06543_ _03443_ _06544_ _06545_ VDD VSS AOI21_X2
X_23662_ _06542_ _06545_ _06387_ _06546_ VDD VSS AOI21_X1
X_23663_ _06469_ _06546_ _06547_ VDD VSS NAND2_X1
X_23664_ _06407_ _06534_ _06478_ _03652_ alu_adder_result_ex\[9\]
+ _06548_ VDD VSS AOI221_X2
X_23665_ _06539_ _06547_ _06548_ _01311_ VDD VSS AOI21_X1
X_23666_ _05724_ _06374_ _06549_ VDD VSS NAND2_X1
X_23667_ _06549_ _06450_ _05723_ _11898_ _06382_ _06550_ VDD
+ VSS OAI221_X1
X_23668_ _00078_ _06470_ _06531_ _06551_ VDD VSS OAI21_X1
X_23669_ net404 _06390_ _06552_ VDD VSS NOR2_X1
X_23670_ _06552_ _06399_ _00564_ _06553_ VDD VSS AOI21_X1
X_23671_ _06551_ _06553_ _06397_ _06554_ VDD VSS MUX2_X1
X_23672_ _06469_ _06554_ _06555_ VDD VSS NAND2_X1
X_23673_ _06406_ _06541_ _06478_ _03652_ alu_adder_result_ex\[10\]
+ _06556_ VDD VSS AOI221_X2
X_23674_ _06550_ _06555_ _06556_ _01312_ VDD VSS AOI21_X1
X_23675_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[43\]
+ _06370_ _06557_ VDD VSS NOR2_X1
X_23676_ _06452_ _06553_ _03403_ _03650_ alu_adder_result_ex\[11\]
+ _06558_ VDD VSS AOI221_X1
X_23677_ _00079_ _06378_ _06484_ _06531_ _06559_ VDD VSS OAI211_X2
X_23678_ alu_adder_result_ex\[11\] _06391_ _06560_ VDD VSS
+ NOR2_X1
X_23679_ _06560_ _06473_ _00565_ _06561_ VDD VSS AOI21_X2
X_23680_ _06559_ _06561_ _06378_ _06562_ VDD VSS OAI21_X1
X_23681_ _06558_ _06562_ _03452_ _06563_ VDD VSS OAI21_X1
X_23682_ _06453_ _06395_ _06564_ VDD VSS NAND2_X2
X_23683_ _06563_ _06564_ _11398_ _06565_ VDD VSS OAI21_X1
X_23684_ _06557_ _06565_ _06375_ _05771_ _06371_ _01313_ VDD
+ VSS AOI221_X1
X_23685_ _05816_ _06465_ _10868_ _06566_ VDD VSS OAI21_X1
X_23686_ _06374_ _06566_ _06567_ VDD VSS NOR2_X1
X_23687_ _06567_ _06450_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[44\]
+ _06568_ VDD VSS AOI21_X1
X_23688_ _00066_ _00067_ _06390_ _06569_ VDD VSS OR3_X1
X_23689_ _06569_ _06570_ VDD VSS BUF_X2
X_23690_ _00080_ _06398_ _06570_ _06571_ VDD VSS OAI21_X1
X_23691_ alu_adder_result_ex\[12\] _06456_ _06572_ VDD VSS
+ NOR2_X1
X_23692_ _06572_ _06474_ _00566_ _06573_ VDD VSS AOI21_X2
X_23693_ _06571_ _06573_ _06397_ _06574_ VDD VSS MUX2_X1
X_23694_ _06469_ _06574_ _06575_ VDD VSS NAND2_X1
X_23695_ _06406_ _06561_ _06478_ _03652_ alu_adder_result_ex\[12\]
+ _06576_ VDD VSS AOI221_X2
X_23696_ _06568_ _06575_ _06576_ _01314_ VDD VSS AOI21_X1
X_23697_ _04023_ _04626_ _06577_ VDD VSS NAND2_X1
X_23698_ _06577_ _05104_ _04626_ _06578_ VDD VSS OAI21_X1
X_23699_ _12103_ _06501_ _06578_ _06579_ VDD VSS NAND3_X1
X_23700_ _06579_ _06381_ _12075_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[45\]
+ _06371_ _06580_ VDD VSS OAI221_X1
X_23701_ _00081_ _06505_ _06570_ _06581_ VDD VSS OAI21_X1
X_23702_ alu_adder_result_ex\[13\] _06456_ _06582_ VDD VSS
+ NOR2_X1
X_23703_ _06582_ _06474_ _04023_ _06583_ VDD VSS AOI21_X1
X_23704_ _06581_ _06583_ _06397_ _06584_ VDD VSS MUX2_X1
X_23705_ _06469_ _06584_ _06585_ VDD VSS NAND2_X1
X_23706_ _06406_ _06573_ _06478_ _03652_ alu_adder_result_ex\[13\]
+ _06586_ VDD VSS AOI221_X2
X_23707_ _06580_ _06585_ _06586_ _01315_ VDD VSS AOI21_X1
X_23708_ _04026_ _04626_ _06587_ VDD VSS NAND2_X1
X_23709_ _06587_ _05158_ _04626_ _06588_ VDD VSS OAI21_X1
X_23710_ _12103_ _06501_ _06588_ _06589_ VDD VSS NAND3_X1
X_23711_ _06589_ _06381_ _12177_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[46\]
+ _06371_ _06590_ VDD VSS OAI221_X1
X_23712_ _00082_ _06470_ _06570_ _06591_ VDD VSS OAI21_X1
X_23713_ net394 _06391_ _06592_ VDD VSS NOR2_X1
X_23714_ _06592_ _06473_ _04026_ _06593_ VDD VSS AOI21_X1
X_23715_ _06591_ _06593_ _06397_ _06594_ VDD VSS MUX2_X1
X_23716_ _06469_ _06594_ _06595_ VDD VSS NAND2_X1
X_23717_ _06406_ _06583_ _06478_ _03652_ net394 _06596_ VDD
+ VSS AOI221_X2
X_23718_ _06590_ _06595_ _06596_ _01316_ VDD VSS AOI21_X1
X_23719_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[47\]
+ _06370_ _06381_ _12254_ _06597_ VDD VSS OAI22_X1
X_23720_ _10495_ _06374_ _06598_ VDD VSS NOR2_X2
X_23721_ _00659_ _05219_ _04791_ _06599_ VDD VSS MUX2_X1
X_23722_ _06406_ _06593_ _03431_ _03651_ alu_adder_result_ex\[15\]
+ _06600_ VDD VSS AOI221_X2
X_23723_ _00083_ _06484_ _06570_ _06601_ VDD VSS OAI21_X1
X_23724_ alu_adder_result_ex\[15\] _06473_ _06602_ VDD VSS
+ NOR2_X1
X_23725_ _06602_ _06392_ _00659_ _06603_ VDD VSS AOI21_X1
X_23726_ _06601_ _06603_ _06395_ _06604_ VDD VSS MUX2_X1
X_23727_ _06385_ _06604_ _06605_ VDD VSS NAND2_X1
X_23728_ _06597_ _06598_ _06599_ _06600_ _06605_ _01317_ VDD
+ VSS AOI221_X1
X_23729_ alu_adder_result_ex\[4\] _03519_ _06347_ _06606_
+ VDD VSS MUX2_X1
X_23730_ _06606_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[4\]
+ _03612_ _01318_ VDD VSS MUX2_X1
X_23731_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[48\]
+ _06370_ _06607_ VDD VSS OR2_X1
X_23732_ _06607_ _06374_ _05991_ _12350_ _06382_ _06608_ VDD
+ VSS OAI221_X1
X_23733_ alu_adder_result_ex\[16\] _06473_ _06609_ VDD VSS
+ NOR2_X1
X_23734_ _06609_ _06392_ _03670_ _06610_ VDD VSS AOI21_X1
X_23735_ _06387_ _06610_ _06611_ VDD VSS NOR2_X1
X_23736_ _00084_ _06612_ VDD VSS INV_X1
X_23737_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[4\]
+ _06613_ VDD VSS BUF_X2
X_23738_ _06613_ _15540_ _06614_ VDD VSS AND2_X1
X_23739_ _06612_ _06461_ _06614_ _06615_ VDD VSS AOI21_X2
X_23740_ _06611_ _06615_ _06387_ _06616_ VDD VSS AOI21_X1
X_23741_ _06469_ _06616_ _06617_ VDD VSS NAND2_X1
X_23742_ _06406_ _06603_ _06478_ _03651_ alu_adder_result_ex\[16\]
+ _06618_ VDD VSS AOI221_X2
X_23743_ _06608_ _06617_ _06618_ _01319_ VDD VSS AOI21_X1
X_23744_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[49\]
+ _06370_ _06619_ VDD VSS OR2_X1
X_23745_ _06619_ _06374_ _06027_ _12425_ _06382_ _06620_ VDD
+ VSS OAI221_X1
X_23746_ _06613_ _15546_ _06621_ VDD VSS NAND2_X2
X_23747_ _00085_ _06400_ _06621_ _06622_ VDD VSS OAI21_X1
X_23748_ alu_adder_result_ex\[17\] _06456_ _06623_ VDD VSS
+ NOR2_X1
X_23749_ _06623_ _06474_ _03800_ _06624_ VDD VSS AOI21_X1
X_23750_ _06622_ _06624_ _06397_ _06625_ VDD VSS MUX2_X1
X_23751_ _06469_ _06625_ _06626_ VDD VSS NAND2_X1
X_23752_ _06406_ _06610_ _06478_ _03651_ alu_adder_result_ex\[17\]
+ _06627_ VDD VSS AOI221_X1
X_23753_ _06620_ _06626_ _06627_ _01320_ VDD VSS AOI21_X1
X_23754_ _06082_ _06501_ _06628_ VDD VSS NAND2_X1
X_23755_ _06628_ _06381_ _12514_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[50\]
+ _06371_ _06629_ VDD VSS OAI221_X1
X_23756_ _06613_ _15544_ _06630_ VDD VSS NAND2_X1
X_23757_ _00086_ _06400_ _06630_ _06631_ VDD VSS OAI21_X1
X_23758_ alu_adder_result_ex\[18\] _06456_ _06632_ VDD VSS
+ NOR2_X1
X_23759_ _06632_ _06392_ _03804_ _06633_ VDD VSS AOI21_X1
X_23760_ _06631_ _06633_ _06397_ _06634_ VDD VSS MUX2_X1
X_23761_ _06386_ _06634_ _06635_ VDD VSS NAND2_X1
X_23762_ _06406_ _06624_ _03431_ _03651_ net379 _06636_ VDD
+ VSS AOI221_X2
X_23763_ _06629_ _06635_ _06636_ _01321_ VDD VSS AOI21_X1
X_23764_ _06111_ _06501_ _06637_ VDD VSS NAND2_X1
X_23765_ _06637_ _06381_ _12589_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[51\]
+ _06371_ _06638_ VDD VSS OAI221_X2
X_23766_ _06613_ _15548_ _06639_ VDD VSS NAND2_X2
X_23767_ _00087_ _06400_ _06639_ _06640_ VDD VSS OAI21_X1
X_23768_ alu_adder_result_ex\[19\] _03806_ _06399_ _06641_
+ VDD VSS MUX2_X1
X_23769_ _06640_ _06641_ _06396_ _06642_ VDD VSS MUX2_X1
X_23770_ _06386_ _06642_ _06643_ VDD VSS NAND2_X1
X_23771_ _06406_ _06633_ _03431_ _03651_ alu_adder_result_ex\[19\]
+ _06644_ VDD VSS AOI221_X2
X_23772_ _06638_ _06643_ _06644_ _01322_ VDD VSS AOI21_X1
X_23773_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[52\]
+ _06370_ _06381_ net358 _06645_ VDD VSS OAI22_X2
X_23774_ _06405_ _06641_ _03403_ _03651_ alu_adder_result_ex\[20\]
+ _06646_ VDD VSS AOI221_X2
X_23775_ _06613_ _15540_ _06647_ VDD VSS NAND2_X1
X_23776_ _00088_ _06495_ _06647_ _06648_ VDD VSS OAI21_X1
X_23777_ alu_adder_result_ex\[20\] _06391_ _06649_ VDD VSS
+ NOR2_X1
X_23778_ _06649_ _06473_ _03808_ _06650_ VDD VSS AOI21_X1
X_23779_ _06648_ _06650_ _06395_ _06651_ VDD VSS MUX2_X1
X_23780_ _06385_ _06651_ _06652_ VDD VSS NAND2_X1
X_23781_ _10495_ _06154_ _06653_ VDD VSS NOR2_X1
X_23782_ _06645_ _06646_ _06652_ _06482_ _06653_ _01323_ VDD
+ VSS AOI221_X2
X_23783_ _06182_ _06183_ _06654_ VDD VSS AND2_X1
X_23784_ _06654_ _06501_ _06655_ VDD VSS NAND2_X1
X_23785_ _06655_ _06381_ net375 ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[53\]
+ _06371_ _06656_ VDD VSS OAI221_X1
X_23786_ _06407_ _06650_ _03614_ _03652_ net386 _06657_ VDD
+ VSS AOI221_X1
X_23787_ _00089_ _06495_ _06621_ _06658_ VDD VSS OAI21_X1
X_23788_ net386 _03810_ _06399_ _06659_ VDD VSS MUX2_X1
X_23789_ _06658_ _06659_ _06396_ _06660_ VDD VSS MUX2_X1
X_23790_ _06386_ _06660_ _06661_ VDD VSS NAND2_X1
X_23791_ _06656_ _06657_ _06661_ _01324_ VDD VSS AOI21_X1
X_23792_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[54\]
+ _06450_ _06662_ VDD VSS NAND2_X1
X_23793_ _06453_ _06659_ _03403_ _03650_ net396 _06663_ VDD
+ VSS AOI221_X2
X_23794_ _06663_ _06379_ _12859_ _06664_ VDD VSS AOI21_X1
X_23795_ _00090_ _06495_ _06630_ _06665_ VDD VSS OAI21_X1
X_23796_ net396 _06399_ _06666_ VDD VSS NOR2_X1
X_23797_ _06666_ _06391_ _03813_ _06667_ VDD VSS AOI21_X1
X_23798_ _06665_ _06667_ _06396_ _06668_ VDD VSS MUX2_X1
X_23799_ _06664_ _06668_ _06385_ _06669_ VDD VSS AOI21_X1
X_23800_ _03440_ _06371_ _06670_ VDD VSS NAND2_X1
X_23801_ _06598_ _06671_ VDD VSS INV_X1
X_23802_ _06662_ _06669_ _06670_ _06671_ _04503_ _01325_ VDD
+ VSS OAI221_X1
X_23803_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[55\]
+ _06370_ _06380_ _03724_ _06672_ VDD VSS OAI22_X1
X_23804_ _06405_ _06667_ _03403_ _03651_ net392 _06673_ VDD
+ VSS AOI221_X1
X_23805_ _00091_ _06495_ _06639_ _06674_ VDD VSS OAI21_X1
X_23806_ net393 _06391_ _06675_ VDD VSS NOR2_X1
X_23807_ _06675_ _06473_ _03815_ _06676_ VDD VSS AOI21_X2
X_23808_ _06674_ _06676_ _06395_ _06677_ VDD VSS MUX2_X1
X_23809_ _06385_ _06677_ _06678_ VDD VSS NAND2_X1
X_23810_ _04659_ _06679_ VDD VSS INV_X1
X_23811_ _06672_ _06673_ _06678_ _06482_ _06679_ _01326_ VDD
+ VSS AOI221_X1
X_23812_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[56\]
+ _06450_ _06680_ VDD VSS NAND2_X1
X_23813_ _06453_ alu_adder_result_ex\[24\] _03650_ _06681_
+ VDD VSS AOI21_X1
X_23814_ _06681_ _06682_ VDD VSS INV_X1
X_23815_ _00092_ _06531_ _06647_ _06683_ VDD VSS OAI21_X1
X_23816_ alu_adder_result_ex\[24\] _06399_ _06684_ VDD VSS
+ NOR2_X1
X_23817_ _06684_ _06391_ _03817_ _06685_ VDD VSS AOI21_X1
X_23818_ _06683_ _06685_ _06395_ _06686_ VDD VSS MUX2_X1
X_23819_ _06682_ _06686_ _03404_ _06676_ _03614_ _06687_ VDD
+ VSS AOI221_X2
X_23820_ _03450_ _06379_ _13023_ _06688_ VDD VSS AOI21_X1
X_23821_ _06482_ _06688_ _06689_ VDD VSS NAND2_X1
X_23822_ _06680_ _06687_ _06689_ _06671_ _04890_ _01327_ VDD
+ VSS OAI221_X1
X_23823_ _06453_ net387 _03650_ _06690_ VDD VSS AOI21_X1
X_23824_ _06690_ _06691_ VDD VSS INV_X1
X_23825_ _00093_ _06531_ _06621_ _06692_ VDD VSS OAI21_X1
X_23826_ alu_adder_result_ex\[25\] _06399_ _06693_ VDD VSS
+ NOR2_X1
X_23827_ _06693_ _06391_ _03819_ _06694_ VDD VSS AOI21_X1
X_23828_ _06692_ _06694_ _06395_ _06695_ VDD VSS MUX2_X1
X_23829_ _06691_ _06695_ _03404_ _06685_ _03431_ _06696_ VDD
+ VSS AOI221_X2
X_23830_ _13097_ _06564_ _06697_ VDD VSS NOR2_X1
X_23831_ _06375_ _06696_ _06697_ _06698_ VDD VSS OAI21_X1
X_23832_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[57\]
+ _04949_ _06370_ _06699_ VDD VSS MUX2_X1
X_23833_ _06698_ _06699_ _01328_ VDD VSS AND2_X1
X_23834_ alu_adder_result_ex\[5\] _03696_ _03779_ _06700_
+ VDD VSS MUX2_X1
X_23835_ _06700_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[5\]
+ _03612_ _01329_ VDD VSS MUX2_X1
X_23836_ _06453_ _06694_ _03431_ _03651_ net397 _06701_ VDD
+ VSS AOI221_X1
X_23837_ _00094_ _06531_ _06630_ _06702_ VDD VSS OAI21_X1
X_23838_ net397 _03821_ _06390_ _06703_ VDD VSS MUX2_X1
X_23839_ _06702_ _06703_ _06395_ _06704_ VDD VSS MUX2_X1
X_23840_ _06385_ _06704_ _06705_ VDD VSS NAND2_X1
X_23841_ _06701_ _06705_ _06706_ VDD VSS NAND2_X1
X_23842_ net356 _06564_ _06707_ VDD VSS OR2_X1
X_23843_ _03440_ _06383_ _06706_ _06707_ _06708_ VDD VSS NAND4_X1
X_23844_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[58\]
+ _06709_ VDD VSS INV_X1
X_23845_ _06708_ _06671_ _05002_ _06709_ _06383_ _01330_ VDD
+ VSS OAI221_X1
X_23846_ _06452_ _06703_ _03403_ _03650_ alu_adder_result_ex\[27\]
+ _06710_ VDD VSS AOI221_X2
X_23847_ _06531_ _06639_ _06711_ VDD VSS OR2_X1
X_23848_ _00095_ _06378_ _06711_ _06712_ VDD VSS NAND3_X1
X_23849_ alu_adder_result_ex\[27\] _06390_ _06713_ VDD VSS
+ NOR2_X1
X_23850_ _06713_ _06399_ _03824_ _06714_ VDD VSS AOI21_X2
X_23851_ _03404_ _06712_ _06714_ _06378_ _06715_ VDD VSS OAI211_X2
X_23852_ _13259_ _06379_ _06710_ _06715_ _06716_ VDD VSS AOI22_X1
X_23853_ _04811_ _06716_ _03440_ _06717_ VDD VSS MUX2_X1
X_23854_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[59\]
+ _06717_ _06383_ _01331_ VDD VSS MUX2_X1
X_23855_ _03450_ _05089_ _06383_ _06718_ VDD VSS NAND3_X1
X_23856_ _06452_ _06714_ _03403_ _03650_ alu_adder_result_ex\[28\]
+ _06719_ VDD VSS AOI221_X2
X_23857_ _06719_ _06379_ _03131_ _06720_ VDD VSS AOI21_X1
X_23858_ alu_adder_result_ex\[28\] _06391_ _06721_ VDD VSS
+ NOR2_X1
X_23859_ _06721_ _06473_ _03827_ _06722_ VDD VSS AOI21_X2
X_23860_ _06378_ _06722_ _06723_ VDD VSS NOR2_X1
X_23861_ _00096_ _06724_ VDD VSS INV_X1
X_23862_ _06570_ _06725_ VDD VSS INV_X1
X_23863_ _06724_ _06725_ _06614_ _06726_ VDD VSS AOI21_X2
X_23864_ _06723_ _06726_ _06387_ _06727_ VDD VSS AOI21_X1
X_23865_ _06720_ _06727_ _06385_ _06728_ VDD VSS AOI21_X1
X_23866_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[60\]
+ _06729_ VDD VSS INV_X1
X_23867_ _06718_ _06728_ _06670_ _06729_ _06383_ _01332_ VDD
+ VSS OAI221_X1
X_23868_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[61\]
+ _06450_ _06598_ _05111_ _06730_ VDD VSS AOI22_X1
X_23869_ _06453_ _06722_ _03431_ _03651_ net246 _06731_ VDD
+ VSS AOI221_X2
X_23870_ _06731_ _06732_ VDD VSS INV_X1
X_23871_ _00097_ _06570_ _06621_ _06733_ VDD VSS OAI21_X1
X_23872_ net246 _03829_ _06399_ _06734_ VDD VSS MUX2_X1
X_23873_ _06733_ _06734_ _06396_ _06735_ VDD VSS MUX2_X1
X_23874_ _06732_ _06735_ _06385_ _06736_ VDD VSS AOI21_X1
X_23875_ _06375_ _06564_ _03769_ _06737_ VDD VSS OAI21_X1
X_23876_ _06730_ _06736_ _06737_ _01333_ VDD VSS OAI21_X1
X_23877_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[62\]
+ _06450_ _06738_ VDD VSS NAND2_X1
X_23878_ _06453_ _06734_ _03403_ _03650_ alu_adder_result_ex\[30\]
+ _06739_ VDD VSS AOI221_X1
X_23879_ _06739_ _06740_ VDD VSS INV_X1
X_23880_ _00098_ _06570_ _06630_ _06741_ VDD VSS OAI21_X1
X_23881_ alu_adder_result_ex\[30\] _03831_ _06473_ _06742_
+ VDD VSS MUX2_X1
X_23882_ _06741_ _06742_ _06396_ _06743_ VDD VSS MUX2_X1
X_23883_ _06740_ _06743_ _06385_ _06744_ VDD VSS AOI21_X1
X_23884_ _03440_ _06564_ _03311_ _06745_ VDD VSS OAI21_X1
X_23885_ _06374_ _06745_ _06746_ VDD VSS OR2_X1
X_23886_ _06738_ _06744_ _06746_ _06671_ _05173_ _01334_ VDD
+ VSS OAI221_X1
X_23887_ _04791_ _05223_ _06747_ VDD VSS NAND2_X1
X_23888_ _06747_ _05219_ _04791_ _06748_ VDD VSS OAI21_X1
X_23889_ _03408_ _06450_ _06598_ _06748_ _06749_ VDD VSS AOI22_X1
X_23890_ _06366_ net277 _04044_ _06750_ VDD VSS OAI21_X2
X_23891_ _00099_ _06570_ _06639_ _06751_ VDD VSS OAI21_X2
X_23892_ _03408_ net323 _06752_ VDD VSS AND2_X1
X_23893_ _06751_ _06752_ _06395_ _06753_ VDD VSS MUX2_X1
X_23894_ _06750_ _06753_ _03404_ _06742_ _03614_ _06754_ VDD
+ VSS AOI221_X2
X_23895_ _06375_ _06564_ _03783_ _06755_ VDD VSS OAI21_X1
X_23896_ _06749_ _06754_ _06755_ _01335_ VDD VSS OAI21_X1
X_23897_ _15822_ _06756_ VDD VSS INV_X1
X_23898_ _15811_ _05107_ _05161_ _06757_ VDD VSS NAND3_X1
X_23899_ _05170_ _05166_ _06757_ _06758_ VDD VSS AOI21_X1
X_23900_ _15823_ _15816_ _06758_ _06759_ VDD VSS OAI21_X1
X_23901_ _06756_ _06759_ _06760_ VDD VSS AND2_X1
X_23902_ _15830_ _06760_ _06761_ VDD VSS XNOR2_X1
X_23903_ _03450_ _04791_ _06761_ _06762_ VDD VSS NAND3_X1
X_23904_ _06453_ _06378_ _06752_ _03614_ _06763_ VDD VSS AOI22_X2
X_23905_ _06762_ _06763_ _03450_ _06764_ VDD VSS OAI21_X1
X_23906_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.imd_val_q_i\[66\]
+ _06764_ _06383_ _01336_ VDD VSS MUX2_X1
X_23907_ _06450_ _06387_ _06453_ _06765_ VDD VSS AOI21_X1
X_23908_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.imd_val_q_i\[67\]
+ _06383_ _06766_ VDD VSS NOR2_X1
X_23909_ _10888_ _03450_ _04791_ _06383_ _06767_ VDD VSS NAND4_X1
X_23910_ _15344_ _15732_ _06768_ VDD VSS XOR2_X1
X_23911_ _15340_ _06768_ _06769_ VDD VSS XNOR2_X1
X_23912_ _15347_ _14815_ _06770_ VDD VSS XOR2_X1
X_23913_ _15335_ _15826_ _06771_ VDD VSS XNOR2_X1
X_23914_ _06770_ _06771_ _06772_ VDD VSS XNOR2_X1
X_23915_ _15261_ _15304_ _06773_ VDD VSS XNOR2_X1
X_23916_ _06772_ _06773_ _06774_ VDD VSS XNOR2_X1
X_23917_ _15327_ _15220_ _06775_ VDD VSS XOR2_X1
X_23918_ _15326_ _15350_ _06776_ VDD VSS XNOR2_X1
X_23919_ _06775_ _06776_ _06777_ VDD VSS XNOR2_X1
X_23920_ _15332_ _15338_ _06778_ VDD VSS XNOR2_X1
X_23921_ _15303_ _15330_ _06779_ VDD VSS XNOR2_X1
X_23922_ _06778_ _06779_ _06780_ VDD VSS XNOR2_X1
X_23923_ _06777_ _06780_ _06781_ VDD VSS XNOR2_X1
X_23924_ _06774_ _06781_ _06782_ VDD VSS XNOR2_X1
X_23925_ _06769_ _06782_ _06783_ VDD VSS XNOR2_X1
X_23926_ _03802_ _03794_ _00132_ _06784_ VDD VSS OAI21_X1
X_23927_ _03664_ _06784_ _06785_ VDD VSS NAND2_X1
X_23928_ _06783_ _06785_ _06786_ VDD VSS XNOR2_X1
X_23929_ _15823_ _06787_ VDD VSS INV_X1
X_23930_ _06756_ _05222_ _06787_ _06788_ VDD VSS OAI21_X1
X_23931_ _15829_ _06788_ _15830_ _06789_ VDD VSS AOI21_X1
X_23932_ _06786_ _06789_ _06790_ VDD VSS XNOR2_X1
X_23933_ _06765_ _06766_ _06767_ _06790_ _01337_ VDD VSS OAI22_X1
X_23934_ alu_adder_result_ex\[6\] net345 _03779_ _06791_ VDD
+ VSS MUX2_X1
X_23935_ _06791_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[6\]
+ _03612_ _01338_ VDD VSS MUX2_X1
X_23936_ alu_adder_result_ex\[7\] _11202_ _03779_ _06792_
+ VDD VSS MUX2_X1
X_23937_ _06792_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[7\]
+ _03612_ _01339_ VDD VSS MUX2_X1
X_23938_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[8\]
+ _03613_ _06793_ VDD VSS NAND2_X1
X_23939_ _11241_ _03780_ _06794_ VDD VSS NAND2_X1
X_23940_ _06794_ _03780_ alu_adder_result_ex\[8\] _06795_
+ VDD VSS OAI21_X1
X_23941_ _06793_ _06795_ _03613_ _01340_ VDD VSS OAI21_X1
X_23942_ alu_adder_result_ex\[9\] _03727_ _03779_ _06796_
+ VDD VSS MUX2_X1
X_23943_ _06796_ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[9\]
+ _03612_ _01341_ VDD VSS MUX2_X1
X_23944_ _03836_ _03921_ _06797_ VDD VSS NOR2_X4
X_23945_ cs_registers_i.csr_mepc_o\[4\] _06797_ _06798_ VDD
+ VSS NAND2_X1
X_23946_ _03918_ _03867_ _06799_ VDD VSS NAND2_X2
X_23947_ _03863_ _03864_ _06799_ _06800_ VDD VSS NAND3_X1
X_23948_ _03856_ _03857_ _06801_ VDD VSS NAND2_X1
X_23949_ _06800_ _03866_ _03902_ _06801_ _03900_ _06802_ VDD
+ VSS AOI221_X2
X_23950_ _03465_ _03839_ _03921_ _06803_ VDD VSS OR3_X4
X_23951_ _06798_ _06802_ _03873_ _01164_ _06803_ _06804_ VDD
+ VSS OAI221_X2
X_23952_ _03889_ _06804_ _06805_ VDD VSS OR2_X1
X_23953_ _06805_ alu_adder_result_ex\[4\] _03929_ _06806_
+ VDD VSS AOI21_X4
X_23954_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[4\]
+ _03936_ _06807_ VDD VSS NOR2_X2
X_23955_ _06806_ _06807_ _06808_ VDD VSS NOR2_X2
X_23956_ net126 cs_registers_i.mie_q\[15\] _03860_ _06809_
+ VDD VSS NAND3_X2
X_23957_ _03865_ _06799_ _06810_ VDD VSS AND2_X1
X_23958_ _03873_ _06809_ _06810_ _06811_ VDD VSS AOI21_X4
X_23959_ cs_registers_i.csr_mepc_o\[5\] _06812_ VDD VSS INV_X1
X_23960_ _06812_ _03894_ _03895_ _01165_ _06813_ VDD VSS OAI22_X2
X_23961_ _03952_ _03891_ _06814_ VDD VSS NOR2_X1
X_23962_ _06811_ _06813_ _06814_ alu_adder_result_ex\[5\]
+ net254 _06815_ VDD VSS AOI221_X2
X_23963_ _03935_ _06815_ _06816_ VDD VSS AND2_X2
X_23964_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[5\]
+ _06817_ VDD VSS INV_X1
X_23965_ _06816_ _03957_ _06817_ _06818_ VDD VSS AOI21_X4
X_23966_ _16111_ _06808_ _06818_ _06819_ VDD VSS NAND3_X1
X_23967_ _03436_ _03954_ _03838_ _06820_ VDD VSS OAI21_X2
X_23968_ _03459_ _06820_ _06821_ VDD VSS NAND2_X4
X_23969_ _01167_ _06821_ _06822_ VDD VSS NOR2_X1
X_23970_ _06822_ _03922_ cs_registers_i.csr_mepc_o\[8\] cs_registers_i.csr_depc_o\[8\]
+ _03925_ _06823_ VDD VSS AOI221_X2
X_23971_ net25 _03897_ _06824_ VDD VSS NAND2_X1
X_23972_ _03935_ _06823_ _06824_ _06825_ VDD VSS NAND3_X2
X_23973_ _06825_ alu_adder_result_ex\[8\] _03929_ _06826_
+ VDD VSS AOI21_X4
X_23974_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[8\]
+ _06827_ VDD VSS INV_X1
X_23975_ _06826_ _03957_ _06827_ _06828_ VDD VSS AOI21_X4
X_23976_ _01168_ _06821_ _06829_ VDD VSS NOR2_X1
X_23977_ _06829_ _03922_ cs_registers_i.csr_mepc_o\[9\] cs_registers_i.csr_depc_o\[9\]
+ _03925_ _06830_ VDD VSS AOI221_X2
X_23978_ net254 alu_adder_result_ex\[9\] _06831_ VDD VSS NAND2_X1
X_23979_ _06830_ _06831_ _06832_ VDD VSS NAND2_X1
X_23980_ net254 _03893_ _06833_ VDD VSS NOR2_X1
X_23981_ _03461_ _03896_ _06834_ VDD VSS NAND2_X2
X_23982_ _06833_ _06834_ _06835_ VDD VSS NAND2_X4
X_23983_ net26 _06832_ _06835_ _06836_ VDD VSS MUX2_X1
X_23984_ _03936_ _06836_ _06837_ VDD VSS NAND2_X1
X_23985_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[9\]
+ _06838_ VDD VSS INV_X1
X_23986_ _06837_ _03936_ _06838_ _06839_ VDD VSS OAI21_X2
X_23987_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[7\]
+ _03935_ _06840_ VDD VSS NOR2_X2
X_23988_ net254 alu_adder_result_ex\[7\] _06841_ VDD VSS NAND2_X1
X_23989_ cs_registers_i.csr_mepc_o\[7\] _03922_ _03925_ cs_registers_i.csr_depc_o\[7\]
+ _06842_ VDD VSS AOI22_X2
X_23990_ _03898_ _06841_ _06842_ _06843_ VDD VSS AND3_X2
X_23991_ _03873_ _06799_ _03902_ _06844_ VDD VSS AOI21_X4
X_23992_ _06844_ _03922_ cs_registers_i.csr_mepc_o\[6\] _05601_
+ _03925_ _06845_ VDD VSS AOI221_X2
X_23993_ _03935_ _06845_ _06846_ VDD VSS NAND2_X1
X_23994_ _06846_ alu_adder_result_ex\[6\] _03929_ _06847_
+ VDD VSS AOI21_X4
X_23995_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[6\]
+ _03935_ _06848_ VDD VSS NOR2_X2
X_23996_ _06840_ _06843_ _06847_ _06848_ _06849_ VDD VSS NOR4_X4
X_23997_ _06828_ _06839_ _06849_ _06850_ VDD VSS NAND3_X1
X_23998_ _06819_ _06850_ _06851_ VDD VSS OR2_X1
X_23999_ _04154_ _06852_ VDD VSS BUF_X4
X_24000_ cs_registers_i.csr_mepc_o\[10\] _03922_ _03925_ cs_registers_i.csr_depc_o\[10\]
+ _06853_ VDD VSS AOI22_X1
X_24001_ _06853_ _06821_ _01169_ _06854_ VDD VSS OAI21_X1
X_24002_ _06854_ alu_adder_result_ex\[10\] _03929_ net3 _03897_
+ _06855_ VDD VSS AOI221_X2
X_24003_ _06852_ _06855_ _06856_ VDD VSS OR2_X1
X_24004_ _06851_ _06856_ _06857_ VDD VSS XOR2_X1
X_24005_ _06852_ _06858_ VDD VSS BUF_X4
X_24006_ _06857_ _06858_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[10\]
+ _06859_ VDD VSS AOI21_X1
X_24007_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[10\]
+ _06860_ VDD VSS INV_X1
X_24008_ _06860_ _04164_ _06851_ _06861_ VDD VSS OR3_X1
X_24009_ _06861_ _16107_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[10\]
+ _06862_ VDD VSS OAI21_X1
X_24010_ _06858_ _06863_ VDD VSS CLKBUF_X3
X_24011_ _06859_ _06862_ _06863_ _01342_ VDD VSS AOI21_X1
X_24012_ _00550_ _03844_ _03953_ _06864_ VDD VSS NAND3_X1
X_24013_ cs_registers_i.csr_mtvec_o\[11\] _03878_ _03953_
+ _06865_ VDD VSS OR3_X1
X_24014_ _03893_ _06864_ _06865_ _06866_ VDD VSS NAND3_X1
X_24015_ cs_registers_i.csr_mepc_o\[11\] _03922_ _03925_ cs_registers_i.csr_depc_o\[11\]
+ _06867_ VDD VSS AOI22_X2
X_24016_ _06866_ _06867_ _06868_ VDD VSS NAND2_X1
X_24017_ _06868_ alu_adder_result_ex\[11\] net254 net4 _03897_
+ _06869_ VDD VSS AOI221_X2
X_24018_ _03957_ _06869_ _06870_ VDD VSS NOR2_X1
X_24019_ _06870_ _03957_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[11\]
+ _06871_ VDD VSS AOI21_X2
X_24020_ _06860_ _06855_ _03936_ _06872_ VDD VSS MUX2_X2
X_24021_ _16109_ _06873_ VDD VSS INV_X1
X_24022_ _16110_ _06818_ _06874_ VDD VSS NAND2_X1
X_24023_ _06873_ _06806_ _06807_ _06874_ _06875_ VDD VSS NOR4_X4
X_24024_ _06828_ _06839_ _06849_ _06875_ _06876_ VDD VSS NAND4_X1
X_24025_ _06872_ _06876_ _06877_ VDD VSS NOR2_X1
X_24026_ _06871_ _06877_ _06878_ VDD VSS XNOR2_X1
X_24027_ _06852_ _04164_ _06879_ VDD VSS NAND2_X2
X_24028_ _06879_ _06880_ VDD VSS CLKBUF_X3
X_24029_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[11\]
+ _06878_ _06880_ _01343_ VDD VSS MUX2_X1
X_24030_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[12\]
+ _06881_ VDD VSS INV_X1
X_24031_ _06819_ _06850_ _06871_ _06872_ _06882_ VDD VSS OR4_X2
X_24032_ _04164_ _06882_ _06883_ VDD VSS NOR2_X1
X_24033_ _06881_ _06883_ _06884_ VDD VSS XNOR2_X1
X_24034_ _03931_ alu_adder_result_ex\[12\] _06885_ VDD VSS
+ NAND2_X1
X_24035_ cs_registers_i.csr_mepc_o\[12\] _03922_ _03926_ cs_registers_i.csr_depc_o\[12\]
+ _06886_ VDD VSS AOI22_X2
X_24036_ _06886_ _06821_ _00549_ _06887_ VDD VSS OAI21_X2
X_24037_ _03897_ _06888_ VDD VSS BUF_X4
X_24038_ _06888_ _06889_ VDD VSS BUF_X4
X_24039_ _06887_ _06889_ net5 _06890_ VDD VSS AOI21_X1
X_24040_ _06885_ _06890_ _06891_ VDD VSS NAND2_X1
X_24041_ _06882_ _06891_ _06892_ VDD VSS XNOR2_X1
X_24042_ _03939_ _06893_ VDD VSS BUF_X4
X_24043_ _06884_ _06892_ _06893_ _01344_ VDD VSS MUX2_X1
X_24044_ cs_registers_i.csr_mepc_o\[13\] _03923_ _03926_ cs_registers_i.csr_depc_o\[13\]
+ _06894_ VDD VSS AOI22_X1
X_24045_ _06821_ _06895_ VDD VSS BUF_X4
X_24046_ _06894_ _06895_ _01170_ _06896_ VDD VSS OAI21_X1
X_24047_ _06896_ _06888_ net6 _06897_ VDD VSS AOI21_X1
X_24048_ _03936_ _06897_ _06898_ VDD VSS NAND2_X1
X_24049_ _06898_ alu_adder_result_ex\[13\] _03930_ _06899_
+ VDD VSS AOI21_X2
X_24050_ _06899_ _06900_ VDD VSS INV_X1
X_24051_ _06900_ _03938_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[13\]
+ _06901_ VDD VSS OAI21_X2
X_24052_ _06828_ _06849_ _06902_ VDD VSS NAND2_X1
X_24053_ _06887_ alu_adder_result_ex\[12\] _03929_ net5 _06888_
+ _06903_ VDD VSS AOI221_X2
X_24054_ _06881_ _06903_ _03937_ _06904_ VDD VSS MUX2_X2
X_24055_ _04154_ _06869_ _06905_ VDD VSS OR2_X1
X_24056_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[11\]
+ _06906_ VDD VSS INV_X1
X_24057_ _06905_ _03937_ _06906_ _06907_ VDD VSS OAI21_X1
X_24058_ _06839_ _06907_ _06875_ _06908_ VDD VSS NAND3_X1
X_24059_ _06902_ _06872_ _06904_ _06908_ _06909_ VDD VSS NOR4_X4
X_24060_ _06901_ _06909_ _06910_ VDD VSS XNOR2_X1
X_24061_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[13\]
+ _06910_ _06880_ _01345_ VDD VSS MUX2_X1
X_24062_ _06882_ _06901_ _06904_ _06911_ VDD VSS NOR3_X4
X_24063_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[14\]
+ _16107_ _06911_ _06912_ VDD VSS NAND3_X1
X_24064_ _06912_ _16107_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[14\]
+ _06913_ VDD VSS OAI21_X1
X_24065_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[14\]
+ _04154_ _06914_ VDD VSS NAND2_X1
X_24066_ cs_registers_i.csr_mepc_o\[14\] _03923_ _03926_ cs_registers_i.csr_depc_o\[14\]
+ _06915_ VDD VSS AOI22_X1
X_24067_ _06915_ _06895_ _01171_ _06916_ VDD VSS OAI21_X1
X_24068_ _06916_ alu_adder_result_ex\[14\] _03929_ net7 _06888_
+ _06917_ VDD VSS AOI221_X2
X_24069_ _04154_ _06917_ _06918_ VDD VSS OR2_X2
X_24070_ _06911_ _06918_ _06919_ VDD VSS XOR2_X1
X_24071_ _06863_ _06913_ _06914_ _06919_ _01346_ VDD VSS AOI22_X1
X_24072_ _11426_ _12266_ _12273_ _06920_ VDD VSS NOR3_X2
X_24073_ cs_registers_i.csr_mepc_o\[15\] _03469_ _03476_ cs_registers_i.csr_depc_o\[15\]
+ _06921_ VDD VSS AOI22_X2
X_24074_ _01172_ _06821_ _06921_ _03921_ _06922_ VDD VSS OAI22_X2
X_24075_ _06888_ _06920_ _06922_ _06923_ VDD VSS OR3_X1
X_24076_ _06923_ _03888_ _03883_ net8 _06835_ _06924_ VDD
+ VSS OAI221_X2
X_24077_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[15\]
+ _06925_ VDD VSS INV_X1
X_24078_ _06924_ _03936_ _06925_ _06926_ VDD VSS OAI21_X2
X_24079_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[13\]
+ _06927_ VDD VSS INV_X1
X_24080_ _06899_ _06852_ _06927_ _06928_ VDD VSS AOI21_X2
X_24081_ _06914_ _06918_ _06929_ VDD VSS NAND2_X2
X_24082_ _06928_ _06909_ _06929_ _06930_ VDD VSS NAND3_X2
X_24083_ _06926_ _06930_ _06931_ VDD VSS XNOR2_X1
X_24084_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[15\]
+ _06931_ _06880_ _01347_ VDD VSS MUX2_X1
X_24085_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[16\]
+ _03936_ _06932_ VDD VSS NOR2_X1
X_24086_ _03844_ _01173_ _03953_ _06933_ VDD VSS NAND3_X1
X_24087_ cs_registers_i.csr_mtvec_o\[16\] _03878_ _03953_
+ _06934_ VDD VSS OR3_X1
X_24088_ _03893_ _06933_ _06934_ _06935_ VDD VSS NAND3_X1
X_24089_ cs_registers_i.csr_mepc_o\[16\] _03923_ _03926_ cs_registers_i.csr_depc_o\[16\]
+ _06936_ VDD VSS AOI22_X1
X_24090_ net9 _06888_ _06937_ VDD VSS NAND2_X1
X_24091_ _03936_ _06935_ _06936_ _06937_ _06938_ VDD VSS AND4_X2
X_24092_ _03930_ _12445_ _12446_ _06939_ VDD VSS NAND3_X2
X_24093_ _06932_ _06938_ _06939_ _06940_ VDD VSS AOI21_X2
X_24094_ _06911_ _06929_ _06926_ _06941_ VDD VSS AND3_X1
X_24095_ _06940_ _06941_ _06942_ VDD VSS XOR2_X1
X_24096_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[16\]
+ _06942_ _06880_ _01348_ VDD VSS MUX2_X1
X_24097_ _06926_ _06940_ _06943_ VDD VSS NAND2_X1
X_24098_ _06930_ _06943_ _06944_ VDD VSS NOR2_X1
X_24099_ _16107_ _06944_ _06945_ VDD VSS NAND2_X1
X_24100_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[17\]
+ _06945_ _06946_ VDD VSS XNOR2_X1
X_24101_ cs_registers_i.csr_mepc_o\[17\] _03469_ _03476_ cs_registers_i.csr_depc_o\[17\]
+ _06947_ VDD VSS AOI22_X2
X_24102_ _01174_ _06821_ _06947_ _03921_ _06948_ VDD VSS OAI22_X2
X_24103_ _06948_ alu_adder_result_ex\[17\] _03929_ _06949_
+ VDD VSS AOI21_X1
X_24104_ _06835_ _06949_ _06950_ VDD VSS NAND2_X1
X_24105_ _06950_ _06835_ net10 _06951_ VDD VSS OAI21_X2
X_24106_ _06944_ _06951_ _06952_ VDD VSS XNOR2_X1
X_24107_ _06946_ _06952_ _06893_ _01349_ VDD VSS MUX2_X1
X_24108_ net11 _06835_ _06953_ VDD VSS NOR2_X1
X_24109_ cs_registers_i.csr_depc_o\[18\] _06954_ VDD VSS INV_X1
X_24110_ _06954_ _06803_ _06895_ _01175_ _06955_ VDD VSS OAI22_X1
X_24111_ _06955_ _06797_ cs_registers_i.csr_mepc_o\[18\] _06956_
+ VDD VSS AOI21_X2
X_24112_ _06835_ _06956_ _06957_ VDD VSS NAND2_X1
X_24113_ _06957_ alu_adder_result_ex\[18\] _03930_ _06958_
+ VDD VSS AOI21_X2
X_24114_ _06852_ _06953_ _06958_ _06959_ VDD VSS OR3_X2
X_24115_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[18\]
+ _06960_ VDD VSS INV_X1
X_24116_ _06959_ _03938_ _06960_ _06961_ VDD VSS OAI21_X2
X_24117_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[17\]
+ _03957_ _06962_ VDD VSS NAND2_X1
X_24118_ _06962_ _06951_ _04154_ _06963_ VDD VSS OAI21_X1
X_24119_ _06926_ _06940_ _06963_ _06964_ VDD VSS AND3_X1
X_24120_ _06911_ _06929_ _06964_ _06965_ VDD VSS AND3_X1
X_24121_ _06961_ _06965_ _06966_ VDD VSS XOR2_X1
X_24122_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[18\]
+ _06966_ _06880_ _01350_ VDD VSS MUX2_X1
X_24123_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[19\]
+ _03957_ _06967_ VDD VSS AND2_X1
X_24124_ _06871_ _06872_ _06876_ _06904_ _06968_ VDD VSS NOR4_X1
X_24125_ _06928_ _06968_ _06929_ _06969_ VDD VSS AND3_X1
X_24126_ _06969_ _06961_ _06964_ _06970_ VDD VSS NAND3_X1
X_24127_ _06967_ _06970_ _04164_ _06971_ VDD VSS OAI21_X1
X_24128_ cs_registers_i.csr_mepc_o\[19\] _03922_ _03925_ cs_registers_i.csr_depc_o\[19\]
+ _06972_ VDD VSS AOI22_X1
X_24129_ _06972_ _06821_ _01176_ _06973_ VDD VSS OAI21_X1
X_24130_ _06973_ alu_adder_result_ex\[19\] _03929_ net12 _06888_
+ _06974_ VDD VSS AOI221_X2
X_24131_ _03957_ _06974_ _06975_ VDD VSS NOR2_X2
X_24132_ _06975_ _06976_ VDD VSS INV_X1
X_24133_ _06970_ _06976_ _06977_ VDD VSS NAND2_X1
X_24134_ _06880_ _06977_ _06978_ VDD VSS NAND2_X1
X_24135_ _06967_ _06979_ VDD VSS INV_X1
X_24136_ _06970_ _06976_ _06979_ _06980_ VDD VSS AOI21_X1
X_24137_ _06971_ _06978_ _06980_ _01351_ VDD VSS OAI21_X1
X_24138_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[20\]
+ _06981_ VDD VSS INV_X1
X_24139_ _06975_ _06835_ net11 _06982_ VDD VSS OAI21_X2
X_24140_ _06960_ _06979_ _06982_ _06958_ _06983_ VDD VSS OAI22_X4
X_24141_ _06964_ _06983_ _06984_ VDD VSS AND2_X1
X_24142_ _06911_ _06929_ _06984_ _06985_ VDD VSS NAND3_X1
X_24143_ _04164_ _06985_ _06986_ VDD VSS NOR2_X1
X_24144_ _06981_ _06986_ _06987_ VDD VSS XNOR2_X1
X_24145_ _11426_ _12776_ _12778_ _12781_ _06988_ VDD VSS NOR4_X4
X_24146_ _03953_ _06989_ VDD VSS BUF_X4
X_24147_ _03844_ _01177_ _06989_ _06990_ VDD VSS NAND3_X1
X_24148_ cs_registers_i.csr_mtvec_o\[20\] _03878_ _03953_
+ _06991_ VDD VSS OR3_X1
X_24149_ _03893_ _06990_ _06991_ _06992_ VDD VSS NAND3_X1
X_24150_ cs_registers_i.csr_mepc_o\[20\] _03923_ _03926_ cs_registers_i.csr_depc_o\[20\]
+ _06993_ VDD VSS AOI22_X2
X_24151_ net13 _06888_ _06994_ VDD VSS NAND2_X1
X_24152_ _06992_ _06993_ _06994_ _06995_ VDD VSS NAND3_X2
X_24153_ _06988_ _06995_ _06996_ VDD VSS NOR2_X1
X_24154_ _06985_ _06996_ _06997_ VDD VSS XOR2_X1
X_24155_ _03939_ _06998_ VDD VSS BUF_X4
X_24156_ _06987_ _06997_ _06998_ _01352_ VDD VSS MUX2_X1
X_24157_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[21\]
+ _06880_ _06999_ VDD VSS NOR2_X1
X_24158_ cs_registers_i.csr_depc_o\[21\] _07000_ VDD VSS INV_X1
X_24159_ _07000_ _06803_ _06821_ _01178_ _07001_ VDD VSS OAI22_X2
X_24160_ _07001_ alu_adder_result_ex\[21\] _03929_ cs_registers_i.csr_mepc_o\[21\]
+ _03923_ _07002_ VDD VSS AOI221_X1
X_24161_ net14 _06889_ _07003_ VDD VSS NAND2_X1
X_24162_ _07002_ _07003_ _07004_ VDD VSS NAND2_X1
X_24163_ _03937_ _07004_ _07005_ VDD VSS NAND2_X2
X_24164_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[21\]
+ _07006_ VDD VSS INV_X1
X_24165_ _07005_ _03937_ _07006_ _07007_ VDD VSS OAI21_X4
X_24166_ _03957_ _06988_ _06995_ _07008_ VDD VSS NOR3_X2
X_24167_ _07008_ _04154_ _06981_ _07009_ VDD VSS AOI21_X4
X_24168_ _06969_ _06984_ _07009_ _07010_ VDD VSS NAND3_X1
X_24169_ _07007_ _07010_ _07011_ VDD VSS XOR2_X1
X_24170_ _06999_ _07011_ _06880_ _01353_ VDD VSS AOI21_X1
X_24171_ cs_registers_i.csr_mepc_o\[22\] _03924_ _03927_ cs_registers_i.csr_depc_o\[22\]
+ _07012_ VDD VSS AOI22_X1
X_24172_ _07012_ _06895_ _01179_ _07013_ VDD VSS OAI21_X1
X_24173_ _07013_ _06889_ net15 _07014_ VDD VSS AOI21_X1
X_24174_ _03937_ _07014_ _07015_ VDD VSS NAND2_X1
X_24175_ _07015_ alu_adder_result_ex\[22\] _03930_ _07016_
+ VDD VSS AOI21_X2
X_24176_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[22\]
+ _03937_ _07017_ VDD VSS NOR2_X1
X_24177_ _07017_ _07016_ _07018_ VDD VSS NOR2_X1
X_24178_ _06965_ _06983_ _07007_ _07009_ _07019_ VDD VSS NAND4_X1
X_24179_ _07016_ _07018_ _07019_ _07020_ VDD VSS MUX2_X1
X_24180_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[22\]
+ _06858_ _04164_ _07021_ VDD VSS NAND3_X1
X_24181_ _16107_ _07017_ _07022_ VDD VSS NAND2_X1
X_24182_ _07021_ _07022_ _07019_ _07023_ VDD VSS OAI21_X1
X_24183_ _07020_ _07023_ _01354_ VDD VSS OR2_X1
X_24184_ cs_registers_i.csr_mepc_o\[23\] _03923_ _03926_ cs_registers_i.csr_depc_o\[23\]
+ _07024_ VDD VSS AOI22_X1
X_24185_ _07024_ _06895_ _01180_ _07025_ VDD VSS OAI21_X1
X_24186_ _07025_ _06889_ net16 _07026_ VDD VSS AOI21_X1
X_24187_ _03937_ _07026_ _07027_ VDD VSS NAND2_X1
X_24188_ _07027_ alu_adder_result_ex\[23\] _03930_ _07028_
+ VDD VSS AOI21_X1
X_24189_ _07028_ _07029_ VDD VSS INV_X2
X_24190_ _07029_ _03938_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[23\]
+ _07030_ VDD VSS OAI21_X4
X_24191_ _06984_ _07007_ _07009_ _07018_ _07031_ VDD VSS NAND4_X1
X_24192_ _06930_ _07031_ _07032_ VDD VSS NOR2_X1
X_24193_ _07030_ _07032_ _07033_ VDD VSS XNOR2_X1
X_24194_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[23\]
+ _07033_ _06880_ _01355_ VDD VSS MUX2_X1
X_24195_ cs_registers_i.csr_mepc_o\[24\] _03923_ _03926_ cs_registers_i.csr_depc_o\[24\]
+ _07034_ VDD VSS AOI22_X1
X_24196_ _07034_ _06895_ _01181_ _07035_ VDD VSS OAI21_X1
X_24197_ _07035_ _06889_ net17 _07036_ VDD VSS AOI21_X1
X_24198_ _03936_ _07036_ _07037_ VDD VSS NAND2_X1
X_24199_ _07037_ alu_adder_result_ex\[24\] _03930_ _07038_
+ VDD VSS AOI21_X2
X_24200_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[24\]
+ _03937_ _07039_ VDD VSS NOR2_X1
X_24201_ _07038_ _07039_ _07040_ VDD VSS OR2_X2
X_24202_ _06911_ _06929_ _07041_ VDD VSS NAND2_X1
X_24203_ _07041_ _07030_ _07031_ _07042_ VDD VSS NOR3_X1
X_24204_ _07040_ _07042_ _07043_ VDD VSS XNOR2_X1
X_24205_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[24\]
+ _07043_ _06880_ _01356_ VDD VSS MUX2_X1
X_24206_ _03844_ _01182_ _06989_ _07044_ VDD VSS NAND3_X1
X_24207_ cs_registers_i.csr_mtvec_o\[25\] _03878_ _03953_
+ _07045_ VDD VSS OR3_X1
X_24208_ _03893_ _07044_ _07045_ _07046_ VDD VSS NAND3_X1
X_24209_ cs_registers_i.csr_mepc_o\[25\] _03923_ _03926_ cs_registers_i.csr_depc_o\[25\]
+ _07047_ VDD VSS AOI22_X1
X_24210_ _07046_ _07047_ _07048_ VDD VSS NAND2_X1
X_24211_ _07048_ alu_adder_result_ex\[25\] _03930_ net18 _06888_
+ _07049_ VDD VSS AOI221_X2
X_24212_ _07049_ _04154_ _07050_ VDD VSS OR2_X4
X_24213_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[25\]
+ _07051_ VDD VSS INV_X1
X_24214_ _07050_ _03938_ _07051_ _07052_ VDD VSS OAI21_X4
X_24215_ _07017_ _07016_ _07053_ VDD VSS OR2_X1
X_24216_ _06964_ _06983_ _07007_ _07009_ _07054_ VDD VSS NAND4_X2
X_24217_ _07053_ _07030_ _07054_ _07040_ _07055_ VDD VSS NOR4_X4
X_24218_ _06969_ _07055_ _07056_ VDD VSS NAND2_X2
X_24219_ _07052_ _07056_ _07057_ VDD VSS XNOR2_X1
X_24220_ _06879_ _07058_ VDD VSS CLKBUF_X3
X_24221_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[25\]
+ _07057_ _07058_ _01357_ VDD VSS MUX2_X1
X_24222_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[26\]
+ _03938_ _07059_ VDD VSS NOR2_X2
X_24223_ cs_registers_i.csr_mepc_o\[26\] _03924_ _07060_ VDD
+ VSS NAND2_X1
X_24224_ _07060_ _06895_ _01183_ _07061_ VDD VSS OAI21_X1
X_24225_ _07061_ _06888_ net19 cs_registers_i.csr_depc_o\[26\]
+ _03927_ _07062_ VDD VSS AOI221_X2
X_24226_ _03937_ _07062_ _07063_ VDD VSS AND2_X1
X_24227_ _03931_ alu_adder_result_ex\[26\] _07064_ VDD VSS
+ NAND2_X1
X_24228_ _07059_ _07063_ _07064_ _07065_ VDD VSS AOI21_X4
X_24229_ _06911_ _06929_ _07055_ _07066_ VDD VSS AND3_X1
X_24230_ _07052_ _07066_ _07067_ VDD VSS NAND2_X1
X_24231_ _07065_ _07067_ _07068_ VDD VSS XNOR2_X1
X_24232_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[26\]
+ _07068_ _07058_ _01358_ VDD VSS MUX2_X1
X_24233_ _03844_ _00007_ _06989_ _07069_ VDD VSS NAND3_X1
X_24234_ cs_registers_i.csr_mtvec_o\[27\] _03878_ _03953_
+ _07070_ VDD VSS OR3_X1
X_24235_ _03893_ _07069_ _07070_ _07071_ VDD VSS NAND3_X1
X_24236_ cs_registers_i.csr_mepc_o\[27\] _03923_ _03926_ cs_registers_i.csr_depc_o\[27\]
+ _07072_ VDD VSS AOI22_X1
X_24237_ _07071_ _07072_ _07073_ VDD VSS NAND2_X1
X_24238_ _07073_ alu_adder_result_ex\[27\] _03930_ net20 _06889_
+ _07074_ VDD VSS AOI221_X2
X_24239_ _07074_ _04154_ _07075_ VDD VSS OR2_X2
X_24240_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[27\]
+ _07076_ VDD VSS INV_X1
X_24241_ _07075_ _03938_ _07076_ _07077_ VDD VSS OAI21_X2
X_24242_ _06969_ _07052_ _07055_ _07065_ _07078_ VDD VSS NAND4_X1
X_24243_ _07077_ _07078_ _07079_ VDD VSS XNOR2_X1
X_24244_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[27\]
+ _07079_ _07058_ _01359_ VDD VSS MUX2_X1
X_24245_ _03844_ _00008_ _06989_ _07080_ VDD VSS NAND3_X1
X_24246_ cs_registers_i.csr_mtvec_o\[28\] _03878_ _06989_
+ _07081_ VDD VSS OR3_X1
X_24247_ _03893_ _07080_ _07081_ _07082_ VDD VSS NAND3_X1
X_24248_ cs_registers_i.csr_mepc_o\[28\] _03924_ _03927_ cs_registers_i.csr_depc_o\[28\]
+ _07083_ VDD VSS AOI22_X1
X_24249_ net21 _06889_ _07084_ VDD VSS NAND2_X1
X_24250_ _03938_ _07082_ _07083_ _07084_ _07085_ VDD VSS NAND4_X1
X_24251_ _07085_ alu_adder_result_ex\[28\] _03931_ _07086_
+ VDD VSS AOI21_X2
X_24252_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[28\]
+ _03938_ _07087_ VDD VSS NOR2_X1
X_24253_ _07086_ _07087_ _07088_ VDD VSS NOR2_X1
X_24254_ _07052_ _07065_ _07077_ _07089_ VDD VSS NAND3_X1
X_24255_ _07089_ _07090_ VDD VSS INV_X1
X_24256_ _07066_ _07090_ _07091_ VDD VSS NAND2_X1
X_24257_ _07088_ _07091_ _07092_ VDD VSS XNOR2_X1
X_24258_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[28\]
+ _07092_ _07058_ _01360_ VDD VSS MUX2_X1
X_24259_ cs_registers_i.csr_mepc_o\[29\] _03924_ _03927_ cs_registers_i.csr_depc_o\[29\]
+ _07093_ VDD VSS AOI22_X2
X_24260_ _07093_ _06895_ _00009_ _07094_ VDD VSS OAI21_X2
X_24261_ _07094_ alu_adder_result_ex\[29\] _03930_ net22 _06889_
+ _07095_ VDD VSS AOI221_X2
X_24262_ _04154_ _07095_ _07096_ VDD VSS NOR2_X4
X_24263_ _07096_ _06852_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[29\]
+ _07097_ VDD VSS AOI21_X4
X_24264_ _07086_ _07087_ _07098_ VDD VSS OR2_X1
X_24265_ _07056_ _07098_ _07089_ _07099_ VDD VSS NOR3_X1
X_24266_ _07097_ _07099_ _07100_ VDD VSS XNOR2_X1
X_24267_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[29\]
+ _07100_ _07058_ _01361_ VDD VSS MUX2_X1
X_24268_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[2\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_d\[2\]
+ _07058_ _01362_ VDD VSS MUX2_X1
X_24269_ cs_registers_i.csr_mepc_o\[30\] _03924_ _03927_ cs_registers_i.csr_depc_o\[30\]
+ _07101_ VDD VSS AOI22_X1
X_24270_ _07101_ _06895_ _00010_ _07102_ VDD VSS OAI21_X1
X_24271_ _07102_ _06889_ net23 _07103_ VDD VSS AOI21_X1
X_24272_ _03938_ _07103_ _07104_ VDD VSS NAND2_X1
X_24273_ _07104_ alu_adder_result_ex\[30\] _03931_ _07105_
+ VDD VSS AOI21_X2
X_24274_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[30\]
+ _07106_ VDD VSS INV_X1
X_24275_ _07105_ _06852_ _07106_ _07107_ VDD VSS AOI21_X2
X_24276_ _07098_ _07089_ _07097_ _07108_ VDD VSS NOR3_X1
X_24277_ _07066_ _07108_ _07109_ VDD VSS NAND2_X1
X_24278_ _07107_ _07109_ _07110_ VDD VSS XNOR2_X1
X_24279_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[30\]
+ _07110_ _07058_ _01363_ VDD VSS MUX2_X1
X_24280_ _07107_ _07108_ _07111_ VDD VSS NAND2_X1
X_24281_ _04164_ _07056_ _07111_ _07112_ VDD VSS NOR3_X1
X_24282_ _04164_ _07112_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[31\]
+ _07113_ VDD VSS MUX2_X1
X_24283_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[31\]
+ _06852_ _07114_ VDD VSS NAND2_X1
X_24284_ _07056_ _07111_ _07115_ VDD VSS NOR2_X1
X_24285_ cs_registers_i.csr_mepc_o\[31\] _03924_ _03927_ cs_registers_i.csr_depc_o\[31\]
+ _07116_ VDD VSS AOI22_X2
X_24286_ _07116_ _06895_ _00011_ _07117_ VDD VSS OAI21_X2
X_24287_ _07117_ _03931_ alu_adder_result_ex\[31\] net24 _06889_
+ _07118_ VDD VSS AOI221_X2
X_24288_ _07118_ _06852_ _07119_ VDD VSS NOR2_X2
X_24289_ _07115_ _07119_ _07120_ VDD VSS XNOR2_X1
X_24290_ _06863_ _07113_ _07114_ _07120_ _01364_ VDD VSS AOI22_X1
X_24291_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[3\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_d\[3\]
+ _07058_ _01365_ VDD VSS MUX2_X1
X_24292_ _16111_ _06808_ _07121_ VDD VSS XOR2_X1
X_24293_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[4\]
+ _07121_ _07058_ _01366_ VDD VSS MUX2_X1
X_24294_ _16109_ _16110_ _06808_ _07122_ VDD VSS NAND3_X1
X_24295_ _06818_ _07122_ _07123_ VDD VSS XNOR2_X1
X_24296_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[5\]
+ _07123_ _07058_ _01367_ VDD VSS MUX2_X1
X_24297_ _06847_ _06848_ _07124_ VDD VSS NOR2_X1
X_24298_ _07124_ _06819_ _07125_ VDD VSS XNOR2_X1
X_24299_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[6\]
+ _07125_ _06879_ _01368_ VDD VSS MUX2_X1
X_24300_ _06840_ _06843_ _07126_ VDD VSS NOR2_X1
X_24301_ _07124_ _06875_ _07127_ VDD VSS NAND2_X1
X_24302_ _07126_ _07127_ _07128_ VDD VSS XNOR2_X1
X_24303_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[7\]
+ _07128_ _06879_ _01369_ VDD VSS MUX2_X1
X_24304_ _16111_ _06808_ _06818_ _06849_ _07129_ VDD VSS NAND4_X1
X_24305_ _06828_ _07129_ _07130_ VDD VSS XNOR2_X1
X_24306_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[8\]
+ _07130_ _06879_ _01370_ VDD VSS MUX2_X1
X_24307_ _06828_ _06849_ _06875_ _07131_ VDD VSS NAND3_X1
X_24308_ _06839_ _07131_ _07132_ VDD VSS XNOR2_X1
X_24309_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[9\]
+ _07132_ _06879_ _01371_ VDD VSS MUX2_X1
X_24310_ _04158_ _07133_ VDD VSS BUF_X4
X_24311_ _07133_ _07134_ VDD VSS BUF_X4
X_24312_ _03966_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ _07134_ _07135_ VDD VSS MUX2_X1
X_24313_ _03979_ _07136_ VDD VSS CLKBUF_X3
X_24314_ _07136_ _07137_ VDD VSS BUF_X4
X_24315_ _04158_ _07138_ VDD VSS INV_X2
X_24316_ _04155_ net125 _07139_ VDD VSS NAND2_X1
X_24317_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[0\]
+ _07139_ _07140_ VDD VSS NOR2_X1
X_24318_ _07137_ _07138_ _07140_ _07141_ VDD VSS NAND3_X2
X_24319_ _00135_ _07141_ _07142_ VDD VSS NAND2_X1
X_24320_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[0\]
+ _07143_ VDD VSS INV_X1
X_24321_ _07139_ _07144_ VDD VSS INV_X1
X_24322_ _07143_ _07144_ _07145_ VDD VSS NAND2_X2
X_24323_ _07137_ _07145_ _07146_ VDD VSS NOR2_X1
X_24324_ _11422_ _06298_ _07147_ VDD VSS NOR2_X1
X_24325_ _11424_ _06303_ _06268_ _07148_ VDD VSS AOI21_X1
X_24326_ _07147_ _07148_ _11421_ _07149_ VDD VSS OAI21_X2
X_24327_ _00136_ _07145_ _07150_ VDD VSS AND2_X1
X_24328_ _03975_ _07150_ _07151_ VDD VSS NAND2_X1
X_24329_ _00135_ _07145_ _00136_ _07152_ VDD VSS OAI21_X2
X_24330_ _07151_ _07152_ _03975_ _07153_ VDD VSS OAI21_X4
X_24331_ _07153_ _03980_ _00137_ _07154_ VDD VSS AOI21_X1
X_24332_ _06306_ _07149_ _07154_ _07155_ VDD VSS NAND3_X2
X_24333_ _06265_ _07155_ _07156_ VDD VSS OR2_X2
X_24334_ _07142_ _07146_ _07156_ _07157_ VDD VSS MUX2_X1
X_24335_ _07157_ _07158_ VDD VSS BUF_X4
X_24336_ _07158_ _07159_ VDD VSS BUF_X8
X_24337_ _03971_ _07135_ _07159_ _01372_ VDD VSS MUX2_X1
X_24338_ _04156_ _07160_ VDD VSS CLKBUF_X3
X_24339_ _03966_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[2\]
+ _07160_ _07161_ VDD VSS MUX2_X1
X_24340_ _04156_ _07140_ _04158_ _07162_ VDD VSS AOI21_X1
X_24341_ _07162_ _07163_ VDD VSS INV_X1
X_24342_ _06265_ _07155_ _07163_ _07164_ VDD VSS NOR3_X2
X_24343_ _07164_ _07141_ _07156_ _07165_ VDD VSS AOI21_X4
X_24344_ _07165_ _07166_ VDD VSS CLKBUF_X3
X_24345_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ _07161_ _07166_ _01373_ VDD VSS MUX2_X1
X_24346_ _07138_ _04156_ _07145_ _07167_ VDD VSS NOR3_X4
X_24347_ _07167_ _07168_ VDD VSS CLKBUF_X3
X_24348_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[2\]
+ _03966_ _07168_ _01374_ VDD VSS MUX2_X1
X_24349_ _03963_ _07169_ VDD VSS INV_X2
X_24350_ _07169_ _07170_ VDD VSS BUF_X4
X_24351_ _07170_ _06852_ _07171_ VDD VSS NAND2_X1
X_24352_ _06253_ _06264_ _06306_ _07149_ _07172_ VDD VSS NAND4_X4
X_24353_ _07150_ _07172_ _07173_ VDD VSS NOR2_X1
X_24354_ _07171_ _07173_ _03980_ _07174_ VDD VSS AOI21_X1
X_24355_ _07170_ _03939_ _03974_ _07175_ VDD VSS NOR3_X1
X_24356_ _16090_ _11426_ _06803_ _00554_ _07176_ VDD VSS OAI22_X2
X_24357_ _07176_ _06797_ cs_registers_i.csr_mepc_o\[1\] _07177_
+ VDD VSS AOI21_X2
X_24358_ _07174_ _07175_ _07173_ _07177_ _06998_ _01375_ VDD
+ VSS AOI221_X1
X_24359_ cs_registers_i.pc_if_i\[11\] _07178_ VDD VSS BUF_X2
X_24360_ _07153_ _07172_ _07179_ VDD VSS NOR2_X2
X_24361_ _07179_ _07180_ VDD VSS BUF_X4
X_24362_ cs_registers_i.pc_if_i\[3\] _07181_ VDD VSS CLKBUF_X2
X_24363_ _15355_ _07182_ VDD VSS INV_X1
X_24364_ _07181_ _07182_ _07183_ VDD VSS NAND2_X2
X_24365_ cs_registers_i.pc_if_i\[9\] _07184_ VDD VSS BUF_X2
X_24366_ cs_registers_i.pc_if_i\[7\] _07185_ VDD VSS CLKBUF_X2
X_24367_ cs_registers_i.pc_if_i\[4\] _07186_ VDD VSS CLKBUF_X2
X_24368_ cs_registers_i.pc_if_i\[5\] _07187_ VDD VSS BUF_X1
X_24369_ _07186_ _07187_ cs_registers_i.pc_if_i\[6\] _07188_
+ VDD VSS AND3_X1
X_24370_ _07185_ cs_registers_i.pc_if_i\[8\] _07188_ _07189_
+ VDD VSS AND3_X1
X_24371_ _07184_ cs_registers_i.pc_if_i\[10\] _07189_ _07190_
+ VDD VSS NAND3_X2
X_24372_ _07183_ _07190_ _07191_ VDD VSS NOR2_X1
X_24373_ _07178_ _06905_ _07180_ _07191_ _07192_ VDD VSS AND4_X1
X_24374_ _07179_ _07193_ VDD VSS CLKBUF_X3
X_24375_ _07178_ _06998_ _07193_ _07194_ VDD VSS NOR3_X1
X_24376_ _07178_ _07195_ VDD VSS INV_X1
X_24377_ _07195_ _07183_ _07190_ _07196_ VDD VSS OAI21_X1
X_24378_ _06870_ _07196_ _06858_ _07197_ VDD VSS AOI21_X1
X_24379_ _07192_ _07194_ _07197_ _01376_ VDD VSS NOR3_X1
X_24380_ _06858_ _06891_ _07198_ VDD VSS NOR2_X1
X_24381_ cs_registers_i.pc_if_i\[12\] _07199_ VDD VSS CLKBUF_X2
X_24382_ _07153_ _07200_ VDD VSS CLKBUF_X3
X_24383_ _07172_ _07201_ VDD VSS BUF_X4
X_24384_ _15833_ _07202_ VDD VSS INV_X1
X_24385_ _07202_ _15354_ _07203_ VDD VSS NOR2_X1
X_24386_ _07181_ _15832_ _07203_ _07204_ VDD VSS OAI21_X2
X_24387_ _07190_ _07204_ _07205_ VDD VSS OR2_X1
X_24388_ _07195_ _07200_ _07201_ _07205_ _07206_ VDD VSS NOR4_X1
X_24389_ _07199_ _07206_ _07207_ VDD VSS XNOR2_X1
X_24390_ _07198_ _07207_ _06863_ _01377_ VDD VSS AOI21_X1
X_24391_ _07153_ _07208_ VDD VSS CLKBUF_X3
X_24392_ _07172_ _07209_ VDD VSS CLKBUF_X3
X_24393_ _07178_ _07199_ _07191_ _07210_ VDD VSS NAND3_X1
X_24394_ _07208_ _07209_ _07210_ _07211_ VDD VSS NOR3_X1
X_24395_ cs_registers_i.pc_if_i\[13\] _07211_ _07212_ VDD
+ VSS XNOR2_X1
X_24396_ _06899_ _07212_ _06863_ _01378_ VDD VSS AOI21_X1
X_24397_ cs_registers_i.pc_if_i\[14\] _07213_ VDD VSS INV_X1
X_24398_ _07178_ _07199_ cs_registers_i.pc_if_i\[13\] _07214_
+ VDD VSS NAND3_X1
X_24399_ _07205_ _07214_ _07215_ VDD VSS OR2_X1
X_24400_ _07215_ _07216_ VDD VSS BUF_X2
X_24401_ _06918_ _07216_ _07217_ VDD VSS NAND2_X1
X_24402_ _07180_ _07218_ VDD VSS BUF_X4
X_24403_ _07217_ _07218_ _06998_ _07219_ VDD VSS OAI21_X1
X_24404_ _07213_ _07200_ _07201_ _07216_ _07220_ VDD VSS NOR4_X1
X_24405_ _06998_ _07220_ _07221_ VDD VSS OR2_X1
X_24406_ _07213_ _07219_ _07221_ _06918_ _01379_ VDD VSS AOI22_X1
X_24407_ cs_registers_i.pc_if_i\[15\] _07222_ VDD VSS BUF_X1
X_24408_ _07183_ _07190_ _07214_ _07223_ VDD VSS OR3_X4
X_24409_ _07213_ _07153_ _07172_ _07223_ _07224_ VDD VSS NOR4_X2
X_24410_ _07222_ _07224_ _07225_ VDD VSS XNOR2_X1
X_24411_ _06924_ _07225_ _06893_ _01380_ VDD VSS OAI21_X1
X_24412_ cs_registers_i.pc_if_i\[14\] _07222_ _07226_ VDD
+ VSS NAND2_X1
X_24413_ _07153_ _07172_ _07216_ _07226_ _07227_ VDD VSS NOR4_X1
X_24414_ cs_registers_i.pc_if_i\[16\] _07227_ _07228_ VDD
+ VSS XNOR2_X1
X_24415_ _06858_ _07229_ VDD VSS BUF_X4
X_24416_ _06939_ _06938_ _07228_ _07229_ _01381_ VDD VSS AOI22_X1
X_24417_ _06951_ _07230_ VDD VSS INV_X1
X_24418_ cs_registers_i.pc_if_i\[17\] _07231_ VDD VSS INV_X1
X_24419_ cs_registers_i.pc_if_i\[14\] _07222_ cs_registers_i.pc_if_i\[16\]
+ _07232_ VDD VSS NAND3_X1
X_24420_ _07153_ _07172_ _07223_ _07232_ _07233_ VDD VSS NOR4_X1
X_24421_ _07231_ _07233_ _07234_ VDD VSS XNOR2_X1
X_24422_ _07230_ _07234_ _06858_ _01382_ VDD VSS MUX2_X1
X_24423_ cs_registers_i.pc_if_i\[18\] _07235_ VDD VSS BUF_X1
X_24424_ _07231_ _07232_ _07236_ VDD VSS NOR2_X1
X_24425_ _07236_ _07237_ VDD VSS INV_X1
X_24426_ _07200_ _07201_ _07216_ _07237_ _07238_ VDD VSS NOR4_X1
X_24427_ _07235_ _07238_ _07239_ VDD VSS XNOR2_X1
X_24428_ _06959_ _07239_ _06893_ _01383_ VDD VSS OAI21_X1
X_24429_ _07153_ _07172_ _07240_ VDD VSS OR2_X2
X_24430_ cs_registers_i.pc_if_i\[19\] _07241_ VDD VSS BUF_X1
X_24431_ _07235_ _07241_ _07236_ _07242_ VDD VSS NAND3_X1
X_24432_ _06975_ _07240_ _07223_ _07242_ _07243_ VDD VSS NOR4_X1
X_24433_ _07241_ _06998_ _07180_ _07244_ VDD VSS NOR3_X1
X_24434_ _07241_ _07245_ VDD VSS INV_X1
X_24435_ _07235_ _07236_ _07246_ VDD VSS NAND2_X1
X_24436_ _07245_ _07223_ _07246_ _07247_ VDD VSS OAI21_X1
X_24437_ _06975_ _07247_ _06858_ _07248_ VDD VSS AOI21_X1
X_24438_ _07243_ _07244_ _07248_ _01384_ VDD VSS NOR3_X1
X_24439_ cs_registers_i.pc_if_i\[20\] _07249_ VDD VSS CLKBUF_X2
X_24440_ _07208_ _07209_ _07216_ _07242_ _07250_ VDD VSS NOR4_X2
X_24441_ _07249_ _07250_ _07251_ VDD VSS XNOR2_X1
X_24442_ _07008_ _07251_ _06863_ _01385_ VDD VSS AOI21_X1
X_24443_ _15356_ _07208_ _07209_ _07252_ VDD VSS NOR3_X1
X_24444_ _07240_ _07253_ VDD VSS BUF_X4
X_24445_ _07252_ _07253_ cs_registers_i.pc_if_i\[2\] _07254_
+ VDD VSS AOI21_X1
X_24446_ _03934_ _07254_ _06893_ _01386_ VDD VSS OAI21_X1
X_24447_ _07245_ _07246_ _07255_ VDD VSS NOR2_X1
X_24448_ _07249_ _07255_ _07256_ VDD VSS NAND2_X1
X_24449_ _07200_ _07201_ _07223_ _07256_ _07257_ VDD VSS NOR4_X1
X_24450_ cs_registers_i.pc_if_i\[21\] _07257_ _07258_ VDD
+ VSS XNOR2_X1
X_24451_ _07005_ _07258_ _06893_ _01387_ VDD VSS OAI21_X1
X_24452_ cs_registers_i.pc_if_i\[22\] _07259_ VDD VSS CLKBUF_X2
X_24453_ _07249_ cs_registers_i.pc_if_i\[21\] _07255_ _07260_
+ VDD VSS NAND3_X2
X_24454_ _07208_ _07209_ _07216_ _07260_ _07261_ VDD VSS NOR4_X1
X_24455_ _07259_ _07261_ _07262_ VDD VSS XNOR2_X1
X_24456_ _07016_ _07262_ _06863_ _01388_ VDD VSS AOI21_X1
X_24457_ cs_registers_i.pc_if_i\[23\] _07263_ VDD VSS BUF_X1
X_24458_ _07259_ _07264_ VDD VSS INV_X1
X_24459_ _07223_ _07260_ _07265_ VDD VSS OR2_X1
X_24460_ _07264_ _07200_ _07201_ _07265_ _07266_ VDD VSS NOR4_X1
X_24461_ _07263_ _07266_ _07267_ VDD VSS XNOR2_X1
X_24462_ _07028_ _07267_ _06863_ _01389_ VDD VSS AOI21_X1
X_24463_ _07260_ _07268_ VDD VSS INV_X1
X_24464_ _07259_ _07263_ _07268_ _07269_ VDD VSS NAND3_X1
X_24465_ _07208_ _07209_ _07216_ _07269_ _07270_ VDD VSS NOR4_X1
X_24466_ cs_registers_i.pc_if_i\[24\] _07270_ _07271_ VDD
+ VSS XNOR2_X1
X_24467_ _07038_ _07271_ _06863_ _01390_ VDD VSS AOI21_X1
X_24468_ _07259_ _07263_ cs_registers_i.pc_if_i\[24\] _07272_
+ VDD VSS AND3_X1
X_24469_ cs_registers_i.pc_if_i\[25\] _07272_ _07273_ VDD
+ VSS NAND2_X1
X_24470_ _07265_ _07273_ _07274_ VDD VSS NOR2_X2
X_24471_ _07050_ _07193_ _07274_ _07275_ VDD VSS NAND3_X1
X_24472_ cs_registers_i.pc_if_i\[25\] _03939_ _07179_ _07276_
+ VDD VSS OR3_X1
X_24473_ _07223_ _07260_ _07277_ VDD VSS NOR2_X1
X_24474_ cs_registers_i.pc_if_i\[25\] _07277_ _07272_ _07278_
+ VDD VSS AOI21_X1
X_24475_ _07050_ _07278_ _06998_ _07279_ VDD VSS OAI21_X1
X_24476_ _07275_ _07276_ _07279_ _01391_ VDD VSS AND3_X1
X_24477_ _07064_ _07063_ _07280_ VDD VSS AND2_X1
X_24478_ cs_registers_i.pc_if_i\[26\] _07281_ VDD VSS CLKBUF_X2
X_24479_ _07216_ _07260_ _07273_ _07282_ VDD VSS OR3_X1
X_24480_ _07208_ _07209_ _07282_ _07283_ VDD VSS NOR3_X1
X_24481_ _07281_ _07283_ _07284_ VDD VSS XNOR2_X1
X_24482_ _07280_ _07284_ _06863_ _01392_ VDD VSS AOI21_X1
X_24483_ cs_registers_i.pc_if_i\[27\] _07285_ VDD VSS BUF_X1
X_24484_ _07281_ _07285_ _07286_ VDD VSS AND2_X1
X_24485_ _07075_ _07193_ _07274_ _07286_ _07287_ VDD VSS NAND4_X1
X_24486_ _07285_ _03939_ _07179_ _07288_ VDD VSS OR3_X1
X_24487_ _07285_ _07274_ _07281_ _07289_ VDD VSS AOI21_X1
X_24488_ _07075_ _07289_ _06998_ _07290_ VDD VSS OAI21_X1
X_24489_ _07287_ _07288_ _07290_ _01393_ VDD VSS AND3_X1
X_24490_ _07281_ _07285_ _07291_ VDD VSS NAND2_X1
X_24491_ _07208_ _07209_ _07282_ _07291_ _07292_ VDD VSS NOR4_X1
X_24492_ cs_registers_i.pc_if_i\[28\] _07292_ _07293_ VDD
+ VSS XNOR2_X1
X_24493_ _07086_ _07293_ _07229_ _01394_ VDD VSS AOI21_X1
X_24494_ _07274_ _07294_ VDD VSS INV_X1
X_24495_ cs_registers_i.pc_if_i\[28\] _07286_ _07295_ VDD
+ VSS AND2_X1
X_24496_ cs_registers_i.pc_if_i\[29\] _07295_ _07296_ VDD
+ VSS NAND2_X1
X_24497_ _07096_ _07253_ _07294_ _07296_ _07297_ VDD VSS NOR4_X1
X_24498_ _07096_ _07298_ VDD VSS INV_X1
X_24499_ cs_registers_i.pc_if_i\[29\] _07274_ _07295_ _07299_
+ VDD VSS AOI21_X1
X_24500_ _07298_ _07299_ _06998_ _07300_ VDD VSS OAI21_X1
X_24501_ cs_registers_i.pc_if_i\[29\] _03939_ _07301_ VDD
+ VSS OR2_X1
X_24502_ _07300_ _07301_ _07218_ _07302_ VDD VSS OAI21_X1
X_24503_ _07297_ _07302_ _01395_ VDD VSS NOR2_X1
X_24504_ _07208_ _07209_ _07282_ _07296_ _07303_ VDD VSS NOR4_X1
X_24505_ cs_registers_i.pc_if_i\[30\] _07303_ _07304_ VDD
+ VSS XNOR2_X1
X_24506_ _07105_ _07304_ _07229_ _01396_ VDD VSS AOI21_X1
X_24507_ _15355_ _07208_ _07209_ _07305_ VDD VSS NOR3_X1
X_24508_ _07181_ _07305_ _07306_ VDD VSS XNOR2_X1
X_24509_ _03956_ _07306_ _07229_ _01397_ VDD VSS AOI21_X1
X_24510_ _07119_ _07307_ VDD VSS INV_X2
X_24511_ cs_registers_i.pc_if_i\[30\] _07308_ VDD VSS INV_X1
X_24512_ _07308_ _07294_ _07296_ _07309_ VDD VSS NOR3_X1
X_24513_ cs_registers_i.pc_if_i\[31\] _07309_ _07310_ VDD
+ VSS NAND2_X1
X_24514_ _06858_ _07253_ _07310_ _07311_ VDD VSS OAI21_X1
X_24515_ _06998_ _07193_ _07309_ _07119_ _07312_ VDD VSS OAI22_X1
X_24516_ cs_registers_i.pc_if_i\[31\] _07313_ VDD VSS INV_X1
X_24517_ _07307_ _07311_ _07312_ _07313_ _01398_ VDD VSS AOI22_X1
X_24518_ _07208_ _07209_ _07204_ _07314_ VDD VSS NOR3_X1
X_24519_ _07186_ _07314_ _07315_ VDD VSS XNOR2_X1
X_24520_ _06806_ _07315_ _07229_ _01399_ VDD VSS AOI21_X1
X_24521_ _07186_ _07316_ VDD VSS INV_X1
X_24522_ _07316_ _07153_ _07172_ _07183_ _07317_ VDD VSS NOR4_X1
X_24523_ _07187_ _07317_ _07318_ VDD VSS XNOR2_X1
X_24524_ _06816_ _07318_ _07229_ _01400_ VDD VSS AOI21_X1
X_24525_ _07186_ _07187_ _07319_ VDD VSS NAND2_X1
X_24526_ _07200_ _07201_ _07319_ _07204_ _07320_ VDD VSS NOR4_X1
X_24527_ cs_registers_i.pc_if_i\[6\] _07320_ _07321_ VDD VSS
+ XNOR2_X1
X_24528_ _06847_ _07321_ _07229_ _01401_ VDD VSS AOI21_X1
X_24529_ _07188_ _07322_ VDD VSS INV_X1
X_24530_ _07200_ _07201_ _07183_ _07322_ _07323_ VDD VSS NOR4_X1
X_24531_ _07185_ _07323_ _07324_ VDD VSS XNOR2_X1
X_24532_ _06843_ _07324_ _07229_ _01402_ VDD VSS AOI21_X1
X_24533_ _07185_ _07188_ _07325_ VDD VSS NAND2_X1
X_24534_ _07200_ _07201_ _07325_ _07204_ _07326_ VDD VSS NOR4_X1
X_24535_ cs_registers_i.pc_if_i\[8\] _07326_ _07327_ VDD VSS
+ XNOR2_X1
X_24536_ _06826_ _07327_ _07229_ _01403_ VDD VSS AOI21_X1
X_24537_ _07189_ _07328_ VDD VSS INV_X1
X_24538_ _07200_ _07201_ _07183_ _07328_ _07329_ VDD VSS NOR4_X1
X_24539_ _07184_ _07329_ _07330_ VDD VSS XNOR2_X1
X_24540_ _06837_ _07330_ _06893_ _01404_ VDD VSS OAI21_X1
X_24541_ _07184_ _07189_ _07331_ VDD VSS NAND2_X1
X_24542_ _07200_ _07201_ _07331_ _07204_ _07332_ VDD VSS NOR4_X1
X_24543_ cs_registers_i.pc_if_i\[10\] _07332_ _07333_ VDD
+ VSS XNOR2_X1
X_24544_ _06856_ _07333_ _06893_ _01405_ VDD VSS OAI21_X1
X_24545_ net95 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[32\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[0\]
+ _07334_ VDD VSS MUX2_X1
X_24546_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[0\]
+ _07334_ _07159_ _01406_ VDD VSS MUX2_X1
X_24547_ net96 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[42\]
+ _04157_ _07335_ VDD VSS MUX2_X1
X_24548_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[10\]
+ _07335_ _07159_ _01407_ VDD VSS MUX2_X1
X_24549_ net97 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[43\]
+ _04157_ _07336_ VDD VSS MUX2_X1
X_24550_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[11\]
+ _07336_ _07159_ _01408_ VDD VSS MUX2_X1
X_24551_ net98 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[44\]
+ _04157_ _07337_ VDD VSS MUX2_X1
X_24552_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[12\]
+ _07337_ _07159_ _01409_ VDD VSS MUX2_X1
X_24553_ net99 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[45\]
+ _04157_ _07338_ VDD VSS MUX2_X1
X_24554_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[13\]
+ _07338_ _07159_ _01410_ VDD VSS MUX2_X1
X_24555_ net100 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[46\]
+ _04157_ _07339_ VDD VSS MUX2_X1
X_24556_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[14\]
+ _07339_ _07159_ _01411_ VDD VSS MUX2_X1
X_24557_ net101 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[47\]
+ _04158_ _07340_ VDD VSS MUX2_X1
X_24558_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[15\]
+ _07340_ _07159_ _01412_ VDD VSS MUX2_X1
X_24559_ _03968_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[48\]
+ _07134_ _07341_ VDD VSS MUX2_X1
X_24560_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[16\]
+ _07341_ _07159_ _01413_ VDD VSS MUX2_X1
X_24561_ _03967_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[49\]
+ _07134_ _07342_ VDD VSS MUX2_X1
X_24562_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]
+ _07342_ _07159_ _01414_ VDD VSS MUX2_X1
X_24563_ net102 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[50\]
+ _07134_ _07343_ VDD VSS MUX2_X1
X_24564_ _07158_ _07344_ VDD VSS BUF_X8
X_24565_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[18\]
+ _07343_ _07344_ _01415_ VDD VSS MUX2_X1
X_24566_ net103 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[51\]
+ _07134_ _07345_ VDD VSS MUX2_X1
X_24567_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[19\]
+ _07345_ _07344_ _01416_ VDD VSS MUX2_X1
X_24568_ net104 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[33\]
+ _04157_ _07346_ VDD VSS MUX2_X1
X_24569_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[1\]
+ _07346_ _07344_ _01417_ VDD VSS MUX2_X1
X_24570_ net105 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[52\]
+ _07134_ _07347_ VDD VSS MUX2_X1
X_24571_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[20\]
+ _07347_ _07344_ _01418_ VDD VSS MUX2_X1
X_24572_ net106 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[53\]
+ _07134_ _07348_ VDD VSS MUX2_X1
X_24573_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[21\]
+ _07348_ _07344_ _01419_ VDD VSS MUX2_X1
X_24574_ net107 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[54\]
+ _07134_ _07349_ VDD VSS MUX2_X1
X_24575_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[22\]
+ _07349_ _07344_ _01420_ VDD VSS MUX2_X1
X_24576_ net108 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[55\]
+ _07134_ _07350_ VDD VSS MUX2_X1
X_24577_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[23\]
+ _07350_ _07344_ _01421_ VDD VSS MUX2_X1
X_24578_ net109 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[56\]
+ _07134_ _07351_ VDD VSS MUX2_X1
X_24579_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[24\]
+ _07351_ _07344_ _01422_ VDD VSS MUX2_X1
X_24580_ net110 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[57\]
+ _07133_ _07352_ VDD VSS MUX2_X1
X_24581_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[25\]
+ _07352_ _07344_ _01423_ VDD VSS MUX2_X1
X_24582_ net111 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[58\]
+ _07133_ _07353_ VDD VSS MUX2_X1
X_24583_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[26\]
+ _07353_ _07344_ _01424_ VDD VSS MUX2_X1
X_24584_ net112 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[59\]
+ _07133_ _07354_ VDD VSS MUX2_X1
X_24585_ _07158_ _07355_ VDD VSS BUF_X8
X_24586_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[27\]
+ _07354_ _07355_ _01425_ VDD VSS MUX2_X1
X_24587_ net113 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[60\]
+ _07133_ _07356_ VDD VSS MUX2_X1
X_24588_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[28\]
+ _07356_ _07355_ _01426_ VDD VSS MUX2_X1
X_24589_ net114 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[61\]
+ _07133_ _07357_ VDD VSS MUX2_X1
X_24590_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[29\]
+ _07357_ _07355_ _01427_ VDD VSS MUX2_X1
X_24591_ net115 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[34\]
+ _04157_ _07358_ VDD VSS MUX2_X1
X_24592_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[2\]
+ _07358_ _07355_ _01428_ VDD VSS MUX2_X1
X_24593_ net116 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[62\]
+ _07133_ _07359_ VDD VSS MUX2_X1
X_24594_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[30\]
+ _07359_ _07355_ _01429_ VDD VSS MUX2_X1
X_24595_ net117 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[63\]
+ _07133_ _07360_ VDD VSS MUX2_X1
X_24596_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[31\]
+ _07360_ _07355_ _01430_ VDD VSS MUX2_X1
X_24597_ net95 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[64\]
+ _07160_ _07361_ VDD VSS MUX2_X1
X_24598_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[32\]
+ _07361_ _07166_ _01431_ VDD VSS MUX2_X1
X_24599_ net104 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[65\]
+ _07160_ _07362_ VDD VSS MUX2_X1
X_24600_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[33\]
+ _07362_ _07166_ _01432_ VDD VSS MUX2_X1
X_24601_ net115 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[66\]
+ _07160_ _07363_ VDD VSS MUX2_X1
X_24602_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[34\]
+ _07363_ _07166_ _01433_ VDD VSS MUX2_X1
X_24603_ net118 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[67\]
+ _07160_ _07364_ VDD VSS MUX2_X1
X_24604_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[35\]
+ _07364_ _07166_ _01434_ VDD VSS MUX2_X1
X_24605_ net119 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[68\]
+ _07160_ _07365_ VDD VSS MUX2_X1
X_24606_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[36\]
+ _07365_ _07166_ _01435_ VDD VSS MUX2_X1
X_24607_ net120 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[69\]
+ _07160_ _07366_ VDD VSS MUX2_X1
X_24608_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[37\]
+ _07366_ _07166_ _01436_ VDD VSS MUX2_X1
X_24609_ net121 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[70\]
+ _07160_ _07367_ VDD VSS MUX2_X1
X_24610_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[38\]
+ _07367_ _07166_ _01437_ VDD VSS MUX2_X1
X_24611_ net122 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[71\]
+ _07160_ _07368_ VDD VSS MUX2_X1
X_24612_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[39\]
+ _07368_ _07166_ _01438_ VDD VSS MUX2_X1
X_24613_ net118 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[35\]
+ _04158_ _07369_ VDD VSS MUX2_X1
X_24614_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[3\]
+ _07369_ _07355_ _01439_ VDD VSS MUX2_X1
X_24615_ net123 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[72\]
+ _07160_ _07370_ VDD VSS MUX2_X1
X_24616_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[40\]
+ _07370_ _07166_ _01440_ VDD VSS MUX2_X1
X_24617_ _04156_ _07371_ VDD VSS CLKBUF_X3
X_24618_ net124 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[73\]
+ _07371_ _07372_ VDD VSS MUX2_X1
X_24619_ _07165_ _07373_ VDD VSS CLKBUF_X3
X_24620_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[41\]
+ _07372_ _07373_ _01441_ VDD VSS MUX2_X1
X_24621_ net96 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[74\]
+ _07371_ _07374_ VDD VSS MUX2_X1
X_24622_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[42\]
+ _07374_ _07373_ _01442_ VDD VSS MUX2_X1
X_24623_ net97 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[75\]
+ _07371_ _07375_ VDD VSS MUX2_X1
X_24624_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[43\]
+ _07375_ _07373_ _01443_ VDD VSS MUX2_X1
X_24625_ net98 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[76\]
+ _07371_ _07376_ VDD VSS MUX2_X1
X_24626_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[44\]
+ _07376_ _07373_ _01444_ VDD VSS MUX2_X1
X_24627_ net99 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[77\]
+ _07371_ _07377_ VDD VSS MUX2_X1
X_24628_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[45\]
+ _07377_ _07373_ _01445_ VDD VSS MUX2_X1
X_24629_ net100 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[78\]
+ _07371_ _07378_ VDD VSS MUX2_X1
X_24630_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[46\]
+ _07378_ _07373_ _01446_ VDD VSS MUX2_X1
X_24631_ net101 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[79\]
+ _07371_ _07379_ VDD VSS MUX2_X1
X_24632_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[47\]
+ _07379_ _07373_ _01447_ VDD VSS MUX2_X1
X_24633_ _03968_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[80\]
+ _07371_ _07380_ VDD VSS MUX2_X1
X_24634_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[48\]
+ _07380_ _07373_ _01448_ VDD VSS MUX2_X1
X_24635_ _03967_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[81\]
+ _07371_ _07381_ VDD VSS MUX2_X1
X_24636_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[49\]
+ _07381_ _07373_ _01449_ VDD VSS MUX2_X1
X_24637_ net119 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[36\]
+ _04157_ _07382_ VDD VSS MUX2_X1
X_24638_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[4\]
+ _07382_ _07355_ _01450_ VDD VSS MUX2_X1
X_24639_ net102 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[82\]
+ _07371_ _07383_ VDD VSS MUX2_X1
X_24640_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[50\]
+ _07383_ _07373_ _01451_ VDD VSS MUX2_X1
X_24641_ _04156_ _07384_ VDD VSS CLKBUF_X3
X_24642_ net103 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[83\]
+ _07384_ _07385_ VDD VSS MUX2_X1
X_24643_ _07165_ _07386_ VDD VSS CLKBUF_X3
X_24644_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[51\]
+ _07385_ _07386_ _01452_ VDD VSS MUX2_X1
X_24645_ net105 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[84\]
+ _07384_ _07387_ VDD VSS MUX2_X1
X_24646_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[52\]
+ _07387_ _07386_ _01453_ VDD VSS MUX2_X1
X_24647_ net106 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[85\]
+ _07384_ _07388_ VDD VSS MUX2_X1
X_24648_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[53\]
+ _07388_ _07386_ _01454_ VDD VSS MUX2_X1
X_24649_ net107 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[86\]
+ _07384_ _07389_ VDD VSS MUX2_X1
X_24650_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[54\]
+ _07389_ _07386_ _01455_ VDD VSS MUX2_X1
X_24651_ net108 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[87\]
+ _07384_ _07390_ VDD VSS MUX2_X1
X_24652_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[55\]
+ _07390_ _07386_ _01456_ VDD VSS MUX2_X1
X_24653_ net109 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[88\]
+ _07384_ _07391_ VDD VSS MUX2_X1
X_24654_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[56\]
+ _07391_ _07386_ _01457_ VDD VSS MUX2_X1
X_24655_ net110 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[89\]
+ _07384_ _07392_ VDD VSS MUX2_X1
X_24656_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[57\]
+ _07392_ _07386_ _01458_ VDD VSS MUX2_X1
X_24657_ net111 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[90\]
+ _07384_ _07393_ VDD VSS MUX2_X1
X_24658_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[58\]
+ _07393_ _07386_ _01459_ VDD VSS MUX2_X1
X_24659_ net112 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[91\]
+ _07384_ _07394_ VDD VSS MUX2_X1
X_24660_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[59\]
+ _07394_ _07386_ _01460_ VDD VSS MUX2_X1
X_24661_ net120 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[37\]
+ _04158_ _07395_ VDD VSS MUX2_X1
X_24662_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[5\]
+ _07395_ _07355_ _01461_ VDD VSS MUX2_X1
X_24663_ net113 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[92\]
+ _07384_ _07396_ VDD VSS MUX2_X1
X_24664_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[60\]
+ _07396_ _07386_ _01462_ VDD VSS MUX2_X1
X_24665_ net114 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[93\]
+ _04156_ _07397_ VDD VSS MUX2_X1
X_24666_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[61\]
+ _07397_ _07165_ _01463_ VDD VSS MUX2_X1
X_24667_ net116 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[94\]
+ _04156_ _07398_ VDD VSS MUX2_X1
X_24668_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[62\]
+ _07398_ _07165_ _01464_ VDD VSS MUX2_X1
X_24669_ net117 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[95\]
+ _04156_ _07399_ VDD VSS MUX2_X1
X_24670_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[63\]
+ _07399_ _07165_ _01465_ VDD VSS MUX2_X1
X_24671_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[64\]
+ net95 _07168_ _01466_ VDD VSS MUX2_X1
X_24672_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[65\]
+ net104 _07168_ _01467_ VDD VSS MUX2_X1
X_24673_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[66\]
+ net115 _07168_ _01468_ VDD VSS MUX2_X1
X_24674_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[67\]
+ net118 _07168_ _01469_ VDD VSS MUX2_X1
X_24675_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[68\]
+ net119 _07168_ _01470_ VDD VSS MUX2_X1
X_24676_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[69\]
+ net120 _07168_ _01471_ VDD VSS MUX2_X1
X_24677_ net121 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[38\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[0\]
+ _07400_ VDD VSS MUX2_X1
X_24678_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[6\]
+ _07400_ _07355_ _01472_ VDD VSS MUX2_X1
X_24679_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[70\]
+ net121 _07168_ _01473_ VDD VSS MUX2_X1
X_24680_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[71\]
+ net122 _07168_ _01474_ VDD VSS MUX2_X1
X_24681_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[72\]
+ net123 _07168_ _01475_ VDD VSS MUX2_X1
X_24682_ _07167_ _07401_ VDD VSS CLKBUF_X3
X_24683_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[73\]
+ net124 _07401_ _01476_ VDD VSS MUX2_X1
X_24684_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[74\]
+ net96 _07401_ _01477_ VDD VSS MUX2_X1
X_24685_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[75\]
+ net97 _07401_ _01478_ VDD VSS MUX2_X1
X_24686_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[76\]
+ net98 _07401_ _01479_ VDD VSS MUX2_X1
X_24687_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[77\]
+ net99 _07401_ _01480_ VDD VSS MUX2_X1
X_24688_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[78\]
+ net100 _07401_ _01481_ VDD VSS MUX2_X1
X_24689_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[79\]
+ net101 _07401_ _01482_ VDD VSS MUX2_X1
X_24690_ net122 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[39\]
+ _04158_ _07402_ VDD VSS MUX2_X1
X_24691_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[7\]
+ _07402_ _07158_ _01483_ VDD VSS MUX2_X1
X_24692_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[80\]
+ _03968_ _07401_ _01484_ VDD VSS MUX2_X1
X_24693_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[81\]
+ _03967_ _07401_ _01485_ VDD VSS MUX2_X1
X_24694_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[82\]
+ net102 _07401_ _01486_ VDD VSS MUX2_X1
X_24695_ _07167_ _07403_ VDD VSS CLKBUF_X3
X_24696_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[83\]
+ net103 _07403_ _01487_ VDD VSS MUX2_X1
X_24697_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[84\]
+ net105 _07403_ _01488_ VDD VSS MUX2_X1
X_24698_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[85\]
+ net106 _07403_ _01489_ VDD VSS MUX2_X1
X_24699_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[86\]
+ net107 _07403_ _01490_ VDD VSS MUX2_X1
X_24700_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[87\]
+ net108 _07403_ _01491_ VDD VSS MUX2_X1
X_24701_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[88\]
+ net109 _07403_ _01492_ VDD VSS MUX2_X1
X_24702_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[89\]
+ net110 _07403_ _01493_ VDD VSS MUX2_X1
X_24703_ net123 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[40\]
+ _04157_ _07404_ VDD VSS MUX2_X1
X_24704_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[8\]
+ _07404_ _07158_ _01494_ VDD VSS MUX2_X1
X_24705_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[90\]
+ net111 _07403_ _01495_ VDD VSS MUX2_X1
X_24706_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[91\]
+ net112 _07403_ _01496_ VDD VSS MUX2_X1
X_24707_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[92\]
+ net113 _07403_ _01497_ VDD VSS MUX2_X1
X_24708_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[93\]
+ net114 _07167_ _01498_ VDD VSS MUX2_X1
X_24709_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[94\]
+ net116 _07167_ _01499_ VDD VSS MUX2_X1
X_24710_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[95\]
+ net117 _07167_ _01500_ VDD VSS MUX2_X1
X_24711_ net124 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[41\]
+ _04158_ _07405_ VDD VSS MUX2_X1
X_24712_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[9\]
+ _07405_ _07158_ _01501_ VDD VSS MUX2_X1
X_24713_ _03959_ _07406_ VDD VSS INV_X1
X_24714_ _07406_ _07407_ VDD VSS CLKBUF_X3
X_24715_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[10\]
+ _07407_ _07408_ VDD VSS NOR2_X1
X_24716_ _07408_ _06872_ _07407_ net215 VDD VSS AOI21_X1
X_24717_ net94 _04164_ _07409_ VDD VSS NOR2_X1
X_24718_ _07409_ _07410_ VDD VSS CLKBUF_X3
X_24719_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[10\]
+ net215 _07410_ _01502_ VDD VSS MUX2_X1
X_24720_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[11\]
+ _06907_ _07407_ net216 VDD VSS MUX2_X1
X_24721_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[11\]
+ net216 _07410_ _01503_ VDD VSS MUX2_X1
X_24722_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[12\]
+ _03959_ _07411_ VDD VSS NAND2_X1
X_24723_ _07411_ _06904_ _03959_ net217 VDD VSS OAI21_X1
X_24724_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[12\]
+ net217 _07410_ _01504_ VDD VSS MUX2_X1
X_24725_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[13\]
+ _06928_ _07407_ net218 VDD VSS MUX2_X1
X_24726_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[13\]
+ net218 _07410_ _01505_ VDD VSS MUX2_X1
X_24727_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[14\]
+ _06929_ _07407_ net219 VDD VSS MUX2_X1
X_24728_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[14\]
+ net219 _07410_ _01506_ VDD VSS MUX2_X1
X_24729_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[15\]
+ _06926_ _07407_ net220 VDD VSS MUX2_X1
X_24730_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[15\]
+ net220 _07410_ _01507_ VDD VSS MUX2_X1
X_24731_ _07406_ _07412_ VDD VSS CLKBUF_X3
X_24732_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[16\]
+ _06940_ _07412_ net221 VDD VSS MUX2_X1
X_24733_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[16\]
+ net221 _07410_ _01508_ VDD VSS MUX2_X1
X_24734_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[17\]
+ _06963_ _07412_ net222 VDD VSS MUX2_X1
X_24735_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[17\]
+ net222 _07410_ _01509_ VDD VSS MUX2_X1
X_24736_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[18\]
+ _06961_ _07412_ net223 VDD VSS MUX2_X1
X_24737_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[18\]
+ net223 _07410_ _01510_ VDD VSS MUX2_X1
X_24738_ _07407_ _06967_ _06975_ _07413_ VDD VSS OAI21_X1
X_24739_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[19\]
+ _07414_ VDD VSS INV_X1
X_24740_ _07413_ _07407_ _07414_ net224 VDD VSS OAI21_X1
X_24741_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[19\]
+ net224 _07410_ _01511_ VDD VSS MUX2_X1
X_24742_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[20\]
+ _07009_ _07412_ net225 VDD VSS MUX2_X1
X_24743_ _07409_ _07415_ VDD VSS CLKBUF_X3
X_24744_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[20\]
+ net225 _07415_ _01512_ VDD VSS MUX2_X1
X_24745_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[21\]
+ _07007_ _07412_ net226 VDD VSS MUX2_X1
X_24746_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[21\]
+ net226 _07415_ _01513_ VDD VSS MUX2_X1
X_24747_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[22\]
+ _07018_ _07412_ net227 VDD VSS MUX2_X1
X_24748_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[22\]
+ net227 _07415_ _01514_ VDD VSS MUX2_X1
X_24749_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[23\]
+ _03959_ _07416_ VDD VSS NAND2_X1
X_24750_ _07416_ _07030_ _03959_ net228 VDD VSS OAI21_X1
X_24751_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[23\]
+ net228 _07415_ _01515_ VDD VSS MUX2_X1
X_24752_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[24\]
+ _03959_ _07417_ VDD VSS NAND2_X1
X_24753_ _07417_ _07040_ _03959_ net229 VDD VSS OAI21_X1
X_24754_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[24\]
+ net229 _07415_ _01516_ VDD VSS MUX2_X1
X_24755_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[25\]
+ _07052_ _07412_ net230 VDD VSS MUX2_X1
X_24756_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[25\]
+ net230 _07415_ _01517_ VDD VSS MUX2_X1
X_24757_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[26\]
+ _07065_ _07412_ net231 VDD VSS MUX2_X1
X_24758_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[26\]
+ net231 _07415_ _01518_ VDD VSS MUX2_X1
X_24759_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[27\]
+ _07077_ _07412_ net232 VDD VSS MUX2_X1
X_24760_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[27\]
+ net232 _07415_ _01519_ VDD VSS MUX2_X1
X_24761_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[28\]
+ _07088_ _07412_ net233 VDD VSS MUX2_X1
X_24762_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[28\]
+ net233 _07415_ _01520_ VDD VSS MUX2_X1
X_24763_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[29\]
+ _07407_ _07418_ VDD VSS NOR2_X1
X_24764_ _07418_ _07407_ _07097_ net234 VDD VSS AOI21_X2
X_24765_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[29\]
+ net234 _07415_ _01521_ VDD VSS MUX2_X1
X_24766_ _07406_ _07419_ VDD VSS CLKBUF_X3
X_24767_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[2\]
+ _16108_ _07419_ net235 VDD VSS MUX2_X1
X_24768_ _07409_ _07420_ VDD VSS CLKBUF_X3
X_24769_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[2\]
+ net235 _07420_ _01522_ VDD VSS MUX2_X1
X_24770_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[30\]
+ _07107_ _07419_ net236 VDD VSS MUX2_X1
X_24771_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[30\]
+ net236 _07420_ _01523_ VDD VSS MUX2_X1
X_24772_ _07307_ _07114_ _07421_ VDD VSS NAND2_X2
X_24773_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[31\]
+ _07421_ _07419_ net237 VDD VSS MUX2_X1
X_24774_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[31\]
+ net237 _07420_ _01524_ VDD VSS MUX2_X1
X_24775_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[3\]
+ _16110_ _07419_ net238 VDD VSS MUX2_X1
X_24776_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[3\]
+ net238 _07420_ _01525_ VDD VSS MUX2_X1
X_24777_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[4\]
+ _06808_ _07419_ net239 VDD VSS MUX2_X1
X_24778_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[4\]
+ net239 _07420_ _01526_ VDD VSS MUX2_X1
X_24779_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[5\]
+ _06818_ _07419_ net240 VDD VSS MUX2_X1
X_24780_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[5\]
+ net240 _07420_ _01527_ VDD VSS MUX2_X1
X_24781_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[6\]
+ _07124_ _07419_ net241 VDD VSS MUX2_X1
X_24782_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[6\]
+ net241 _07420_ _01528_ VDD VSS MUX2_X1
X_24783_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[7\]
+ _07126_ _07419_ net242 VDD VSS MUX2_X1
X_24784_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[7\]
+ net242 _07420_ _01529_ VDD VSS MUX2_X1
X_24785_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[8\]
+ _06828_ _07419_ net243 VDD VSS MUX2_X1
X_24786_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[8\]
+ net243 _07420_ _01530_ VDD VSS MUX2_X1
X_24787_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[9\]
+ _06839_ _07419_ net244 VDD VSS MUX2_X1
X_24788_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[9\]
+ net244 _07420_ _01531_ VDD VSS MUX2_X1
X_24789_ _10319_ load_store_unit_i.lsu_err_q _07422_ VDD VSS
+ NAND2_X1
X_24790_ _10324_ _10320_ _07422_ _07423_ VDD VSS NAND3_X1
X_24791_ _10350_ _11427_ _06256_ _07424_ VDD VSS NAND3_X4
X_24792_ _10320_ _03454_ _07425_ VDD VSS NAND2_X2
X_24793_ _03453_ _10356_ _07426_ VDD VSS NAND2_X1
X_24794_ _07423_ _07424_ _07425_ net27 _07426_ _07427_ VDD
+ VSS OAI221_X1
X_24795_ net28 _07428_ VDD VSS INV_X1
X_24796_ _10322_ _03453_ _03454_ _07429_ VDD VSS NAND3_X1
X_24797_ _07428_ net27 _07429_ _07430_ VDD VSS OAI21_X1
X_24798_ _07427_ _07430_ _07431_ VDD VSS AND2_X1
X_24799_ _07431_ _07432_ VDD VSS BUF_X2
X_24800_ _07432_ _07433_ VDD VSS CLKBUF_X3
X_24801_ id_stage_i.controller_i.lsu_addr_last_i\[0\] alu_adder_result_ex\[0\]
+ _07433_ _01615_ VDD VSS MUX2_X1
X_24802_ id_stage_i.controller_i.lsu_addr_last_i\[10\] alu_adder_result_ex\[10\]
+ _07433_ _01616_ VDD VSS MUX2_X1
X_24803_ id_stage_i.controller_i.lsu_addr_last_i\[11\] alu_adder_result_ex\[11\]
+ _07433_ _01617_ VDD VSS MUX2_X1
X_24804_ id_stage_i.controller_i.lsu_addr_last_i\[12\] alu_adder_result_ex\[12\]
+ _07433_ _01618_ VDD VSS MUX2_X1
X_24805_ id_stage_i.controller_i.lsu_addr_last_i\[13\] alu_adder_result_ex\[13\]
+ _07433_ _01619_ VDD VSS MUX2_X1
X_24806_ id_stage_i.controller_i.lsu_addr_last_i\[14\] alu_adder_result_ex\[14\]
+ _07433_ _01620_ VDD VSS MUX2_X1
X_24807_ id_stage_i.controller_i.lsu_addr_last_i\[15\] alu_adder_result_ex\[15\]
+ _07433_ _01621_ VDD VSS MUX2_X1
X_24808_ id_stage_i.controller_i.lsu_addr_last_i\[16\] alu_adder_result_ex\[16\]
+ _07433_ _01622_ VDD VSS MUX2_X1
X_24809_ id_stage_i.controller_i.lsu_addr_last_i\[17\] alu_adder_result_ex\[17\]
+ _07433_ _01623_ VDD VSS MUX2_X1
X_24810_ id_stage_i.controller_i.lsu_addr_last_i\[18\] net378
+ _07433_ _01624_ VDD VSS MUX2_X1
X_24811_ _07432_ _07434_ VDD VSS CLKBUF_X3
X_24812_ id_stage_i.controller_i.lsu_addr_last_i\[19\] alu_adder_result_ex\[19\]
+ _07434_ _01625_ VDD VSS MUX2_X1
X_24813_ id_stage_i.controller_i.lsu_addr_last_i\[1\] net247
+ _07434_ _01626_ VDD VSS MUX2_X1
X_24814_ id_stage_i.controller_i.lsu_addr_last_i\[20\] alu_adder_result_ex\[20\]
+ _07434_ _01627_ VDD VSS MUX2_X1
X_24815_ id_stage_i.controller_i.lsu_addr_last_i\[21\] net386
+ _07434_ _01628_ VDD VSS MUX2_X1
X_24816_ id_stage_i.controller_i.lsu_addr_last_i\[22\] net396
+ _07434_ _01629_ VDD VSS MUX2_X1
X_24817_ id_stage_i.controller_i.lsu_addr_last_i\[23\] alu_adder_result_ex\[23\]
+ _07434_ _01630_ VDD VSS MUX2_X1
X_24818_ id_stage_i.controller_i.lsu_addr_last_i\[24\] alu_adder_result_ex\[24\]
+ _07434_ _01631_ VDD VSS MUX2_X1
X_24819_ id_stage_i.controller_i.lsu_addr_last_i\[25\] net387
+ _07434_ _01632_ VDD VSS MUX2_X1
X_24820_ id_stage_i.controller_i.lsu_addr_last_i\[26\] net398
+ _07434_ _01633_ VDD VSS MUX2_X1
X_24821_ id_stage_i.controller_i.lsu_addr_last_i\[27\] alu_adder_result_ex\[27\]
+ _07434_ _01634_ VDD VSS MUX2_X1
X_24822_ _07432_ _07435_ VDD VSS CLKBUF_X3
X_24823_ id_stage_i.controller_i.lsu_addr_last_i\[28\] alu_adder_result_ex\[28\]
+ _07435_ _01635_ VDD VSS MUX2_X1
X_24824_ id_stage_i.controller_i.lsu_addr_last_i\[29\] alu_adder_result_ex\[29\]
+ _07435_ _01636_ VDD VSS MUX2_X1
X_24825_ id_stage_i.controller_i.lsu_addr_last_i\[2\] alu_adder_result_ex\[2\]
+ _07435_ _01637_ VDD VSS MUX2_X1
X_24826_ id_stage_i.controller_i.lsu_addr_last_i\[30\] alu_adder_result_ex\[30\]
+ _07435_ _01638_ VDD VSS MUX2_X1
X_24827_ id_stage_i.controller_i.lsu_addr_last_i\[31\] net323
+ _07435_ _01639_ VDD VSS MUX2_X1
X_24828_ id_stage_i.controller_i.lsu_addr_last_i\[3\] alu_adder_result_ex\[3\]
+ _07435_ _01640_ VDD VSS MUX2_X1
X_24829_ id_stage_i.controller_i.lsu_addr_last_i\[4\] alu_adder_result_ex\[4\]
+ _07435_ _01641_ VDD VSS MUX2_X1
X_24830_ id_stage_i.controller_i.lsu_addr_last_i\[5\] alu_adder_result_ex\[5\]
+ _07435_ _01642_ VDD VSS MUX2_X1
X_24831_ id_stage_i.controller_i.lsu_addr_last_i\[6\] alu_adder_result_ex\[6\]
+ _07435_ _01643_ VDD VSS MUX2_X1
X_24832_ id_stage_i.controller_i.lsu_addr_last_i\[7\] alu_adder_result_ex\[7\]
+ _07435_ _01644_ VDD VSS MUX2_X1
X_24833_ id_stage_i.controller_i.lsu_addr_last_i\[8\] alu_adder_result_ex\[8\]
+ _07432_ _01645_ VDD VSS MUX2_X1
X_24834_ id_stage_i.controller_i.lsu_addr_last_i\[9\] alu_adder_result_ex\[9\]
+ _07432_ _01646_ VDD VSS MUX2_X1
X_24835_ _10287_ _10495_ _10909_ _07436_ VDD VSS NOR3_X1
X_24836_ _10320_ _07437_ VDD VSS INV_X1
X_24837_ _07437_ _07428_ _07438_ VDD VSS NOR2_X1
X_24838_ _10325_ _10319_ _07424_ _07439_ VDD VSS OAI21_X1
X_24839_ _07438_ _07439_ _07440_ VDD VSS NAND2_X2
X_24840_ _07436_ load_store_unit_i.data_sign_ext_q _07440_
+ _01647_ VDD VSS MUX2_X1
X_24841_ _10289_ _10909_ _03434_ net214 VDD VSS NOR3_X4
X_24842_ net214 load_store_unit_i.data_we_q _07440_ _01648_
+ VDD VSS MUX2_X1
X_24843_ _07437_ _03454_ _07424_ net181 VDD VSS AOI21_X4
X_24844_ _10319_ _07441_ VDD VSS INV_X1
X_24845_ _10324_ _07441_ _07442_ VDD VSS NOR2_X1
X_24846_ net28 _03453_ _07442_ _07443_ VDD VSS AOI21_X1
X_24847_ _07443_ _07444_ VDD VSS INV_X1
X_24848_ load_store_unit_i.handle_misaligned_q net181 _07444_
+ _07445_ VDD VSS AOI21_X1
X_24849_ _16095_ _07446_ VDD VSS CLKBUF_X2
X_24850_ _10488_ _10909_ _07447_ VDD VSS NOR2_X4
X_24851_ _10477_ _07446_ _07447_ _07448_ VDD VSS NAND3_X1
X_24852_ _07448_ _07447_ _03619_ _07449_ VDD VSS OAI21_X2
X_24853_ _10324_ _07449_ _07450_ VDD VSS OR2_X1
X_24854_ _07441_ _07424_ _07450_ _07451_ VDD VSS OAI21_X1
X_24855_ _07445_ _07451_ _07438_ _01649_ VDD VSS AOI21_X1
X_24856_ _10320_ _07428_ _07452_ VDD VSS NAND2_X1
X_24857_ _03453_ _07453_ VDD VSS INV_X1
X_24858_ _10322_ _07453_ _03454_ _07454_ VDD VSS NAND3_X1
X_24859_ _10324_ _10319_ _07453_ _07455_ VDD VSS AOI21_X1
X_24860_ _07454_ _07455_ _07452_ _07456_ VDD VSS OAI21_X1
X_24861_ _07456_ _07424_ _03455_ _07457_ VDD VSS AOI21_X2
X_24862_ _07457_ _03453_ _07441_ _07458_ VDD VSS OAI21_X1
X_24863_ _07452_ _07458_ _10325_ _01650_ VDD VSS AOI21_X1
X_24864_ _10324_ net28 _07449_ _07459_ VDD VSS AOI21_X1
X_24865_ _10319_ _07449_ _07460_ VDD VSS NOR2_X1
X_24866_ _07460_ _07442_ _03453_ _07461_ VDD VSS AOI21_X1
X_24867_ _10319_ _07459_ _07461_ net28 _07462_ VDD VSS OAI22_X1
X_24868_ _10320_ _07457_ _07462_ _07463_ VDD VSS NAND3_X1
X_24869_ _07463_ _07457_ _07441_ _01651_ VDD VSS OAI21_X1
X_24870_ _10324_ _03453_ _10357_ _07464_ VDD VSS NOR3_X1
X_24871_ _10322_ _07464_ _07457_ _01652_ VDD VSS MUX2_X1
X_24872_ _07426_ _07424_ _03455_ _07465_ VDD VSS AOI21_X1
X_24873_ _03455_ _07424_ _07466_ VDD VSS NAND2_X1
X_24874_ _07426_ _07425_ _10322_ _07467_ VDD VSS OAI21_X1
X_24875_ _07466_ _07467_ _07468_ VDD VSS NAND2_X1
X_24876_ net27 _07465_ _07468_ load_store_unit_i.lsu_err_q
+ _07469_ VDD VSS AOI22_X1
X_24877_ _07469_ _01653_ VDD VSS INV_X1
X_24878_ alu_adder_result_ex\[0\] _04594_ _07440_ _01654_
+ VDD VSS MUX2_X1
X_24879_ net247 _04597_ _07440_ _01655_ VDD VSS MUX2_X1
X_24880_ load_store_unit_i.data_we_q _07426_ _07470_ VDD VSS
+ OR2_X1
X_24881_ _07470_ _07471_ VDD VSS BUF_X2
X_24882_ _07471_ _07472_ VDD VSS BUF_X4
X_24883_ net58 load_store_unit_i.rdata_q\[8\] _07472_ _01656_
+ VDD VSS MUX2_X1
X_24884_ net38 load_store_unit_i.rdata_q\[18\] _07472_ _01657_
+ VDD VSS MUX2_X1
X_24885_ net39 load_store_unit_i.rdata_q\[19\] _07472_ _01658_
+ VDD VSS MUX2_X1
X_24886_ net41 load_store_unit_i.rdata_q\[20\] _07472_ _01659_
+ VDD VSS MUX2_X1
X_24887_ net42 load_store_unit_i.rdata_q\[21\] _07472_ _01660_
+ VDD VSS MUX2_X1
X_24888_ net43 load_store_unit_i.rdata_q\[22\] _07472_ _01661_
+ VDD VSS MUX2_X1
X_24889_ _04568_ load_store_unit_i.rdata_q\[23\] _07472_ _01662_
+ VDD VSS MUX2_X1
X_24890_ net44 load_store_unit_i.rdata_q\[24\] _07472_ _01663_
+ VDD VSS MUX2_X1
X_24891_ net45 load_store_unit_i.rdata_q\[25\] _07472_ _01664_
+ VDD VSS MUX2_X1
X_24892_ net46 load_store_unit_i.rdata_q\[26\] _07472_ _01665_
+ VDD VSS MUX2_X1
X_24893_ _07471_ _07473_ VDD VSS CLKBUF_X3
X_24894_ net47 load_store_unit_i.rdata_q\[27\] _07473_ _01666_
+ VDD VSS MUX2_X1
X_24895_ net59 load_store_unit_i.rdata_q\[9\] _07473_ _01667_
+ VDD VSS MUX2_X1
X_24896_ net48 load_store_unit_i.rdata_q\[28\] _07473_ _01668_
+ VDD VSS MUX2_X1
X_24897_ net49 load_store_unit_i.rdata_q\[29\] _07473_ _01669_
+ VDD VSS MUX2_X1
X_24898_ net51 load_store_unit_i.rdata_q\[30\] _07473_ _01670_
+ VDD VSS MUX2_X1
X_24899_ net52 load_store_unit_i.rdata_q\[31\] _07473_ _01671_
+ VDD VSS MUX2_X1
X_24900_ net30 load_store_unit_i.rdata_q\[10\] _07473_ _01672_
+ VDD VSS MUX2_X1
X_24901_ net31 load_store_unit_i.rdata_q\[11\] _07473_ _01673_
+ VDD VSS MUX2_X1
X_24902_ net32 load_store_unit_i.rdata_q\[12\] _07473_ _01674_
+ VDD VSS MUX2_X1
X_24903_ net33 load_store_unit_i.rdata_q\[13\] _07473_ _01675_
+ VDD VSS MUX2_X1
X_24904_ net34 load_store_unit_i.rdata_q\[14\] _07471_ _01676_
+ VDD VSS MUX2_X1
X_24905_ net35 load_store_unit_i.rdata_q\[15\] _07471_ _01677_
+ VDD VSS MUX2_X1
X_24906_ net36 load_store_unit_i.rdata_q\[16\] _07471_ _01678_
+ VDD VSS MUX2_X1
X_24907_ net37 load_store_unit_i.rdata_q\[17\] _07471_ _01679_
+ VDD VSS MUX2_X1
X_24908_ _10909_ _10549_ _07474_ VDD VSS NOR2_X1
X_24909_ _07474_ _04574_ _07440_ _01680_ VDD VSS MUX2_X1
X_24910_ _10909_ _10677_ _07475_ VDD VSS NOR2_X2
X_24911_ _07475_ _05270_ _07440_ _01681_ VDD VSS MUX2_X1
X_24912_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[2\]
+ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]
+ _11429_ _01682_ VDD VSS MUX2_X1
X_24913_ _11431_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[2\]
+ _11429_ _01683_ VDD VSS MUX2_X1
X_24914_ _06386_ _03652_ _03441_ _01684_ VDD VSS MUX2_X1
X_24915_ _03617_ _03611_ _03441_ _01685_ VDD VSS MUX2_X1
X_24916_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_valid
+ _03647_ _03441_ _01686_ VDD VSS MUX2_X1
X_24917_ _15530_ _07476_ VDD VSS BUF_X2
X_24918_ _07476_ _07477_ VDD VSS BUF_X2
X_24919_ _07477_ _15526_ _15842_ _07478_ VDD VSS MUX2_X1
X_24920_ _15524_ _07479_ VDD VSS BUF_X4
X_24921_ _07479_ _07480_ VDD VSS BUF_X4
X_24922_ _07480_ _07481_ VDD VSS BUF_X8
X_24923_ _15842_ _05369_ _07478_ _07481_ _07482_ VDD VSS OAI22_X4
X_24924_ _07482_ _07483_ VDD VSS INV_X1
X_24925_ _03484_ _03507_ _04509_ _07484_ VDD VSS OAI21_X2
X_24926_ _15527_ _03486_ _07485_ VDD VSS OR2_X1
X_24927_ _07484_ _03485_ _07485_ _07486_ VDD VSS OR3_X1
X_24928_ _07486_ _07487_ VDD VSS BUF_X4
X_24929_ _04260_ _07487_ _07488_ VDD VSS NOR2_X4
X_24930_ _07488_ _07489_ VDD VSS BUF_X4
X_24931_ _05231_ _07489_ _07490_ VDD VSS NAND2_X1
X_24932_ _07483_ cs_registers_i.mcountinhibit\[0\] _07490_
+ _01687_ VDD VSS MUX2_X1
X_24933_ _15530_ _11355_ _15852_ _07491_ VDD VSS MUX2_X1
X_24934_ _15852_ _05461_ _07491_ _07479_ _07492_ VDD VSS OAI22_X4
X_24935_ _07492_ _07493_ VDD VSS INV_X2
X_24936_ _07493_ cs_registers_i.mcountinhibit\[2\] _07490_
+ _01688_ VDD VSS MUX2_X1
X_24937_ _07484_ _03485_ _07485_ _07494_ VDD VSS NOR3_X2
X_24938_ _03500_ _10922_ _11070_ _15873_ _07495_ VDD VSS NAND4_X1
X_24939_ _03499_ _15873_ _15857_ _07496_ VDD VSS AOI21_X1
X_24940_ _07495_ _07496_ _03500_ _07497_ VDD VSS OAI21_X2
X_24941_ _10922_ _03540_ _04289_ _07498_ VDD VSS OAI21_X2
X_24942_ _15509_ _15513_ _07497_ _07498_ _07499_ VDD VSS AND4_X1
X_24943_ _04237_ _07494_ _07499_ _07500_ VDD VSS NAND3_X1
X_24944_ _07500_ _07501_ VDD VSS CLKBUF_X3
X_24945_ _07501_ _07502_ VDD VSS CLKBUF_X3
X_24946_ _00551_ _07502_ _07503_ VDD VSS NAND2_X1
X_24947_ _07501_ _07504_ VDD VSS CLKBUF_X3
X_24948_ _07503_ _07504_ _07482_ _07505_ VDD VSS OAI21_X1
X_24949_ _04558_ _00553_ _07501_ _07506_ VDD VSS MUX2_X1
X_24950_ _07506_ _07507_ VDD VSS CLKBUF_X3
X_24951_ cs_registers_i.mcycle_counter_i.counter\[0\] _07505_
+ _07507_ _01689_ VDD VSS MUX2_X1
X_24952_ _05745_ _05362_ _07501_ _07508_ VDD VSS MUX2_X2
X_24953_ _07508_ _07509_ VDD VSS CLKBUF_X3
X_24954_ _05749_ _07510_ VDD VSS INV_X1
X_24955_ _05748_ _05745_ _07511_ VDD VSS NOR2_X4
X_24956_ _07494_ _07499_ _07512_ VDD VSS NAND2_X2
X_24957_ _07511_ _07512_ _07513_ VDD VSS NOR2_X2
X_24958_ _15534_ _07514_ VDD VSS CLKBUF_X2
X_24959_ _05459_ _05494_ cs_registers_i.mcycle_counter_i.counter\[4\]
+ _07515_ VDD VSS AND3_X1
X_24960_ cs_registers_i.mcycle_counter_i.counter\[5\] _07514_
+ _07515_ _07516_ VDD VSS NAND3_X2
X_24961_ cs_registers_i.mcycle_counter_i.counter\[9\] _07517_
+ VDD VSS INV_X1
X_24962_ _05606_ _05628_ cs_registers_i.mcycle_counter_i.counter\[8\]
+ _07518_ VDD VSS NAND3_X1
X_24963_ _07517_ _07518_ _07519_ VDD VSS OR2_X1
X_24964_ _07516_ _07519_ _07520_ VDD VSS OR2_X2
X_24965_ _07510_ _07513_ _07520_ _07521_ VDD VSS NOR3_X1
X_24966_ _15921_ _05753_ _07522_ VDD VSS NAND2_X1
X_24967_ _15526_ _07477_ _15921_ _07523_ VDD VSS MUX2_X1
X_24968_ _07522_ _07523_ _07481_ _07524_ VDD VSS OAI21_X2
X_24969_ _07524_ _07525_ VDD VSS BUF_X4
X_24970_ _07513_ _07526_ VDD VSS CLKBUF_X3
X_24971_ _07521_ _07525_ _07526_ _07527_ VDD VSS AOI21_X1
X_24972_ _07501_ _07528_ VDD VSS CLKBUF_X3
X_24973_ _07508_ _07520_ _07528_ _07529_ VDD VSS AOI21_X1
X_24974_ _07509_ _07527_ _07529_ _05749_ _07530_ VDD VSS OAI22_X1
X_24975_ _07530_ _01690_ VDD VSS INV_X1
X_24976_ _07513_ _07531_ VDD VSS CLKBUF_X3
X_24977_ _11355_ _07532_ VDD VSS CLKBUF_X2
X_24978_ _07532_ _07476_ _15928_ _07533_ VDD VSS MUX2_X1
X_24979_ _07479_ _07534_ VDD VSS BUF_X8
X_24980_ _15924_ _05792_ _07533_ _07534_ _07535_ VDD VSS OAI22_X4
X_24981_ _07531_ _07535_ _07536_ VDD VSS NAND2_X1
X_24982_ _07513_ _07537_ VDD VSS CLKBUF_X3
X_24983_ cs_registers_i.mcycle_counter_i.counter\[4\] _07538_
+ VDD VSS INV_X1
X_24984_ cs_registers_i.mcycle_counter_i.counter\[1\] _05459_
+ _05494_ cs_registers_i.mcycle_counter_i.counter\[0\] _07539_
+ VDD VSS NAND4_X2
X_24985_ _07538_ _07539_ _07540_ VDD VSS NOR2_X1
X_24986_ cs_registers_i.mcycle_counter_i.counter\[5\] _07540_
+ _07541_ VDD VSS NAND2_X2
X_24987_ _07519_ _07541_ _07542_ VDD VSS OR2_X2
X_24988_ cs_registers_i.mcycle_counter_i.counter\[11\] _05749_
+ _07543_ VDD VSS NAND2_X1
X_24989_ _07537_ _07542_ _07543_ _07544_ VDD VSS OR3_X1
X_24990_ _07509_ _07536_ _07544_ _07545_ VDD VSS AOI21_X1
X_24991_ _07507_ _07546_ VDD VSS CLKBUF_X3
X_24992_ _07504_ _07542_ _07510_ _07547_ VDD VSS OAI21_X1
X_24993_ cs_registers_i.mcycle_counter_i.counter\[11\] _07546_
+ _07547_ _07548_ VDD VSS AOI21_X1
X_24994_ _07545_ _07548_ _01691_ VDD VSS NOR2_X1
X_24995_ _07506_ _07549_ VDD VSS CLKBUF_X3
X_24996_ _07501_ _07550_ VDD VSS CLKBUF_X3
X_24997_ _07550_ _07520_ _07543_ _07551_ VDD VSS OAI21_X1
X_24998_ cs_registers_i.mcycle_counter_i.counter\[12\] _07549_
+ _07551_ _07552_ VDD VSS AOI21_X1
X_24999_ _07532_ _07476_ _15936_ _07553_ VDD VSS MUX2_X1
X_25000_ _15932_ _05846_ _07553_ _07534_ _07554_ VDD VSS OAI22_X4
X_25001_ _07526_ _07554_ _07555_ VDD VSS NAND2_X1
X_25002_ cs_registers_i.mcycle_counter_i.counter\[12\] cs_registers_i.mcycle_counter_i.counter\[11\]
+ _05749_ _07556_ VDD VSS NAND3_X2
X_25003_ _07537_ _07520_ _07557_ VDD VSS OR2_X1
X_25004_ _07555_ _07556_ _07557_ _07558_ VDD VSS OAI21_X1
X_25005_ _07507_ _07559_ VDD VSS CLKBUF_X3
X_25006_ _07552_ _07558_ _07559_ _01692_ VDD VSS AOI21_X1
X_25007_ _07507_ _07560_ VDD VSS CLKBUF_X3
X_25008_ _07528_ _07542_ _07556_ _07561_ VDD VSS OAI21_X1
X_25009_ cs_registers_i.mcycle_counter_i.counter\[13\] _07560_
+ _07561_ _07562_ VDD VSS AOI21_X1
X_25010_ _07501_ _07563_ VDD VSS CLKBUF_X3
X_25011_ _15530_ _07564_ VDD VSS CLKBUF_X2
X_25012_ _11356_ _07564_ _15944_ _07565_ VDD VSS MUX2_X1
X_25013_ _07480_ _07565_ _07566_ VDD VSS NOR2_X1
X_25014_ _05877_ _05880_ _05886_ _07567_ VDD VSS NOR3_X2
X_25015_ _07566_ _07567_ _15944_ _07568_ VDD VSS AOI21_X2
X_25016_ _07568_ _07569_ VDD VSS BUF_X4
X_25017_ _07563_ _07569_ _07570_ VDD VSS OR2_X1
X_25018_ cs_registers_i.mcycle_counter_i.counter\[13\] _07571_
+ VDD VSS INV_X1
X_25019_ _07571_ _07513_ _07542_ _07556_ _07572_ VDD VSS OR4_X1
X_25020_ _07509_ _07570_ _07572_ _07573_ VDD VSS AOI21_X1
X_25021_ _07562_ _07573_ _01693_ VDD VSS NOR2_X1
X_25022_ _15509_ _15513_ _07497_ _07498_ _07574_ VDD VSS NAND4_X4
X_25023_ _07511_ _07487_ _07574_ _07520_ _07556_ _07571_ _07575_
+ VDD VSS OAI33_X1
X_25024_ cs_registers_i.mcycle_counter_i.counter\[14\] _07549_
+ _07575_ _07576_ VDD VSS AOI21_X1
X_25025_ _11356_ _07476_ _15952_ _07577_ VDD VSS MUX2_X1
X_25026_ _07534_ _07577_ _07578_ VDD VSS NOR2_X1
X_25027_ _07578_ _05924_ _15952_ _07579_ VDD VSS AOI21_X4
X_25028_ _07563_ _07579_ _07580_ VDD VSS OR2_X1
X_25029_ _07571_ _07556_ _07581_ VDD VSS NOR2_X1
X_25030_ cs_registers_i.mcycle_counter_i.counter\[14\] _07581_
+ _07582_ VDD VSS NAND2_X1
X_25031_ _07580_ _07582_ _07557_ _07583_ VDD VSS OAI21_X1
X_25032_ _07576_ _07583_ _07559_ _01694_ VDD VSS AOI21_X1
X_25033_ _11356_ _07564_ _15957_ _07584_ VDD VSS MUX2_X1
X_25034_ _15961_ _05970_ _07584_ _07480_ _07585_ VDD VSS OAI22_X4
X_25035_ _07537_ _07585_ _07586_ VDD VSS NAND2_X1
X_25036_ _07542_ _07582_ _07587_ VDD VSS NOR2_X1
X_25037_ cs_registers_i.mcycle_counter_i.counter\[15\] _07550_
+ _07587_ _07588_ VDD VSS NAND3_X1
X_25038_ _07509_ _07586_ _07588_ _07589_ VDD VSS AOI21_X1
X_25039_ _07537_ _07590_ VDD VSS CLKBUF_X3
X_25040_ _07546_ _07587_ _07590_ _07591_ VDD VSS OAI21_X1
X_25041_ cs_registers_i.mcycle_counter_i.counter\[15\] _07592_
+ VDD VSS INV_X1
X_25042_ _07589_ _07591_ _07592_ _01695_ VDD VSS AOI21_X1
X_25043_ _06004_ _07593_ VDD VSS INV_X1
X_25044_ cs_registers_i.mcycle_counter_i.counter\[14\] cs_registers_i.mcycle_counter_i.counter\[15\]
+ _07581_ _07594_ VDD VSS NAND3_X2
X_25045_ _07520_ _07594_ _07595_ VDD VSS NOR2_X1
X_25046_ _07537_ _07596_ VDD VSS CLKBUF_X3
X_25047_ _07546_ _07595_ _07596_ _07597_ VDD VSS OAI21_X1
X_25048_ _11356_ _07564_ _15968_ _07598_ VDD VSS MUX2_X1
X_25049_ _07534_ _07598_ _07599_ VDD VSS NOR2_X1
X_25050_ _07599_ _06013_ _15968_ _07600_ VDD VSS AOI21_X4
X_25051_ _07563_ _07600_ _07601_ VDD VSS OR2_X1
X_25052_ _06004_ _07595_ _07602_ VDD VSS NAND2_X1
X_25053_ _07601_ _07602_ _07596_ _07603_ VDD VSS OAI21_X1
X_25054_ _07593_ _07597_ _07603_ _07560_ _01696_ VDD VSS AOI22_X1
X_25055_ _07532_ _07476_ _15976_ _07604_ VDD VSS MUX2_X1
X_25056_ _15972_ _06054_ _07604_ _07534_ _07605_ VDD VSS OAI22_X4
X_25057_ _07531_ _07605_ _07606_ VDD VSS NAND2_X1
X_25058_ _07593_ _07542_ _07594_ _07607_ VDD VSS NOR3_X1
X_25059_ _06037_ _07550_ _07607_ _07608_ VDD VSS NAND3_X1
X_25060_ _07508_ _07606_ _07608_ _07609_ VDD VSS AOI21_X1
X_25061_ _07546_ _07607_ _07590_ _07610_ VDD VSS OAI21_X1
X_25062_ _06037_ _07611_ VDD VSS INV_X1
X_25063_ _07609_ _07610_ _07611_ _01697_ VDD VSS AOI21_X1
X_25064_ _07550_ _07602_ _07611_ _07612_ VDD VSS OAI21_X1
X_25065_ _06094_ _07549_ _07612_ _07613_ VDD VSS AOI21_X1
X_25066_ _06004_ _06037_ _06094_ _07595_ _07614_ VDD VSS AND4_X1
X_25067_ _11356_ _07564_ _15981_ _07615_ VDD VSS MUX2_X1
X_25068_ _15985_ _06097_ _07615_ _07479_ _07616_ VDD VSS OAI22_X4
X_25069_ _04756_ _03532_ _07617_ VDD VSS AND2_X1
X_25070_ _03518_ _11427_ _07618_ VDD VSS NAND2_X1
X_25071_ _15527_ _07484_ _03485_ _07618_ _07619_ VDD VSS OR4_X2
X_25072_ _07617_ _07619_ _07574_ _07620_ VDD VSS NOR3_X2
X_25073_ _07614_ _07616_ _07620_ _07621_ VDD VSS MUX2_X1
X_25074_ _07613_ _07621_ _07559_ _01698_ VDD VSS AOI21_X1
X_25075_ _07532_ _07477_ _15992_ _07622_ VDD VSS MUX2_X1
X_25076_ _15988_ _06127_ _07622_ _07481_ _07623_ VDD VSS OAI22_X4
X_25077_ _07623_ _07624_ VDD VSS BUF_X4
X_25078_ _07531_ _07624_ _07625_ VDD VSS NAND2_X1
X_25079_ _07542_ _07594_ _07626_ VDD VSS NOR2_X1
X_25080_ _06004_ _06037_ _06094_ _07626_ _07627_ VDD VSS AND4_X2
X_25081_ _07502_ _07627_ _07628_ VDD VSS NAND2_X1
X_25082_ _06123_ _07629_ VDD VSS INV_X1
X_25083_ _07625_ _07628_ _07629_ _07630_ VDD VSS OAI21_X1
X_25084_ _07507_ _07627_ _07596_ _07631_ VDD VSS OAI21_X1
X_25085_ _07559_ _07630_ _07631_ _07629_ _01699_ VDD VSS AOI22_X1
X_25086_ _15535_ _07563_ _07632_ VDD VSS NAND2_X1
X_25087_ _07477_ _15526_ _15845_ _07633_ VDD VSS MUX2_X1
X_25088_ _15845_ _05407_ _07633_ _07481_ _07634_ VDD VSS OAI22_X2
X_25089_ _07634_ _07635_ VDD VSS BUF_X4
X_25090_ _07501_ _07636_ VDD VSS CLKBUF_X3
X_25091_ _07632_ _07635_ _07636_ _07637_ VDD VSS OAI21_X1
X_25092_ cs_registers_i.mcycle_counter_i.counter\[1\] _07637_
+ _07507_ _01700_ VDD VSS MUX2_X1
X_25093_ _07532_ _07476_ _15997_ _07638_ VDD VSS MUX2_X1
X_25094_ _16001_ _06170_ _07638_ _07534_ _07639_ VDD VSS OAI22_X4
X_25095_ _07639_ _07640_ VDD VSS BUF_X4
X_25096_ _07526_ _07640_ _07641_ VDD VSS NAND2_X1
X_25097_ _06123_ _06168_ _07636_ _07614_ _07642_ VDD VSS NAND4_X1
X_25098_ _07509_ _07641_ _07642_ _07643_ VDD VSS AOI21_X1
X_25099_ _07614_ _07644_ VDD VSS INV_X1
X_25100_ _07504_ _07644_ _07629_ _07645_ VDD VSS OAI21_X1
X_25101_ _06168_ _07546_ _07645_ _07646_ VDD VSS AOI21_X1
X_25102_ _07643_ _07646_ _01701_ VDD VSS NOR2_X1
X_25103_ _06123_ _06168_ _07627_ _07647_ VDD VSS NAND3_X1
X_25104_ _07504_ _07647_ _07648_ VDD VSS NAND2_X1
X_25105_ cs_registers_i.mcycle_counter_i.counter\[21\] _07549_
+ _07648_ _07649_ VDD VSS AOI21_X1
X_25106_ _11355_ _07564_ _16005_ _07650_ VDD VSS MUX2_X1
X_25107_ _16009_ _06197_ _07650_ _07479_ _07651_ VDD VSS OAI22_X4
X_25108_ _07537_ _07651_ _07652_ VDD VSS NAND2_X1
X_25109_ _06123_ _06168_ cs_registers_i.mcycle_counter_i.counter\[21\]
+ _07653_ VDD VSS NAND3_X2
X_25110_ _07652_ _07653_ _07628_ _07654_ VDD VSS OAI21_X1
X_25111_ _07649_ _07654_ _07559_ _01702_ VDD VSS AOI21_X1
X_25112_ _07476_ _07532_ _16017_ _07655_ VDD VSS MUX2_X1
X_25113_ _16017_ _04562_ _07655_ _07534_ _07656_ VDD VSS OAI22_X4
X_25114_ _07656_ _07657_ VDD VSS BUF_X4
X_25115_ _07537_ _07657_ _07658_ VDD VSS NAND2_X1
X_25116_ cs_registers_i.mcycle_counter_i.counter\[22\] _07659_
+ VDD VSS INV_X1
X_25117_ _07659_ _07653_ _07660_ VDD VSS NOR2_X2
X_25118_ _07528_ _07614_ _07660_ _07661_ VDD VSS NAND3_X1
X_25119_ _07509_ _07658_ _07661_ _07662_ VDD VSS AOI21_X1
X_25120_ _07504_ _07644_ _07653_ _07663_ VDD VSS OAI21_X1
X_25121_ cs_registers_i.mcycle_counter_i.counter\[22\] _07546_
+ _07663_ _07664_ VDD VSS AOI21_X1
X_25122_ _07662_ _07664_ _01703_ VDD VSS NOR2_X1
X_25123_ _07627_ _07660_ _07665_ VDD VSS NAND2_X1
X_25124_ _07504_ _07665_ _07666_ VDD VSS NAND2_X1
X_25125_ _04758_ _07549_ _07666_ _07667_ VDD VSS AOI21_X1
X_25126_ _07564_ _11356_ _16020_ _07668_ VDD VSS MUX2_X1
X_25127_ _16020_ _04762_ _07668_ _07480_ _07669_ VDD VSS OAI22_X4
X_25128_ _07531_ _07669_ _07670_ VDD VSS NAND2_X1
X_25129_ _04758_ _07660_ _07671_ VDD VSS NAND2_X1
X_25130_ _07670_ _07671_ _07628_ _07672_ VDD VSS OAI21_X1
X_25131_ _07667_ _07672_ _07559_ _01704_ VDD VSS AOI21_X1
X_25132_ _07550_ _07644_ _07671_ _07673_ VDD VSS OAI21_X1
X_25133_ cs_registers_i.mcycle_counter_i.counter\[24\] _07549_
+ _07673_ _07674_ VDD VSS AOI21_X1
X_25134_ _07564_ _11356_ _16033_ _07675_ VDD VSS MUX2_X1
X_25135_ _16033_ _04903_ _07675_ _07480_ _07676_ VDD VSS OAI22_X4
X_25136_ _07531_ _07676_ _07677_ VDD VSS NAND2_X1
X_25137_ _04758_ cs_registers_i.mcycle_counter_i.counter\[24\]
+ _07614_ _07660_ _07678_ VDD VSS NAND4_X1
X_25138_ _07677_ _07678_ _07590_ _07679_ VDD VSS OAI21_X1
X_25139_ _07674_ _07679_ _07559_ _01705_ VDD VSS AOI21_X1
X_25140_ _07501_ _07680_ VDD VSS CLKBUF_X3
X_25141_ _07627_ _07681_ VDD VSS INV_X1
X_25142_ _04758_ cs_registers_i.mcycle_counter_i.counter\[24\]
+ _07660_ _07682_ VDD VSS NAND3_X2
X_25143_ _07680_ _07681_ _07682_ _07683_ VDD VSS OAI21_X1
X_25144_ cs_registers_i.mcycle_counter_i.counter\[25\] _07549_
+ _07683_ _07684_ VDD VSS AOI21_X1
X_25145_ _11355_ _15530_ _16040_ _07685_ VDD VSS MUX2_X1
X_25146_ _07480_ _07685_ _07686_ VDD VSS NOR2_X1
X_25147_ _04962_ _04966_ _04974_ _07687_ VDD VSS NOR3_X4
X_25148_ _07686_ _07687_ _16040_ _07688_ VDD VSS AOI21_X4
X_25149_ _07688_ _07689_ VDD VSS BUF_X4
X_25150_ _07563_ _07689_ _07690_ VDD VSS OR2_X1
X_25151_ _06004_ _06037_ _06094_ cs_registers_i.mcycle_counter_i.counter\[25\]
+ _07691_ VDD VSS NAND4_X2
X_25152_ _07519_ _07594_ _07682_ _07691_ _07692_ VDD VSS OR4_X2
X_25153_ _07541_ _07692_ _07693_ VDD VSS OR2_X2
X_25154_ _07690_ _07693_ _07590_ _07694_ VDD VSS OAI21_X1
X_25155_ _07684_ _07694_ _07559_ _01706_ VDD VSS AOI21_X1
X_25156_ _15526_ _07477_ _16045_ _07695_ VDD VSS MUX2_X1
X_25157_ _16049_ _05034_ _07695_ _07481_ _07696_ VDD VSS OAI22_X4
X_25158_ _07537_ _07696_ _07697_ VDD VSS NAND2_X1
X_25159_ _07516_ _07692_ _07698_ VDD VSS NOR2_X2
X_25160_ _05032_ _07550_ _07698_ _07699_ VDD VSS NAND3_X1
X_25161_ _07508_ _07697_ _07699_ _07700_ VDD VSS AOI21_X1
X_25162_ _07546_ _07698_ _07590_ _07701_ VDD VSS OAI21_X1
X_25163_ _05032_ _07702_ VDD VSS INV_X1
X_25164_ _07700_ _07701_ _07702_ _01707_ VDD VSS AOI21_X1
X_25165_ _07617_ _07619_ _07574_ _07541_ _07692_ _07702_ _07703_
+ VDD VSS OAI33_X1
X_25166_ cs_registers_i.mcycle_counter_i.counter\[27\] _07549_
+ _07703_ _07704_ VDD VSS AOI21_X1
X_25167_ _05032_ cs_registers_i.mcycle_counter_i.counter\[27\]
+ _07705_ VDD VSS NAND2_X2
X_25168_ _07693_ _07705_ _07706_ VDD VSS NOR2_X1
X_25169_ _07532_ _07476_ _16056_ _07707_ VDD VSS MUX2_X1
X_25170_ _16052_ _04787_ _07707_ _07534_ _07708_ VDD VSS OAI22_X4
X_25171_ _07708_ _07709_ VDD VSS BUF_X4
X_25172_ _07706_ _07709_ _07620_ _07710_ VDD VSS MUX2_X1
X_25173_ _07704_ _07710_ _07560_ _01708_ VDD VSS AOI21_X1
X_25174_ _07563_ _07711_ VDD VSS CLKBUF_X3
X_25175_ _05032_ cs_registers_i.mcycle_counter_i.counter\[27\]
+ _07698_ _07712_ VDD VSS NAND3_X2
X_25176_ _07711_ _07712_ _07713_ VDD VSS NAND2_X1
X_25177_ _05066_ _07560_ _07713_ _07714_ VDD VSS AOI21_X1
X_25178_ _15530_ _11355_ _16060_ _07715_ VDD VSS MUX2_X1
X_25179_ _07480_ _07715_ _07716_ VDD VSS NOR2_X1
X_25180_ _07716_ _05077_ _16064_ _07717_ VDD VSS AOI21_X4
X_25181_ _07717_ _07718_ VDD VSS BUF_X4
X_25182_ _07563_ _07718_ _07719_ VDD VSS OR2_X1
X_25183_ _07712_ _07720_ VDD VSS INV_X1
X_25184_ _05066_ _07504_ _07720_ _07721_ VDD VSS NAND3_X1
X_25185_ _07509_ _07719_ _07721_ _07722_ VDD VSS AOI21_X1
X_25186_ _07714_ _07722_ _01709_ VDD VSS NOR2_X1
X_25187_ _05066_ _07706_ _07723_ VDD VSS NAND2_X1
X_25188_ _07711_ _07723_ _07724_ VDD VSS NAND2_X1
X_25189_ _05142_ _07560_ _07724_ _07725_ VDD VSS AOI21_X1
X_25190_ _07477_ _07532_ _16068_ _07726_ VDD VSS MUX2_X1
X_25191_ _16068_ _05145_ _07726_ _07481_ _07727_ VDD VSS OAI22_X4
X_25192_ _07727_ _07728_ VDD VSS BUF_X4
X_25193_ _07526_ _07728_ _07729_ VDD VSS NAND2_X1
X_25194_ _05066_ _05142_ _07550_ _07706_ _07730_ VDD VSS NAND4_X1
X_25195_ _07509_ _07729_ _07730_ _07731_ VDD VSS AOI21_X1
X_25196_ _07725_ _07731_ _01710_ VDD VSS NOR2_X1
X_25197_ _07492_ _07537_ _07732_ VDD VSS NAND2_X1
X_25198_ _05459_ _07514_ _07502_ _07733_ VDD VSS NAND3_X1
X_25199_ _07508_ _07732_ _07733_ _07734_ VDD VSS AOI21_X1
X_25200_ _07546_ _07590_ _07514_ _07735_ VDD VSS OAI21_X1
X_25201_ _05459_ _07736_ VDD VSS INV_X1
X_25202_ _07734_ _07735_ _07736_ _01711_ VDD VSS AOI21_X1
X_25203_ _07501_ _07737_ VDD VSS CLKBUF_X3
X_25204_ _05066_ _05142_ _07720_ _07738_ VDD VSS NAND3_X1
X_25205_ _07737_ _07738_ _07739_ VDD VSS NAND2_X1
X_25206_ cs_registers_i.mcycle_counter_i.counter\[30\] _07549_
+ _07739_ _07740_ VDD VSS AOI21_X1
X_25207_ _05066_ _05142_ cs_registers_i.mcycle_counter_i.counter\[30\]
+ _07741_ VDD VSS NAND3_X4
X_25208_ _07712_ _07741_ _07742_ VDD VSS NOR2_X2
X_25209_ _16080_ _05203_ _07743_ VDD VSS NAND2_X1
X_25210_ _15526_ _07477_ _16080_ _07744_ VDD VSS MUX2_X1
X_25211_ _07743_ _07744_ _07481_ _07745_ VDD VSS OAI21_X4
X_25212_ _07742_ _07745_ _07620_ _07746_ VDD VSS MUX2_X1
X_25213_ _07740_ _07746_ _07560_ _01712_ VDD VSS AOI21_X1
X_25214_ _07476_ _07532_ _15496_ _07747_ VDD VSS MUX2_X1
X_25215_ _15496_ _05238_ _07747_ _07534_ _07748_ VDD VSS OAI22_X4
X_25216_ _07531_ _07748_ _07749_ VDD VSS NAND2_X1
X_25217_ _07693_ _07705_ _07741_ _07750_ VDD VSS NOR3_X4
X_25218_ _05236_ _07550_ _07750_ _07751_ VDD VSS NAND3_X1
X_25219_ _07508_ _07749_ _07751_ _07752_ VDD VSS AOI21_X1
X_25220_ _07546_ _07750_ _07590_ _07753_ VDD VSS OAI21_X1
X_25221_ _05236_ _07754_ VDD VSS INV_X1
X_25222_ _07752_ _07753_ _07754_ _01713_ VDD VSS AOI21_X1
X_25223_ _00553_ _04560_ _07512_ _07755_ VDD VSS OAI21_X1
X_25224_ _07755_ _07512_ _04558_ _07756_ VDD VSS OAI21_X2
X_25225_ _07756_ _07757_ VDD VSS BUF_X2
X_25226_ _07757_ _07758_ VDD VSS CLKBUF_X3
X_25227_ _05236_ _07742_ _07759_ VDD VSS NAND2_X1
X_25228_ _07711_ _07759_ _07760_ VDD VSS NAND2_X1
X_25229_ cs_registers_i.mcycle_counter_i.counter\[32\] _07758_
+ _07760_ _07761_ VDD VSS AOI21_X1
X_25230_ _07756_ _07762_ VDD VSS INV_X2
X_25231_ _07482_ _07526_ _07763_ VDD VSS NAND2_X1
X_25232_ cs_registers_i.mcycle_counter_i.counter\[32\] _05236_
+ _07764_ VDD VSS AND2_X2
X_25233_ _07528_ _07742_ _07764_ _07765_ VDD VSS NAND3_X1
X_25234_ _07762_ _07763_ _07765_ _07766_ VDD VSS AOI21_X1
X_25235_ _07761_ _07766_ _01714_ VDD VSS NOR2_X1
X_25236_ _07757_ _07767_ VDD VSS CLKBUF_X3
X_25237_ _07750_ _07764_ _07768_ VDD VSS NAND2_X1
X_25238_ _07737_ _07768_ _07769_ VDD VSS NAND2_X1
X_25239_ _05404_ _07767_ _07769_ _07770_ VDD VSS AOI21_X1
X_25240_ _07526_ _07635_ _07771_ VDD VSS NAND2_X1
X_25241_ cs_registers_i.mcycle_counter_i.counter\[5\] _07772_
+ VDD VSS INV_X1
X_25242_ _07538_ _07772_ _07539_ _07773_ VDD VSS NOR3_X2
X_25243_ _07519_ _07594_ _07682_ _07691_ _07774_ VDD VSS NOR4_X2
X_25244_ _07773_ _07774_ _07775_ VDD VSS NAND2_X1
X_25245_ _07775_ _07705_ _07741_ _07776_ VDD VSS NOR3_X2
X_25246_ _05404_ _07776_ _07764_ _07777_ VDD VSS NAND3_X1
X_25247_ _07771_ _07777_ _07590_ _07778_ VDD VSS OAI21_X1
X_25248_ _07757_ _07779_ VDD VSS CLKBUF_X3
X_25249_ _07770_ _07778_ _07779_ _01715_ VDD VSS AOI21_X1
X_25250_ _05404_ _07742_ _07764_ _07780_ VDD VSS NAND3_X1
X_25251_ _07711_ _07780_ _07781_ VDD VSS NAND2_X1
X_25252_ _05457_ _07758_ _07781_ _07782_ VDD VSS AOI21_X1
X_25253_ _05457_ _07783_ VDD VSS INV_X1
X_25254_ _07783_ _07780_ _07784_ VDD VSS NOR2_X2
X_25255_ _07528_ _07784_ _07785_ VDD VSS NAND2_X1
X_25256_ _07762_ _07785_ _07732_ _07786_ VDD VSS AOI21_X1
X_25257_ _07782_ _07786_ _01716_ VDD VSS NOR2_X1
X_25258_ _05404_ _05457_ _07750_ _07764_ _07787_ VDD VSS NAND4_X2
X_25259_ _07737_ _07787_ _07788_ VDD VSS NAND2_X1
X_25260_ _05482_ _07767_ _07788_ _07789_ VDD VSS AOI21_X1
X_25261_ _07564_ _11355_ _15865_ _07790_ VDD VSS MUX2_X1
X_25262_ _15865_ _05497_ _07790_ _07480_ _07791_ VDD VSS OAI22_X4
X_25263_ _07531_ _07791_ _07792_ VDD VSS NAND2_X1
X_25264_ _07513_ _07787_ _07793_ VDD VSS OR2_X1
X_25265_ _05482_ _07794_ VDD VSS INV_X1
X_25266_ _07792_ _07793_ _07794_ _07795_ VDD VSS OAI21_X1
X_25267_ _07789_ _07795_ _07779_ _01717_ VDD VSS AOI21_X1
X_25268_ _05482_ _07784_ _07796_ VDD VSS NAND2_X1
X_25269_ _07737_ _07796_ _07797_ VDD VSS NAND2_X1
X_25270_ _05536_ _07767_ _07797_ _07798_ VDD VSS AOI21_X1
X_25271_ _15526_ _07477_ _15872_ _07799_ VDD VSS MUX2_X1
X_25272_ _15868_ _05540_ _07799_ _07481_ _07800_ VDD VSS OAI22_X4
X_25273_ _07526_ _07800_ _07801_ VDD VSS NAND2_X1
X_25274_ _05482_ _05536_ _07784_ _07802_ VDD VSS NAND3_X1
X_25275_ _07801_ _07802_ _07590_ _07803_ VDD VSS OAI21_X1
X_25276_ _07798_ _07803_ _07779_ _01718_ VDD VSS AOI21_X1
X_25277_ _05404_ _05457_ _07776_ _07764_ _07804_ VDD VSS NAND4_X2
X_25278_ _05482_ _05536_ _07805_ VDD VSS NAND2_X1
X_25279_ _07680_ _07804_ _07805_ _07806_ VDD VSS OAI21_X1
X_25280_ cs_registers_i.mcycle_counter_i.counter\[37\] _07767_
+ _07806_ _07807_ VDD VSS AOI21_X1
X_25281_ _07532_ _07476_ _15881_ _07808_ VDD VSS MUX2_X1
X_25282_ _07534_ _07808_ _07809_ VDD VSS NOR2_X1
X_25283_ _07809_ _05577_ _15881_ _07810_ VDD VSS AOI21_X4
X_25284_ _05482_ _05536_ cs_registers_i.mcycle_counter_i.counter\[37\]
+ _07811_ VDD VSS NAND3_X2
X_25285_ _07711_ _07810_ _07811_ _07793_ _07812_ VDD VSS OAI22_X1
X_25286_ _07807_ _07812_ _07779_ _01719_ VDD VSS AOI21_X1
X_25287_ _05459_ _05494_ _07514_ _07813_ VDD VSS NAND3_X1
X_25288_ _07538_ _07772_ _07813_ _07814_ VDD VSS NOR3_X2
X_25289_ _07814_ _07774_ _07815_ VDD VSS NAND2_X1
X_25290_ _07815_ _07705_ _07741_ _07816_ VDD VSS NOR3_X1
X_25291_ _05404_ _05457_ _07816_ _07764_ _07817_ VDD VSS NAND4_X2
X_25292_ _07528_ _07817_ _07811_ _07818_ VDD VSS OAI21_X1
X_25293_ _05609_ _07758_ _07818_ _07819_ VDD VSS AOI21_X1
X_25294_ _15526_ _07477_ _15889_ _07820_ VDD VSS MUX2_X1
X_25295_ _15885_ _05611_ _07820_ _07481_ _07821_ VDD VSS OAI22_X4
X_25296_ _07531_ _07821_ _07822_ VDD VSS NAND2_X1
X_25297_ _05482_ _05536_ cs_registers_i.mcycle_counter_i.counter\[37\]
+ _07823_ VDD VSS AND3_X1
X_25298_ _05609_ _07784_ _07823_ _07824_ VDD VSS NAND3_X2
X_25299_ _07537_ _07824_ _07825_ VDD VSS OR2_X1
X_25300_ _07762_ _07822_ _07825_ _07826_ VDD VSS AOI21_X1
X_25301_ _07819_ _07826_ _01720_ VDD VSS NOR2_X1
X_25302_ _07477_ _15526_ _15893_ _07827_ VDD VSS MUX2_X1
X_25303_ _15893_ _05639_ _07827_ _07481_ _07828_ VDD VSS OAI22_X4
X_25304_ _07531_ _07828_ _07829_ VDD VSS NAND2_X1
X_25305_ _05609_ _07823_ _07830_ VDD VSS NAND2_X1
X_25306_ _07787_ _07830_ _07831_ VDD VSS NOR2_X1
X_25307_ _05625_ _07550_ _07831_ _07832_ VDD VSS NAND3_X1
X_25308_ _07762_ _07829_ _07832_ _07833_ VDD VSS AOI21_X1
X_25309_ _07758_ _07831_ _07590_ _07834_ VDD VSS OAI21_X1
X_25310_ _05625_ _07835_ VDD VSS INV_X1
X_25311_ _07833_ _07834_ _07835_ _01721_ VDD VSS AOI21_X1
X_25312_ cs_registers_i.mcycle_counter_i.counter\[1\] _05459_
+ cs_registers_i.mcycle_counter_i.counter\[0\] _07836_ VDD VSS
+ NAND3_X1
X_25313_ _07737_ _07836_ _07837_ VDD VSS NAND2_X1
X_25314_ _05494_ _07549_ _07837_ _07838_ VDD VSS AOI21_X1
X_25315_ _07792_ _07539_ _07596_ _07839_ VDD VSS OAI21_X1
X_25316_ _07838_ _07839_ _07560_ _01722_ VDD VSS AOI21_X1
X_25317_ _07680_ _07824_ _07835_ _07840_ VDD VSS OAI21_X1
X_25318_ cs_registers_i.mcycle_counter_i.counter\[40\] _07767_
+ _07840_ _07841_ VDD VSS AOI21_X1
X_25319_ _07564_ _11356_ _15901_ _07842_ VDD VSS MUX2_X1
X_25320_ _07480_ _07842_ _07843_ VDD VSS NOR2_X1
X_25321_ _07843_ _05685_ _15905_ _07844_ VDD VSS AOI21_X4
X_25322_ _07563_ _07844_ _07845_ VDD VSS OR2_X1
X_25323_ _05625_ cs_registers_i.mcycle_counter_i.counter\[40\]
+ _07846_ VDD VSS NAND2_X1
X_25324_ _07845_ _07846_ _07825_ _07847_ VDD VSS OAI21_X1
X_25325_ _07841_ _07847_ _07779_ _01723_ VDD VSS AOI21_X1
X_25326_ _07787_ _07830_ _07848_ VDD VSS OR2_X1
X_25327_ _07680_ _07848_ _07846_ _07849_ VDD VSS OAI21_X1
X_25328_ cs_registers_i.mcycle_counter_i.counter\[41\] _07767_
+ _07849_ _07850_ VDD VSS AOI21_X1
X_25329_ _11356_ _07564_ _15913_ _07851_ VDD VSS MUX2_X1
X_25330_ _07480_ _07851_ _07852_ VDD VSS NOR2_X1
X_25331_ _07852_ _05718_ _15913_ _07853_ VDD VSS AOI21_X2
X_25332_ _07853_ _07854_ VDD VSS BUF_X4
X_25333_ _05625_ cs_registers_i.mcycle_counter_i.counter\[40\]
+ cs_registers_i.mcycle_counter_i.counter\[41\] _07855_ VDD
+ VSS NAND3_X4
X_25334_ _07550_ _07831_ _07856_ VDD VSS NAND2_X1
X_25335_ _07711_ _07854_ _07855_ _07856_ _07857_ VDD VSS OAI22_X1
X_25336_ _07850_ _07857_ _07779_ _01724_ VDD VSS AOI21_X1
X_25337_ _05742_ _07858_ VDD VSS INV_X1
X_25338_ _05609_ _07859_ VDD VSS INV_X1
X_25339_ _07859_ _07817_ _07811_ _07855_ _07860_ VDD VSS NOR4_X4
X_25340_ _07767_ _07860_ _07596_ _07861_ VDD VSS OAI21_X1
X_25341_ _07531_ _07524_ _07862_ VDD VSS NAND2_X1
X_25342_ _07502_ _07860_ _07863_ VDD VSS NAND2_X1
X_25343_ _07862_ _07863_ _07858_ _07864_ VDD VSS OAI21_X1
X_25344_ _07858_ _07861_ _07864_ _07758_ _01725_ VDD VSS AOI22_X1
X_25345_ _07848_ _07855_ _07865_ VDD VSS NOR2_X2
X_25346_ _05742_ _07865_ _07866_ VDD VSS NAND2_X1
X_25347_ _07528_ _07866_ _07867_ VDD VSS NAND2_X1
X_25348_ _05786_ _07758_ _07867_ _07868_ VDD VSS AOI21_X1
X_25349_ _05786_ _05742_ _07636_ _07865_ _07869_ VDD VSS NAND4_X1
X_25350_ _07762_ _07869_ _07536_ _07870_ VDD VSS AOI21_X1
X_25351_ _07868_ _07870_ _01726_ VDD VSS NOR2_X1
X_25352_ _07757_ _07871_ VDD VSS CLKBUF_X3
X_25353_ _05786_ _05742_ _07860_ _07872_ VDD VSS NAND3_X1
X_25354_ _07737_ _07872_ _07873_ VDD VSS NAND2_X1
X_25355_ cs_registers_i.mcycle_counter_i.counter\[44\] _07871_
+ _07873_ _07874_ VDD VSS AOI21_X1
X_25356_ cs_registers_i.mcycle_counter_i.counter\[44\] _05786_
+ _05742_ _07875_ VDD VSS AND3_X2
X_25357_ _07875_ _07876_ VDD VSS INV_X1
X_25358_ _07555_ _07863_ _07876_ _07877_ VDD VSS OAI21_X1
X_25359_ _07874_ _07877_ _07779_ _01727_ VDD VSS AOI21_X1
X_25360_ _07865_ _07875_ _07878_ VDD VSS NAND2_X1
X_25361_ _07528_ _07878_ _07879_ VDD VSS NAND2_X1
X_25362_ _05875_ _07758_ _07879_ _07880_ VDD VSS AOI21_X1
X_25363_ _05875_ _07636_ _07865_ _07875_ _07881_ VDD VSS NAND4_X1
X_25364_ _07762_ _07881_ _07570_ _07882_ VDD VSS AOI21_X1
X_25365_ _07880_ _07882_ _01728_ VDD VSS NOR2_X1
X_25366_ _05875_ _07860_ _07875_ _07883_ VDD VSS NAND3_X1
X_25367_ _07737_ _07883_ _07884_ VDD VSS NAND2_X1
X_25368_ cs_registers_i.mcycle_counter_i.counter\[46\] _07871_
+ _07884_ _07885_ VDD VSS AOI21_X1
X_25369_ _05875_ cs_registers_i.mcycle_counter_i.counter\[46\]
+ _07875_ _07886_ VDD VSS NAND3_X4
X_25370_ _07580_ _07863_ _07886_ _07887_ VDD VSS OAI21_X1
X_25371_ _07885_ _07887_ _07779_ _01729_ VDD VSS AOI21_X1
X_25372_ _07848_ _07855_ _07886_ _07888_ VDD VSS NOR3_X2
X_25373_ _05966_ _07636_ _07888_ _07889_ VDD VSS NAND3_X1
X_25374_ _07762_ _07889_ _07586_ _07890_ VDD VSS AOI21_X1
X_25375_ _07804_ _07830_ _07855_ _07886_ _07891_ VDD VSS NOR4_X2
X_25376_ _07767_ _07891_ _07596_ _07892_ VDD VSS OAI21_X1
X_25377_ _05966_ _07893_ VDD VSS INV_X1
X_25378_ _07890_ _07892_ _07893_ _01730_ VDD VSS AOI21_X1
X_25379_ _05875_ cs_registers_i.mcycle_counter_i.counter\[46\]
+ _07875_ _07894_ VDD VSS AND3_X1
X_25380_ _05966_ _07860_ _07894_ _07895_ VDD VSS NAND3_X1
X_25381_ _07737_ _07895_ _07896_ VDD VSS NAND2_X1
X_25382_ cs_registers_i.mcycle_counter_i.counter\[48\] _07871_
+ _07896_ _07897_ VDD VSS AOI21_X1
X_25383_ _05966_ cs_registers_i.mcycle_counter_i.counter\[48\]
+ _07860_ _07894_ _07898_ VDD VSS NAND4_X1
X_25384_ _07601_ _07898_ _07596_ _07899_ VDD VSS OAI21_X1
X_25385_ _07897_ _07899_ _07779_ _01731_ VDD VSS AOI21_X1
X_25386_ _05966_ cs_registers_i.mcycle_counter_i.counter\[48\]
+ _07900_ VDD VSS AND2_X2
X_25387_ _07888_ _07900_ _07901_ VDD VSS NAND2_X1
X_25388_ _07737_ _07901_ _07902_ VDD VSS NAND2_X1
X_25389_ _06034_ _07871_ _07902_ _07903_ VDD VSS AOI21_X1
X_25390_ _06034_ _07502_ _07888_ _07900_ _07904_ VDD VSS NAND4_X1
X_25391_ _07606_ _07904_ _07905_ VDD VSS NAND2_X1
X_25392_ _07903_ _07905_ _07779_ _01732_ VDD VSS AOI21_X1
X_25393_ _07528_ _07813_ _07906_ VDD VSS NAND2_X1
X_25394_ cs_registers_i.mcycle_counter_i.counter\[4\] _07560_
+ _07906_ _07907_ VDD VSS AOI21_X1
X_25395_ _07514_ _07504_ _07515_ _07908_ VDD VSS NAND3_X1
X_25396_ _07509_ _07801_ _07908_ _07909_ VDD VSS AOI21_X1
X_25397_ _07907_ _07909_ _01733_ VDD VSS NOR2_X1
X_25398_ _06091_ _07910_ VDD VSS INV_X1
X_25399_ _06034_ _07900_ _07911_ VDD VSS NAND2_X1
X_25400_ _07824_ _07855_ _07886_ _07911_ _07912_ VDD VSS NOR4_X4
X_25401_ _07767_ _07912_ _07596_ _07913_ VDD VSS OAI21_X1
X_25402_ _07616_ _07914_ VDD VSS INV_X2
X_25403_ _07502_ _07912_ _07915_ VDD VSS NAND2_X1
X_25404_ _07711_ _07914_ _07915_ _07910_ _07916_ VDD VSS OAI22_X1
X_25405_ _07910_ _07913_ _07916_ _07758_ _01734_ VDD VSS AOI22_X1
X_25406_ _06034_ _07891_ _07900_ _07917_ VDD VSS NAND3_X1
X_25407_ _07680_ _07917_ _07910_ _07918_ VDD VSS OAI21_X1
X_25408_ _06120_ _07871_ _07918_ _07919_ VDD VSS AOI21_X1
X_25409_ _06091_ _06120_ _07920_ VDD VSS NAND2_X1
X_25410_ _07625_ _07904_ _07920_ _07921_ VDD VSS OAI21_X1
X_25411_ _07757_ _07922_ VDD VSS CLKBUF_X3
X_25412_ _07919_ _07921_ _07922_ _01735_ VDD VSS AOI21_X1
X_25413_ _06034_ _07860_ _07894_ _07900_ _07923_ VDD VSS NAND4_X2
X_25414_ _07680_ _07923_ _07920_ _07924_ VDD VSS OAI21_X1
X_25415_ cs_registers_i.mcycle_counter_i.counter\[52\] _07871_
+ _07924_ _07925_ VDD VSS AOI21_X1
X_25416_ _06091_ _06120_ cs_registers_i.mcycle_counter_i.counter\[52\]
+ _07926_ VDD VSS NAND3_X2
X_25417_ _07641_ _07915_ _07926_ _07927_ VDD VSS OAI21_X1
X_25418_ _07925_ _07927_ _07922_ _01736_ VDD VSS AOI21_X1
X_25419_ _06034_ _07928_ VDD VSS INV_X1
X_25420_ _07928_ _07901_ _07926_ _07929_ VDD VSS NOR3_X2
X_25421_ _06193_ _07636_ _07929_ _07930_ VDD VSS NAND3_X1
X_25422_ _07762_ _07930_ _07652_ _07931_ VDD VSS AOI21_X1
X_25423_ _06091_ _06120_ cs_registers_i.mcycle_counter_i.counter\[52\]
+ _07932_ VDD VSS AND3_X1
X_25424_ _06034_ _07891_ _07900_ _07932_ _07933_ VDD VSS NAND4_X1
X_25425_ _07711_ _07933_ _07934_ VDD VSS NAND2_X1
X_25426_ _07758_ _07934_ _07935_ VDD VSS NAND2_X1
X_25427_ _06193_ _07936_ VDD VSS INV_X1
X_25428_ _07931_ _07935_ _07936_ _01737_ VDD VSS AOI21_X1
X_25429_ _07936_ _07923_ _07926_ _07937_ VDD VSS NOR3_X2
X_25430_ _04547_ _07563_ _07937_ _07938_ VDD VSS NAND3_X2
X_25431_ _07762_ _07938_ _07658_ _07939_ VDD VSS AOI21_X1
X_25432_ _07767_ _07937_ _07596_ _07940_ VDD VSS OAI21_X1
X_25433_ _04547_ _07941_ VDD VSS INV_X1
X_25434_ _07939_ _07940_ _07941_ _01738_ VDD VSS AOI21_X1
X_25435_ _07936_ _07941_ _07933_ _07942_ VDD VSS OR3_X2
X_25436_ _07737_ _07942_ _07943_ VDD VSS NAND2_X1
X_25437_ _04751_ _07871_ _07943_ _07944_ VDD VSS AOI21_X1
X_25438_ _06193_ _04547_ _07563_ _07929_ _07945_ VDD VSS NAND4_X2
X_25439_ _04751_ _07946_ VDD VSS INV_X1
X_25440_ _07670_ _07945_ _07946_ _07947_ VDD VSS OAI21_X1
X_25441_ _07944_ _07947_ _07922_ _01739_ VDD VSS AOI21_X1
X_25442_ _06193_ _04547_ _07912_ _07932_ _07948_ VDD VSS NAND4_X2
X_25443_ _07680_ _07948_ _07946_ _07949_ VDD VSS OAI21_X1
X_25444_ cs_registers_i.mcycle_counter_i.counter\[56\] _07871_
+ _07949_ _07950_ VDD VSS AOI21_X1
X_25445_ _04751_ cs_registers_i.mcycle_counter_i.counter\[56\]
+ _07951_ VDD VSS NAND2_X1
X_25446_ _07677_ _07938_ _07951_ _07952_ VDD VSS OAI21_X1
X_25447_ _07950_ _07952_ _07922_ _01740_ VDD VSS AOI21_X1
X_25448_ _07680_ _07942_ _07951_ _07953_ VDD VSS OAI21_X1
X_25449_ cs_registers_i.mcycle_counter_i.counter\[57\] _07871_
+ _07953_ _07954_ VDD VSS AOI21_X1
X_25450_ _04751_ cs_registers_i.mcycle_counter_i.counter\[56\]
+ cs_registers_i.mcycle_counter_i.counter\[57\] _07955_ VDD
+ VSS NAND3_X1
X_25451_ _07690_ _07945_ _07955_ _07956_ VDD VSS OAI21_X1
X_25452_ _07954_ _07956_ _07922_ _01741_ VDD VSS AOI21_X1
X_25453_ _07680_ _07948_ _07955_ _07957_ VDD VSS OAI21_X1
X_25454_ cs_registers_i.mcycle_counter_i.counter\[58\] _07871_
+ _07957_ _07958_ VDD VSS AOI21_X1
X_25455_ cs_registers_i.mcycle_counter_i.counter\[58\] _07959_
+ VDD VSS INV_X1
X_25456_ _07959_ _07955_ _07960_ VDD VSS OR2_X1
X_25457_ _07697_ _07938_ _07960_ _07961_ VDD VSS OAI21_X1
X_25458_ _07958_ _07961_ _07922_ _01742_ VDD VSS AOI21_X1
X_25459_ _07680_ _07942_ _07960_ _07962_ VDD VSS OAI21_X1
X_25460_ cs_registers_i.mcycle_counter_i.counter\[59\] _07757_
+ _07962_ _07963_ VDD VSS AOI21_X1
X_25461_ _07526_ _07709_ _07964_ VDD VSS NAND2_X1
X_25462_ _07959_ _07955_ _07965_ VDD VSS NOR2_X1
X_25463_ cs_registers_i.mcycle_counter_i.counter\[59\] _07965_
+ _07966_ VDD VSS NAND2_X1
X_25464_ _07964_ _07945_ _07966_ _07967_ VDD VSS OAI21_X1
X_25465_ _07963_ _07967_ _07922_ _01743_ VDD VSS AOI21_X1
X_25466_ _07504_ _07773_ _07968_ VDD VSS NAND2_X1
X_25467_ _07968_ _07810_ _07711_ _07969_ VDD VSS OAI21_X1
X_25468_ _07507_ _07540_ _07596_ _07970_ VDD VSS OAI21_X1
X_25469_ _07559_ _07969_ _07970_ _07772_ _01744_ VDD VSS AOI22_X1
X_25470_ _07502_ _07948_ _07966_ _07971_ VDD VSS OAI21_X1
X_25471_ cs_registers_i.mcycle_counter_i.counter\[60\] _07757_
+ _07971_ _07972_ VDD VSS AOI21_X1
X_25472_ cs_registers_i.mcycle_counter_i.counter\[59\] _07965_
+ _07973_ VDD VSS AND2_X1
X_25473_ cs_registers_i.mcycle_counter_i.counter\[60\] _07973_
+ _07974_ VDD VSS NAND2_X1
X_25474_ _07719_ _07938_ _07974_ _07975_ VDD VSS OAI21_X1
X_25475_ _07972_ _07975_ _07922_ _01745_ VDD VSS AOI21_X1
X_25476_ _07502_ _07942_ _07974_ _07976_ VDD VSS OAI21_X1
X_25477_ cs_registers_i.mcycle_counter_i.counter\[61\] _07757_
+ _07976_ _07977_ VDD VSS AOI21_X1
X_25478_ cs_registers_i.mcycle_counter_i.counter\[60\] _07973_
+ _07978_ VDD VSS AND2_X1
X_25479_ cs_registers_i.mcycle_counter_i.counter\[61\] _07978_
+ _07979_ VDD VSS NAND2_X1
X_25480_ _07729_ _07945_ _07979_ _07980_ VDD VSS OAI21_X1
X_25481_ _07977_ _07980_ _07922_ _01746_ VDD VSS AOI21_X1
X_25482_ _07502_ _07948_ _07979_ _07981_ VDD VSS OAI21_X1
X_25483_ cs_registers_i.mcycle_counter_i.counter\[62\] _07757_
+ _07981_ _07982_ VDD VSS AOI21_X1
X_25484_ _07745_ _07983_ VDD VSS BUF_X4
X_25485_ _07526_ _07983_ _07984_ VDD VSS NAND2_X1
X_25486_ cs_registers_i.mcycle_counter_i.counter\[61\] cs_registers_i.mcycle_counter_i.counter\[62\]
+ _07978_ _07985_ VDD VSS NAND3_X1
X_25487_ _07984_ _07938_ _07985_ _07986_ VDD VSS OAI21_X1
X_25488_ _07982_ _07986_ _07922_ _01747_ VDD VSS AOI21_X1
X_25489_ _07502_ _07942_ _07985_ _07987_ VDD VSS OAI21_X1
X_25490_ cs_registers_i.mcycle_counter_i.counter\[63\] _07757_
+ _07987_ _07988_ VDD VSS AOI21_X1
X_25491_ _07942_ _07985_ _07989_ VDD VSS NOR2_X1
X_25492_ cs_registers_i.mcycle_counter_i.counter\[63\] _07528_
+ _07989_ _07990_ VDD VSS NAND3_X1
X_25493_ _07749_ _07990_ _07991_ VDD VSS NAND2_X1
X_25494_ _07988_ _07991_ _07758_ _01748_ VDD VSS AOI21_X1
X_25495_ _07636_ _07814_ _07992_ VDD VSS NAND2_X1
X_25496_ _05606_ _07993_ VDD VSS INV_X1
X_25497_ _07822_ _07992_ _07993_ _07994_ VDD VSS OAI21_X1
X_25498_ _07507_ _07814_ _07526_ _07995_ VDD VSS OAI21_X1
X_25499_ _07559_ _07994_ _07995_ _07993_ _01749_ VDD VSS AOI22_X1
X_25500_ _05606_ _05628_ _07636_ _07773_ _07996_ VDD VSS NAND4_X1
X_25501_ _07509_ _07829_ _07996_ _07997_ VDD VSS AOI21_X1
X_25502_ _07504_ _07541_ _07993_ _07998_ VDD VSS OAI21_X1
X_25503_ _05628_ _07546_ _07998_ _07999_ VDD VSS AOI21_X1
X_25504_ _07997_ _07999_ _01750_ VDD VSS NOR2_X1
X_25505_ _05606_ _05628_ _07814_ _08000_ VDD VSS NAND3_X1
X_25506_ _07636_ _08000_ _08001_ VDD VSS NAND2_X1
X_25507_ cs_registers_i.mcycle_counter_i.counter\[8\] _07507_
+ _08001_ _08002_ VDD VSS AOI21_X1
X_25508_ _07845_ _07992_ _07518_ _08003_ VDD VSS OAI21_X1
X_25509_ _08002_ _08003_ _07560_ _01751_ VDD VSS AOI21_X1
X_25510_ _07518_ _07541_ _08004_ VDD VSS OR2_X1
X_25511_ _07636_ _08004_ _08005_ VDD VSS NAND2_X1
X_25512_ cs_registers_i.mcycle_counter_i.counter\[9\] _07507_
+ _08005_ _08006_ VDD VSS AOI21_X1
X_25513_ _07517_ _07513_ _08004_ _08007_ VDD VSS OR3_X1
X_25514_ _08007_ _07854_ _07711_ _08008_ VDD VSS OAI21_X1
X_25515_ _08006_ _08008_ _07560_ _01752_ VDD VSS AOI21_X1
X_25516_ _05241_ _05292_ _05303_ _05286_ _08009_ VDD VSS NOR4_X1
X_25517_ _05241_ _05292_ _05286_ _08010_ VDD VSS NOR3_X1
X_25518_ _03398_ _03399_ _08011_ VDD VSS NAND2_X1
X_25519_ _08009_ _08010_ _08011_ _08012_ VDD VSS AOI21_X1
X_25520_ _05241_ _05304_ _08013_ VDD VSS NAND2_X1
X_25521_ _08012_ _08013_ _05311_ _05286_ _05282_ _08014_ VDD
+ VSS OAI221_X1
X_25522_ _05241_ _05311_ _05297_ _08015_ VDD VSS AND3_X1
X_25523_ _05283_ _05297_ _08016_ VDD VSS NAND2_X1
X_25524_ _05292_ _08011_ _08016_ _08017_ VDD VSS NOR3_X1
X_25525_ net273 _05289_ _08016_ _08018_ VDD VSS NOR3_X1
X_25526_ _08015_ _08017_ _08018_ _08019_ VDD VSS OR3_X1
X_25527_ _10895_ _05316_ _08020_ VDD VSS NAND2_X1
X_25528_ _03645_ _08014_ _08019_ _08020_ _08021_ VDD VSS NOR4_X1
X_25529_ _05315_ _08021_ _06248_ _08022_ VDD VSS MUX2_X1
X_25530_ _10332_ _05314_ _05316_ _06249_ _08023_ VDD VSS OAI22_X2
X_25531_ _03886_ _08022_ _08023_ _08024_ VDD VSS OAI21_X2
X_25532_ _15846_ _15860_ _08025_ VDD VSS XNOR2_X1
X_25533_ _11066_ _15853_ _08026_ VDD VSS NOR2_X1
X_25534_ _11066_ _03594_ _08025_ _08026_ _08027_ VDD VSS AOI22_X2
X_25535_ _15509_ _15513_ _15841_ _08027_ _08028_ VDD VSS OR4_X4
X_25536_ _07617_ _07619_ _08028_ _08029_ VDD VSS OR3_X2
X_25537_ _03435_ _01159_ _08030_ VDD VSS NAND2_X1
X_25538_ _10742_ _03471_ _03608_ _08031_ VDD VSS NOR3_X2
X_25539_ _06262_ _06272_ _08030_ _08031_ _08032_ VDD VSS NOR4_X4
X_25540_ _07484_ _03485_ _03487_ _08033_ VDD VSS AOI21_X1
X_25541_ _08033_ _03603_ _04608_ _08034_ VDD VSS OAI21_X1
X_25542_ _03518_ _08034_ _08035_ VDD VSS NAND2_X1
X_25543_ _03439_ _08032_ _08035_ _08036_ VDD VSS AND3_X1
X_25544_ _08024_ _08029_ _08036_ _08037_ VDD VSS AND3_X1
X_25545_ _08037_ _08038_ VDD VSS CLKBUF_X3
X_25546_ _08029_ _08039_ VDD VSS INV_X1
X_25547_ _04756_ _08039_ _08040_ VDD VSS AND2_X1
X_25548_ _08040_ _08041_ VDD VSS BUF_X2
X_25549_ cs_registers_i.mhpmcounter\[2\]\[0\] _08038_ _08041_
+ _08042_ VDD VSS OR3_X1
X_25550_ _07487_ _08028_ _08043_ VDD VSS OR2_X2
X_25551_ _07511_ _08043_ _08044_ VDD VSS OR2_X2
X_25552_ _05745_ _08044_ _08045_ VDD VSS NOR2_X4
X_25553_ _08045_ _08046_ VDD VSS CLKBUF_X3
X_25554_ _08046_ _08047_ VDD VSS CLKBUF_X3
X_25555_ _07511_ _08043_ _08048_ VDD VSS NOR2_X4
X_25556_ net303 _06251_ _05314_ _05338_ _08049_ VDD VSS AOI211_X2
X_25557_ _03439_ _04261_ _08032_ _08050_ VDD VSS NAND3_X4
X_25558_ _08048_ _08049_ _08050_ _08051_ VDD VSS NOR3_X2
X_25559_ _08051_ _08052_ VDD VSS CLKBUF_X3
X_25560_ _07482_ _08047_ _08052_ _05356_ _08053_ VDD VSS AOI22_X1
X_25561_ _08042_ _08053_ _01753_ VDD VSS AND2_X1
X_25562_ _04558_ _08048_ _08054_ VDD VSS NAND2_X2
X_25563_ _08054_ _08055_ VDD VSS CLKBUF_X3
X_25564_ _07525_ _08055_ _08056_ VDD VSS NOR2_X1
X_25565_ _05750_ _08054_ _08057_ VDD VSS NAND2_X1
X_25566_ _05607_ cs_registers_i.mhpmcounter\[2\]\[7\] cs_registers_i.mhpmcounter\[2\]\[8\]
+ cs_registers_i.mhpmcounter\[2\]\[9\] _08058_ VDD VSS AND4_X1
X_25567_ cs_registers_i.mhpmcounter\[2\]\[2\] _15532_ cs_registers_i.mhpmcounter\[2\]\[3\]
+ _08059_ VDD VSS AND3_X1
X_25568_ _08059_ _08060_ VDD VSS BUF_X2
X_25569_ _05538_ cs_registers_i.mhpmcounter\[2\]\[5\] _08061_
+ VDD VSS AND2_X1
X_25570_ _08060_ _08061_ _08062_ VDD VSS AND2_X1
X_25571_ _08058_ _08062_ _08063_ VDD VSS AND2_X1
X_25572_ _08057_ _08063_ _08038_ _08064_ VDD VSS AOI21_X1
X_25573_ _05750_ _08065_ VDD VSS INV_X1
X_25574_ _08058_ _08061_ _08066_ VDD VSS AND2_X1
X_25575_ _08065_ _08052_ _08060_ _08066_ _08067_ VDD VSS AND4_X1
X_25576_ _08056_ _08064_ _08067_ _01754_ VDD VSS OR3_X1
X_25577_ _05789_ _08046_ _08068_ VDD VSS NOR2_X1
X_25578_ cs_registers_i.mhpmcounter\[2\]\[1\] cs_registers_i.mhpmcounter\[2\]\[2\]
+ cs_registers_i.mhpmcounter\[2\]\[0\] _08069_ VDD VSS AND3_X1
X_25579_ cs_registers_i.mhpmcounter\[2\]\[3\] _08069_ _08070_
+ VDD VSS AND2_X1
X_25580_ _05750_ _08058_ _08061_ _08070_ _08071_ VDD VSS AND4_X1
X_25581_ _08024_ _08029_ _08036_ _08071_ _08072_ VDD VSS NAND4_X1
X_25582_ _05789_ _08068_ _08072_ _08073_ VDD VSS MUX2_X1
X_25583_ _08073_ _08047_ _07535_ _01755_ VDD VSS AOI21_X1
X_25584_ cs_registers_i.mhpmcounter\[2\]\[12\] _08046_ _08074_
+ VDD VSS OR2_X1
X_25585_ _05789_ _05750_ _08058_ _08062_ _08075_ VDD VSS AND4_X1
X_25586_ _08074_ _08075_ _08037_ _08076_ VDD VSS AOI21_X1
X_25587_ cs_registers_i.mhpmcounter\[2\]\[12\] _05789_ _05750_
+ _08066_ _08077_ VDD VSS AND4_X1
X_25588_ _08060_ _08077_ _08078_ VDD VSS AND2_X1
X_25589_ _08076_ _08078_ _08038_ _08041_ _07554_ _01756_ VDD
+ VSS AOI221_X1
X_25590_ _07569_ _08054_ _08079_ VDD VSS NOR2_X1
X_25591_ _08070_ _08080_ VDD VSS BUF_X2
X_25592_ _05878_ _08051_ _08080_ _08077_ _08081_ VDD VSS AND4_X1
X_25593_ _08052_ _08080_ _08077_ _08082_ VDD VSS NAND3_X1
X_25594_ _08046_ _08083_ VDD VSS CLKBUF_X3
X_25595_ _05878_ _08083_ _08084_ VDD VSS NOR2_X1
X_25596_ _08079_ _08081_ _08082_ _08084_ _01757_ VDD VSS AOI211_X2
X_25597_ cs_registers_i.mhpmcounter\[2\]\[14\] _08046_ _08085_
+ VDD VSS OR2_X1
X_25598_ _08060_ _08077_ _08086_ VDD VSS NAND2_X1
X_25599_ _08048_ net400 _08050_ _08086_ _08087_ VDD VSS NOR4_X2
X_25600_ _08085_ _08087_ _05878_ _08088_ VDD VSS AOI21_X1
X_25601_ _07579_ _08089_ VDD VSS INV_X1
X_25602_ _05878_ _08087_ _08090_ VDD VSS AND2_X1
X_25603_ _08088_ _08047_ _08089_ cs_registers_i.mhpmcounter\[2\]\[14\]
+ _08090_ _01758_ VDD VSS AOI221_X1
X_25604_ cs_registers_i.mhpmcounter\[2\]\[15\] _08046_ _08091_
+ VDD VSS OR2_X1
X_25605_ _05878_ cs_registers_i.mhpmcounter\[2\]\[14\] _08092_
+ VDD VSS AND2_X1
X_25606_ _08080_ _08077_ _08092_ _08093_ VDD VSS AND3_X1
X_25607_ _08091_ _08093_ _08037_ _08094_ VDD VSS AOI21_X1
X_25608_ cs_registers_i.mhpmcounter\[2\]\[15\] _08080_ _08077_
+ _08092_ _08095_ VDD VSS AND4_X1
X_25609_ _08094_ _08095_ _08038_ _08041_ _07585_ _01759_ VDD
+ VSS AOI221_X1
X_25610_ cs_registers_i.mhpmcounter\[2\]\[16\] _08045_ _08096_
+ VDD VSS OR2_X1
X_25611_ cs_registers_i.mhpmcounter\[2\]\[15\] _08092_ _08097_
+ VDD VSS AND2_X1
X_25612_ _08096_ _08097_ _08087_ _08098_ VDD VSS AOI21_X1
X_25613_ cs_registers_i.mhpmcounter\[2\]\[16\] _08078_ _08097_
+ _08099_ VDD VSS AND3_X1
X_25614_ _07600_ _08100_ VDD VSS INV_X1
X_25615_ _08098_ _08099_ _08038_ _08041_ _08100_ _01760_ VDD
+ VSS AOI221_X1
X_25616_ cs_registers_i.mhpmcounter\[2\]\[16\] _08070_ _08077_
+ _08097_ _08101_ VDD VSS AND4_X1
X_25617_ _08101_ _08102_ VDD VSS INV_X1
X_25618_ _08048_ net401 _08050_ _08102_ _08103_ VDD VSS NOR4_X4
X_25619_ _06038_ _08046_ _08103_ _08104_ VDD VSS NOR3_X1
X_25620_ _08103_ _08105_ VDD VSS BUF_X4
X_25621_ _08104_ _08083_ _07605_ _06038_ _08105_ _01761_ VDD
+ VSS AOI221_X1
X_25622_ _06095_ _08055_ _08106_ VDD VSS NAND2_X1
X_25623_ cs_registers_i.mhpmcounter\[2\]\[16\] _08078_ _08097_
+ _08107_ VDD VSS NAND3_X4
X_25624_ _08048_ net400 _08050_ _08107_ _08108_ VDD VSS NOR4_X4
X_25625_ _06038_ _08108_ _08109_ VDD VSS AND2_X1
X_25626_ _06038_ _08110_ VDD VSS INV_X1
X_25627_ _08110_ _06095_ _08048_ _08107_ _08111_ VDD VSS NOR4_X1
X_25628_ _08048_ _08112_ VDD VSS CLKBUF_X3
X_25629_ _08111_ _08112_ _07914_ _08113_ VDD VSS AOI21_X1
X_25630_ _08083_ _08052_ _08114_ VDD VSS NOR2_X2
X_25631_ _08106_ _08109_ _08113_ _08114_ _01762_ VDD VSS OAI22_X1
X_25632_ _07624_ _08047_ _08115_ VDD VSS AND2_X1
X_25633_ _06124_ _08046_ _08116_ VDD VSS OR2_X1
X_25634_ _06038_ _06095_ _08117_ VDD VSS AND2_X1
X_25635_ _08116_ _08117_ _08105_ _08118_ VDD VSS AOI21_X1
X_25636_ _06124_ _08105_ _08117_ _08119_ VDD VSS AND3_X1
X_25637_ _08115_ _08118_ _08119_ _01763_ VDD VSS NOR3_X1
X_25638_ cs_registers_i.mhpmcounter\[2\]\[1\] _08038_ _08041_
+ _08120_ VDD VSS OR3_X1
X_25639_ _15533_ _08121_ VDD VSS INV_X1
X_25640_ _07635_ _08047_ _08052_ _08121_ _08122_ VDD VSS AOI22_X1
X_25641_ _08120_ _08122_ _01764_ VDD VSS AND2_X1
X_25642_ cs_registers_i.mhpmcounter\[2\]\[20\] _08055_ _08123_
+ VDD VSS NAND2_X1
X_25643_ _06124_ _08108_ _08117_ _08124_ VDD VSS AND3_X1
X_25644_ _08044_ _08125_ VDD VSS CLKBUF_X3
X_25645_ _07640_ _08125_ _08126_ VDD VSS NOR2_X1
X_25646_ _06124_ _08117_ _08127_ VDD VSS NAND2_X1
X_25647_ cs_registers_i.mhpmcounter\[2\]\[20\] _08107_ _08127_
+ _08128_ VDD VSS NOR3_X1
X_25648_ _08125_ _08129_ VDD VSS CLKBUF_X3
X_25649_ _08126_ _08128_ _08129_ _08130_ VDD VSS AOI21_X1
X_25650_ _08123_ _08124_ _08130_ _08114_ _01765_ VDD VSS OAI22_X1
X_25651_ cs_registers_i.mhpmcounter\[2\]\[21\] _08045_ _08131_
+ VDD VSS OR2_X1
X_25652_ _06038_ _06095_ _06124_ cs_registers_i.mhpmcounter\[2\]\[20\]
+ _08132_ VDD VSS AND4_X2
X_25653_ _08131_ _08132_ _08105_ _08133_ VDD VSS AOI21_X1
X_25654_ _08103_ _08132_ _08134_ VDD VSS AND2_X1
X_25655_ _08133_ _08083_ _07651_ cs_registers_i.mhpmcounter\[2\]\[21\]
+ _08134_ _01766_ VDD VSS AOI221_X1
X_25656_ cs_registers_i.mhpmcounter\[2\]\[22\] _08045_ _08135_
+ VDD VSS OR2_X1
X_25657_ cs_registers_i.mhpmcounter\[2\]\[21\] _08132_ _08136_
+ VDD VSS AND2_X1
X_25658_ _08135_ _08136_ _08108_ _08137_ VDD VSS AOI21_X1
X_25659_ _08108_ _08136_ _08138_ VDD VSS AND2_X1
X_25660_ _08137_ _08083_ _07656_ cs_registers_i.mhpmcounter\[2\]\[22\]
+ _08138_ _01767_ VDD VSS AOI221_X1
X_25661_ _04759_ _08045_ _08139_ VDD VSS OR2_X1
X_25662_ cs_registers_i.mhpmcounter\[2\]\[21\] cs_registers_i.mhpmcounter\[2\]\[22\]
+ _08140_ VDD VSS AND2_X1
X_25663_ _08132_ _08140_ _08141_ VDD VSS AND2_X1
X_25664_ _08139_ _08141_ _08105_ _08142_ VDD VSS AOI21_X1
X_25665_ _08103_ _08141_ _08143_ VDD VSS AND2_X1
X_25666_ _08142_ _08083_ _07669_ _04759_ _08143_ _01768_ VDD
+ VSS AOI221_X1
X_25667_ _04901_ _08055_ _08144_ VDD VSS NAND2_X1
X_25668_ _04759_ _08108_ _08141_ _08145_ VDD VSS AND3_X1
X_25669_ _08048_ _08146_ VDD VSS CLKBUF_X3
X_25670_ _04759_ _08141_ _08147_ VDD VSS NAND2_X1
X_25671_ _04901_ _08146_ _08107_ _08147_ _08148_ VDD VSS NOR4_X1
X_25672_ _07676_ _08149_ VDD VSS INV_X4
X_25673_ _08148_ _08112_ _08149_ _08150_ VDD VSS AOI21_X1
X_25674_ _08144_ _08145_ _08150_ _08114_ _01769_ VDD VSS OAI22_X1
X_25675_ _07689_ _08055_ _08151_ VDD VSS NOR2_X1
X_25676_ cs_registers_i.mhpmcounter\[2\]\[25\] _08152_ VDD
+ VSS INV_X1
X_25677_ _08152_ _08055_ _08153_ VDD VSS NAND2_X1
X_25678_ _04759_ _04901_ _08141_ _08154_ VDD VSS AND3_X1
X_25679_ _08153_ _08154_ _08105_ _08155_ VDD VSS AOI21_X1
X_25680_ cs_registers_i.mhpmcounter\[2\]\[25\] _08105_ _08154_
+ _08156_ VDD VSS AND3_X1
X_25681_ _08151_ _08155_ _08156_ _01770_ VDD VSS NOR3_X1
X_25682_ cs_registers_i.mhpmcounter\[2\]\[26\] _08157_ VDD
+ VSS INV_X1
X_25683_ _08157_ _08054_ _08158_ VDD VSS NAND2_X1
X_25684_ _04759_ _04901_ _08132_ _08140_ _08159_ VDD VSS NAND4_X2
X_25685_ _08152_ _08159_ _08160_ VDD VSS NOR2_X1
X_25686_ _08158_ _08160_ _08108_ _08161_ VDD VSS AOI21_X1
X_25687_ _08152_ _08157_ _08159_ _08162_ VDD VSS NOR3_X2
X_25688_ _07696_ _08163_ VDD VSS BUF_X4
X_25689_ _08161_ _08162_ _08108_ _08047_ _08163_ _01771_ VDD
+ VSS AOI221_X1
X_25690_ cs_registers_i.mhpmcounter\[2\]\[27\] _08055_ _08164_
+ VDD VSS NAND2_X1
X_25691_ _08105_ _08162_ _08165_ VDD VSS AND2_X1
X_25692_ cs_registers_i.mhpmcounter\[2\]\[27\] _08166_ VDD
+ VSS INV_X1
X_25693_ _08166_ _08101_ _08162_ _08167_ VDD VSS NAND3_X1
X_25694_ _07708_ _08167_ _08125_ _08168_ VDD VSS MUX2_X1
X_25695_ _08164_ _08165_ _08168_ _08114_ _01772_ VDD VSS OAI22_X1
X_25696_ _05067_ _08055_ _08169_ VDD VSS NAND2_X1
X_25697_ _08152_ _08157_ _08166_ _08159_ _08170_ VDD VSS NOR4_X2
X_25698_ _08108_ _08170_ _08171_ VDD VSS AND2_X1
X_25699_ _08170_ _08172_ VDD VSS INV_X1
X_25700_ _05067_ _08146_ _08107_ _08172_ _08173_ VDD VSS NOR4_X1
X_25701_ _08173_ _08112_ _07718_ _08174_ VDD VSS AOI21_X1
X_25702_ _08169_ _08171_ _08174_ _08114_ _01773_ VDD VSS OAI22_X1
X_25703_ _05143_ _08045_ _08175_ VDD VSS OR2_X1
X_25704_ _05067_ _08170_ _08176_ VDD VSS AND2_X1
X_25705_ _08175_ _08176_ _08105_ _08177_ VDD VSS AOI21_X1
X_25706_ _08103_ _08176_ _08178_ VDD VSS AND2_X1
X_25707_ _08177_ _08083_ _07727_ _05143_ _08178_ _01774_ VDD
+ VSS AOI221_X1
X_25708_ _04756_ _08039_ _08179_ VDD VSS NAND2_X1
X_25709_ cs_registers_i.mhpmcounter\[2\]\[2\] _07492_ _08179_
+ _08180_ VDD VSS OAI21_X1
X_25710_ cs_registers_i.mhpmcounter\[2\]\[2\] _07493_ _08041_
+ _08181_ VDD VSS MUX2_X1
X_25711_ _15532_ _08038_ _08182_ VDD VSS NAND2_X1
X_25712_ _08180_ _08181_ _08182_ _01775_ VDD VSS MUX2_X1
X_25713_ cs_registers_i.mhpmcounter\[2\]\[30\] _08047_ _08183_
+ VDD VSS NOR2_X1
X_25714_ _04901_ cs_registers_i.mhpmcounter\[2\]\[25\] cs_registers_i.mhpmcounter\[2\]\[26\]
+ cs_registers_i.mhpmcounter\[2\]\[27\] _08184_ VDD VSS NAND4_X1
X_25715_ _08147_ _08184_ _08185_ VDD VSS NOR2_X1
X_25716_ _05067_ _05143_ _08099_ _08185_ _08186_ VDD VSS NAND4_X1
X_25717_ _08024_ _08029_ _08036_ _08187_ VDD VSS NAND3_X1
X_25718_ _08183_ _08186_ _08187_ _08188_ VDD VSS OAI21_X1
X_25719_ _05067_ _05143_ cs_registers_i.mhpmcounter\[2\]\[30\]
+ _08185_ _08189_ VDD VSS NAND4_X1
X_25720_ _08107_ _08189_ _08190_ VDD VSS NOR2_X1
X_25721_ _07983_ _08041_ _08190_ _08038_ _08191_ VDD VSS AOI22_X1
X_25722_ _08188_ _08191_ _01776_ VDD VSS AND2_X1
X_25723_ cs_registers_i.mhpmcounter\[2\]\[31\] _08045_ _08192_
+ VDD VSS OR2_X1
X_25724_ _05067_ _05143_ cs_registers_i.mhpmcounter\[2\]\[30\]
+ _08170_ _08193_ VDD VSS AND4_X1
X_25725_ _08192_ _08193_ _08105_ _08194_ VDD VSS AOI21_X1
X_25726_ _08103_ _08193_ _08195_ VDD VSS AND2_X1
X_25727_ _08194_ _08083_ _07748_ cs_registers_i.mhpmcounter\[2\]\[31\]
+ _08195_ _01777_ VDD VSS AOI221_X1
X_25728_ cs_registers_i.mhpmcounter\[2\]\[31\] _08193_ _08196_
+ VDD VSS AND2_X1
X_25729_ _08099_ _08196_ _08197_ VDD VSS NAND2_X1
X_25730_ _08129_ _08197_ _08198_ VDD VSS NAND2_X1
X_25731_ _04560_ _08043_ _08199_ VDD VSS NOR2_X1
X_25732_ _04558_ _07487_ _08028_ net400 _08050_ _08199_ _08200_
+ VDD VSS OAI33_X1
X_25733_ _08200_ _08201_ VDD VSS BUF_X4
X_25734_ _05352_ _08198_ _08201_ _08202_ VDD VSS AOI21_X1
X_25735_ _08125_ _08203_ VDD VSS CLKBUF_X3
X_25736_ _08146_ _08197_ _08204_ VDD VSS OR2_X1
X_25737_ _05352_ _08205_ VDD VSS INV_X1
X_25738_ _07483_ _08203_ _08204_ _08205_ _08206_ VDD VSS OAI22_X1
X_25739_ _08201_ _08207_ VDD VSS BUF_X4
X_25740_ _08202_ _08206_ _08207_ _01778_ VDD VSS AOI21_X1
X_25741_ _08201_ _08208_ VDD VSS BUF_X8
X_25742_ _08125_ _08209_ VDD VSS CLKBUF_X3
X_25743_ _08101_ _08196_ _08210_ VDD VSS NAND2_X1
X_25744_ _08209_ _08210_ _08205_ _08211_ VDD VSS OAI21_X1
X_25745_ cs_registers_i.mhpmcounter\[2\]\[33\] _08208_ _08211_
+ _08212_ VDD VSS AOI21_X1
X_25746_ _05352_ cs_registers_i.mhpmcounter\[2\]\[33\] _08213_
+ VDD VSS NAND2_X1
X_25747_ _08210_ _08213_ _08214_ VDD VSS NOR2_X1
X_25748_ _08044_ _08215_ VDD VSS CLKBUF_X3
X_25749_ _07635_ _08214_ _08215_ _08216_ VDD VSS MUX2_X1
X_25750_ _08212_ _08216_ _08207_ _01779_ VDD VSS AOI21_X1
X_25751_ _08209_ _08197_ _08213_ _08217_ VDD VSS OAI21_X1
X_25752_ cs_registers_i.mhpmcounter\[2\]\[34\] _08208_ _08217_
+ _08218_ VDD VSS AOI21_X1
X_25753_ _05352_ cs_registers_i.mhpmcounter\[2\]\[33\] cs_registers_i.mhpmcounter\[2\]\[34\]
+ _08219_ VDD VSS NAND3_X1
X_25754_ _07493_ _08203_ _08204_ _08219_ _08220_ VDD VSS OAI22_X1
X_25755_ _08218_ _08220_ _08207_ _01780_ VDD VSS AOI21_X1
X_25756_ _08210_ _08219_ _08221_ VDD VSS OR2_X1
X_25757_ _08129_ _08221_ _08222_ VDD VSS NAND2_X1
X_25758_ _05483_ _08208_ _08222_ _08223_ VDD VSS AOI21_X1
X_25759_ _07791_ _08224_ VDD VSS INV_X1
X_25760_ _08146_ _08221_ _08225_ VDD VSS OR2_X1
X_25761_ _05483_ _08226_ VDD VSS INV_X1
X_25762_ _08224_ _08203_ _08225_ _08226_ _08227_ VDD VSS OAI22_X1
X_25763_ _08223_ _08227_ _08207_ _01781_ VDD VSS AOI21_X1
X_25764_ _08197_ _08219_ _08228_ VDD VSS OR2_X1
X_25765_ _08209_ _08228_ _08226_ _08229_ VDD VSS OAI21_X1
X_25766_ cs_registers_i.mhpmcounter\[2\]\[36\] _08208_ _08229_
+ _08230_ VDD VSS AOI21_X1
X_25767_ _07800_ _08231_ VDD VSS INV_X2
X_25768_ _05483_ cs_registers_i.mhpmcounter\[2\]\[36\] _08232_
+ VDD VSS NAND2_X1
X_25769_ _08048_ _08228_ _08233_ VDD VSS OR2_X1
X_25770_ _08231_ _08203_ _08232_ _08233_ _08234_ VDD VSS OAI22_X1
X_25771_ _08230_ _08234_ _08207_ _01782_ VDD VSS AOI21_X1
X_25772_ _08209_ _08221_ _08232_ _08235_ VDD VSS OAI21_X1
X_25773_ cs_registers_i.mhpmcounter\[2\]\[37\] _08208_ _08235_
+ _08236_ VDD VSS AOI21_X1
X_25774_ _08125_ _08237_ VDD VSS CLKBUF_X3
X_25775_ _05483_ cs_registers_i.mhpmcounter\[2\]\[36\] cs_registers_i.mhpmcounter\[2\]\[37\]
+ _08238_ VDD VSS NAND3_X2
X_25776_ _07810_ _08237_ _08225_ _08238_ _08239_ VDD VSS OAI22_X1
X_25777_ _08236_ _08239_ _08207_ _01783_ VDD VSS AOI21_X1
X_25778_ _08125_ _08240_ VDD VSS CLKBUF_X3
X_25779_ _08240_ _08228_ _08238_ _08241_ VDD VSS OAI21_X1
X_25780_ cs_registers_i.mhpmcounter\[2\]\[38\] _08208_ _08241_
+ _08242_ VDD VSS AOI21_X1
X_25781_ _07821_ _08243_ VDD VSS INV_X1
X_25782_ cs_registers_i.mhpmcounter\[2\]\[38\] _08244_ VDD
+ VSS INV_X1
X_25783_ _08244_ _08238_ _08245_ VDD VSS OR2_X1
X_25784_ _08243_ _08237_ _08233_ _08245_ _08246_ VDD VSS OAI22_X1
X_25785_ _08242_ _08246_ _08207_ _01784_ VDD VSS AOI21_X1
X_25786_ _08201_ _08247_ VDD VSS BUF_X8
X_25787_ _08240_ _08221_ _08245_ _08248_ VDD VSS OAI21_X1
X_25788_ cs_registers_i.mhpmcounter\[2\]\[39\] _08247_ _08248_
+ _08249_ VDD VSS AOI21_X1
X_25789_ _07828_ _08250_ VDD VSS INV_X1
X_25790_ _08244_ _08238_ _08251_ VDD VSS NOR2_X1
X_25791_ cs_registers_i.mhpmcounter\[2\]\[39\] _08251_ _08252_
+ VDD VSS NAND2_X1
X_25792_ _08250_ _08237_ _08225_ _08252_ _08253_ VDD VSS OAI22_X1
X_25793_ _08249_ _08253_ _08207_ _01785_ VDD VSS AOI21_X1
X_25794_ cs_registers_i.mhpmcounter\[2\]\[3\] _08045_ _08254_
+ VDD VSS OR2_X1
X_25795_ _08254_ _08069_ _08037_ _08255_ VDD VSS AOI21_X1
X_25796_ _08255_ _08080_ _08038_ _07791_ _08041_ _01786_ VDD
+ VSS AOI221_X1
X_25797_ _08240_ _08228_ _08252_ _08256_ VDD VSS OAI21_X1
X_25798_ cs_registers_i.mhpmcounter\[2\]\[40\] _08247_ _08256_
+ _08257_ VDD VSS AOI21_X1
X_25799_ cs_registers_i.mhpmcounter\[2\]\[39\] cs_registers_i.mhpmcounter\[2\]\[40\]
+ _08251_ _08258_ VDD VSS NAND3_X1
X_25800_ _07844_ _08237_ _08233_ _08258_ _08259_ VDD VSS OAI22_X1
X_25801_ _08257_ _08259_ _08207_ _01787_ VDD VSS AOI21_X1
X_25802_ _08221_ _08258_ _08260_ VDD VSS OR2_X2
X_25803_ _08129_ _08260_ _08261_ VDD VSS NAND2_X1
X_25804_ _05708_ _08247_ _08261_ _08262_ VDD VSS AOI21_X1
X_25805_ _08146_ _08260_ _08263_ VDD VSS OR2_X1
X_25806_ _05708_ _08264_ VDD VSS INV_X1
X_25807_ _07854_ _08237_ _08263_ _08264_ _08265_ VDD VSS OAI22_X1
X_25808_ _08262_ _08265_ _08207_ _01788_ VDD VSS AOI21_X1
X_25809_ _08228_ _08258_ _08266_ VDD VSS OR2_X2
X_25810_ _08240_ _08266_ _08264_ _08267_ VDD VSS OAI21_X1
X_25811_ cs_registers_i.mhpmcounter\[2\]\[42\] _08247_ _08267_
+ _08268_ VDD VSS AOI21_X1
X_25812_ _05708_ cs_registers_i.mhpmcounter\[2\]\[42\] _08269_
+ VDD VSS NAND2_X1
X_25813_ _08266_ _08269_ _08270_ VDD VSS NOR2_X1
X_25814_ _07525_ _08270_ _08215_ _08271_ VDD VSS MUX2_X1
X_25815_ _08201_ _08272_ VDD VSS BUF_X4
X_25816_ _08268_ _08271_ _08272_ _01789_ VDD VSS AOI21_X1
X_25817_ _08240_ _08260_ _08269_ _08273_ VDD VSS OAI21_X1
X_25818_ cs_registers_i.mhpmcounter\[2\]\[43\] _08247_ _08273_
+ _08274_ VDD VSS AOI21_X1
X_25819_ _07535_ _08275_ VDD VSS INV_X2
X_25820_ cs_registers_i.mhpmcounter\[2\]\[43\] _05708_ cs_registers_i.mhpmcounter\[2\]\[42\]
+ _08276_ VDD VSS NAND3_X1
X_25821_ _08275_ _08237_ _08263_ _08276_ _08277_ VDD VSS OAI22_X1
X_25822_ _08274_ _08277_ _08272_ _01790_ VDD VSS AOI21_X1
X_25823_ _08240_ _08266_ _08276_ _08278_ VDD VSS OAI21_X1
X_25824_ cs_registers_i.mhpmcounter\[2\]\[44\] _08247_ _08278_
+ _08279_ VDD VSS AOI21_X1
X_25825_ cs_registers_i.mhpmcounter\[2\]\[44\] _08280_ VDD
+ VSS INV_X1
X_25826_ _08280_ _08266_ _08276_ _08281_ VDD VSS NOR3_X1
X_25827_ _07554_ _08281_ _08215_ _08282_ VDD VSS MUX2_X1
X_25828_ _08279_ _08282_ _08272_ _01791_ VDD VSS AOI21_X1
X_25829_ _08280_ _08276_ _08283_ VDD VSS OR2_X1
X_25830_ _08240_ _08260_ _08283_ _08284_ VDD VSS OAI21_X1
X_25831_ cs_registers_i.mhpmcounter\[2\]\[45\] _08247_ _08284_
+ _08285_ VDD VSS AOI21_X1
X_25832_ cs_registers_i.mhpmcounter\[2\]\[45\] _08286_ VDD
+ VSS INV_X1
X_25833_ _08286_ _08283_ _08287_ VDD VSS OR2_X1
X_25834_ _07569_ _08237_ _08263_ _08287_ _08288_ VDD VSS OAI22_X1
X_25835_ _08285_ _08288_ _08272_ _01792_ VDD VSS AOI21_X1
X_25836_ _05914_ _08289_ VDD VSS INV_X1
X_25837_ _08266_ _08287_ _08290_ VDD VSS NOR2_X1
X_25838_ _08208_ _08290_ _08112_ _08291_ VDD VSS OAI21_X1
X_25839_ _05914_ _08215_ _08290_ _08292_ VDD VSS NAND3_X1
X_25840_ _08292_ _08237_ _07579_ _08293_ VDD VSS OAI21_X1
X_25841_ _08289_ _08291_ _08293_ _08208_ _01793_ VDD VSS AOI22_X1
X_25842_ _08260_ _08287_ _08294_ VDD VSS NOR2_X1
X_25843_ _05914_ _08294_ _08295_ VDD VSS NAND2_X1
X_25844_ _08129_ _08295_ _08296_ VDD VSS NAND2_X1
X_25845_ _05967_ _08247_ _08296_ _08297_ VDD VSS AOI21_X1
X_25846_ _05914_ _05967_ _08209_ _08294_ _08298_ VDD VSS NAND4_X1
X_25847_ _07585_ _08299_ VDD VSS INV_X2
X_25848_ _08298_ _08203_ _08299_ _08300_ VDD VSS OAI21_X1
X_25849_ _08297_ _08300_ _08272_ _01794_ VDD VSS AOI21_X1
X_25850_ _05914_ _05967_ _08290_ _08301_ VDD VSS NAND3_X1
X_25851_ _08129_ _08301_ _08302_ VDD VSS NAND2_X1
X_25852_ cs_registers_i.mhpmcounter\[2\]\[48\] _08247_ _08302_
+ _08303_ VDD VSS AOI21_X1
X_25853_ cs_registers_i.mhpmcounter\[2\]\[48\] _08304_ VDD
+ VSS INV_X1
X_25854_ _08304_ _08301_ _08305_ VDD VSS NOR2_X1
X_25855_ _08129_ _08305_ _08306_ VDD VSS NAND2_X1
X_25856_ _08306_ _08203_ _07600_ _08307_ VDD VSS OAI21_X1
X_25857_ _08303_ _08307_ _08272_ _01795_ VDD VSS AOI21_X1
X_25858_ cs_registers_i.mhpmcounter\[2\]\[49\] _08308_ VDD
+ VSS INV_X1
X_25859_ _05914_ _05967_ cs_registers_i.mhpmcounter\[2\]\[48\]
+ _08309_ VDD VSS NAND3_X1
X_25860_ _08260_ _08287_ _08309_ _08310_ VDD VSS NOR3_X2
X_25861_ _08208_ _08310_ _08112_ _08311_ VDD VSS OAI21_X1
X_25862_ _07605_ _08312_ VDD VSS BUF_X4
X_25863_ _08312_ _08112_ _08313_ VDD VSS NAND2_X1
X_25864_ cs_registers_i.mhpmcounter\[2\]\[49\] _08310_ _08314_
+ VDD VSS NAND2_X2
X_25865_ _08313_ _08314_ _08112_ _08315_ VDD VSS OAI21_X1
X_25866_ _08308_ _08311_ _08315_ _08208_ _01796_ VDD VSS AOI22_X1
X_25867_ _08231_ _08055_ _08316_ VDD VSS NOR2_X1
X_25868_ _05538_ _08046_ _08317_ VDD VSS OR2_X1
X_25869_ _08317_ _08060_ _08038_ _08318_ VDD VSS AOI21_X1
X_25870_ _05538_ _08052_ _08060_ _08319_ VDD VSS AND3_X1
X_25871_ _08316_ _08318_ _08319_ _01797_ VDD VSS NOR3_X1
X_25872_ cs_registers_i.mhpmcounter\[2\]\[49\] _08305_ _08320_
+ VDD VSS NAND2_X2
X_25873_ _08129_ _08320_ _08321_ VDD VSS NAND2_X1
X_25874_ _06092_ _08247_ _08321_ _08322_ VDD VSS AOI21_X1
X_25875_ _08146_ _08320_ _08323_ VDD VSS NOR2_X1
X_25876_ _07616_ _08112_ _08323_ _06092_ _08324_ VDD VSS AOI22_X1
X_25877_ _08324_ _08325_ VDD VSS INV_X1
X_25878_ _08322_ _08325_ _08272_ _01798_ VDD VSS AOI21_X1
X_25879_ _08201_ _08326_ VDD VSS BUF_X8
X_25880_ _06092_ _08327_ VDD VSS INV_X1
X_25881_ _08240_ _08314_ _08327_ _08328_ VDD VSS OAI21_X1
X_25882_ cs_registers_i.mhpmcounter\[2\]\[51\] _08326_ _08328_
+ _08329_ VDD VSS AOI21_X1
X_25883_ _06092_ cs_registers_i.mhpmcounter\[2\]\[51\] _08330_
+ VDD VSS NAND2_X1
X_25884_ _08314_ _08330_ _08331_ VDD VSS NOR2_X1
X_25885_ _07624_ _08331_ _08215_ _08332_ VDD VSS MUX2_X1
X_25886_ _08329_ _08332_ _08272_ _01799_ VDD VSS AOI21_X1
X_25887_ _08240_ _08320_ _08330_ _08333_ VDD VSS OAI21_X1
X_25888_ cs_registers_i.mhpmcounter\[2\]\[52\] _08326_ _08333_
+ _08334_ VDD VSS AOI21_X1
X_25889_ _06092_ cs_registers_i.mhpmcounter\[2\]\[51\] cs_registers_i.mhpmcounter\[2\]\[52\]
+ _08335_ VDD VSS NAND3_X1
X_25890_ _08335_ _08336_ VDD VSS INV_X1
X_25891_ _07640_ _08112_ _08323_ _08336_ _08337_ VDD VSS AOI22_X1
X_25892_ _08337_ _08338_ VDD VSS INV_X1
X_25893_ _08334_ _08338_ _08272_ _01800_ VDD VSS AOI21_X1
X_25894_ _08314_ _08335_ _08339_ VDD VSS NOR2_X1
X_25895_ _08146_ _08339_ _08340_ VDD VSS OR2_X1
X_25896_ _06194_ _08326_ _08340_ _08341_ VDD VSS AOI21_X1
X_25897_ _06194_ _08129_ _08339_ _08342_ VDD VSS NAND3_X1
X_25898_ _07651_ _08343_ VDD VSS INV_X2
X_25899_ _08342_ _08203_ _08343_ _08344_ VDD VSS OAI21_X1
X_25900_ _08341_ _08344_ _08272_ _01801_ VDD VSS AOI21_X1
X_25901_ _06194_ _08345_ VDD VSS INV_X1
X_25902_ _07511_ _07487_ _08028_ _08320_ _08335_ _08345_ _08346_
+ VDD VSS OAI33_X1
X_25903_ cs_registers_i.mhpmcounter\[2\]\[54\] _08326_ _08346_
+ _08347_ VDD VSS AOI21_X1
X_25904_ _06194_ cs_registers_i.mhpmcounter\[2\]\[54\] _08336_
+ _08348_ VDD VSS NAND3_X1
X_25905_ _08320_ _08348_ _08349_ VDD VSS NOR2_X1
X_25906_ _07657_ _08349_ _08215_ _08350_ VDD VSS MUX2_X1
X_25907_ _08201_ _08351_ VDD VSS BUF_X4
X_25908_ _08347_ _08350_ _08351_ _01802_ VDD VSS AOI21_X1
X_25909_ _08314_ _08348_ _08352_ VDD VSS OR2_X1
X_25910_ _08129_ _08352_ _08353_ VDD VSS NAND2_X1
X_25911_ _04754_ _08326_ _08353_ _08354_ VDD VSS AOI21_X1
X_25912_ _07669_ _08355_ VDD VSS INV_X2
X_25913_ _08146_ _08352_ _08356_ VDD VSS OR2_X1
X_25914_ _04754_ _08357_ VDD VSS INV_X1
X_25915_ _08355_ _08237_ _08356_ _08357_ _08358_ VDD VSS OAI22_X1
X_25916_ _08354_ _08358_ _08351_ _01803_ VDD VSS AOI21_X1
X_25917_ _04754_ _08349_ _08359_ VDD VSS NAND2_X1
X_25918_ _08209_ _08359_ _08360_ VDD VSS NAND2_X1
X_25919_ _04899_ _08326_ _08360_ _08361_ VDD VSS AOI21_X1
X_25920_ _04754_ _04899_ _08209_ _08349_ _08362_ VDD VSS NAND4_X1
X_25921_ _08362_ _08203_ _08149_ _08363_ VDD VSS OAI21_X1
X_25922_ _08361_ _08363_ _08351_ _01804_ VDD VSS AOI21_X1
X_25923_ _04754_ _04899_ _08364_ VDD VSS NAND2_X1
X_25924_ _08240_ _08352_ _08364_ _08365_ VDD VSS OAI21_X1
X_25925_ cs_registers_i.mhpmcounter\[2\]\[57\] _08326_ _08365_
+ _08366_ VDD VSS AOI21_X1
X_25926_ _04754_ _04899_ cs_registers_i.mhpmcounter\[2\]\[57\]
+ _08367_ VDD VSS NAND3_X1
X_25927_ _07689_ _08237_ _08356_ _08367_ _08368_ VDD VSS OAI22_X1
X_25928_ _08366_ _08368_ _08351_ _01805_ VDD VSS AOI21_X1
X_25929_ _08320_ _08348_ _08367_ _08369_ VDD VSS OR3_X2
X_25930_ _08209_ _08369_ _08370_ VDD VSS NAND2_X1
X_25931_ _05029_ _08326_ _08370_ _08371_ VDD VSS AOI21_X1
X_25932_ _05029_ _08372_ VDD VSS INV_X1
X_25933_ _08372_ _08146_ _08369_ _08373_ VDD VSS NOR3_X1
X_25934_ _08373_ _08112_ _08163_ _08374_ VDD VSS AOI21_X1
X_25935_ _08374_ _08375_ VDD VSS INV_X1
X_25936_ _08371_ _08375_ _08351_ _01806_ VDD VSS AOI21_X1
X_25937_ _08352_ _08367_ _08376_ VDD VSS OR2_X1
X_25938_ _08215_ _08376_ _08372_ _08377_ VDD VSS OAI21_X1
X_25939_ _04781_ _08326_ _08377_ _08378_ VDD VSS AOI21_X1
X_25940_ _05029_ _04781_ _08379_ VDD VSS NAND2_X1
X_25941_ _08376_ _08379_ _08380_ VDD VSS NOR2_X1
X_25942_ _07708_ _08380_ _08125_ _08381_ VDD VSS MUX2_X1
X_25943_ _08378_ _08381_ _08351_ _01807_ VDD VSS AOI21_X1
X_25944_ _08061_ _08080_ _08382_ VDD VSS NAND2_X1
X_25945_ _07810_ _08179_ _08382_ _08187_ _08383_ VDD VSS OAI22_X1
X_25946_ _05538_ _08052_ _08080_ _08384_ VDD VSS NAND3_X1
X_25947_ cs_registers_i.mhpmcounter\[2\]\[5\] _08047_ _08385_
+ VDD VSS NOR2_X1
X_25948_ _08383_ _08384_ _08385_ _01808_ VDD VSS AOI21_X1
X_25949_ _08215_ _08369_ _08379_ _08386_ VDD VSS OAI21_X1
X_25950_ cs_registers_i.mhpmcounter\[2\]\[60\] _08326_ _08386_
+ _08387_ VDD VSS AOI21_X1
X_25951_ _05029_ _04781_ cs_registers_i.mhpmcounter\[2\]\[60\]
+ _08388_ VDD VSS NAND3_X1
X_25952_ _08146_ _08369_ _08388_ _08389_ VDD VSS OR3_X1
X_25953_ _08389_ _08203_ _07718_ _08390_ VDD VSS OAI21_X1
X_25954_ _08387_ _08390_ _08351_ _01809_ VDD VSS AOI21_X1
X_25955_ _08215_ _08376_ _08388_ _08391_ VDD VSS OAI21_X1
X_25956_ cs_registers_i.mhpmcounter\[2\]\[61\] _08201_ _08391_
+ _08392_ VDD VSS AOI21_X1
X_25957_ _05029_ _04781_ cs_registers_i.mhpmcounter\[2\]\[60\]
+ cs_registers_i.mhpmcounter\[2\]\[61\] _08393_ VDD VSS NAND4_X2
X_25958_ _08376_ _08393_ _08394_ VDD VSS NOR2_X1
X_25959_ _07728_ _08394_ _08125_ _08395_ VDD VSS MUX2_X1
X_25960_ _08392_ _08395_ _08351_ _01810_ VDD VSS AOI21_X1
X_25961_ _08215_ _08369_ _08393_ _08396_ VDD VSS OAI21_X1
X_25962_ _05188_ _08201_ _08396_ _08397_ VDD VSS AOI21_X1
X_25963_ _05188_ _08398_ VDD VSS INV_X1
X_25964_ _08398_ _08369_ _08393_ _08399_ VDD VSS NOR3_X1
X_25965_ _07745_ _08399_ _08125_ _08400_ VDD VSS MUX2_X1
X_25966_ _08397_ _08400_ _08351_ _01811_ VDD VSS AOI21_X1
X_25967_ _05188_ _08394_ _08401_ VDD VSS NAND2_X1
X_25968_ _08209_ _08401_ _08402_ VDD VSS NAND2_X1
X_25969_ cs_registers_i.mhpmcounter\[2\]\[63\] _08201_ _08402_
+ _08403_ VDD VSS AOI21_X1
X_25970_ _05188_ cs_registers_i.mhpmcounter\[2\]\[63\] _08209_
+ _08394_ _08404_ VDD VSS NAND4_X1
X_25971_ _07748_ _08405_ VDD VSS INV_X2
X_25972_ _08404_ _08203_ _08405_ _08406_ VDD VSS OAI21_X1
X_25973_ _08403_ _08406_ _08351_ _01812_ VDD VSS AOI21_X1
X_25974_ _05607_ _08045_ _08407_ VDD VSS OR2_X1
X_25975_ _08407_ _08062_ _08037_ _08408_ VDD VSS AOI21_X1
X_25976_ _08051_ _08060_ _08061_ _08409_ VDD VSS AND3_X1
X_25977_ _08408_ _08083_ _07821_ _05607_ _08409_ _01813_ VDD
+ VSS AOI221_X2
X_25978_ cs_registers_i.mhpmcounter\[2\]\[7\] _08046_ _08410_
+ VDD VSS NOR2_X1
X_25979_ _05607_ _08029_ _08061_ _08080_ _08411_ VDD VSS AND4_X1
X_25980_ _08024_ _08036_ _08411_ _08412_ VDD VSS NAND3_X1
X_25981_ cs_registers_i.mhpmcounter\[2\]\[7\] _08410_ _08412_
+ _08413_ VDD VSS MUX2_X1
X_25982_ _08413_ _08047_ _07828_ _01814_ VDD VSS AOI21_X1
X_25983_ _07844_ _08054_ _08414_ VDD VSS NOR2_X1
X_25984_ _05607_ cs_registers_i.mhpmcounter\[2\]\[7\] _08061_
+ _08415_ VDD VSS AND3_X1
X_25985_ cs_registers_i.mhpmcounter\[2\]\[8\] _08051_ _08060_
+ _08415_ _08416_ VDD VSS AND4_X1
X_25986_ _08052_ _08060_ _08415_ _08417_ VDD VSS NAND3_X1
X_25987_ cs_registers_i.mhpmcounter\[2\]\[8\] _08083_ _08418_
+ VDD VSS NOR2_X1
X_25988_ _08414_ _08416_ _08417_ _08418_ _01815_ VDD VSS AOI211_X2
X_25989_ _07854_ _08047_ _08419_ VDD VSS NAND2_X1
X_25990_ cs_registers_i.mhpmcounter\[2\]\[9\] _08420_ VDD
+ VSS INV_X1
X_25991_ cs_registers_i.mhpmcounter\[2\]\[8\] _08415_ _08421_
+ VDD VSS AND2_X1
X_25992_ _08420_ _08052_ _08080_ _08421_ _08422_ VDD VSS NAND4_X1
X_25993_ _08052_ _08080_ _08421_ _08423_ VDD VSS AND3_X1
X_25994_ cs_registers_i.mhpmcounter\[2\]\[9\] _08055_ _08424_
+ VDD VSS NAND2_X1
X_25995_ _08419_ _08422_ _08423_ _08424_ _01816_ VDD VSS OAI211_X2
X_25996_ _06989_ _06291_ _03850_ _08425_ VDD VSS OAI21_X1
X_25997_ _03436_ _03954_ _06293_ _03890_ _08426_ VDD VSS OR4_X2
X_25998_ _11420_ _03890_ _08427_ VDD VSS NOR2_X2
X_25999_ _03880_ _08427_ _08428_ VDD VSS NAND2_X2
X_26000_ _03873_ _08428_ _08429_ VDD VSS AND2_X2
X_26001_ _08425_ _08426_ _08429_ _08430_ VDD VSS AND3_X1
X_26002_ _03462_ cs_registers_i.mstack_d\[0\] _03924_ _08431_
+ VDD VSS MUX2_X1
X_26003_ _03927_ _08431_ _08432_ VDD VSS NOR2_X1
X_26004_ cs_registers_i.dcsr_q\[0\] _06803_ _08433_ VDD VSS
+ NOR2_X1
X_26005_ _08430_ _08432_ _08433_ _01817_ VDD VSS OAI21_X1
X_26006_ _03463_ cs_registers_i.mstack_d\[1\] _03924_ _08434_
+ VDD VSS MUX2_X1
X_26007_ _03927_ _08434_ _08435_ VDD VSS NOR2_X1
X_26008_ cs_registers_i.dcsr_q\[1\] _06803_ _08436_ VDD VSS
+ NOR2_X1
X_26009_ _08430_ _08435_ _08436_ _01818_ VDD VSS OAI21_X1
X_26010_ _08426_ _08428_ _08437_ VDD VSS NAND2_X2
X_26011_ _08437_ _08438_ VDD VSS CLKBUF_X3
X_26012_ _03462_ _08438_ _08439_ VDD VSS NAND2_X1
X_26013_ net249 _07489_ _08440_ VDD VSS AND2_X1
X_26014_ _08440_ _08441_ VDD VSS CLKBUF_X3
X_26015_ _07482_ _07635_ _08441_ _08442_ VDD VSS NAND3_X1
X_26016_ _08442_ _08441_ cs_registers_i.dcsr_q\[0\] _08443_
+ VDD VSS OAI21_X1
X_26017_ _08439_ _08443_ _08438_ _01819_ VDD VSS OAI21_X1
X_26018_ cs_registers_i.dcsr_q\[11\] _08275_ _08441_ _01820_
+ VDD VSS MUX2_X1
X_26019_ _07554_ _08444_ VDD VSS INV_X1
X_26020_ cs_registers_i.dcsr_q\[12\] _08444_ _08441_ _01821_
+ VDD VSS MUX2_X1
X_26021_ cs_registers_i.dcsr_q\[13\] _07569_ _08441_ _01822_
+ VDD VSS MUX2_X1
X_26022_ cs_registers_i.dcsr_q\[15\] _08299_ _08441_ _01823_
+ VDD VSS MUX2_X1
X_26023_ _03463_ _08438_ _08445_ VDD VSS NAND2_X1
X_26024_ _08442_ _08441_ cs_registers_i.dcsr_q\[1\] _08446_
+ VDD VSS OAI21_X1
X_26025_ _08445_ _08446_ _08438_ _01824_ VDD VSS OAI21_X1
X_26026_ _03879_ _07493_ _08441_ _01825_ VDD VSS MUX2_X1
X_26027_ _08426_ _08428_ _08447_ VDD VSS AND2_X1
X_26028_ _08447_ _08448_ VDD VSS CLKBUF_X3
X_26029_ cs_registers_i.dcsr_q\[6\] _08449_ VDD VSS INV_X1
X_26030_ _03879_ _08427_ _08448_ _08449_ _01826_ VDD VSS AOI22_X1
X_26031_ cs_registers_i.dcsr_q\[7\] _08426_ _08427_ net60
+ _08450_ VDD VSS AOI22_X1
X_26032_ _08450_ _08427_ _03879_ _01827_ VDD VSS AOI21_X1
X_26033_ cs_registers_i.dcsr_q\[8\] _08451_ VDD VSS INV_X1
X_26034_ _01162_ _08428_ _08438_ _08451_ _01828_ VDD VSS OAI22_X1
X_26035_ _03873_ _08428_ _08452_ VDD VSS NAND2_X2
X_26036_ _08452_ _08453_ VDD VSS BUF_X4
X_26037_ _08453_ _08454_ VDD VSS BUF_X4
X_26038_ cs_registers_i.pc_id_i\[10\] cs_registers_i.pc_if_i\[10\]
+ _08454_ _08455_ VDD VSS MUX2_X1
X_26039_ _08438_ _08455_ _08456_ VDD VSS NAND2_X1
X_26040_ _04968_ _07489_ _08457_ VDD VSS NAND2_X2
X_26041_ _08457_ _08458_ VDD VSS CLKBUF_X3
X_26042_ _08448_ _08457_ _08459_ VDD VSS NAND2_X2
X_26043_ _08459_ _08460_ VDD VSS CLKBUF_X3
X_26044_ cs_registers_i.csr_depc_o\[10\] _08461_ VDD VSS INV_X1
X_26045_ _08456_ _08458_ _07525_ _08460_ _08461_ _01829_ VDD
+ VSS OAI221_X1
X_26046_ cs_registers_i.pc_id_i\[11\] _07178_ _08454_ _08462_
+ VDD VSS MUX2_X1
X_26047_ _08438_ _08462_ _08463_ VDD VSS NAND2_X1
X_26048_ cs_registers_i.csr_depc_o\[11\] _08464_ VDD VSS INV_X1
X_26049_ _08463_ _08458_ _07535_ _08464_ _08460_ _01830_ VDD
+ VSS OAI221_X1
X_26050_ cs_registers_i.pc_id_i\[12\] _07199_ _08454_ _08465_
+ VDD VSS MUX2_X1
X_26051_ _08438_ _08465_ _08466_ VDD VSS NAND2_X1
X_26052_ cs_registers_i.csr_depc_o\[12\] _08467_ VDD VSS INV_X1
X_26053_ _08466_ _08458_ _07554_ _08467_ _08460_ _01831_ VDD
+ VSS OAI221_X1
X_26054_ _04260_ _04539_ _07487_ _08468_ VDD VSS NOR3_X4
X_26055_ _12076_ cs_registers_i.pc_if_i\[13\] _08453_ _08469_
+ VDD VSS MUX2_X1
X_26056_ _08437_ _08470_ VDD VSS CLKBUF_X3
X_26057_ _07569_ _08468_ _08469_ _08470_ _08471_ VDD VSS AOI22_X1
X_26058_ cs_registers_i.csr_depc_o\[13\] _08472_ VDD VSS INV_X1
X_26059_ _08471_ _08460_ _08472_ _01832_ VDD VSS OAI21_X1
X_26060_ _07213_ _08429_ _08473_ VDD VSS NOR2_X1
X_26061_ _08473_ _08429_ _12179_ _08474_ VDD VSS AOI21_X2
X_26062_ _08470_ _08474_ _08475_ VDD VSS NAND2_X1
X_26063_ _08457_ _08476_ VDD VSS CLKBUF_X3
X_26064_ _08475_ _08476_ _07579_ cs_registers_i.csr_depc_o\[14\]
+ _08459_ _08477_ VDD VSS OAI221_X1
X_26065_ _08477_ _01833_ VDD VSS INV_X1
X_26066_ cs_registers_i.pc_id_i\[15\] _07222_ _08454_ _08478_
+ VDD VSS MUX2_X1
X_26067_ _08438_ _08478_ _08479_ VDD VSS NAND2_X1
X_26068_ cs_registers_i.csr_depc_o\[15\] _08480_ VDD VSS INV_X1
X_26069_ _08479_ _08458_ _07585_ _08480_ _08460_ _01834_ VDD
+ VSS OAI221_X1
X_26070_ _12352_ _08453_ _08481_ VDD VSS NOR2_X1
X_26071_ _08481_ _08454_ cs_registers_i.pc_if_i\[16\] _08482_
+ VDD VSS AOI21_X2
X_26072_ _08448_ _08482_ _08483_ VDD VSS NOR2_X1
X_26073_ _08437_ _08468_ _08484_ VDD VSS NOR2_X2
X_26074_ _08483_ _08468_ _07600_ cs_registers_i.csr_depc_o\[16\]
+ _08484_ _08485_ VDD VSS AOI221_X1
X_26075_ _08485_ _01835_ VDD VSS INV_X1
X_26076_ cs_registers_i.pc_id_i\[17\] cs_registers_i.pc_if_i\[17\]
+ _08453_ _08486_ VDD VSS MUX2_X1
X_26077_ _08438_ _08486_ _08487_ VDD VSS NAND2_X1
X_26078_ _08487_ _08458_ _08312_ _06051_ _08460_ _01836_ VDD
+ VSS OAI221_X1
X_26079_ _08437_ _08488_ VDD VSS CLKBUF_X3
X_26080_ cs_registers_i.pc_id_i\[18\] _07235_ _08454_ _08489_
+ VDD VSS MUX2_X2
X_26081_ _08488_ _08489_ _08490_ VDD VSS NAND2_X1
X_26082_ _08459_ _08491_ VDD VSS CLKBUF_X3
X_26083_ _08490_ _08458_ _07616_ _06954_ _08491_ _01837_ VDD
+ VSS OAI221_X1
X_26084_ _08452_ _08492_ VDD VSS BUF_X4
X_26085_ _12590_ _07241_ _08492_ _08493_ VDD VSS MUX2_X1
X_26086_ _08448_ _08493_ _08494_ VDD VSS NOR2_X1
X_26087_ cs_registers_i.csr_depc_o\[19\] _08495_ VDD VSS INV_X1
X_26088_ _08494_ _08468_ _07623_ _08495_ _08484_ _01838_ VDD
+ VSS AOI221_X1
X_26089_ _03981_ _10675_ _08429_ _08496_ VDD VSS MUX2_X1
X_26090_ cs_registers_i.csr_depc_o\[1\] _08457_ _08497_ VDD
+ VSS NAND2_X1
X_26091_ _08497_ _08457_ _07635_ _08498_ VDD VSS OAI21_X1
X_26092_ _08496_ _08498_ _08448_ _01839_ VDD VSS MUX2_X1
X_26093_ _12685_ _07249_ _08453_ _08499_ VDD VSS MUX2_X1
X_26094_ _08448_ _08499_ _08500_ VDD VSS NOR2_X1
X_26095_ cs_registers_i.csr_depc_o\[20\] _08501_ VDD VSS INV_X1
X_26096_ _08500_ _08468_ _07639_ _08501_ _08484_ _01840_ VDD
+ VSS AOI221_X1
X_26097_ cs_registers_i.pc_id_i\[21\] cs_registers_i.pc_if_i\[21\]
+ _08454_ _08502_ VDD VSS MUX2_X2
X_26098_ _08488_ _08502_ _08503_ VDD VSS NAND2_X1
X_26099_ _08503_ _08458_ _07651_ _07000_ _08491_ _01841_ VDD
+ VSS OAI221_X1
X_26100_ cs_registers_i.pc_id_i\[22\] _07259_ _08492_ _08504_
+ VDD VSS MUX2_X2
X_26101_ _08488_ _08504_ _08505_ VDD VSS NAND2_X1
X_26102_ _08505_ _08458_ _07657_ _04540_ _08491_ _01842_ VDD
+ VSS OAI221_X1
X_26103_ _12935_ _07263_ _08492_ _08506_ VDD VSS MUX2_X1
X_26104_ _08488_ _08506_ _08507_ VDD VSS NAND2_X1
X_26105_ cs_registers_i.csr_depc_o\[23\] _08508_ VDD VSS INV_X1
X_26106_ _08507_ _08458_ _07669_ _08508_ _08491_ _01843_ VDD
+ VSS OAI221_X1
X_26107_ _13024_ cs_registers_i.pc_if_i\[24\] _08492_ _08509_
+ VDD VSS MUX2_X1
X_26108_ _08488_ _08509_ _08510_ VDD VSS NAND2_X1
X_26109_ cs_registers_i.csr_depc_o\[24\] _08511_ VDD VSS INV_X1
X_26110_ _08510_ _08458_ _07676_ _08511_ _08491_ _01844_ VDD
+ VSS OAI221_X1
X_26111_ cs_registers_i.pc_id_i\[25\] cs_registers_i.pc_if_i\[25\]
+ _08453_ _08512_ VDD VSS MUX2_X1
X_26112_ _07689_ _08468_ _08512_ _08470_ _08513_ VDD VSS AOI22_X1
X_26113_ cs_registers_i.csr_depc_o\[25\] _08514_ VDD VSS INV_X1
X_26114_ _08513_ _08460_ _08514_ _01845_ VDD VSS OAI21_X1
X_26115_ cs_registers_i.pc_id_i\[26\] _07281_ _08492_ _08515_
+ VDD VSS MUX2_X1
X_26116_ _08488_ _08515_ _08516_ VDD VSS NAND2_X1
X_26117_ _08516_ _08476_ _08163_ _05025_ _08491_ _01846_ VDD
+ VSS OAI221_X1
X_26118_ cs_registers_i.pc_id_i\[27\] _07285_ _08492_ _08517_
+ VDD VSS MUX2_X2
X_26119_ _08488_ _08517_ _08518_ VDD VSS NAND2_X1
X_26120_ cs_registers_i.csr_depc_o\[27\] _08519_ VDD VSS INV_X1
X_26121_ _08518_ _08476_ _07709_ _08519_ _08491_ _01847_ VDD
+ VSS OAI221_X1
X_26122_ cs_registers_i.pc_id_i\[28\] _08429_ _08520_ VDD
+ VSS AND2_X1
X_26123_ _08520_ _08454_ cs_registers_i.pc_if_i\[28\] _08521_
+ VDD VSS AOI21_X2
X_26124_ _08448_ _08521_ _08522_ VDD VSS NOR2_X1
X_26125_ _08522_ _08468_ _07718_ cs_registers_i.csr_depc_o\[28\]
+ _08484_ _08523_ VDD VSS AOI221_X1
X_26126_ _08523_ _01848_ VDD VSS INV_X1
X_26127_ cs_registers_i.pc_id_i\[29\] cs_registers_i.pc_if_i\[29\]
+ _08492_ _08524_ VDD VSS MUX2_X2
X_26128_ _08488_ _08524_ _08525_ VDD VSS NAND2_X1
X_26129_ cs_registers_i.csr_depc_o\[29\] _08526_ VDD VSS INV_X1
X_26130_ _08525_ _08476_ _07728_ _08526_ _08491_ _01849_ VDD
+ VSS OAI221_X1
X_26131_ _15352_ _00012_ _08429_ _08527_ VDD VSS MUX2_X1
X_26132_ _07492_ _08457_ _08527_ _08448_ _08528_ VDD VSS OAI22_X1
X_26133_ _08528_ _08484_ cs_registers_i.csr_depc_o\[2\] _08529_
+ VDD VSS AOI21_X1
X_26134_ _08529_ _01850_ VDD VSS INV_X1
X_26135_ cs_registers_i.pc_id_i\[30\] cs_registers_i.pc_if_i\[30\]
+ _08492_ _08530_ VDD VSS MUX2_X1
X_26136_ _08488_ _08530_ _08531_ VDD VSS NAND2_X1
X_26137_ cs_registers_i.csr_depc_o\[30\] _08532_ VDD VSS INV_X1
X_26138_ _08531_ _08476_ _07983_ _08532_ _08491_ _01851_ VDD
+ VSS OAI221_X1
X_26139_ cs_registers_i.pc_id_i\[31\] cs_registers_i.pc_if_i\[31\]
+ _08453_ _08533_ VDD VSS MUX2_X1
X_26140_ _08488_ _08533_ _08534_ VDD VSS NAND2_X1
X_26141_ cs_registers_i.csr_depc_o\[31\] _08535_ VDD VSS INV_X1
X_26142_ _08534_ _08476_ _07748_ _08535_ _08491_ _01852_ VDD
+ VSS OAI221_X1
X_26143_ _11517_ _07181_ _08453_ _08536_ VDD VSS MUX2_X1
X_26144_ _08470_ _08536_ _08537_ VDD VSS NAND2_X1
X_26145_ cs_registers_i.csr_depc_o\[3\] _08538_ VDD VSS INV_X1
X_26146_ _08537_ _08476_ _07791_ _08538_ _08459_ _01853_ VDD
+ VSS OAI221_X1
X_26147_ cs_registers_i.pc_id_i\[4\] _07186_ _08454_ _08539_
+ VDD VSS MUX2_X1
X_26148_ _08470_ _08539_ _08540_ VDD VSS NAND2_X1
X_26149_ cs_registers_i.csr_depc_o\[4\] _08541_ VDD VSS INV_X1
X_26150_ _08540_ _08476_ _07800_ _08541_ _08459_ _01854_ VDD
+ VSS OAI221_X1
X_26151_ cs_registers_i.pc_id_i\[5\] _07187_ _08454_ _08542_
+ VDD VSS MUX2_X1
X_26152_ _07810_ _08468_ _08542_ _08470_ _08543_ VDD VSS AOI22_X1
X_26153_ cs_registers_i.csr_depc_o\[5\] _08544_ VDD VSS INV_X1
X_26154_ _08543_ _08460_ _08544_ _01855_ VDD VSS OAI21_X1
X_26155_ cs_registers_i.pc_id_i\[6\] cs_registers_i.pc_if_i\[6\]
+ _08492_ _08545_ VDD VSS MUX2_X1
X_26156_ _08470_ _08545_ _08546_ VDD VSS NAND2_X1
X_26157_ cs_registers_i.csr_depc_o\[6\] _08547_ VDD VSS INV_X1
X_26158_ _08546_ _08476_ _07821_ _08547_ _08459_ _01856_ VDD
+ VSS OAI221_X1
X_26159_ cs_registers_i.pc_id_i\[7\] _07185_ _08492_ _08548_
+ VDD VSS MUX2_X1
X_26160_ _08470_ _08548_ _08549_ VDD VSS NAND2_X1
X_26161_ cs_registers_i.csr_depc_o\[7\] _08550_ VDD VSS INV_X1
X_26162_ _08549_ _08476_ _07828_ _08550_ _08459_ _01857_ VDD
+ VSS OAI221_X1
X_26163_ _11788_ cs_registers_i.pc_if_i\[8\] _08453_ _08551_
+ VDD VSS MUX2_X1
X_26164_ _07844_ _08468_ _08551_ _08470_ _08552_ VDD VSS AOI22_X1
X_26165_ cs_registers_i.csr_depc_o\[8\] _08553_ VDD VSS INV_X1
X_26166_ _08552_ _08460_ _08553_ _01858_ VDD VSS OAI21_X1
X_26167_ _11826_ _07184_ _08453_ _08554_ VDD VSS MUX2_X1
X_26168_ _07854_ _08468_ _08554_ _08470_ _08555_ VDD VSS AOI22_X1
X_26169_ cs_registers_i.csr_depc_o\[9\] _08556_ VDD VSS INV_X1
X_26170_ _08555_ _08460_ _08556_ _01859_ VDD VSS OAI21_X1
X_26171_ _04511_ _07489_ _08557_ VDD VSS NAND2_X2
X_26172_ _08557_ _08558_ VDD VSS BUF_X4
X_26173_ _07483_ cs_registers_i.dscratch0_q\[0\] _08558_ _01860_
+ VDD VSS MUX2_X1
X_26174_ _08557_ _08559_ VDD VSS CLKBUF_X3
X_26175_ cs_registers_i.dscratch0_q\[10\] _08559_ _08560_
+ VDD VSS NAND2_X1
X_26176_ _08557_ _08561_ VDD VSS CLKBUF_X3
X_26177_ _08560_ _08561_ _07525_ _01861_ VDD VSS OAI21_X1
X_26178_ _08275_ cs_registers_i.dscratch0_q\[11\] _08558_
+ _01862_ VDD VSS MUX2_X1
X_26179_ _08444_ cs_registers_i.dscratch0_q\[12\] _08558_
+ _01863_ VDD VSS MUX2_X1
X_26180_ _07569_ cs_registers_i.dscratch0_q\[13\] _08558_
+ _01864_ VDD VSS MUX2_X1
X_26181_ _07579_ cs_registers_i.dscratch0_q\[14\] _08558_
+ _01865_ VDD VSS MUX2_X1
X_26182_ _08299_ cs_registers_i.dscratch0_q\[15\] _08558_
+ _01866_ VDD VSS MUX2_X1
X_26183_ _07600_ cs_registers_i.dscratch0_q\[16\] _08558_
+ _01867_ VDD VSS MUX2_X1
X_26184_ cs_registers_i.dscratch0_q\[17\] _08559_ _08562_
+ VDD VSS NAND2_X1
X_26185_ _08562_ _08561_ _08312_ _01868_ VDD VSS OAI21_X1
X_26186_ _07914_ cs_registers_i.dscratch0_q\[18\] _08558_
+ _01869_ VDD VSS MUX2_X1
X_26187_ cs_registers_i.dscratch0_q\[19\] _08559_ _08563_
+ VDD VSS NAND2_X1
X_26188_ _08563_ _08561_ _07624_ _01870_ VDD VSS OAI21_X1
X_26189_ cs_registers_i.dscratch0_q\[1\] _08559_ _08564_ VDD
+ VSS NAND2_X1
X_26190_ _08564_ _08561_ _07635_ _01871_ VDD VSS OAI21_X1
X_26191_ cs_registers_i.dscratch0_q\[20\] _08559_ _08565_
+ VDD VSS NAND2_X1
X_26192_ _08565_ _08561_ _07640_ _01872_ VDD VSS OAI21_X1
X_26193_ _08343_ cs_registers_i.dscratch0_q\[21\] _08558_
+ _01873_ VDD VSS MUX2_X1
X_26194_ cs_registers_i.dscratch0_q\[22\] _08559_ _08566_
+ VDD VSS NAND2_X1
X_26195_ _08566_ _08561_ _07657_ _01874_ VDD VSS OAI21_X1
X_26196_ _08355_ cs_registers_i.dscratch0_q\[23\] _08558_
+ _01875_ VDD VSS MUX2_X1
X_26197_ _08557_ _08567_ VDD VSS BUF_X4
X_26198_ _08149_ cs_registers_i.dscratch0_q\[24\] _08567_
+ _01876_ VDD VSS MUX2_X1
X_26199_ _07689_ cs_registers_i.dscratch0_q\[25\] _08567_
+ _01877_ VDD VSS MUX2_X1
X_26200_ cs_registers_i.dscratch0_q\[26\] _08559_ _08568_
+ VDD VSS NAND2_X1
X_26201_ _08568_ _08561_ _08163_ _01878_ VDD VSS OAI21_X1
X_26202_ cs_registers_i.dscratch0_q\[27\] _08559_ _08569_
+ VDD VSS NAND2_X1
X_26203_ _08569_ _08561_ _07709_ _01879_ VDD VSS OAI21_X1
X_26204_ _07718_ cs_registers_i.dscratch0_q\[28\] _08567_
+ _01880_ VDD VSS MUX2_X1
X_26205_ cs_registers_i.dscratch0_q\[29\] _08559_ _08570_
+ VDD VSS NAND2_X1
X_26206_ _08570_ _08561_ _07728_ _01881_ VDD VSS OAI21_X1
X_26207_ _07493_ cs_registers_i.dscratch0_q\[2\] _08567_ _01882_
+ VDD VSS MUX2_X1
X_26208_ cs_registers_i.dscratch0_q\[30\] _08559_ _08571_
+ VDD VSS NAND2_X1
X_26209_ _08571_ _08561_ _07983_ _01883_ VDD VSS OAI21_X1
X_26210_ _08405_ cs_registers_i.dscratch0_q\[31\] _08567_
+ _01884_ VDD VSS MUX2_X1
X_26211_ _08224_ cs_registers_i.dscratch0_q\[3\] _08567_ _01885_
+ VDD VSS MUX2_X1
X_26212_ _08231_ cs_registers_i.dscratch0_q\[4\] _08567_ _01886_
+ VDD VSS MUX2_X1
X_26213_ _07810_ cs_registers_i.dscratch0_q\[5\] _08567_ _01887_
+ VDD VSS MUX2_X1
X_26214_ _08243_ cs_registers_i.dscratch0_q\[6\] _08567_ _01888_
+ VDD VSS MUX2_X1
X_26215_ _08250_ cs_registers_i.dscratch0_q\[7\] _08567_ _01889_
+ VDD VSS MUX2_X1
X_26216_ _07844_ cs_registers_i.dscratch0_q\[8\] _08557_ _01890_
+ VDD VSS MUX2_X1
X_26217_ _07854_ cs_registers_i.dscratch0_q\[9\] _08557_ _01891_
+ VDD VSS MUX2_X1
X_26218_ _04530_ _07489_ _08572_ VDD VSS NAND2_X2
X_26219_ _08572_ _08573_ VDD VSS BUF_X4
X_26220_ _07483_ cs_registers_i.dscratch1_q\[0\] _08573_ _01892_
+ VDD VSS MUX2_X1
X_26221_ _08572_ _08574_ VDD VSS CLKBUF_X3
X_26222_ cs_registers_i.dscratch1_q\[10\] _08574_ _08575_
+ VDD VSS NAND2_X1
X_26223_ _08572_ _08576_ VDD VSS CLKBUF_X3
X_26224_ _08575_ _08576_ _07525_ _01893_ VDD VSS OAI21_X1
X_26225_ _08275_ cs_registers_i.dscratch1_q\[11\] _08573_
+ _01894_ VDD VSS MUX2_X1
X_26226_ _08444_ cs_registers_i.dscratch1_q\[12\] _08573_
+ _01895_ VDD VSS MUX2_X1
X_26227_ _07569_ cs_registers_i.dscratch1_q\[13\] _08573_
+ _01896_ VDD VSS MUX2_X1
X_26228_ _07579_ cs_registers_i.dscratch1_q\[14\] _08573_
+ _01897_ VDD VSS MUX2_X1
X_26229_ _08299_ cs_registers_i.dscratch1_q\[15\] _08573_
+ _01898_ VDD VSS MUX2_X1
X_26230_ _07600_ cs_registers_i.dscratch1_q\[16\] _08573_
+ _01899_ VDD VSS MUX2_X1
X_26231_ cs_registers_i.dscratch1_q\[17\] _08574_ _08577_
+ VDD VSS NAND2_X1
X_26232_ _08577_ _08576_ _08312_ _01900_ VDD VSS OAI21_X1
X_26233_ _07914_ cs_registers_i.dscratch1_q\[18\] _08573_
+ _01901_ VDD VSS MUX2_X1
X_26234_ cs_registers_i.dscratch1_q\[19\] _08574_ _08578_
+ VDD VSS NAND2_X1
X_26235_ _08578_ _08576_ _07624_ _01902_ VDD VSS OAI21_X1
X_26236_ cs_registers_i.dscratch1_q\[1\] _08574_ _08579_ VDD
+ VSS NAND2_X1
X_26237_ _08579_ _08576_ _07635_ _01903_ VDD VSS OAI21_X1
X_26238_ cs_registers_i.dscratch1_q\[20\] _08574_ _08580_
+ VDD VSS NAND2_X1
X_26239_ _08580_ _08576_ _07640_ _01904_ VDD VSS OAI21_X1
X_26240_ _08343_ cs_registers_i.dscratch1_q\[21\] _08573_
+ _01905_ VDD VSS MUX2_X1
X_26241_ cs_registers_i.dscratch1_q\[22\] _08574_ _08581_
+ VDD VSS NAND2_X1
X_26242_ _08581_ _08576_ _07657_ _01906_ VDD VSS OAI21_X1
X_26243_ _08355_ cs_registers_i.dscratch1_q\[23\] _08573_
+ _01907_ VDD VSS MUX2_X1
X_26244_ _08572_ _08582_ VDD VSS BUF_X4
X_26245_ _08149_ cs_registers_i.dscratch1_q\[24\] _08582_
+ _01908_ VDD VSS MUX2_X1
X_26246_ _07689_ cs_registers_i.dscratch1_q\[25\] _08582_
+ _01909_ VDD VSS MUX2_X1
X_26247_ cs_registers_i.dscratch1_q\[26\] _08574_ _08583_
+ VDD VSS NAND2_X1
X_26248_ _08583_ _08576_ _08163_ _01910_ VDD VSS OAI21_X1
X_26249_ cs_registers_i.dscratch1_q\[27\] _08574_ _08584_
+ VDD VSS NAND2_X1
X_26250_ _08584_ _08576_ _07709_ _01911_ VDD VSS OAI21_X1
X_26251_ _07718_ cs_registers_i.dscratch1_q\[28\] _08582_
+ _01912_ VDD VSS MUX2_X1
X_26252_ cs_registers_i.dscratch1_q\[29\] _08574_ _08585_
+ VDD VSS NAND2_X1
X_26253_ _08585_ _08576_ _07728_ _01913_ VDD VSS OAI21_X1
X_26254_ _07493_ cs_registers_i.dscratch1_q\[2\] _08582_ _01914_
+ VDD VSS MUX2_X1
X_26255_ cs_registers_i.dscratch1_q\[30\] _08574_ _08586_
+ VDD VSS NAND2_X1
X_26256_ _08586_ _08576_ _07983_ _01915_ VDD VSS OAI21_X1
X_26257_ _08405_ cs_registers_i.dscratch1_q\[31\] _08582_
+ _01916_ VDD VSS MUX2_X1
X_26258_ _08224_ cs_registers_i.dscratch1_q\[3\] _08582_ _01917_
+ VDD VSS MUX2_X1
X_26259_ _08231_ cs_registers_i.dscratch1_q\[4\] _08582_ _01918_
+ VDD VSS MUX2_X1
X_26260_ _07810_ cs_registers_i.dscratch1_q\[5\] _08582_ _01919_
+ VDD VSS MUX2_X1
X_26261_ _08243_ cs_registers_i.dscratch1_q\[6\] _08582_ _01920_
+ VDD VSS MUX2_X1
X_26262_ _08250_ cs_registers_i.dscratch1_q\[7\] _08582_ _01921_
+ VDD VSS MUX2_X1
X_26263_ _07844_ cs_registers_i.dscratch1_q\[8\] _08572_ _01922_
+ VDD VSS MUX2_X1
X_26264_ _07854_ cs_registers_i.dscratch1_q\[9\] _08572_ _01923_
+ VDD VSS MUX2_X1
X_26265_ _03918_ _03894_ _03921_ _08587_ VDD VSS NOR3_X4
X_26266_ _08587_ _08588_ VDD VSS BUF_X4
X_26267_ cs_registers_i.mstack_cause_q\[0\] _08588_ _08589_
+ VDD VSS NAND2_X1
X_26268_ _03870_ _06797_ _08590_ VDD VSS NAND2_X4
X_26269_ _08430_ _08437_ _08591_ VDD VSS NOR2_X2
X_26270_ _03478_ _08591_ _08592_ VDD VSS NAND2_X4
X_26271_ _08590_ _08592_ _08593_ VDD VSS NAND2_X1
X_26272_ _08593_ _08594_ VDD VSS BUF_X4
X_26273_ _08592_ _08595_ VDD VSS BUF_X4
X_26274_ _08595_ _08596_ VDD VSS CLKBUF_X3
X_26275_ _06989_ _08597_ VDD VSS CLKBUF_X3
X_26276_ _03843_ _08598_ VDD VSS BUF_X4
X_26277_ _08598_ _08599_ VDD VSS BUF_X4
X_26278_ id_stage_i.controller_i.illegal_insn_q _08600_ VDD
+ VSS INV_X1
X_26279_ _03842_ _08601_ VDD VSS BUF_X4
X_26280_ _08600_ _08601_ _03610_ _03837_ _08602_ VDD VSS NAND4_X4
X_26281_ _08602_ _08603_ VDD VSS BUF_X4
X_26282_ _08601_ _08604_ VDD VSS INV_X1
X_26283_ _11935_ _08604_ _08605_ VDD VSS NOR2_X1
X_26284_ _03435_ _03464_ _03609_ _08605_ _08606_ VDD VSS NAND4_X1
X_26285_ _08606_ _06291_ _03849_ _08607_ VDD VSS OAI21_X1
X_26286_ _08601_ _08607_ _08608_ VDD VSS NAND2_X1
X_26287_ _08599_ _08603_ _08608_ _08609_ VDD VSS NAND3_X1
X_26288_ _03920_ _08597_ _08609_ _08610_ VDD VSS AOI21_X1
X_26289_ _08589_ _08594_ _07482_ _08596_ _08610_ _08611_ VDD
+ VSS OAI221_X1
X_26290_ _03844_ _08591_ _08612_ VDD VSS NAND2_X2
X_26291_ _08612_ _08590_ _08613_ VDD VSS NAND2_X2
X_26292_ _08613_ _07489_ _05228_ _08614_ VDD VSS AOI21_X4
X_26293_ _08611_ cs_registers_i.mcause_q\[0\] _08614_ _01924_
+ VDD VSS MUX2_X1
X_26294_ _08430_ _08437_ _08615_ VDD VSS OR2_X2
X_26295_ _03477_ _08615_ _08616_ VDD VSS NOR2_X4
X_26296_ _08587_ _08616_ _08617_ VDD VSS NOR2_X2
X_26297_ _08617_ _08618_ VDD VSS BUF_X4
X_26298_ _07634_ _08618_ _08619_ VDD VSS AND2_X1
X_26299_ _08616_ _08620_ VDD VSS BUF_X4
X_26300_ _03461_ _03891_ _08621_ VDD VSS NAND2_X2
X_26301_ _03607_ _08621_ _08622_ VDD VSS NOR2_X1
X_26302_ id_stage_i.controller_i.store_err_q _08600_ _08598_
+ _08623_ VDD VSS NAND3_X1
X_26303_ _03609_ _08623_ _08624_ VDD VSS NOR2_X1
X_26304_ _03849_ _03852_ _08625_ VDD VSS NOR2_X1
X_26305_ _08624_ _08625_ _03609_ _08626_ VDD VSS AOI21_X1
X_26306_ _08601_ _08606_ _08626_ _08627_ VDD VSS NAND3_X1
X_26307_ _08622_ _08627_ _08628_ VDD VSS NAND2_X1
X_26308_ _03949_ _08620_ _08628_ _08629_ VDD VSS NAND3_X1
X_26309_ _08629_ _08590_ cs_registers_i.mstack_cause_q\[1\]
+ _08630_ VDD VSS OAI21_X1
X_26310_ _08619_ _08630_ _08631_ VDD VSS NOR2_X1
X_26311_ _08631_ cs_registers_i.mcause_q\[1\] _08614_ _01925_
+ VDD VSS MUX2_X1
X_26312_ cs_registers_i.mcause_q\[2\] _08614_ _08632_ VDD
+ VSS NAND2_X1
X_26313_ _08620_ _08633_ VDD VSS BUF_X4
X_26314_ _08598_ _06989_ _08634_ VDD VSS NAND2_X1
X_26315_ _08633_ _08603_ _08634_ _06802_ _03873_ _08635_ VDD
+ VSS OAI221_X1
X_26316_ _08593_ _08636_ VDD VSS BUF_X4
X_26317_ _08587_ _08637_ VDD VSS INV_X1
X_26318_ _08635_ _08636_ _07493_ cs_registers_i.mstack_cause_q\[2\]
+ _08637_ _08638_ VDD VSS OAI221_X1
X_26319_ _08632_ _08638_ _08614_ _01926_ VDD VSS OAI21_X1
X_26320_ _03609_ _08605_ _08622_ _08639_ VDD VSS AND3_X1
X_26321_ _06811_ _08592_ _08639_ _08640_ VDD VSS NOR3_X1
X_26322_ cs_registers_i.mstack_cause_q\[3\] _08641_ VDD VSS
+ INV_X1
X_26323_ _08640_ _08617_ _07791_ _08641_ _08587_ _08642_ VDD
+ VSS AOI221_X1
X_26324_ _08642_ cs_registers_i.mcause_q\[3\] _08614_ _01927_
+ VDD VSS MUX2_X1
X_26325_ cs_registers_i.mcause_q\[4\] _08614_ _08643_ VDD
+ VSS NAND2_X1
X_26326_ _07800_ _08618_ _08644_ VDD VSS NAND2_X1
X_26327_ _08644_ _08596_ _06844_ cs_registers_i.mstack_cause_q\[4\]
+ _08637_ _08645_ VDD VSS OAI221_X1
X_26328_ _08643_ _08645_ _08614_ _01928_ VDD VSS OAI21_X1
X_26329_ cs_registers_i.mcause_q\[5\] _08646_ VDD VSS INV_X1
X_26330_ _08616_ _08647_ VDD VSS CLKBUF_X3
X_26331_ _07748_ _08588_ _08647_ _08648_ VDD VSS NOR3_X1
X_26332_ _08648_ _08588_ cs_registers_i.mstack_cause_q\[5\]
+ _08649_ VDD VSS AOI21_X1
X_26333_ _03941_ _08614_ _08650_ VDD VSS NOR2_X1
X_26334_ _08646_ _08614_ _08649_ _08650_ _01929_ VDD VSS AOI22_X1
X_26335_ _08613_ _07489_ _04544_ _08651_ VDD VSS AOI21_X4
X_26336_ cs_registers_i.mstack_epc_q\[0\] _08588_ _08651_
+ cs_registers_i.csr_mepc_o\[0\] _08652_ VDD VSS AOI22_X1
X_26337_ _08652_ _01930_ VDD VSS INV_X1
X_26338_ _08587_ _08653_ VDD VSS BUF_X4
X_26339_ cs_registers_i.mstack_epc_q\[10\] _08653_ _08647_
+ _08455_ _08654_ VDD VSS AOI22_X1
X_26340_ _08654_ _08636_ _07525_ _08655_ VDD VSS OAI21_X1
X_26341_ _04544_ _07488_ _08656_ VDD VSS NAND2_X1
X_26342_ _08612_ _08590_ _08656_ _08657_ VDD VSS NAND3_X4
X_26343_ _08657_ _08658_ VDD VSS CLKBUF_X3
X_26344_ cs_registers_i.csr_mepc_o\[10\] _08655_ _08658_ _01931_
+ VDD VSS MUX2_X1
X_26345_ cs_registers_i.mstack_epc_q\[11\] _08653_ _08647_
+ _08462_ _08659_ VDD VSS AOI22_X1
X_26346_ _08659_ _08636_ _07535_ _08660_ VDD VSS OAI21_X1
X_26347_ cs_registers_i.csr_mepc_o\[11\] _08660_ _08658_ _01932_
+ VDD VSS MUX2_X1
X_26348_ cs_registers_i.mstack_epc_q\[12\] _08653_ _08647_
+ _08465_ _08661_ VDD VSS AOI22_X1
X_26349_ _08661_ _08636_ _07554_ _08662_ VDD VSS OAI21_X1
X_26350_ cs_registers_i.csr_mepc_o\[12\] _08662_ _08658_ _01933_
+ VDD VSS MUX2_X1
X_26351_ _08657_ _08663_ VDD VSS CLKBUF_X3
X_26352_ cs_registers_i.csr_mepc_o\[13\] _08663_ _08664_ VDD
+ VSS NOR2_X1
X_26353_ _08469_ _08616_ _08665_ VDD VSS AND2_X1
X_26354_ _08665_ _08618_ _07568_ cs_registers_i.mstack_epc_q\[13\]
+ _08588_ _08666_ VDD VSS AOI221_X1
X_26355_ _08664_ _08666_ _08663_ _01934_ VDD VSS AOI21_X1
X_26356_ cs_registers_i.csr_mepc_o\[14\] _08663_ _08667_ VDD
+ VSS NOR2_X1
X_26357_ _08474_ _08592_ _08668_ VDD VSS NOR2_X1
X_26358_ _08668_ _08618_ _07579_ cs_registers_i.mstack_epc_q\[14\]
+ _08588_ _08669_ VDD VSS AOI221_X1
X_26359_ _08667_ _08669_ _08663_ _01935_ VDD VSS AOI21_X1
X_26360_ cs_registers_i.mstack_epc_q\[15\] _08653_ _08647_
+ _08478_ _08670_ VDD VSS AOI22_X1
X_26361_ _08670_ _08636_ _07585_ _08671_ VDD VSS OAI21_X1
X_26362_ cs_registers_i.csr_mepc_o\[15\] _08671_ _08658_ _01936_
+ VDD VSS MUX2_X1
X_26363_ cs_registers_i.csr_mepc_o\[16\] _08663_ _08672_ VDD
+ VSS NOR2_X1
X_26364_ _08482_ _08592_ _08673_ VDD VSS NOR2_X1
X_26365_ _08673_ _08618_ _07600_ cs_registers_i.mstack_epc_q\[16\]
+ _08653_ _08674_ VDD VSS AOI221_X1
X_26366_ _08672_ _08674_ _08663_ _01937_ VDD VSS AOI21_X1
X_26367_ cs_registers_i.mstack_epc_q\[17\] _08587_ _08620_
+ _08486_ _08675_ VDD VSS AOI22_X1
X_26368_ _08675_ _08594_ _08312_ _08676_ VDD VSS OAI21_X1
X_26369_ _08676_ cs_registers_i.csr_mepc_o\[17\] _08651_ _01938_
+ VDD VSS MUX2_X1
X_26370_ cs_registers_i.mstack_epc_q\[18\] _08653_ _08647_
+ _08489_ _08677_ VDD VSS AOI22_X1
X_26371_ _08677_ _08636_ _07616_ _08678_ VDD VSS OAI21_X1
X_26372_ cs_registers_i.csr_mepc_o\[18\] _08678_ _08658_ _01939_
+ VDD VSS MUX2_X1
X_26373_ _08587_ _08679_ VDD VSS BUF_X4
X_26374_ cs_registers_i.mstack_epc_q\[19\] _08679_ _08647_
+ _08493_ _08680_ VDD VSS AOI22_X1
X_26375_ _08680_ _08636_ _07624_ _08681_ VDD VSS OAI21_X1
X_26376_ cs_registers_i.csr_mepc_o\[19\] _08681_ _08658_ _01940_
+ VDD VSS MUX2_X1
X_26377_ cs_registers_i.mstack_epc_q\[1\] _08590_ _08595_
+ _08496_ _08682_ VDD VSS OAI22_X1
X_26378_ _08619_ _08682_ _08683_ VDD VSS NOR2_X1
X_26379_ _08657_ _08684_ VDD VSS BUF_X4
X_26380_ cs_registers_i.csr_mepc_o\[1\] _08683_ _08684_ _01941_
+ VDD VSS MUX2_X1
X_26381_ _08616_ _08685_ VDD VSS CLKBUF_X3
X_26382_ cs_registers_i.mstack_epc_q\[20\] _08679_ _08685_
+ _08499_ _08686_ VDD VSS AOI22_X1
X_26383_ _08686_ _08636_ _07640_ _08687_ VDD VSS OAI21_X1
X_26384_ cs_registers_i.csr_mepc_o\[20\] _08687_ _08684_ _01942_
+ VDD VSS MUX2_X1
X_26385_ cs_registers_i.mstack_epc_q\[21\] _08679_ _08685_
+ _08502_ _08688_ VDD VSS AOI22_X1
X_26386_ _08688_ _08636_ _07651_ _08689_ VDD VSS OAI21_X1
X_26387_ cs_registers_i.csr_mepc_o\[21\] _08689_ _08684_ _01943_
+ VDD VSS MUX2_X1
X_26388_ cs_registers_i.mstack_epc_q\[22\] _08679_ _08685_
+ _08504_ _08690_ VDD VSS AOI22_X1
X_26389_ _08690_ _08636_ _07657_ _08691_ VDD VSS OAI21_X1
X_26390_ cs_registers_i.csr_mepc_o\[22\] _08691_ _08684_ _01944_
+ VDD VSS MUX2_X1
X_26391_ cs_registers_i.mstack_epc_q\[23\] _08679_ _08685_
+ _08506_ _08692_ VDD VSS AOI22_X1
X_26392_ _08692_ _08594_ _07669_ _08693_ VDD VSS OAI21_X1
X_26393_ cs_registers_i.csr_mepc_o\[23\] _08693_ _08684_ _01945_
+ VDD VSS MUX2_X1
X_26394_ cs_registers_i.mstack_epc_q\[24\] _08679_ _08685_
+ _08509_ _08694_ VDD VSS AOI22_X1
X_26395_ _08694_ _08594_ _07676_ _08695_ VDD VSS OAI21_X1
X_26396_ cs_registers_i.csr_mepc_o\[24\] _08695_ _08684_ _01946_
+ VDD VSS MUX2_X1
X_26397_ cs_registers_i.csr_mepc_o\[25\] _08658_ _08696_ VDD
+ VSS NOR2_X1
X_26398_ _08512_ _08616_ _08697_ VDD VSS AND2_X1
X_26399_ _08697_ _08618_ _07688_ cs_registers_i.mstack_epc_q\[25\]
+ _08653_ _08698_ VDD VSS AOI221_X2
X_26400_ _08696_ _08698_ _08663_ _01947_ VDD VSS AOI21_X1
X_26401_ cs_registers_i.mstack_epc_q\[26\] _08679_ _08685_
+ _08515_ _08699_ VDD VSS AOI22_X1
X_26402_ _08699_ _08594_ _08163_ _08700_ VDD VSS OAI21_X1
X_26403_ cs_registers_i.csr_mepc_o\[26\] _08700_ _08684_ _01948_
+ VDD VSS MUX2_X1
X_26404_ cs_registers_i.mstack_epc_q\[27\] _08679_ _08685_
+ _08517_ _08701_ VDD VSS AOI22_X1
X_26405_ _08701_ _08594_ _07709_ _08702_ VDD VSS OAI21_X1
X_26406_ cs_registers_i.csr_mepc_o\[27\] _08702_ _08684_ _01949_
+ VDD VSS MUX2_X1
X_26407_ cs_registers_i.csr_mepc_o\[28\] _08658_ _08703_ VDD
+ VSS NOR2_X1
X_26408_ _08521_ _08592_ _08704_ VDD VSS NOR2_X1
X_26409_ _08704_ _08618_ _07717_ cs_registers_i.mstack_epc_q\[28\]
+ _08653_ _08705_ VDD VSS AOI221_X2
X_26410_ _08703_ _08705_ _08663_ _01950_ VDD VSS AOI21_X1
X_26411_ cs_registers_i.mstack_epc_q\[29\] _08679_ _08685_
+ _08524_ _08706_ VDD VSS AOI22_X1
X_26412_ _08706_ _08594_ _07728_ _08707_ VDD VSS OAI21_X1
X_26413_ cs_registers_i.csr_mepc_o\[29\] _08707_ _08684_ _01951_
+ VDD VSS MUX2_X1
X_26414_ cs_registers_i.mstack_epc_q\[2\] _08637_ _08708_
+ VDD VSS NOR2_X1
X_26415_ _08708_ _08620_ _08527_ _07492_ _08617_ _08709_ VDD
+ VSS AOI221_X1
X_26416_ cs_registers_i.csr_mepc_o\[2\] _08709_ _08684_ _01952_
+ VDD VSS MUX2_X1
X_26417_ cs_registers_i.mstack_epc_q\[30\] _08679_ _08685_
+ _08530_ _08710_ VDD VSS AOI22_X1
X_26418_ _08710_ _08594_ _07983_ _08711_ VDD VSS OAI21_X1
X_26419_ cs_registers_i.csr_mepc_o\[30\] _08711_ _08657_ _01953_
+ VDD VSS MUX2_X1
X_26420_ cs_registers_i.mstack_epc_q\[31\] _08590_ _08595_
+ _08533_ _08712_ VDD VSS OAI22_X1
X_26421_ _08712_ _08618_ _07748_ _08713_ VDD VSS AOI21_X1
X_26422_ _08713_ cs_registers_i.csr_mepc_o\[31\] _08651_ _01954_
+ VDD VSS MUX2_X1
X_26423_ cs_registers_i.mstack_epc_q\[3\] _08590_ _08595_
+ _08536_ _08714_ VDD VSS OAI22_X1
X_26424_ _08714_ _08618_ _07791_ _08715_ VDD VSS AOI21_X1
X_26425_ cs_registers_i.csr_mepc_o\[3\] _08715_ _08657_ _01955_
+ VDD VSS MUX2_X1
X_26426_ cs_registers_i.csr_mepc_o\[4\] _08651_ _08716_ VDD
+ VSS NAND2_X1
X_26427_ _08644_ _08596_ _08539_ cs_registers_i.mstack_epc_q\[4\]
+ _08637_ _08717_ VDD VSS OAI221_X1
X_26428_ _08716_ _08717_ _08651_ _01956_ VDD VSS OAI21_X1
X_26429_ cs_registers_i.mstack_epc_q\[5\] _08588_ _08647_
+ _08542_ _08718_ VDD VSS AOI22_X1
X_26430_ _07810_ _08618_ _08719_ VDD VSS NAND2_X1
X_26431_ _08657_ _08718_ _08719_ _08720_ VDD VSS AND3_X1
X_26432_ _08720_ _08651_ _06812_ _01957_ VDD VSS AOI21_X1
X_26433_ cs_registers_i.mstack_epc_q\[6\] _08587_ _08685_
+ _08545_ _08721_ VDD VSS AOI22_X1
X_26434_ _08721_ _08594_ _07821_ _08722_ VDD VSS OAI21_X1
X_26435_ cs_registers_i.csr_mepc_o\[6\] _08722_ _08657_ _01958_
+ VDD VSS MUX2_X1
X_26436_ cs_registers_i.mstack_epc_q\[7\] _08587_ _08620_
+ _08548_ _08723_ VDD VSS AOI22_X1
X_26437_ _08723_ _08594_ _07828_ _08724_ VDD VSS OAI21_X1
X_26438_ cs_registers_i.csr_mepc_o\[7\] _08724_ _08657_ _01959_
+ VDD VSS MUX2_X1
X_26439_ cs_registers_i.csr_mepc_o\[8\] _08658_ _08725_ VDD
+ VSS NOR2_X1
X_26440_ _08551_ _08616_ _08726_ VDD VSS AND2_X1
X_26441_ _08726_ _08617_ _07844_ cs_registers_i.mstack_epc_q\[8\]
+ _08653_ _08727_ VDD VSS AOI221_X1
X_26442_ _08725_ _08727_ _08663_ _01960_ VDD VSS AOI21_X1
X_26443_ cs_registers_i.csr_mepc_o\[9\] _08658_ _08728_ VDD
+ VSS NOR2_X1
X_26444_ _08554_ _08616_ _08729_ VDD VSS AND2_X1
X_26445_ _08729_ _08617_ _07853_ cs_registers_i.mstack_epc_q\[9\]
+ _08653_ _08730_ VDD VSS AOI221_X1
X_26446_ _08728_ _08730_ _08663_ _01961_ VDD VSS AOI21_X1
X_26447_ _04515_ _07489_ _08731_ VDD VSS NAND2_X4
X_26448_ _08731_ _08732_ VDD VSS CLKBUF_X3
X_26449_ _07600_ cs_registers_i.mie_q\[0\] _08732_ _01962_
+ VDD VSS MUX2_X1
X_26450_ _08731_ _08733_ VDD VSS CLKBUF_X3
X_26451_ cs_registers_i.mie_q\[10\] _08733_ _08734_ VDD VSS
+ NAND2_X1
X_26452_ _08734_ _08733_ _08163_ _01963_ VDD VSS OAI21_X1
X_26453_ cs_registers_i.mie_q\[11\] _08733_ _08735_ VDD VSS
+ NAND2_X1
X_26454_ _08735_ _08733_ _07709_ _01964_ VDD VSS OAI21_X1
X_26455_ _07718_ cs_registers_i.mie_q\[12\] _08732_ _01965_
+ VDD VSS MUX2_X1
X_26456_ cs_registers_i.mie_q\[13\] _08732_ _08736_ VDD VSS
+ NAND2_X1
X_26457_ _08736_ _08733_ _07728_ _01966_ VDD VSS OAI21_X1
X_26458_ cs_registers_i.mie_q\[14\] _08732_ _08737_ VDD VSS
+ NAND2_X1
X_26459_ _08737_ _08733_ _07983_ _01967_ VDD VSS OAI21_X1
X_26460_ _08275_ cs_registers_i.mie_q\[15\] _08732_ _01968_
+ VDD VSS MUX2_X1
X_26461_ _08250_ cs_registers_i.mie_q\[16\] _08732_ _01969_
+ VDD VSS MUX2_X1
X_26462_ _08224_ cs_registers_i.mie_q\[17\] _08731_ _01970_
+ VDD VSS MUX2_X1
X_26463_ cs_registers_i.mie_q\[1\] _08732_ _08738_ VDD VSS
+ NAND2_X1
X_26464_ _08738_ _08733_ _08312_ _01971_ VDD VSS OAI21_X1
X_26465_ _07914_ cs_registers_i.mie_q\[2\] _08731_ _01972_
+ VDD VSS MUX2_X1
X_26466_ cs_registers_i.mie_q\[3\] _08732_ _08739_ VDD VSS
+ NAND2_X1
X_26467_ _08739_ _08733_ _07624_ _01973_ VDD VSS OAI21_X1
X_26468_ cs_registers_i.mie_q\[4\] _08732_ _08740_ VDD VSS
+ NAND2_X1
X_26469_ _08740_ _08733_ _07640_ _01974_ VDD VSS OAI21_X1
X_26470_ _08343_ cs_registers_i.mie_q\[5\] _08731_ _01975_
+ VDD VSS MUX2_X1
X_26471_ cs_registers_i.mie_q\[6\] _08732_ _08741_ VDD VSS
+ NAND2_X1
X_26472_ _08741_ _08733_ _07657_ _01976_ VDD VSS OAI21_X1
X_26473_ _08355_ cs_registers_i.mie_q\[7\] _08731_ _01977_
+ VDD VSS MUX2_X1
X_26474_ _08149_ cs_registers_i.mie_q\[8\] _08731_ _01978_
+ VDD VSS MUX2_X1
X_26475_ _07689_ cs_registers_i.mie_q\[9\] _08731_ _01979_
+ VDD VSS MUX2_X1
X_26476_ _04524_ _07489_ _08742_ VDD VSS NAND2_X2
X_26477_ _08742_ _08743_ VDD VSS BUF_X4
X_26478_ _07483_ cs_registers_i.mscratch_q\[0\] _08743_ _01980_
+ VDD VSS MUX2_X1
X_26479_ _08742_ _08744_ VDD VSS CLKBUF_X3
X_26480_ cs_registers_i.mscratch_q\[10\] _08744_ _08745_ VDD
+ VSS NAND2_X1
X_26481_ _08742_ _08746_ VDD VSS CLKBUF_X3
X_26482_ _08745_ _08746_ _07525_ _01981_ VDD VSS OAI21_X1
X_26483_ _08275_ cs_registers_i.mscratch_q\[11\] _08743_ _01982_
+ VDD VSS MUX2_X1
X_26484_ _08444_ cs_registers_i.mscratch_q\[12\] _08743_ _01983_
+ VDD VSS MUX2_X1
X_26485_ _07569_ cs_registers_i.mscratch_q\[13\] _08743_ _01984_
+ VDD VSS MUX2_X1
X_26486_ _07579_ cs_registers_i.mscratch_q\[14\] _08743_ _01985_
+ VDD VSS MUX2_X1
X_26487_ _08299_ cs_registers_i.mscratch_q\[15\] _08743_ _01986_
+ VDD VSS MUX2_X1
X_26488_ _07600_ cs_registers_i.mscratch_q\[16\] _08743_ _01987_
+ VDD VSS MUX2_X1
X_26489_ cs_registers_i.mscratch_q\[17\] _08744_ _08747_ VDD
+ VSS NAND2_X1
X_26490_ _08747_ _08746_ _08312_ _01988_ VDD VSS OAI21_X1
X_26491_ _07914_ cs_registers_i.mscratch_q\[18\] _08743_ _01989_
+ VDD VSS MUX2_X1
X_26492_ cs_registers_i.mscratch_q\[19\] _08744_ _08748_ VDD
+ VSS NAND2_X1
X_26493_ _08748_ _08746_ _07624_ _01990_ VDD VSS OAI21_X1
X_26494_ cs_registers_i.mscratch_q\[1\] _08744_ _08749_ VDD
+ VSS NAND2_X1
X_26495_ _08749_ _08746_ _07635_ _01991_ VDD VSS OAI21_X1
X_26496_ cs_registers_i.mscratch_q\[20\] _08744_ _08750_ VDD
+ VSS NAND2_X1
X_26497_ _08750_ _08746_ _07640_ _01992_ VDD VSS OAI21_X1
X_26498_ _08343_ cs_registers_i.mscratch_q\[21\] _08743_ _01993_
+ VDD VSS MUX2_X1
X_26499_ cs_registers_i.mscratch_q\[22\] _08744_ _08751_ VDD
+ VSS NAND2_X1
X_26500_ _08751_ _08746_ _07657_ _01994_ VDD VSS OAI21_X1
X_26501_ _08355_ cs_registers_i.mscratch_q\[23\] _08743_ _01995_
+ VDD VSS MUX2_X1
X_26502_ _08742_ _08752_ VDD VSS BUF_X4
X_26503_ _08149_ cs_registers_i.mscratch_q\[24\] _08752_ _01996_
+ VDD VSS MUX2_X1
X_26504_ _07689_ cs_registers_i.mscratch_q\[25\] _08752_ _01997_
+ VDD VSS MUX2_X1
X_26505_ cs_registers_i.mscratch_q\[26\] _08744_ _08753_ VDD
+ VSS NAND2_X1
X_26506_ _08753_ _08746_ _08163_ _01998_ VDD VSS OAI21_X1
X_26507_ cs_registers_i.mscratch_q\[27\] _08744_ _08754_ VDD
+ VSS NAND2_X1
X_26508_ _08754_ _08746_ _07709_ _01999_ VDD VSS OAI21_X1
X_26509_ _07718_ cs_registers_i.mscratch_q\[28\] _08752_ _02000_
+ VDD VSS MUX2_X1
X_26510_ cs_registers_i.mscratch_q\[29\] _08744_ _08755_ VDD
+ VSS NAND2_X1
X_26511_ _08755_ _08746_ _07728_ _02001_ VDD VSS OAI21_X1
X_26512_ _07493_ cs_registers_i.mscratch_q\[2\] _08752_ _02002_
+ VDD VSS MUX2_X1
X_26513_ cs_registers_i.mscratch_q\[30\] _08744_ _08756_ VDD
+ VSS NAND2_X1
X_26514_ _08756_ _08746_ _07983_ _02003_ VDD VSS OAI21_X1
X_26515_ _08405_ cs_registers_i.mscratch_q\[31\] _08752_ _02004_
+ VDD VSS MUX2_X1
X_26516_ _08224_ cs_registers_i.mscratch_q\[3\] _08752_ _02005_
+ VDD VSS MUX2_X1
X_26517_ _08231_ cs_registers_i.mscratch_q\[4\] _08752_ _02006_
+ VDD VSS MUX2_X1
X_26518_ _07810_ cs_registers_i.mscratch_q\[5\] _08752_ _02007_
+ VDD VSS MUX2_X1
X_26519_ _08243_ cs_registers_i.mscratch_q\[6\] _08752_ _02008_
+ VDD VSS MUX2_X1
X_26520_ _08250_ cs_registers_i.mscratch_q\[7\] _08752_ _02009_
+ VDD VSS MUX2_X1
X_26521_ _07844_ cs_registers_i.mscratch_q\[8\] _08742_ _02010_
+ VDD VSS MUX2_X1
X_26522_ _07854_ cs_registers_i.mscratch_q\[9\] _08742_ _02011_
+ VDD VSS MUX2_X1
X_26523_ _08596_ _08757_ VDD VSS CLKBUF_X3
X_26524_ cs_registers_i.mcause_q\[0\] cs_registers_i.mstack_cause_q\[0\]
+ _08757_ _02012_ VDD VSS MUX2_X1
X_26525_ cs_registers_i.mcause_q\[1\] cs_registers_i.mstack_cause_q\[1\]
+ _08757_ _02013_ VDD VSS MUX2_X1
X_26526_ cs_registers_i.mcause_q\[2\] cs_registers_i.mstack_cause_q\[2\]
+ _08757_ _02014_ VDD VSS MUX2_X1
X_26527_ cs_registers_i.mcause_q\[3\] cs_registers_i.mstack_cause_q\[3\]
+ _08757_ _02015_ VDD VSS MUX2_X1
X_26528_ cs_registers_i.mcause_q\[4\] cs_registers_i.mstack_cause_q\[4\]
+ _08757_ _02016_ VDD VSS MUX2_X1
X_26529_ cs_registers_i.mcause_q\[5\] cs_registers_i.mstack_cause_q\[5\]
+ _08757_ _02017_ VDD VSS MUX2_X1
X_26530_ cs_registers_i.mstack_d\[0\] cs_registers_i.mstack_q\[0\]
+ _08757_ _02018_ VDD VSS MUX2_X1
X_26531_ cs_registers_i.mstack_d\[1\] cs_registers_i.mstack_q\[1\]
+ _08757_ _02019_ VDD VSS MUX2_X1
X_26532_ _08596_ _08758_ VDD VSS BUF_X4
X_26533_ cs_registers_i.mstack_d\[2\] cs_registers_i.mstack_q\[2\]
+ _08758_ _02020_ VDD VSS MUX2_X1
X_26534_ cs_registers_i.csr_mepc_o\[0\] cs_registers_i.mstack_epc_q\[0\]
+ _08758_ _02021_ VDD VSS MUX2_X1
X_26535_ cs_registers_i.csr_mepc_o\[10\] cs_registers_i.mstack_epc_q\[10\]
+ _08758_ _02022_ VDD VSS MUX2_X1
X_26536_ cs_registers_i.csr_mepc_o\[11\] cs_registers_i.mstack_epc_q\[11\]
+ _08758_ _02023_ VDD VSS MUX2_X1
X_26537_ cs_registers_i.csr_mepc_o\[12\] cs_registers_i.mstack_epc_q\[12\]
+ _08758_ _02024_ VDD VSS MUX2_X1
X_26538_ cs_registers_i.csr_mepc_o\[13\] cs_registers_i.mstack_epc_q\[13\]
+ _08758_ _02025_ VDD VSS MUX2_X1
X_26539_ cs_registers_i.csr_mepc_o\[14\] cs_registers_i.mstack_epc_q\[14\]
+ _08758_ _02026_ VDD VSS MUX2_X1
X_26540_ cs_registers_i.csr_mepc_o\[15\] cs_registers_i.mstack_epc_q\[15\]
+ _08758_ _02027_ VDD VSS MUX2_X1
X_26541_ cs_registers_i.csr_mepc_o\[16\] cs_registers_i.mstack_epc_q\[16\]
+ _08758_ _02028_ VDD VSS MUX2_X1
X_26542_ cs_registers_i.csr_mepc_o\[17\] cs_registers_i.mstack_epc_q\[17\]
+ _08758_ _02029_ VDD VSS MUX2_X1
X_26543_ _08595_ _08759_ VDD VSS BUF_X4
X_26544_ cs_registers_i.csr_mepc_o\[18\] cs_registers_i.mstack_epc_q\[18\]
+ _08759_ _02030_ VDD VSS MUX2_X1
X_26545_ cs_registers_i.csr_mepc_o\[19\] cs_registers_i.mstack_epc_q\[19\]
+ _08759_ _02031_ VDD VSS MUX2_X1
X_26546_ cs_registers_i.csr_mepc_o\[1\] cs_registers_i.mstack_epc_q\[1\]
+ _08759_ _02032_ VDD VSS MUX2_X1
X_26547_ cs_registers_i.csr_mepc_o\[20\] cs_registers_i.mstack_epc_q\[20\]
+ _08759_ _02033_ VDD VSS MUX2_X1
X_26548_ cs_registers_i.csr_mepc_o\[21\] cs_registers_i.mstack_epc_q\[21\]
+ _08759_ _02034_ VDD VSS MUX2_X1
X_26549_ cs_registers_i.csr_mepc_o\[22\] cs_registers_i.mstack_epc_q\[22\]
+ _08759_ _02035_ VDD VSS MUX2_X1
X_26550_ cs_registers_i.csr_mepc_o\[23\] cs_registers_i.mstack_epc_q\[23\]
+ _08759_ _02036_ VDD VSS MUX2_X1
X_26551_ cs_registers_i.csr_mepc_o\[24\] cs_registers_i.mstack_epc_q\[24\]
+ _08759_ _02037_ VDD VSS MUX2_X1
X_26552_ cs_registers_i.csr_mepc_o\[25\] cs_registers_i.mstack_epc_q\[25\]
+ _08759_ _02038_ VDD VSS MUX2_X1
X_26553_ cs_registers_i.csr_mepc_o\[26\] cs_registers_i.mstack_epc_q\[26\]
+ _08759_ _02039_ VDD VSS MUX2_X1
X_26554_ _08595_ _08760_ VDD VSS BUF_X4
X_26555_ cs_registers_i.csr_mepc_o\[27\] cs_registers_i.mstack_epc_q\[27\]
+ _08760_ _02040_ VDD VSS MUX2_X1
X_26556_ cs_registers_i.csr_mepc_o\[28\] cs_registers_i.mstack_epc_q\[28\]
+ _08760_ _02041_ VDD VSS MUX2_X1
X_26557_ cs_registers_i.csr_mepc_o\[29\] cs_registers_i.mstack_epc_q\[29\]
+ _08760_ _02042_ VDD VSS MUX2_X1
X_26558_ cs_registers_i.csr_mepc_o\[2\] cs_registers_i.mstack_epc_q\[2\]
+ _08760_ _02043_ VDD VSS MUX2_X1
X_26559_ cs_registers_i.csr_mepc_o\[30\] cs_registers_i.mstack_epc_q\[30\]
+ _08760_ _02044_ VDD VSS MUX2_X1
X_26560_ cs_registers_i.csr_mepc_o\[31\] cs_registers_i.mstack_epc_q\[31\]
+ _08760_ _02045_ VDD VSS MUX2_X1
X_26561_ cs_registers_i.csr_mepc_o\[3\] cs_registers_i.mstack_epc_q\[3\]
+ _08760_ _02046_ VDD VSS MUX2_X1
X_26562_ cs_registers_i.csr_mepc_o\[4\] cs_registers_i.mstack_epc_q\[4\]
+ _08760_ _02047_ VDD VSS MUX2_X1
X_26563_ cs_registers_i.csr_mepc_o\[5\] cs_registers_i.mstack_epc_q\[5\]
+ _08760_ _02048_ VDD VSS MUX2_X1
X_26564_ cs_registers_i.csr_mepc_o\[6\] cs_registers_i.mstack_epc_q\[6\]
+ _08760_ _02049_ VDD VSS MUX2_X1
X_26565_ cs_registers_i.csr_mepc_o\[7\] cs_registers_i.mstack_epc_q\[7\]
+ _08596_ _02050_ VDD VSS MUX2_X1
X_26566_ cs_registers_i.csr_mepc_o\[8\] cs_registers_i.mstack_epc_q\[8\]
+ _08596_ _02051_ VDD VSS MUX2_X1
X_26567_ cs_registers_i.csr_mepc_o\[9\] cs_registers_i.mstack_epc_q\[9\]
+ _08596_ _02052_ VDD VSS MUX2_X1
X_26568_ _05487_ _07489_ _08761_ VDD VSS NAND2_X2
X_26569_ _08343_ cs_registers_i.csr_mstatus_tw_o _08761_ _02053_
+ VDD VSS MUX2_X1
X_26570_ cs_registers_i.mstatus_q\[1\] _08761_ _08762_ VDD
+ VSS NAND2_X1
X_26571_ _08762_ _08761_ _08312_ _02054_ VDD VSS OAI21_X1
X_26572_ _03954_ _08615_ _08763_ VDD VSS NOR2_X2
X_26573_ _06797_ _08763_ _08764_ VDD VSS NOR2_X1
X_26574_ _03487_ _04261_ _05487_ _08765_ VDD VSS NAND3_X1
X_26575_ _08764_ _08765_ _08766_ VDD VSS NAND2_X1
X_26576_ cs_registers_i.mstack_q\[0\] _08588_ _08633_ _03462_
+ _08767_ VDD VSS AOI22_X1
X_26577_ _08767_ _08768_ VDD VSS INV_X1
X_26578_ _08761_ _07554_ _07535_ _08769_ VDD VSS AOI21_X1
X_26579_ _08766_ _08768_ _08769_ _08770_ VDD VSS OAI21_X1
X_26580_ _06797_ _08763_ _08633_ _08771_ VDD VSS AOI21_X1
X_26581_ _08761_ _08771_ _08772_ VDD VSS NAND2_X1
X_26582_ cs_registers_i.mstack_d\[0\] _08773_ VDD VSS INV_X1
X_26583_ _08770_ _08772_ _08773_ _02055_ VDD VSS OAI21_X1
X_26584_ _08620_ _08774_ VDD VSS CLKBUF_X3
X_26585_ cs_registers_i.mstack_q\[1\] _08588_ _08774_ _03463_
+ _08775_ VDD VSS AOI22_X1
X_26586_ _08775_ _08776_ VDD VSS INV_X1
X_26587_ _08766_ _08769_ _08776_ _08777_ VDD VSS OAI21_X1
X_26588_ cs_registers_i.mstack_d\[1\] _08778_ VDD VSS INV_X1
X_26589_ _08777_ _08772_ _08778_ _02056_ VDD VSS OAI21_X1
X_26590_ cs_registers_i.mstack_q\[2\] _08779_ VDD VSS INV_X1
X_26591_ _03870_ _08779_ _06803_ _08780_ VDD VSS NAND3_X1
X_26592_ cs_registers_i.csr_mstatus_mie_o _08633_ _08780_
+ _06797_ _08781_ VDD VSS AOI22_X1
X_26593_ _08781_ _08761_ _07828_ _08782_ VDD VSS OAI21_X1
X_26594_ _08766_ _08782_ _08783_ VDD VSS NAND2_X1
X_26595_ _08633_ _08588_ _08779_ _08784_ VDD VSS AOI21_X1
X_26596_ _08764_ _08765_ _08784_ _08761_ _08785_ VDD VSS AOI22_X1
X_26597_ cs_registers_i.mstack_d\[2\] _08786_ VDD VSS INV_X1
X_26598_ _08783_ _08785_ _08786_ _02057_ VDD VSS OAI21_X1
X_26599_ _07791_ _08761_ _08787_ VDD VSS NOR2_X1
X_26600_ _08787_ _06797_ cs_registers_i.mstack_d\[2\] _08788_
+ VDD VSS AOI21_X1
X_26601_ cs_registers_i.csr_mstatus_mie_o _08789_ VDD VSS
+ INV_X1
X_26602_ _08788_ _08766_ _08789_ _02058_ VDD VSS OAI21_X1
X_26603_ _08600_ _03842_ _03610_ _03837_ _08790_ VDD VSS AND4_X1
X_26604_ _08790_ _08791_ VDD VSS BUF_X4
X_26605_ _08791_ _08792_ VDD VSS BUF_X4
X_26606_ _10291_ id_stage_i.controller_i.instr_compressed_i\[0\]
+ _10338_ _08793_ VDD VSS MUX2_X1
X_26607_ id_stage_i.controller_i.lsu_addr_last_i\[0\] _08792_
+ _08793_ _08604_ _08794_ VDD VSS AOI22_X1
X_26608_ _08595_ _08634_ _08794_ _08795_ VDD VSS OR3_X1
X_26609_ _08647_ _08796_ VDD VSS CLKBUF_X3
X_26610_ _08795_ _08796_ _07482_ _08797_ VDD VSS OAI21_X1
X_26611_ _08763_ _07488_ _04521_ _08798_ VDD VSS AOI21_X4
X_26612_ _08798_ _08799_ VDD VSS BUF_X4
X_26613_ _08797_ cs_registers_i.mtval_q\[0\] _08799_ _02059_
+ VDD VSS MUX2_X1
X_26614_ _06989_ _08800_ VDD VSS CLKBUF_X3
X_26615_ _03607_ _08801_ VDD VSS BUF_X4
X_26616_ _08801_ _08802_ VDD VSS BUF_X2
X_26617_ id_stage_i.controller_i.instr_fetch_err_plus2_i _08803_
+ VDD VSS BUF_X4
X_26618_ _10675_ cs_registers_i.pc_id_i\[2\] _08803_ _08804_
+ VDD VSS NAND3_X1
X_26619_ _11517_ cs_registers_i.pc_id_i\[4\] cs_registers_i.pc_id_i\[5\]
+ _08805_ VDD VSS NAND3_X1
X_26620_ _11673_ _08805_ _08806_ VDD VSS NOR2_X1
X_26621_ cs_registers_i.pc_id_i\[7\] _08806_ _08807_ VDD VSS
+ NAND2_X1
X_26622_ _08804_ _08807_ _08808_ VDD VSS NOR2_X2
X_26623_ _11788_ _11826_ _08808_ _08809_ VDD VSS NAND3_X1
X_26624_ _00038_ _08809_ _08810_ VDD VSS XNOR2_X1
X_26625_ _08802_ _08810_ _08811_ VDD VSS NAND2_X1
X_26626_ id_stage_i.controller_i.lsu_addr_last_i\[10\] _08812_
+ VDD VSS INV_X1
X_26627_ _10338_ _08813_ VDD VSS BUF_X4
X_26628_ _00036_ _00037_ _08813_ _08814_ VDD VSS MUX2_X2
X_26629_ _08601_ _08815_ VDD VSS BUF_X4
X_26630_ _08599_ _08603_ _08812_ _08814_ _08815_ _08816_ VDD
+ VSS OAI221_X2
X_26631_ _08800_ _08774_ _08811_ _08816_ _08817_ VDD VSS NAND4_X2
X_26632_ _08817_ _08796_ _07525_ _08818_ VDD VSS OAI21_X1
X_26633_ _08818_ cs_registers_i.mtval_q\[10\] _08799_ _02060_
+ VDD VSS MUX2_X1
X_26634_ _08620_ _08819_ VDD VSS CLKBUF_X3
X_26635_ _08803_ _15536_ _08820_ VDD VSS NAND2_X1
X_26636_ _08807_ _08820_ _08821_ VDD VSS NOR2_X2
X_26637_ _11788_ _11826_ cs_registers_i.pc_id_i\[10\] _08821_
+ _08822_ VDD VSS NAND4_X1
X_26638_ _00041_ _08822_ _08823_ VDD VSS XNOR2_X1
X_26639_ _08802_ _08823_ _08824_ VDD VSS NAND2_X1
X_26640_ id_stage_i.controller_i.lsu_addr_last_i\[11\] _08825_
+ VDD VSS INV_X1
X_26641_ _04603_ _00040_ _08813_ _08826_ VDD VSS MUX2_X2
X_26642_ _08599_ _08603_ _08825_ _08826_ _08815_ _08827_ VDD
+ VSS OAI221_X2
X_26643_ _08800_ _08819_ _08824_ _08827_ _08828_ VDD VSS NAND4_X2
X_26644_ _08828_ _08796_ _07535_ _08829_ VDD VSS OAI21_X1
X_26645_ _08829_ cs_registers_i.mtval_q\[11\] _08799_ _02061_
+ VDD VSS MUX2_X1
X_26646_ cs_registers_i.pc_id_i\[11\] _11788_ _11826_ cs_registers_i.pc_id_i\[10\]
+ _08830_ VDD VSS AND4_X2
X_26647_ _08808_ _08830_ _08831_ VDD VSS NAND2_X1
X_26648_ _00043_ _08831_ _08832_ VDD VSS XNOR2_X1
X_26649_ _08802_ _08832_ _08833_ VDD VSS NAND2_X1
X_26650_ id_stage_i.controller_i.lsu_addr_last_i\[12\] _08834_
+ VDD VSS INV_X1
X_26651_ _00176_ _00042_ _08813_ _08835_ VDD VSS MUX2_X2
X_26652_ _08599_ _08603_ _08834_ _08835_ _08815_ _08836_ VDD
+ VSS OAI221_X2
X_26653_ _08597_ _08819_ _08833_ _08836_ _08837_ VDD VSS NAND4_X2
X_26654_ _08837_ _08796_ _07554_ _08838_ VDD VSS OAI21_X1
X_26655_ _08798_ _08839_ VDD VSS CLKBUF_X3
X_26656_ _08838_ cs_registers_i.mtval_q\[12\] _08839_ _02062_
+ VDD VSS MUX2_X1
X_26657_ cs_registers_i.mtval_q\[13\] _08799_ _08840_ VDD
+ VSS NAND2_X1
X_26658_ id_stage_i.controller_i.lsu_addr_last_i\[13\] _08841_
+ VDD VSS INV_X1
X_26659_ _00175_ _00044_ _10338_ _08842_ VDD VSS MUX2_X2
X_26660_ _08598_ _08602_ _08841_ _08842_ _08601_ _08843_ VDD
+ VSS OAI221_X2
X_26661_ cs_registers_i.pc_id_i\[12\] _08821_ _08830_ _08844_
+ VDD VSS NAND3_X4
X_26662_ _00045_ _08844_ _08845_ VDD VSS XOR2_X2
X_26663_ _08843_ _08845_ _08599_ _08846_ VDD VSS OAI21_X1
X_26664_ _08621_ _08596_ _08846_ _08847_ VDD VSS NOR3_X1
X_26665_ _08847_ _08757_ _07569_ _08848_ VDD VSS AOI21_X1
X_26666_ _08840_ _08848_ _08799_ _02063_ VDD VSS OAI21_X1
X_26667_ cs_registers_i.pc_id_i\[12\] _08808_ _08830_ _08849_
+ VDD VSS NAND3_X2
X_26668_ _08849_ _08850_ VDD VSS INV_X1
X_26669_ _12076_ _08850_ _08851_ VDD VSS NAND2_X1
X_26670_ _00047_ _08851_ _08852_ VDD VSS XNOR2_X1
X_26671_ _08802_ _08852_ _08853_ VDD VSS NAND2_X1
X_26672_ _08598_ _08854_ VDD VSS BUF_X4
X_26673_ id_stage_i.controller_i.lsu_addr_last_i\[14\] _08855_
+ VDD VSS INV_X1
X_26674_ _10522_ _00046_ _08813_ _08856_ VDD VSS MUX2_X2
X_26675_ _08854_ _08603_ _08855_ _08856_ _08815_ _08857_ VDD
+ VSS OAI221_X2
X_26676_ _08597_ _08819_ _08853_ _08857_ _08858_ VDD VSS NAND4_X2
X_26677_ _08858_ _08796_ _08089_ _08859_ VDD VSS OAI21_X1
X_26678_ _08859_ cs_registers_i.mtval_q\[14\] _08839_ _02064_
+ VDD VSS MUX2_X1
X_26679_ _08844_ _08860_ VDD VSS INV_X1
X_26680_ _12076_ _12179_ _08860_ _08861_ VDD VSS NAND3_X1
X_26681_ _00049_ _08861_ _08862_ VDD VSS XNOR2_X1
X_26682_ _08802_ _08862_ _08863_ VDD VSS NAND2_X1
X_26683_ id_stage_i.controller_i.lsu_addr_last_i\[15\] _08864_
+ VDD VSS INV_X1
X_26684_ _00184_ _00048_ _08813_ _08865_ VDD VSS MUX2_X1
X_26685_ _08854_ _08603_ _08864_ _08865_ _08815_ _08866_ VDD
+ VSS OAI221_X2
X_26686_ _08597_ _08819_ _08863_ _08866_ _08867_ VDD VSS NAND4_X2
X_26687_ _08867_ _08796_ _07585_ _08868_ VDD VSS OAI21_X1
X_26688_ _08868_ cs_registers_i.mtval_q\[15\] _08839_ _02065_
+ VDD VSS MUX2_X1
X_26689_ _10338_ _03842_ _08869_ VDD VSS NOR2_X4
X_26690_ _08869_ _08870_ VDD VSS BUF_X4
X_26691_ _08801_ _08792_ id_stage_i.controller_i.lsu_addr_last_i\[16\]
+ _08870_ _10759_ _08871_ VDD VSS AOI221_X2
X_26692_ _12076_ _12179_ cs_registers_i.pc_id_i\[15\] _08872_
+ VDD VSS NAND3_X1
X_26693_ _08849_ _08872_ _08873_ VDD VSS NOR2_X1
X_26694_ _00050_ _08873_ _08874_ VDD VSS XOR2_X1
X_26695_ _08801_ _08875_ VDD VSS CLKBUF_X3
X_26696_ _08871_ _08874_ _08875_ _08876_ VDD VSS AOI21_X1
X_26697_ _08800_ _08774_ _08876_ _08877_ VDD VSS NAND3_X1
X_26698_ _08877_ _08796_ _08100_ _08878_ VDD VSS OAI21_X1
X_26699_ _08878_ cs_registers_i.mtval_q\[16\] _08839_ _02066_
+ VDD VSS MUX2_X1
X_26700_ _08801_ _08792_ id_stage_i.controller_i.lsu_addr_last_i\[17\]
+ _08870_ _10752_ _08879_ VDD VSS AOI221_X2
X_26701_ _12352_ _08872_ _08880_ VDD VSS NOR2_X2
X_26702_ _08860_ _08880_ _08881_ VDD VSS NAND2_X1
X_26703_ _00051_ _08881_ _08882_ VDD VSS XNOR2_X1
X_26704_ _08879_ _08882_ _08875_ _08883_ VDD VSS AOI21_X1
X_26705_ _08800_ _08774_ _08883_ _08884_ VDD VSS NAND3_X1
X_26706_ _08884_ _08796_ _08312_ _08885_ VDD VSS OAI21_X1
X_26707_ _08885_ cs_registers_i.mtval_q\[17\] _08839_ _02067_
+ VDD VSS MUX2_X1
X_26708_ _08801_ _08792_ id_stage_i.controller_i.lsu_addr_last_i\[18\]
+ _08870_ _10767_ _08886_ VDD VSS AOI221_X2
X_26709_ cs_registers_i.pc_id_i\[17\] _08850_ _08880_ _08887_
+ VDD VSS NAND3_X1
X_26710_ _00052_ _08887_ _08888_ VDD VSS XNOR2_X1
X_26711_ _08886_ _08888_ _08875_ _08889_ VDD VSS AOI21_X1
X_26712_ _08800_ _08774_ _08889_ _08890_ VDD VSS NAND3_X1
X_26713_ _08890_ _08796_ _07616_ _08891_ VDD VSS OAI21_X1
X_26714_ _08891_ cs_registers_i.mtval_q\[18\] _08839_ _02068_
+ VDD VSS MUX2_X1
X_26715_ _08801_ _08792_ id_stage_i.controller_i.lsu_addr_last_i\[19\]
+ _08870_ _10750_ _08892_ VDD VSS AOI221_X2
X_26716_ cs_registers_i.pc_id_i\[17\] cs_registers_i.pc_id_i\[18\]
+ _08880_ _08893_ VDD VSS NAND3_X4
X_26717_ _08844_ _08893_ _08894_ VDD VSS NOR2_X1
X_26718_ _00053_ _08894_ _08895_ VDD VSS XOR2_X1
X_26719_ _08892_ _08895_ _08875_ _08896_ VDD VSS AOI21_X1
X_26720_ _08800_ _08774_ _08896_ _08897_ VDD VSS NAND3_X1
X_26721_ _08897_ _08796_ _07624_ _08898_ VDD VSS OAI21_X1
X_26722_ _08898_ cs_registers_i.mtval_q\[19\] _08839_ _02069_
+ VDD VSS MUX2_X1
X_26723_ id_stage_i.controller_i.lsu_addr_last_i\[1\] _08899_
+ VDD VSS INV_X1
X_26724_ _00013_ _00014_ _08813_ _08900_ VDD VSS MUX2_X2
X_26725_ _08599_ _08603_ _08899_ _08900_ _08815_ _08901_ VDD
+ VSS OAI221_X1
X_26726_ _10675_ _08803_ _08902_ VDD VSS XNOR2_X1
X_26727_ _08802_ _08902_ _08903_ VDD VSS NAND2_X1
X_26728_ _08597_ _08819_ _08901_ _08903_ _08904_ VDD VSS NAND4_X1
X_26729_ _08647_ _08905_ VDD VSS CLKBUF_X3
X_26730_ _08904_ _08905_ _07635_ _08906_ VDD VSS OAI21_X1
X_26731_ _08906_ cs_registers_i.mtval_q\[1\] _08839_ _02070_
+ VDD VSS MUX2_X1
X_26732_ _08801_ _08791_ id_stage_i.controller_i.lsu_addr_last_i\[20\]
+ _08870_ _11935_ _08907_ VDD VSS AOI221_X2
X_26733_ _08849_ _08893_ _08908_ VDD VSS NOR2_X1
X_26734_ _12590_ _08908_ _08909_ VDD VSS NAND2_X1
X_26735_ _00054_ _08909_ _08910_ VDD VSS XNOR2_X1
X_26736_ _08907_ _08910_ _08875_ _08911_ VDD VSS AOI21_X1
X_26737_ _08800_ _08774_ _08911_ _08912_ VDD VSS NAND3_X1
X_26738_ _08912_ _08905_ _07640_ _08913_ VDD VSS OAI21_X1
X_26739_ _08913_ cs_registers_i.mtval_q\[20\] _08839_ _02071_
+ VDD VSS MUX2_X1
X_26740_ _08801_ _08791_ id_stage_i.controller_i.lsu_addr_last_i\[21\]
+ _08869_ _12034_ _08914_ VDD VSS AOI221_X2
X_26741_ _12590_ _12685_ _08894_ _08915_ VDD VSS NAND3_X1
X_26742_ _00055_ _08915_ _08916_ VDD VSS XNOR2_X1
X_26743_ _08914_ _08916_ _08875_ _08917_ VDD VSS AOI21_X1
X_26744_ _08800_ _08774_ _08917_ _08918_ VDD VSS NAND3_X1
X_26745_ _08918_ _08905_ _07651_ _08919_ VDD VSS OAI21_X1
X_26746_ _08919_ cs_registers_i.mtval_q\[21\] _08839_ _02072_
+ VDD VSS MUX2_X1
X_26747_ _03607_ _08791_ id_stage_i.controller_i.lsu_addr_last_i\[22\]
+ _08869_ _11989_ _08920_ VDD VSS AOI221_X2
X_26748_ _12590_ _12685_ cs_registers_i.pc_id_i\[21\] _08908_
+ _08921_ VDD VSS NAND4_X1
X_26749_ _00056_ _08921_ _08922_ VDD VSS XNOR2_X1
X_26750_ _08920_ _08922_ _08875_ _08923_ VDD VSS AOI21_X1
X_26751_ _08800_ _08774_ _08923_ _08924_ VDD VSS NAND3_X1
X_26752_ _08924_ _08905_ _07657_ _08925_ VDD VSS OAI21_X2
X_26753_ _08798_ _08926_ VDD VSS BUF_X4
X_26754_ _08925_ cs_registers_i.mtval_q\[22\] _08926_ _02073_
+ VDD VSS MUX2_X1
X_26755_ _03607_ _08791_ id_stage_i.controller_i.lsu_addr_last_i\[23\]
+ _08869_ _12041_ _08927_ VDD VSS AOI221_X2
X_26756_ _12590_ _12685_ cs_registers_i.pc_id_i\[21\] cs_registers_i.pc_id_i\[22\]
+ _08928_ VDD VSS NAND4_X4
X_26757_ _08844_ _08893_ _08928_ _08929_ VDD VSS NOR3_X4
X_26758_ _00057_ _08929_ _08930_ VDD VSS XOR2_X1
X_26759_ _08927_ _08930_ _08875_ _08931_ VDD VSS AOI21_X1
X_26760_ _08800_ _08774_ _08931_ _08932_ VDD VSS NAND3_X1
X_26761_ _08932_ _08905_ _07669_ _08933_ VDD VSS OAI21_X1
X_26762_ _08933_ cs_registers_i.mtval_q\[23\] _08926_ _02074_
+ VDD VSS MUX2_X1
X_26763_ _03607_ _08791_ id_stage_i.controller_i.lsu_addr_last_i\[24\]
+ _08869_ _11929_ _08934_ VDD VSS AOI221_X2
X_26764_ _08849_ _08893_ _08928_ _08935_ VDD VSS NOR3_X2
X_26765_ _12935_ _08935_ _08936_ VDD VSS NAND2_X1
X_26766_ _00058_ _08936_ _08937_ VDD VSS XNOR2_X1
X_26767_ _08934_ _08937_ _08875_ _08938_ VDD VSS AOI21_X2
X_26768_ _08621_ _08592_ _08939_ VDD VSS NOR2_X2
X_26769_ _08798_ _08938_ _08939_ _08595_ _08149_ _08940_ VDD
+ VSS AOI221_X2
X_26770_ cs_registers_i.mtval_q\[24\] _08941_ VDD VSS INV_X1
X_26771_ _08940_ _08799_ _08941_ _02075_ VDD VSS AOI21_X1
X_26772_ _03607_ _08791_ id_stage_i.controller_i.lsu_addr_last_i\[25\]
+ _08869_ _10873_ _08942_ VDD VSS AOI221_X2
X_26773_ _12935_ _13024_ _08929_ _08943_ VDD VSS NAND3_X1
X_26774_ _00059_ _08943_ _08944_ VDD VSS XNOR2_X1
X_26775_ _08942_ _08944_ _08801_ _08945_ VDD VSS AOI21_X2
X_26776_ _08798_ _08939_ _08945_ _08595_ _07689_ _08946_ VDD
+ VSS AOI221_X2
X_26777_ cs_registers_i.mtval_q\[25\] _08947_ VDD VSS INV_X1
X_26778_ _08946_ _08799_ _08947_ _02076_ VDD VSS AOI21_X1
X_26779_ _06989_ _08620_ _08948_ VDD VSS NAND2_X2
X_26780_ _12935_ _13024_ cs_registers_i.pc_id_i\[25\] _08935_
+ _08949_ VDD VSS NAND4_X1
X_26781_ _00060_ _08949_ _08950_ VDD VSS XNOR2_X1
X_26782_ id_stage_i.controller_i.lsu_addr_last_i\[26\] _08792_
+ _08870_ _10874_ _08951_ VDD VSS AOI22_X1
X_26783_ _08950_ _08951_ _08854_ _08952_ VDD VSS MUX2_X1
X_26784_ _08163_ _08633_ _08948_ _08952_ _08953_ VDD VSS OAI22_X2
X_26785_ _08953_ cs_registers_i.mtval_q\[26\] _08926_ _02077_
+ VDD VSS MUX2_X1
X_26786_ _12935_ _13024_ cs_registers_i.pc_id_i\[25\] cs_registers_i.pc_id_i\[26\]
+ _08954_ VDD VSS AND4_X1
X_26787_ _08929_ _08954_ _08955_ VDD VSS NAND2_X1
X_26788_ _00061_ _08955_ _08956_ VDD VSS XNOR2_X1
X_26789_ id_stage_i.controller_i.lsu_addr_last_i\[27\] _08792_
+ _08870_ _10500_ _08957_ VDD VSS AOI22_X1
X_26790_ _08956_ _08957_ _08854_ _08958_ VDD VSS MUX2_X1
X_26791_ _07709_ _08633_ _08948_ _08958_ _08959_ VDD VSS OAI22_X2
X_26792_ _08959_ cs_registers_i.mtval_q\[27\] _08926_ _02078_
+ VDD VSS MUX2_X1
X_26793_ _03607_ _08791_ id_stage_i.controller_i.lsu_addr_last_i\[28\]
+ _08869_ net320 _08960_ VDD VSS AOI221_X2
X_26794_ cs_registers_i.pc_id_i\[27\] _08954_ _08961_ VDD
+ VSS AND2_X1
X_26795_ _08935_ _08961_ _08962_ VDD VSS NAND2_X1
X_26796_ _00062_ _08962_ _08963_ VDD VSS XNOR2_X1
X_26797_ _08960_ _08963_ _08801_ _08964_ VDD VSS AOI21_X2
X_26798_ _08798_ _08939_ _08964_ _08595_ _07718_ _08965_ VDD
+ VSS AOI221_X2
X_26799_ cs_registers_i.mtval_q\[28\] _08966_ VDD VSS INV_X1
X_26800_ _08965_ _08799_ _08966_ _02079_ VDD VSS AOI21_X1
X_26801_ cs_registers_i.pc_id_i\[28\] _08929_ _08961_ _08967_
+ VDD VSS NAND3_X1
X_26802_ _00063_ _08967_ _08968_ VDD VSS XNOR2_X1
X_26803_ id_stage_i.controller_i.lsu_addr_last_i\[29\] _08792_
+ _08870_ _10502_ _08969_ VDD VSS AOI22_X1
X_26804_ _08968_ _08969_ _08854_ _08970_ VDD VSS MUX2_X1
X_26805_ _07728_ _08633_ _08948_ _08970_ _08971_ VDD VSS OAI22_X2
X_26806_ _08971_ cs_registers_i.mtval_q\[29\] _08926_ _02080_
+ VDD VSS MUX2_X1
X_26807_ _00015_ _00016_ _08813_ _08972_ VDD VSS MUX2_X2
X_26808_ _08599_ _08603_ _11435_ _08972_ _08815_ _08973_ VDD
+ VSS OAI221_X1
X_26809_ _00012_ _08803_ _08974_ VDD VSS NOR2_X1
X_26810_ _08974_ _15537_ _08803_ _08975_ VDD VSS AOI21_X1
X_26811_ _08875_ _08975_ _08976_ VDD VSS NAND2_X1
X_26812_ _08597_ _08819_ _08973_ _08976_ _08977_ VDD VSS NAND4_X1
X_26813_ _08977_ _08905_ _07492_ _08978_ VDD VSS OAI21_X1
X_26814_ _08978_ cs_registers_i.mtval_q\[2\] _08926_ _02081_
+ VDD VSS MUX2_X1
X_26815_ cs_registers_i.pc_id_i\[28\] cs_registers_i.pc_id_i\[29\]
+ _08961_ _08979_ VDD VSS AND3_X1
X_26816_ _08935_ _08979_ _08980_ VDD VSS NAND2_X1
X_26817_ _00064_ _08980_ _08981_ VDD VSS XNOR2_X1
X_26818_ id_stage_i.controller_i.lsu_addr_last_i\[30\] _08792_
+ _08870_ _10498_ _08982_ VDD VSS AOI22_X1
X_26819_ _08981_ _08982_ _08854_ _08983_ VDD VSS MUX2_X1
X_26820_ _07983_ _08633_ _08948_ _08983_ _08984_ VDD VSS OAI22_X1
X_26821_ _08984_ cs_registers_i.mtval_q\[30\] _08926_ _02082_
+ VDD VSS MUX2_X1
X_26822_ id_stage_i.controller_i.lsu_addr_last_i\[31\] _08792_
+ _08870_ _10509_ _08985_ VDD VSS AOI22_X1
X_26823_ _08599_ _08985_ _08986_ VDD VSS NAND2_X1
X_26824_ cs_registers_i.pc_id_i\[30\] _08929_ _08979_ _08987_
+ VDD VSS NAND3_X1
X_26825_ _00065_ _08987_ _08988_ VDD VSS XOR2_X1
X_26826_ _08986_ _08988_ _08599_ _08989_ VDD VSS OAI21_X1
X_26827_ _07748_ _08633_ _08948_ _08989_ _08990_ VDD VSS OAI22_X1
X_26828_ _08990_ cs_registers_i.mtval_q\[31\] _08926_ _02083_
+ VDD VSS MUX2_X1
X_26829_ _00019_ _08820_ _08991_ VDD VSS XNOR2_X1
X_26830_ _08802_ _08991_ _08992_ VDD VSS NAND2_X1
X_26831_ id_stage_i.controller_i.lsu_addr_last_i\[3\] _08993_
+ VDD VSS INV_X1
X_26832_ _00017_ _00018_ _08813_ _08994_ VDD VSS MUX2_X2
X_26833_ _08854_ _08603_ _08993_ _08994_ _08815_ _08995_ VDD
+ VSS OAI221_X1
X_26834_ _08597_ _08819_ _08992_ _08995_ _08996_ VDD VSS NAND4_X1
X_26835_ _08996_ _08905_ _07791_ _08997_ VDD VSS OAI21_X1
X_26836_ _08997_ cs_registers_i.mtval_q\[3\] _08926_ _02084_
+ VDD VSS MUX2_X1
X_26837_ _10675_ cs_registers_i.pc_id_i\[2\] _11517_ _08803_
+ _08998_ VDD VSS NAND4_X1
X_26838_ _00022_ _08998_ _08999_ VDD VSS XNOR2_X1
X_26839_ _08802_ _08999_ _09000_ VDD VSS NAND2_X1
X_26840_ _00020_ _00021_ _08813_ _09001_ VDD VSS MUX2_X1
X_26841_ _08854_ _08602_ _11556_ _09001_ _08815_ _09002_ VDD
+ VSS OAI221_X1
X_26842_ _08597_ _08819_ _09000_ _09002_ _09003_ VDD VSS NAND4_X1
X_26843_ _09003_ _08905_ _07800_ _09004_ VDD VSS OAI21_X1
X_26844_ _09004_ cs_registers_i.mtval_q\[4\] _08926_ _02085_
+ VDD VSS MUX2_X1
X_26845_ id_stage_i.controller_i.lsu_addr_last_i\[5\] _09005_
+ VDD VSS INV_X1
X_26846_ _00023_ _00024_ _10338_ _09006_ VDD VSS MUX2_X1
X_26847_ _08598_ _08602_ _09005_ _09006_ _08601_ _09007_ VDD
+ VSS OAI221_X1
X_26848_ _11517_ cs_registers_i.pc_id_i\[4\] _08803_ _15536_
+ _09008_ VDD VSS NAND4_X1
X_26849_ _00025_ _09008_ _09009_ VDD VSS XOR2_X1
X_26850_ _09007_ _09009_ _08598_ _09010_ VDD VSS OAI21_X1
X_26851_ _08621_ _09010_ _09011_ VDD VSS NOR2_X1
X_26852_ _07810_ _09011_ _08620_ _09012_ VDD VSS MUX2_X1
X_26853_ _09012_ cs_registers_i.mtval_q\[5\] _08798_ _02086_
+ VDD VSS MUX2_X1
X_26854_ _08804_ _08805_ _09013_ VDD VSS NOR2_X1
X_26855_ _00027_ _09013_ _09014_ VDD VSS XOR2_X1
X_26856_ _08802_ _09014_ _09015_ VDD VSS NAND2_X1
X_26857_ id_stage_i.controller_i.lsu_addr_last_i\[6\] _09016_
+ VDD VSS INV_X1
X_26858_ _10301_ _00026_ _10338_ _09017_ VDD VSS MUX2_X1
X_26859_ _08854_ _08602_ _09016_ _09017_ _08815_ _09018_ VDD
+ VSS OAI221_X1
X_26860_ _08597_ _08819_ _09015_ _09018_ _09019_ VDD VSS NAND4_X1
X_26861_ _09019_ _08905_ _07821_ _09020_ VDD VSS OAI21_X1
X_26862_ _09020_ cs_registers_i.mtval_q\[6\] _08798_ _02087_
+ VDD VSS MUX2_X1
X_26863_ _08803_ _15536_ _08806_ _09021_ VDD VSS NAND3_X1
X_26864_ _00029_ _09021_ _09022_ VDD VSS XNOR2_X1
X_26865_ _08802_ _09022_ _09023_ VDD VSS NAND2_X1
X_26866_ id_stage_i.controller_i.lsu_addr_last_i\[7\] _09024_
+ VDD VSS INV_X1
X_26867_ _00216_ _00028_ _10338_ _09025_ VDD VSS MUX2_X1
X_26868_ _08854_ _08602_ _09024_ _09025_ _08601_ _09026_ VDD
+ VSS OAI221_X1
X_26869_ _08597_ _08819_ _09023_ _09026_ _09027_ VDD VSS NAND4_X1
X_26870_ _09027_ _08905_ _07828_ _09028_ VDD VSS OAI21_X1
X_26871_ _09028_ cs_registers_i.mtval_q\[7\] _08798_ _02088_
+ VDD VSS MUX2_X1
X_26872_ cs_registers_i.mtval_q\[8\] _08799_ _09029_ VDD VSS
+ NAND2_X1
X_26873_ id_stage_i.controller_i.lsu_addr_last_i\[8\] _09030_
+ VDD VSS INV_X1
X_26874_ _00030_ _00031_ _10338_ _09031_ VDD VSS MUX2_X2
X_26875_ _08598_ _08602_ _09030_ _09031_ _08601_ _09032_ VDD
+ VSS OAI221_X2
X_26876_ _00032_ _08808_ _09033_ VDD VSS XNOR2_X1
X_26877_ _09032_ _09033_ _08599_ _09034_ VDD VSS OAI21_X1
X_26878_ _08621_ _08596_ _09034_ _09035_ VDD VSS NOR3_X1
X_26879_ _09035_ _08757_ _07844_ _09036_ VDD VSS AOI21_X1
X_26880_ _09029_ _09036_ _08799_ _02089_ VDD VSS OAI21_X1
X_26881_ id_stage_i.controller_i.lsu_addr_last_i\[9\] _09037_
+ VDD VSS INV_X1
X_26882_ _00033_ _00034_ _10338_ _09038_ VDD VSS MUX2_X2
X_26883_ _08598_ _08602_ _09037_ _09038_ _08601_ _09039_ VDD
+ VSS OAI221_X1
X_26884_ _11788_ _08821_ _09040_ VDD VSS NAND2_X1
X_26885_ _00035_ _09040_ _09041_ VDD VSS XOR2_X2
X_26886_ _09039_ _09041_ _08598_ _09042_ VDD VSS OAI21_X1
X_26887_ _08621_ _09042_ _09043_ VDD VSS NOR2_X1
X_26888_ _07854_ _09043_ _08620_ _09044_ VDD VSS MUX2_X1
X_26889_ _09044_ cs_registers_i.mtval_q\[9\] _08798_ _02090_
+ VDD VSS MUX2_X1
X_26890_ _05199_ _07488_ _09045_ VDD VSS NAND2_X2
X_26891_ _09045_ _09046_ VDD VSS CLKBUF_X3
X_26892_ cs_registers_i.csr_mtvec_o\[10\] _09046_ _09047_
+ VDD VSS NAND2_X1
X_26893_ _09047_ _09046_ _07525_ _09048_ VDD VSS OAI21_X1
X_26894_ _03876_ _09049_ VDD VSS CLKBUF_X3
X_26895_ net3 _09048_ _09049_ _02091_ VDD VSS MUX2_X1
X_26896_ _09045_ _09050_ VDD VSS CLKBUF_X3
X_26897_ _08275_ cs_registers_i.csr_mtvec_o\[11\] _09050_
+ _09051_ VDD VSS MUX2_X1
X_26898_ net4 _09051_ _09049_ _02092_ VDD VSS MUX2_X1
X_26899_ _08444_ cs_registers_i.csr_mtvec_o\[12\] _09050_
+ _09052_ VDD VSS MUX2_X1
X_26900_ net5 _09052_ _09049_ _02093_ VDD VSS MUX2_X1
X_26901_ _09045_ _09053_ VDD VSS BUF_X4
X_26902_ _07569_ cs_registers_i.csr_mtvec_o\[13\] _09053_
+ _09054_ VDD VSS MUX2_X1
X_26903_ net6 _09054_ _09049_ _02094_ VDD VSS MUX2_X1
X_26904_ _07579_ cs_registers_i.csr_mtvec_o\[14\] _09053_
+ _09055_ VDD VSS MUX2_X1
X_26905_ net7 _09055_ _09049_ _02095_ VDD VSS MUX2_X1
X_26906_ _08299_ cs_registers_i.csr_mtvec_o\[15\] _09053_
+ _09056_ VDD VSS MUX2_X1
X_26907_ net8 _09056_ _09049_ _02096_ VDD VSS MUX2_X1
X_26908_ _07600_ cs_registers_i.csr_mtvec_o\[16\] _09053_
+ _09057_ VDD VSS MUX2_X1
X_26909_ net9 _09057_ _09049_ _02097_ VDD VSS MUX2_X1
X_26910_ cs_registers_i.csr_mtvec_o\[17\] _09050_ _09058_
+ VDD VSS NAND2_X1
X_26911_ _09058_ _09046_ _08312_ _09059_ VDD VSS OAI21_X1
X_26912_ net10 _09059_ _09049_ _02098_ VDD VSS MUX2_X1
X_26913_ _07914_ cs_registers_i.csr_mtvec_o\[18\] _09053_
+ _09060_ VDD VSS MUX2_X1
X_26914_ net11 _09060_ _09049_ _02099_ VDD VSS MUX2_X1
X_26915_ cs_registers_i.csr_mtvec_o\[19\] _09050_ _09061_
+ VDD VSS NAND2_X1
X_26916_ _09061_ _09046_ _07624_ _09062_ VDD VSS OAI21_X1
X_26917_ net12 _09062_ _09049_ _02100_ VDD VSS MUX2_X1
X_26918_ cs_registers_i.csr_mtvec_o\[20\] _09050_ _09063_
+ VDD VSS NAND2_X1
X_26919_ _09063_ _09046_ _07640_ _09064_ VDD VSS OAI21_X1
X_26920_ _03876_ _09065_ VDD VSS CLKBUF_X3
X_26921_ net13 _09064_ _09065_ _02101_ VDD VSS MUX2_X1
X_26922_ _08343_ cs_registers_i.csr_mtvec_o\[21\] _09053_
+ _09066_ VDD VSS MUX2_X1
X_26923_ net14 _09066_ _09065_ _02102_ VDD VSS MUX2_X1
X_26924_ cs_registers_i.csr_mtvec_o\[22\] _09050_ _09067_
+ VDD VSS NAND2_X1
X_26925_ _09067_ _09046_ _07657_ _09068_ VDD VSS OAI21_X1
X_26926_ net15 _09068_ _09065_ _02103_ VDD VSS MUX2_X1
X_26927_ _08355_ cs_registers_i.csr_mtvec_o\[23\] _09053_
+ _09069_ VDD VSS MUX2_X1
X_26928_ net16 _09069_ _09065_ _02104_ VDD VSS MUX2_X1
X_26929_ _08149_ cs_registers_i.csr_mtvec_o\[24\] _09053_
+ _09070_ VDD VSS MUX2_X1
X_26930_ net17 _09070_ _09065_ _02105_ VDD VSS MUX2_X1
X_26931_ _07689_ cs_registers_i.csr_mtvec_o\[25\] _09053_
+ _09071_ VDD VSS MUX2_X1
X_26932_ net18 _09071_ _09065_ _02106_ VDD VSS MUX2_X1
X_26933_ cs_registers_i.csr_mtvec_o\[26\] _09050_ _09072_
+ VDD VSS NAND2_X1
X_26934_ _09072_ _09046_ _08163_ _09073_ VDD VSS OAI21_X1
X_26935_ net19 _09073_ _09065_ _02107_ VDD VSS MUX2_X1
X_26936_ cs_registers_i.csr_mtvec_o\[27\] _09050_ _09074_
+ VDD VSS NAND2_X1
X_26937_ _09074_ _09046_ _07709_ _09075_ VDD VSS OAI21_X1
X_26938_ net20 _09075_ _09065_ _02108_ VDD VSS MUX2_X1
X_26939_ _07718_ cs_registers_i.csr_mtvec_o\[28\] _09053_
+ _09076_ VDD VSS MUX2_X1
X_26940_ net21 _09076_ _09065_ _02109_ VDD VSS MUX2_X1
X_26941_ cs_registers_i.csr_mtvec_o\[29\] _09050_ _09077_
+ VDD VSS NAND2_X1
X_26942_ _09077_ _09046_ _07728_ _09078_ VDD VSS OAI21_X1
X_26943_ net22 _09078_ _09065_ _02110_ VDD VSS MUX2_X1
X_26944_ cs_registers_i.csr_mtvec_o\[30\] _09050_ _09079_
+ VDD VSS NAND2_X1
X_26945_ _09079_ _09046_ _07983_ _09080_ VDD VSS OAI21_X1
X_26946_ net23 _09080_ _03876_ _02111_ VDD VSS MUX2_X1
X_26947_ _08405_ cs_registers_i.csr_mtvec_o\[31\] _09045_
+ _09081_ VDD VSS MUX2_X1
X_26948_ net24 _09081_ _03876_ _02112_ VDD VSS MUX2_X1
X_26949_ _07844_ cs_registers_i.csr_mtvec_o\[8\] _09045_ _09082_
+ VDD VSS MUX2_X1
X_26950_ net25 _09082_ _03876_ _02113_ VDD VSS MUX2_X1
X_26951_ _07854_ cs_registers_i.csr_mtvec_o\[9\] _09045_ _09083_
+ VDD VSS MUX2_X1
X_26952_ net26 _09083_ _03876_ _02114_ VDD VSS MUX2_X1
X_26953_ _03647_ _03451_ _06387_ _09084_ VDD VSS NAND3_X1
X_26954_ _03646_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_by_zero_q
+ _09084_ _02115_ VDD VSS MUX2_X1
X_26955_ _06412_ _03615_ _09085_ VDD VSS NAND2_X1
X_26956_ _03617_ _03647_ _03611_ _15538_ _09086_ VDD VSS NOR4_X1
X_26957_ _09085_ _09086_ _03615_ _02116_ VDD VSS OAI21_X1
X_26958_ _03617_ _03647_ _03611_ _09087_ VDD VSS NOR3_X1
X_26959_ _06421_ _09087_ _09088_ VDD VSS NAND2_X1
X_26960_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]
+ _09088_ _03451_ _02117_ VDD VSS MUX2_X1
X_26961_ _03445_ _03615_ _09089_ VDD VSS NAND2_X1
X_26962_ _03617_ _03647_ _03611_ _06428_ _09090_ VDD VSS NOR4_X1
X_26963_ _09089_ _09090_ _03615_ _02118_ VDD VSS OAI21_X1
X_26964_ _03444_ _03615_ _09091_ VDD VSS NAND2_X1
X_26965_ _03617_ _03647_ _03611_ _06418_ _09092_ VDD VSS NOR4_X1
X_26966_ _09091_ _09092_ _03615_ _02119_ VDD VSS OAI21_X1
X_26967_ _06446_ _09087_ _09093_ VDD VSS NAND2_X1
X_26968_ _06613_ _09093_ _03451_ _02120_ VDD VSS MUX2_X1
X_26969_ _04045_ alu_adder_result_ex\[0\] _03791_ _09094_
+ VDD VSS MUX2_X1
X_26970_ _04038_ _03441_ _09095_ VDD VSS NOR2_X4
X_26971_ _09095_ _09096_ VDD VSS CLKBUF_X3
X_26972_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[0\]
+ _09094_ _09096_ _02121_ VDD VSS MUX2_X1
X_26973_ _11898_ alu_adder_result_ex\[10\] _03791_ _09097_
+ VDD VSS MUX2_X1
X_26974_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[10\]
+ _09097_ _09096_ _02122_ VDD VSS MUX2_X1
X_26975_ _11398_ alu_adder_result_ex\[11\] _03791_ _09098_
+ VDD VSS MUX2_X1
X_26976_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[11\]
+ _09098_ _09096_ _02123_ VDD VSS MUX2_X1
X_26977_ _10868_ alu_adder_result_ex\[12\] _03791_ _09099_
+ VDD VSS MUX2_X1
X_26978_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[12\]
+ _09099_ _09096_ _02124_ VDD VSS MUX2_X1
X_26979_ _12075_ alu_adder_result_ex\[13\] _03791_ _09100_
+ VDD VSS MUX2_X1
X_26980_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[13\]
+ _09100_ _09096_ _02125_ VDD VSS MUX2_X1
X_26981_ _12177_ net395 _03791_ _09101_ VDD VSS MUX2_X1
X_26982_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[14\]
+ _09101_ _09096_ _02126_ VDD VSS MUX2_X1
X_26983_ _12254_ alu_adder_result_ex\[15\] _03791_ _09102_
+ VDD VSS MUX2_X1
X_26984_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[15\]
+ _09102_ _09096_ _02127_ VDD VSS MUX2_X1
X_26985_ _12350_ alu_adder_result_ex\[16\] _03791_ _09103_
+ VDD VSS MUX2_X1
X_26986_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[16\]
+ _09103_ _09096_ _02128_ VDD VSS MUX2_X1
X_26987_ _12425_ alu_adder_result_ex\[17\] _03791_ _09104_
+ VDD VSS MUX2_X1
X_26988_ _09095_ _09105_ VDD VSS CLKBUF_X3
X_26989_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[17\]
+ _09104_ _09105_ _02129_ VDD VSS MUX2_X1
X_26990_ _03790_ _09106_ VDD VSS CLKBUF_X3
X_26991_ _12514_ net381 _09106_ _09107_ VDD VSS MUX2_X1
X_26992_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[18\]
+ _09107_ _09105_ _02130_ VDD VSS MUX2_X1
X_26993_ _12589_ net403 _09106_ _09108_ VDD VSS MUX2_X1
X_26994_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[19\]
+ _09108_ _09105_ _02131_ VDD VSS MUX2_X1
X_26995_ _03681_ alu_adder_result_ex\[1\] _09106_ _09109_
+ VDD VSS MUX2_X1
X_26996_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[1\]
+ _09109_ _09105_ _02132_ VDD VSS MUX2_X1
X_26997_ net359 alu_adder_result_ex\[20\] _09106_ _09110_
+ VDD VSS MUX2_X1
X_26998_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[20\]
+ _09110_ _09105_ _02133_ VDD VSS MUX2_X1
X_26999_ net377 net386 _09106_ _09111_ VDD VSS MUX2_X1
X_27000_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[21\]
+ _09111_ _09105_ _02134_ VDD VSS MUX2_X1
X_27001_ _03713_ net396 _09106_ _09112_ VDD VSS MUX2_X1
X_27002_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[22\]
+ _09112_ _09105_ _02135_ VDD VSS MUX2_X1
X_27003_ _03724_ net392 _09106_ _09113_ VDD VSS MUX2_X1
X_27004_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[23\]
+ _09113_ _09105_ _02136_ VDD VSS MUX2_X1
X_27005_ _03733_ alu_adder_result_ex\[24\] _09106_ _09114_
+ VDD VSS MUX2_X1
X_27006_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[24\]
+ _09114_ _09105_ _02137_ VDD VSS MUX2_X1
X_27007_ _13097_ net387 _09106_ _09115_ VDD VSS MUX2_X1
X_27008_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[25\]
+ _09115_ _09105_ _02138_ VDD VSS MUX2_X1
X_27009_ net357 net399 _09106_ _09116_ VDD VSS MUX2_X1
X_27010_ _09095_ _09117_ VDD VSS CLKBUF_X3
X_27011_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[26\]
+ _09116_ _09117_ _02139_ VDD VSS MUX2_X1
X_27012_ _03790_ _09118_ VDD VSS CLKBUF_X3
X_27013_ net351 net391 _09118_ _09119_ VDD VSS MUX2_X1
X_27014_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[27\]
+ _09119_ _09117_ _02140_ VDD VSS MUX2_X1
X_27015_ _03762_ alu_adder_result_ex\[28\] _09118_ _09120_
+ VDD VSS MUX2_X1
X_27016_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[28\]
+ _09120_ _09117_ _02141_ VDD VSS MUX2_X1
X_27017_ _03769_ net246 _09118_ _09121_ VDD VSS MUX2_X1
X_27018_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[29\]
+ _09121_ _09117_ _02142_ VDD VSS MUX2_X1
X_27019_ net297 alu_adder_result_ex\[2\] _09118_ _09122_ VDD
+ VSS MUX2_X1
X_27020_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[2\]
+ _09122_ _09117_ _02143_ VDD VSS MUX2_X1
X_27021_ _03311_ alu_adder_result_ex\[30\] _09118_ _09123_
+ VDD VSS MUX2_X1
X_27022_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[30\]
+ _09123_ _09117_ _02144_ VDD VSS MUX2_X1
X_27023_ _09096_ _03789_ net323 _03371_ _03386_ _09124_ VDD
+ VSS OAI221_X1
X_27024_ _09124_ _09096_ _06408_ _02145_ VDD VSS OAI21_X1
X_27025_ net318 alu_adder_result_ex\[3\] _09118_ _09125_ VDD
+ VSS MUX2_X1
X_27026_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[3\]
+ _09125_ _09117_ _02146_ VDD VSS MUX2_X1
X_27027_ _11591_ alu_adder_result_ex\[4\] _09118_ _09126_
+ VDD VSS MUX2_X1
X_27028_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[4\]
+ _09126_ _09117_ _02147_ VDD VSS MUX2_X1
X_27029_ _11629_ alu_adder_result_ex\[5\] _09118_ _09127_
+ VDD VSS MUX2_X1
X_27030_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[5\]
+ _09127_ _09117_ _02148_ VDD VSS MUX2_X1
X_27031_ _11672_ alu_adder_result_ex\[6\] _09118_ _09128_
+ VDD VSS MUX2_X1
X_27032_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[6\]
+ _09128_ _09117_ _02149_ VDD VSS MUX2_X1
X_27033_ _03723_ alu_adder_result_ex\[7\] _09118_ _09129_
+ VDD VSS MUX2_X1
X_27034_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[7\]
+ _09129_ _09095_ _02150_ VDD VSS MUX2_X1
X_27035_ _03732_ alu_adder_result_ex\[8\] _03790_ _09130_
+ VDD VSS MUX2_X1
X_27036_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[8\]
+ _09130_ _09095_ _02151_ VDD VSS MUX2_X1
X_27037_ _11824_ alu_adder_result_ex\[9\] _03790_ _09131_
+ VDD VSS MUX2_X1
X_27038_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[9\]
+ _09131_ _09095_ _02152_ VDD VSS MUX2_X1
X_27039_ _03451_ _03617_ _03431_ _09132_ VDD VSS OAI21_X2
X_27040_ _09132_ _09133_ VDD VSS CLKBUF_X3
X_27041_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[0\]
+ _09133_ _09134_ VDD VSS NAND2_X1
X_27042_ _03614_ _03451_ _09135_ VDD VSS NAND2_X2
X_27043_ _09134_ _09135_ _06402_ _02153_ VDD VSS OAI21_X1
X_27044_ _03432_ _03441_ _09136_ VDD VSS NOR2_X4
X_27045_ _09136_ _09137_ VDD VSS CLKBUF_X3
X_27046_ _06551_ _09137_ _09133_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[10\]
+ _09138_ VDD VSS AOI22_X1
X_27047_ _09138_ _02154_ VDD VSS INV_X1
X_27048_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[11\]
+ _09133_ _09139_ VDD VSS NAND2_X1
X_27049_ _00079_ _09140_ VDD VSS INV_X1
X_27050_ _06484_ _09141_ VDD VSS INV_X1
X_27051_ _09140_ _09141_ _06544_ _09142_ VDD VSS AOI21_X1
X_27052_ _09139_ _09135_ _09142_ _02155_ VDD VSS OAI21_X1
X_27053_ _06571_ _09137_ _09133_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[12\]
+ _09143_ VDD VSS AOI22_X1
X_27054_ _09143_ _02156_ VDD VSS INV_X1
X_27055_ _06581_ _09137_ _09133_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[13\]
+ _09144_ VDD VSS AOI22_X1
X_27056_ _09144_ _02157_ VDD VSS INV_X1
X_27057_ _09132_ _09145_ VDD VSS CLKBUF_X3
X_27058_ _06591_ _09137_ _09145_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[14\]
+ _09146_ VDD VSS AOI22_X1
X_27059_ _09146_ _02158_ VDD VSS INV_X1
X_27060_ _06601_ _09137_ _09145_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[15\]
+ _09147_ VDD VSS AOI22_X1
X_27061_ _09147_ _02159_ VDD VSS INV_X1
X_27062_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[16\]
+ _09133_ _09148_ VDD VSS NAND2_X1
X_27063_ _09148_ _09135_ _06615_ _02160_ VDD VSS OAI21_X1
X_27064_ _06622_ _09137_ _09145_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[17\]
+ _09149_ VDD VSS AOI22_X1
X_27065_ _09149_ _02161_ VDD VSS INV_X1
X_27066_ _06631_ _09137_ _09145_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[18\]
+ _09150_ VDD VSS AOI22_X1
X_27067_ _09150_ _02162_ VDD VSS INV_X1
X_27068_ _06640_ _09137_ _09145_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[19\]
+ _09151_ VDD VSS AOI22_X1
X_27069_ _09151_ _02163_ VDD VSS INV_X1
X_27070_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[1\]
+ _09133_ _09152_ VDD VSS NAND2_X1
X_27071_ _09152_ _09135_ _06462_ _02164_ VDD VSS OAI21_X1
X_27072_ _06648_ _09137_ _09145_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[20\]
+ _09153_ VDD VSS AOI22_X1
X_27073_ _09153_ _02165_ VDD VSS INV_X1
X_27074_ _06658_ _09137_ _09145_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[21\]
+ _09154_ VDD VSS AOI22_X1
X_27075_ _09154_ _02166_ VDD VSS INV_X1
X_27076_ _09136_ _09155_ VDD VSS CLKBUF_X3
X_27077_ _06665_ _09155_ _09145_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[22\]
+ _09156_ VDD VSS AOI22_X1
X_27078_ _09156_ _02167_ VDD VSS INV_X1
X_27079_ _06674_ _09155_ _09145_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[23\]
+ _09157_ VDD VSS AOI22_X1
X_27080_ _09157_ _02168_ VDD VSS INV_X1
X_27081_ _06683_ _09155_ _09145_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[24\]
+ _09158_ VDD VSS AOI22_X1
X_27082_ _09158_ _02169_ VDD VSS INV_X1
X_27083_ _09132_ _09159_ VDD VSS CLKBUF_X3
X_27084_ _06692_ _09155_ _09159_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[25\]
+ _09160_ VDD VSS AOI22_X1
X_27085_ _09160_ _02170_ VDD VSS INV_X1
X_27086_ _06702_ _09155_ _09159_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[26\]
+ _09161_ VDD VSS AOI22_X1
X_27087_ _09161_ _02171_ VDD VSS INV_X1
X_27088_ _09135_ _06711_ _00095_ _09162_ VDD VSS AOI21_X1
X_27089_ _09162_ _09133_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[27\]
+ _09163_ VDD VSS AOI21_X1
X_27090_ _09163_ _02172_ VDD VSS INV_X1
X_27091_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[28\]
+ _09133_ _09164_ VDD VSS NAND2_X1
X_27092_ _09164_ _09135_ _06726_ _02173_ VDD VSS OAI21_X1
X_27093_ _06733_ _09155_ _09159_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[29\]
+ _09165_ VDD VSS AOI22_X1
X_27094_ _09165_ _02174_ VDD VSS INV_X1
X_27095_ _06471_ _09155_ _09159_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[2\]
+ _09166_ VDD VSS AOI22_X1
X_27096_ _09166_ _02175_ VDD VSS INV_X1
X_27097_ _06741_ _09155_ _09159_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[30\]
+ _09167_ VDD VSS AOI22_X1
X_27098_ _09167_ _02176_ VDD VSS INV_X1
X_27099_ _06751_ _09155_ _09159_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[31\]
+ _09168_ VDD VSS AOI22_X1
X_27100_ _09168_ _02177_ VDD VSS INV_X1
X_27101_ _06485_ _09155_ _09159_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[3\]
+ _09169_ VDD VSS AOI22_X1
X_27102_ _09169_ _02178_ VDD VSS INV_X1
X_27103_ _06496_ _09136_ _09159_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[4\]
+ _09170_ VDD VSS AOI22_X1
X_27104_ _09170_ _02179_ VDD VSS INV_X1
X_27105_ _06506_ _09136_ _09159_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[5\]
+ _09171_ VDD VSS AOI22_X1
X_27106_ _09171_ _02180_ VDD VSS INV_X1
X_27107_ _06515_ _09136_ _09159_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[6\]
+ _09172_ VDD VSS AOI22_X1
X_27108_ _09172_ _02181_ VDD VSS INV_X1
X_27109_ _06523_ _09136_ _09132_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[7\]
+ _09173_ VDD VSS AOI22_X1
X_27110_ _09173_ _02182_ VDD VSS INV_X1
X_27111_ _06532_ _09136_ _09132_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[8\]
+ _09174_ VDD VSS AOI22_X1
X_27112_ _09174_ _02183_ VDD VSS INV_X1
X_27113_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[9\]
+ _09133_ _09175_ VDD VSS NAND2_X1
X_27114_ _09175_ _09135_ _06545_ _02184_ VDD VSS OAI21_X1
X_27115_ fetch_enable_q net61 _02185_ VDD VSS OR2_X1
X_27116_ _05805_ _06245_ _09176_ VDD VSS AND2_X2
X_27117_ _09176_ _09177_ VDD VSS BUF_X4
X_27118_ gen_regfile_ff.register_file_i.rf_reg\[32\] _06223_
+ _09177_ _02186_ VDD VSS MUX2_X1
X_27119_ _05543_ _09178_ VDD VSS BUF_X2
X_27120_ gen_regfile_ff.register_file_i.rf_reg\[132\] _09178_
+ _06229_ _02187_ VDD VSS MUX2_X1
X_27121_ _05579_ _09179_ VDD VSS BUF_X2
X_27122_ gen_regfile_ff.register_file_i.rf_reg\[133\] _09179_
+ _06229_ _02188_ VDD VSS MUX2_X1
X_27123_ _05613_ _09180_ VDD VSS BUF_X2
X_27124_ gen_regfile_ff.register_file_i.rf_reg\[134\] _09180_
+ _06229_ _02189_ VDD VSS MUX2_X1
X_27125_ _05652_ _09181_ VDD VSS BUF_X2
X_27126_ gen_regfile_ff.register_file_i.rf_reg\[135\] _09181_
+ _06229_ _02190_ VDD VSS MUX2_X1
X_27127_ gen_regfile_ff.register_file_i.rf_reg\[136\] _06240_
+ _09182_ VDD VSS NAND2_X1
X_27128_ _09182_ _06241_ _06222_ _02191_ VDD VSS OAI21_X1
X_27129_ _05720_ _09183_ VDD VSS BUF_X2
X_27130_ _06228_ _09184_ VDD VSS BUF_X4
X_27131_ gen_regfile_ff.register_file_i.rf_reg\[137\] _09183_
+ _09184_ _02192_ VDD VSS MUX2_X1
X_27132_ _05761_ _09185_ VDD VSS BUF_X2
X_27133_ gen_regfile_ff.register_file_i.rf_reg\[138\] _09185_
+ _09184_ _02193_ VDD VSS MUX2_X1
X_27134_ _05801_ _09186_ VDD VSS BUF_X2
X_27135_ gen_regfile_ff.register_file_i.rf_reg\[139\] _09186_
+ _09184_ _02194_ VDD VSS MUX2_X1
X_27136_ gen_regfile_ff.register_file_i.rf_reg\[140\] _06229_
+ _09187_ VDD VSS NOR2_X1
X_27137_ _09187_ _06229_ _05850_ _02195_ VDD VSS AOI21_X1
X_27138_ _05889_ _09188_ VDD VSS BUF_X2
X_27139_ gen_regfile_ff.register_file_i.rf_reg\[141\] _09188_
+ _09184_ _02196_ VDD VSS MUX2_X1
X_27140_ gen_regfile_ff.register_file_i.rf_reg\[42\] _09185_
+ _09177_ _02197_ VDD VSS MUX2_X1
X_27141_ _05927_ _09189_ VDD VSS BUF_X2
X_27142_ gen_regfile_ff.register_file_i.rf_reg\[142\] _09189_
+ _09184_ _02198_ VDD VSS MUX2_X1
X_27143_ _05973_ _09190_ VDD VSS BUF_X4
X_27144_ gen_regfile_ff.register_file_i.rf_reg\[143\] _09190_
+ _09184_ _02199_ VDD VSS MUX2_X1
X_27145_ gen_regfile_ff.register_file_i.rf_reg\[144\] _06229_
+ _09191_ VDD VSS NOR2_X1
X_27146_ _09191_ _06229_ _06016_ _02200_ VDD VSS AOI21_X1
X_27147_ _06061_ _09192_ VDD VSS BUF_X2
X_27148_ gen_regfile_ff.register_file_i.rf_reg\[145\] _09192_
+ _09184_ _02201_ VDD VSS MUX2_X1
X_27149_ _06099_ _09193_ VDD VSS BUF_X2
X_27150_ gen_regfile_ff.register_file_i.rf_reg\[146\] _09193_
+ _09184_ _02202_ VDD VSS MUX2_X1
X_27151_ gen_regfile_ff.register_file_i.rf_reg\[147\] _06240_
+ _09194_ VDD VSS NAND2_X1
X_27152_ _09194_ _06241_ _06138_ _02203_ VDD VSS OAI21_X1
X_27153_ _06173_ _09195_ VDD VSS BUF_X4
X_27154_ gen_regfile_ff.register_file_i.rf_reg\[148\] _09195_
+ _09184_ _02204_ VDD VSS MUX2_X1
X_27155_ _06206_ _09196_ VDD VSS BUF_X2
X_27156_ gen_regfile_ff.register_file_i.rf_reg\[149\] _09196_
+ _09184_ _02205_ VDD VSS MUX2_X1
X_27157_ _04601_ _09197_ VDD VSS CLKBUF_X3
X_27158_ gen_regfile_ff.register_file_i.rf_reg\[150\] _09197_
+ _06228_ _02206_ VDD VSS MUX2_X1
X_27159_ _04765_ _09198_ VDD VSS BUF_X4
X_27160_ gen_regfile_ff.register_file_i.rf_reg\[151\] _09198_
+ _06228_ _02207_ VDD VSS MUX2_X1
X_27161_ gen_regfile_ff.register_file_i.rf_reg\[43\] _09186_
+ _09177_ _02208_ VDD VSS MUX2_X1
X_27162_ gen_regfile_ff.register_file_i.rf_reg\[152\] _06240_
+ _09199_ VDD VSS NAND2_X1
X_27163_ _09199_ _06241_ _04908_ _02209_ VDD VSS OAI21_X1
X_27164_ gen_regfile_ff.register_file_i.rf_reg\[153\] _06240_
+ _09200_ VDD VSS NAND2_X1
X_27165_ _09200_ _06241_ _04978_ _02210_ VDD VSS OAI21_X1
X_27166_ _05036_ _09201_ VDD VSS BUF_X2
X_27167_ gen_regfile_ff.register_file_i.rf_reg\[154\] _09201_
+ _06228_ _02211_ VDD VSS MUX2_X1
X_27168_ _04849_ _09202_ VDD VSS BUF_X4
X_27169_ gen_regfile_ff.register_file_i.rf_reg\[155\] net518
+ _06228_ _02212_ VDD VSS MUX2_X1
X_27170_ gen_regfile_ff.register_file_i.rf_reg\[156\] _05411_
+ _06228_ _02213_ VDD VSS MUX2_X1
X_27171_ gen_regfile_ff.register_file_i.rf_reg\[157\] _06240_
+ _09203_ VDD VSS NAND2_X1
X_27172_ _09203_ _06241_ _05148_ _02214_ VDD VSS OAI21_X1
X_27173_ gen_regfile_ff.register_file_i.rf_reg\[158\] _06208_
+ _06228_ _02215_ VDD VSS MUX2_X1
X_27174_ gen_regfile_ff.register_file_i.rf_reg\[159\] _06240_
+ _09204_ VDD VSS NAND2_X1
X_27175_ _09204_ net681 _06241_ _02216_ VDD VSS OAI21_X2
X_27176_ _05412_ _06225_ _06245_ _09205_ VDD VSS AND3_X1
X_27177_ _09205_ _09206_ VDD VSS BUF_X4
X_27178_ _09206_ _09207_ VDD VSS BUF_X4
X_27179_ gen_regfile_ff.register_file_i.rf_reg\[160\] _06223_
+ _09207_ _02217_ VDD VSS MUX2_X1
X_27180_ gen_regfile_ff.register_file_i.rf_reg\[161\] _06236_
+ _09207_ _02218_ VDD VSS MUX2_X1
X_27181_ gen_regfile_ff.register_file_i.rf_reg\[44\] _09177_
+ _09208_ VDD VSS NOR2_X1
X_27182_ _09208_ _09177_ _05850_ _02219_ VDD VSS AOI21_X1
X_27183_ _06224_ _06226_ _06245_ _09209_ VDD VSS NAND3_X4
X_27184_ _09209_ _09210_ VDD VSS BUF_X4
X_27185_ gen_regfile_ff.register_file_i.rf_reg\[162\] _09210_
+ _09211_ VDD VSS NAND2_X1
X_27186_ _09211_ _09210_ _05464_ _02220_ VDD VSS OAI21_X1
X_27187_ gen_regfile_ff.register_file_i.rf_reg\[163\] _09210_
+ _09212_ VDD VSS NAND2_X1
X_27188_ _09212_ _09210_ _05510_ _02221_ VDD VSS OAI21_X1
X_27189_ gen_regfile_ff.register_file_i.rf_reg\[164\] _09178_
+ _09207_ _02222_ VDD VSS MUX2_X1
X_27190_ gen_regfile_ff.register_file_i.rf_reg\[165\] _09179_
+ _09207_ _02223_ VDD VSS MUX2_X1
X_27191_ _09206_ _09213_ VDD VSS BUF_X4
X_27192_ gen_regfile_ff.register_file_i.rf_reg\[166\] _09180_
+ _09213_ _02224_ VDD VSS MUX2_X1
X_27193_ gen_regfile_ff.register_file_i.rf_reg\[167\] _09181_
+ _09213_ _02225_ VDD VSS MUX2_X1
X_27194_ gen_regfile_ff.register_file_i.rf_reg\[168\] _09207_
+ _09214_ VDD VSS NOR2_X1
X_27195_ _09214_ _09207_ _05688_ _02226_ VDD VSS AOI21_X1
X_27196_ gen_regfile_ff.register_file_i.rf_reg\[169\] _09183_
+ _09213_ _02227_ VDD VSS MUX2_X1
X_27197_ gen_regfile_ff.register_file_i.rf_reg\[170\] _09185_
+ _09213_ _02228_ VDD VSS MUX2_X1
X_27198_ gen_regfile_ff.register_file_i.rf_reg\[171\] _09186_
+ _09213_ _02229_ VDD VSS MUX2_X1
X_27199_ _05890_ gen_regfile_ff.register_file_i.rf_reg\[45\]
+ _06246_ _02230_ VDD VSS MUX2_X1
X_27200_ gen_regfile_ff.register_file_i.rf_reg\[172\] _09207_
+ _09215_ VDD VSS NOR2_X1
X_27201_ _09215_ _09207_ _05850_ _02231_ VDD VSS AOI21_X1
X_27202_ gen_regfile_ff.register_file_i.rf_reg\[173\] _09188_
+ _09213_ _02232_ VDD VSS MUX2_X1
X_27203_ gen_regfile_ff.register_file_i.rf_reg\[174\] _09189_
+ _09213_ _02233_ VDD VSS MUX2_X1
X_27204_ gen_regfile_ff.register_file_i.rf_reg\[175\] _09190_
+ _09213_ _02234_ VDD VSS MUX2_X1
X_27205_ gen_regfile_ff.register_file_i.rf_reg\[176\] _09207_
+ _09216_ VDD VSS NOR2_X1
X_27206_ _09216_ _09207_ _06016_ _02235_ VDD VSS AOI21_X1
X_27207_ gen_regfile_ff.register_file_i.rf_reg\[177\] _09192_
+ _09213_ _02236_ VDD VSS MUX2_X1
X_27208_ gen_regfile_ff.register_file_i.rf_reg\[178\] _09193_
+ _09213_ _02237_ VDD VSS MUX2_X1
X_27209_ gen_regfile_ff.register_file_i.rf_reg\[179\] _09210_
+ _09217_ VDD VSS NAND2_X1
X_27210_ _09217_ _09210_ _06138_ _02238_ VDD VSS OAI21_X1
X_27211_ gen_regfile_ff.register_file_i.rf_reg\[180\] _09195_
+ _09206_ _02239_ VDD VSS MUX2_X1
X_27212_ gen_regfile_ff.register_file_i.rf_reg\[181\] _09196_
+ _09206_ _02240_ VDD VSS MUX2_X1
X_27213_ _05928_ gen_regfile_ff.register_file_i.rf_reg\[46\]
+ _06246_ _02241_ VDD VSS MUX2_X1
X_27214_ gen_regfile_ff.register_file_i.rf_reg\[182\] _09197_
+ _09206_ _02242_ VDD VSS MUX2_X1
X_27215_ gen_regfile_ff.register_file_i.rf_reg\[183\] _09198_
+ _09206_ _02243_ VDD VSS MUX2_X1
X_27216_ gen_regfile_ff.register_file_i.rf_reg\[184\] _09209_
+ _09218_ VDD VSS NAND2_X1
X_27217_ _09218_ _09210_ _04908_ _02244_ VDD VSS OAI21_X1
X_27218_ gen_regfile_ff.register_file_i.rf_reg\[185\] _09209_
+ _09219_ VDD VSS NAND2_X1
X_27219_ _09219_ _09210_ _04978_ _02245_ VDD VSS OAI21_X1
X_27220_ gen_regfile_ff.register_file_i.rf_reg\[186\] _09201_
+ _09206_ _02246_ VDD VSS MUX2_X1
X_27221_ gen_regfile_ff.register_file_i.rf_reg\[187\] _09202_
+ _09206_ _02247_ VDD VSS MUX2_X1
X_27222_ gen_regfile_ff.register_file_i.rf_reg\[188\] _05411_
+ _09206_ _02248_ VDD VSS MUX2_X1
X_27223_ gen_regfile_ff.register_file_i.rf_reg\[189\] _09209_
+ _09220_ VDD VSS NAND2_X1
X_27224_ _09220_ _09210_ _05148_ _02249_ VDD VSS OAI21_X1
X_27225_ gen_regfile_ff.register_file_i.rf_reg\[190\] _06208_
+ _09206_ _02250_ VDD VSS MUX2_X1
X_27226_ gen_regfile_ff.register_file_i.rf_reg\[191\] _09209_
+ _09221_ VDD VSS NAND2_X1
X_27227_ _09221_ _05260_ _09210_ _02251_ VDD VSS OAI21_X4
X_27228_ gen_regfile_ff.register_file_i.rf_reg\[47\] _09190_
+ _09177_ _02252_ VDD VSS MUX2_X1
X_27229_ _10395_ _10902_ _09222_ VDD VSS NOR2_X2
X_27230_ _05412_ _04603_ _06225_ _09222_ _09223_ VDD VSS AND4_X1
X_27231_ _09223_ _09224_ VDD VSS BUF_X4
X_27232_ _09224_ _09225_ VDD VSS BUF_X4
X_27233_ gen_regfile_ff.register_file_i.rf_reg\[192\] _06223_
+ _09225_ _02253_ VDD VSS MUX2_X1
X_27234_ gen_regfile_ff.register_file_i.rf_reg\[193\] _06236_
+ _09225_ _02254_ VDD VSS MUX2_X1
X_27235_ _06224_ _04603_ _06226_ _09222_ _09226_ VDD VSS NAND4_X4
X_27236_ _09226_ _09227_ VDD VSS CLKBUF_X3
X_27237_ gen_regfile_ff.register_file_i.rf_reg\[194\] _09227_
+ _09228_ VDD VSS NAND2_X1
X_27238_ _09228_ _09227_ _05464_ _02255_ VDD VSS OAI21_X1
X_27239_ gen_regfile_ff.register_file_i.rf_reg\[195\] _09227_
+ _09229_ VDD VSS NAND2_X1
X_27240_ _09229_ _09227_ _05510_ _02256_ VDD VSS OAI21_X1
X_27241_ gen_regfile_ff.register_file_i.rf_reg\[196\] _09178_
+ _09225_ _02257_ VDD VSS MUX2_X1
X_27242_ gen_regfile_ff.register_file_i.rf_reg\[197\] _09179_
+ _09225_ _02258_ VDD VSS MUX2_X1
X_27243_ _09224_ _09230_ VDD VSS BUF_X4
X_27244_ gen_regfile_ff.register_file_i.rf_reg\[198\] _09180_
+ _09230_ _02259_ VDD VSS MUX2_X1
X_27245_ gen_regfile_ff.register_file_i.rf_reg\[199\] _09181_
+ _09230_ _02260_ VDD VSS MUX2_X1
X_27246_ gen_regfile_ff.register_file_i.rf_reg\[200\] _09225_
+ _09231_ VDD VSS NOR2_X1
X_27247_ _09231_ _09225_ _05688_ _02261_ VDD VSS AOI21_X1
X_27248_ gen_regfile_ff.register_file_i.rf_reg\[201\] _09183_
+ _09230_ _02262_ VDD VSS MUX2_X1
X_27249_ gen_regfile_ff.register_file_i.rf_reg\[48\] _09177_
+ _09232_ VDD VSS NOR2_X1
X_27250_ _09232_ _09177_ _06016_ _02263_ VDD VSS AOI21_X1
X_27251_ gen_regfile_ff.register_file_i.rf_reg\[202\] _09185_
+ _09230_ _02264_ VDD VSS MUX2_X1
X_27252_ gen_regfile_ff.register_file_i.rf_reg\[203\] _09186_
+ _09230_ _02265_ VDD VSS MUX2_X1
X_27253_ gen_regfile_ff.register_file_i.rf_reg\[204\] _09225_
+ _09233_ VDD VSS NOR2_X1
X_27254_ _09233_ _09225_ _05850_ _02266_ VDD VSS AOI21_X1
X_27255_ gen_regfile_ff.register_file_i.rf_reg\[205\] _09188_
+ _09230_ _02267_ VDD VSS MUX2_X1
X_27256_ gen_regfile_ff.register_file_i.rf_reg\[206\] _09189_
+ _09230_ _02268_ VDD VSS MUX2_X1
X_27257_ gen_regfile_ff.register_file_i.rf_reg\[207\] _09190_
+ _09230_ _02269_ VDD VSS MUX2_X1
X_27258_ gen_regfile_ff.register_file_i.rf_reg\[208\] _09225_
+ _09234_ VDD VSS NOR2_X1
X_27259_ _09234_ _09225_ _06016_ _02270_ VDD VSS AOI21_X1
X_27260_ gen_regfile_ff.register_file_i.rf_reg\[209\] _09192_
+ _09230_ _02271_ VDD VSS MUX2_X1
X_27261_ gen_regfile_ff.register_file_i.rf_reg\[210\] _09193_
+ _09230_ _02272_ VDD VSS MUX2_X1
X_27262_ gen_regfile_ff.register_file_i.rf_reg\[211\] _09227_
+ _09235_ VDD VSS NAND2_X1
X_27263_ _09235_ _09227_ _06138_ _02273_ VDD VSS OAI21_X1
X_27264_ _09176_ _09236_ VDD VSS BUF_X4
X_27265_ gen_regfile_ff.register_file_i.rf_reg\[49\] _09192_
+ _09236_ _02274_ VDD VSS MUX2_X1
X_27266_ gen_regfile_ff.register_file_i.rf_reg\[212\] _09195_
+ _09224_ _02275_ VDD VSS MUX2_X1
X_27267_ gen_regfile_ff.register_file_i.rf_reg\[213\] _09196_
+ _09224_ _02276_ VDD VSS MUX2_X1
X_27268_ gen_regfile_ff.register_file_i.rf_reg\[214\] _09197_
+ _09224_ _02277_ VDD VSS MUX2_X1
X_27269_ gen_regfile_ff.register_file_i.rf_reg\[215\] net686
+ _09224_ _02278_ VDD VSS MUX2_X1
X_27270_ gen_regfile_ff.register_file_i.rf_reg\[216\] _09226_
+ _09237_ VDD VSS NAND2_X1
X_27271_ _09237_ _09227_ _04908_ _02279_ VDD VSS OAI21_X1
X_27272_ gen_regfile_ff.register_file_i.rf_reg\[217\] _09226_
+ _09238_ VDD VSS NAND2_X1
X_27273_ _09238_ _09227_ _04978_ _02280_ VDD VSS OAI21_X1
X_27274_ gen_regfile_ff.register_file_i.rf_reg\[218\] _09201_
+ _09224_ _02281_ VDD VSS MUX2_X1
X_27275_ gen_regfile_ff.register_file_i.rf_reg\[219\] _09202_
+ _09224_ _02282_ VDD VSS MUX2_X1
X_27276_ gen_regfile_ff.register_file_i.rf_reg\[220\] _05411_
+ _09224_ _02283_ VDD VSS MUX2_X1
X_27277_ gen_regfile_ff.register_file_i.rf_reg\[221\] _09226_
+ _09239_ VDD VSS NAND2_X1
X_27278_ _09239_ _09227_ _05148_ _02284_ VDD VSS OAI21_X1
X_27279_ gen_regfile_ff.register_file_i.rf_reg\[50\] _09193_
+ _09236_ _02285_ VDD VSS MUX2_X1
X_27280_ gen_regfile_ff.register_file_i.rf_reg\[222\] _06208_
+ _09224_ _02286_ VDD VSS MUX2_X1
X_27281_ gen_regfile_ff.register_file_i.rf_reg\[223\] _09226_
+ _09240_ VDD VSS NAND2_X1
X_27282_ _09240_ net681 _09227_ _02287_ VDD VSS OAI21_X2
X_27283_ _05412_ _04852_ _06225_ _09241_ VDD VSS AND3_X1
X_27284_ _09241_ _09242_ VDD VSS BUF_X4
X_27285_ _09242_ _09243_ VDD VSS BUF_X4
X_27286_ gen_regfile_ff.register_file_i.rf_reg\[224\] _06223_
+ _09243_ _02288_ VDD VSS MUX2_X1
X_27287_ gen_regfile_ff.register_file_i.rf_reg\[225\] _06236_
+ _09243_ _02289_ VDD VSS MUX2_X1
X_27288_ _06224_ _04852_ _06226_ _09244_ VDD VSS NAND3_X4
X_27289_ _09244_ _09245_ VDD VSS BUF_X4
X_27290_ gen_regfile_ff.register_file_i.rf_reg\[226\] _09245_
+ _09246_ VDD VSS NAND2_X1
X_27291_ _09246_ _09245_ _05464_ _02290_ VDD VSS OAI21_X1
X_27292_ gen_regfile_ff.register_file_i.rf_reg\[227\] _09245_
+ _09247_ VDD VSS NAND2_X1
X_27293_ _09247_ _09245_ _05510_ _02291_ VDD VSS OAI21_X1
X_27294_ gen_regfile_ff.register_file_i.rf_reg\[228\] _09178_
+ _09243_ _02292_ VDD VSS MUX2_X1
X_27295_ gen_regfile_ff.register_file_i.rf_reg\[229\] _09179_
+ _09243_ _02293_ VDD VSS MUX2_X1
X_27296_ _09242_ _09248_ VDD VSS BUF_X4
X_27297_ gen_regfile_ff.register_file_i.rf_reg\[230\] _09180_
+ _09248_ _02294_ VDD VSS MUX2_X1
X_27298_ gen_regfile_ff.register_file_i.rf_reg\[231\] _09181_
+ _09248_ _02295_ VDD VSS MUX2_X1
X_27299_ _06246_ _09249_ VDD VSS CLKBUF_X3
X_27300_ gen_regfile_ff.register_file_i.rf_reg\[51\] _09249_
+ _09250_ VDD VSS NAND2_X1
X_27301_ _05805_ _06245_ _09251_ VDD VSS NAND2_X2
X_27302_ _09250_ _09251_ _06138_ _02296_ VDD VSS OAI21_X1
X_27303_ gen_regfile_ff.register_file_i.rf_reg\[33\] _06236_
+ _09236_ _02297_ VDD VSS MUX2_X1
X_27304_ gen_regfile_ff.register_file_i.rf_reg\[232\] _09243_
+ _09252_ VDD VSS NOR2_X1
X_27305_ _09252_ _09243_ _05688_ _02298_ VDD VSS AOI21_X1
X_27306_ gen_regfile_ff.register_file_i.rf_reg\[233\] _09183_
+ _09248_ _02299_ VDD VSS MUX2_X1
X_27307_ gen_regfile_ff.register_file_i.rf_reg\[234\] _09185_
+ _09248_ _02300_ VDD VSS MUX2_X1
X_27308_ gen_regfile_ff.register_file_i.rf_reg\[235\] _09186_
+ _09248_ _02301_ VDD VSS MUX2_X1
X_27309_ gen_regfile_ff.register_file_i.rf_reg\[236\] _09243_
+ _09253_ VDD VSS NOR2_X1
X_27310_ _09253_ _09243_ _05850_ _02302_ VDD VSS AOI21_X1
X_27311_ gen_regfile_ff.register_file_i.rf_reg\[237\] _09188_
+ _09248_ _02303_ VDD VSS MUX2_X1
X_27312_ gen_regfile_ff.register_file_i.rf_reg\[238\] _09189_
+ _09248_ _02304_ VDD VSS MUX2_X1
X_27313_ gen_regfile_ff.register_file_i.rf_reg\[239\] _09190_
+ _09248_ _02305_ VDD VSS MUX2_X1
X_27314_ gen_regfile_ff.register_file_i.rf_reg\[240\] _09243_
+ _09254_ VDD VSS NOR2_X1
X_27315_ _09254_ _09243_ _06016_ _02306_ VDD VSS AOI21_X1
X_27316_ gen_regfile_ff.register_file_i.rf_reg\[241\] _09192_
+ _09248_ _02307_ VDD VSS MUX2_X1
X_27317_ gen_regfile_ff.register_file_i.rf_reg\[52\] net679
+ _09236_ _02308_ VDD VSS MUX2_X1
X_27318_ gen_regfile_ff.register_file_i.rf_reg\[242\] _09193_
+ _09248_ _02309_ VDD VSS MUX2_X1
X_27319_ gen_regfile_ff.register_file_i.rf_reg\[243\] _09245_
+ _09255_ VDD VSS NAND2_X1
X_27320_ _09255_ _09245_ _06138_ _02310_ VDD VSS OAI21_X1
X_27321_ gen_regfile_ff.register_file_i.rf_reg\[244\] _09195_
+ _09242_ _02311_ VDD VSS MUX2_X1
X_27322_ gen_regfile_ff.register_file_i.rf_reg\[245\] _09196_
+ _09242_ _02312_ VDD VSS MUX2_X1
X_27323_ gen_regfile_ff.register_file_i.rf_reg\[246\] _09197_
+ _09242_ _02313_ VDD VSS MUX2_X1
X_27324_ gen_regfile_ff.register_file_i.rf_reg\[247\] _09198_
+ _09242_ _02314_ VDD VSS MUX2_X1
X_27325_ gen_regfile_ff.register_file_i.rf_reg\[248\] _09244_
+ _09256_ VDD VSS NAND2_X1
X_27326_ _09256_ _09245_ _04908_ _02315_ VDD VSS OAI21_X1
X_27327_ gen_regfile_ff.register_file_i.rf_reg\[249\] _09244_
+ _09257_ VDD VSS NAND2_X1
X_27328_ _09257_ _09245_ _04978_ _02316_ VDD VSS OAI21_X1
X_27329_ gen_regfile_ff.register_file_i.rf_reg\[250\] _09201_
+ _09242_ _02317_ VDD VSS MUX2_X1
X_27330_ gen_regfile_ff.register_file_i.rf_reg\[251\] net518
+ _09242_ _02318_ VDD VSS MUX2_X1
X_27331_ gen_regfile_ff.register_file_i.rf_reg\[53\] _09196_
+ _09236_ _02319_ VDD VSS MUX2_X1
X_27332_ gen_regfile_ff.register_file_i.rf_reg\[252\] _05411_
+ _09242_ _02320_ VDD VSS MUX2_X1
X_27333_ gen_regfile_ff.register_file_i.rf_reg\[253\] _09244_
+ _09258_ VDD VSS NAND2_X1
X_27334_ _09258_ _09245_ _05148_ _02321_ VDD VSS OAI21_X1
X_27335_ gen_regfile_ff.register_file_i.rf_reg\[254\] _06208_
+ _09242_ _02322_ VDD VSS MUX2_X1
X_27336_ gen_regfile_ff.register_file_i.rf_reg\[255\] _09244_
+ _09259_ VDD VSS NAND2_X1
X_27337_ _09259_ net681 _09245_ _02323_ VDD VSS OAI21_X2
X_27338_ _10900_ _05412_ _04605_ _04610_ _09260_ VDD VSS AOI211_X2
X_27339_ _10904_ _09260_ _09261_ VDD VSS AND2_X1
X_27340_ _09261_ _09262_ VDD VSS BUF_X4
X_27341_ _09262_ _09263_ VDD VSS BUF_X4
X_27342_ gen_regfile_ff.register_file_i.rf_reg\[256\] _06223_
+ _09263_ _02324_ VDD VSS MUX2_X1
X_27343_ gen_regfile_ff.register_file_i.rf_reg\[257\] _06236_
+ _09263_ _02325_ VDD VSS MUX2_X1
X_27344_ _09260_ _09264_ VDD VSS BUF_X4
X_27345_ _10904_ _09264_ _09265_ VDD VSS NAND2_X2
X_27346_ _09265_ _09266_ VDD VSS CLKBUF_X3
X_27347_ gen_regfile_ff.register_file_i.rf_reg\[258\] _09266_
+ _09267_ VDD VSS NAND2_X1
X_27348_ _09267_ _09266_ _05464_ _02326_ VDD VSS OAI21_X1
X_27349_ gen_regfile_ff.register_file_i.rf_reg\[259\] _09266_
+ _09268_ VDD VSS NAND2_X1
X_27350_ _09268_ _09266_ _05510_ _02327_ VDD VSS OAI21_X1
X_27351_ gen_regfile_ff.register_file_i.rf_reg\[260\] _09178_
+ _09263_ _02328_ VDD VSS MUX2_X1
X_27352_ gen_regfile_ff.register_file_i.rf_reg\[261\] _09179_
+ _09263_ _02329_ VDD VSS MUX2_X1
X_27353_ _04602_ gen_regfile_ff.register_file_i.rf_reg\[54\]
+ _06246_ _02330_ VDD VSS MUX2_X1
X_27354_ _09262_ _09269_ VDD VSS BUF_X4
X_27355_ gen_regfile_ff.register_file_i.rf_reg\[262\] _09180_
+ _09269_ _02331_ VDD VSS MUX2_X1
X_27356_ gen_regfile_ff.register_file_i.rf_reg\[263\] _09181_
+ _09269_ _02332_ VDD VSS MUX2_X1
X_27357_ gen_regfile_ff.register_file_i.rf_reg\[264\] _09263_
+ _09270_ VDD VSS NOR2_X1
X_27358_ _09270_ _09263_ _05688_ _02333_ VDD VSS AOI21_X1
X_27359_ gen_regfile_ff.register_file_i.rf_reg\[265\] _09183_
+ _09269_ _02334_ VDD VSS MUX2_X1
X_27360_ gen_regfile_ff.register_file_i.rf_reg\[266\] _09185_
+ _09269_ _02335_ VDD VSS MUX2_X1
X_27361_ gen_regfile_ff.register_file_i.rf_reg\[267\] _09186_
+ _09269_ _02336_ VDD VSS MUX2_X1
X_27362_ gen_regfile_ff.register_file_i.rf_reg\[268\] _09263_
+ _09271_ VDD VSS NOR2_X1
X_27363_ _09271_ _09263_ _05850_ _02337_ VDD VSS AOI21_X1
X_27364_ gen_regfile_ff.register_file_i.rf_reg\[269\] _09188_
+ _09269_ _02338_ VDD VSS MUX2_X1
X_27365_ gen_regfile_ff.register_file_i.rf_reg\[270\] _09189_
+ _09269_ _02339_ VDD VSS MUX2_X1
X_27366_ gen_regfile_ff.register_file_i.rf_reg\[271\] _09190_
+ _09269_ _02340_ VDD VSS MUX2_X1
X_27367_ gen_regfile_ff.register_file_i.rf_reg\[55\] net686
+ _09236_ _02341_ VDD VSS MUX2_X1
X_27368_ gen_regfile_ff.register_file_i.rf_reg\[272\] _09263_
+ _09272_ VDD VSS NOR2_X1
X_27369_ _09272_ _09263_ _06016_ _02342_ VDD VSS AOI21_X1
X_27370_ gen_regfile_ff.register_file_i.rf_reg\[273\] _09192_
+ _09269_ _02343_ VDD VSS MUX2_X1
X_27371_ gen_regfile_ff.register_file_i.rf_reg\[274\] _09193_
+ _09269_ _02344_ VDD VSS MUX2_X1
X_27372_ gen_regfile_ff.register_file_i.rf_reg\[275\] _09266_
+ _09273_ VDD VSS NAND2_X1
X_27373_ _09273_ _09266_ _06138_ _02345_ VDD VSS OAI21_X1
X_27374_ gen_regfile_ff.register_file_i.rf_reg\[276\] net679
+ _09262_ _02346_ VDD VSS MUX2_X1
X_27375_ gen_regfile_ff.register_file_i.rf_reg\[277\] _09196_
+ _09262_ _02347_ VDD VSS MUX2_X1
X_27376_ gen_regfile_ff.register_file_i.rf_reg\[278\] _09197_
+ _09262_ _02348_ VDD VSS MUX2_X1
X_27377_ gen_regfile_ff.register_file_i.rf_reg\[279\] _09198_
+ _09262_ _02349_ VDD VSS MUX2_X1
X_27378_ gen_regfile_ff.register_file_i.rf_reg\[280\] _09265_
+ _09274_ VDD VSS NAND2_X1
X_27379_ _09274_ _09266_ _04908_ _02350_ VDD VSS OAI21_X1
X_27380_ gen_regfile_ff.register_file_i.rf_reg\[281\] _09265_
+ _09275_ VDD VSS NAND2_X1
X_27381_ _09275_ _09266_ _04978_ _02351_ VDD VSS OAI21_X1
X_27382_ gen_regfile_ff.register_file_i.rf_reg\[56\] _09249_
+ _09276_ VDD VSS NAND2_X1
X_27383_ _09276_ _09251_ _04908_ _02352_ VDD VSS OAI21_X1
X_27384_ gen_regfile_ff.register_file_i.rf_reg\[282\] _09201_
+ _09262_ _02353_ VDD VSS MUX2_X1
X_27385_ gen_regfile_ff.register_file_i.rf_reg\[283\] net518
+ _09262_ _02354_ VDD VSS MUX2_X1
X_27386_ gen_regfile_ff.register_file_i.rf_reg\[284\] _05411_
+ _09262_ _02355_ VDD VSS MUX2_X1
X_27387_ gen_regfile_ff.register_file_i.rf_reg\[285\] _09265_
+ _09277_ VDD VSS NAND2_X1
X_27388_ _09277_ _09266_ _05148_ _02356_ VDD VSS OAI21_X1
X_27389_ gen_regfile_ff.register_file_i.rf_reg\[286\] net675
+ _09262_ _02357_ VDD VSS MUX2_X1
X_27390_ gen_regfile_ff.register_file_i.rf_reg\[287\] _09265_
+ _09278_ VDD VSS NAND2_X1
X_27391_ _09278_ _05260_ _09266_ _02358_ VDD VSS OAI21_X4
X_27392_ _06245_ _09260_ _09279_ VDD VSS AND2_X1
X_27393_ _09279_ _09280_ VDD VSS BUF_X4
X_27394_ _09280_ _09281_ VDD VSS BUF_X4
X_27395_ gen_regfile_ff.register_file_i.rf_reg\[288\] _06223_
+ _09281_ _02359_ VDD VSS MUX2_X1
X_27396_ gen_regfile_ff.register_file_i.rf_reg\[289\] _06236_
+ _09281_ _02360_ VDD VSS MUX2_X1
X_27397_ _06245_ _09264_ _09282_ VDD VSS NAND2_X2
X_27398_ _09282_ _09283_ VDD VSS BUF_X4
X_27399_ gen_regfile_ff.register_file_i.rf_reg\[290\] _09283_
+ _09284_ VDD VSS NAND2_X1
X_27400_ _09284_ _09283_ _05464_ _02361_ VDD VSS OAI21_X1
X_27401_ gen_regfile_ff.register_file_i.rf_reg\[291\] _09283_
+ _09285_ VDD VSS NAND2_X1
X_27402_ _09285_ _09283_ _05510_ _02362_ VDD VSS OAI21_X1
X_27403_ gen_regfile_ff.register_file_i.rf_reg\[57\] _09249_
+ _09286_ VDD VSS NAND2_X1
X_27404_ _09286_ _09249_ _04978_ _02363_ VDD VSS OAI21_X1
X_27405_ gen_regfile_ff.register_file_i.rf_reg\[292\] _09178_
+ _09281_ _02364_ VDD VSS MUX2_X1
X_27406_ gen_regfile_ff.register_file_i.rf_reg\[293\] _09179_
+ _09281_ _02365_ VDD VSS MUX2_X1
X_27407_ _09280_ _09287_ VDD VSS BUF_X4
X_27408_ gen_regfile_ff.register_file_i.rf_reg\[294\] _09180_
+ _09287_ _02366_ VDD VSS MUX2_X1
X_27409_ gen_regfile_ff.register_file_i.rf_reg\[295\] _09181_
+ _09287_ _02367_ VDD VSS MUX2_X1
X_27410_ gen_regfile_ff.register_file_i.rf_reg\[296\] _09281_
+ _09288_ VDD VSS NOR2_X1
X_27411_ _09288_ _09281_ _05688_ _02368_ VDD VSS AOI21_X1
X_27412_ gen_regfile_ff.register_file_i.rf_reg\[297\] _09183_
+ _09287_ _02369_ VDD VSS MUX2_X1
X_27413_ gen_regfile_ff.register_file_i.rf_reg\[298\] _09185_
+ _09287_ _02370_ VDD VSS MUX2_X1
X_27414_ gen_regfile_ff.register_file_i.rf_reg\[299\] _09186_
+ _09287_ _02371_ VDD VSS MUX2_X1
X_27415_ gen_regfile_ff.register_file_i.rf_reg\[300\] _09281_
+ _09289_ VDD VSS NOR2_X1
X_27416_ _09289_ _09281_ _05850_ _02372_ VDD VSS AOI21_X1
X_27417_ gen_regfile_ff.register_file_i.rf_reg\[301\] _09188_
+ _09287_ _02373_ VDD VSS MUX2_X1
X_27418_ gen_regfile_ff.register_file_i.rf_reg\[58\] _09201_
+ _09236_ _02374_ VDD VSS MUX2_X1
X_27419_ gen_regfile_ff.register_file_i.rf_reg\[302\] _09189_
+ _09287_ _02375_ VDD VSS MUX2_X1
X_27420_ gen_regfile_ff.register_file_i.rf_reg\[303\] _09190_
+ _09287_ _02376_ VDD VSS MUX2_X1
X_27421_ gen_regfile_ff.register_file_i.rf_reg\[304\] _09281_
+ _09290_ VDD VSS NOR2_X1
X_27422_ _09290_ _09281_ _06016_ _02377_ VDD VSS AOI21_X1
X_27423_ gen_regfile_ff.register_file_i.rf_reg\[305\] _09192_
+ _09287_ _02378_ VDD VSS MUX2_X1
X_27424_ gen_regfile_ff.register_file_i.rf_reg\[306\] _09193_
+ _09287_ _02379_ VDD VSS MUX2_X1
X_27425_ gen_regfile_ff.register_file_i.rf_reg\[307\] _09283_
+ _09291_ VDD VSS NAND2_X1
X_27426_ _06137_ _09292_ VDD VSS CLKBUF_X3
X_27427_ _09291_ _09283_ _09292_ _02380_ VDD VSS OAI21_X1
X_27428_ gen_regfile_ff.register_file_i.rf_reg\[308\] net679
+ _09280_ _02381_ VDD VSS MUX2_X1
X_27429_ gen_regfile_ff.register_file_i.rf_reg\[309\] _09196_
+ _09280_ _02382_ VDD VSS MUX2_X1
X_27430_ gen_regfile_ff.register_file_i.rf_reg\[310\] _09197_
+ _09280_ _02383_ VDD VSS MUX2_X1
X_27431_ gen_regfile_ff.register_file_i.rf_reg\[311\] net686
+ _09280_ _02384_ VDD VSS MUX2_X1
X_27432_ _04849_ _09293_ VDD VSS BUF_X4
X_27433_ net409 gen_regfile_ff.register_file_i.rf_reg\[59\]
+ _06246_ _02385_ VDD VSS MUX2_X1
X_27434_ gen_regfile_ff.register_file_i.rf_reg\[312\] _09282_
+ _09294_ VDD VSS NAND2_X1
X_27435_ _04907_ _09295_ VDD VSS CLKBUF_X3
X_27436_ _09294_ _09283_ _09295_ _02386_ VDD VSS OAI21_X1
X_27437_ gen_regfile_ff.register_file_i.rf_reg\[313\] _09282_
+ _09296_ VDD VSS NAND2_X1
X_27438_ _04977_ _09297_ VDD VSS BUF_X8
X_27439_ _09296_ net683 _09283_ _02387_ VDD VSS OAI21_X2
X_27440_ gen_regfile_ff.register_file_i.rf_reg\[314\] _09201_
+ _09280_ _02388_ VDD VSS MUX2_X1
X_27441_ gen_regfile_ff.register_file_i.rf_reg\[315\] _09202_
+ _09280_ _02389_ VDD VSS MUX2_X1
X_27442_ gen_regfile_ff.register_file_i.rf_reg\[316\] _05411_
+ _09280_ _02390_ VDD VSS MUX2_X1
X_27443_ gen_regfile_ff.register_file_i.rf_reg\[317\] _09282_
+ _09298_ VDD VSS NAND2_X1
X_27444_ _09298_ _09283_ _05148_ _02391_ VDD VSS OAI21_X1
X_27445_ gen_regfile_ff.register_file_i.rf_reg\[318\] net675
+ _09280_ _02392_ VDD VSS MUX2_X1
X_27446_ gen_regfile_ff.register_file_i.rf_reg\[319\] _09282_
+ _09299_ VDD VSS NAND2_X1
X_27447_ _09299_ _05260_ _09283_ _02393_ VDD VSS OAI21_X4
X_27448_ _10903_ _05373_ _09300_ VDD VSS NOR2_X4
X_27449_ _09264_ _09300_ _09301_ VDD VSS AND2_X1
X_27450_ _09301_ _09302_ VDD VSS BUF_X4
X_27451_ _09302_ _09303_ VDD VSS BUF_X4
X_27452_ gen_regfile_ff.register_file_i.rf_reg\[320\] _06223_
+ _09303_ _02394_ VDD VSS MUX2_X1
X_27453_ gen_regfile_ff.register_file_i.rf_reg\[321\] _06236_
+ _09303_ _02395_ VDD VSS MUX2_X1
X_27454_ gen_regfile_ff.register_file_i.rf_reg\[60\] _05411_
+ _09236_ _02396_ VDD VSS MUX2_X1
X_27455_ _09264_ _09300_ _09304_ VDD VSS NAND2_X2
X_27456_ _09304_ _09305_ VDD VSS CLKBUF_X3
X_27457_ gen_regfile_ff.register_file_i.rf_reg\[322\] _09305_
+ _09306_ VDD VSS NAND2_X1
X_27458_ _05463_ _09307_ VDD VSS CLKBUF_X3
X_27459_ _09306_ _09305_ _09307_ _02397_ VDD VSS OAI21_X1
X_27460_ gen_regfile_ff.register_file_i.rf_reg\[323\] _09305_
+ _09308_ VDD VSS NAND2_X1
X_27461_ _05509_ _09309_ VDD VSS CLKBUF_X3
X_27462_ _09308_ _09305_ _09309_ _02398_ VDD VSS OAI21_X1
X_27463_ gen_regfile_ff.register_file_i.rf_reg\[324\] _09178_
+ _09303_ _02399_ VDD VSS MUX2_X1
X_27464_ gen_regfile_ff.register_file_i.rf_reg\[325\] _09179_
+ _09303_ _02400_ VDD VSS MUX2_X1
X_27465_ _09302_ _09310_ VDD VSS BUF_X4
X_27466_ gen_regfile_ff.register_file_i.rf_reg\[326\] _09180_
+ _09310_ _02401_ VDD VSS MUX2_X1
X_27467_ gen_regfile_ff.register_file_i.rf_reg\[327\] _09181_
+ _09310_ _02402_ VDD VSS MUX2_X1
X_27468_ gen_regfile_ff.register_file_i.rf_reg\[328\] _09303_
+ _09311_ VDD VSS NOR2_X1
X_27469_ _09311_ _09303_ _05688_ _02403_ VDD VSS AOI21_X1
X_27470_ gen_regfile_ff.register_file_i.rf_reg\[329\] _09183_
+ _09310_ _02404_ VDD VSS MUX2_X1
X_27471_ gen_regfile_ff.register_file_i.rf_reg\[330\] _09185_
+ _09310_ _02405_ VDD VSS MUX2_X1
X_27472_ gen_regfile_ff.register_file_i.rf_reg\[331\] _09186_
+ _09310_ _02406_ VDD VSS MUX2_X1
X_27473_ gen_regfile_ff.register_file_i.rf_reg\[61\] _09249_
+ _09312_ VDD VSS NAND2_X1
X_27474_ _05147_ _09313_ VDD VSS BUF_X8
X_27475_ _09312_ _09251_ _09313_ _02407_ VDD VSS OAI21_X1
X_27476_ gen_regfile_ff.register_file_i.rf_reg\[34\] _09249_
+ _09314_ VDD VSS NAND2_X1
X_27477_ _09314_ _09249_ _09307_ _02408_ VDD VSS OAI21_X1
X_27478_ gen_regfile_ff.register_file_i.rf_reg\[332\] _09303_
+ _09315_ VDD VSS NOR2_X1
X_27479_ _05849_ _09316_ VDD VSS CLKBUF_X3
X_27480_ _09315_ _09303_ _09316_ _02409_ VDD VSS AOI21_X1
X_27481_ gen_regfile_ff.register_file_i.rf_reg\[333\] _09188_
+ _09310_ _02410_ VDD VSS MUX2_X1
X_27482_ gen_regfile_ff.register_file_i.rf_reg\[334\] _09189_
+ _09310_ _02411_ VDD VSS MUX2_X1
X_27483_ gen_regfile_ff.register_file_i.rf_reg\[335\] _09190_
+ _09310_ _02412_ VDD VSS MUX2_X1
X_27484_ gen_regfile_ff.register_file_i.rf_reg\[336\] _09303_
+ _09317_ VDD VSS NOR2_X1
X_27485_ _06015_ _09318_ VDD VSS CLKBUF_X3
X_27486_ _09317_ _09303_ _09318_ _02413_ VDD VSS AOI21_X1
X_27487_ gen_regfile_ff.register_file_i.rf_reg\[337\] _09192_
+ _09310_ _02414_ VDD VSS MUX2_X1
X_27488_ gen_regfile_ff.register_file_i.rf_reg\[338\] _09193_
+ _09310_ _02415_ VDD VSS MUX2_X1
X_27489_ gen_regfile_ff.register_file_i.rf_reg\[339\] _09305_
+ _09319_ VDD VSS NAND2_X1
X_27490_ _09319_ _09305_ _09292_ _02416_ VDD VSS OAI21_X1
X_27491_ gen_regfile_ff.register_file_i.rf_reg\[340\] net679
+ _09302_ _02417_ VDD VSS MUX2_X1
X_27492_ gen_regfile_ff.register_file_i.rf_reg\[341\] _09196_
+ _09302_ _02418_ VDD VSS MUX2_X1
X_27493_ gen_regfile_ff.register_file_i.rf_reg\[62\] net675
+ _09236_ _02419_ VDD VSS MUX2_X1
X_27494_ gen_regfile_ff.register_file_i.rf_reg\[342\] _09197_
+ _09302_ _02420_ VDD VSS MUX2_X1
X_27495_ gen_regfile_ff.register_file_i.rf_reg\[343\] _09198_
+ _09302_ _02421_ VDD VSS MUX2_X1
X_27496_ gen_regfile_ff.register_file_i.rf_reg\[344\] _09304_
+ _09320_ VDD VSS NAND2_X1
X_27497_ _09320_ _09305_ _09295_ _02422_ VDD VSS OAI21_X1
X_27498_ gen_regfile_ff.register_file_i.rf_reg\[345\] _09304_
+ _09321_ VDD VSS NAND2_X1
X_27499_ _09321_ net683 _09305_ _02423_ VDD VSS OAI21_X4
X_27500_ gen_regfile_ff.register_file_i.rf_reg\[346\] _09201_
+ _09302_ _02424_ VDD VSS MUX2_X1
X_27501_ gen_regfile_ff.register_file_i.rf_reg\[347\] net518
+ _09302_ _02425_ VDD VSS MUX2_X1
X_27502_ gen_regfile_ff.register_file_i.rf_reg\[348\] _05411_
+ _09302_ _02426_ VDD VSS MUX2_X1
X_27503_ gen_regfile_ff.register_file_i.rf_reg\[349\] _09304_
+ _09322_ VDD VSS NAND2_X1
X_27504_ _09322_ _09305_ _09313_ _02427_ VDD VSS OAI21_X1
X_27505_ gen_regfile_ff.register_file_i.rf_reg\[350\] net675
+ _09302_ _02428_ VDD VSS MUX2_X1
X_27506_ gen_regfile_ff.register_file_i.rf_reg\[351\] _09304_
+ _09323_ VDD VSS NAND2_X1
X_27507_ _05259_ _09324_ VDD VSS BUF_X8
X_27508_ _09323_ _09324_ _09305_ _02429_ VDD VSS OAI21_X4
X_27509_ gen_regfile_ff.register_file_i.rf_reg\[63\] _09249_
+ _09325_ VDD VSS NAND2_X1
X_27510_ _09325_ _09324_ _09251_ _02430_ VDD VSS OAI21_X4
X_27511_ _04852_ _09260_ _09326_ VDD VSS AND2_X1
X_27512_ _09326_ _09327_ VDD VSS BUF_X4
X_27513_ _09327_ _09328_ VDD VSS BUF_X4
X_27514_ gen_regfile_ff.register_file_i.rf_reg\[352\] _06223_
+ _09328_ _02431_ VDD VSS MUX2_X1
X_27515_ gen_regfile_ff.register_file_i.rf_reg\[353\] _06236_
+ _09328_ _02432_ VDD VSS MUX2_X1
X_27516_ _04852_ _09264_ _09329_ VDD VSS NAND2_X2
X_27517_ _09329_ _09330_ VDD VSS CLKBUF_X3
X_27518_ gen_regfile_ff.register_file_i.rf_reg\[354\] _09330_
+ _09331_ VDD VSS NAND2_X1
X_27519_ _09331_ _09330_ _09307_ _02433_ VDD VSS OAI21_X1
X_27520_ gen_regfile_ff.register_file_i.rf_reg\[355\] _09330_
+ _09332_ VDD VSS NAND2_X1
X_27521_ _09332_ _09330_ _09309_ _02434_ VDD VSS OAI21_X1
X_27522_ gen_regfile_ff.register_file_i.rf_reg\[356\] _09178_
+ _09328_ _02435_ VDD VSS MUX2_X1
X_27523_ gen_regfile_ff.register_file_i.rf_reg\[357\] _09179_
+ _09328_ _02436_ VDD VSS MUX2_X1
X_27524_ _09327_ _09333_ VDD VSS BUF_X4
X_27525_ gen_regfile_ff.register_file_i.rf_reg\[358\] _09180_
+ _09333_ _02437_ VDD VSS MUX2_X1
X_27526_ gen_regfile_ff.register_file_i.rf_reg\[359\] _09181_
+ _09333_ _02438_ VDD VSS MUX2_X1
X_27527_ gen_regfile_ff.register_file_i.rf_reg\[360\] _09328_
+ _09334_ VDD VSS NOR2_X1
X_27528_ _09334_ _09328_ _05688_ _02439_ VDD VSS AOI21_X1
X_27529_ gen_regfile_ff.register_file_i.rf_reg\[361\] _09183_
+ _09333_ _02440_ VDD VSS MUX2_X1
X_27530_ _05805_ _09300_ _09335_ VDD VSS AND2_X1
X_27531_ _09335_ _09336_ VDD VSS BUF_X4
X_27532_ gen_regfile_ff.register_file_i.rf_reg\[64\] _06223_
+ _09336_ _02441_ VDD VSS MUX2_X1
X_27533_ gen_regfile_ff.register_file_i.rf_reg\[362\] _09185_
+ _09333_ _02442_ VDD VSS MUX2_X1
X_27534_ gen_regfile_ff.register_file_i.rf_reg\[363\] _09186_
+ _09333_ _02443_ VDD VSS MUX2_X1
X_27535_ gen_regfile_ff.register_file_i.rf_reg\[364\] _09328_
+ _09337_ VDD VSS NOR2_X1
X_27536_ _09337_ _09328_ _09316_ _02444_ VDD VSS AOI21_X1
X_27537_ gen_regfile_ff.register_file_i.rf_reg\[365\] _09188_
+ _09333_ _02445_ VDD VSS MUX2_X1
X_27538_ gen_regfile_ff.register_file_i.rf_reg\[366\] _09189_
+ _09333_ _02446_ VDD VSS MUX2_X1
X_27539_ gen_regfile_ff.register_file_i.rf_reg\[367\] _09190_
+ _09333_ _02447_ VDD VSS MUX2_X1
X_27540_ gen_regfile_ff.register_file_i.rf_reg\[368\] _09328_
+ _09338_ VDD VSS NOR2_X1
X_27541_ _09338_ _09328_ _09318_ _02448_ VDD VSS AOI21_X1
X_27542_ gen_regfile_ff.register_file_i.rf_reg\[369\] _09192_
+ _09333_ _02449_ VDD VSS MUX2_X1
X_27543_ gen_regfile_ff.register_file_i.rf_reg\[370\] _09193_
+ _09333_ _02450_ VDD VSS MUX2_X1
X_27544_ gen_regfile_ff.register_file_i.rf_reg\[371\] _09330_
+ _09339_ VDD VSS NAND2_X1
X_27545_ _09339_ _09330_ _09292_ _02451_ VDD VSS OAI21_X1
X_27546_ gen_regfile_ff.register_file_i.rf_reg\[65\] _06236_
+ _09336_ _02452_ VDD VSS MUX2_X1
X_27547_ gen_regfile_ff.register_file_i.rf_reg\[372\] net679
+ _09327_ _02453_ VDD VSS MUX2_X1
X_27548_ gen_regfile_ff.register_file_i.rf_reg\[373\] _09196_
+ _09327_ _02454_ VDD VSS MUX2_X1
X_27549_ gen_regfile_ff.register_file_i.rf_reg\[374\] _09197_
+ _09327_ _02455_ VDD VSS MUX2_X1
X_27550_ gen_regfile_ff.register_file_i.rf_reg\[375\] net686
+ _09327_ _02456_ VDD VSS MUX2_X1
X_27551_ gen_regfile_ff.register_file_i.rf_reg\[376\] _09329_
+ _09340_ VDD VSS NAND2_X1
X_27552_ _09340_ _09330_ _09295_ _02457_ VDD VSS OAI21_X1
X_27553_ gen_regfile_ff.register_file_i.rf_reg\[377\] _09329_
+ _09341_ VDD VSS NAND2_X1
X_27554_ _09341_ _09297_ _09330_ _02458_ VDD VSS OAI21_X4
X_27555_ gen_regfile_ff.register_file_i.rf_reg\[378\] _09201_
+ _09327_ _02459_ VDD VSS MUX2_X1
X_27556_ gen_regfile_ff.register_file_i.rf_reg\[379\] net518
+ _09327_ _02460_ VDD VSS MUX2_X1
X_27557_ gen_regfile_ff.register_file_i.rf_reg\[380\] _05411_
+ _09327_ _02461_ VDD VSS MUX2_X1
X_27558_ gen_regfile_ff.register_file_i.rf_reg\[381\] _09329_
+ _09342_ VDD VSS NAND2_X1
X_27559_ _09342_ _09330_ _09313_ _02462_ VDD VSS OAI21_X1
X_27560_ _04854_ _09300_ _09343_ VDD VSS NAND2_X4
X_27561_ _09343_ _09344_ VDD VSS CLKBUF_X3
X_27562_ gen_regfile_ff.register_file_i.rf_reg\[66\] _09344_
+ _09345_ VDD VSS NAND2_X1
X_27563_ _09345_ _09344_ _09307_ _02463_ VDD VSS OAI21_X1
X_27564_ gen_regfile_ff.register_file_i.rf_reg\[382\] _06208_
+ _09327_ _02464_ VDD VSS MUX2_X1
X_27565_ gen_regfile_ff.register_file_i.rf_reg\[383\] _09329_
+ _09346_ VDD VSS NAND2_X1
X_27566_ _09346_ _09324_ _09330_ _02465_ VDD VSS OAI21_X4
X_27567_ _10904_ _04613_ _09347_ VDD VSS NAND2_X4
X_27568_ _09347_ _09348_ VDD VSS BUF_X4
X_27569_ _05372_ gen_regfile_ff.register_file_i.rf_reg\[384\]
+ _09348_ _02466_ VDD VSS MUX2_X1
X_27570_ _05410_ gen_regfile_ff.register_file_i.rf_reg\[385\]
+ _09348_ _02467_ VDD VSS MUX2_X1
X_27571_ _09347_ _09349_ VDD VSS BUF_X4
X_27572_ gen_regfile_ff.register_file_i.rf_reg\[386\] _09349_
+ _09350_ VDD VSS NAND2_X1
X_27573_ _09347_ _09351_ VDD VSS BUF_X4
X_27574_ _09350_ _09351_ _09307_ _02468_ VDD VSS OAI21_X1
X_27575_ gen_regfile_ff.register_file_i.rf_reg\[387\] _09349_
+ _09352_ VDD VSS NAND2_X1
X_27576_ _09352_ _09351_ _09309_ _02469_ VDD VSS OAI21_X1
X_27577_ _05544_ gen_regfile_ff.register_file_i.rf_reg\[388\]
+ _09348_ _02470_ VDD VSS MUX2_X1
X_27578_ _05580_ gen_regfile_ff.register_file_i.rf_reg\[389\]
+ _09348_ _02471_ VDD VSS MUX2_X1
X_27579_ _05614_ gen_regfile_ff.register_file_i.rf_reg\[390\]
+ _09348_ _02472_ VDD VSS MUX2_X1
X_27580_ _05653_ gen_regfile_ff.register_file_i.rf_reg\[391\]
+ _09348_ _02473_ VDD VSS MUX2_X1
X_27581_ gen_regfile_ff.register_file_i.rf_reg\[67\] _09344_
+ _09353_ VDD VSS NAND2_X1
X_27582_ _09353_ _09344_ _09309_ _02474_ VDD VSS OAI21_X1
X_27583_ gen_regfile_ff.register_file_i.rf_reg\[392\] _09349_
+ _09354_ VDD VSS NAND2_X1
X_27584_ _09354_ _09351_ _06222_ _02475_ VDD VSS OAI21_X1
X_27585_ _05721_ gen_regfile_ff.register_file_i.rf_reg\[393\]
+ _09348_ _02476_ VDD VSS MUX2_X1
X_27586_ _05762_ gen_regfile_ff.register_file_i.rf_reg\[394\]
+ _09348_ _02477_ VDD VSS MUX2_X1
X_27587_ _05802_ gen_regfile_ff.register_file_i.rf_reg\[395\]
+ _09348_ _02478_ VDD VSS MUX2_X1
X_27588_ gen_regfile_ff.register_file_i.rf_reg\[396\] _09349_
+ _09355_ VDD VSS NAND2_X1
X_27589_ _09355_ _09351_ _06231_ _02479_ VDD VSS OAI21_X1
X_27590_ _05890_ gen_regfile_ff.register_file_i.rf_reg\[397\]
+ _09348_ _02480_ VDD VSS MUX2_X1
X_27591_ _09347_ _09356_ VDD VSS BUF_X4
X_27592_ _05928_ gen_regfile_ff.register_file_i.rf_reg\[398\]
+ _09356_ _02481_ VDD VSS MUX2_X1
X_27593_ _05974_ gen_regfile_ff.register_file_i.rf_reg\[399\]
+ _09356_ _02482_ VDD VSS MUX2_X1
X_27594_ gen_regfile_ff.register_file_i.rf_reg\[400\] _09349_
+ _09357_ VDD VSS NAND2_X1
X_27595_ _09357_ _09351_ _06234_ _02483_ VDD VSS OAI21_X1
X_27596_ _06062_ gen_regfile_ff.register_file_i.rf_reg\[401\]
+ _09356_ _02484_ VDD VSS MUX2_X1
X_27597_ gen_regfile_ff.register_file_i.rf_reg\[68\] _09178_
+ _09336_ _02485_ VDD VSS MUX2_X1
X_27598_ _06100_ gen_regfile_ff.register_file_i.rf_reg\[402\]
+ _09356_ _02486_ VDD VSS MUX2_X1
X_27599_ gen_regfile_ff.register_file_i.rf_reg\[403\] _09349_
+ _09358_ VDD VSS NAND2_X1
X_27600_ _09358_ _09351_ _09292_ _02487_ VDD VSS OAI21_X1
X_27601_ _06174_ gen_regfile_ff.register_file_i.rf_reg\[404\]
+ _09356_ _02488_ VDD VSS MUX2_X1
X_27602_ _06207_ gen_regfile_ff.register_file_i.rf_reg\[405\]
+ _09356_ _02489_ VDD VSS MUX2_X1
X_27603_ _04601_ _09359_ VDD VSS BUF_X2
X_27604_ _09359_ gen_regfile_ff.register_file_i.rf_reg\[406\]
+ _09356_ _02490_ VDD VSS MUX2_X1
X_27605_ _04766_ gen_regfile_ff.register_file_i.rf_reg\[407\]
+ _09356_ _02491_ VDD VSS MUX2_X1
X_27606_ gen_regfile_ff.register_file_i.rf_reg\[408\] _09349_
+ _09360_ VDD VSS NAND2_X1
X_27607_ _09360_ _09351_ _09295_ _02492_ VDD VSS OAI21_X1
X_27608_ gen_regfile_ff.register_file_i.rf_reg\[409\] _09349_
+ _09361_ VDD VSS NAND2_X1
X_27609_ _09361_ _09351_ _09297_ _02493_ VDD VSS OAI21_X1
X_27610_ net687 gen_regfile_ff.register_file_i.rf_reg\[410\]
+ _09356_ _02494_ VDD VSS MUX2_X1
X_27611_ _09293_ gen_regfile_ff.register_file_i.rf_reg\[411\]
+ _09356_ _02495_ VDD VSS MUX2_X1
X_27612_ _05580_ gen_regfile_ff.register_file_i.rf_reg\[69\]
+ _09343_ _02496_ VDD VSS MUX2_X1
X_27613_ _05094_ gen_regfile_ff.register_file_i.rf_reg\[412\]
+ _09347_ _02497_ VDD VSS MUX2_X1
X_27614_ gen_regfile_ff.register_file_i.rf_reg\[413\] _09349_
+ _09362_ VDD VSS NAND2_X1
X_27615_ _09362_ _09351_ _09313_ _02498_ VDD VSS OAI21_X1
X_27616_ _05211_ gen_regfile_ff.register_file_i.rf_reg\[414\]
+ _09347_ _02499_ VDD VSS MUX2_X1
X_27617_ gen_regfile_ff.register_file_i.rf_reg\[415\] _09349_
+ _09363_ VDD VSS NAND2_X1
X_27618_ _09363_ _09351_ _09324_ _02500_ VDD VSS OAI21_X1
X_27619_ _04613_ _06245_ _09364_ VDD VSS NAND2_X4
X_27620_ _09364_ _09365_ VDD VSS BUF_X4
X_27621_ _05372_ gen_regfile_ff.register_file_i.rf_reg\[416\]
+ _09365_ _02501_ VDD VSS MUX2_X1
X_27622_ _05410_ gen_regfile_ff.register_file_i.rf_reg\[417\]
+ _09365_ _02502_ VDD VSS MUX2_X1
X_27623_ _09364_ _09366_ VDD VSS BUF_X4
X_27624_ gen_regfile_ff.register_file_i.rf_reg\[418\] _09366_
+ _09367_ VDD VSS NAND2_X1
X_27625_ _09364_ _09368_ VDD VSS BUF_X4
X_27626_ _09367_ _09368_ _09307_ _02503_ VDD VSS OAI21_X1
X_27627_ gen_regfile_ff.register_file_i.rf_reg\[419\] _09366_
+ _09369_ VDD VSS NAND2_X1
X_27628_ _09369_ _09368_ _09309_ _02504_ VDD VSS OAI21_X1
X_27629_ _05544_ gen_regfile_ff.register_file_i.rf_reg\[420\]
+ _09365_ _02505_ VDD VSS MUX2_X1
X_27630_ _05579_ _09370_ VDD VSS BUF_X2
X_27631_ _09370_ gen_regfile_ff.register_file_i.rf_reg\[421\]
+ _09365_ _02506_ VDD VSS MUX2_X1
X_27632_ gen_regfile_ff.register_file_i.rf_reg\[70\] _09180_
+ _09336_ _02507_ VDD VSS MUX2_X1
X_27633_ _05614_ gen_regfile_ff.register_file_i.rf_reg\[422\]
+ _09365_ _02508_ VDD VSS MUX2_X1
X_27634_ _05653_ gen_regfile_ff.register_file_i.rf_reg\[423\]
+ _09365_ _02509_ VDD VSS MUX2_X1
X_27635_ gen_regfile_ff.register_file_i.rf_reg\[424\] _09366_
+ _09371_ VDD VSS NAND2_X1
X_27636_ _09371_ _09368_ _06222_ _02510_ VDD VSS OAI21_X1
X_27637_ _05720_ _09372_ VDD VSS BUF_X2
X_27638_ _09372_ gen_regfile_ff.register_file_i.rf_reg\[425\]
+ _09365_ _02511_ VDD VSS MUX2_X1
X_27639_ _05762_ gen_regfile_ff.register_file_i.rf_reg\[426\]
+ _09365_ _02512_ VDD VSS MUX2_X1
X_27640_ _05802_ gen_regfile_ff.register_file_i.rf_reg\[427\]
+ _09365_ _02513_ VDD VSS MUX2_X1
X_27641_ gen_regfile_ff.register_file_i.rf_reg\[428\] _09366_
+ _09373_ VDD VSS NAND2_X1
X_27642_ _09373_ _09368_ _06231_ _02514_ VDD VSS OAI21_X1
X_27643_ _05889_ _09374_ VDD VSS BUF_X2
X_27644_ _09374_ gen_regfile_ff.register_file_i.rf_reg\[429\]
+ _09365_ _02515_ VDD VSS MUX2_X1
X_27645_ _05927_ _09375_ VDD VSS BUF_X2
X_27646_ _09364_ _09376_ VDD VSS BUF_X4
X_27647_ _09375_ gen_regfile_ff.register_file_i.rf_reg\[430\]
+ _09376_ _02516_ VDD VSS MUX2_X1
X_27648_ _05974_ gen_regfile_ff.register_file_i.rf_reg\[431\]
+ _09376_ _02517_ VDD VSS MUX2_X1
X_27649_ _05652_ _09377_ VDD VSS BUF_X2
X_27650_ _09377_ gen_regfile_ff.register_file_i.rf_reg\[71\]
+ _09343_ _02518_ VDD VSS MUX2_X1
X_27651_ gen_regfile_ff.register_file_i.rf_reg\[35\] _09249_
+ _09378_ VDD VSS NAND2_X1
X_27652_ _09378_ _09249_ _09309_ _02519_ VDD VSS OAI21_X1
X_27653_ gen_regfile_ff.register_file_i.rf_reg\[432\] _09366_
+ _09379_ VDD VSS NAND2_X1
X_27654_ _09379_ _09368_ _06234_ _02520_ VDD VSS OAI21_X1
X_27655_ _06062_ gen_regfile_ff.register_file_i.rf_reg\[433\]
+ _09376_ _02521_ VDD VSS MUX2_X1
X_27656_ _06100_ gen_regfile_ff.register_file_i.rf_reg\[434\]
+ _09376_ _02522_ VDD VSS MUX2_X1
X_27657_ gen_regfile_ff.register_file_i.rf_reg\[435\] _09366_
+ _09380_ VDD VSS NAND2_X1
X_27658_ _09380_ _09368_ _09292_ _02523_ VDD VSS OAI21_X1
X_27659_ _06174_ gen_regfile_ff.register_file_i.rf_reg\[436\]
+ _09376_ _02524_ VDD VSS MUX2_X1
X_27660_ _06207_ gen_regfile_ff.register_file_i.rf_reg\[437\]
+ _09376_ _02525_ VDD VSS MUX2_X1
X_27661_ _09359_ gen_regfile_ff.register_file_i.rf_reg\[438\]
+ _09376_ _02526_ VDD VSS MUX2_X1
X_27662_ _04766_ gen_regfile_ff.register_file_i.rf_reg\[439\]
+ _09376_ _02527_ VDD VSS MUX2_X1
X_27663_ gen_regfile_ff.register_file_i.rf_reg\[440\] _09366_
+ _09381_ VDD VSS NAND2_X1
X_27664_ _09381_ _09368_ _09295_ _02528_ VDD VSS OAI21_X1
X_27665_ gen_regfile_ff.register_file_i.rf_reg\[441\] _09366_
+ _09382_ VDD VSS NAND2_X1
X_27666_ _09382_ _09297_ _09368_ _02529_ VDD VSS OAI21_X4
X_27667_ gen_regfile_ff.register_file_i.rf_reg\[72\] _09336_
+ _09383_ VDD VSS NOR2_X1
X_27668_ _05687_ _09384_ VDD VSS CLKBUF_X3
X_27669_ _09383_ _09336_ _09384_ _02530_ VDD VSS AOI21_X1
X_27670_ _05037_ gen_regfile_ff.register_file_i.rf_reg\[442\]
+ _09376_ _02531_ VDD VSS MUX2_X1
X_27671_ _09293_ gen_regfile_ff.register_file_i.rf_reg\[443\]
+ _09376_ _02532_ VDD VSS MUX2_X1
X_27672_ _05094_ gen_regfile_ff.register_file_i.rf_reg\[444\]
+ _09364_ _02533_ VDD VSS MUX2_X1
X_27673_ gen_regfile_ff.register_file_i.rf_reg\[445\] _09366_
+ _09385_ VDD VSS NAND2_X1
X_27674_ _09385_ _09368_ _09313_ _02534_ VDD VSS OAI21_X1
X_27675_ _05211_ gen_regfile_ff.register_file_i.rf_reg\[446\]
+ _09364_ _02535_ VDD VSS MUX2_X1
X_27676_ gen_regfile_ff.register_file_i.rf_reg\[447\] _09366_
+ _09386_ VDD VSS NAND2_X1
X_27677_ _09386_ net680 _09368_ _02536_ VDD VSS OAI21_X4
X_27678_ _04613_ _09300_ _09387_ VDD VSS NAND2_X4
X_27679_ _09387_ _09388_ VDD VSS BUF_X4
X_27680_ _05372_ gen_regfile_ff.register_file_i.rf_reg\[448\]
+ _09388_ _02537_ VDD VSS MUX2_X1
X_27681_ _05410_ gen_regfile_ff.register_file_i.rf_reg\[449\]
+ _09388_ _02538_ VDD VSS MUX2_X1
X_27682_ _09387_ _09389_ VDD VSS BUF_X4
X_27683_ gen_regfile_ff.register_file_i.rf_reg\[450\] _09389_
+ _09390_ VDD VSS NAND2_X1
X_27684_ _09387_ _09391_ VDD VSS BUF_X4
X_27685_ _09390_ _09391_ _09307_ _02539_ VDD VSS OAI21_X1
X_27686_ gen_regfile_ff.register_file_i.rf_reg\[451\] _09389_
+ _09392_ VDD VSS NAND2_X1
X_27687_ _09392_ _09391_ _09309_ _02540_ VDD VSS OAI21_X1
X_27688_ _09372_ gen_regfile_ff.register_file_i.rf_reg\[73\]
+ _09343_ _02541_ VDD VSS MUX2_X1
X_27689_ _05544_ gen_regfile_ff.register_file_i.rf_reg\[452\]
+ _09388_ _02542_ VDD VSS MUX2_X1
X_27690_ _09370_ gen_regfile_ff.register_file_i.rf_reg\[453\]
+ _09388_ _02543_ VDD VSS MUX2_X1
X_27691_ _05614_ gen_regfile_ff.register_file_i.rf_reg\[454\]
+ _09388_ _02544_ VDD VSS MUX2_X1
X_27692_ _09377_ gen_regfile_ff.register_file_i.rf_reg\[455\]
+ _09388_ _02545_ VDD VSS MUX2_X1
X_27693_ gen_regfile_ff.register_file_i.rf_reg\[456\] _09389_
+ _09393_ VDD VSS NAND2_X1
X_27694_ _09393_ _09391_ _06222_ _02546_ VDD VSS OAI21_X1
X_27695_ _09372_ gen_regfile_ff.register_file_i.rf_reg\[457\]
+ _09388_ _02547_ VDD VSS MUX2_X1
X_27696_ _05762_ gen_regfile_ff.register_file_i.rf_reg\[458\]
+ _09388_ _02548_ VDD VSS MUX2_X1
X_27697_ _05802_ gen_regfile_ff.register_file_i.rf_reg\[459\]
+ _09388_ _02549_ VDD VSS MUX2_X1
X_27698_ gen_regfile_ff.register_file_i.rf_reg\[460\] _09389_
+ _09394_ VDD VSS NAND2_X1
X_27699_ _09394_ _09391_ _06231_ _02550_ VDD VSS OAI21_X1
X_27700_ _09374_ gen_regfile_ff.register_file_i.rf_reg\[461\]
+ _09388_ _02551_ VDD VSS MUX2_X1
X_27701_ _09335_ _09395_ VDD VSS BUF_X4
X_27702_ gen_regfile_ff.register_file_i.rf_reg\[74\] _09185_
+ _09395_ _02552_ VDD VSS MUX2_X1
X_27703_ _09387_ _09396_ VDD VSS BUF_X4
X_27704_ _09375_ gen_regfile_ff.register_file_i.rf_reg\[462\]
+ _09396_ _02553_ VDD VSS MUX2_X1
X_27705_ _05974_ gen_regfile_ff.register_file_i.rf_reg\[463\]
+ _09396_ _02554_ VDD VSS MUX2_X1
X_27706_ gen_regfile_ff.register_file_i.rf_reg\[464\] _09389_
+ _09397_ VDD VSS NAND2_X1
X_27707_ _09397_ _09391_ _06234_ _02555_ VDD VSS OAI21_X1
X_27708_ _06062_ gen_regfile_ff.register_file_i.rf_reg\[465\]
+ _09396_ _02556_ VDD VSS MUX2_X1
X_27709_ _06100_ gen_regfile_ff.register_file_i.rf_reg\[466\]
+ _09396_ _02557_ VDD VSS MUX2_X1
X_27710_ gen_regfile_ff.register_file_i.rf_reg\[467\] _09389_
+ _09398_ VDD VSS NAND2_X1
X_27711_ _09398_ _09391_ _09292_ _02558_ VDD VSS OAI21_X1
X_27712_ _06174_ gen_regfile_ff.register_file_i.rf_reg\[468\]
+ _09396_ _02559_ VDD VSS MUX2_X1
X_27713_ _06207_ gen_regfile_ff.register_file_i.rf_reg\[469\]
+ _09396_ _02560_ VDD VSS MUX2_X1
X_27714_ _09359_ gen_regfile_ff.register_file_i.rf_reg\[470\]
+ _09396_ _02561_ VDD VSS MUX2_X1
X_27715_ net684 gen_regfile_ff.register_file_i.rf_reg\[471\]
+ _09396_ _02562_ VDD VSS MUX2_X1
X_27716_ gen_regfile_ff.register_file_i.rf_reg\[75\] _09186_
+ _09395_ _02563_ VDD VSS MUX2_X1
X_27717_ gen_regfile_ff.register_file_i.rf_reg\[472\] _09389_
+ _09399_ VDD VSS NAND2_X1
X_27718_ _09399_ _09391_ _09295_ _02564_ VDD VSS OAI21_X1
X_27719_ gen_regfile_ff.register_file_i.rf_reg\[473\] _09389_
+ _09400_ VDD VSS NAND2_X1
X_27720_ _09400_ _09297_ _09391_ _02565_ VDD VSS OAI21_X4
X_27721_ net687 gen_regfile_ff.register_file_i.rf_reg\[474\]
+ _09396_ _02566_ VDD VSS MUX2_X1
X_27722_ _09293_ gen_regfile_ff.register_file_i.rf_reg\[475\]
+ _09396_ _02567_ VDD VSS MUX2_X1
X_27723_ _05094_ gen_regfile_ff.register_file_i.rf_reg\[476\]
+ _09387_ _02568_ VDD VSS MUX2_X1
X_27724_ gen_regfile_ff.register_file_i.rf_reg\[477\] _09389_
+ _09401_ VDD VSS NAND2_X1
X_27725_ _09401_ _09391_ _09313_ _02569_ VDD VSS OAI21_X1
X_27726_ _05211_ gen_regfile_ff.register_file_i.rf_reg\[478\]
+ _09387_ _02570_ VDD VSS MUX2_X1
X_27727_ gen_regfile_ff.register_file_i.rf_reg\[479\] _09389_
+ _09402_ VDD VSS NAND2_X1
X_27728_ _09402_ _09324_ _09391_ _02571_ VDD VSS OAI21_X4
X_27729_ _04613_ _04852_ _09403_ VDD VSS NAND2_X4
X_27730_ _09403_ _09404_ VDD VSS BUF_X4
X_27731_ _05372_ gen_regfile_ff.register_file_i.rf_reg\[480\]
+ _09404_ _02572_ VDD VSS MUX2_X1
X_27732_ _05410_ gen_regfile_ff.register_file_i.rf_reg\[481\]
+ _09404_ _02573_ VDD VSS MUX2_X1
X_27733_ gen_regfile_ff.register_file_i.rf_reg\[76\] _09336_
+ _09405_ VDD VSS NOR2_X1
X_27734_ _09405_ _09336_ _09316_ _02574_ VDD VSS AOI21_X1
X_27735_ _09403_ _09406_ VDD VSS BUF_X4
X_27736_ gen_regfile_ff.register_file_i.rf_reg\[482\] _09406_
+ _09407_ VDD VSS NAND2_X1
X_27737_ _09403_ _09408_ VDD VSS BUF_X4
X_27738_ _09407_ _09408_ _09307_ _02575_ VDD VSS OAI21_X1
X_27739_ gen_regfile_ff.register_file_i.rf_reg\[483\] _09406_
+ _09409_ VDD VSS NAND2_X1
X_27740_ _09409_ _09408_ _09309_ _02576_ VDD VSS OAI21_X1
X_27741_ _05544_ gen_regfile_ff.register_file_i.rf_reg\[484\]
+ _09404_ _02577_ VDD VSS MUX2_X1
X_27742_ _09370_ gen_regfile_ff.register_file_i.rf_reg\[485\]
+ _09404_ _02578_ VDD VSS MUX2_X1
X_27743_ _05614_ gen_regfile_ff.register_file_i.rf_reg\[486\]
+ _09404_ _02579_ VDD VSS MUX2_X1
X_27744_ _09377_ gen_regfile_ff.register_file_i.rf_reg\[487\]
+ _09404_ _02580_ VDD VSS MUX2_X1
X_27745_ gen_regfile_ff.register_file_i.rf_reg\[488\] _09406_
+ _09410_ VDD VSS NAND2_X1
X_27746_ _09410_ _09408_ _06222_ _02581_ VDD VSS OAI21_X1
X_27747_ _09372_ gen_regfile_ff.register_file_i.rf_reg\[489\]
+ _09404_ _02582_ VDD VSS MUX2_X1
X_27748_ _05762_ gen_regfile_ff.register_file_i.rf_reg\[490\]
+ _09404_ _02583_ VDD VSS MUX2_X1
X_27749_ _05802_ gen_regfile_ff.register_file_i.rf_reg\[491\]
+ _09404_ _02584_ VDD VSS MUX2_X1
X_27750_ _09374_ gen_regfile_ff.register_file_i.rf_reg\[77\]
+ _09343_ _02585_ VDD VSS MUX2_X1
X_27751_ gen_regfile_ff.register_file_i.rf_reg\[492\] _09406_
+ _09411_ VDD VSS NAND2_X1
X_27752_ _09411_ _09408_ _06231_ _02586_ VDD VSS OAI21_X1
X_27753_ _09374_ gen_regfile_ff.register_file_i.rf_reg\[493\]
+ _09404_ _02587_ VDD VSS MUX2_X1
X_27754_ _09403_ _09412_ VDD VSS BUF_X4
X_27755_ _09375_ gen_regfile_ff.register_file_i.rf_reg\[494\]
+ _09412_ _02588_ VDD VSS MUX2_X1
X_27756_ _05974_ gen_regfile_ff.register_file_i.rf_reg\[495\]
+ _09412_ _02589_ VDD VSS MUX2_X1
X_27757_ gen_regfile_ff.register_file_i.rf_reg\[496\] _09406_
+ _09413_ VDD VSS NAND2_X1
X_27758_ _09413_ _09408_ _06234_ _02590_ VDD VSS OAI21_X1
X_27759_ _06062_ gen_regfile_ff.register_file_i.rf_reg\[497\]
+ _09412_ _02591_ VDD VSS MUX2_X1
X_27760_ _06100_ gen_regfile_ff.register_file_i.rf_reg\[498\]
+ _09412_ _02592_ VDD VSS MUX2_X1
X_27761_ gen_regfile_ff.register_file_i.rf_reg\[499\] _09406_
+ _09414_ VDD VSS NAND2_X1
X_27762_ _09414_ _09408_ _09292_ _02593_ VDD VSS OAI21_X1
X_27763_ net668 gen_regfile_ff.register_file_i.rf_reg\[500\]
+ _09412_ _02594_ VDD VSS MUX2_X1
X_27764_ _06207_ gen_regfile_ff.register_file_i.rf_reg\[501\]
+ _09412_ _02595_ VDD VSS MUX2_X1
X_27765_ _09375_ gen_regfile_ff.register_file_i.rf_reg\[78\]
+ _09343_ _02596_ VDD VSS MUX2_X1
X_27766_ _09359_ gen_regfile_ff.register_file_i.rf_reg\[502\]
+ _09412_ _02597_ VDD VSS MUX2_X1
X_27767_ _04766_ gen_regfile_ff.register_file_i.rf_reg\[503\]
+ _09412_ _02598_ VDD VSS MUX2_X1
X_27768_ gen_regfile_ff.register_file_i.rf_reg\[504\] _09406_
+ _09415_ VDD VSS NAND2_X1
X_27769_ _09415_ _09408_ _09295_ _02599_ VDD VSS OAI21_X1
X_27770_ gen_regfile_ff.register_file_i.rf_reg\[505\] _09406_
+ _09416_ VDD VSS NAND2_X1
X_27771_ _09416_ _09297_ _09408_ _02600_ VDD VSS OAI21_X4
X_27772_ _05037_ gen_regfile_ff.register_file_i.rf_reg\[506\]
+ _09412_ _02601_ VDD VSS MUX2_X1
X_27773_ net409 gen_regfile_ff.register_file_i.rf_reg\[507\]
+ _09412_ _02602_ VDD VSS MUX2_X1
X_27774_ _05094_ gen_regfile_ff.register_file_i.rf_reg\[508\]
+ _09403_ _02603_ VDD VSS MUX2_X1
X_27775_ gen_regfile_ff.register_file_i.rf_reg\[509\] _09406_
+ _09417_ VDD VSS NAND2_X1
X_27776_ _09417_ _09408_ _09313_ _02604_ VDD VSS OAI21_X1
X_27777_ _05211_ gen_regfile_ff.register_file_i.rf_reg\[510\]
+ _09403_ _02605_ VDD VSS MUX2_X1
X_27778_ gen_regfile_ff.register_file_i.rf_reg\[511\] _09406_
+ _09418_ VDD VSS NAND2_X1
X_27779_ _09418_ net680 _09408_ _02606_ VDD VSS OAI21_X4
X_27780_ gen_regfile_ff.register_file_i.rf_reg\[79\] _09190_
+ _09395_ _02607_ VDD VSS MUX2_X1
X_27781_ _05371_ _09419_ VDD VSS BUF_X2
X_27782_ _10394_ _10902_ _04603_ _09420_ VDD VSS NOR3_X4
X_27783_ _05805_ _09420_ _09421_ VDD VSS AND2_X1
X_27784_ _09421_ _09422_ VDD VSS BUF_X4
X_27785_ gen_regfile_ff.register_file_i.rf_reg\[512\] _09419_
+ _09422_ _02608_ VDD VSS MUX2_X1
X_27786_ _05409_ _09423_ VDD VSS BUF_X2
X_27787_ gen_regfile_ff.register_file_i.rf_reg\[513\] _09423_
+ _09422_ _02609_ VDD VSS MUX2_X1
X_27788_ _04854_ _09420_ _09424_ VDD VSS NAND2_X4
X_27789_ _09424_ _09425_ VDD VSS CLKBUF_X3
X_27790_ gen_regfile_ff.register_file_i.rf_reg\[514\] _09425_
+ _09426_ VDD VSS NAND2_X1
X_27791_ _09426_ _09425_ _09307_ _02610_ VDD VSS OAI21_X1
X_27792_ gen_regfile_ff.register_file_i.rf_reg\[515\] _09425_
+ _09427_ VDD VSS NAND2_X1
X_27793_ _09427_ _09425_ _09309_ _02611_ VDD VSS OAI21_X1
X_27794_ gen_regfile_ff.register_file_i.rf_reg\[516\] _09178_
+ _09422_ _02612_ VDD VSS MUX2_X1
X_27795_ _09370_ gen_regfile_ff.register_file_i.rf_reg\[517\]
+ _09424_ _02613_ VDD VSS MUX2_X1
X_27796_ gen_regfile_ff.register_file_i.rf_reg\[518\] _09180_
+ _09422_ _02614_ VDD VSS MUX2_X1
X_27797_ _09377_ gen_regfile_ff.register_file_i.rf_reg\[519\]
+ _09424_ _02615_ VDD VSS MUX2_X1
X_27798_ gen_regfile_ff.register_file_i.rf_reg\[520\] _09422_
+ _09428_ VDD VSS NOR2_X1
X_27799_ _09428_ _09422_ _09384_ _02616_ VDD VSS AOI21_X1
X_27800_ _09372_ gen_regfile_ff.register_file_i.rf_reg\[521\]
+ _09424_ _02617_ VDD VSS MUX2_X1
X_27801_ gen_regfile_ff.register_file_i.rf_reg\[80\] _09336_
+ _09429_ VDD VSS NOR2_X1
X_27802_ _09429_ _09336_ _09318_ _02618_ VDD VSS AOI21_X1
X_27803_ _05761_ _09430_ VDD VSS BUF_X2
X_27804_ _09421_ _09431_ VDD VSS BUF_X4
X_27805_ gen_regfile_ff.register_file_i.rf_reg\[522\] _09430_
+ _09431_ _02619_ VDD VSS MUX2_X1
X_27806_ _05801_ _09432_ VDD VSS BUF_X2
X_27807_ gen_regfile_ff.register_file_i.rf_reg\[523\] _09432_
+ _09431_ _02620_ VDD VSS MUX2_X1
X_27808_ gen_regfile_ff.register_file_i.rf_reg\[524\] _09422_
+ _09433_ VDD VSS NOR2_X1
X_27809_ _09433_ _09422_ _09316_ _02621_ VDD VSS AOI21_X1
X_27810_ _09374_ gen_regfile_ff.register_file_i.rf_reg\[525\]
+ _09424_ _02622_ VDD VSS MUX2_X1
X_27811_ _09375_ gen_regfile_ff.register_file_i.rf_reg\[526\]
+ _09424_ _02623_ VDD VSS MUX2_X1
X_27812_ _05973_ _09434_ VDD VSS BUF_X4
X_27813_ gen_regfile_ff.register_file_i.rf_reg\[527\] _09434_
+ _09431_ _02624_ VDD VSS MUX2_X1
X_27814_ gen_regfile_ff.register_file_i.rf_reg\[528\] _09422_
+ _09435_ VDD VSS NOR2_X1
X_27815_ _09435_ _09422_ _09318_ _02625_ VDD VSS AOI21_X1
X_27816_ gen_regfile_ff.register_file_i.rf_reg\[529\] _09192_
+ _09431_ _02626_ VDD VSS MUX2_X1
X_27817_ gen_regfile_ff.register_file_i.rf_reg\[530\] _09193_
+ _09431_ _02627_ VDD VSS MUX2_X1
X_27818_ gen_regfile_ff.register_file_i.rf_reg\[531\] _09425_
+ _09436_ VDD VSS NAND2_X1
X_27819_ _05805_ _09420_ _09437_ VDD VSS NAND2_X2
X_27820_ _09436_ _09437_ _09292_ _02628_ VDD VSS OAI21_X1
X_27821_ _06061_ _09438_ VDD VSS BUF_X2
X_27822_ gen_regfile_ff.register_file_i.rf_reg\[81\] _09438_
+ _09395_ _02629_ VDD VSS MUX2_X1
X_27823_ _05543_ _09439_ VDD VSS BUF_X2
X_27824_ gen_regfile_ff.register_file_i.rf_reg\[36\] _09439_
+ _09236_ _02630_ VDD VSS MUX2_X1
X_27825_ gen_regfile_ff.register_file_i.rf_reg\[532\] _09195_
+ _09431_ _02631_ VDD VSS MUX2_X1
X_27826_ gen_regfile_ff.register_file_i.rf_reg\[533\] _09196_
+ _09431_ _02632_ VDD VSS MUX2_X1
X_27827_ _09359_ gen_regfile_ff.register_file_i.rf_reg\[534\]
+ _09424_ _02633_ VDD VSS MUX2_X1
X_27828_ gen_regfile_ff.register_file_i.rf_reg\[535\] net686
+ _09431_ _02634_ VDD VSS MUX2_X1
X_27829_ gen_regfile_ff.register_file_i.rf_reg\[536\] _09425_
+ _09440_ VDD VSS NAND2_X1
X_27830_ _09440_ _09437_ _09295_ _02635_ VDD VSS OAI21_X1
X_27831_ gen_regfile_ff.register_file_i.rf_reg\[537\] _09425_
+ _09441_ VDD VSS NAND2_X1
X_27832_ _09441_ net683 _09425_ _02636_ VDD VSS OAI21_X4
X_27833_ gen_regfile_ff.register_file_i.rf_reg\[538\] _09201_
+ _09431_ _02637_ VDD VSS MUX2_X1
X_27834_ net409 gen_regfile_ff.register_file_i.rf_reg\[539\]
+ _09424_ _02638_ VDD VSS MUX2_X1
X_27835_ _05093_ _09442_ VDD VSS BUF_X2
X_27836_ gen_regfile_ff.register_file_i.rf_reg\[540\] _09442_
+ _09431_ _02639_ VDD VSS MUX2_X1
X_27837_ gen_regfile_ff.register_file_i.rf_reg\[541\] _09425_
+ _09443_ VDD VSS NAND2_X1
X_27838_ _09443_ _09437_ _09313_ _02640_ VDD VSS OAI21_X1
X_27839_ _06099_ _09444_ VDD VSS BUF_X2
X_27840_ gen_regfile_ff.register_file_i.rf_reg\[82\] _09444_
+ _09395_ _02641_ VDD VSS MUX2_X1
X_27841_ _05210_ _09445_ VDD VSS BUF_X4
X_27842_ gen_regfile_ff.register_file_i.rf_reg\[542\] net354
+ _09421_ _02642_ VDD VSS MUX2_X1
X_27843_ gen_regfile_ff.register_file_i.rf_reg\[543\] _09425_
+ _09446_ VDD VSS NAND2_X1
X_27844_ _09446_ net680 _09437_ _02643_ VDD VSS OAI21_X4
X_27845_ _04604_ _05413_ _09447_ VDD VSS AND2_X1
X_27846_ _09447_ _09448_ VDD VSS BUF_X4
X_27847_ gen_regfile_ff.register_file_i.rf_reg\[544\] _09419_
+ _09448_ _02644_ VDD VSS MUX2_X1
X_27848_ gen_regfile_ff.register_file_i.rf_reg\[545\] _09423_
+ _09448_ _02645_ VDD VSS MUX2_X1
X_27849_ _04604_ _04854_ _09449_ VDD VSS NAND2_X4
X_27850_ _09449_ _09450_ VDD VSS CLKBUF_X3
X_27851_ gen_regfile_ff.register_file_i.rf_reg\[546\] _09450_
+ _09451_ VDD VSS NAND2_X1
X_27852_ _09451_ _09450_ _09307_ _02646_ VDD VSS OAI21_X1
X_27853_ gen_regfile_ff.register_file_i.rf_reg\[547\] _09450_
+ _09452_ VDD VSS NAND2_X1
X_27854_ _09452_ _09450_ _09309_ _02647_ VDD VSS OAI21_X1
X_27855_ gen_regfile_ff.register_file_i.rf_reg\[548\] _09439_
+ _09448_ _02648_ VDD VSS MUX2_X1
X_27856_ _09370_ gen_regfile_ff.register_file_i.rf_reg\[549\]
+ _09449_ _02649_ VDD VSS MUX2_X1
X_27857_ _05613_ _09453_ VDD VSS BUF_X2
X_27858_ gen_regfile_ff.register_file_i.rf_reg\[550\] _09453_
+ _09448_ _02650_ VDD VSS MUX2_X1
X_27859_ _09377_ gen_regfile_ff.register_file_i.rf_reg\[551\]
+ _09449_ _02651_ VDD VSS MUX2_X1
X_27860_ gen_regfile_ff.register_file_i.rf_reg\[83\] _09344_
+ _09454_ VDD VSS NAND2_X1
X_27861_ _05805_ _09300_ _09455_ VDD VSS NAND2_X2
X_27862_ _09454_ _09455_ _09292_ _02652_ VDD VSS OAI21_X1
X_27863_ gen_regfile_ff.register_file_i.rf_reg\[552\] _09448_
+ _09456_ VDD VSS NOR2_X1
X_27864_ _09456_ _09448_ _09384_ _02653_ VDD VSS AOI21_X1
X_27865_ _09372_ gen_regfile_ff.register_file_i.rf_reg\[553\]
+ _09449_ _02654_ VDD VSS MUX2_X1
X_27866_ _09447_ _09457_ VDD VSS BUF_X4
X_27867_ gen_regfile_ff.register_file_i.rf_reg\[554\] _09430_
+ _09457_ _02655_ VDD VSS MUX2_X1
X_27868_ gen_regfile_ff.register_file_i.rf_reg\[555\] _09432_
+ _09457_ _02656_ VDD VSS MUX2_X1
X_27869_ gen_regfile_ff.register_file_i.rf_reg\[556\] _09448_
+ _09458_ VDD VSS NOR2_X1
X_27870_ _09458_ _09448_ _09316_ _02657_ VDD VSS AOI21_X1
X_27871_ _09374_ gen_regfile_ff.register_file_i.rf_reg\[557\]
+ _09449_ _02658_ VDD VSS MUX2_X1
X_27872_ _09375_ gen_regfile_ff.register_file_i.rf_reg\[558\]
+ _09449_ _02659_ VDD VSS MUX2_X1
X_27873_ gen_regfile_ff.register_file_i.rf_reg\[559\] _09434_
+ _09457_ _02660_ VDD VSS MUX2_X1
X_27874_ gen_regfile_ff.register_file_i.rf_reg\[560\] _09448_
+ _09459_ VDD VSS NOR2_X1
X_27875_ _09459_ _09448_ _09318_ _02661_ VDD VSS AOI21_X1
X_27876_ gen_regfile_ff.register_file_i.rf_reg\[561\] _09438_
+ _09457_ _02662_ VDD VSS MUX2_X1
X_27877_ _06173_ _09460_ VDD VSS BUF_X4
X_27878_ gen_regfile_ff.register_file_i.rf_reg\[84\] net655
+ _09395_ _02663_ VDD VSS MUX2_X1
X_27879_ gen_regfile_ff.register_file_i.rf_reg\[562\] _09444_
+ _09457_ _02664_ VDD VSS MUX2_X1
X_27880_ gen_regfile_ff.register_file_i.rf_reg\[563\] _09450_
+ _09461_ VDD VSS NAND2_X1
X_27881_ _04604_ _05805_ _09462_ VDD VSS NAND2_X2
X_27882_ _09461_ _09462_ _09292_ _02665_ VDD VSS OAI21_X1
X_27883_ gen_regfile_ff.register_file_i.rf_reg\[564\] _09460_
+ _09457_ _02666_ VDD VSS MUX2_X1
X_27884_ _06206_ _09463_ VDD VSS BUF_X2
X_27885_ gen_regfile_ff.register_file_i.rf_reg\[565\] _09463_
+ _09457_ _02667_ VDD VSS MUX2_X1
X_27886_ _09359_ gen_regfile_ff.register_file_i.rf_reg\[566\]
+ _09449_ _02668_ VDD VSS MUX2_X1
X_27887_ _04765_ _09464_ VDD VSS BUF_X2
X_27888_ gen_regfile_ff.register_file_i.rf_reg\[567\] _09464_
+ _09457_ _02669_ VDD VSS MUX2_X1
X_27889_ gen_regfile_ff.register_file_i.rf_reg\[568\] _09450_
+ _09465_ VDD VSS NAND2_X1
X_27890_ _09465_ _09462_ _09295_ _02670_ VDD VSS OAI21_X1
X_27891_ gen_regfile_ff.register_file_i.rf_reg\[569\] _09450_
+ _09466_ VDD VSS NAND2_X1
X_27892_ _09466_ net683 _09450_ _02671_ VDD VSS OAI21_X4
X_27893_ _05036_ _09467_ VDD VSS BUF_X2
X_27894_ gen_regfile_ff.register_file_i.rf_reg\[570\] _09467_
+ _09457_ _02672_ VDD VSS MUX2_X1
X_27895_ _09293_ gen_regfile_ff.register_file_i.rf_reg\[571\]
+ _09449_ _02673_ VDD VSS MUX2_X1
X_27896_ gen_regfile_ff.register_file_i.rf_reg\[85\] _09463_
+ _09395_ _02674_ VDD VSS MUX2_X1
X_27897_ gen_regfile_ff.register_file_i.rf_reg\[572\] _09442_
+ _09457_ _02675_ VDD VSS MUX2_X1
X_27898_ gen_regfile_ff.register_file_i.rf_reg\[573\] _09450_
+ _09468_ VDD VSS NAND2_X1
X_27899_ _09468_ _09462_ _09313_ _02676_ VDD VSS OAI21_X1
X_27900_ gen_regfile_ff.register_file_i.rf_reg\[574\] net354
+ _09447_ _02677_ VDD VSS MUX2_X1
X_27901_ gen_regfile_ff.register_file_i.rf_reg\[575\] _09450_
+ _09469_ VDD VSS NAND2_X1
X_27902_ _09469_ net680 _09462_ _02678_ VDD VSS OAI21_X4
X_27903_ _05413_ _05374_ _09470_ VDD VSS AND2_X1
X_27904_ _09470_ _09471_ VDD VSS BUF_X4
X_27905_ gen_regfile_ff.register_file_i.rf_reg\[576\] _09419_
+ _09471_ _02679_ VDD VSS MUX2_X1
X_27906_ gen_regfile_ff.register_file_i.rf_reg\[577\] _09423_
+ _09471_ _02680_ VDD VSS MUX2_X1
X_27907_ _04854_ _05374_ _09472_ VDD VSS NAND2_X4
X_27908_ _09472_ _09473_ VDD VSS CLKBUF_X3
X_27909_ gen_regfile_ff.register_file_i.rf_reg\[578\] _09473_
+ _09474_ VDD VSS NAND2_X1
X_27910_ _05463_ _09475_ VDD VSS CLKBUF_X3
X_27911_ _09474_ _09473_ _09475_ _02681_ VDD VSS OAI21_X1
X_27912_ gen_regfile_ff.register_file_i.rf_reg\[579\] _09473_
+ _09476_ VDD VSS NAND2_X1
X_27913_ _05509_ _09477_ VDD VSS CLKBUF_X3
X_27914_ _09476_ _09473_ _09477_ _02682_ VDD VSS OAI21_X1
X_27915_ gen_regfile_ff.register_file_i.rf_reg\[580\] _09439_
+ _09471_ _02683_ VDD VSS MUX2_X1
X_27916_ _09370_ gen_regfile_ff.register_file_i.rf_reg\[581\]
+ _09472_ _02684_ VDD VSS MUX2_X1
X_27917_ _09359_ gen_regfile_ff.register_file_i.rf_reg\[86\]
+ _09343_ _02685_ VDD VSS MUX2_X1
X_27918_ gen_regfile_ff.register_file_i.rf_reg\[582\] _09453_
+ _09471_ _02686_ VDD VSS MUX2_X1
X_27919_ _09377_ gen_regfile_ff.register_file_i.rf_reg\[583\]
+ _09472_ _02687_ VDD VSS MUX2_X1
X_27920_ gen_regfile_ff.register_file_i.rf_reg\[584\] _09471_
+ _09478_ VDD VSS NOR2_X1
X_27921_ _09478_ _09471_ _09384_ _02688_ VDD VSS AOI21_X1
X_27922_ _09372_ gen_regfile_ff.register_file_i.rf_reg\[585\]
+ _09472_ _02689_ VDD VSS MUX2_X1
X_27923_ _09470_ _09479_ VDD VSS BUF_X4
X_27924_ gen_regfile_ff.register_file_i.rf_reg\[586\] _09430_
+ _09479_ _02690_ VDD VSS MUX2_X1
X_27925_ gen_regfile_ff.register_file_i.rf_reg\[587\] _09432_
+ _09479_ _02691_ VDD VSS MUX2_X1
X_27926_ gen_regfile_ff.register_file_i.rf_reg\[588\] _09471_
+ _09480_ VDD VSS NOR2_X1
X_27927_ _09480_ _09471_ _09316_ _02692_ VDD VSS AOI21_X1
X_27928_ _09374_ gen_regfile_ff.register_file_i.rf_reg\[589\]
+ _09472_ _02693_ VDD VSS MUX2_X1
X_27929_ _09375_ gen_regfile_ff.register_file_i.rf_reg\[590\]
+ _09472_ _02694_ VDD VSS MUX2_X1
X_27930_ gen_regfile_ff.register_file_i.rf_reg\[591\] _09434_
+ _09479_ _02695_ VDD VSS MUX2_X1
X_27931_ gen_regfile_ff.register_file_i.rf_reg\[87\] _09464_
+ _09395_ _02696_ VDD VSS MUX2_X1
X_27932_ gen_regfile_ff.register_file_i.rf_reg\[592\] _09471_
+ _09481_ VDD VSS NOR2_X1
X_27933_ _09481_ _09471_ _09318_ _02697_ VDD VSS AOI21_X1
X_27934_ gen_regfile_ff.register_file_i.rf_reg\[593\] _09438_
+ _09479_ _02698_ VDD VSS MUX2_X1
X_27935_ gen_regfile_ff.register_file_i.rf_reg\[594\] _09444_
+ _09479_ _02699_ VDD VSS MUX2_X1
X_27936_ gen_regfile_ff.register_file_i.rf_reg\[595\] _09473_
+ _09482_ VDD VSS NAND2_X1
X_27937_ _05805_ _05374_ _09483_ VDD VSS NAND2_X2
X_27938_ _06137_ _09484_ VDD VSS CLKBUF_X3
X_27939_ _09482_ _09483_ _09484_ _02700_ VDD VSS OAI21_X1
X_27940_ gen_regfile_ff.register_file_i.rf_reg\[596\] net655
+ _09479_ _02701_ VDD VSS MUX2_X1
X_27941_ gen_regfile_ff.register_file_i.rf_reg\[597\] _09463_
+ _09479_ _02702_ VDD VSS MUX2_X1
X_27942_ _09359_ gen_regfile_ff.register_file_i.rf_reg\[598\]
+ _09472_ _02703_ VDD VSS MUX2_X1
X_27943_ gen_regfile_ff.register_file_i.rf_reg\[599\] _09464_
+ _09479_ _02704_ VDD VSS MUX2_X1
X_27944_ gen_regfile_ff.register_file_i.rf_reg\[600\] _09473_
+ _09485_ VDD VSS NAND2_X1
X_27945_ _09485_ _09483_ _09295_ _02705_ VDD VSS OAI21_X1
X_27946_ gen_regfile_ff.register_file_i.rf_reg\[601\] _09473_
+ _09486_ VDD VSS NAND2_X1
X_27947_ _09486_ net683 _09473_ _02706_ VDD VSS OAI21_X4
X_27948_ gen_regfile_ff.register_file_i.rf_reg\[88\] _09344_
+ _09487_ VDD VSS NAND2_X1
X_27949_ _04907_ _09488_ VDD VSS CLKBUF_X3
X_27950_ _09487_ _09455_ _09488_ _02707_ VDD VSS OAI21_X1
X_27951_ gen_regfile_ff.register_file_i.rf_reg\[602\] _09467_
+ _09479_ _02708_ VDD VSS MUX2_X1
X_27952_ _09293_ gen_regfile_ff.register_file_i.rf_reg\[603\]
+ _09472_ _02709_ VDD VSS MUX2_X1
X_27953_ gen_regfile_ff.register_file_i.rf_reg\[604\] _09442_
+ _09479_ _02710_ VDD VSS MUX2_X1
X_27954_ gen_regfile_ff.register_file_i.rf_reg\[605\] _09473_
+ _09489_ VDD VSS NAND2_X1
X_27955_ _09489_ _09483_ _09313_ _02711_ VDD VSS OAI21_X1
X_27956_ gen_regfile_ff.register_file_i.rf_reg\[606\] net354
+ _09470_ _02712_ VDD VSS MUX2_X1
X_27957_ gen_regfile_ff.register_file_i.rf_reg\[607\] _09473_
+ _09490_ VDD VSS NAND2_X1
X_27958_ _09490_ net680 _09483_ _02713_ VDD VSS OAI21_X4
X_27959_ _05413_ _06214_ _09491_ VDD VSS AND2_X1
X_27960_ _09491_ _09492_ VDD VSS BUF_X4
X_27961_ gen_regfile_ff.register_file_i.rf_reg\[608\] _09419_
+ _09492_ _02714_ VDD VSS MUX2_X1
X_27962_ gen_regfile_ff.register_file_i.rf_reg\[609\] _09423_
+ _09492_ _02715_ VDD VSS MUX2_X1
X_27963_ _04854_ _06214_ _09493_ VDD VSS NAND2_X4
X_27964_ _09493_ _09494_ VDD VSS CLKBUF_X3
X_27965_ gen_regfile_ff.register_file_i.rf_reg\[610\] _09494_
+ _09495_ VDD VSS NAND2_X1
X_27966_ _09495_ _09494_ _09475_ _02716_ VDD VSS OAI21_X1
X_27967_ gen_regfile_ff.register_file_i.rf_reg\[611\] _09494_
+ _09496_ VDD VSS NAND2_X1
X_27968_ _09496_ _09494_ _09477_ _02717_ VDD VSS OAI21_X1
X_27969_ gen_regfile_ff.register_file_i.rf_reg\[89\] _09344_
+ _09497_ VDD VSS NAND2_X1
X_27970_ _04977_ _09498_ VDD VSS BUF_X8
X_27971_ _09497_ net685 _09344_ _02718_ VDD VSS OAI21_X4
X_27972_ gen_regfile_ff.register_file_i.rf_reg\[612\] _09439_
+ _09492_ _02719_ VDD VSS MUX2_X1
X_27973_ _09370_ gen_regfile_ff.register_file_i.rf_reg\[613\]
+ _09493_ _02720_ VDD VSS MUX2_X1
X_27974_ gen_regfile_ff.register_file_i.rf_reg\[614\] _09453_
+ _09492_ _02721_ VDD VSS MUX2_X1
X_27975_ _09377_ gen_regfile_ff.register_file_i.rf_reg\[615\]
+ _09493_ _02722_ VDD VSS MUX2_X1
X_27976_ gen_regfile_ff.register_file_i.rf_reg\[616\] _09492_
+ _09499_ VDD VSS NOR2_X1
X_27977_ _09499_ _09492_ _09384_ _02723_ VDD VSS AOI21_X1
X_27978_ _09372_ gen_regfile_ff.register_file_i.rf_reg\[617\]
+ _09493_ _02724_ VDD VSS MUX2_X1
X_27979_ _09491_ _09500_ VDD VSS BUF_X4
X_27980_ gen_regfile_ff.register_file_i.rf_reg\[618\] _09430_
+ _09500_ _02725_ VDD VSS MUX2_X1
X_27981_ gen_regfile_ff.register_file_i.rf_reg\[619\] _09432_
+ _09500_ _02726_ VDD VSS MUX2_X1
X_27982_ gen_regfile_ff.register_file_i.rf_reg\[620\] _09492_
+ _09501_ VDD VSS NOR2_X1
X_27983_ _09501_ _09492_ _09316_ _02727_ VDD VSS AOI21_X1
X_27984_ _09374_ gen_regfile_ff.register_file_i.rf_reg\[621\]
+ _09493_ _02728_ VDD VSS MUX2_X1
X_27985_ gen_regfile_ff.register_file_i.rf_reg\[90\] _09467_
+ _09395_ _02729_ VDD VSS MUX2_X1
X_27986_ _09375_ gen_regfile_ff.register_file_i.rf_reg\[622\]
+ _09493_ _02730_ VDD VSS MUX2_X1
X_27987_ gen_regfile_ff.register_file_i.rf_reg\[623\] _09434_
+ _09500_ _02731_ VDD VSS MUX2_X1
X_27988_ gen_regfile_ff.register_file_i.rf_reg\[624\] _09492_
+ _09502_ VDD VSS NOR2_X1
X_27989_ _09502_ _09492_ _09318_ _02732_ VDD VSS AOI21_X1
X_27990_ gen_regfile_ff.register_file_i.rf_reg\[625\] _09438_
+ _09500_ _02733_ VDD VSS MUX2_X1
X_27991_ gen_regfile_ff.register_file_i.rf_reg\[626\] _09444_
+ _09500_ _02734_ VDD VSS MUX2_X1
X_27992_ gen_regfile_ff.register_file_i.rf_reg\[627\] _09494_
+ _09503_ VDD VSS NAND2_X1
X_27993_ _05805_ _06214_ _09504_ VDD VSS NAND2_X2
X_27994_ _09503_ _09504_ _09484_ _02735_ VDD VSS OAI21_X1
X_27995_ gen_regfile_ff.register_file_i.rf_reg\[628\] net655
+ _09500_ _02736_ VDD VSS MUX2_X1
X_27996_ gen_regfile_ff.register_file_i.rf_reg\[629\] _09463_
+ _09500_ _02737_ VDD VSS MUX2_X1
X_27997_ _09359_ gen_regfile_ff.register_file_i.rf_reg\[630\]
+ _09493_ _02738_ VDD VSS MUX2_X1
X_27998_ gen_regfile_ff.register_file_i.rf_reg\[631\] _09464_
+ _09500_ _02739_ VDD VSS MUX2_X1
X_27999_ net409 gen_regfile_ff.register_file_i.rf_reg\[91\]
+ _09343_ _02740_ VDD VSS MUX2_X1
X_28000_ _09370_ gen_regfile_ff.register_file_i.rf_reg\[37\]
+ _06246_ _02741_ VDD VSS MUX2_X1
X_28001_ gen_regfile_ff.register_file_i.rf_reg\[632\] _09494_
+ _09505_ VDD VSS NAND2_X1
X_28002_ _09505_ _09504_ _09488_ _02742_ VDD VSS OAI21_X1
X_28003_ gen_regfile_ff.register_file_i.rf_reg\[633\] _09494_
+ _09506_ VDD VSS NAND2_X1
X_28004_ _09506_ net685 _09494_ _02743_ VDD VSS OAI21_X4
X_28005_ gen_regfile_ff.register_file_i.rf_reg\[634\] _09467_
+ _09500_ _02744_ VDD VSS MUX2_X1
X_28006_ net409 gen_regfile_ff.register_file_i.rf_reg\[635\]
+ _09493_ _02745_ VDD VSS MUX2_X1
X_28007_ gen_regfile_ff.register_file_i.rf_reg\[636\] _09442_
+ _09500_ _02746_ VDD VSS MUX2_X1
X_28008_ gen_regfile_ff.register_file_i.rf_reg\[637\] _09494_
+ _09507_ VDD VSS NAND2_X1
X_28009_ _05147_ _09508_ VDD VSS BUF_X8
X_28010_ _09507_ _09504_ _09508_ _02747_ VDD VSS OAI21_X1
X_28011_ gen_regfile_ff.register_file_i.rf_reg\[638\] net354
+ _09491_ _02748_ VDD VSS MUX2_X1
X_28012_ gen_regfile_ff.register_file_i.rf_reg\[639\] _09494_
+ _09509_ VDD VSS NAND2_X1
X_28013_ _05259_ _09510_ VDD VSS BUF_X8
X_28014_ _09509_ net682 _09504_ _02749_ VDD VSS OAI21_X4
X_28015_ _05412_ _06226_ _09420_ _09511_ VDD VSS AND3_X1
X_28016_ _09511_ _09512_ VDD VSS BUF_X4
X_28017_ _09512_ _09513_ VDD VSS BUF_X4
X_28018_ gen_regfile_ff.register_file_i.rf_reg\[640\] _09419_
+ _09513_ _02750_ VDD VSS MUX2_X1
X_28019_ gen_regfile_ff.register_file_i.rf_reg\[641\] _09423_
+ _09513_ _02751_ VDD VSS MUX2_X1
X_28020_ gen_regfile_ff.register_file_i.rf_reg\[92\] _09442_
+ _09395_ _02752_ VDD VSS MUX2_X1
X_28021_ _06224_ _06226_ _09420_ _09514_ VDD VSS NAND3_X4
X_28022_ _09514_ _09515_ VDD VSS CLKBUF_X3
X_28023_ gen_regfile_ff.register_file_i.rf_reg\[642\] _09515_
+ _09516_ VDD VSS NAND2_X1
X_28024_ _09516_ _09515_ _09475_ _02753_ VDD VSS OAI21_X1
X_28025_ gen_regfile_ff.register_file_i.rf_reg\[643\] _09515_
+ _09517_ VDD VSS NAND2_X1
X_28026_ _09517_ _09515_ _09477_ _02754_ VDD VSS OAI21_X1
X_28027_ gen_regfile_ff.register_file_i.rf_reg\[644\] _09439_
+ _09513_ _02755_ VDD VSS MUX2_X1
X_28028_ gen_regfile_ff.register_file_i.rf_reg\[645\] _09179_
+ _09513_ _02756_ VDD VSS MUX2_X1
X_28029_ gen_regfile_ff.register_file_i.rf_reg\[646\] _09453_
+ _09513_ _02757_ VDD VSS MUX2_X1
X_28030_ gen_regfile_ff.register_file_i.rf_reg\[647\] _09181_
+ _09513_ _02758_ VDD VSS MUX2_X1
X_28031_ gen_regfile_ff.register_file_i.rf_reg\[648\] _09514_
+ _09518_ VDD VSS NAND2_X1
X_28032_ _09518_ _09515_ _06222_ _02759_ VDD VSS OAI21_X1
X_28033_ _09512_ _09519_ VDD VSS BUF_X4
X_28034_ gen_regfile_ff.register_file_i.rf_reg\[649\] _09183_
+ _09519_ _02760_ VDD VSS MUX2_X1
X_28035_ gen_regfile_ff.register_file_i.rf_reg\[650\] _09430_
+ _09519_ _02761_ VDD VSS MUX2_X1
X_28036_ gen_regfile_ff.register_file_i.rf_reg\[651\] _09432_
+ _09519_ _02762_ VDD VSS MUX2_X1
X_28037_ gen_regfile_ff.register_file_i.rf_reg\[93\] _09344_
+ _09520_ VDD VSS NAND2_X1
X_28038_ _09520_ _09455_ _09508_ _02763_ VDD VSS OAI21_X1
X_28039_ gen_regfile_ff.register_file_i.rf_reg\[652\] _09513_
+ _09521_ VDD VSS NOR2_X1
X_28040_ _09521_ _09513_ _09316_ _02764_ VDD VSS AOI21_X1
X_28041_ gen_regfile_ff.register_file_i.rf_reg\[653\] _09188_
+ _09519_ _02765_ VDD VSS MUX2_X1
X_28042_ gen_regfile_ff.register_file_i.rf_reg\[654\] _09189_
+ _09519_ _02766_ VDD VSS MUX2_X1
X_28043_ gen_regfile_ff.register_file_i.rf_reg\[655\] _09434_
+ _09519_ _02767_ VDD VSS MUX2_X1
X_28044_ gen_regfile_ff.register_file_i.rf_reg\[656\] _09513_
+ _09522_ VDD VSS NOR2_X1
X_28045_ _09522_ _09513_ _09318_ _02768_ VDD VSS AOI21_X1
X_28046_ gen_regfile_ff.register_file_i.rf_reg\[657\] _09438_
+ _09519_ _02769_ VDD VSS MUX2_X1
X_28047_ gen_regfile_ff.register_file_i.rf_reg\[658\] _09444_
+ _09519_ _02770_ VDD VSS MUX2_X1
X_28048_ gen_regfile_ff.register_file_i.rf_reg\[659\] _09514_
+ _09523_ VDD VSS NAND2_X1
X_28049_ _09523_ _09515_ _09484_ _02771_ VDD VSS OAI21_X1
X_28050_ gen_regfile_ff.register_file_i.rf_reg\[660\] net655
+ _09519_ _02772_ VDD VSS MUX2_X1
X_28051_ gen_regfile_ff.register_file_i.rf_reg\[661\] _09463_
+ _09519_ _02773_ VDD VSS MUX2_X1
X_28052_ gen_regfile_ff.register_file_i.rf_reg\[94\] net354
+ _09335_ _02774_ VDD VSS MUX2_X1
X_28053_ gen_regfile_ff.register_file_i.rf_reg\[662\] _09197_
+ _09512_ _02775_ VDD VSS MUX2_X1
X_28054_ gen_regfile_ff.register_file_i.rf_reg\[663\] _09464_
+ _09512_ _02776_ VDD VSS MUX2_X1
X_28055_ gen_regfile_ff.register_file_i.rf_reg\[664\] _09514_
+ _09524_ VDD VSS NAND2_X1
X_28056_ _09524_ _09515_ _09488_ _02777_ VDD VSS OAI21_X1
X_28057_ gen_regfile_ff.register_file_i.rf_reg\[665\] _09514_
+ _09525_ VDD VSS NAND2_X1
X_28058_ _09525_ net685 _09515_ _02778_ VDD VSS OAI21_X4
X_28059_ gen_regfile_ff.register_file_i.rf_reg\[666\] _09467_
+ _09512_ _02779_ VDD VSS MUX2_X1
X_28060_ gen_regfile_ff.register_file_i.rf_reg\[667\] _09202_
+ _09512_ _02780_ VDD VSS MUX2_X1
X_28061_ gen_regfile_ff.register_file_i.rf_reg\[668\] _09442_
+ _09512_ _02781_ VDD VSS MUX2_X1
X_28062_ gen_regfile_ff.register_file_i.rf_reg\[669\] _09514_
+ _09526_ VDD VSS NAND2_X1
X_28063_ _09526_ _09515_ _09508_ _02782_ VDD VSS OAI21_X1
X_28064_ gen_regfile_ff.register_file_i.rf_reg\[670\] _09445_
+ _09512_ _02783_ VDD VSS MUX2_X1
X_28065_ gen_regfile_ff.register_file_i.rf_reg\[671\] _09514_
+ _09527_ VDD VSS NAND2_X1
X_28066_ _09527_ net682 _09515_ _02784_ VDD VSS OAI21_X2
X_28067_ gen_regfile_ff.register_file_i.rf_reg\[95\] _09344_
+ _09528_ VDD VSS NAND2_X1
X_28068_ _09528_ _09510_ _09455_ _02785_ VDD VSS OAI21_X4
X_28069_ _05412_ _04604_ _06225_ _09529_ VDD VSS AND3_X1
X_28070_ _09529_ _09530_ VDD VSS BUF_X4
X_28071_ _09530_ _09531_ VDD VSS BUF_X4
X_28072_ gen_regfile_ff.register_file_i.rf_reg\[672\] _09419_
+ _09531_ _02786_ VDD VSS MUX2_X1
X_28073_ gen_regfile_ff.register_file_i.rf_reg\[673\] _09423_
+ _09531_ _02787_ VDD VSS MUX2_X1
X_28074_ _06224_ _04604_ _06226_ _09532_ VDD VSS NAND3_X2
X_28075_ _09532_ _09533_ VDD VSS CLKBUF_X3
X_28076_ gen_regfile_ff.register_file_i.rf_reg\[674\] _09533_
+ _09534_ VDD VSS NAND2_X1
X_28077_ _09534_ _09533_ _09475_ _02788_ VDD VSS OAI21_X1
X_28078_ gen_regfile_ff.register_file_i.rf_reg\[675\] _09533_
+ _09535_ VDD VSS NAND2_X1
X_28079_ _09535_ _09533_ _09477_ _02789_ VDD VSS OAI21_X1
X_28080_ gen_regfile_ff.register_file_i.rf_reg\[676\] _09439_
+ _09531_ _02790_ VDD VSS MUX2_X1
X_28081_ gen_regfile_ff.register_file_i.rf_reg\[677\] _09179_
+ _09531_ _02791_ VDD VSS MUX2_X1
X_28082_ _09530_ _09536_ VDD VSS BUF_X4
X_28083_ gen_regfile_ff.register_file_i.rf_reg\[678\] _09453_
+ _09536_ _02792_ VDD VSS MUX2_X1
X_28084_ gen_regfile_ff.register_file_i.rf_reg\[679\] _09181_
+ _09536_ _02793_ VDD VSS MUX2_X1
X_28085_ gen_regfile_ff.register_file_i.rf_reg\[680\] _09531_
+ _09537_ VDD VSS NOR2_X1
X_28086_ _09537_ _09531_ _09384_ _02794_ VDD VSS AOI21_X1
X_28087_ gen_regfile_ff.register_file_i.rf_reg\[681\] _09183_
+ _09536_ _02795_ VDD VSS MUX2_X1
X_28088_ gen_regfile_ff.register_file_i.rf_reg\[96\] _09419_
+ _05415_ _02796_ VDD VSS MUX2_X1
X_28089_ gen_regfile_ff.register_file_i.rf_reg\[682\] _09430_
+ _09536_ _02797_ VDD VSS MUX2_X1
X_28090_ gen_regfile_ff.register_file_i.rf_reg\[683\] _09432_
+ _09536_ _02798_ VDD VSS MUX2_X1
X_28091_ gen_regfile_ff.register_file_i.rf_reg\[684\] _09531_
+ _09538_ VDD VSS NOR2_X1
X_28092_ _09538_ _09531_ _09316_ _02799_ VDD VSS AOI21_X1
X_28093_ gen_regfile_ff.register_file_i.rf_reg\[685\] _09188_
+ _09536_ _02800_ VDD VSS MUX2_X1
X_28094_ gen_regfile_ff.register_file_i.rf_reg\[686\] _09189_
+ _09536_ _02801_ VDD VSS MUX2_X1
X_28095_ gen_regfile_ff.register_file_i.rf_reg\[687\] _09434_
+ _09536_ _02802_ VDD VSS MUX2_X1
X_28096_ gen_regfile_ff.register_file_i.rf_reg\[688\] _09531_
+ _09539_ VDD VSS NOR2_X1
X_28097_ _09539_ _09531_ _09318_ _02803_ VDD VSS AOI21_X1
X_28098_ gen_regfile_ff.register_file_i.rf_reg\[689\] _09438_
+ _09536_ _02804_ VDD VSS MUX2_X1
X_28099_ gen_regfile_ff.register_file_i.rf_reg\[690\] _09444_
+ _09536_ _02805_ VDD VSS MUX2_X1
X_28100_ gen_regfile_ff.register_file_i.rf_reg\[691\] _09533_
+ _09540_ VDD VSS NAND2_X1
X_28101_ _09540_ _09533_ _09484_ _02806_ VDD VSS OAI21_X1
X_28102_ gen_regfile_ff.register_file_i.rf_reg\[97\] _09423_
+ _05415_ _02807_ VDD VSS MUX2_X1
X_28103_ gen_regfile_ff.register_file_i.rf_reg\[692\] _09460_
+ _09530_ _02808_ VDD VSS MUX2_X1
X_28104_ gen_regfile_ff.register_file_i.rf_reg\[693\] _09463_
+ _09530_ _02809_ VDD VSS MUX2_X1
X_28105_ gen_regfile_ff.register_file_i.rf_reg\[694\] _09197_
+ _09530_ _02810_ VDD VSS MUX2_X1
X_28106_ gen_regfile_ff.register_file_i.rf_reg\[695\] _09464_
+ _09530_ _02811_ VDD VSS MUX2_X1
X_28107_ gen_regfile_ff.register_file_i.rf_reg\[696\] _09532_
+ _09541_ VDD VSS NAND2_X1
X_28108_ _09541_ _09533_ _09488_ _02812_ VDD VSS OAI21_X1
X_28109_ gen_regfile_ff.register_file_i.rf_reg\[697\] _09532_
+ _09542_ VDD VSS NAND2_X1
X_28110_ _09542_ _09498_ _09533_ _02813_ VDD VSS OAI21_X4
X_28111_ gen_regfile_ff.register_file_i.rf_reg\[698\] _09467_
+ _09530_ _02814_ VDD VSS MUX2_X1
X_28112_ gen_regfile_ff.register_file_i.rf_reg\[699\] _09202_
+ _09530_ _02815_ VDD VSS MUX2_X1
X_28113_ gen_regfile_ff.register_file_i.rf_reg\[700\] _09442_
+ _09530_ _02816_ VDD VSS MUX2_X1
X_28114_ gen_regfile_ff.register_file_i.rf_reg\[701\] _09532_
+ _09543_ VDD VSS NAND2_X1
X_28115_ _09543_ _09533_ _09508_ _02817_ VDD VSS OAI21_X1
X_28116_ gen_regfile_ff.register_file_i.rf_reg\[98\] _05803_
+ _09544_ VDD VSS NAND2_X1
X_28117_ _09544_ _05464_ _05803_ _02818_ VDD VSS OAI21_X1
X_28118_ gen_regfile_ff.register_file_i.rf_reg\[702\] _09445_
+ _09530_ _02819_ VDD VSS MUX2_X1
X_28119_ gen_regfile_ff.register_file_i.rf_reg\[703\] _09532_
+ _09545_ VDD VSS NAND2_X1
X_28120_ _09545_ _09510_ _09533_ _02820_ VDD VSS OAI21_X4
X_28121_ _05412_ _06225_ _05374_ _09546_ VDD VSS AND3_X1
X_28122_ _09546_ _09547_ VDD VSS BUF_X4
X_28123_ _09547_ _09548_ VDD VSS BUF_X4
X_28124_ gen_regfile_ff.register_file_i.rf_reg\[704\] _09419_
+ _09548_ _02821_ VDD VSS MUX2_X1
X_28125_ gen_regfile_ff.register_file_i.rf_reg\[705\] _09423_
+ _09548_ _02822_ VDD VSS MUX2_X1
X_28126_ _06224_ _06226_ _05374_ _09549_ VDD VSS NAND3_X2
X_28127_ _09549_ _09550_ VDD VSS CLKBUF_X3
X_28128_ gen_regfile_ff.register_file_i.rf_reg\[706\] _09550_
+ _09551_ VDD VSS NAND2_X1
X_28129_ _09551_ _09550_ _09475_ _02823_ VDD VSS OAI21_X1
X_28130_ gen_regfile_ff.register_file_i.rf_reg\[707\] _09550_
+ _09552_ VDD VSS NAND2_X1
X_28131_ _09552_ _09550_ _09477_ _02824_ VDD VSS OAI21_X1
X_28132_ gen_regfile_ff.register_file_i.rf_reg\[708\] _09439_
+ _09548_ _02825_ VDD VSS MUX2_X1
X_28133_ gen_regfile_ff.register_file_i.rf_reg\[709\] _05580_
+ _09548_ _02826_ VDD VSS MUX2_X1
X_28134_ _09547_ _09553_ VDD VSS BUF_X4
X_28135_ gen_regfile_ff.register_file_i.rf_reg\[710\] _09453_
+ _09553_ _02827_ VDD VSS MUX2_X1
X_28136_ gen_regfile_ff.register_file_i.rf_reg\[711\] _05653_
+ _09553_ _02828_ VDD VSS MUX2_X1
X_28137_ gen_regfile_ff.register_file_i.rf_reg\[99\] _05803_
+ _09554_ VDD VSS NAND2_X1
X_28138_ _09554_ _05510_ _05803_ _02829_ VDD VSS OAI21_X1
X_28139_ gen_regfile_ff.register_file_i.rf_reg\[712\] _09548_
+ _09555_ VDD VSS NOR2_X1
X_28140_ _09555_ _09548_ _09384_ _02830_ VDD VSS AOI21_X1
X_28141_ gen_regfile_ff.register_file_i.rf_reg\[713\] _05721_
+ _09553_ _02831_ VDD VSS MUX2_X1
X_28142_ gen_regfile_ff.register_file_i.rf_reg\[714\] _09430_
+ _09553_ _02832_ VDD VSS MUX2_X1
X_28143_ gen_regfile_ff.register_file_i.rf_reg\[715\] _09432_
+ _09553_ _02833_ VDD VSS MUX2_X1
X_28144_ gen_regfile_ff.register_file_i.rf_reg\[716\] _09548_
+ _09556_ VDD VSS NOR2_X1
X_28145_ _09556_ _09548_ _09316_ _02834_ VDD VSS AOI21_X1
X_28146_ gen_regfile_ff.register_file_i.rf_reg\[717\] _05890_
+ _09553_ _02835_ VDD VSS MUX2_X1
X_28147_ gen_regfile_ff.register_file_i.rf_reg\[718\] _05928_
+ _09553_ _02836_ VDD VSS MUX2_X1
X_28148_ gen_regfile_ff.register_file_i.rf_reg\[719\] _09434_
+ _09553_ _02837_ VDD VSS MUX2_X1
X_28149_ gen_regfile_ff.register_file_i.rf_reg\[720\] _09548_
+ _09557_ VDD VSS NOR2_X1
X_28150_ _09557_ _09548_ _09318_ _02838_ VDD VSS AOI21_X1
X_28151_ gen_regfile_ff.register_file_i.rf_reg\[721\] _09438_
+ _09553_ _02839_ VDD VSS MUX2_X1
X_28152_ _05414_ _09558_ VDD VSS BUF_X4
X_28153_ gen_regfile_ff.register_file_i.rf_reg\[100\] _09439_
+ _09558_ _02840_ VDD VSS MUX2_X1
X_28154_ gen_regfile_ff.register_file_i.rf_reg\[722\] _09444_
+ _09553_ _02841_ VDD VSS MUX2_X1
X_28155_ gen_regfile_ff.register_file_i.rf_reg\[723\] _09550_
+ _09559_ VDD VSS NAND2_X1
X_28156_ _09559_ _09550_ _09484_ _02842_ VDD VSS OAI21_X1
X_28157_ gen_regfile_ff.register_file_i.rf_reg\[724\] net655
+ _09547_ _02843_ VDD VSS MUX2_X1
X_28158_ gen_regfile_ff.register_file_i.rf_reg\[725\] _09463_
+ _09547_ _02844_ VDD VSS MUX2_X1
X_28159_ gen_regfile_ff.register_file_i.rf_reg\[726\] _04602_
+ _09547_ _02845_ VDD VSS MUX2_X1
X_28160_ gen_regfile_ff.register_file_i.rf_reg\[727\] _09464_
+ _09547_ _02846_ VDD VSS MUX2_X1
X_28161_ gen_regfile_ff.register_file_i.rf_reg\[728\] _09549_
+ _09560_ VDD VSS NAND2_X1
X_28162_ _09560_ _09550_ _09488_ _02847_ VDD VSS OAI21_X1
X_28163_ gen_regfile_ff.register_file_i.rf_reg\[729\] _09549_
+ _09561_ VDD VSS NAND2_X1
X_28164_ _09561_ _09550_ _09498_ _02848_ VDD VSS OAI21_X1
X_28165_ gen_regfile_ff.register_file_i.rf_reg\[730\] _09467_
+ _09547_ _02849_ VDD VSS MUX2_X1
X_28166_ gen_regfile_ff.register_file_i.rf_reg\[731\] _04850_
+ _09547_ _02850_ VDD VSS MUX2_X1
X_28167_ _09370_ gen_regfile_ff.register_file_i.rf_reg\[101\]
+ _04855_ _02851_ VDD VSS MUX2_X1
X_28168_ gen_regfile_ff.register_file_i.rf_reg\[38\] _09453_
+ _09176_ _02852_ VDD VSS MUX2_X1
X_28169_ gen_regfile_ff.register_file_i.rf_reg\[732\] _09442_
+ _09547_ _02853_ VDD VSS MUX2_X1
X_28170_ gen_regfile_ff.register_file_i.rf_reg\[733\] _09549_
+ _09562_ VDD VSS NAND2_X1
X_28171_ _09562_ _09550_ _09508_ _02854_ VDD VSS OAI21_X1
X_28172_ gen_regfile_ff.register_file_i.rf_reg\[734\] _09445_
+ _09547_ _02855_ VDD VSS MUX2_X1
X_28173_ gen_regfile_ff.register_file_i.rf_reg\[735\] _09549_
+ _09563_ VDD VSS NAND2_X1
X_28174_ _09563_ _09510_ _09550_ _02856_ VDD VSS OAI21_X4
X_28175_ _05412_ _06225_ _06214_ _09564_ VDD VSS AND3_X1
X_28176_ _09564_ _09565_ VDD VSS BUF_X4
X_28177_ _09565_ _09566_ VDD VSS BUF_X4
X_28178_ gen_regfile_ff.register_file_i.rf_reg\[736\] _09419_
+ _09566_ _02857_ VDD VSS MUX2_X1
X_28179_ gen_regfile_ff.register_file_i.rf_reg\[737\] _09423_
+ _09566_ _02858_ VDD VSS MUX2_X1
X_28180_ _06224_ _06226_ _06214_ _09567_ VDD VSS NAND3_X2
X_28181_ _09567_ _09568_ VDD VSS CLKBUF_X3
X_28182_ gen_regfile_ff.register_file_i.rf_reg\[738\] _09568_
+ _09569_ VDD VSS NAND2_X1
X_28183_ _09569_ _09568_ _09475_ _02859_ VDD VSS OAI21_X1
X_28184_ gen_regfile_ff.register_file_i.rf_reg\[739\] _09568_
+ _09570_ VDD VSS NAND2_X1
X_28185_ _09570_ _09568_ _09477_ _02860_ VDD VSS OAI21_X1
X_28186_ gen_regfile_ff.register_file_i.rf_reg\[740\] _09439_
+ _09566_ _02861_ VDD VSS MUX2_X1
X_28187_ gen_regfile_ff.register_file_i.rf_reg\[741\] _05580_
+ _09566_ _02862_ VDD VSS MUX2_X1
X_28188_ gen_regfile_ff.register_file_i.rf_reg\[102\] _09453_
+ _09558_ _02863_ VDD VSS MUX2_X1
X_28189_ _09565_ _09571_ VDD VSS BUF_X4
X_28190_ gen_regfile_ff.register_file_i.rf_reg\[742\] _09453_
+ _09571_ _02864_ VDD VSS MUX2_X1
X_28191_ gen_regfile_ff.register_file_i.rf_reg\[743\] _05653_
+ _09571_ _02865_ VDD VSS MUX2_X1
X_28192_ gen_regfile_ff.register_file_i.rf_reg\[744\] _09566_
+ _09572_ VDD VSS NOR2_X1
X_28193_ _09572_ _09566_ _09384_ _02866_ VDD VSS AOI21_X1
X_28194_ gen_regfile_ff.register_file_i.rf_reg\[745\] _05721_
+ _09571_ _02867_ VDD VSS MUX2_X1
X_28195_ gen_regfile_ff.register_file_i.rf_reg\[746\] _09430_
+ _09571_ _02868_ VDD VSS MUX2_X1
X_28196_ gen_regfile_ff.register_file_i.rf_reg\[747\] _09432_
+ _09571_ _02869_ VDD VSS MUX2_X1
X_28197_ gen_regfile_ff.register_file_i.rf_reg\[748\] _09566_
+ _09573_ VDD VSS NOR2_X1
X_28198_ _09573_ _09566_ _06231_ _02870_ VDD VSS AOI21_X1
X_28199_ gen_regfile_ff.register_file_i.rf_reg\[749\] _05890_
+ _09571_ _02871_ VDD VSS MUX2_X1
X_28200_ gen_regfile_ff.register_file_i.rf_reg\[750\] _05928_
+ _09571_ _02872_ VDD VSS MUX2_X1
X_28201_ gen_regfile_ff.register_file_i.rf_reg\[751\] _09434_
+ _09571_ _02873_ VDD VSS MUX2_X1
X_28202_ _09377_ gen_regfile_ff.register_file_i.rf_reg\[103\]
+ _04855_ _02874_ VDD VSS MUX2_X1
X_28203_ gen_regfile_ff.register_file_i.rf_reg\[752\] _09566_
+ _09574_ VDD VSS NOR2_X1
X_28204_ _09574_ _09566_ _06234_ _02875_ VDD VSS AOI21_X1
X_28205_ gen_regfile_ff.register_file_i.rf_reg\[753\] _09438_
+ _09571_ _02876_ VDD VSS MUX2_X1
X_28206_ gen_regfile_ff.register_file_i.rf_reg\[754\] _09444_
+ _09571_ _02877_ VDD VSS MUX2_X1
X_28207_ gen_regfile_ff.register_file_i.rf_reg\[755\] _09568_
+ _09575_ VDD VSS NAND2_X1
X_28208_ _09575_ _09568_ _09484_ _02878_ VDD VSS OAI21_X1
X_28209_ gen_regfile_ff.register_file_i.rf_reg\[756\] _09460_
+ _09565_ _02879_ VDD VSS MUX2_X1
X_28210_ gen_regfile_ff.register_file_i.rf_reg\[757\] _09463_
+ _09565_ _02880_ VDD VSS MUX2_X1
X_28211_ gen_regfile_ff.register_file_i.rf_reg\[758\] _04602_
+ _09565_ _02881_ VDD VSS MUX2_X1
X_28212_ gen_regfile_ff.register_file_i.rf_reg\[759\] _09464_
+ _09565_ _02882_ VDD VSS MUX2_X1
X_28213_ gen_regfile_ff.register_file_i.rf_reg\[760\] _09567_
+ _09576_ VDD VSS NAND2_X1
X_28214_ _09576_ _09568_ _09488_ _02883_ VDD VSS OAI21_X1
X_28215_ gen_regfile_ff.register_file_i.rf_reg\[761\] _09567_
+ _09577_ VDD VSS NAND2_X1
X_28216_ _09577_ _09498_ _09568_ _02884_ VDD VSS OAI21_X4
X_28217_ gen_regfile_ff.register_file_i.rf_reg\[104\] _05415_
+ _09578_ VDD VSS NOR2_X1
X_28218_ _09578_ _05688_ _05415_ _02885_ VDD VSS AOI21_X1
X_28219_ gen_regfile_ff.register_file_i.rf_reg\[762\] _09467_
+ _09565_ _02886_ VDD VSS MUX2_X1
X_28220_ gen_regfile_ff.register_file_i.rf_reg\[763\] _04850_
+ _09565_ _02887_ VDD VSS MUX2_X1
X_28221_ gen_regfile_ff.register_file_i.rf_reg\[764\] _09442_
+ _09565_ _02888_ VDD VSS MUX2_X1
X_28222_ gen_regfile_ff.register_file_i.rf_reg\[765\] _09567_
+ _09579_ VDD VSS NAND2_X1
X_28223_ _09579_ _09568_ _09508_ _02889_ VDD VSS OAI21_X1
X_28224_ gen_regfile_ff.register_file_i.rf_reg\[766\] _09445_
+ _09565_ _02890_ VDD VSS MUX2_X1
X_28225_ gen_regfile_ff.register_file_i.rf_reg\[767\] _09567_
+ _09580_ VDD VSS NAND2_X1
X_28226_ _09580_ net682 _09568_ _02891_ VDD VSS OAI21_X2
X_28227_ _09264_ _09420_ _09581_ VDD VSS AND2_X1
X_28228_ _09581_ _09582_ VDD VSS BUF_X4
X_28229_ _09582_ _09583_ VDD VSS BUF_X4
X_28230_ gen_regfile_ff.register_file_i.rf_reg\[768\] _09419_
+ _09583_ _02892_ VDD VSS MUX2_X1
X_28231_ gen_regfile_ff.register_file_i.rf_reg\[769\] _09423_
+ _09583_ _02893_ VDD VSS MUX2_X1
X_28232_ _09264_ _09420_ _09584_ VDD VSS NAND2_X2
X_28233_ _09584_ _09585_ VDD VSS CLKBUF_X3
X_28234_ gen_regfile_ff.register_file_i.rf_reg\[770\] _09585_
+ _09586_ VDD VSS NAND2_X1
X_28235_ _09586_ _09585_ _09475_ _02894_ VDD VSS OAI21_X1
X_28236_ gen_regfile_ff.register_file_i.rf_reg\[771\] _09585_
+ _09587_ VDD VSS NAND2_X1
X_28237_ _09587_ _09585_ _09477_ _02895_ VDD VSS OAI21_X1
X_28238_ _09372_ gen_regfile_ff.register_file_i.rf_reg\[105\]
+ _04855_ _02896_ VDD VSS MUX2_X1
X_28239_ gen_regfile_ff.register_file_i.rf_reg\[772\] _09439_
+ _09583_ _02897_ VDD VSS MUX2_X1
X_28240_ gen_regfile_ff.register_file_i.rf_reg\[773\] _05580_
+ _09583_ _02898_ VDD VSS MUX2_X1
X_28241_ _09582_ _09588_ VDD VSS BUF_X4
X_28242_ gen_regfile_ff.register_file_i.rf_reg\[774\] _09453_
+ _09588_ _02899_ VDD VSS MUX2_X1
X_28243_ gen_regfile_ff.register_file_i.rf_reg\[775\] _05653_
+ _09588_ _02900_ VDD VSS MUX2_X1
X_28244_ gen_regfile_ff.register_file_i.rf_reg\[776\] _09583_
+ _09589_ VDD VSS NOR2_X1
X_28245_ _09589_ _09583_ _09384_ _02901_ VDD VSS AOI21_X1
X_28246_ gen_regfile_ff.register_file_i.rf_reg\[777\] _05721_
+ _09588_ _02902_ VDD VSS MUX2_X1
X_28247_ gen_regfile_ff.register_file_i.rf_reg\[778\] _09430_
+ _09588_ _02903_ VDD VSS MUX2_X1
X_28248_ gen_regfile_ff.register_file_i.rf_reg\[779\] _09432_
+ _09588_ _02904_ VDD VSS MUX2_X1
X_28249_ gen_regfile_ff.register_file_i.rf_reg\[780\] _09583_
+ _09590_ VDD VSS NOR2_X1
X_28250_ _09590_ _09583_ _06231_ _02905_ VDD VSS AOI21_X1
X_28251_ gen_regfile_ff.register_file_i.rf_reg\[781\] _05890_
+ _09588_ _02906_ VDD VSS MUX2_X1
X_28252_ gen_regfile_ff.register_file_i.rf_reg\[106\] _09430_
+ _09558_ _02907_ VDD VSS MUX2_X1
X_28253_ gen_regfile_ff.register_file_i.rf_reg\[782\] _05928_
+ _09588_ _02908_ VDD VSS MUX2_X1
X_28254_ gen_regfile_ff.register_file_i.rf_reg\[783\] _09434_
+ _09588_ _02909_ VDD VSS MUX2_X1
X_28255_ gen_regfile_ff.register_file_i.rf_reg\[784\] _09583_
+ _09591_ VDD VSS NOR2_X1
X_28256_ _09591_ _09583_ _06234_ _02910_ VDD VSS AOI21_X1
X_28257_ gen_regfile_ff.register_file_i.rf_reg\[785\] _09438_
+ _09588_ _02911_ VDD VSS MUX2_X1
X_28258_ gen_regfile_ff.register_file_i.rf_reg\[786\] _09444_
+ _09588_ _02912_ VDD VSS MUX2_X1
X_28259_ gen_regfile_ff.register_file_i.rf_reg\[787\] _09585_
+ _09592_ VDD VSS NAND2_X1
X_28260_ _09592_ _09585_ _09484_ _02913_ VDD VSS OAI21_X1
X_28261_ gen_regfile_ff.register_file_i.rf_reg\[788\] _09460_
+ _09582_ _02914_ VDD VSS MUX2_X1
X_28262_ gen_regfile_ff.register_file_i.rf_reg\[789\] _09463_
+ _09582_ _02915_ VDD VSS MUX2_X1
X_28263_ gen_regfile_ff.register_file_i.rf_reg\[790\] _04602_
+ _09582_ _02916_ VDD VSS MUX2_X1
X_28264_ gen_regfile_ff.register_file_i.rf_reg\[791\] _09464_
+ _09582_ _02917_ VDD VSS MUX2_X1
X_28265_ gen_regfile_ff.register_file_i.rf_reg\[107\] _09432_
+ _09558_ _02918_ VDD VSS MUX2_X1
X_28266_ gen_regfile_ff.register_file_i.rf_reg\[792\] _09584_
+ _09593_ VDD VSS NAND2_X1
X_28267_ _09593_ _09585_ _09488_ _02919_ VDD VSS OAI21_X1
X_28268_ gen_regfile_ff.register_file_i.rf_reg\[793\] _09584_
+ _09594_ VDD VSS NAND2_X1
X_28269_ _09594_ _09498_ _09585_ _02920_ VDD VSS OAI21_X4
X_28270_ gen_regfile_ff.register_file_i.rf_reg\[794\] _09467_
+ _09582_ _02921_ VDD VSS MUX2_X1
X_28271_ gen_regfile_ff.register_file_i.rf_reg\[795\] _04850_
+ _09582_ _02922_ VDD VSS MUX2_X1
X_28272_ gen_regfile_ff.register_file_i.rf_reg\[796\] _09442_
+ _09582_ _02923_ VDD VSS MUX2_X1
X_28273_ gen_regfile_ff.register_file_i.rf_reg\[797\] _09584_
+ _09595_ VDD VSS NAND2_X1
X_28274_ _09595_ _09585_ _09508_ _02924_ VDD VSS OAI21_X1
X_28275_ gen_regfile_ff.register_file_i.rf_reg\[798\] _09445_
+ _09582_ _02925_ VDD VSS MUX2_X1
X_28276_ gen_regfile_ff.register_file_i.rf_reg\[799\] _09584_
+ _09596_ VDD VSS NAND2_X1
X_28277_ _09596_ net682 _09585_ _02926_ VDD VSS OAI21_X2
X_28278_ _04604_ _09260_ _09597_ VDD VSS AND2_X1
X_28279_ _09597_ _09598_ VDD VSS BUF_X4
X_28280_ _09598_ _09599_ VDD VSS BUF_X4
X_28281_ gen_regfile_ff.register_file_i.rf_reg\[800\] _05372_
+ _09599_ _02927_ VDD VSS MUX2_X1
X_28282_ gen_regfile_ff.register_file_i.rf_reg\[801\] _05410_
+ _09599_ _02928_ VDD VSS MUX2_X1
X_28283_ gen_regfile_ff.register_file_i.rf_reg\[108\] _05415_
+ _09600_ VDD VSS NOR2_X1
X_28284_ _09600_ _05850_ _05415_ _02929_ VDD VSS AOI21_X1
X_28285_ _04604_ _09264_ _09601_ VDD VSS NAND2_X2
X_28286_ _09601_ _09602_ VDD VSS CLKBUF_X3
X_28287_ gen_regfile_ff.register_file_i.rf_reg\[802\] _09602_
+ _09603_ VDD VSS NAND2_X1
X_28288_ _09603_ _09602_ _09475_ _02930_ VDD VSS OAI21_X1
X_28289_ gen_regfile_ff.register_file_i.rf_reg\[803\] _09602_
+ _09604_ VDD VSS NAND2_X1
X_28290_ _09604_ _09602_ _09477_ _02931_ VDD VSS OAI21_X1
X_28291_ gen_regfile_ff.register_file_i.rf_reg\[804\] _05544_
+ _09599_ _02932_ VDD VSS MUX2_X1
X_28292_ gen_regfile_ff.register_file_i.rf_reg\[805\] _05580_
+ _09599_ _02933_ VDD VSS MUX2_X1
X_28293_ _09598_ _09605_ VDD VSS BUF_X4
X_28294_ gen_regfile_ff.register_file_i.rf_reg\[806\] _05614_
+ _09605_ _02934_ VDD VSS MUX2_X1
X_28295_ gen_regfile_ff.register_file_i.rf_reg\[807\] _05653_
+ _09605_ _02935_ VDD VSS MUX2_X1
X_28296_ gen_regfile_ff.register_file_i.rf_reg\[808\] _09599_
+ _09606_ VDD VSS NOR2_X1
X_28297_ _09606_ _09599_ _09384_ _02936_ VDD VSS AOI21_X1
X_28298_ gen_regfile_ff.register_file_i.rf_reg\[809\] _05721_
+ _09605_ _02937_ VDD VSS MUX2_X1
X_28299_ gen_regfile_ff.register_file_i.rf_reg\[810\] _05762_
+ _09605_ _02938_ VDD VSS MUX2_X1
X_28300_ gen_regfile_ff.register_file_i.rf_reg\[811\] _05802_
+ _09605_ _02939_ VDD VSS MUX2_X1
X_28301_ _09374_ gen_regfile_ff.register_file_i.rf_reg\[109\]
+ _04855_ _02940_ VDD VSS MUX2_X1
X_28302_ gen_regfile_ff.register_file_i.rf_reg\[812\] _09599_
+ _09607_ VDD VSS NOR2_X1
X_28303_ _09607_ _09599_ _06231_ _02941_ VDD VSS AOI21_X1
X_28304_ gen_regfile_ff.register_file_i.rf_reg\[813\] _05890_
+ _09605_ _02942_ VDD VSS MUX2_X1
X_28305_ gen_regfile_ff.register_file_i.rf_reg\[814\] _05928_
+ _09605_ _02943_ VDD VSS MUX2_X1
X_28306_ gen_regfile_ff.register_file_i.rf_reg\[815\] _09434_
+ _09605_ _02944_ VDD VSS MUX2_X1
X_28307_ gen_regfile_ff.register_file_i.rf_reg\[816\] _09599_
+ _09608_ VDD VSS NOR2_X1
X_28308_ _09608_ _09599_ _06234_ _02945_ VDD VSS AOI21_X1
X_28309_ gen_regfile_ff.register_file_i.rf_reg\[817\] _09438_
+ _09605_ _02946_ VDD VSS MUX2_X1
X_28310_ gen_regfile_ff.register_file_i.rf_reg\[818\] _09444_
+ _09605_ _02947_ VDD VSS MUX2_X1
X_28311_ gen_regfile_ff.register_file_i.rf_reg\[819\] _09602_
+ _09609_ VDD VSS NAND2_X1
X_28312_ _09609_ _09602_ _09484_ _02948_ VDD VSS OAI21_X1
X_28313_ gen_regfile_ff.register_file_i.rf_reg\[820\] _09460_
+ _09598_ _02949_ VDD VSS MUX2_X1
X_28314_ gen_regfile_ff.register_file_i.rf_reg\[821\] _09463_
+ _09598_ _02950_ VDD VSS MUX2_X1
X_28315_ _09375_ gen_regfile_ff.register_file_i.rf_reg\[110\]
+ _04855_ _02951_ VDD VSS MUX2_X1
X_28316_ gen_regfile_ff.register_file_i.rf_reg\[822\] _04602_
+ _09598_ _02952_ VDD VSS MUX2_X1
X_28317_ gen_regfile_ff.register_file_i.rf_reg\[823\] _09464_
+ _09598_ _02953_ VDD VSS MUX2_X1
X_28318_ gen_regfile_ff.register_file_i.rf_reg\[824\] _09601_
+ _09610_ VDD VSS NAND2_X1
X_28319_ _09610_ _09602_ _09488_ _02954_ VDD VSS OAI21_X1
X_28320_ gen_regfile_ff.register_file_i.rf_reg\[825\] _09601_
+ _09611_ VDD VSS NAND2_X1
X_28321_ _09611_ net685 _09602_ _02955_ VDD VSS OAI21_X4
X_28322_ gen_regfile_ff.register_file_i.rf_reg\[826\] _09467_
+ _09598_ _02956_ VDD VSS MUX2_X1
X_28323_ gen_regfile_ff.register_file_i.rf_reg\[827\] _04850_
+ _09598_ _02957_ VDD VSS MUX2_X1
X_28324_ gen_regfile_ff.register_file_i.rf_reg\[828\] _05094_
+ _09598_ _02958_ VDD VSS MUX2_X1
X_28325_ gen_regfile_ff.register_file_i.rf_reg\[829\] _09601_
+ _09612_ VDD VSS NAND2_X1
X_28326_ _09612_ _09602_ _09508_ _02959_ VDD VSS OAI21_X1
X_28327_ gen_regfile_ff.register_file_i.rf_reg\[830\] _05211_
+ _09598_ _02960_ VDD VSS MUX2_X1
X_28328_ gen_regfile_ff.register_file_i.rf_reg\[831\] _09601_
+ _09613_ VDD VSS NAND2_X1
X_28329_ _09613_ _09510_ _09602_ _02961_ VDD VSS OAI21_X4
X_28330_ gen_regfile_ff.register_file_i.rf_reg\[111\] _05974_
+ _09558_ _02962_ VDD VSS MUX2_X1
X_28331_ _09377_ gen_regfile_ff.register_file_i.rf_reg\[39\]
+ _06246_ _02963_ VDD VSS MUX2_X1
X_28332_ _05374_ _09260_ _09614_ VDD VSS AND2_X1
X_28333_ _09614_ _09615_ VDD VSS BUF_X4
X_28334_ _09615_ _09616_ VDD VSS BUF_X4
X_28335_ gen_regfile_ff.register_file_i.rf_reg\[832\] _05372_
+ _09616_ _02964_ VDD VSS MUX2_X1
X_28336_ gen_regfile_ff.register_file_i.rf_reg\[833\] _05410_
+ _09616_ _02965_ VDD VSS MUX2_X1
X_28337_ _05374_ _09264_ _09617_ VDD VSS NAND2_X2
X_28338_ _09617_ _09618_ VDD VSS CLKBUF_X3
X_28339_ gen_regfile_ff.register_file_i.rf_reg\[834\] _09618_
+ _09619_ VDD VSS NAND2_X1
X_28340_ _09619_ _09618_ _09475_ _02966_ VDD VSS OAI21_X1
X_28341_ gen_regfile_ff.register_file_i.rf_reg\[835\] _09618_
+ _09620_ VDD VSS NAND2_X1
X_28342_ _09620_ _09618_ _09477_ _02967_ VDD VSS OAI21_X1
X_28343_ gen_regfile_ff.register_file_i.rf_reg\[836\] _05544_
+ _09616_ _02968_ VDD VSS MUX2_X1
X_28344_ gen_regfile_ff.register_file_i.rf_reg\[837\] _05580_
+ _09616_ _02969_ VDD VSS MUX2_X1
X_28345_ _09615_ _09621_ VDD VSS BUF_X4
X_28346_ gen_regfile_ff.register_file_i.rf_reg\[838\] _05614_
+ _09621_ _02970_ VDD VSS MUX2_X1
X_28347_ gen_regfile_ff.register_file_i.rf_reg\[839\] _05653_
+ _09621_ _02971_ VDD VSS MUX2_X1
X_28348_ gen_regfile_ff.register_file_i.rf_reg\[840\] _09616_
+ _09622_ VDD VSS NOR2_X1
X_28349_ _09622_ _09616_ _06222_ _02972_ VDD VSS AOI21_X1
X_28350_ gen_regfile_ff.register_file_i.rf_reg\[841\] _05721_
+ _09621_ _02973_ VDD VSS MUX2_X1
X_28351_ gen_regfile_ff.register_file_i.rf_reg\[112\] _05415_
+ _09623_ VDD VSS NOR2_X1
X_28352_ _09623_ _06016_ _05415_ _02974_ VDD VSS AOI21_X1
X_28353_ gen_regfile_ff.register_file_i.rf_reg\[842\] _05762_
+ _09621_ _02975_ VDD VSS MUX2_X1
X_28354_ gen_regfile_ff.register_file_i.rf_reg\[843\] _05802_
+ _09621_ _02976_ VDD VSS MUX2_X1
X_28355_ gen_regfile_ff.register_file_i.rf_reg\[844\] _09616_
+ _09624_ VDD VSS NOR2_X1
X_28356_ _09624_ _09616_ _06231_ _02977_ VDD VSS AOI21_X1
X_28357_ gen_regfile_ff.register_file_i.rf_reg\[845\] _05890_
+ _09621_ _02978_ VDD VSS MUX2_X1
X_28358_ gen_regfile_ff.register_file_i.rf_reg\[846\] _05928_
+ _09621_ _02979_ VDD VSS MUX2_X1
X_28359_ gen_regfile_ff.register_file_i.rf_reg\[847\] _05974_
+ _09621_ _02980_ VDD VSS MUX2_X1
X_28360_ gen_regfile_ff.register_file_i.rf_reg\[848\] _09616_
+ _09625_ VDD VSS NOR2_X1
X_28361_ _09625_ _09616_ _06234_ _02981_ VDD VSS AOI21_X1
X_28362_ gen_regfile_ff.register_file_i.rf_reg\[849\] _06062_
+ _09621_ _02982_ VDD VSS MUX2_X1
X_28363_ gen_regfile_ff.register_file_i.rf_reg\[850\] _06100_
+ _09621_ _02983_ VDD VSS MUX2_X1
X_28364_ gen_regfile_ff.register_file_i.rf_reg\[851\] _09618_
+ _09626_ VDD VSS NAND2_X1
X_28365_ _09626_ _09618_ _09484_ _02984_ VDD VSS OAI21_X1
X_28366_ gen_regfile_ff.register_file_i.rf_reg\[113\] _06062_
+ _09558_ _02985_ VDD VSS MUX2_X1
X_28367_ gen_regfile_ff.register_file_i.rf_reg\[852\] _06174_
+ _09615_ _02986_ VDD VSS MUX2_X1
X_28368_ gen_regfile_ff.register_file_i.rf_reg\[853\] _06207_
+ _09615_ _02987_ VDD VSS MUX2_X1
X_28369_ gen_regfile_ff.register_file_i.rf_reg\[854\] _04602_
+ _09615_ _02988_ VDD VSS MUX2_X1
X_28370_ gen_regfile_ff.register_file_i.rf_reg\[855\] net684
+ _09615_ _02989_ VDD VSS MUX2_X1
X_28371_ gen_regfile_ff.register_file_i.rf_reg\[856\] _09617_
+ _09627_ VDD VSS NAND2_X1
X_28372_ _09627_ _09618_ _09488_ _02990_ VDD VSS OAI21_X1
X_28373_ gen_regfile_ff.register_file_i.rf_reg\[857\] _09617_
+ _09628_ VDD VSS NAND2_X1
X_28374_ _09628_ net685 _09618_ _02991_ VDD VSS OAI21_X2
X_28375_ gen_regfile_ff.register_file_i.rf_reg\[858\] _05037_
+ _09615_ _02992_ VDD VSS MUX2_X1
X_28376_ gen_regfile_ff.register_file_i.rf_reg\[859\] _04850_
+ _09615_ _02993_ VDD VSS MUX2_X1
X_28377_ gen_regfile_ff.register_file_i.rf_reg\[860\] _05094_
+ _09615_ _02994_ VDD VSS MUX2_X1
X_28378_ gen_regfile_ff.register_file_i.rf_reg\[861\] _09617_
+ _09629_ VDD VSS NAND2_X1
X_28379_ _09629_ _09618_ _09508_ _02995_ VDD VSS OAI21_X1
X_28380_ gen_regfile_ff.register_file_i.rf_reg\[114\] _06100_
+ _09558_ _02996_ VDD VSS MUX2_X1
X_28381_ gen_regfile_ff.register_file_i.rf_reg\[862\] _05211_
+ _09615_ _02997_ VDD VSS MUX2_X1
X_28382_ gen_regfile_ff.register_file_i.rf_reg\[863\] _09617_
+ _09630_ VDD VSS NAND2_X1
X_28383_ _09630_ net682 _09618_ _02998_ VDD VSS OAI21_X2
X_28384_ _06214_ _09260_ _09631_ VDD VSS AND2_X1
X_28385_ _09631_ _09632_ VDD VSS BUF_X4
X_28386_ _09632_ _09633_ VDD VSS BUF_X4
X_28387_ gen_regfile_ff.register_file_i.rf_reg\[864\] _05372_
+ _09633_ _02999_ VDD VSS MUX2_X1
X_28388_ gen_regfile_ff.register_file_i.rf_reg\[865\] _05410_
+ _09633_ _03000_ VDD VSS MUX2_X1
X_28389_ _06214_ _09264_ _09634_ VDD VSS NAND2_X2
X_28390_ _09634_ _09635_ VDD VSS CLKBUF_X3
X_28391_ gen_regfile_ff.register_file_i.rf_reg\[866\] _09635_
+ _09636_ VDD VSS NAND2_X1
X_28392_ _09636_ _09635_ _09475_ _03001_ VDD VSS OAI21_X1
X_28393_ gen_regfile_ff.register_file_i.rf_reg\[867\] _09635_
+ _09637_ VDD VSS NAND2_X1
X_28394_ _09637_ _09635_ _09477_ _03002_ VDD VSS OAI21_X1
X_28395_ gen_regfile_ff.register_file_i.rf_reg\[868\] _05544_
+ _09633_ _03003_ VDD VSS MUX2_X1
X_28396_ gen_regfile_ff.register_file_i.rf_reg\[869\] _05580_
+ _09633_ _03004_ VDD VSS MUX2_X1
X_28397_ _09632_ _09638_ VDD VSS BUF_X4
X_28398_ gen_regfile_ff.register_file_i.rf_reg\[870\] _05614_
+ _09638_ _03005_ VDD VSS MUX2_X1
X_28399_ gen_regfile_ff.register_file_i.rf_reg\[871\] _05653_
+ _09638_ _03006_ VDD VSS MUX2_X1
X_28400_ gen_regfile_ff.register_file_i.rf_reg\[115\] _05803_
+ _09639_ VDD VSS NAND2_X1
X_28401_ _09639_ _06138_ _05806_ _03007_ VDD VSS OAI21_X1
X_28402_ gen_regfile_ff.register_file_i.rf_reg\[872\] _09633_
+ _09640_ VDD VSS NOR2_X1
X_28403_ _09640_ _09633_ _06222_ _03008_ VDD VSS AOI21_X1
X_28404_ gen_regfile_ff.register_file_i.rf_reg\[873\] _05721_
+ _09638_ _03009_ VDD VSS MUX2_X1
X_28405_ gen_regfile_ff.register_file_i.rf_reg\[874\] _05762_
+ _09638_ _03010_ VDD VSS MUX2_X1
X_28406_ gen_regfile_ff.register_file_i.rf_reg\[875\] _05802_
+ _09638_ _03011_ VDD VSS MUX2_X1
X_28407_ gen_regfile_ff.register_file_i.rf_reg\[876\] _09633_
+ _09641_ VDD VSS NOR2_X1
X_28408_ _09641_ _09633_ _06231_ _03012_ VDD VSS AOI21_X1
X_28409_ gen_regfile_ff.register_file_i.rf_reg\[877\] _05890_
+ _09638_ _03013_ VDD VSS MUX2_X1
X_28410_ gen_regfile_ff.register_file_i.rf_reg\[878\] _05928_
+ _09638_ _03014_ VDD VSS MUX2_X1
X_28411_ gen_regfile_ff.register_file_i.rf_reg\[879\] _05974_
+ _09638_ _03015_ VDD VSS MUX2_X1
X_28412_ gen_regfile_ff.register_file_i.rf_reg\[880\] _09633_
+ _09642_ VDD VSS NOR2_X1
X_28413_ _09642_ _09633_ _06234_ _03016_ VDD VSS AOI21_X1
X_28414_ gen_regfile_ff.register_file_i.rf_reg\[881\] _06062_
+ _09638_ _03017_ VDD VSS MUX2_X1
X_28415_ gen_regfile_ff.register_file_i.rf_reg\[116\] net668
+ _09558_ _03018_ VDD VSS MUX2_X1
X_28416_ gen_regfile_ff.register_file_i.rf_reg\[882\] _06100_
+ _09638_ _03019_ VDD VSS MUX2_X1
X_28417_ gen_regfile_ff.register_file_i.rf_reg\[883\] _09635_
+ _09643_ VDD VSS NAND2_X1
X_28418_ _09643_ _09635_ _09484_ _03020_ VDD VSS OAI21_X1
X_28419_ gen_regfile_ff.register_file_i.rf_reg\[884\] _06174_
+ _09632_ _03021_ VDD VSS MUX2_X1
X_28420_ gen_regfile_ff.register_file_i.rf_reg\[885\] _06207_
+ _09632_ _03022_ VDD VSS MUX2_X1
X_28421_ gen_regfile_ff.register_file_i.rf_reg\[886\] _04602_
+ _09632_ _03023_ VDD VSS MUX2_X1
X_28422_ gen_regfile_ff.register_file_i.rf_reg\[887\] net684
+ _09632_ _03024_ VDD VSS MUX2_X1
X_28423_ gen_regfile_ff.register_file_i.rf_reg\[888\] _09634_
+ _09644_ VDD VSS NAND2_X1
X_28424_ _09644_ _09635_ _09488_ _03025_ VDD VSS OAI21_X1
X_28425_ gen_regfile_ff.register_file_i.rf_reg\[889\] _09634_
+ _09645_ VDD VSS NAND2_X1
X_28426_ _09645_ _09498_ _09635_ _03026_ VDD VSS OAI21_X4
X_28427_ gen_regfile_ff.register_file_i.rf_reg\[890\] net687
+ _09632_ _03027_ VDD VSS MUX2_X1
X_28428_ gen_regfile_ff.register_file_i.rf_reg\[891\] _04850_
+ _09632_ _03028_ VDD VSS MUX2_X1
X_28429_ gen_regfile_ff.register_file_i.rf_reg\[117\] _06207_
+ _09558_ _03029_ VDD VSS MUX2_X1
X_28430_ gen_regfile_ff.register_file_i.rf_reg\[892\] _05094_
+ _09632_ _03030_ VDD VSS MUX2_X1
X_28431_ gen_regfile_ff.register_file_i.rf_reg\[893\] _09634_
+ _09646_ VDD VSS NAND2_X1
X_28432_ _09646_ _09635_ _09508_ _03031_ VDD VSS OAI21_X1
X_28433_ gen_regfile_ff.register_file_i.rf_reg\[894\] _05211_
+ _09632_ _03032_ VDD VSS MUX2_X1
X_28434_ gen_regfile_ff.register_file_i.rf_reg\[895\] _09634_
+ _09647_ VDD VSS NAND2_X1
X_28435_ _09647_ _09510_ _09635_ _03033_ VDD VSS OAI21_X4
X_28436_ _04613_ _09420_ _09648_ VDD VSS NAND2_X4
X_28437_ _09648_ _09649_ VDD VSS BUF_X4
X_28438_ _05372_ gen_regfile_ff.register_file_i.rf_reg\[896\]
+ _09649_ _03034_ VDD VSS MUX2_X1
X_28439_ _05410_ gen_regfile_ff.register_file_i.rf_reg\[897\]
+ _09649_ _03035_ VDD VSS MUX2_X1
X_28440_ _09648_ _09650_ VDD VSS BUF_X4
X_28441_ gen_regfile_ff.register_file_i.rf_reg\[898\] _09650_
+ _09651_ VDD VSS NAND2_X1
X_28442_ _09648_ _09652_ VDD VSS BUF_X4
X_28443_ _09651_ _09652_ _05463_ _03036_ VDD VSS OAI21_X1
X_28444_ gen_regfile_ff.register_file_i.rf_reg\[899\] _09650_
+ _09653_ VDD VSS NAND2_X1
X_28445_ _09653_ _09652_ _05509_ _03037_ VDD VSS OAI21_X1
X_28446_ _05544_ gen_regfile_ff.register_file_i.rf_reg\[900\]
+ _09649_ _03038_ VDD VSS MUX2_X1
X_28447_ _09370_ gen_regfile_ff.register_file_i.rf_reg\[901\]
+ _09649_ _03039_ VDD VSS MUX2_X1
X_28448_ _09359_ gen_regfile_ff.register_file_i.rf_reg\[118\]
+ _04855_ _03040_ VDD VSS MUX2_X1
X_28449_ _05614_ gen_regfile_ff.register_file_i.rf_reg\[902\]
+ _09649_ _03041_ VDD VSS MUX2_X1
X_28450_ _09377_ gen_regfile_ff.register_file_i.rf_reg\[903\]
+ _09649_ _03042_ VDD VSS MUX2_X1
X_28451_ gen_regfile_ff.register_file_i.rf_reg\[904\] _09650_
+ _09654_ VDD VSS NAND2_X1
X_28452_ _09654_ _09652_ _05687_ _03043_ VDD VSS OAI21_X1
X_28453_ _09372_ gen_regfile_ff.register_file_i.rf_reg\[905\]
+ _09649_ _03044_ VDD VSS MUX2_X1
X_28454_ _05762_ gen_regfile_ff.register_file_i.rf_reg\[906\]
+ _09649_ _03045_ VDD VSS MUX2_X1
X_28455_ _05802_ gen_regfile_ff.register_file_i.rf_reg\[907\]
+ _09649_ _03046_ VDD VSS MUX2_X1
X_28456_ gen_regfile_ff.register_file_i.rf_reg\[908\] _09650_
+ _09655_ VDD VSS NAND2_X1
X_28457_ _09655_ _09652_ _05849_ _03047_ VDD VSS OAI21_X1
X_28458_ _09374_ gen_regfile_ff.register_file_i.rf_reg\[909\]
+ _09649_ _03048_ VDD VSS MUX2_X1
X_28459_ _09648_ _09656_ VDD VSS BUF_X4
X_28460_ _09375_ gen_regfile_ff.register_file_i.rf_reg\[910\]
+ _09656_ _03049_ VDD VSS MUX2_X1
X_28461_ _05974_ gen_regfile_ff.register_file_i.rf_reg\[911\]
+ _09656_ _03050_ VDD VSS MUX2_X1
X_28462_ gen_regfile_ff.register_file_i.rf_reg\[119\] net684
+ _09558_ _03051_ VDD VSS MUX2_X1
X_28463_ gen_regfile_ff.register_file_i.rf_reg\[912\] _09650_
+ _09657_ VDD VSS NAND2_X1
X_28464_ _09657_ _09652_ _06015_ _03052_ VDD VSS OAI21_X1
X_28465_ _06062_ gen_regfile_ff.register_file_i.rf_reg\[913\]
+ _09656_ _03053_ VDD VSS MUX2_X1
X_28466_ _06100_ gen_regfile_ff.register_file_i.rf_reg\[914\]
+ _09656_ _03054_ VDD VSS MUX2_X1
X_28467_ gen_regfile_ff.register_file_i.rf_reg\[915\] _09650_
+ _09658_ VDD VSS NAND2_X1
X_28468_ _09658_ _09652_ _06137_ _03055_ VDD VSS OAI21_X1
X_28469_ net668 gen_regfile_ff.register_file_i.rf_reg\[916\]
+ _09656_ _03056_ VDD VSS MUX2_X1
X_28470_ _06207_ gen_regfile_ff.register_file_i.rf_reg\[917\]
+ _09656_ _03057_ VDD VSS MUX2_X1
X_28471_ _04601_ gen_regfile_ff.register_file_i.rf_reg\[918\]
+ _09656_ _03058_ VDD VSS MUX2_X1
X_28472_ _04765_ gen_regfile_ff.register_file_i.rf_reg\[919\]
+ _09656_ _03059_ VDD VSS MUX2_X1
X_28473_ gen_regfile_ff.register_file_i.rf_reg\[920\] _09650_
+ _09659_ VDD VSS NAND2_X1
X_28474_ _09659_ _09652_ _04907_ _03060_ VDD VSS OAI21_X1
X_28475_ gen_regfile_ff.register_file_i.rf_reg\[921\] _09650_
+ _09660_ VDD VSS NAND2_X1
X_28476_ _09660_ _09652_ _04977_ _03061_ VDD VSS OAI21_X1
X_28477_ gen_regfile_ff.register_file_i.rf_reg\[120\] _05803_
+ _09661_ VDD VSS NAND2_X1
X_28478_ _09661_ _04908_ _05806_ _03062_ VDD VSS OAI21_X1
X_28479_ _05036_ gen_regfile_ff.register_file_i.rf_reg\[922\]
+ _09656_ _03063_ VDD VSS MUX2_X1
X_28480_ _04849_ gen_regfile_ff.register_file_i.rf_reg\[923\]
+ _09656_ _03064_ VDD VSS MUX2_X1
X_28481_ _05093_ gen_regfile_ff.register_file_i.rf_reg\[924\]
+ _09648_ _03065_ VDD VSS MUX2_X1
X_28482_ gen_regfile_ff.register_file_i.rf_reg\[925\] _09650_
+ _09662_ VDD VSS NAND2_X1
X_28483_ _09662_ _09652_ _05147_ _03066_ VDD VSS OAI21_X1
X_28484_ _05210_ gen_regfile_ff.register_file_i.rf_reg\[926\]
+ _09648_ _03067_ VDD VSS MUX2_X1
X_28485_ gen_regfile_ff.register_file_i.rf_reg\[927\] _09650_
+ _09663_ VDD VSS NAND2_X1
X_28486_ _09663_ _09652_ _05259_ _03068_ VDD VSS OAI21_X1
X_28487_ _05371_ gen_regfile_ff.register_file_i.rf_reg\[928\]
+ _04615_ _03069_ VDD VSS MUX2_X1
X_28488_ _05409_ gen_regfile_ff.register_file_i.rf_reg\[929\]
+ _04615_ _03070_ VDD VSS MUX2_X1
X_28489_ gen_regfile_ff.register_file_i.rf_reg\[930\] _04856_
+ _09664_ VDD VSS NAND2_X1
X_28490_ _09664_ _05464_ _04909_ _03071_ VDD VSS OAI21_X1
X_28491_ gen_regfile_ff.register_file_i.rf_reg\[931\] _04856_
+ _09665_ VDD VSS NAND2_X1
X_28492_ _09665_ _05510_ _04909_ _03072_ VDD VSS OAI21_X1
X_28493_ gen_regfile_ff.register_file_i.rf_reg\[121\] _05803_
+ _09666_ VDD VSS NAND2_X1
X_28494_ _09666_ _04978_ _05803_ _03073_ VDD VSS OAI21_X1
X_28495_ gen_regfile_ff.register_file_i.rf_reg\[40\] _09177_
+ _09667_ VDD VSS NOR2_X1
X_28496_ _09667_ _09177_ _06222_ _03074_ VDD VSS AOI21_X1
X_28497_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[932\]
+ _04615_ _03075_ VDD VSS MUX2_X1
X_28498_ _05579_ gen_regfile_ff.register_file_i.rf_reg\[933\]
+ _04615_ _03076_ VDD VSS MUX2_X1
X_28499_ _04614_ _09668_ VDD VSS BUF_X4
X_28500_ _05613_ gen_regfile_ff.register_file_i.rf_reg\[934\]
+ _09668_ _03077_ VDD VSS MUX2_X1
X_28501_ _05652_ gen_regfile_ff.register_file_i.rf_reg\[935\]
+ _09668_ _03078_ VDD VSS MUX2_X1
X_28502_ gen_regfile_ff.register_file_i.rf_reg\[936\] _04856_
+ _09669_ VDD VSS NAND2_X1
X_28503_ _09669_ _05688_ _04909_ _03079_ VDD VSS OAI21_X1
X_28504_ _05720_ gen_regfile_ff.register_file_i.rf_reg\[937\]
+ _09668_ _03080_ VDD VSS MUX2_X1
X_28505_ _05761_ gen_regfile_ff.register_file_i.rf_reg\[938\]
+ _09668_ _03081_ VDD VSS MUX2_X1
X_28506_ _05801_ gen_regfile_ff.register_file_i.rf_reg\[939\]
+ _09668_ _03082_ VDD VSS MUX2_X1
X_28507_ gen_regfile_ff.register_file_i.rf_reg\[940\] _04856_
+ _09670_ VDD VSS NAND2_X1
X_28508_ _09670_ _05850_ _04909_ _03083_ VDD VSS OAI21_X1
X_28509_ _05889_ gen_regfile_ff.register_file_i.rf_reg\[941\]
+ _09668_ _03084_ VDD VSS MUX2_X1
X_28510_ gen_regfile_ff.register_file_i.rf_reg\[122\] net687
+ _05414_ _03085_ VDD VSS MUX2_X1
X_28511_ _05927_ gen_regfile_ff.register_file_i.rf_reg\[942\]
+ _09668_ _03086_ VDD VSS MUX2_X1
X_28512_ _05973_ gen_regfile_ff.register_file_i.rf_reg\[943\]
+ _09668_ _03087_ VDD VSS MUX2_X1
X_28513_ gen_regfile_ff.register_file_i.rf_reg\[944\] _04856_
+ _09671_ VDD VSS NAND2_X1
X_28514_ _09671_ _06016_ _04909_ _03088_ VDD VSS OAI21_X1
X_28515_ _06061_ gen_regfile_ff.register_file_i.rf_reg\[945\]
+ _09668_ _03089_ VDD VSS MUX2_X1
X_28516_ _06099_ gen_regfile_ff.register_file_i.rf_reg\[946\]
+ _09668_ _03090_ VDD VSS MUX2_X1
X_28517_ gen_regfile_ff.register_file_i.rf_reg\[947\] _04856_
+ _09672_ VDD VSS NAND2_X1
X_28518_ _09672_ _06138_ _04909_ _03091_ VDD VSS OAI21_X1
X_28519_ _06173_ gen_regfile_ff.register_file_i.rf_reg\[948\]
+ _04614_ _03092_ VDD VSS MUX2_X1
X_28520_ _06206_ gen_regfile_ff.register_file_i.rf_reg\[949\]
+ _04614_ _01184_ VDD VSS MUX2_X1
X_28521_ net98 net113 _03961_ _09673_ VDD VSS MUX2_X1
X_28522_ _03978_ _09673_ _09674_ VDD VSS OR2_X1
X_28523_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[12\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[28\]
+ _03962_ _09675_ VDD VSS MUX2_X1
X_28524_ _09674_ _09675_ _03965_ _09676_ VDD VSS OAI21_X4
X_28525_ net99 net114 _03961_ _09677_ VDD VSS MUX2_X1
X_28526_ _03973_ _09677_ _09678_ VDD VSS OR2_X1
X_28527_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[13\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[29\]
+ _03961_ _09679_ VDD VSS MUX2_X1
X_28528_ _09678_ _09679_ _03965_ _09680_ VDD VSS OAI21_X2
X_28529_ _09680_ _09681_ VDD VSS BUF_X4
X_28530_ cs_registers_i.pc_if_i\[1\] _09682_ VDD VSS CLKBUF_X3
X_28531_ net101 net117 _09682_ _09683_ VDD VSS MUX2_X1
X_28532_ _03973_ _09683_ _09684_ VDD VSS OR2_X1
X_28533_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[15\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[31\]
+ _09682_ _09685_ VDD VSS MUX2_X1
X_28534_ _09684_ _09685_ _03965_ _09686_ VDD VSS OAI21_X4
X_28535_ _09681_ _09686_ _09687_ VDD VSS NAND2_X4
X_28536_ net100 net116 _09682_ _09688_ VDD VSS MUX2_X1
X_28537_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[14\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[30\]
+ _03961_ _09689_ VDD VSS MUX2_X1
X_28538_ _09688_ _09689_ _03973_ _09690_ VDD VSS MUX2_X1
X_28539_ _09690_ _09691_ VDD VSS BUF_X4
X_28540_ _09687_ _09691_ _09692_ VDD VSS NOR2_X4
X_28541_ _09692_ _09693_ VDD VSS BUF_X4
X_28542_ _09676_ _09693_ _09694_ VDD VSS NAND2_X2
X_28543_ _09681_ _09695_ VDD VSS CLKBUF_X3
X_28544_ _09683_ _09685_ _03973_ _09696_ VDD VSS MUX2_X2
X_28545_ _09696_ _09697_ VDD VSS CLKBUF_X3
X_28546_ _09691_ _09698_ VDD VSS CLKBUF_X3
X_28547_ _09698_ _09699_ VDD VSS CLKBUF_X3
X_28548_ net123 net109 _03961_ _09700_ VDD VSS MUX2_X1
X_28549_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[8\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[24\]
+ _03961_ _09701_ VDD VSS MUX2_X1
X_28550_ _09700_ _09701_ _03978_ _09702_ VDD VSS MUX2_X1
X_28551_ _09702_ _09703_ VDD VSS BUF_X4
X_28552_ _09703_ _09704_ VDD VSS INV_X1
X_28553_ net124 net110 _09682_ _09705_ VDD VSS MUX2_X1
X_28554_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[9\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[25\]
+ _03961_ _09706_ VDD VSS MUX2_X1
X_28555_ _09705_ _09706_ _03973_ _09707_ VDD VSS MUX2_X2
X_28556_ net122 net108 _09682_ _09708_ VDD VSS MUX2_X1
X_28557_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[7\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[23\]
+ _09682_ _09709_ VDD VSS MUX2_X1
X_28558_ _09708_ _09709_ _03964_ _09710_ VDD VSS MUX2_X2
X_28559_ net97 net112 _09682_ _09711_ VDD VSS MUX2_X1
X_28560_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[11\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[27\]
+ _09682_ _09712_ VDD VSS MUX2_X1
X_28561_ _09711_ _09712_ _03973_ _09713_ VDD VSS MUX2_X2
X_28562_ net96 net111 _09682_ _09714_ VDD VSS MUX2_X1
X_28563_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[10\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[26\]
+ _09682_ _09715_ VDD VSS MUX2_X1
X_28564_ _09714_ _09715_ _03973_ _09716_ VDD VSS MUX2_X2
X_28565_ _09707_ _09710_ _09713_ _09716_ _09717_ VDD VSS NOR4_X4
X_28566_ _09704_ _09717_ _09718_ VDD VSS NAND2_X1
X_28567_ _09686_ _09719_ VDD VSS BUF_X4
X_28568_ net121 net107 _03962_ _09720_ VDD VSS MUX2_X1
X_28569_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[6\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[22\]
+ _03962_ _09721_ VDD VSS MUX2_X1
X_28570_ _09720_ _09721_ _03978_ _09722_ VDD VSS MUX2_X2
X_28571_ net120 net106 _03961_ _09723_ VDD VSS MUX2_X1
X_28572_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[5\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[21\]
+ _03961_ _09724_ VDD VSS MUX2_X1
X_28573_ _09723_ _09724_ _03978_ _09725_ VDD VSS MUX2_X1
X_28574_ _09725_ _09726_ VDD VSS CLKBUF_X3
X_28575_ _09722_ _09726_ _09727_ VDD VSS NOR2_X2
X_28576_ net115 net102 _03962_ _09728_ VDD VSS MUX2_X1
X_28577_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[2\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[18\]
+ _03962_ _09729_ VDD VSS MUX2_X1
X_28578_ _09728_ _09729_ _03978_ _09730_ VDD VSS MUX2_X1
X_28579_ net118 net103 _03962_ _09731_ VDD VSS MUX2_X1
X_28580_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[3\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[19\]
+ _03962_ _09732_ VDD VSS MUX2_X1
X_28581_ _09731_ _09732_ _03978_ _09733_ VDD VSS MUX2_X2
X_28582_ net119 net105 _03962_ _09734_ VDD VSS MUX2_X1
X_28583_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[4\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[20\]
+ _03962_ _09735_ VDD VSS MUX2_X1
X_28584_ _09734_ _09735_ _03978_ _09736_ VDD VSS MUX2_X1
X_28585_ _09730_ _09733_ _09736_ _09737_ VDD VSS NOR3_X2
X_28586_ _09727_ _09737_ _09738_ VDD VSS NAND2_X2
X_28587_ _09691_ _09738_ _09739_ VDD VSS NOR2_X1
X_28588_ _09719_ _09676_ _09739_ _09740_ VDD VSS AOI21_X1
X_28589_ _09695_ _09697_ _09699_ _09718_ _09740_ _09741_ VDD
+ VSS OAI221_X1
X_28590_ net95 _03968_ _03963_ _09742_ VDD VSS MUX2_X1
X_28591_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[0\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[16\]
+ _03963_ _09743_ VDD VSS MUX2_X1
X_28592_ _09742_ _09743_ _03979_ _09744_ VDD VSS MUX2_X1
X_28593_ _09744_ _09745_ VDD VSS BUF_X4
X_28594_ net104 _03967_ _03963_ _09746_ VDD VSS MUX2_X1
X_28595_ _03979_ _09746_ _09747_ VDD VSS OR2_X1
X_28596_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[1\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]
+ _03963_ _09748_ VDD VSS MUX2_X1
X_28597_ _03965_ _09749_ VDD VSS BUF_X4
X_28598_ _09747_ _09748_ _09749_ _09750_ VDD VSS OAI21_X4
X_28599_ _09745_ _09750_ _09751_ VDD VSS NOR2_X1
X_28600_ _09751_ _09752_ VDD VSS CLKBUF_X3
X_28601_ _09694_ _09741_ _09752_ _09753_ VDD VSS NAND3_X1
X_28602_ _09673_ _09675_ _03979_ _09754_ VDD VSS MUX2_X1
X_28603_ _09754_ _09755_ VDD VSS CLKBUF_X3
X_28604_ _09755_ _09756_ VDD VSS CLKBUF_X3
X_28605_ _09686_ _09690_ _09757_ VDD VSS NAND2_X2
X_28606_ _09695_ _09756_ _09738_ _09757_ _09758_ VDD VSS NOR4_X1
X_28607_ _09686_ _09691_ _09759_ VDD VSS NOR2_X1
X_28608_ _09681_ _09759_ _09760_ VDD VSS NAND2_X2
X_28609_ _07136_ _09714_ _09761_ VDD VSS OR2_X1
X_28610_ _09761_ _09715_ _09749_ _09762_ VDD VSS OAI21_X4
X_28611_ _09713_ _09763_ VDD VSS CLKBUF_X3
X_28612_ _09760_ _09762_ _09763_ _09764_ VDD VSS AOI21_X1
X_28613_ _09758_ _09764_ _09756_ _09765_ VDD VSS AOI21_X1
X_28614_ _09745_ _09750_ _09766_ VDD VSS NAND2_X4
X_28615_ _03979_ _09742_ _09767_ VDD VSS OR2_X1
X_28616_ _09767_ _09743_ _03965_ _09768_ VDD VSS OAI21_X4
X_28617_ _09768_ _09750_ _09769_ VDD VSS NAND2_X4
X_28618_ _09677_ _09679_ _03978_ _09770_ VDD VSS MUX2_X2
X_28619_ _09770_ _09696_ _09771_ VDD VSS NOR2_X4
X_28620_ _09770_ _09772_ VDD VSS BUF_X4
X_28621_ _03973_ _09688_ _09773_ VDD VSS OR2_X1
X_28622_ _09773_ _09689_ _03965_ _09774_ VDD VSS OAI21_X4
X_28623_ _09774_ _09775_ VDD VSS BUF_X4
X_28624_ _09772_ _09775_ _09776_ VDD VSS NOR2_X4
X_28625_ _09771_ _09776_ _09777_ VDD VSS NOR2_X4
X_28626_ _09777_ _09778_ VDD VSS BUF_X4
X_28627_ _09727_ _09779_ VDD VSS INV_X1
X_28628_ _09779_ _09718_ _09694_ _09780_ VDD VSS NOR3_X1
X_28629_ _09778_ _09780_ _09781_ VDD VSS NOR2_X1
X_28630_ _09753_ _09765_ _09766_ _09769_ _09781_ _09782_ VDD
+ VSS OAI221_X1
X_28631_ id_stage_i.decoder_i.illegal_c_insn_i _09782_ _07218_
+ _01532_ VDD VSS MUX2_X1
X_28632_ _07240_ _09783_ VDD VSS BUF_X4
X_28633_ _11419_ _09783_ _09784_ VDD VSS NAND2_X1
X_28634_ _03966_ _09785_ VDD VSS INV_X1
X_28635_ _07137_ _03981_ _09785_ _09786_ VDD VSS NOR3_X1
X_28636_ _03966_ _00136_ _03974_ _09787_ VDD VSS OAI21_X1
X_28637_ _04158_ _09787_ _09788_ VDD VSS OR2_X1
X_28638_ _03971_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ _03974_ _09789_ VDD VSS AOI21_X1
X_28639_ _09788_ _09789_ _07138_ _09790_ VDD VSS OAI21_X1
X_28640_ _09786_ _09790_ _03981_ _07137_ _03971_ _09791_ VDD
+ VSS AOI221_X2
X_28641_ _09784_ _09791_ _09783_ _01533_ VDD VSS OAI21_X1
X_28642_ _09749_ _07133_ _09785_ _09792_ VDD VSS NOR3_X1
X_28643_ _09792_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ _07133_ _09793_ VDD VSS AOI21_X1
X_28644_ _07170_ _03971_ _09793_ _09794_ VDD VSS NOR3_X1
X_28645_ _08803_ _09794_ _07218_ _01534_ VDD VSS MUX2_X1
X_28646_ _09745_ _09795_ VDD VSS CLKBUF_X3
X_28647_ _09746_ _09748_ _03979_ _09796_ VDD VSS MUX2_X2
X_28648_ _09796_ _09797_ VDD VSS CLKBUF_X3
X_28649_ _09797_ _09798_ VDD VSS CLKBUF_X3
X_28650_ _09795_ _09798_ _09799_ VDD VSS NAND2_X1
X_28651_ _08813_ _09799_ _07218_ _01535_ VDD VSS MUX2_X1
X_28652_ _09768_ _09800_ VDD VSS CLKBUF_X3
X_28653_ _09696_ _09774_ _09801_ VDD VSS NAND2_X2
X_28654_ _09695_ _09801_ _09797_ _09802_ VDD VSS OAI21_X1
X_28655_ _09800_ _09802_ _09803_ VDD VSS NAND2_X1
X_28656_ _10291_ _09803_ _07218_ _01536_ VDD VSS MUX2_X1
X_28657_ _09697_ _09801_ _09795_ _09804_ VDD VSS MUX2_X1
X_28658_ _09716_ _09805_ VDD VSS CLKBUF_X3
X_28659_ _09805_ _09766_ _09699_ _09806_ VDD VSS OAI21_X1
X_28660_ _09772_ _09807_ VDD VSS CLKBUF_X3
X_28661_ _09807_ _09808_ VDD VSS CLKBUF_X3
X_28662_ _09745_ _09772_ _09809_ VDD VSS NOR2_X2
X_28663_ _09739_ _09809_ _09810_ VDD VSS NAND2_X1
X_28664_ _09719_ _09811_ VDD VSS CLKBUF_X3
X_28665_ _09805_ _09810_ _09811_ _09812_ VDD VSS OAI21_X1
X_28666_ _09762_ _09804_ _09806_ _09808_ _09798_ _09812_ _09813_
+ VDD VSS AOI222_X2
X_28667_ _10899_ _09813_ _07218_ _01537_ VDD VSS MUX2_X1
X_28668_ _09771_ _09775_ _09814_ VDD VSS NAND2_X2
X_28669_ _09763_ _09814_ _09815_ VDD VSS NOR2_X1
X_28670_ _09768_ _09796_ _09816_ VDD VSS NOR2_X4
X_28671_ _09816_ _09817_ VDD VSS BUF_X4
X_28672_ _09770_ _09801_ _09818_ VDD VSS NOR2_X4
X_28673_ _09713_ _09716_ _09819_ VDD VSS NAND2_X2
X_28674_ _09676_ _09819_ _09820_ VDD VSS NOR2_X4
X_28675_ _09818_ _09820_ _09821_ VDD VSS AND2_X1
X_28676_ _09817_ _09821_ _09693_ _09822_ VDD VSS OAI21_X1
X_28677_ _09775_ _09823_ VDD VSS CLKBUF_X3
X_28678_ _09752_ _09763_ _09823_ _09824_ VDD VSS OAI21_X1
X_28679_ _09822_ _09824_ _09687_ _09825_ VDD VSS OAI21_X1
X_28680_ _09745_ _09687_ _09826_ VDD VSS NOR2_X1
X_28681_ _09826_ _09823_ _09745_ _09827_ VDD VSS AOI21_X1
X_28682_ _09750_ _09828_ VDD VSS CLKBUF_X3
X_28683_ _09810_ _09827_ _09828_ _09829_ VDD VSS MUX2_X1
X_28684_ _09825_ _09829_ _09763_ _09830_ VDD VSS AOI21_X1
X_28685_ _07253_ _09815_ _09830_ _09831_ VDD VSS OR3_X1
X_28686_ _09831_ _07218_ _11062_ _01538_ VDD VSS OAI21_X1
X_28687_ _09814_ _09816_ _09832_ VDD VSS NAND2_X2
X_28688_ _09819_ _09726_ _09722_ _09833_ VDD VSS AOI21_X1
X_28689_ _09833_ _09834_ VDD VSS INV_X1
X_28690_ _09772_ _09686_ _09835_ VDD VSS NOR2_X2
X_28691_ _09687_ _09755_ _09834_ _09835_ _09836_ VDD VSS AOI22_X1
X_28692_ _09698_ _09836_ _09837_ VDD VSS NOR2_X1
X_28693_ _09680_ _09757_ _09838_ VDD VSS NOR2_X4
X_28694_ _09703_ _09717_ _09839_ VDD VSS NAND2_X4
X_28695_ _09838_ _09839_ _09840_ VDD VSS AND2_X2
X_28696_ _09730_ _09841_ VDD VSS CLKBUF_X3
X_28697_ _09719_ _09775_ _09842_ VDD VSS NOR2_X4
X_28698_ _09837_ _09840_ _09841_ _09807_ _09842_ _09843_ VDD
+ VSS AOI221_X2
X_28699_ _09795_ _09756_ _09826_ _09823_ _09844_ VDD VSS AOI22_X2
X_28700_ _09676_ _09803_ _09832_ _09843_ _09844_ _09828_ _09845_
+ VDD VSS OAI222_X2
X_28701_ _10477_ _09845_ _07218_ _01539_ VDD VSS MUX2_X1
X_28702_ _09695_ _09823_ _09795_ _09846_ VDD VSS OAI21_X1
X_28703_ _09766_ _09846_ _09847_ VDD VSS NAND2_X1
X_28704_ _09681_ _09691_ _09848_ VDD VSS NOR2_X4
X_28705_ _09755_ _09848_ _09849_ VDD VSS NAND2_X1
X_28706_ _09849_ _09850_ VDD VSS INV_X1
X_28707_ _09713_ _09818_ _09851_ VDD VSS AND2_X1
X_28708_ _07136_ _09720_ _09852_ VDD VSS OR2_X1
X_28709_ _09852_ _09721_ _09749_ _09853_ VDD VSS OAI21_X4
X_28710_ _09805_ _09755_ _09853_ _09854_ VDD VSS OAI21_X1
X_28711_ _09850_ _09851_ _09854_ _09840_ _09733_ _09855_ VDD
+ VSS AOI221_X2
X_28712_ _09847_ _09855_ _09766_ _09856_ VDD VSS OAI21_X1
X_28713_ _10488_ _09856_ _07218_ _01540_ VDD VSS MUX2_X1
X_28714_ _09699_ _09687_ _09828_ _09857_ VDD VSS AOI21_X1
X_28715_ _09795_ _09808_ _09699_ _09858_ VDD VSS AOI21_X1
X_28716_ _09816_ _09849_ _09859_ VDD VSS NAND2_X1
X_28717_ _09736_ _09860_ VDD VSS CLKBUF_X3
X_28718_ _09763_ _09805_ _09861_ VDD VSS AND2_X1
X_28719_ _09861_ _09756_ _09727_ _09862_ VDD VSS OAI21_X1
X_28720_ _09859_ _09840_ _09860_ _09818_ _09862_ _09863_ VDD
+ VSS AOI221_X2
X_28721_ _09857_ _09858_ _09863_ _09864_ VDD VSS NOR3_X1
X_28722_ _07180_ _09865_ VDD VSS BUF_X4
X_28723_ _10495_ _09864_ _09865_ _01541_ VDD VSS MUX2_X1
X_28724_ _10597_ _07253_ _09866_ VDD VSS NAND2_X1
X_28725_ _09710_ _09867_ VDD VSS INV_X1
X_28726_ _09818_ _09820_ _09868_ VDD VSS NAND2_X2
X_28727_ _09676_ _09738_ _09869_ VDD VSS NAND2_X2
X_28728_ _09719_ _09710_ _09869_ _09870_ VDD VSS AOI21_X1
X_28729_ _09681_ _09691_ _09870_ _09871_ VDD VSS OAI21_X1
X_28730_ _09681_ _09696_ _09872_ VDD VSS NOR2_X1
X_28731_ _09872_ _09873_ VDD VSS INV_X1
X_28732_ _09751_ _09871_ _09873_ _09874_ VDD VSS NAND3_X1
X_28733_ _09726_ _09840_ _09875_ VDD VSS NAND2_X1
X_28734_ _09692_ _09850_ _09876_ VDD VSS NOR2_X1
X_28735_ _09868_ _09874_ _09875_ _09876_ _09877_ VDD VSS NAND4_X1
X_28736_ _09814_ _09877_ _09878_ VDD VSS NAND2_X1
X_28737_ _09868_ _09875_ _09876_ _09879_ VDD VSS NAND3_X1
X_28738_ _09719_ _09774_ _09760_ _09820_ _09880_ VDD VSS OAI22_X4
X_28739_ _09817_ _09879_ _09880_ _09881_ VDD VSS OAI21_X1
X_28740_ _09867_ _09878_ _09881_ _09874_ _09882_ VDD VSS AOI22_X2
X_28741_ _09697_ _09710_ _09776_ _09883_ VDD VSS MUX2_X1
X_28742_ _09745_ _09796_ _09884_ VDD VSS NOR2_X4
X_28743_ _09828_ _09811_ _09885_ VDD VSS NOR2_X1
X_28744_ _09882_ _09883_ _09884_ _09795_ _09885_ _09886_ VDD
+ VSS AOI221_X2
X_28745_ _09866_ _09886_ _09783_ _01542_ VDD VSS OAI21_X1
X_28746_ _09884_ _09887_ VDD VSS BUF_X4
X_28747_ _09695_ _09698_ _09888_ VDD VSS NAND2_X2
X_28748_ _03968_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[16\]
+ _03979_ _09889_ VDD VSS MUX2_X1
X_28749_ _07334_ _09889_ _07169_ _09890_ VDD VSS MUX2_X2
X_28750_ _09687_ _09888_ _09891_ VDD VSS NAND2_X2
X_28751_ _09887_ _09888_ _09703_ _09890_ _09891_ _09892_ VDD
+ VSS OAI221_X2
X_28752_ _09760_ _09869_ _09703_ _09893_ VDD VSS AOI21_X1
X_28753_ _09751_ _09890_ _09681_ _09894_ VDD VSS OAI21_X1
X_28754_ _09893_ _09894_ _09895_ VDD VSS NOR2_X1
X_28755_ _09816_ _09838_ _09896_ VDD VSS NAND2_X1
X_28756_ _09896_ _09839_ _09853_ _09897_ VDD VSS AOI21_X1
X_28757_ _09895_ _09897_ _09898_ VDD VSS NOR2_X1
X_28758_ _09692_ _09821_ _09890_ _09848_ _09754_ _09899_ VDD
+ VSS AOI221_X2
X_28759_ _09899_ _09900_ VDD VSS INV_X1
X_28760_ _09816_ _09880_ _09900_ _09901_ VDD VSS OAI21_X1
X_28761_ _09898_ _09901_ _09902_ VDD VSS NAND2_X1
X_28762_ _09693_ _09898_ _09899_ _09903_ VDD VSS AOI21_X1
X_28763_ _09902_ _09903_ _09703_ _09904_ VDD VSS OAI21_X1
X_28764_ _09797_ _09890_ _09905_ VDD VSS NAND2_X1
X_28765_ _09904_ _09905_ _09906_ VDD VSS AND2_X1
X_28766_ _09892_ _09904_ _09828_ _09800_ _09906_ _09907_ VDD
+ VSS OAI221_X2
X_28767_ _10759_ _09907_ _09865_ _01543_ VDD VSS MUX2_X1
X_28768_ _09840_ _09848_ _09908_ VDD VSS NOR2_X1
X_28769_ _09676_ _09908_ _09909_ VDD VSS NOR2_X1
X_28770_ _09692_ _09909_ _09910_ VDD VSS NOR2_X2
X_28771_ _03967_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]
+ _03979_ _09911_ VDD VSS MUX2_X1
X_28772_ _07346_ _09911_ _07169_ _09912_ VDD VSS MUX2_X2
X_28773_ _09707_ _09880_ _09912_ _09821_ _09913_ VDD VSS AOI22_X2
X_28774_ _09766_ _09910_ _09913_ _09914_ VDD VSS AOI21_X2
X_28775_ _09768_ _09797_ _09915_ VDD VSS NAND2_X1
X_28776_ _09807_ _09912_ _09916_ VDD VSS NAND2_X1
X_28777_ _09692_ _09818_ _09869_ _09917_ VDD VSS AOI21_X1
X_28778_ _09915_ _09916_ _09917_ _09918_ VDD VSS AOI21_X1
X_28779_ _09914_ _09912_ _09807_ _09919_ VDD VSS AOI21_X1
X_28780_ _09693_ _09919_ _09920_ VDD VSS NOR2_X1
X_28781_ _09914_ _09918_ _09920_ _09707_ _09921_ VDD VSS OAI22_X2
X_28782_ _09776_ _09707_ _09912_ _09778_ _09922_ VDD VSS AOI22_X2
X_28783_ _09912_ _09923_ VDD VSS INV_X1
X_28784_ _09921_ _09922_ _09769_ _09799_ _09923_ _09924_ VDD
+ VSS OAI221_X2
X_28785_ _10752_ _09924_ _09865_ _01544_ VDD VSS MUX2_X1
X_28786_ _10767_ _07253_ _09925_ VDD VSS NAND2_X1
X_28787_ _07136_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[18\]
+ _09926_ VDD VSS NAND2_X1
X_28788_ _09749_ net102 _09927_ VDD VSS NAND2_X1
X_28789_ _03963_ _09926_ _09927_ _09928_ VDD VSS AOI21_X2
X_28790_ _09928_ _07358_ _03963_ _09929_ VDD VSS AOI21_X4
X_28791_ _09762_ _09917_ _09929_ _09681_ _09930_ VDD VSS OAI22_X1
X_28792_ _09752_ _09930_ _09931_ VDD VSS AND2_X1
X_28793_ _09772_ _09820_ _09929_ _09932_ VDD VSS AOI21_X1
X_28794_ _09696_ _09691_ _09932_ _09933_ VDD VSS OAI21_X1
X_28795_ _09797_ _09910_ _09933_ _09934_ VDD VSS AOI21_X1
X_28796_ _09805_ _09814_ _09931_ _09934_ _09935_ VDD VSS OAI22_X1
X_28797_ _09935_ _09929_ _09828_ _09936_ VDD VSS OAI21_X1
X_28798_ _09888_ _09929_ _09771_ _09937_ VDD VSS OAI21_X1
X_28799_ _09931_ _09936_ _09795_ _09937_ _09887_ _09938_ VDD
+ VSS AOI221_X2
X_28800_ _09925_ _09938_ _09783_ _01545_ VDD VSS OAI21_X1
X_28801_ _07137_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[19\]
+ _09939_ VDD VSS NAND2_X1
X_28802_ _09749_ net103 _09940_ VDD VSS NAND2_X1
X_28803_ _07170_ _09939_ _09940_ _09941_ VDD VSS NAND3_X1
X_28804_ _09941_ _07369_ _07170_ _09942_ VDD VSS OAI21_X2
X_28805_ _09800_ _09828_ _09943_ VDD VSS NOR2_X1
X_28806_ _09943_ _09778_ _09887_ _09944_ VDD VSS AOI21_X1
X_28807_ _09851_ _09869_ _09945_ VDD VSS NAND2_X1
X_28808_ _09945_ _09699_ _09687_ _09695_ _09942_ _09946_ VDD
+ VSS OAI221_X2
X_28809_ _09910_ _09942_ _09868_ _09947_ VDD VSS OAI21_X1
X_28810_ _09752_ _09946_ _09947_ _09817_ _09948_ VDD VSS AOI22_X2
X_28811_ _09942_ _09944_ _09948_ _09815_ _09949_ VDD VSS OAI22_X2
X_28812_ _10750_ _09949_ _09865_ _01546_ VDD VSS MUX2_X1
X_28813_ _09766_ _09868_ _09950_ VDD VSS NOR2_X1
X_28814_ _09950_ _09778_ _09887_ _09951_ VDD VSS AOI21_X1
X_28815_ _10290_ _09951_ _09865_ _01547_ VDD VSS MUX2_X1
X_28816_ _11935_ _07253_ _09952_ VDD VSS NAND2_X1
X_28817_ net105 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[20\]
+ _03979_ _09953_ VDD VSS MUX2_X1
X_28818_ _07382_ _09953_ _07169_ _09954_ VDD VSS MUX2_X2
X_28819_ _09772_ _09954_ _09955_ VDD VSS NAND2_X1
X_28820_ _09727_ _09737_ _09956_ VDD VSS AND2_X1
X_28821_ _09755_ _09818_ _09956_ _09957_ VDD VSS NAND3_X1
X_28822_ _09681_ _09719_ _09841_ _09958_ VDD VSS OAI21_X1
X_28823_ _09696_ _09775_ _09959_ VDD VSS NOR2_X1
X_28824_ _09955_ _09957_ _09718_ _09958_ _09959_ _09960_ VDD
+ VSS OAI221_X1
X_28825_ _09841_ _09954_ _09820_ _09961_ VDD VSS MUX2_X1
X_28826_ _09841_ _09959_ _09961_ _09759_ _09962_ VDD VSS AOI22_X1
X_28827_ _09910_ _09962_ _09807_ _09963_ VDD VSS OAI21_X1
X_28828_ _09752_ _09960_ _09963_ _09817_ _09964_ VDD VSS AOI22_X1
X_28829_ _09841_ _09965_ VDD VSS INV_X1
X_28830_ _09964_ _09965_ _09693_ _09966_ VDD VSS AOI21_X1
X_28831_ _09776_ _09841_ _09954_ _09823_ _09967_ VDD VSS AOI22_X1
X_28832_ _09955_ _09967_ _09811_ _09968_ VDD VSS OAI21_X1
X_28833_ _09966_ _09954_ _09943_ _09887_ _09968_ _09969_ VDD
+ VSS AOI221_X2
X_28834_ _09952_ _09969_ _09783_ _01548_ VDD VSS OAI21_X1
X_28835_ _09755_ _09840_ _09970_ VDD VSS AND2_X1
X_28836_ _07136_ _09731_ _09971_ VDD VSS OR2_X1
X_28837_ _09971_ _09732_ _09749_ _09972_ VDD VSS OAI21_X2
X_28838_ _09972_ _09699_ _09687_ _09973_ VDD VSS AOI21_X1
X_28839_ _09697_ _09698_ _09733_ _09974_ VDD VSS NOR3_X1
X_28840_ _09974_ _09820_ _09697_ _09975_ VDD VSS AOI21_X1
X_28841_ _09817_ _09970_ _09973_ _09975_ _09808_ _09976_ VDD
+ VSS OAI221_X2
X_28842_ _09811_ _09888_ _09972_ _09977_ VDD VSS NOR3_X1
X_28843_ net106 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[21\]
+ _07137_ _09978_ VDD VSS MUX2_X1
X_28844_ _07395_ _09978_ _07170_ _09979_ VDD VSS MUX2_X1
X_28845_ _09778_ _09979_ _09980_ VDD VSS AND2_X1
X_28846_ _09887_ _09977_ _09980_ _09981_ VDD VSS OAI21_X1
X_28847_ _09807_ _09915_ _09982_ VDD VSS NOR2_X1
X_28848_ _09733_ _09757_ _09982_ _09983_ VDD VSS NAND3_X1
X_28849_ _09750_ _09809_ _09984_ VDD VSS NOR2_X4
X_28850_ _09979_ _09984_ _09950_ _09985_ VDD VSS OAI21_X1
X_28851_ _09976_ _09981_ _09983_ _09985_ _09986_ VDD VSS NAND4_X2
X_28852_ _12034_ _09986_ _09865_ _01549_ VDD VSS MUX2_X1
X_28853_ _09681_ _09820_ _09987_ VDD VSS NAND2_X1
X_28854_ _09775_ _09860_ _09987_ _09988_ VDD VSS NAND3_X1
X_28855_ net107 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[22\]
+ _03978_ _09989_ VDD VSS MUX2_X1
X_28856_ _07400_ _09989_ _07169_ _09990_ VDD VSS MUX2_X2
X_28857_ _09686_ _09820_ _09990_ _09991_ VDD VSS AOI21_X1
X_28858_ _09691_ _09991_ _09992_ VDD VSS NOR2_X1
X_28859_ _09992_ _09860_ _09719_ _09993_ VDD VSS AOI21_X1
X_28860_ _09988_ _09993_ _09772_ _09994_ VDD VSS OAI21_X1
X_28861_ _09816_ _09970_ _09994_ _09995_ VDD VSS OAI21_X1
X_28862_ _09693_ _09995_ _09695_ _09996_ VDD VSS AOI21_X1
X_28863_ _09860_ _09996_ _09997_ VDD VSS NOR2_X1
X_28864_ _09752_ _09990_ _09695_ _09998_ VDD VSS OAI21_X1
X_28865_ _09997_ _09998_ _09995_ _09999_ VDD VSS AOI21_X1
X_28866_ _09777_ _09990_ _10000_ VDD VSS NAND2_X1
X_28867_ _09811_ _09722_ _09860_ _09842_ _10001_ VDD VSS AOI22_X1
X_28868_ _10000_ _10001_ _09808_ _10002_ VDD VSS OAI21_X1
X_28869_ _09798_ _09999_ _10002_ _09887_ _10003_ VDD VSS AOI22_X1
X_28870_ _09999_ _09990_ _09798_ _10004_ VDD VSS AOI21_X1
X_28871_ _10003_ _10004_ _09800_ _10005_ VDD VSS OAI21_X1
X_28872_ _11989_ _10005_ _09865_ _01550_ VDD VSS MUX2_X1
X_28873_ _09772_ _09775_ _10006_ VDD VSS NAND2_X2
X_28874_ _09766_ _10006_ _09687_ _10007_ VDD VSS AOI21_X1
X_28875_ _09726_ _09982_ _10007_ _10008_ VDD VSS OAI21_X1
X_28876_ _09726_ _10009_ VDD VSS INV_X1
X_28877_ _10009_ _09762_ _09698_ _10010_ VDD VSS MUX2_X1
X_28878_ _09769_ _09771_ _10010_ _10011_ VDD VSS AOI21_X1
X_28879_ net108 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[23\]
+ _07137_ _10012_ VDD VSS MUX2_X1
X_28880_ _07402_ _10012_ _07170_ _10013_ VDD VSS MUX2_X1
X_28881_ _10011_ _10013_ _09984_ _10014_ VDD VSS AOI21_X1
X_28882_ _09891_ _10013_ _10015_ VDD VSS NOR2_X1
X_28883_ _09861_ _10013_ _09676_ _10016_ VDD VSS OAI21_X1
X_28884_ _10016_ _09861_ _10009_ _10017_ VDD VSS OAI21_X1
X_28885_ _09970_ _10017_ _09818_ _10018_ VDD VSS AOI21_X1
X_28886_ _10008_ _10014_ _10015_ _10018_ _09832_ _10019_ VDD
+ VSS OAI221_X2
X_28887_ _12041_ _10019_ _09865_ _01551_ VDD VSS MUX2_X1
X_28888_ net109 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[24\]
+ _07137_ _10020_ VDD VSS MUX2_X1
X_28889_ _07404_ _10020_ _07170_ _10021_ VDD VSS MUX2_X2
X_28890_ _09752_ _10021_ _09695_ _10022_ VDD VSS OAI21_X1
X_28891_ _09719_ _09775_ _09722_ _10023_ VDD VSS OAI21_X1
X_28892_ _09775_ _09722_ _09819_ _10024_ VDD VSS NAND3_X1
X_28893_ _09772_ _10023_ _10024_ _10025_ VDD VSS AOI21_X1
X_28894_ _09755_ _09839_ _10026_ VDD VSS NAND2_X2
X_28895_ _10026_ _09839_ _09853_ _10027_ VDD VSS OAI21_X1
X_28896_ _10025_ _10027_ _09838_ _09763_ _09848_ _10028_ VDD
+ VSS AOI221_X2
X_28897_ _10022_ _10028_ _09766_ _10029_ VDD VSS OAI21_X1
X_28898_ _10029_ _09722_ _09808_ _10030_ VDD VSS OAI21_X1
X_28899_ _09771_ _09763_ _10021_ _09778_ _10031_ VDD VSS AOI22_X2
X_28900_ _10021_ _09821_ _09798_ _10032_ VDD VSS OAI21_X1
X_28901_ _10030_ _10031_ _09769_ _09800_ _10032_ _10033_ VDD
+ VSS OAI221_X2
X_28902_ _11992_ _10033_ _09865_ _01552_ VDD VSS MUX2_X1
X_28903_ _09694_ _09817_ _10034_ VDD VSS NAND2_X4
X_28904_ _09807_ _09841_ _10035_ VDD VSS NAND2_X1
X_28905_ _10035_ _09839_ _09699_ _10036_ VDD VSS AOI21_X1
X_28906_ _09771_ _09775_ _09755_ _10037_ VDD VSS OAI21_X1
X_28907_ _10037_ _10038_ VDD VSS INV_X1
X_28908_ _09755_ _09851_ _10039_ VDD VSS NAND2_X2
X_28909_ _07137_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[25\]
+ _10040_ VDD VSS NAND2_X1
X_28910_ _09749_ net110 _10041_ VDD VSS NAND2_X1
X_28911_ _03981_ _10040_ _10041_ _10042_ VDD VSS AOI21_X1
X_28912_ _10042_ _07405_ _03981_ _10043_ VDD VSS AOI21_X2
X_28913_ _10039_ _10043_ _09805_ _10044_ VDD VSS AOI21_X1
X_28914_ _10026_ _10045_ VDD VSS INV_X1
X_28915_ _09697_ _09841_ _09872_ _10045_ _10046_ VDD VSS AOI22_X1
X_28916_ _09823_ _10046_ _10047_ VDD VSS NOR2_X1
X_28917_ _10036_ _10038_ _10044_ _10047_ _10048_ VDD VSS NOR4_X1
X_28918_ _09984_ _09777_ _09884_ _10049_ VDD VSS AOI21_X4
X_28919_ _09884_ _09891_ _09752_ _09776_ _10050_ VDD VSS AOI22_X2
X_28920_ _10034_ _10048_ _10049_ _10043_ _10050_ _09676_ _10051_
+ VDD VSS OAI222_X2
X_28921_ _10873_ _10051_ _09865_ _01553_ VDD VSS MUX2_X1
X_28922_ _09841_ _09710_ _09697_ _10052_ VDD VSS MUX2_X1
X_28923_ _09776_ _09752_ _10052_ _10053_ VDD VSS NAND3_X1
X_28924_ _09769_ _09776_ _10009_ _09867_ _09693_ _10054_ VDD
+ VSS AOI221_X2
X_28925_ _09984_ _10054_ _10055_ VDD VSS NOR2_X1
X_28926_ net111 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[26\]
+ _07136_ _10056_ VDD VSS MUX2_X1
X_28927_ _07335_ _10056_ _07170_ _10057_ VDD VSS MUX2_X1
X_28928_ _10057_ _10054_ _09891_ _10058_ VDD VSS AOI21_X1
X_28929_ _09807_ _09823_ _09710_ _10059_ VDD VSS NAND3_X1
X_28930_ _10038_ _09842_ _09726_ _10060_ VDD VSS AOI21_X1
X_28931_ _10039_ _10061_ VDD VSS INV_X1
X_28932_ _10061_ _10057_ _09762_ _10062_ VDD VSS OAI21_X1
X_28933_ _10059_ _10060_ _10062_ _10063_ VDD VSS NAND3_X1
X_28934_ _10026_ _09839_ _10009_ _10064_ VDD VSS OAI21_X1
X_28935_ _10063_ _10064_ _09838_ _10065_ VDD VSS AOI21_X1
X_28936_ _10053_ _10055_ _10058_ _10034_ _10065_ _10066_ VDD
+ VSS OAI221_X2
X_28937_ _07180_ _10067_ VDD VSS CLKBUF_X3
X_28938_ _10874_ _10066_ _10067_ _01554_ VDD VSS MUX2_X1
X_28939_ net112 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[27\]
+ _07136_ _10068_ VDD VSS MUX2_X1
X_28940_ _07336_ _10068_ _07169_ _10069_ VDD VSS MUX2_X2
X_28941_ _09762_ _10069_ _10070_ VDD VSS NOR2_X1
X_28942_ _09842_ _09848_ _10071_ VDD VSS NOR2_X1
X_28943_ _10037_ _10039_ _10070_ _10071_ _09853_ _10072_ VDD
+ VSS OAI221_X1
X_28944_ _10026_ _09839_ _09972_ _10073_ VDD VSS OAI21_X1
X_28945_ _10072_ _10073_ _09838_ _10074_ VDD VSS AOI21_X1
X_28946_ _10034_ _10074_ _10075_ VDD VSS NOR2_X1
X_28947_ _09800_ _09797_ _10069_ _10076_ VDD VSS AOI21_X1
X_28948_ _09704_ _09972_ _09719_ _10077_ VDD VSS MUX2_X1
X_28949_ _09809_ _10077_ _09823_ _10078_ VDD VSS OAI21_X1
X_28950_ _10078_ _10069_ _09695_ _10079_ VDD VSS OAI21_X1
X_28951_ _10076_ _10079_ _09798_ _10080_ VDD VSS AOI21_X1
X_28952_ _10075_ _10080_ _10081_ VDD VSS NOR2_X1
X_28953_ _09703_ _09693_ _10069_ _09778_ _10082_ VDD VSS AOI22_X1
X_28954_ _10081_ _10082_ _09887_ _10083_ VDD VSS AOI21_X1
X_28955_ _10500_ _10083_ _10067_ _01555_ VDD VSS MUX2_X1
X_28956_ net113 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[28\]
+ _07136_ _10084_ VDD VSS MUX2_X1
X_28957_ _07337_ _10084_ _07169_ _10085_ VDD VSS MUX2_X1
X_28958_ _09984_ _10085_ _10086_ VDD VSS NAND2_X1
X_28959_ _09707_ _09693_ _10085_ _09778_ _10087_ VDD VSS AOI22_X2
X_28960_ _09757_ _09707_ _09691_ _10088_ VDD VSS OAI21_X1
X_28961_ _09818_ _10088_ _09772_ _09691_ _09676_ _10089_ VDD
+ VSS AOI221_X2
X_28962_ _09762_ _10085_ _10090_ VDD VSS OR2_X1
X_28963_ _09860_ _10091_ VDD VSS INV_X1
X_28964_ _10026_ _09839_ _10091_ _10092_ VDD VSS OAI21_X1
X_28965_ _10089_ _10090_ _10061_ _10092_ _09838_ _10093_ VDD
+ VSS AOI221_X2
X_28966_ _10086_ _10087_ _09769_ _10034_ _10093_ _10094_ VDD
+ VSS OAI221_X2
X_28967_ net320 _10094_ _10067_ _01556_ VDD VSS MUX2_X1
X_28968_ _10502_ _07253_ _10095_ VDD VSS NAND2_X1
X_28969_ net114 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[29\]
+ _07136_ _10096_ VDD VSS MUX2_X1
X_28970_ _07338_ _10096_ _07170_ _10097_ VDD VSS MUX2_X1
X_28971_ _09805_ _09693_ _10097_ _09777_ _10098_ VDD VSS AOI22_X1
X_28972_ _09769_ _10098_ _10099_ VDD VSS NOR2_X1
X_28973_ _09756_ _09698_ _09771_ _10100_ VDD VSS OAI21_X1
X_28974_ _09762_ _10097_ _10101_ VDD VSS NOR2_X1
X_28975_ _10100_ _10101_ _10039_ _10006_ _09762_ _10102_ VDD
+ VSS OAI221_X2
X_28976_ _10099_ _10097_ _09984_ _09817_ _10102_ _10103_ VDD
+ VSS AOI221_X2
X_28977_ _10095_ _10103_ _09783_ _01557_ VDD VSS OAI21_X1
X_28978_ _09718_ _10104_ VDD VSS INV_X1
X_28979_ _09738_ _09756_ _10104_ _10105_ VDD VSS AOI21_X1
X_28980_ _09818_ _09752_ _10105_ _10106_ VDD VSS NAND3_X1
X_28981_ _09868_ _09832_ _10107_ VDD VSS OR2_X1
X_28982_ _10049_ _10107_ _10108_ VDD VSS AND2_X1
X_28983_ _10106_ _09908_ _09832_ _09965_ _10108_ _10109_ VDD
+ VSS OAI221_X1
X_28984_ id_stage_i.controller_i.instr_i\[2\] _10109_ _10067_
+ _01558_ VDD VSS MUX2_X1
X_28985_ _07136_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[30\]
+ _10110_ VDD VSS NAND2_X1
X_28986_ _09749_ net116 _10111_ VDD VSS NAND2_X1
X_28987_ _03963_ _10110_ _10111_ _10112_ VDD VSS AOI21_X1
X_28988_ _10112_ _07339_ _03981_ _10113_ VDD VSS AOI21_X2
X_28989_ _09820_ _10113_ _10114_ VDD VSS NAND2_X1
X_28990_ _09762_ _09763_ _09779_ _10115_ VDD VSS AOI21_X1
X_28991_ _10114_ _10115_ _09755_ _09763_ _09805_ _10116_ VDD
+ VSS OAI221_X2
X_28992_ _09698_ _09835_ _10116_ _09704_ _09807_ _10117_ VDD
+ VSS AOI221_X2
X_28993_ _10117_ _09756_ _09699_ _10118_ VDD VSS AOI21_X1
X_28994_ _10049_ _10113_ _10118_ _10034_ _10119_ VDD VSS OAI22_X2
X_28995_ _10498_ _10119_ _10067_ _01559_ VDD VSS MUX2_X1
X_28996_ _07137_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[31\]
+ _10120_ VDD VSS NAND2_X1
X_28997_ _09749_ net117 _10121_ VDD VSS NAND2_X1
X_28998_ _03981_ _10120_ _10121_ _10122_ VDD VSS AOI21_X1
X_28999_ _10122_ _07340_ _03981_ _10123_ VDD VSS AOI21_X2
X_29000_ _10039_ _10123_ _09805_ _10124_ VDD VSS AOI21_X1
X_29001_ _10124_ _09760_ _09756_ _10125_ VDD VSS AOI21_X1
X_29002_ _10049_ _10123_ _10125_ _10034_ _10126_ VDD VSS OAI22_X2
X_29003_ _10509_ _10126_ _10067_ _01560_ VDD VSS MUX2_X1
X_29004_ _09766_ _10006_ _10108_ _09972_ _10127_ VDD VSS OAI22_X1
X_29005_ _10341_ _10127_ _10067_ _01561_ VDD VSS MUX2_X1
X_29006_ _09807_ _09697_ _09828_ _10128_ VDD VSS AOI21_X1
X_29007_ _09699_ _09885_ _10105_ _10129_ VDD VSS AOI21_X1
X_29008_ _09800_ _09860_ _10128_ _10129_ _09808_ _10130_ VDD
+ VSS OAI221_X1
X_29009_ _09797_ _09697_ _09820_ _10131_ VDD VSS AOI21_X1
X_29010_ _09795_ _09798_ _10071_ _10131_ _09860_ _10132_ VDD
+ VSS OAI221_X1
X_29011_ _07180_ _10130_ _10132_ _10133_ VDD VSS AND3_X1
X_29012_ _10133_ _09783_ _10372_ _01562_ VDD VSS AOI21_X1
X_29013_ _09861_ _09676_ _09726_ _10134_ VDD VSS OAI21_X1
X_29014_ _09811_ _09823_ _10134_ _10135_ VDD VSS AOI21_X1
X_29015_ _09817_ _09757_ _09839_ _10135_ _09808_ _10136_ VDD
+ VSS OAI221_X1
X_29016_ _09800_ _09797_ _09726_ _10137_ VDD VSS AOI21_X1
X_29017_ _09826_ _10137_ _10138_ VDD VSS NOR2_X1
X_29018_ _09808_ _09823_ _09828_ _10139_ VDD VSS AOI21_X1
X_29019_ _10138_ _10139_ _09726_ _10140_ VDD VSS OAI21_X1
X_29020_ _07180_ _10136_ _10140_ _10141_ VDD VSS AND3_X1
X_29021_ _10141_ _09783_ _10289_ _01563_ VDD VSS AOI21_X1
X_29022_ _09750_ _09698_ _10142_ VDD VSS NAND2_X1
X_29023_ _09800_ _10142_ _10143_ VDD VSS NOR2_X1
X_29024_ _10143_ _09982_ _09739_ _10144_ VDD VSS AOI21_X1
X_29025_ _09766_ _10006_ _10108_ _09853_ _09811_ _10144_ _10145_
+ VDD VSS OAI222_X2
X_29026_ _10299_ _10145_ _10067_ _01564_ VDD VSS MUX2_X1
X_29027_ _10104_ _09957_ _10146_ VDD VSS NOR2_X1
X_29028_ _09800_ _09828_ _10146_ _10147_ VDD VSS OAI21_X1
X_29029_ _09872_ _09835_ _09710_ _10148_ VDD VSS AOI21_X1
X_29030_ _09698_ _10148_ _10149_ VDD VSS NOR2_X1
X_29031_ _10149_ _09842_ _09756_ _10150_ VDD VSS AOI21_X1
X_29032_ _10147_ _10150_ _09798_ _10151_ VDD VSS OAI21_X1
X_29033_ _09835_ _09956_ _09698_ _10152_ VDD VSS OAI21_X1
X_29034_ _09745_ _09797_ _10152_ _10153_ VDD VSS AOI21_X1
X_29035_ _09797_ _09719_ _10006_ _10154_ VDD VSS AOI21_X1
X_29036_ _10153_ _10154_ _10155_ VDD VSS NOR2_X1
X_29037_ _09884_ _09687_ _09965_ _10156_ VDD VSS OAI21_X1
X_29038_ _10151_ _10155_ _10156_ _09778_ _10157_ VDD VSS OAI22_X1
X_29039_ _09710_ _10151_ _10156_ _10158_ VDD VSS AOI21_X1
X_29040_ _10157_ _10158_ _10159_ VDD VSS NOR2_X1
X_29041_ _10902_ _10159_ _10067_ _01565_ VDD VSS MUX2_X1
X_29042_ _09817_ _09733_ _09842_ _10160_ VDD VSS NAND3_X1
X_29043_ _10155_ _09818_ _09817_ _10161_ VDD VSS AOI21_X1
X_29044_ _09778_ _09703_ _09733_ _09771_ _10162_ VDD VSS AOI22_X1
X_29045_ _10160_ _10161_ _09704_ _10162_ _09769_ _10163_ VDD
+ VSS OAI221_X1
X_29046_ _10394_ _10163_ _10067_ _01566_ VDD VSS MUX2_X1
X_29047_ _06224_ _07253_ _10164_ VDD VSS NAND2_X1
X_29048_ _09707_ _10165_ VDD VSS INV_X1
X_29049_ _09811_ _09860_ _09842_ _09722_ _10166_ VDD VSS AOI22_X1
X_29050_ _09887_ _09891_ _10165_ _10166_ _09808_ _10167_ VDD
+ VSS OAI221_X1
X_29051_ _09798_ _10006_ _09795_ _10168_ VDD VSS AOI21_X1
X_29052_ _09811_ _09810_ _10142_ _10169_ VDD VSS AOI21_X1
X_29053_ _09811_ _10091_ _10142_ _10168_ _10169_ _10165_ _10170_
+ VDD VSS OAI33_X1
X_29054_ _10167_ _10170_ _09887_ _10171_ VDD VSS OAI21_X1
X_29055_ _10164_ _10171_ _09783_ _01567_ VDD VSS OAI21_X1
X_29056_ _07180_ _10172_ VDD VSS CLKBUF_X3
X_29057_ id_stage_i.controller_i.instr_compressed_i\[0\] _09795_
+ _10172_ _01568_ VDD VSS MUX2_X1
X_29058_ id_stage_i.controller_i.instr_compressed_i\[10\]
+ _09805_ _10172_ _01569_ VDD VSS MUX2_X1
X_29059_ id_stage_i.controller_i.instr_compressed_i\[11\]
+ _09763_ _10172_ _01570_ VDD VSS MUX2_X1
X_29060_ id_stage_i.controller_i.instr_compressed_i\[12\]
+ _09756_ _10172_ _01571_ VDD VSS MUX2_X1
X_29061_ id_stage_i.controller_i.instr_compressed_i\[13\]
+ _09808_ _10172_ _01572_ VDD VSS MUX2_X1
X_29062_ id_stage_i.controller_i.instr_compressed_i\[14\]
+ _09699_ _10172_ _01573_ VDD VSS MUX2_X1
X_29063_ id_stage_i.controller_i.instr_compressed_i\[15\]
+ _09697_ _10172_ _01574_ VDD VSS MUX2_X1
X_29064_ id_stage_i.controller_i.instr_compressed_i\[1\] _09798_
+ _10172_ _01575_ VDD VSS MUX2_X1
X_29065_ id_stage_i.controller_i.instr_compressed_i\[2\] _09841_
+ _10172_ _01576_ VDD VSS MUX2_X1
X_29066_ id_stage_i.controller_i.instr_compressed_i\[3\] _09733_
+ _10172_ _01577_ VDD VSS MUX2_X1
X_29067_ _07180_ _10173_ VDD VSS BUF_X4
X_29068_ id_stage_i.controller_i.instr_compressed_i\[4\] _09860_
+ _10173_ _01578_ VDD VSS MUX2_X1
X_29069_ id_stage_i.controller_i.instr_compressed_i\[5\] _09726_
+ _10173_ _01579_ VDD VSS MUX2_X1
X_29070_ id_stage_i.controller_i.instr_compressed_i\[6\] _09722_
+ _10173_ _01580_ VDD VSS MUX2_X1
X_29071_ id_stage_i.controller_i.instr_compressed_i\[7\] _09710_
+ _10173_ _01581_ VDD VSS MUX2_X1
X_29072_ id_stage_i.controller_i.instr_compressed_i\[8\] _09703_
+ _10173_ _01582_ VDD VSS MUX2_X1
X_29073_ id_stage_i.controller_i.instr_compressed_i\[9\] _09707_
+ _10173_ _01583_ VDD VSS MUX2_X1
X_29074_ cs_registers_i.pc_id_i\[10\] cs_registers_i.pc_if_i\[10\]
+ _10173_ _01584_ VDD VSS MUX2_X1
X_29075_ cs_registers_i.pc_id_i\[11\] _07178_ _10173_ _01585_
+ VDD VSS MUX2_X1
X_29076_ cs_registers_i.pc_id_i\[12\] _07199_ _10173_ _01586_
+ VDD VSS MUX2_X1
X_29077_ _12076_ cs_registers_i.pc_if_i\[13\] _10173_ _01587_
+ VDD VSS MUX2_X1
X_29078_ _07180_ _10174_ VDD VSS CLKBUF_X3
X_29079_ _12179_ cs_registers_i.pc_if_i\[14\] _10174_ _01588_
+ VDD VSS MUX2_X1
X_29080_ cs_registers_i.pc_id_i\[15\] _07222_ _10174_ _01589_
+ VDD VSS MUX2_X1
X_29081_ cs_registers_i.pc_id_i\[16\] cs_registers_i.pc_if_i\[16\]
+ _10174_ _01590_ VDD VSS MUX2_X1
X_29082_ cs_registers_i.pc_id_i\[17\] cs_registers_i.pc_if_i\[17\]
+ _10174_ _01591_ VDD VSS MUX2_X1
X_29083_ cs_registers_i.pc_id_i\[18\] _07235_ _10174_ _01592_
+ VDD VSS MUX2_X1
X_29084_ _12590_ _07241_ _10174_ _01593_ VDD VSS MUX2_X1
X_29085_ _03981_ _10675_ _07253_ _01594_ VDD VSS MUX2_X1
X_29086_ _12685_ _07249_ _10174_ _01595_ VDD VSS MUX2_X1
X_29087_ cs_registers_i.pc_id_i\[21\] cs_registers_i.pc_if_i\[21\]
+ _10174_ _01596_ VDD VSS MUX2_X1
X_29088_ cs_registers_i.pc_id_i\[22\] _07259_ _10174_ _01597_
+ VDD VSS MUX2_X1
X_29089_ _12935_ _07263_ _10174_ _01598_ VDD VSS MUX2_X1
X_29090_ _07179_ _10175_ VDD VSS CLKBUF_X3
X_29091_ _13024_ cs_registers_i.pc_if_i\[24\] _10175_ _01599_
+ VDD VSS MUX2_X1
X_29092_ cs_registers_i.pc_id_i\[25\] cs_registers_i.pc_if_i\[25\]
+ _10175_ _01600_ VDD VSS MUX2_X1
X_29093_ cs_registers_i.pc_id_i\[26\] _07281_ _10175_ _01601_
+ VDD VSS MUX2_X1
X_29094_ cs_registers_i.pc_id_i\[27\] _07285_ _10175_ _01602_
+ VDD VSS MUX2_X1
X_29095_ cs_registers_i.pc_id_i\[28\] cs_registers_i.pc_if_i\[28\]
+ _10175_ _01603_ VDD VSS MUX2_X1
X_29096_ cs_registers_i.pc_id_i\[29\] cs_registers_i.pc_if_i\[29\]
+ _10175_ _01604_ VDD VSS MUX2_X1
X_29097_ cs_registers_i.pc_id_i\[2\] cs_registers_i.pc_if_i\[2\]
+ _10175_ _01605_ VDD VSS MUX2_X1
X_29098_ cs_registers_i.pc_id_i\[30\] cs_registers_i.pc_if_i\[30\]
+ _10175_ _01606_ VDD VSS MUX2_X1
X_29099_ cs_registers_i.pc_id_i\[31\] cs_registers_i.pc_if_i\[31\]
+ _10175_ _01607_ VDD VSS MUX2_X1
X_29100_ _11517_ _07181_ _10175_ _01608_ VDD VSS MUX2_X1
X_29101_ cs_registers_i.pc_id_i\[4\] _07186_ _07193_ _01609_
+ VDD VSS MUX2_X1
X_29102_ cs_registers_i.pc_id_i\[5\] _07187_ _07193_ _01610_
+ VDD VSS MUX2_X1
X_29103_ cs_registers_i.pc_id_i\[6\] cs_registers_i.pc_if_i\[6\]
+ _07193_ _01611_ VDD VSS MUX2_X1
X_29104_ cs_registers_i.pc_id_i\[7\] _07185_ _07193_ _01612_
+ VDD VSS MUX2_X1
X_29105_ _11788_ cs_registers_i.pc_if_i\[8\] _07193_ _01613_
+ VDD VSS MUX2_X1
X_29106_ _11826_ _07184_ _07193_ _01614_ VDD VSS MUX2_X1
X_29107_ _00133_ _04162_ net245 VDD VSS NAND2_X2
X_29108_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]
+ _04155_ _07425_ _06287_ _10176_ VDD VSS NOR4_X2
X_29109_ _10176_ _06286_ _03436_ _10177_ VDD VSS OAI21_X2
X_29110_ net245 _10177_ core_busy_d VDD VSS OR2_X1
X_29111_ clknet_1_0__leaf_clk_i core_clock_gate_i.en_latch
+ clk VDD VSS AND2_X1
X_29112_ _10477_ _03619_ _10178_ VDD VSS NOR2_X1
X_29113_ _10178_ _16086_ _10477_ _10179_ VDD VSS AOI21_X1
X_29114_ _16087_ _10179_ _07447_ net177 VDD VSS MUX2_X2
X_29115_ _16101_ _16091_ _10477_ _10180_ VDD VSS MUX2_X1
X_29116_ _16089_ _10180_ _07447_ net178 VDD VSS MUX2_X2
X_29117_ _16097_ _07475_ _10181_ VDD VSS NAND2_X1
X_29118_ _07446_ _10182_ VDD VSS INV_X1
X_29119_ load_store_unit_i.handle_misaligned_q _07447_ _10182_
+ _10183_ VDD VSS OAI21_X1
X_29120_ _10477_ _16094_ _07447_ _10184_ VDD VSS NAND3_X1
X_29121_ _10184_ _07447_ _16093_ _10185_ VDD VSS OAI21_X1
X_29122_ _10183_ _10185_ load_store_unit_i.handle_misaligned_q
+ _10186_ VDD VSS OAI21_X1
X_29123_ _10181_ _10186_ net179 VDD VSS NAND2_X2
X_29124_ _07446_ _16088_ _10477_ _10187_ VDD VSS MUX2_X1
X_29125_ _16085_ _10187_ _07447_ net180 VDD VSS MUX2_X2
X_29126_ _16099_ _10188_ VDD VSS BUF_X2
X_29127_ _10188_ _10189_ VDD VSS BUF_X4
X_29128_ _16103_ _10190_ VDD VSS BUF_X2
X_29129_ _10189_ _12316_ net372 _10190_ _10191_ VDD VSS AOI22_X1
X_29130_ _10191_ _11241_ _10182_ _10192_ VDD VSS OAI21_X1
X_29131_ _03619_ _10192_ _10193_ VDD VSS NOR2_X1
X_29132_ _10193_ _03660_ _03619_ net182 VDD VSS AOI21_X4
X_29133_ _03620_ _10194_ VDD VSS BUF_X8
X_29134_ _10194_ _03736_ _10195_ VDD VSS NOR2_X1
X_29135_ _07446_ _10196_ VDD VSS BUF_X4
X_29136_ _10196_ _10197_ VDD VSS BUF_X4
X_29137_ _10188_ _10198_ VDD VSS BUF_X4
X_29138_ _10190_ _10199_ VDD VSS BUF_X4
X_29139_ _10197_ _12482_ net331 _10198_ _10199_ _10973_ _10200_
+ VDD VSS AOI222_X2
X_29140_ _10195_ _10200_ _16084_ net183 VDD VSS AOI21_X2
X_29141_ _10194_ _11351_ _10201_ VDD VSS NOR2_X1
X_29142_ _10197_ net280 net344 _10198_ _10199_ _11019_ _10202_
+ VDD VSS AOI222_X2
X_29143_ _10201_ _10202_ _16084_ net184 VDD VSS AOI21_X2
X_29144_ _03620_ _10203_ VDD VSS CLKBUF_X3
X_29145_ _10203_ net295 _10204_ VDD VSS NOR2_X1
X_29146_ _10197_ _12651_ _13314_ _10198_ _10199_ _03519_ _10205_
+ VDD VSS AOI222_X2
X_29147_ _10204_ _10205_ _16084_ net185 VDD VSS AOI21_X2
X_29148_ _10203_ _12044_ _10206_ VDD VSS NOR2_X1
X_29149_ _10188_ _10207_ VDD VSS BUF_X4
X_29150_ _10190_ _10208_ VDD VSS BUF_X4
X_29151_ _10197_ net325 _03166_ _10207_ _10208_ _03696_ _10209_
+ VDD VSS AOI222_X2
X_29152_ _10206_ _10209_ _16084_ net186 VDD VSS AOI21_X2
X_29153_ _10203_ _12144_ _10210_ VDD VSS NOR2_X1
X_29154_ _10197_ net283 _03275_ _10207_ _10208_ net345 _10211_
+ VDD VSS AOI222_X2
X_29155_ _10210_ _10211_ _16084_ net187 VDD VSS AOI21_X2
X_29156_ _10203_ _12221_ _10212_ VDD VSS NOR2_X1
X_29157_ _10197_ net282 _03772_ _10207_ _10208_ _11202_ _10213_
+ VDD VSS AOI222_X2
X_29158_ _10212_ _10213_ _16084_ net188 VDD VSS AOI21_X2
X_29159_ _10196_ _12985_ _10214_ VDD VSS NAND2_X1
X_29160_ _10190_ _10215_ VDD VSS BUF_X4
X_29161_ _10215_ _10216_ VDD VSS INV_X1
X_29162_ _10189_ _10217_ VDD VSS INV_X1
X_29163_ _10214_ _11241_ _10216_ _10217_ _03660_ _10218_ VDD
+ VSS OAI221_X1
X_29164_ _12316_ _10218_ _04153_ net189 VDD VSS MUX2_X2
X_29165_ _10203_ net284 _10219_ VDD VSS NOR2_X1
X_29166_ _10198_ net347 _03727_ _10199_ net333 _10196_ _10220_
+ VDD VSS AOI222_X2
X_29167_ _10219_ _10220_ _16084_ net190 VDD VSS AOI21_X2
X_29168_ _10203_ _12482_ _10221_ VDD VSS NOR2_X1
X_29169_ _10198_ _10973_ _03736_ _10199_ net331 _10196_ _10222_
+ VDD VSS AOI222_X2
X_29170_ _10221_ _10222_ _16084_ net191 VDD VSS AOI21_X2
X_29171_ _10203_ net280 _10223_ VDD VSS NOR2_X1
X_29172_ _10198_ _11019_ _11351_ _10199_ net344 _10196_ _10224_
+ VDD VSS AOI222_X2
X_29173_ _10223_ _10224_ _16084_ net192 VDD VSS AOI21_X2
X_29174_ _10203_ net347 _10225_ VDD VSS NOR2_X1
X_29175_ _10197_ _03727_ net284 _10207_ net333 _10208_ _10226_
+ VDD VSS AOI222_X2
X_29176_ _04153_ _10227_ VDD VSS BUF_X8
X_29177_ _10225_ _10226_ _10227_ net193 VDD VSS AOI21_X2
X_29178_ _10203_ _12651_ _10228_ VDD VSS NOR2_X1
X_29179_ _10198_ _03519_ net295 _10199_ _13314_ _10196_ _10229_
+ VDD VSS AOI222_X2
X_29180_ _10228_ _10229_ _10227_ net194 VDD VSS AOI21_X2
X_29181_ _10203_ net325 _10230_ VDD VSS NOR2_X1
X_29182_ _10198_ _03696_ net341 _10199_ _03166_ _10196_ _10231_
+ VDD VSS AOI222_X2
X_29183_ _10230_ _10231_ _10227_ net195 VDD VSS AOI21_X2
X_29184_ _03620_ _10232_ VDD VSS CLKBUF_X3
X_29185_ _10232_ net283 _10233_ VDD VSS NOR2_X1
X_29186_ _10198_ net345 _12144_ _10199_ _03275_ _10196_ _10234_
+ VDD VSS AOI222_X2
X_29187_ _10233_ _10234_ _10227_ net196 VDD VSS AOI21_X2
X_29188_ _10232_ net282 _10235_ VDD VSS NOR2_X1
X_29189_ _10198_ _11202_ _12221_ _10199_ _03772_ _10196_ _10236_
+ VDD VSS AOI222_X2
X_29190_ _10235_ _10236_ _10227_ net197 VDD VSS AOI21_X2
X_29191_ _10215_ _12316_ _10237_ VDD VSS NAND2_X1
X_29192_ _10237_ _11241_ _10217_ _10182_ _03660_ _10238_ VDD
+ VSS OAI221_X1
X_29193_ _12985_ _10238_ _04153_ net198 VDD VSS MUX2_X2
X_29194_ _10232_ _13061_ _10239_ VDD VSS NOR2_X1
X_29195_ _10197_ net347 _03727_ _10207_ net284 _10208_ _10240_
+ VDD VSS AOI222_X2
X_29196_ _10239_ _10240_ _10227_ net199 VDD VSS AOI21_X4
X_29197_ _10232_ net331 _10241_ VDD VSS NOR2_X1
X_29198_ _10197_ _10973_ _03736_ _10207_ _12482_ _10208_ _10242_
+ VDD VSS AOI222_X2
X_29199_ _10241_ _10242_ _10227_ net200 VDD VSS AOI21_X2
X_29200_ _10232_ net344 _10243_ VDD VSS NOR2_X1
X_29201_ _10197_ _11019_ _11351_ _10207_ net280 _10208_ _10244_
+ VDD VSS AOI222_X2
X_29202_ _10243_ _10244_ _10227_ net201 VDD VSS AOI21_X2
X_29203_ _10232_ _13314_ _10245_ VDD VSS NOR2_X1
X_29204_ _10196_ _10246_ VDD VSS BUF_X4
X_29205_ _10246_ _03519_ net330 _10207_ _12651_ _10208_ _10247_
+ VDD VSS AOI222_X2
X_29206_ _10245_ _10247_ _10227_ net202 VDD VSS AOI21_X4
X_29207_ _10232_ _03166_ _10248_ VDD VSS NOR2_X1
X_29208_ _10246_ _03696_ _12044_ _10207_ net410 _10208_ _10249_
+ VDD VSS AOI222_X2
X_29209_ _10248_ _10249_ _10227_ net203 VDD VSS AOI21_X4
X_29210_ _10189_ _12482_ _13155_ _10215_ _10250_ VDD VSS AOI22_X1
X_29211_ _10250_ _11313_ _10182_ _10251_ VDD VSS OAI21_X1
X_29212_ _10973_ _10251_ _04153_ net204 VDD VSS MUX2_X2
X_29213_ _10232_ _03275_ _10252_ VDD VSS NOR2_X1
X_29214_ _10246_ net345 net335 _10207_ _12823_ _10215_ _10253_
+ VDD VSS AOI222_X2
X_29215_ _10252_ _10253_ _10194_ net205 VDD VSS AOI21_X4
X_29216_ _10232_ _03772_ _10254_ VDD VSS NOR2_X1
X_29217_ _10246_ _11202_ net332 _10189_ _12896_ _10215_ _10255_
+ VDD VSS AOI222_X2
X_29218_ _10254_ _10255_ _10194_ net206 VDD VSS AOI21_X4
X_29219_ _10232_ _11019_ _10256_ VDD VSS NOR2_X1
X_29220_ _10246_ _11351_ net369 _10189_ _13224_ _10215_ _10257_
+ VDD VSS AOI222_X2
X_29221_ _10256_ _10257_ _10194_ net207 VDD VSS AOI21_X4
X_29222_ _04153_ _03519_ _10258_ VDD VSS NOR2_X1
X_29223_ _10246_ net329 _12651_ _10189_ _13314_ _10215_ _10259_
+ VDD VSS AOI222_X2
X_29224_ _10258_ _10259_ _10194_ net208 VDD VSS AOI21_X4
X_29225_ _04153_ _03696_ _10260_ VDD VSS NOR2_X1
X_29226_ _10246_ _12044_ _12725_ _10189_ _03166_ _10215_ _10261_
+ VDD VSS AOI222_X2
X_29227_ _10260_ _10261_ _10194_ net209 VDD VSS AOI21_X4
X_29228_ _04153_ net345 _10262_ VDD VSS NOR2_X1
X_29229_ _10246_ net335 _12823_ _10189_ _03275_ _10215_ _10263_
+ VDD VSS AOI222_X2
X_29230_ _10262_ _10263_ _10194_ net210 VDD VSS AOI21_X4
X_29231_ _04153_ _11202_ _10264_ VDD VSS NOR2_X1
X_29232_ _10246_ net332 _12896_ _10189_ _03772_ _10215_ _10265_
+ VDD VSS AOI222_X2
X_29233_ _10264_ _10265_ _10194_ net211 VDD VSS AOI21_X4
X_29234_ _07446_ _12316_ _12985_ _10188_ _10266_ VDD VSS AOI22_X1
X_29235_ _10266_ _03660_ _10216_ _10267_ VDD VSS OAI21_X1
X_29236_ _03619_ _10267_ _10268_ VDD VSS NOR2_X1
X_29237_ _10268_ _11241_ _03619_ net212 VDD VSS AOI21_X4
X_29238_ _04153_ _03727_ _10269_ VDD VSS NOR2_X1
X_29239_ _10246_ net289 _13061_ _10189_ _10208_ _03675_ _10270_
+ VDD VSS AOI222_X2
X_29240_ _10269_ _10270_ _10194_ net213 VDD VSS AOI21_X4
X_29241_ _11418_ _03886_ _06323_ id_stage_i.branch_set_d VDD
+ VSS AND3_X1
X_29242_ net94 net245 _10271_ VDD VSS NAND2_X1
X_29243_ _03960_ _10271_ _10272_ VDD VSS NOR2_X1
X_29244_ _04155_ net125 _03939_ _10273_ VDD VSS OAI21_X1
X_29245_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[1\]
+ _03939_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]
+ _10274_ VDD VSS AOI21_X1
X_29246_ _07143_ _10273_ _10274_ _07144_ _10275_ VDD VSS AOI22_X1
X_29247_ _10272_ _10275_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_s\[0\]
+ VDD VSS OR2_X1
X_29248_ _04155_ _10272_ _10276_ VDD VSS NAND2_X1
X_29249_ _07144_ _10274_ _10276_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_s\[1\]
+ VDD VSS AOI21_X1
X_29250_ _07156_ _07142_ _10277_ VDD VSS OR2_X1
X_29251_ _07150_ _07156_ _10278_ VDD VSS NAND2_X1
X_29252_ _07229_ _10277_ _10278_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[0\]
+ VDD VSS AND3_X1
X_29253_ _06265_ _07155_ _10279_ VDD VSS NOR2_X1
X_29254_ _06858_ _10279_ _07142_ _10280_ VDD VSS OAI21_X1
X_29255_ _07164_ _10280_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[1\]
+ VDD VSS NOR2_X1
X_29256_ _06893_ _10279_ _07162_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[2\]
+ VDD VSS NOR3_X1
X_29257_ _00134_ net125 _10281_ VDD VSS NAND2_X1
X_29258_ _04155_ _10281_ _10282_ VDD VSS NAND2_X1
X_29259_ _10271_ _10282_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_s\[0\]
+ VDD VSS NAND2_X1
X_29260_ _04155_ net94 net245 _10283_ VDD VSS NAND3_X1
X_29261_ _07144_ _10283_ _00134_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_s\[1\]
+ VDD VSS AOI21_X1
X_29262_ net94 _04162_ _00133_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_d
+ VDD VSS AOI21_X1
X_29263_ _03461_ _03854_ _10284_ VDD VSS NAND2_X1
X_29264_ _10304_ _10284_ _03881_ _06287_ _10285_ VDD VSS NAND4_X1
X_29265_ _06265_ _06283_ _03931_ _10286_ VDD VSS AOI21_X1
X_29266_ _06893_ _09783_ _10285_ _10286_ if_stage_i.instr_valid_id_d
+ VDD VSS OAI22_X1
X_29267_ _14065_ _14064_ _14066_ _14067_ _14068_ VDD VSS FA_X1
X_29268_ _14069_ _14070_ _14071_ _14072_ _14073_ VDD VSS FA_X1
X_29269_ _14074_ _14075_ _14076_ _14077_ _14078_ VDD VSS FA_X1
X_29270_ _14079_ _14080_ _14081_ _14082_ _14083_ VDD VSS FA_X1
X_29271_ _14084_ _14085_ _14086_ _14087_ _14088_ VDD VSS FA_X1
X_29272_ _14089_ _14090_ _14091_ _14092_ _14093_ VDD VSS FA_X1
X_29273_ _14094_ _14095_ _14096_ _14097_ _14098_ VDD VSS FA_X1
X_29274_ _14099_ _14100_ _14101_ _14102_ _14103_ VDD VSS FA_X1
X_29275_ _14104_ _14105_ _14106_ _14107_ _14108_ VDD VSS FA_X1
X_29276_ _14109_ _14110_ _14111_ _14112_ _14113_ VDD VSS FA_X1
X_29277_ _14092_ _14114_ _14113_ _14115_ _14116_ VDD VSS FA_X1
X_29278_ _14117_ _14118_ _14119_ _14120_ _14121_ VDD VSS FA_X1
X_29279_ _14122_ _14123_ _14124_ _14125_ _14126_ VDD VSS FA_X1
X_29280_ _14127_ _14128_ _14129_ _14130_ _14131_ VDD VSS FA_X1
X_29281_ _14132_ _14133_ _14134_ _14135_ _14136_ VDD VSS FA_X1
X_29282_ _14112_ _14137_ _14136_ _14138_ _14139_ VDD VSS FA_X1
X_29283_ _14140_ _14141_ _14142_ _14143_ _14144_ VDD VSS FA_X1
X_29284_ _14145_ _14146_ _14147_ _14148_ _14149_ VDD VSS FA_X1
X_29285_ _14150_ _14151_ _14152_ _14153_ _14154_ VDD VSS FA_X1
X_29286_ _14155_ _14156_ _14154_ _14157_ _14158_ VDD VSS FA_X1
X_29287_ _14159_ _14160_ _14161_ _14162_ _14163_ VDD VSS FA_X1
X_29288_ _14164_ _14163_ _14135_ _14165_ _14166_ VDD VSS FA_X1
X_29289_ _14167_ _14168_ _14169_ _14170_ _14171_ VDD VSS FA_X1
X_29290_ _14172_ _14173_ _14174_ _14175_ _14176_ VDD VSS FA_X1
X_29291_ _14177_ _14178_ _14179_ _14180_ _14181_ VDD VSS FA_X1
X_29292_ _14182_ _14183_ _14184_ _14185_ _14186_ VDD VSS FA_X1
X_29293_ _14187_ _14181_ _14148_ _14188_ _14189_ VDD VSS FA_X1
X_29294_ _14190_ _14191_ _14192_ _14193_ _14194_ VDD VSS FA_X1
X_29295_ _14195_ _14194_ _14162_ _14196_ _14197_ VDD VSS FA_X1
X_29296_ _14198_ _14199_ _14200_ _14201_ _14202_ VDD VSS FA_X1
X_29297_ _14203_ _14204_ _14205_ _14206_ _14207_ VDD VSS FA_X1
X_29298_ _14208_ _14210_ _14209_ _14211_ _14212_ VDD VSS FA_X1
X_29299_ _14213_ _14214_ _14215_ _14216_ _14217_ VDD VSS FA_X1
X_29300_ _14212_ _14180_ _14218_ _14219_ _14220_ VDD VSS FA_X1
X_29301_ _14221_ _14222_ _14223_ _14224_ _14225_ VDD VSS FA_X1
X_29302_ _14226_ _14225_ _14193_ _14227_ _14228_ VDD VSS FA_X1
X_29303_ _14229_ _14230_ _14231_ _14232_ _14233_ VDD VSS FA_X1
X_29304_ _14234_ _14235_ _14236_ _14237_ _14238_ VDD VSS FA_X1
X_29305_ _14239_ _14240_ _14238_ _14241_ _14242_ VDD VSS FA_X1
X_29306_ _14243_ _14244_ _14245_ _14246_ _14247_ VDD VSS FA_X1
X_29307_ _14248_ _14250_ _14249_ _14251_ _14252_ VDD VSS FA_X1
X_29308_ _14253_ _14254_ _14255_ _14256_ _14257_ VDD VSS FA_X1
X_29309_ _14258_ _14211_ _14252_ _14259_ _14260_ VDD VSS FA_X1
X_29310_ _14262_ _14261_ _14263_ _14264_ _14265_ VDD VSS FA_X1
X_29311_ _14266_ _14224_ _14265_ _14267_ _14268_ VDD VSS FA_X1
X_29312_ _14269_ _14270_ _14271_ _14272_ _14273_ VDD VSS FA_X1
X_29313_ _14274_ _14275_ _14276_ _14277_ _14278_ VDD VSS FA_X1
X_29314_ _14279_ _14232_ _14280_ _14281_ _14282_ VDD VSS FA_X1
X_29315_ _14283_ _14284_ _14285_ _14286_ _14287_ VDD VSS FA_X1
X_29316_ _14288_ _14290_ _14289_ _14291_ _14292_ VDD VSS FA_X1
X_29317_ _14293_ _14294_ _14295_ _14296_ _14297_ VDD VSS FA_X1
X_29318_ _14298_ _14251_ _14292_ _14299_ _14300_ VDD VSS FA_X1
X_29319_ _14301_ _14259_ _14300_ _14302_ _14303_ VDD VSS FA_X1
X_29320_ _14305_ _14304_ _14306_ _14307_ _14308_ VDD VSS FA_X1
X_29321_ _14309_ _14264_ _14308_ _14310_ _14311_ VDD VSS FA_X1
X_29322_ _14312_ _14313_ _14314_ _14315_ _14316_ VDD VSS FA_X1
X_29323_ _14317_ _14319_ _14318_ _14320_ _14321_ VDD VSS FA_X1
X_29324_ _14322_ _14272_ _14323_ _14324_ _14325_ VDD VSS FA_X1
X_29325_ _14326_ _14327_ _14328_ _14329_ _14330_ VDD VSS FA_X1
X_29326_ _14331_ _14333_ _14332_ _14334_ _14335_ VDD VSS FA_X1
X_29327_ _14336_ _14337_ _14338_ _14339_ _14340_ VDD VSS FA_X1
X_29328_ _14341_ _14291_ _14335_ _14342_ _14343_ VDD VSS FA_X1
X_29329_ _14344_ _14299_ _14343_ _14345_ _14346_ VDD VSS FA_X1
X_29330_ _14349_ _14348_ _14347_ _14350_ _14351_ VDD VSS FA_X1
X_29331_ _14352_ _14353_ _14354_ _14355_ _14356_ VDD VSS FA_X1
X_29332_ _14357_ _14356_ _14307_ _14358_ _14359_ VDD VSS FA_X1
X_29333_ _14360_ _14361_ _14362_ _14363_ _14364_ VDD VSS FA_X1
X_29334_ _14365_ _14364_ _14351_ _14366_ _14367_ VDD VSS FA_X1
X_29335_ _14315_ _14369_ _14368_ _14370_ _14371_ VDD VSS FA_X1
X_29336_ _14372_ _14373_ _14374_ _14375_ _14376_ VDD VSS FA_X1
X_29337_ _14377_ _14378_ _14379_ _14380_ _14381_ VDD VSS FA_X1
X_29338_ _14381_ _14329_ _14382_ _14383_ _14384_ VDD VSS FA_X1
X_29339_ _14385_ _14386_ _14387_ _14388_ _14389_ VDD VSS FA_X1
X_29340_ _14390_ _14391_ _14392_ _14393_ _14394_ VDD VSS FA_X1
X_29341_ _14395_ _14334_ _14389_ _14396_ _14397_ VDD VSS FA_X1
X_29342_ _14398_ _14342_ _14397_ _14399_ _14400_ VDD VSS FA_X1
X_29343_ _14401_ _14402_ _14403_ _14404_ _14405_ VDD VSS FA_X1
X_29344_ _14406_ _14407_ _14408_ _14409_ _14410_ VDD VSS FA_X1
X_29345_ _14411_ _14410_ _14355_ _14412_ _14413_ VDD VSS FA_X1
X_29346_ _14414_ _14415_ _14416_ _14417_ _14418_ VDD VSS FA_X1
X_29347_ _14421_ _14420_ _14419_ _14422_ _14423_ VDD VSS FA_X1
X_29348_ _14423_ _14424_ _14425_ _14426_ _14427_ VDD VSS FA_X1
X_29349_ _14428_ _14429_ _14430_ _14431_ _14432_ VDD VSS FA_X1
X_29350_ _14433_ _14434_ _14435_ _14436_ _14437_ VDD VSS FA_X1
X_29351_ _14437_ _14380_ _14438_ _14439_ _14440_ VDD VSS FA_X1
X_29352_ _14443_ _14442_ _14441_ _14444_ _14445_ VDD VSS FA_X1
X_29353_ _14446_ _14447_ _14448_ _14449_ _14450_ VDD VSS FA_X1
X_29354_ _14451_ _14445_ _14388_ _14452_ _14453_ VDD VSS FA_X1
X_29355_ _14383_ _14453_ _14396_ _14454_ _14455_ VDD VSS FA_X1
X_29356_ _14457_ _14456_ _14458_ _14459_ _14460_ VDD VSS FA_X1
X_29357_ _14461_ _14462_ _14463_ _14464_ _14465_ VDD VSS FA_X1
X_29358_ _14466_ _14465_ _14409_ _14467_ _14468_ VDD VSS FA_X1
X_29359_ _14469_ _14470_ _14471_ _14472_ _14473_ VDD VSS FA_X1
X_29360_ _14476_ _14474_ _14475_ _14477_ _14478_ VDD VSS FA_X1
X_29361_ _14479_ _14478_ _14422_ _14480_ _14481_ VDD VSS FA_X1
X_29362_ _14482_ _14483_ _14484_ _14485_ _14486_ VDD VSS FA_X1
X_29363_ _14487_ _14488_ _14489_ _14490_ _14491_ VDD VSS FA_X1
X_29364_ _14431_ _14491_ _14436_ _14492_ _14493_ VDD VSS FA_X1
X_29365_ _14494_ _14495_ _14496_ _14497_ _14498_ VDD VSS FA_X1
X_29366_ _14499_ _14501_ _14500_ _14502_ _14503_ VDD VSS FA_X1
X_29367_ _14504_ _14505_ _14506_ _14507_ _14508_ VDD VSS FA_X1
X_29368_ _14509_ _14444_ _14503_ _14510_ _14511_ VDD VSS FA_X1
X_29369_ _14439_ _14452_ _14511_ _14512_ _14513_ VDD VSS FA_X1
X_29370_ _14514_ _14498_ _14515_ _14516_ _14517_ VDD VSS FA_X1
X_29371_ _14518_ _14519_ _14520_ _14521_ _14522_ VDD VSS FA_X1
X_29372_ _14523_ _14522_ _14464_ _14524_ _14525_ VDD VSS FA_X1
X_29373_ _14526_ _14527_ _14528_ _14529_ _14530_ VDD VSS FA_X1
X_29374_ _14533_ _14532_ _14531_ _14534_ _14535_ VDD VSS FA_X1
X_29375_ _14536_ _14477_ _14535_ _14537_ _14538_ VDD VSS FA_X1
X_29376_ _14539_ _14540_ _14541_ _14542_ _14543_ VDD VSS FA_X1
X_29377_ _14544_ _14545_ _14546_ _14547_ _14548_ VDD VSS FA_X1
X_29378_ _14549_ _14550_ _14548_ _14551_ _14552_ VDD VSS FA_X1
X_29379_ _14555_ _14554_ _14553_ _14556_ _14557_ VDD VSS FA_X1
X_29380_ _14558_ _14490_ _14557_ _14559_ _14560_ VDD VSS FA_X1
X_29381_ _14552_ _14561_ _14562_ _14563_ _14564_ VDD VSS FA_X1
X_29382_ _14565_ _14567_ _14566_ _14568_ _14569_ VDD VSS FA_X1
X_29383_ _14570_ _14571_ _14572_ _14573_ _14574_ VDD VSS FA_X1
X_29384_ _14569_ _14502_ _14575_ _14576_ _14577_ VDD VSS FA_X1
X_29385_ _14492_ _14510_ _14577_ _14578_ _14579_ VDD VSS FA_X1
X_29386_ _14579_ _14581_ _14580_ _14582_ _14583_ VDD VSS FA_X1
X_29387_ _14586_ _14585_ _14584_ _14587_ _14588_ VDD VSS FA_X1
X_29388_ _14589_ _14521_ _14590_ _14591_ _14592_ VDD VSS FA_X1
X_29389_ net328 _14595_ _14594_ _14596_ _14597_ VDD VSS FA_X1
X_29390_ _14598_ _14599_ _14597_ _14600_ _14601_ VDD VSS FA_X1
X_29391_ _14603_ _14602_ _14583_ _14604_ _14605_ VDD VSS FA_X1
X_29392_ _14606_ _14534_ _14605_ _14607_ _14608_ VDD VSS FA_X1
X_29393_ _14609_ _14610_ _14611_ _14612_ _14613_ VDD VSS FA_X1
X_29394_ _14614_ _14615_ _14616_ _14617_ _14618_ VDD VSS FA_X1
X_29395_ _14619_ _14613_ _14542_ _14620_ _14621_ VDD VSS FA_X1
X_29396_ _14622_ _14623_ _14624_ _14625_ _14626_ VDD VSS FA_X1
X_29397_ _14627_ _14626_ _14556_ _14628_ _14629_ VDD VSS FA_X1
X_29398_ _14630_ _14629_ _14621_ _14631_ _14632_ VDD VSS FA_X1
X_29399_ _14633_ _14634_ _14635_ _14636_ _14637_ VDD VSS FA_X1
X_29400_ _14638_ _14639_ _14640_ _14641_ _14642_ VDD VSS FA_X1
X_29401_ _14643_ _14637_ _14568_ _14644_ _14645_ VDD VSS FA_X1
X_29402_ _14559_ _14645_ _14576_ _14646_ _14647_ VDD VSS FA_X1
X_29403_ _14632_ _14648_ _14647_ _14649_ _14650_ VDD VSS FA_X1
X_29404_ _14651_ _14586_ _14652_ _14653_ _14654_ VDD VSS FA_X1
X_29405_ _14655_ _14656_ _14657_ _14658_ _14659_ VDD VSS FA_X1
X_29406_ _14660_ _14661_ _14578_ _14662_ _14663_ VDD VSS FA_X1
X_29407_ _14650_ _14582_ _14663_ _14664_ _14665_ VDD VSS FA_X1
X_29408_ _14665_ _14604_ _14666_ _14667_ _14668_ VDD VSS FA_X1
X_29409_ _14669_ _14670_ _14671_ _14672_ _14673_ VDD VSS FA_X1
X_29410_ _14674_ _14675_ _14676_ _14677_ _14678_ VDD VSS FA_X1
X_29411_ _14612_ _14679_ _14673_ _14680_ _14681_ VDD VSS FA_X1
X_29412_ _14682_ _14683_ _14684_ _14685_ _14686_ VDD VSS FA_X1
X_29413_ _14686_ _14625_ _14687_ _14688_ _14689_ VDD VSS FA_X1
X_29414_ _14689_ _14681_ _14620_ _14690_ _14691_ VDD VSS FA_X1
X_29415_ _14692_ _14693_ _14694_ _14695_ _14696_ VDD VSS FA_X1
X_29416_ _14697_ _14698_ _14699_ _14700_ _14701_ VDD VSS FA_X1
X_29417_ _14636_ _14702_ _14696_ _14703_ _14704_ VDD VSS FA_X1
X_29418_ _14628_ _14704_ _14644_ _14705_ _14706_ VDD VSS FA_X1
X_29419_ _14631_ _14706_ _14691_ _14707_ _14708_ VDD VSS FA_X1
X_29420_ _14651_ _14709_ _14586_ _14710_ _14711_ VDD VSS FA_X1
X_29421_ _14712_ _14713_ _14714_ _14715_ _14716_ VDD VSS FA_X1
X_29422_ _14717_ _14718_ _14719_ _14720_ _14721_ VDD VSS FA_X1
X_29423_ _14649_ _14708_ _14722_ _14723_ _14724_ VDD VSS FA_X1
X_29424_ _14724_ _14664_ _14662_ _14725_ _14726_ VDD VSS FA_X1
X_29425_ _14727_ _14728_ _14729_ _14730_ _14731_ VDD VSS FA_X1
X_29426_ _14732_ _14733_ _14734_ _14735_ _14736_ VDD VSS FA_X1
X_29427_ _14672_ _14737_ _14731_ _14738_ _14739_ VDD VSS FA_X1
X_29428_ _14740_ _14741_ _14742_ _14743_ _14744_ VDD VSS FA_X1
X_29429_ _14744_ _14685_ _14745_ _14746_ _14747_ VDD VSS FA_X1
X_29430_ _14747_ _14739_ _14680_ _14748_ _14749_ VDD VSS FA_X1
X_29431_ _14750_ _14751_ _14752_ _14753_ _14754_ VDD VSS FA_X1
X_29432_ _14755_ _14756_ _14757_ _14758_ _14759_ VDD VSS FA_X1
X_29433_ _14695_ _14754_ _14759_ _14760_ _14761_ VDD VSS FA_X1
X_29434_ _14688_ _14761_ _14703_ _14762_ _14763_ VDD VSS FA_X1
X_29435_ _14690_ _14763_ _14749_ _14764_ _14765_ VDD VSS FA_X1
X_29436_ _14651_ _14586_ _14766_ _14767_ _14768_ VDD VSS FA_X1
X_29437_ _14769_ _14770_ _14771_ _14772_ _14773_ VDD VSS FA_X1
X_29438_ _14774_ _14775_ _14776_ _14777_ _14778_ VDD VSS FA_X1
X_29439_ _14765_ _14707_ _14779_ _14780_ _14781_ VDD VSS FA_X1
X_29440_ _14781_ _14723_ _14782_ _14783_ _14784_ VDD VSS FA_X1
X_29441_ _14785_ _14786_ _14787_ _14788_ _14789_ VDD VSS FA_X1
X_29442_ _14790_ _14791_ _14792_ _14793_ _14794_ VDD VSS FA_X1
X_29443_ _14795_ _14789_ _14730_ _14796_ _14797_ VDD VSS FA_X1
X_29444_ _14798_ _14799_ _14800_ _14801_ _14802_ VDD VSS FA_X1
X_29445_ _14803_ _14802_ _14743_ _14804_ _14805_ VDD VSS FA_X1
X_29446_ _14738_ _14805_ _14797_ _14806_ _14807_ VDD VSS FA_X1
X_29447_ _14808_ _14809_ _14810_ _14811_ _14812_ VDD VSS FA_X1
X_29448_ _14813_ _14814_ _14699_ _14815_ _14816_ VDD VSS FA_X1
X_29449_ _14812_ _14753_ _14817_ _14818_ _14819_ VDD VSS FA_X1
X_29450_ _14819_ _14760_ _14746_ _14820_ _14821_ VDD VSS FA_X1
X_29451_ _14821_ _14807_ _14748_ _14822_ _14823_ VDD VSS FA_X1
X_29452_ _14651_ _14824_ _14586_ _14825_ _14826_ VDD VSS FA_X1
X_29453_ _14827_ _14758_ _14828_ _14829_ _14830_ VDD VSS FA_X1
X_29454_ _14831_ _14832_ _14833_ _14834_ _14835_ VDD VSS FA_X1
X_29455_ _14764_ _14836_ _14823_ _14837_ _14838_ VDD VSS FA_X1
X_29456_ _14780_ _14839_ _14838_ _14840_ _14841_ VDD VSS FA_X1
X_29457_ _14842_ _14843_ _14844_ _14845_ _14846_ VDD VSS FA_X1
X_29458_ _14847_ _14848_ _14849_ _14850_ _14851_ VDD VSS FA_X1
X_29459_ _14846_ _14788_ _14852_ _14853_ _14854_ VDD VSS FA_X1
X_29460_ _14855_ _14856_ _14857_ _14858_ _14859_ VDD VSS FA_X1
X_29461_ _14859_ _14801_ _14860_ _14861_ _14862_ VDD VSS FA_X1
X_29462_ _14862_ _14854_ _14796_ _14863_ _14864_ VDD VSS FA_X1
X_29463_ _14865_ _14866_ _14867_ _14868_ _14869_ VDD VSS FA_X1
X_29464_ _14869_ _14811_ _14817_ _14870_ _14871_ VDD VSS FA_X1
X_29465_ _14804_ _14871_ _14818_ _14872_ _14873_ VDD VSS FA_X1
X_29466_ _14864_ _14806_ _14873_ _14874_ _14875_ VDD VSS FA_X1
X_29467_ _14651_ net2 _14876_ _14877_ _14878_ VDD VSS FA_X1
X_29468_ _14879_ _14880_ _14881_ _14882_ _14883_ VDD VSS FA_X1
X_29469_ _14884_ _14885_ _14886_ _14887_ _14888_ VDD VSS FA_X1
X_29470_ _14875_ _14822_ _14889_ _14890_ _14891_ VDD VSS FA_X1
X_29471_ _14891_ _14837_ _14892_ _14893_ _14894_ VDD VSS FA_X1
X_29472_ _14895_ _14896_ _14897_ _14898_ _14899_ VDD VSS FA_X1
X_29473_ _14900_ _14901_ _14902_ _14903_ _14904_ VDD VSS FA_X1
X_29474_ _14845_ _14905_ _14899_ _14906_ _14907_ VDD VSS FA_X1
X_29475_ _14908_ _14909_ _14910_ _14911_ _14912_ VDD VSS FA_X1
X_29476_ _14912_ _14858_ _14913_ _14914_ _14915_ VDD VSS FA_X1
X_29477_ _14915_ _14907_ _14853_ _14916_ _14917_ VDD VSS FA_X1
X_29478_ _14866_ _14918_ _14919_ _14920_ _14921_ VDD VSS FA_X1
X_29479_ _14922_ _14816_ _14923_ _14924_ _14925_ VDD VSS FA_X1
X_29480_ _14861_ _14926_ _14870_ _14927_ _14928_ VDD VSS FA_X1
X_29481_ _14863_ _14928_ _14917_ _14929_ _14930_ VDD VSS FA_X1
X_29482_ _14651_ _14931_ net2 _14932_ _14933_ VDD VSS FA_X1
X_29483_ _14934_ _14935_ _14880_ _14936_ _14937_ VDD VSS FA_X1
X_29484_ _14938_ _14939_ _14940_ _14941_ _14942_ VDD VSS FA_X1
X_29485_ _14930_ _14943_ _14874_ _14944_ _14945_ VDD VSS FA_X1
X_29486_ _14890_ _14946_ _14945_ _14947_ _14948_ VDD VSS FA_X1
X_29487_ _14949_ _14950_ _14951_ _14952_ _14953_ VDD VSS FA_X1
X_29488_ _14954_ _14955_ _14956_ _14957_ _14958_ VDD VSS FA_X1
X_29489_ _14958_ _14953_ _14898_ _14959_ _14960_ VDD VSS FA_X1
X_29490_ _14961_ _14962_ _14963_ _14964_ _14965_ VDD VSS FA_X1
X_29491_ _14966_ _14965_ _14911_ _14967_ _14968_ VDD VSS FA_X1
X_29492_ _14906_ _14968_ _14960_ _14969_ _14970_ VDD VSS FA_X1
X_29493_ _14971_ _14972_ _14973_ _14974_ _14975_ VDD VSS FA_X1
X_29494_ _14817_ _14976_ _14920_ _14977_ _14978_ VDD VSS FA_X1
X_29495_ _14978_ _14979_ _14914_ _14980_ _14981_ VDD VSS FA_X1
X_29496_ _14981_ _14970_ _14916_ _14982_ _14983_ VDD VSS FA_X1
X_29497_ _14984_ _14651_ net2 _14985_ _14986_ VDD VSS FA_X1
X_29498_ _14987_ _14880_ _14988_ _14989_ _14990_ VDD VSS FA_X1
X_29499_ _14991_ _14992_ _14993_ _14994_ _14995_ VDD VSS FA_X1
X_29500_ _14929_ _14983_ _14996_ _14997_ _14998_ VDD VSS FA_X1
X_29501_ _14998_ _14944_ _14999_ _15000_ _15001_ VDD VSS FA_X1
X_29502_ _15002_ _15003_ _15004_ _15005_ _15006_ VDD VSS FA_X1
X_29503_ _15007_ _15008_ _15009_ _15010_ _15011_ VDD VSS FA_X1
X_29504_ _15006_ _14952_ _15011_ _15012_ _15013_ VDD VSS FA_X1
X_29505_ _15014_ _15015_ _15016_ _15017_ _15018_ VDD VSS FA_X1
X_29506_ _15018_ _14964_ _14957_ _15019_ _15020_ VDD VSS FA_X1
X_29507_ _15020_ _15013_ _14959_ _15021_ _15022_ VDD VSS FA_X1
X_29508_ _14816_ _14975_ _14974_ _15023_ _15024_ VDD VSS FA_X1
X_29509_ _15025_ _14977_ _14967_ _15026_ _15027_ VDD VSS FA_X1
X_29510_ _15022_ _14969_ _15027_ _15028_ _15029_ VDD VSS FA_X1
X_29511_ _15030_ _14651_ net1 _15031_ _15032_ VDD VSS FA_X1
X_29512_ _15033_ _14880_ _15034_ _15035_ _15036_ VDD VSS FA_X1
X_29513_ _15037_ _15038_ _15039_ _15040_ _15041_ VDD VSS FA_X1
X_29514_ _15042_ _15029_ _14982_ _15043_ _15044_ VDD VSS FA_X1
X_29515_ _15044_ _14997_ _15045_ _15046_ _15047_ VDD VSS FA_X1
X_29516_ _15048_ _15049_ _15050_ _15051_ _15052_ VDD VSS FA_X1
X_29517_ _15053_ _15054_ _15055_ _15056_ _15057_ VDD VSS FA_X1
X_29518_ _15052_ _15057_ _15005_ _15058_ _15059_ VDD VSS FA_X1
X_29519_ _15060_ _15061_ _15016_ _15062_ _15063_ VDD VSS FA_X1
X_29520_ _15017_ _15010_ _15063_ _15064_ _15065_ VDD VSS FA_X1
X_29521_ _15059_ _15012_ _15065_ _15066_ _15067_ VDD VSS FA_X1
X_29522_ _15025_ _15019_ _15068_ _15069_ _15070_ VDD VSS FA_X1
X_29523_ _15021_ _15070_ _15067_ _15071_ _15072_ VDD VSS FA_X1
X_29524_ _14651_ net2 _15073_ _15074_ _15075_ VDD VSS FA_X1
X_29525_ _15076_ _15077_ _14880_ _15078_ _15079_ VDD VSS FA_X1
X_29526_ _15080_ _15081_ _15082_ _15083_ _15084_ VDD VSS FA_X1
X_29527_ _15072_ _15085_ _15028_ _15086_ _15087_ VDD VSS FA_X1
X_29528_ _15087_ _15043_ _15088_ _15089_ _15090_ VDD VSS FA_X1
X_29529_ _15091_ _15092_ _15093_ _15094_ _15095_ VDD VSS FA_X1
X_29530_ _15096_ _15097_ _15098_ _15099_ _15100_ VDD VSS FA_X1
X_29531_ _15100_ _15051_ _15095_ _15101_ _15102_ VDD VSS FA_X1
X_29532_ _15103_ _15104_ _15105_ _15106_ _15107_ VDD VSS FA_X1
X_29533_ _15062_ _15056_ _15108_ _15109_ _15110_ VDD VSS FA_X1
X_29534_ _15058_ _15102_ _15110_ _15111_ _15112_ VDD VSS FA_X1
X_29535_ _15025_ _15064_ _15068_ _15113_ _15114_ VDD VSS FA_X1
X_29536_ _15066_ _15112_ _15114_ _15115_ _15116_ VDD VSS FA_X1
X_29537_ _14651_ _15117_ net1 _15118_ _15119_ VDD VSS FA_X1
X_29538_ _15120_ _15121_ _14880_ _15122_ _15123_ VDD VSS FA_X1
X_29539_ _15124_ _15125_ _15126_ _15127_ _15128_ VDD VSS FA_X1
X_29540_ _15071_ _15116_ _15129_ _15130_ _15131_ VDD VSS FA_X1
X_29541_ _15086_ _15132_ _15131_ _15133_ _15134_ VDD VSS FA_X1
X_29542_ _15135_ _15136_ _15137_ _15138_ _15139_ VDD VSS FA_X1
X_29543_ _15140_ _15141_ _15142_ _15143_ _15144_ VDD VSS FA_X1
X_29544_ _15139_ _15144_ _15094_ _15145_ _15146_ VDD VSS FA_X1
X_29545_ _15099_ _15147_ _15108_ _15148_ _15149_ VDD VSS FA_X1
X_29546_ _15149_ _15146_ _15101_ _15150_ _15151_ VDD VSS FA_X1
X_29547_ _15025_ _15068_ _15109_ _15152_ _15153_ VDD VSS FA_X1
X_29548_ _15153_ _15111_ _15151_ _15154_ _15155_ VDD VSS FA_X1
X_29549_ _15156_ _14651_ net1 _15157_ _15158_ VDD VSS FA_X1
X_29550_ _15159_ _15160_ _14880_ _15161_ _15162_ VDD VSS FA_X1
X_29551_ _15163_ _15164_ _15165_ _15166_ _15167_ VDD VSS FA_X1
X_29552_ _15168_ _15115_ _15155_ _15169_ _15170_ VDD VSS FA_X1
X_29553_ _15130_ _15171_ _15170_ _15172_ _15173_ VDD VSS FA_X1
X_29554_ _15174_ _15175_ _15176_ _15177_ _15178_ VDD VSS FA_X1
X_29555_ _15179_ _15180_ _15142_ _15181_ _15182_ VDD VSS FA_X1
X_29556_ _15178_ _15182_ _15138_ _15183_ _15184_ VDD VSS FA_X1
X_29557_ _15147_ _15143_ _15108_ _15185_ _15186_ VDD VSS FA_X1
X_29558_ _15184_ _15145_ _15186_ _15187_ _15188_ VDD VSS FA_X1
X_29559_ _15025_ _15068_ _15148_ _15189_ _15190_ VDD VSS FA_X1
X_29560_ _15190_ _15188_ _15150_ _15191_ _15192_ VDD VSS FA_X1
X_29561_ _15193_ _14651_ net1 _15194_ _15195_ VDD VSS FA_X1
X_29562_ _15196_ _15197_ _14880_ _15198_ _15199_ VDD VSS FA_X1
X_29563_ _15200_ _15201_ _15202_ _15203_ _15204_ VDD VSS FA_X1
X_29564_ _15192_ _15205_ _15154_ _15206_ _15207_ VDD VSS FA_X1
X_29565_ _15169_ _15208_ _15207_ _15209_ _15210_ VDD VSS FA_X1
X_29566_ _15211_ _15212_ _15213_ _15214_ _15215_ VDD VSS FA_X1
X_29567_ _15216_ _15217_ _15218_ _15219_ _15220_ VDD VSS FA_X1
X_29568_ _15215_ _15177_ _15221_ _15222_ _15223_ VDD VSS FA_X1
X_29569_ _15147_ _15181_ _15108_ _15224_ _15225_ VDD VSS FA_X1
X_29570_ _15223_ _15183_ _15225_ _15226_ _15227_ VDD VSS FA_X1
X_29571_ _15025_ _15185_ _15068_ _15228_ _15229_ VDD VSS FA_X1
X_29572_ _15227_ _15187_ _15229_ _15230_ _15231_ VDD VSS FA_X1
X_29573_ _14651_ net1 _15232_ _15233_ _15234_ VDD VSS FA_X1
X_29574_ _15235_ _15236_ _14880_ _15237_ _15238_ VDD VSS FA_X1
X_29575_ _15239_ _15240_ _15241_ _15242_ _15243_ VDD VSS FA_X1
X_29576_ _15231_ _15244_ _15191_ _15245_ _15246_ VDD VSS FA_X1
X_29577_ _15246_ _15206_ _15247_ _15248_ _15249_ VDD VSS FA_X1
X_29578_ _15250_ _15251_ _15252_ _15253_ _15254_ VDD VSS FA_X1
X_29579_ _15220_ _15255_ _15256_ _15257_ _15258_ VDD VSS FA_X1
X_29580_ _15147_ _15259_ _15108_ _15260_ _15261_ VDD VSS FA_X1
X_29581_ _15262_ _15222_ _15261_ _15263_ _15264_ VDD VSS FA_X1
X_29582_ _15024_ _15266_ _15023_ _15267_ _15268_ VDD VSS FA_X1
X_29583_ _15264_ _15226_ _15269_ _15270_ _15271_ VDD VSS FA_X1
X_29584_ _14651_ _15272_ net1 _15273_ _15274_ VDD VSS FA_X1
X_29585_ _15275_ _15276_ _14880_ _15277_ _15278_ VDD VSS FA_X1
X_29586_ _15279_ _15280_ _15281_ _15282_ _15283_ VDD VSS FA_X1
X_29587_ _15271_ _15230_ _15284_ _15285_ _15286_ VDD VSS FA_X1
X_29588_ _15286_ _15245_ _15287_ _15288_ _15289_ VDD VSS FA_X1
X_29589_ _15251_ _15290_ _15291_ _15292_ _15293_ VDD VSS FA_X1
X_29590_ _15294_ _15295_ _15220_ _15296_ _15297_ VDD VSS FA_X1
X_29591_ _15261_ _15298_ _15299_ _15300_ _15301_ VDD VSS FA_X1
X_29592_ _15024_ _15302_ _15023_ _15303_ _15304_ VDD VSS FA_X1
X_29593_ _15301_ _15263_ _15305_ _15306_ _15307_ VDD VSS FA_X1
X_29594_ _15308_ _14651_ net1 _15309_ _15310_ VDD VSS FA_X1
X_29595_ _15311_ _15312_ _14880_ _15313_ _15314_ VDD VSS FA_X1
X_29596_ _15315_ _15316_ _15267_ _15317_ _15318_ VDD VSS FA_X1
X_29597_ _15307_ _15270_ _15319_ _15320_ _15321_ VDD VSS FA_X1
X_29598_ _15322_ _15321_ _15285_ _15323_ _15324_ VDD VSS FA_X1
X_29599_ _15251_ _15325_ _15291_ _15326_ _15327_ VDD VSS FA_X1
X_29600_ _15220_ _15328_ _15329_ _15330_ _15331_ VDD VSS FA_X1
X_29601_ _15331_ _15296_ _15265_ _15332_ _15333_ VDD VSS FA_X1
X_29602_ _15334_ _15300_ _15305_ _15335_ _15336_ VDD VSS FA_X1
X_29603_ _15337_ _14651_ net1 _15338_ _15339_ VDD VSS FA_X1
X_29604_ _15339_ _15309_ _14815_ _15340_ _15341_ VDD VSS FA_X1
X_29605_ _15342_ _15303_ _15343_ _15344_ _15345_ VDD VSS FA_X1
X_29606_ _15346_ _15336_ _15306_ _15347_ _15348_ VDD VSS FA_X1
X_29607_ _15349_ _15348_ _15320_ _15350_ _15351_ VDD VSS FA_X1
X_29608_ _15352_ _15353_ _15354_ _15355_ _15356_ VDD VSS FA_X1
X_29609_ _15357_ _15358_ _15359_ _15360_ VDD VSS HA_X1
X_29610_ _15357_ _15361_ _15362_ _15363_ VDD VSS HA_X1
X_29611_ _15364_ _15358_ _15365_ _15366_ VDD VSS HA_X1
X_29612_ _15364_ _15361_ _15367_ _15368_ VDD VSS HA_X1
X_29613_ _15369_ _15370_ _15371_ _15372_ VDD VSS HA_X1
X_29614_ _14065_ _14066_ _15373_ _15374_ VDD VSS HA_X1
X_29615_ _15375_ _15376_ _15377_ _15378_ VDD VSS HA_X1
X_29616_ _15379_ _15380_ _15381_ _15382_ VDD VSS HA_X1
X_29617_ _15383_ _15384_ _15385_ _15386_ VDD VSS HA_X1
X_29618_ _15387_ _15388_ _15389_ _15390_ VDD VSS HA_X1
X_29619_ _15391_ _15392_ _15393_ _15394_ VDD VSS HA_X1
X_29620_ _15395_ _15396_ _15397_ _15398_ VDD VSS HA_X1
X_29621_ _15399_ _15400_ _15401_ _15402_ VDD VSS HA_X1
X_29622_ _15403_ _15404_ _15405_ _15406_ VDD VSS HA_X1
X_29623_ _15407_ _15408_ _15409_ _15410_ VDD VSS HA_X1
X_29624_ _15411_ _15412_ _15413_ _15414_ VDD VSS HA_X1
X_29625_ _15415_ _15416_ _15417_ _15418_ VDD VSS HA_X1
X_29626_ _15419_ _15420_ _15421_ _15422_ VDD VSS HA_X1
X_29627_ _15423_ _15424_ _15425_ _15426_ VDD VSS HA_X1
X_29628_ _15427_ _15428_ _15429_ _15430_ VDD VSS HA_X1
X_29629_ _15431_ _15432_ _15433_ _15434_ VDD VSS HA_X1
X_29630_ _15435_ _15436_ _15437_ _15438_ VDD VSS HA_X1
X_29631_ _15439_ _15440_ _15441_ _15442_ VDD VSS HA_X1
X_29632_ _15443_ _15444_ _15445_ _15446_ VDD VSS HA_X1
X_29633_ _15447_ _15448_ _15449_ _15450_ VDD VSS HA_X1
X_29634_ _15451_ _15452_ _15453_ _15454_ VDD VSS HA_X1
X_29635_ _15455_ _15456_ _15457_ _15458_ VDD VSS HA_X1
X_29636_ _15459_ _15460_ _15461_ _15462_ VDD VSS HA_X1
X_29637_ _15463_ _15464_ _15465_ _15466_ VDD VSS HA_X1
X_29638_ _15467_ _15468_ _15469_ _15470_ VDD VSS HA_X1
X_29639_ _15471_ _15472_ _15473_ _15474_ VDD VSS HA_X1
X_29640_ _15475_ _15476_ _15477_ _15478_ VDD VSS HA_X1
X_29641_ _15479_ _15480_ _15481_ _15482_ VDD VSS HA_X1
X_29642_ _15483_ _15484_ _15485_ _15486_ VDD VSS HA_X1
X_29643_ _15487_ _15488_ _15489_ _15490_ VDD VSS HA_X1
X_29644_ _15491_ _15492_ _15493_ _15494_ VDD VSS HA_X1
X_29645_ _15495_ _15496_ _15497_ _15498_ VDD VSS HA_X1
X_29646_ _15499_ _15500_ _15501_ _15502_ VDD VSS HA_X1
X_29647_ _15503_ cs_registers_i.priv_lvl_q\[0\] _15504_ _15505_
+ VDD VSS HA_X1
X_29648_ _15506_ _15507_ _15508_ _15509_ VDD VSS HA_X1
X_29649_ _15510_ _15511_ _15512_ _15513_ VDD VSS HA_X1
X_29650_ _15510_ _15514_ _15515_ _15516_ VDD VSS HA_X1
X_29651_ _15517_ _15511_ _15518_ _15519_ VDD VSS HA_X1
X_29652_ _15517_ _15514_ _15520_ _15521_ VDD VSS HA_X1
X_29653_ _15522_ _15523_ _15524_ _15525_ VDD VSS HA_X1
X_29654_ _15522_ _15526_ _15527_ _15528_ VDD VSS HA_X1
X_29655_ _15529_ _15523_ _15530_ _15531_ VDD VSS HA_X1
X_29656_ cs_registers_i.mhpmcounter\[2\]\[0\] cs_registers_i.mhpmcounter\[2\]\[1\]
+ _15532_ _15533_ VDD VSS HA_X1
X_29657_ cs_registers_i.mcycle_counter_i.counter\[0\] cs_registers_i.mcycle_counter_i.counter\[1\]
+ _15534_ _15535_ VDD VSS HA_X1
X_29658_ cs_registers_i.pc_id_i\[1\] cs_registers_i.pc_id_i\[2\]
+ _15536_ _15537_ VDD VSS HA_X1
X_29659_ _15538_ _15539_ _15540_ _15541_ VDD VSS HA_X1
X_29660_ _15538_ _15539_ _15542_ _15543_ VDD VSS HA_X1
X_29661_ _15538_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]
+ _15544_ _15545_ VDD VSS HA_X1
X_29662_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]
+ _15539_ _15546_ _15547_ VDD VSS HA_X1
X_29663_ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]
+ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]
+ _15548_ _15549_ VDD VSS HA_X1
X_29664_ _15550_ _15551_ _15552_ _15553_ VDD VSS HA_X1
X_29665_ _15552_ _15554_ _15555_ _15556_ VDD VSS HA_X1
X_29666_ _15557_ _15558_ _15559_ _15560_ VDD VSS HA_X1
X_29667_ _15555_ _15560_ _15561_ _15562_ VDD VSS HA_X1
X_29668_ _15563_ _15562_ _15564_ _15565_ VDD VSS HA_X1
X_29669_ _15566_ _15567_ _14094_ _15568_ VDD VSS HA_X1
X_29670_ _15569_ _15570_ _15571_ _15572_ VDD VSS HA_X1
X_29671_ _15572_ _15559_ _15573_ _15574_ VDD VSS HA_X1
X_29672_ _15561_ _15574_ _15575_ _15576_ VDD VSS HA_X1
X_29673_ _15568_ _15576_ _15577_ _15578_ VDD VSS HA_X1
X_29674_ _15564_ _15578_ _15579_ _15580_ VDD VSS HA_X1
X_29675_ _15571_ _14098_ _15581_ _15582_ VDD VSS HA_X1
X_29676_ _15573_ _15582_ _15583_ _15584_ VDD VSS HA_X1
X_29677_ _15584_ _14088_ _15585_ _15586_ VDD VSS HA_X1
X_29678_ _15579_ _15587_ _14124_ _15588_ VDD VSS HA_X1
X_29679_ _15589_ _14108_ _15590_ _15591_ VDD VSS HA_X1
X_29680_ _15592_ _14097_ _15593_ _15594_ VDD VSS HA_X1
X_29681_ _15581_ _15594_ _15595_ _15596_ VDD VSS HA_X1
X_29682_ _15591_ _15596_ _15597_ _15598_ VDD VSS HA_X1
X_29683_ _14122_ _14123_ _15599_ _15600_ VDD VSS HA_X1
X_29684_ _15601_ _15602_ _14155_ _15603_ VDD VSS HA_X1
X_29685_ _15603_ _14131_ _15604_ _15605_ VDD VSS HA_X1
X_29686_ _15590_ _15605_ _15606_ _15607_ VDD VSS HA_X1
X_29687_ _15608_ _15609_ _15610_ _15611_ VDD VSS HA_X1
X_29688_ _15593_ _15611_ _15612_ _15613_ VDD VSS HA_X1
X_29689_ _15613_ _15607_ _15614_ _15615_ VDD VSS HA_X1
X_29690_ _15616_ _15617_ _15618_ _15619_ VDD VSS HA_X1
X_29691_ _15604_ _14158_ _15620_ _15621_ VDD VSS HA_X1
X_29692_ _15622_ _15623_ _15624_ _15625_ VDD VSS HA_X1
X_29693_ _15621_ _15626_ _14204_ _15627_ VDD VSS HA_X1
X_29694_ _15628_ _15629_ _15630_ _15631_ VDD VSS HA_X1
X_29695_ _15632_ _14157_ _15633_ _15634_ VDD VSS HA_X1
X_29696_ _15634_ _15635_ _14236_ _15636_ VDD VSS HA_X1
X_29697_ _15637_ _15638_ _15639_ _15640_ VDD VSS HA_X1
X_29698_ _15641_ _15636_ _14239_ _14203_ VDD VSS HA_X1
X_29699_ _14207_ _15642_ _15643_ _15644_ VDD VSS HA_X1
X_29700_ _15645_ _15646_ _15647_ _15648_ VDD VSS HA_X1
X_29701_ _15649_ _15650_ _15651_ _15652_ VDD VSS HA_X1
X_29702_ _15652_ _15648_ _14276_ _14234_ VDD VSS HA_X1
X_29703_ _15653_ _15654_ _15655_ _15656_ VDD VSS HA_X1
X_29704_ _14242_ _14206_ _15657_ _15658_ VDD VSS HA_X1
X_29705_ _15659_ _15647_ _15660_ _15661_ VDD VSS HA_X1
X_29706_ _15662_ _15663_ _15664_ _15665_ VDD VSS HA_X1
X_29707_ _15665_ _15661_ _14319_ _14274_ VDD VSS HA_X1
X_29708_ _15666_ _15667_ _15668_ _15669_ VDD VSS HA_X1
X_29709_ _14241_ _15670_ _15671_ _15672_ VDD VSS HA_X1
X_29710_ _15673_ _15674_ _15675_ _15676_ VDD VSS HA_X1
X_29711_ _15676_ _15677_ _14347_ _15678_ VDD VSS HA_X1
X_29712_ _15679_ _15678_ _14365_ _14317_ VDD VSS HA_X1
X_29713_ _15680_ _15681_ _14362_ _15682_ VDD VSS HA_X1
X_29714_ _15684_ _15683_ _15685_ _15686_ VDD VSS HA_X1
X_29715_ _15687_ _15688_ _15689_ _15690_ VDD VSS HA_X1
X_29716_ _15691_ _15692_ _15693_ _15694_ VDD VSS HA_X1
X_29717_ _15690_ _15694_ _14401_ _14348_ VDD VSS HA_X1
X_29718_ _15695_ _15696_ _14416_ _14360_ VDD VSS HA_X1
X_29719_ _15698_ _15697_ _15699_ _15700_ VDD VSS HA_X1
X_29720_ _14376_ _15701_ _14456_ _14402_ VDD VSS HA_X1
X_29721_ _15702_ _15703_ _14471_ _14414_ VDD VSS HA_X1
X_29722_ _15704_ _15705_ _15706_ _15707_ VDD VSS HA_X1
X_29723_ _15708_ _15709_ _14494_ _15710_ VDD VSS HA_X1
X_29724_ _15711_ _15710_ _14514_ _14458_ VDD VSS HA_X1
X_29725_ _15712_ _15713_ _14528_ _14469_ VDD VSS HA_X1
X_29726_ _15714_ _15715_ _15716_ _15717_ VDD VSS HA_X1
X_29727_ _15718_ _15719_ _14550_ _15720_ VDD VSS HA_X1
X_29728_ _15720_ _14486_ _14562_ _14495_ VDD VSS HA_X1
X_29729_ _15721_ _15722_ _14599_ _14526_ VDD VSS HA_X1
X_29730_ _15724_ _15723_ _15725_ _15726_ VDD VSS HA_X1
X_29731_ _15728_ _15727_ _15729_ _15730_ VDD VSS HA_X1
X_29732_ _14651_ net1 _15731_ _15732_ VDD VSS HA_X1
X_29733_ _15733_ _15734_ _14718_ _15735_ VDD VSS HA_X1
X_29734_ _15736_ _15737_ _15738_ _15739_ VDD VSS HA_X1
X_29735_ _15740_ _15741_ _14776_ _14719_ VDD VSS HA_X1
X_29736_ _15743_ _15742_ _15744_ _15745_ VDD VSS HA_X1
X_29737_ _15746_ _15747_ _14832_ _14774_ VDD VSS HA_X1
X_29738_ _15748_ _15749_ _15750_ _15751_ VDD VSS HA_X1
X_29739_ _15752_ _15753_ _14886_ _14833_ VDD VSS HA_X1
X_29740_ _15754_ _15755_ _15756_ _15757_ VDD VSS HA_X1
X_29741_ _15758_ _15759_ _14939_ _14884_ VDD VSS HA_X1
X_29742_ _15760_ _15761_ _15762_ _15763_ VDD VSS HA_X1
X_29743_ _15764_ _15765_ _14992_ _14940_ VDD VSS HA_X1
X_29744_ _15766_ _15767_ _15768_ _15769_ VDD VSS HA_X1
X_29745_ _15770_ _15771_ _15038_ _14993_ VDD VSS HA_X1
X_29746_ _15772_ _15773_ _15774_ _15775_ VDD VSS HA_X1
X_29747_ _15776_ _15777_ _15080_ _15037_ VDD VSS HA_X1
X_29748_ _15778_ _15779_ _15780_ _15781_ VDD VSS HA_X1
X_29749_ _15782_ _15783_ _15124_ _15082_ VDD VSS HA_X1
X_29750_ _15784_ _15785_ _15786_ _15787_ VDD VSS HA_X1
X_29751_ _15788_ _15789_ _15164_ _15126_ VDD VSS HA_X1
X_29752_ _15790_ _15791_ _15792_ _15793_ VDD VSS HA_X1
X_29753_ _15794_ _15795_ _15201_ _15165_ VDD VSS HA_X1
X_29754_ _15796_ _15797_ _15798_ _15799_ VDD VSS HA_X1
X_29755_ _15800_ _15801_ _15241_ _15202_ VDD VSS HA_X1
X_29756_ _15802_ _15803_ _15804_ _15805_ VDD VSS HA_X1
X_29757_ _15806_ _15807_ _15281_ _15239_ VDD VSS HA_X1
X_29758_ _15808_ _15809_ _15810_ _15811_ VDD VSS HA_X1
X_29759_ _15812_ _15813_ _15316_ _15280_ VDD VSS HA_X1
X_29760_ _15814_ _15815_ _15816_ _15817_ VDD VSS HA_X1
X_29761_ _15818_ _15819_ _15343_ _15315_ VDD VSS HA_X1
X_29762_ _15820_ _15821_ _15822_ _15823_ VDD VSS HA_X1
X_29763_ _15824_ _15825_ _15826_ _15342_ VDD VSS HA_X1
X_29764_ _15827_ _15828_ _15829_ _15830_ VDD VSS HA_X1
X_29765_ cs_registers_i.pc_if_i\[2\] _15831_ _15832_ _15833_
+ VDD VSS HA_X1
X_29766_ _15834_ _15835_ _15836_ _15837_ VDD VSS HA_X1
X_29767_ _15835_ _15838_ _15839_ _15840_ VDD VSS HA_X1
X_29768_ _15841_ _15842_ _15843_ _15844_ VDD VSS HA_X1
X_29769_ _15845_ _15846_ _15847_ _15848_ VDD VSS HA_X1
X_29770_ _15849_ _15834_ _15850_ _15851_ VDD VSS HA_X1
X_29771_ _15852_ _15853_ _15854_ _15855_ VDD VSS HA_X1
X_29772_ _15856_ _15857_ _15858_ _15859_ VDD VSS HA_X1
X_29773_ _15860_ _15861_ _15862_ _15863_ VDD VSS HA_X1
X_29774_ _15864_ _15865_ _15866_ _15867_ VDD VSS HA_X1
X_29775_ _15868_ _15869_ _15870_ _15871_ VDD VSS HA_X1
X_29776_ _15872_ _15873_ _15874_ _15875_ VDD VSS HA_X1
X_29777_ _15876_ _15877_ _15878_ _15879_ VDD VSS HA_X1
X_29778_ _15880_ _15881_ _15882_ _15883_ VDD VSS HA_X1
X_29779_ _15884_ _15885_ _15886_ _15887_ VDD VSS HA_X1
X_29780_ _15888_ _15889_ _15890_ _15891_ VDD VSS HA_X1
X_29781_ _15892_ _15893_ _15894_ _15895_ VDD VSS HA_X1
X_29782_ _15896_ _15897_ _15898_ _15899_ VDD VSS HA_X1
X_29783_ _15900_ _15901_ _15902_ _15903_ VDD VSS HA_X1
X_29784_ _15904_ _15905_ _15906_ _15907_ VDD VSS HA_X1
X_29785_ _15908_ _15909_ _15910_ _15911_ VDD VSS HA_X1
X_29786_ _15912_ _15913_ _15914_ _15915_ VDD VSS HA_X1
X_29787_ _15916_ _15917_ _15918_ _15919_ VDD VSS HA_X1
X_29788_ _15920_ _15921_ _15922_ _15923_ VDD VSS HA_X1
X_29789_ _15924_ _15925_ _15926_ _15927_ VDD VSS HA_X1
X_29790_ _15928_ _15929_ _15930_ _15931_ VDD VSS HA_X1
X_29791_ _15932_ _15933_ _15934_ _15935_ VDD VSS HA_X1
X_29792_ _15936_ net301 _15938_ _15939_ VDD VSS HA_X1
X_29793_ _15940_ _15941_ _15942_ _15943_ VDD VSS HA_X1
X_29794_ _15944_ _15945_ _15946_ _15947_ VDD VSS HA_X1
X_29795_ _15948_ _15949_ _15950_ _15951_ VDD VSS HA_X1
X_29796_ _15952_ _15953_ _15954_ _15955_ VDD VSS HA_X1
X_29797_ _15956_ _15957_ _15958_ _15959_ VDD VSS HA_X1
X_29798_ _15960_ _15961_ _15962_ _15963_ VDD VSS HA_X1
X_29799_ _15964_ _15965_ _15966_ _15967_ VDD VSS HA_X1
X_29800_ _15968_ _15969_ _15970_ _15971_ VDD VSS HA_X1
X_29801_ _15972_ _15973_ _15974_ _15975_ VDD VSS HA_X1
X_29802_ _15976_ _15977_ _15978_ _15979_ VDD VSS HA_X1
X_29803_ _15980_ _15981_ _15982_ _15983_ VDD VSS HA_X1
X_29804_ _15984_ _15985_ _15986_ _15987_ VDD VSS HA_X1
X_29805_ _15988_ _15989_ _15990_ _15991_ VDD VSS HA_X1
X_29806_ _15992_ _15993_ _15994_ _15995_ VDD VSS HA_X1
X_29807_ _15996_ _15997_ _15998_ _15999_ VDD VSS HA_X1
X_29808_ _16000_ _16001_ _16002_ _16003_ VDD VSS HA_X1
X_29809_ _16004_ _16005_ _16006_ _16007_ VDD VSS HA_X1
X_29810_ _16008_ _16009_ _16010_ _16011_ VDD VSS HA_X1
X_29811_ _16012_ _16013_ _16014_ _16015_ VDD VSS HA_X1
X_29812_ _16016_ _16017_ _16018_ _16019_ VDD VSS HA_X1
X_29813_ _16020_ _16021_ _16022_ _16023_ VDD VSS HA_X1
X_29814_ _16024_ _16025_ _16026_ _16027_ VDD VSS HA_X1
X_29815_ _16028_ _16029_ _16030_ _16031_ VDD VSS HA_X1
X_29816_ _16032_ _16033_ _16034_ _16035_ VDD VSS HA_X1
X_29817_ _16036_ _16037_ _16038_ _16039_ VDD VSS HA_X1
X_29818_ _16040_ _16041_ _16042_ _16043_ VDD VSS HA_X1
X_29819_ _16044_ _16045_ _16046_ _16047_ VDD VSS HA_X1
X_29820_ _16048_ _16049_ _16050_ _16051_ VDD VSS HA_X1
X_29821_ _16052_ _16053_ _16054_ _16055_ VDD VSS HA_X1
X_29822_ _16056_ _16057_ _16058_ _16059_ VDD VSS HA_X1
X_29823_ _16060_ _16061_ _16062_ _16063_ VDD VSS HA_X1
X_29824_ _16064_ _16065_ _16066_ _16067_ VDD VSS HA_X1
X_29825_ _16068_ _16069_ _16070_ _16071_ VDD VSS HA_X1
X_29826_ _16072_ _16073_ _16074_ _16075_ VDD VSS HA_X1
X_29827_ _16076_ _16077_ _16078_ _16079_ VDD VSS HA_X1
X_29828_ _16080_ _16081_ _16082_ _16083_ VDD VSS HA_X1
X_29829_ _16084_ _16085_ _16086_ _16087_ VDD VSS HA_X1
X_29830_ net247 _16085_ _16088_ _16089_ VDD VSS HA_X1
X_29831_ _16090_ _16085_ _16091_ _16092_ VDD VSS HA_X1
X_29832_ net247 alu_adder_result_ex\[0\] _16093_ _16094_ VDD
+ VSS HA_X1
X_29833_ net247 alu_adder_result_ex\[0\] _16095_ _16096_ VDD
+ VSS HA_X1
X_29834_ net247 _14068_ _16097_ _16098_ VDD VSS HA_X1
X_29835_ alu_adder_result_ex\[1\] _14068_ _16099_ _16100_
+ VDD VSS HA_X1
X_29836_ _16090_ alu_adder_result_ex\[0\] _16101_ _16102_
+ VDD VSS HA_X1
X_29837_ _16090_ alu_adder_result_ex\[0\] _16103_ _16104_
+ VDD VSS HA_X1
X_29838_ _16090_ _14068_ _16105_ _16106_ VDD VSS HA_X1
X_29839_ _16107_ _16108_ _16109_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_d\[2\]
+ VDD VSS HA_X1
X_29840_ _16109_ _16110_ _16111_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_d\[3\]
+ VDD VSS HA_X1
X_29841_ _01680_ net258 clknet_leaf_5_clk load_store_unit_i.data_type_q\[2\]
+ _14049_ VDD VSS DFFR_X1
X_29842_ _01681_ net258 clknet_leaf_5_clk load_store_unit_i.data_type_q\[1\]
+ _14048_ VDD VSS DFFR_X1
X_29843_ _01682_ net263 clknet_leaf_21_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[2\]
+ _14047_ VDD VSS DFFR_X2
X_29844_ _01683_ net263 clknet_leaf_23_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[1\]
+ _14046_ VDD VSS DFFR_X1
X_29845_ _01684_ net263 clknet_leaf_25_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[5\]
+ _00179_ VDD VSS DFFR_X2
X_29846_ _01685_ net264 clknet_leaf_33_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[2\]
+ _14045_ VDD VSS DFFR_X1
X_29847_ _01686_ net264 clknet_leaf_33_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[0\]
+ _14050_ VDD VSS DFFS_X1
Xclkbuf_regs_0_core_clock clk_i delaynet_0_core_clock VDD
+ VSS CLKBUF_X3
X_29849_ net266 alert_major_o VDD VSS BUF_X1
X_29850_ net267 alert_minor_o VDD VSS BUF_X1
X_29851_ net268 data_addr_o[0] VDD VSS BUF_X1
X_29852_ net269 data_addr_o[1] VDD VSS BUF_X1
X_29853_ alu_adder_result_ex\[2\] net167 VDD VSS BUF_X1
X_29854_ alu_adder_result_ex\[3\] net170 VDD VSS BUF_X1
X_29855_ alu_adder_result_ex\[4\] net171 VDD VSS BUF_X1
X_29856_ alu_adder_result_ex\[5\] net172 VDD VSS BUF_X1
X_29857_ alu_adder_result_ex\[6\] net173 VDD VSS BUF_X1
X_29858_ alu_adder_result_ex\[7\] net174 VDD VSS BUF_X1
X_29859_ alu_adder_result_ex\[8\] net175 VDD VSS BUF_X1
X_29860_ alu_adder_result_ex\[9\] net176 VDD VSS BUF_X1
X_29861_ net404 net147 VDD VSS BUF_X1
X_29862_ alu_adder_result_ex\[11\] net148 VDD VSS BUF_X1
X_29863_ alu_adder_result_ex\[12\] net149 VDD VSS BUF_X1
X_29864_ alu_adder_result_ex\[13\] net150 VDD VSS BUF_X1
X_29865_ net394 net151 VDD VSS BUF_X1
X_29866_ alu_adder_result_ex\[15\] net152 VDD VSS BUF_X1
X_29867_ alu_adder_result_ex\[16\] net153 VDD VSS BUF_X1
X_29868_ alu_adder_result_ex\[17\] net154 VDD VSS BUF_X1
X_29869_ net379 net155 VDD VSS BUF_X1
X_29870_ alu_adder_result_ex\[19\] net156 VDD VSS BUF_X1
X_29871_ alu_adder_result_ex\[20\] net157 VDD VSS BUF_X1
X_29872_ alu_adder_result_ex\[21\] net158 VDD VSS BUF_X1
X_29873_ alu_adder_result_ex\[22\] net159 VDD VSS BUF_X1
X_29874_ net393 net160 VDD VSS BUF_X1
X_29875_ alu_adder_result_ex\[24\] net161 VDD VSS BUF_X1
X_29876_ alu_adder_result_ex\[25\] net162 VDD VSS BUF_X1
X_29877_ net397 net163 VDD VSS BUF_X1
X_29878_ alu_adder_result_ex\[27\] net164 VDD VSS BUF_X1
X_29879_ alu_adder_result_ex\[28\] net165 VDD VSS BUF_X1
X_29880_ net246 net166 VDD VSS BUF_X1
X_29881_ alu_adder_result_ex\[30\] net168 VDD VSS BUF_X1
X_29882_ alu_adder_result_ex\[31\] net169 VDD VSS BUF_X1
X_29883_ net270 instr_addr_o[0] VDD VSS BUF_X1
X_29884_ net271 instr_addr_o[1] VDD VSS BUF_X1
Xcore_busy_q$_DFF_PN0_ core_busy_d net144 clknet_leaf_118_clk_i_regs
+ core_busy_q _14044_ VDD VSS DFFR_X1
Xcore_clock_gate_i.en_latch$_DLATCH_N_ _00006_ clknet_leaf_117_clk_i_regs
+ core_clock_gate_i.en_latch VDD VSS DLL_X1
Xcs_registers_i.mcountinhibit_q\[0\]$_DFFE_PN0P_ _01687_ net262
+ clknet_leaf_108_clk cs_registers_i.mcountinhibit\[0\] _00553_
+ VDD VSS DFFR_X1
Xcs_registers_i.mcountinhibit_q\[2\]$_DFFE_PN0P_ _01688_ net262
+ clknet_leaf_108_clk cs_registers_i.mcountinhibit\[2\] _01159_
+ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[0\]$_DFFE_PN0P_
+ _01689_ net261 clknet_leaf_118_clk cs_registers_i.mcycle_counter_i.counter\[0\]
+ _00551_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[10\]$_DFFE_PN0P_
+ _01690_ net261 clknet_leaf_106_clk cs_registers_i.mcycle_counter_i.counter\[10\]
+ _14043_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[11\]$_DFFE_PN0P_
+ _01691_ net261 clknet_leaf_120_clk cs_registers_i.mcycle_counter_i.counter\[11\]
+ _14042_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[12\]$_DFFE_PN0P_
+ _01692_ net261 clknet_leaf_121_clk cs_registers_i.mcycle_counter_i.counter\[12\]
+ _14041_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[13\]$_DFFE_PN0P_
+ _01693_ net261 clknet_leaf_106_clk cs_registers_i.mcycle_counter_i.counter\[13\]
+ _14040_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[14\]$_DFFE_PN0P_
+ _01694_ net261 clknet_leaf_121_clk cs_registers_i.mcycle_counter_i.counter\[14\]
+ _14039_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[15\]$_DFFE_PN0P_
+ _01695_ net144 clknet_leaf_121_clk cs_registers_i.mcycle_counter_i.counter\[15\]
+ _14038_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[16\]$_DFFE_PN0P_
+ _01696_ net144 clknet_leaf_119_clk cs_registers_i.mcycle_counter_i.counter\[16\]
+ _14037_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[17\]$_DFFE_PN0P_
+ _01697_ net144 clknet_leaf_119_clk cs_registers_i.mcycle_counter_i.counter\[17\]
+ _14036_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[18\]$_DFFE_PN0P_
+ _01698_ net144 clknet_leaf_128_clk cs_registers_i.mcycle_counter_i.counter\[18\]
+ _14035_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[19\]$_DFFE_PN0P_
+ _01699_ net144 clknet_leaf_128_clk cs_registers_i.mcycle_counter_i.counter\[19\]
+ _14034_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[1\]$_DFFE_PN0P_
+ _01700_ net261 clknet_leaf_119_clk cs_registers_i.mcycle_counter_i.counter\[1\]
+ _14033_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[20\]$_DFFE_PN0P_
+ _01701_ net144 clknet_leaf_124_clk cs_registers_i.mcycle_counter_i.counter\[20\]
+ _14032_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[21\]$_DFFE_PN0P_
+ _01702_ net144 clknet_leaf_128_clk cs_registers_i.mcycle_counter_i.counter\[21\]
+ _14031_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[22\]$_DFFE_PN0P_
+ _01703_ net144 clknet_leaf_121_clk cs_registers_i.mcycle_counter_i.counter\[22\]
+ _14030_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[23\]$_DFFE_PN0P_
+ _01704_ net144 clknet_leaf_128_clk cs_registers_i.mcycle_counter_i.counter\[23\]
+ _14029_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[24\]$_DFFE_PN0P_
+ _01705_ net144 clknet_leaf_121_clk cs_registers_i.mcycle_counter_i.counter\[24\]
+ _14028_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[25\]$_DFFE_PN0P_
+ _01706_ net144 clknet_leaf_121_clk cs_registers_i.mcycle_counter_i.counter\[25\]
+ _14027_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[26\]$_DFFE_PN0P_
+ _01707_ net261 clknet_leaf_106_clk cs_registers_i.mcycle_counter_i.counter\[26\]
+ _14026_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[27\]$_DFFE_PN0P_
+ _01708_ net262 clknet_leaf_106_clk cs_registers_i.mcycle_counter_i.counter\[27\]
+ _14025_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[28\]$_DFFE_PN0P_
+ _01709_ net144 clknet_leaf_105_clk cs_registers_i.mcycle_counter_i.counter\[28\]
+ _14024_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[29\]$_DFFE_PN0P_
+ _01710_ net262 clknet_leaf_105_clk cs_registers_i.mcycle_counter_i.counter\[29\]
+ _14023_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[2\]$_DFFE_PN0P_
+ _01711_ net261 clknet_leaf_129_clk cs_registers_i.mcycle_counter_i.counter\[2\]
+ _14022_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[30\]$_DFFE_PN0P_
+ _01712_ net262 clknet_leaf_106_clk cs_registers_i.mcycle_counter_i.counter\[30\]
+ _14021_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[31\]$_DFFE_PN0P_
+ _01713_ net144 clknet_leaf_105_clk cs_registers_i.mcycle_counter_i.counter\[31\]
+ _14020_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[32\]$_DFFE_PN0P_
+ _01714_ net144 clknet_leaf_122_clk cs_registers_i.mcycle_counter_i.counter\[32\]
+ _14019_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[33\]$_DFFE_PN0P_
+ _01715_ net144 clknet_leaf_124_clk cs_registers_i.mcycle_counter_i.counter\[33\]
+ _14018_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[34\]$_DFFE_PN0P_
+ _01716_ net144 clknet_leaf_124_clk cs_registers_i.mcycle_counter_i.counter\[34\]
+ _14017_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[35\]$_DFFE_PN0P_
+ _01717_ net144 clknet_leaf_123_clk cs_registers_i.mcycle_counter_i.counter\[35\]
+ _14016_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[36\]$_DFFE_PN0P_
+ _01718_ net144 clknet_leaf_123_clk cs_registers_i.mcycle_counter_i.counter\[36\]
+ _14015_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[37\]$_DFFE_PN0P_
+ _01719_ net144 clknet_leaf_124_clk cs_registers_i.mcycle_counter_i.counter\[37\]
+ _14014_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[38\]$_DFFE_PN0P_
+ _01720_ net144 clknet_leaf_123_clk cs_registers_i.mcycle_counter_i.counter\[38\]
+ _14013_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[39\]$_DFFE_PN0P_
+ _01721_ net144 clknet_leaf_125_clk cs_registers_i.mcycle_counter_i.counter\[39\]
+ _14012_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[3\]$_DFFE_PN0P_
+ _01722_ net261 clknet_leaf_118_clk cs_registers_i.mcycle_counter_i.counter\[3\]
+ _14011_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[40\]$_DFFE_PN0P_
+ _01723_ net144 clknet_leaf_123_clk cs_registers_i.mcycle_counter_i.counter\[40\]
+ _14010_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[41\]$_DFFE_PN0P_
+ _01724_ net144 clknet_leaf_123_clk cs_registers_i.mcycle_counter_i.counter\[41\]
+ _14009_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[42\]$_DFFE_PN0P_
+ _01725_ net144 clknet_leaf_123_clk cs_registers_i.mcycle_counter_i.counter\[42\]
+ _14008_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[43\]$_DFFE_PN0P_
+ _01726_ net144 clknet_leaf_123_clk cs_registers_i.mcycle_counter_i.counter\[43\]
+ _14007_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[44\]$_DFFE_PN0P_
+ _01727_ net144 clknet_leaf_122_clk cs_registers_i.mcycle_counter_i.counter\[44\]
+ _14006_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[45\]$_DFFE_PN0P_
+ _01728_ net144 clknet_leaf_123_clk cs_registers_i.mcycle_counter_i.counter\[45\]
+ _14005_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[46\]$_DFFE_PN0P_
+ _01729_ net144 clknet_leaf_122_clk cs_registers_i.mcycle_counter_i.counter\[46\]
+ _14004_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[47\]$_DFFE_PN0P_
+ _01730_ net144 clknet_leaf_122_clk cs_registers_i.mcycle_counter_i.counter\[47\]
+ _14003_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[48\]$_DFFE_PN0P_
+ _01731_ net144 clknet_leaf_122_clk cs_registers_i.mcycle_counter_i.counter\[48\]
+ _14002_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[49\]$_DFFE_PN0P_
+ _01732_ net144 clknet_leaf_122_clk cs_registers_i.mcycle_counter_i.counter\[49\]
+ _14001_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[4\]$_DFFE_PN0P_
+ _01733_ net261 clknet_leaf_118_clk cs_registers_i.mcycle_counter_i.counter\[4\]
+ _14000_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[50\]$_DFFE_PN0P_
+ _01734_ net144 clknet_leaf_104_clk cs_registers_i.mcycle_counter_i.counter\[50\]
+ _13999_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[51\]$_DFFE_PN0P_
+ _01735_ net144 clknet_leaf_104_clk cs_registers_i.mcycle_counter_i.counter\[51\]
+ _13998_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[52\]$_DFFE_PN0P_
+ _01736_ net144 clknet_leaf_104_clk cs_registers_i.mcycle_counter_i.counter\[52\]
+ _13997_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[53\]$_DFFE_PN0P_
+ _01737_ net144 clknet_leaf_104_clk cs_registers_i.mcycle_counter_i.counter\[53\]
+ _13996_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[54\]$_DFFE_PN0P_
+ _01738_ net144 clknet_leaf_104_clk cs_registers_i.mcycle_counter_i.counter\[54\]
+ _13995_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[55\]$_DFFE_PN0P_
+ _01739_ net144 clknet_leaf_104_clk cs_registers_i.mcycle_counter_i.counter\[55\]
+ _13994_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[56\]$_DFFE_PN0P_
+ _01740_ net144 clknet_leaf_103_clk cs_registers_i.mcycle_counter_i.counter\[56\]
+ _13993_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[57\]$_DFFE_PN0P_
+ _01741_ net144 clknet_leaf_103_clk cs_registers_i.mcycle_counter_i.counter\[57\]
+ _13992_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[58\]$_DFFE_PN0P_
+ _01742_ net144 clknet_leaf_103_clk cs_registers_i.mcycle_counter_i.counter\[58\]
+ _13991_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[59\]$_DFFE_PN0P_
+ _01743_ net144 clknet_leaf_103_clk cs_registers_i.mcycle_counter_i.counter\[59\]
+ _13990_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[5\]$_DFFE_PN0P_
+ _01744_ net261 clknet_leaf_118_clk cs_registers_i.mcycle_counter_i.counter\[5\]
+ _13989_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[60\]$_DFFE_PN0P_
+ _01745_ net144 clknet_leaf_102_clk cs_registers_i.mcycle_counter_i.counter\[60\]
+ _13988_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[61\]$_DFFE_PN0P_
+ _01746_ net144 clknet_leaf_105_clk cs_registers_i.mcycle_counter_i.counter\[61\]
+ _13987_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[62\]$_DFFE_PN0P_
+ _01747_ net144 clknet_leaf_104_clk cs_registers_i.mcycle_counter_i.counter\[62\]
+ _13986_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[63\]$_DFFE_PN0P_
+ _01748_ net144 clknet_leaf_105_clk cs_registers_i.mcycle_counter_i.counter\[63\]
+ _13985_ VDD VSS DFFR_X2
Xcs_registers_i.mcycle_counter_i.counter_q\[6\]$_DFFE_PN0P_
+ _01749_ net261 clknet_leaf_119_clk cs_registers_i.mcycle_counter_i.counter\[6\]
+ _13984_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[7\]$_DFFE_PN0P_
+ _01750_ net261 clknet_leaf_119_clk cs_registers_i.mcycle_counter_i.counter\[7\]
+ _13983_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[8\]$_DFFE_PN0P_
+ _01751_ net261 clknet_leaf_119_clk cs_registers_i.mcycle_counter_i.counter\[8\]
+ _13982_ VDD VSS DFFR_X1
Xcs_registers_i.mcycle_counter_i.counter_q\[9\]$_DFFE_PN0P_
+ _01752_ net261 clknet_leaf_120_clk cs_registers_i.mcycle_counter_i.counter\[9\]
+ _13981_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[0\]$_DFFE_PN0P_
+ _01753_ net261 clknet_leaf_114_clk cs_registers_i.mhpmcounter\[2\]\[0\]
+ _00552_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[10\]$_DFFE_PN0P_
+ _01754_ net262 clknet_leaf_114_clk cs_registers_i.mhpmcounter\[2\]\[10\]
+ _13980_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[11\]$_DFFE_PN0P_
+ _01755_ net262 clknet_leaf_114_clk cs_registers_i.mhpmcounter\[2\]\[11\]
+ _13979_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[12\]$_DFFE_PN0P_
+ _01756_ net262 clknet_leaf_107_clk cs_registers_i.mhpmcounter\[2\]\[12\]
+ _13978_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[13\]$_DFFE_PN0P_
+ _01757_ net262 clknet_leaf_107_clk cs_registers_i.mhpmcounter\[2\]\[13\]
+ _13977_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[14\]$_DFFE_PN0P_
+ _01758_ net262 clknet_leaf_112_clk cs_registers_i.mhpmcounter\[2\]\[14\]
+ _13976_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[15\]$_DFFE_PN0P_
+ _01759_ net262 clknet_leaf_112_clk cs_registers_i.mhpmcounter\[2\]\[15\]
+ _13975_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[16\]$_DFFE_PN0P_
+ _01760_ net262 clknet_leaf_107_clk cs_registers_i.mhpmcounter\[2\]\[16\]
+ _13974_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[17\]$_DFFE_PN0P_
+ _01761_ net262 clknet_leaf_108_clk cs_registers_i.mhpmcounter\[2\]\[17\]
+ _13973_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[18\]$_DFFE_PN0P_
+ _01762_ net262 clknet_leaf_100_clk cs_registers_i.mhpmcounter\[2\]\[18\]
+ _13972_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[19\]$_DFFE_PN0P_
+ _01763_ net144 clknet_leaf_100_clk cs_registers_i.mhpmcounter\[2\]\[19\]
+ _13971_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[1\]$_DFFE_PN0P_
+ _01764_ net261 clknet_leaf_120_clk cs_registers_i.mhpmcounter\[2\]\[1\]
+ _13970_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[20\]$_DFFE_PN0P_
+ _01765_ net262 clknet_leaf_100_clk cs_registers_i.mhpmcounter\[2\]\[20\]
+ _13969_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[21\]$_DFFE_PN0P_
+ _01766_ net262 clknet_leaf_108_clk cs_registers_i.mhpmcounter\[2\]\[21\]
+ _13968_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[22\]$_DFFE_PN0P_
+ _01767_ net262 clknet_leaf_107_clk cs_registers_i.mhpmcounter\[2\]\[22\]
+ _13967_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[23\]$_DFFE_PN0P_
+ _01768_ net262 clknet_leaf_99_clk cs_registers_i.mhpmcounter\[2\]\[23\]
+ _13966_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[24\]$_DFFE_PN0P_
+ _01769_ net262 clknet_leaf_99_clk cs_registers_i.mhpmcounter\[2\]\[24\]
+ _13965_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[25\]$_DFFE_PN0P_
+ _01770_ net144 clknet_leaf_100_clk cs_registers_i.mhpmcounter\[2\]\[25\]
+ _13964_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[26\]$_DFFE_PN0P_
+ _01771_ net262 clknet_leaf_105_clk cs_registers_i.mhpmcounter\[2\]\[26\]
+ _13963_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[27\]$_DFFE_PN0P_
+ _01772_ net144 clknet_leaf_103_clk cs_registers_i.mhpmcounter\[2\]\[27\]
+ _13962_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[28\]$_DFFE_PN0P_
+ _01773_ net262 clknet_leaf_99_clk cs_registers_i.mhpmcounter\[2\]\[28\]
+ _13961_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[29\]$_DFFE_PN0P_
+ _01774_ net262 clknet_leaf_107_clk cs_registers_i.mhpmcounter\[2\]\[29\]
+ _13960_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[2\]$_DFFE_PN0P_
+ _01775_ net262 clknet_leaf_114_clk cs_registers_i.mhpmcounter\[2\]\[2\]
+ _13959_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[30\]$_DFFE_PN0P_
+ _01776_ net262 clknet_leaf_106_clk cs_registers_i.mhpmcounter\[2\]\[30\]
+ _13958_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[31\]$_DFFE_PN0P_
+ _01777_ net262 clknet_leaf_99_clk cs_registers_i.mhpmcounter\[2\]\[31\]
+ _13957_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[32\]$_DFFE_PN0P_
+ _01778_ net262 clknet_leaf_99_clk cs_registers_i.mhpmcounter\[2\]\[32\]
+ _13956_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[33\]$_DFFE_PN0P_
+ _01779_ net144 clknet_leaf_100_clk cs_registers_i.mhpmcounter\[2\]\[33\]
+ _13955_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[34\]$_DFFE_PN0P_
+ _01780_ net144 clknet_leaf_100_clk cs_registers_i.mhpmcounter\[2\]\[34\]
+ _13954_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[35\]$_DFFE_PN0P_
+ _01781_ net144 clknet_leaf_94_clk cs_registers_i.mhpmcounter\[2\]\[35\]
+ _13953_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[36\]$_DFFE_PN0P_
+ _01782_ net262 clknet_leaf_94_clk cs_registers_i.mhpmcounter\[2\]\[36\]
+ _13952_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[37\]$_DFFE_PN0P_
+ _01783_ net144 clknet_leaf_94_clk cs_registers_i.mhpmcounter\[2\]\[37\]
+ _13951_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[38\]$_DFFE_PN0P_
+ _01784_ net144 clknet_leaf_93_clk cs_registers_i.mhpmcounter\[2\]\[38\]
+ _13950_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[39\]$_DFFE_PN0P_
+ _01785_ net144 clknet_leaf_93_clk cs_registers_i.mhpmcounter\[2\]\[39\]
+ _13949_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[3\]$_DFFE_PN0P_
+ _01786_ net262 clknet_leaf_114_clk cs_registers_i.mhpmcounter\[2\]\[3\]
+ _13948_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[40\]$_DFFE_PN0P_
+ _01787_ net144 clknet_leaf_93_clk cs_registers_i.mhpmcounter\[2\]\[40\]
+ _13947_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[41\]$_DFFE_PN0P_
+ _01788_ net144 clknet_leaf_93_clk cs_registers_i.mhpmcounter\[2\]\[41\]
+ _13946_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[42\]$_DFFE_PN0P_
+ _01789_ net144 clknet_leaf_92_clk cs_registers_i.mhpmcounter\[2\]\[42\]
+ _13945_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[43\]$_DFFE_PN0P_
+ _01790_ net144 clknet_leaf_92_clk cs_registers_i.mhpmcounter\[2\]\[43\]
+ _13944_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[44\]$_DFFE_PN0P_
+ _01791_ net144 clknet_leaf_92_clk cs_registers_i.mhpmcounter\[2\]\[44\]
+ _13943_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[45\]$_DFFE_PN0P_
+ _01792_ net144 clknet_leaf_92_clk cs_registers_i.mhpmcounter\[2\]\[45\]
+ _13942_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[46\]$_DFFE_PN0P_
+ _01793_ net144 clknet_leaf_93_clk cs_registers_i.mhpmcounter\[2\]\[46\]
+ _13941_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[47\]$_DFFE_PN0P_
+ _01794_ net144 clknet_leaf_93_clk cs_registers_i.mhpmcounter\[2\]\[47\]
+ _13940_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[48\]$_DFFE_PN0P_
+ _01795_ net144 clknet_leaf_93_clk cs_registers_i.mhpmcounter\[2\]\[48\]
+ _13939_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[49\]$_DFFE_PN0P_
+ _01796_ net144 clknet_leaf_101_clk cs_registers_i.mhpmcounter\[2\]\[49\]
+ _13938_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[4\]$_DFFE_PN0P_
+ _01797_ net261 clknet_leaf_120_clk cs_registers_i.mhpmcounter\[2\]\[4\]
+ _13937_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[50\]$_DFFE_PN0P_
+ _01798_ net144 clknet_leaf_101_clk cs_registers_i.mhpmcounter\[2\]\[50\]
+ _13936_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[51\]$_DFFE_PN0P_
+ _01799_ net144 clknet_leaf_101_clk cs_registers_i.mhpmcounter\[2\]\[51\]
+ _13935_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[52\]$_DFFE_PN0P_
+ _01800_ net144 clknet_leaf_101_clk cs_registers_i.mhpmcounter\[2\]\[52\]
+ _13934_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[53\]$_DFFE_PN0P_
+ _01801_ net144 clknet_leaf_101_clk cs_registers_i.mhpmcounter\[2\]\[53\]
+ _13933_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[54\]$_DFFE_PN0P_
+ _01802_ net144 clknet_leaf_102_clk cs_registers_i.mhpmcounter\[2\]\[54\]
+ _13932_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[55\]$_DFFE_PN0P_
+ _01803_ net144 clknet_leaf_102_clk cs_registers_i.mhpmcounter\[2\]\[55\]
+ _13931_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[56\]$_DFFE_PN0P_
+ _01804_ net144 clknet_leaf_102_clk cs_registers_i.mhpmcounter\[2\]\[56\]
+ _13930_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[57\]$_DFFE_PN0P_
+ _01805_ net144 clknet_leaf_101_clk cs_registers_i.mhpmcounter\[2\]\[57\]
+ _13929_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[58\]$_DFFE_PN0P_
+ _01806_ net144 clknet_leaf_103_clk cs_registers_i.mhpmcounter\[2\]\[58\]
+ _13928_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[59\]$_DFFE_PN0P_
+ _01807_ net144 clknet_leaf_102_clk cs_registers_i.mhpmcounter\[2\]\[59\]
+ _13927_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[5\]$_DFFE_PN0P_
+ _01808_ net261 clknet_leaf_119_clk cs_registers_i.mhpmcounter\[2\]\[5\]
+ _13926_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[60\]$_DFFE_PN0P_
+ _01809_ net144 clknet_leaf_102_clk cs_registers_i.mhpmcounter\[2\]\[60\]
+ _13925_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[61\]$_DFFE_PN0P_
+ _01810_ net144 clknet_leaf_101_clk cs_registers_i.mhpmcounter\[2\]\[61\]
+ _13924_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[62\]$_DFFE_PN0P_
+ _01811_ net144 clknet_leaf_103_clk cs_registers_i.mhpmcounter\[2\]\[62\]
+ _13923_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[63\]$_DFFE_PN0P_
+ _01812_ net144 clknet_leaf_100_clk cs_registers_i.mhpmcounter\[2\]\[63\]
+ _13922_ VDD VSS DFFR_X2
Xcs_registers_i.minstret_counter_i.counter_q\[6\]$_DFFE_PN0P_
+ _01813_ net261 clknet_leaf_118_clk cs_registers_i.mhpmcounter\[2\]\[6\]
+ _13921_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[7\]$_DFFE_PN0P_
+ _01814_ net262 clknet_leaf_114_clk cs_registers_i.mhpmcounter\[2\]\[7\]
+ _13920_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[8\]$_DFFE_PN0P_
+ _01815_ net262 clknet_leaf_120_clk cs_registers_i.mhpmcounter\[2\]\[8\]
+ _13919_ VDD VSS DFFR_X1
Xcs_registers_i.minstret_counter_i.counter_q\[9\]$_DFFE_PN0P_
+ _01816_ net261 clknet_leaf_120_clk cs_registers_i.mhpmcounter\[2\]\[9\]
+ _13918_ VDD VSS DFFR_X1
Xcs_registers_i.priv_lvl_q\[0\]$_DFFE_PN1P_ _01817_ net262
+ clknet_leaf_112_clk cs_registers_i.priv_lvl_q\[0\] _13917_
+ VDD VSS DFFS_X1
Xcs_registers_i.priv_lvl_q\[1\]$_DFFE_PN1P_ _01818_ net262
+ clknet_leaf_113_clk cs_registers_i.priv_lvl_q\[1\] _15500_
+ VDD VSS DFFS_X1
Xcs_registers_i.u_dcsr_csr.rdata_q\[0\]$_DFFE_PN1P_ _01819_
+ net262 clknet_leaf_112_clk cs_registers_i.dcsr_q\[0\] _13916_
+ VDD VSS DFFS_X2
Xcs_registers_i.u_dcsr_csr.rdata_q\[11\]$_DFFE_PN0P_ _01820_
+ net262 clknet_leaf_111_clk cs_registers_i.dcsr_q\[11\] _13915_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_dcsr_csr.rdata_q\[12\]$_DFFE_PN0P_ _01821_
+ net264 clknet_leaf_71_clk cs_registers_i.dcsr_q\[12\] _13914_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_dcsr_csr.rdata_q\[13\]$_DFFE_PN0P_ _01822_
+ net265 clknet_leaf_84_clk cs_registers_i.dcsr_q\[13\] _13913_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_dcsr_csr.rdata_q\[15\]$_DFFE_PN0P_ _01823_
+ net262 clknet_leaf_83_clk cs_registers_i.dcsr_q\[15\] _13912_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_dcsr_csr.rdata_q\[1\]$_DFFE_PN1P_ _01824_
+ net262 clknet_leaf_67_clk cs_registers_i.dcsr_q\[1\] _13911_
+ VDD VSS DFFS_X2
Xcs_registers_i.u_dcsr_csr.rdata_q\[2\]$_DFFE_PN0P_ _01825_
+ net262 clknet_leaf_111_clk cs_registers_i.dcsr_q\[2\] _01162_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_dcsr_csr.rdata_q\[6\]$_DFFE_PN0P_ _01826_
+ net262 clknet_leaf_111_clk cs_registers_i.dcsr_q\[6\] _13910_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_dcsr_csr.rdata_q\[7\]$_DFFE_PN0P_ _01827_
+ net262 clknet_leaf_112_clk cs_registers_i.dcsr_q\[7\] _13909_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_dcsr_csr.rdata_q\[8\]$_DFFE_PN0P_ _01828_
+ net262 clknet_leaf_67_clk cs_registers_i.dcsr_q\[8\] _13908_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[10\]$_DFFE_PN0P_ _01829_
+ net264 clknet_leaf_74_clk cs_registers_i.csr_depc_o\[10\]
+ _13907_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[11\]$_DFFE_PN0P_ _01830_
+ net265 clknet_leaf_65_clk cs_registers_i.csr_depc_o\[11\]
+ _13906_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[12\]$_DFFE_PN0P_ _01831_
+ net264 clknet_leaf_72_clk cs_registers_i.csr_depc_o\[12\]
+ _13905_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[13\]$_DFFE_PN0P_ _01832_
+ net264 clknet_leaf_74_clk cs_registers_i.csr_depc_o\[13\]
+ _13904_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[14\]$_DFFE_PN0P_ _01833_
+ net264 clknet_leaf_74_clk cs_registers_i.csr_depc_o\[14\]
+ _13903_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[15\]$_DFFE_PN0P_ _01834_
+ net264 clknet_leaf_72_clk cs_registers_i.csr_depc_o\[15\]
+ _13902_ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[16\]$_DFFE_PN0P_ _01835_
+ net264 clknet_leaf_53_clk cs_registers_i.csr_depc_o\[16\]
+ _13901_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[17\]$_DFFE_PN0P_ _01836_
+ net265 clknet_leaf_72_clk cs_registers_i.csr_depc_o\[17\]
+ _13900_ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[18\]$_DFFE_PN0P_ _01837_
+ net264 clknet_leaf_71_clk cs_registers_i.csr_depc_o\[18\]
+ _13899_ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[19\]$_DFFE_PN0P_ _01838_
+ net264 clknet_leaf_65_clk cs_registers_i.csr_depc_o\[19\]
+ _13898_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[1\]$_DFFE_PN0P_ _01839_
+ net262 clknet_leaf_64_clk cs_registers_i.csr_depc_o\[1\] _00554_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[20\]$_DFFE_PN0P_ _01840_
+ net264 clknet_leaf_54_clk cs_registers_i.csr_depc_o\[20\]
+ _13897_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[21\]$_DFFE_PN0P_ _01841_
+ net265 clknet_leaf_78_clk cs_registers_i.csr_depc_o\[21\]
+ _13896_ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[22\]$_DFFE_PN0P_ _01842_
+ net265 clknet_leaf_76_clk cs_registers_i.csr_depc_o\[22\]
+ _13895_ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[23\]$_DFFE_PN0P_ _01843_
+ net264 clknet_leaf_76_clk cs_registers_i.csr_depc_o\[23\]
+ _13894_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[24\]$_DFFE_PN0P_ _01844_
+ net265 clknet_leaf_76_clk cs_registers_i.csr_depc_o\[24\]
+ _13893_ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[25\]$_DFFE_PN0P_ _01845_
+ net264 clknet_leaf_73_clk cs_registers_i.csr_depc_o\[25\]
+ _13892_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[26\]$_DFFE_PN0P_ _01846_
+ net265 clknet_leaf_76_clk cs_registers_i.csr_depc_o\[26\]
+ _13891_ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[27\]$_DFFE_PN0P_ _01847_
+ net265 clknet_leaf_78_clk cs_registers_i.csr_depc_o\[27\]
+ _13890_ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[28\]$_DFFE_PN0P_ _01848_
+ net264 clknet_leaf_53_clk cs_registers_i.csr_depc_o\[28\]
+ _13889_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[29\]$_DFFE_PN0P_ _01849_
+ net265 clknet_leaf_79_clk cs_registers_i.csr_depc_o\[29\]
+ _13888_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[2\]$_DFFE_PN0P_ _01850_
+ net262 clknet_leaf_67_clk cs_registers_i.csr_depc_o\[2\] _13887_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[30\]$_DFFE_PN0P_ _01851_
+ net264 clknet_leaf_71_clk cs_registers_i.csr_depc_o\[30\]
+ _13886_ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[31\]$_DFFE_PN0P_ _01852_
+ net264 clknet_leaf_71_clk cs_registers_i.csr_depc_o\[31\]
+ _13885_ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[3\]$_DFFE_PN0P_ _01853_
+ net264 clknet_leaf_72_clk cs_registers_i.csr_depc_o\[3\] _01163_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[4\]$_DFFE_PN0P_ _01854_
+ net265 clknet_leaf_66_clk cs_registers_i.csr_depc_o\[4\] _01164_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[5\]$_DFFE_PN0P_ _01855_
+ net265 clknet_leaf_66_clk cs_registers_i.csr_depc_o\[5\] _01165_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[6\]$_DFFE_PN0P_ _01856_
+ net265 clknet_leaf_65_clk cs_registers_i.csr_depc_o\[6\] _01166_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_depc_csr.rdata_q\[7\]$_DFFE_PN0P_ _01857_
+ net264 clknet_leaf_72_clk cs_registers_i.csr_depc_o\[7\] _13884_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[8\]$_DFFE_PN0P_ _01858_
+ net264 clknet_leaf_74_clk cs_registers_i.csr_depc_o\[8\] _13883_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_depc_csr.rdata_q\[9\]$_DFFE_PN0P_ _01859_
+ net264 clknet_leaf_73_clk cs_registers_i.csr_depc_o\[9\] _13882_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_dscratch0_csr.rdata_q\[0\]$_DFFE_PN0P_ _01860_
+ net262 clknet_leaf_108_clk cs_registers_i.dscratch0_q\[0\]
+ _13881_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[10\]$_DFFE_PN0P_
+ _01861_ net144 clknet_leaf_92_clk cs_registers_i.dscratch0_q\[10\]
+ _13880_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[11\]$_DFFE_PN0P_
+ _01862_ net262 clknet_leaf_110_clk cs_registers_i.dscratch0_q\[11\]
+ _13879_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[12\]$_DFFE_PN0P_
+ _01863_ net265 clknet_leaf_82_clk cs_registers_i.dscratch0_q\[12\]
+ _13878_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[13\]$_DFFE_PN0P_
+ _01864_ net265 clknet_leaf_82_clk cs_registers_i.dscratch0_q\[13\]
+ _13877_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[14\]$_DFFE_PN0P_
+ _01865_ net265 clknet_leaf_86_clk cs_registers_i.dscratch0_q\[14\]
+ _13876_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[15\]$_DFFE_PN0P_
+ _01866_ net265 clknet_leaf_70_clk cs_registers_i.dscratch0_q\[15\]
+ _13875_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[16\]$_DFFE_PN0P_
+ _01867_ net265 clknet_leaf_85_clk cs_registers_i.dscratch0_q\[16\]
+ _13874_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[17\]$_DFFE_PN0P_
+ _01868_ net144 clknet_leaf_94_clk cs_registers_i.dscratch0_q\[17\]
+ _13873_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[18\]$_DFFE_PN0P_
+ _01869_ net265 clknet_leaf_86_clk cs_registers_i.dscratch0_q\[18\]
+ _13872_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[19\]$_DFFE_PN0P_
+ _01870_ net144 clknet_leaf_91_clk cs_registers_i.dscratch0_q\[19\]
+ _13871_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[1\]$_DFFE_PN0P_ _01871_
+ net262 clknet_leaf_94_clk cs_registers_i.dscratch0_q\[1\]
+ _13870_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[20\]$_DFFE_PN0P_
+ _01872_ net144 clknet_leaf_91_clk cs_registers_i.dscratch0_q\[20\]
+ _13869_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[21\]$_DFFE_PN0P_
+ _01873_ net262 clknet_leaf_83_clk cs_registers_i.dscratch0_q\[21\]
+ _13868_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[22\]$_DFFE_PN0P_
+ _01874_ net144 clknet_leaf_91_clk cs_registers_i.dscratch0_q\[22\]
+ _13867_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[23\]$_DFFE_PN0P_
+ _01875_ net265 clknet_leaf_85_clk cs_registers_i.dscratch0_q\[23\]
+ _13866_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[24\]$_DFFE_PN0P_
+ _01876_ net265 clknet_leaf_87_clk cs_registers_i.dscratch0_q\[24\]
+ _13865_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[25\]$_DFFE_PN0P_
+ _01877_ net265 clknet_leaf_86_clk cs_registers_i.dscratch0_q\[25\]
+ _13864_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[26\]$_DFFE_PN0P_
+ _01878_ net144 clknet_leaf_89_clk cs_registers_i.dscratch0_q\[26\]
+ _13863_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[27\]$_DFFE_PN0P_
+ _01879_ net144 clknet_leaf_89_clk cs_registers_i.dscratch0_q\[27\]
+ _13862_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[28\]$_DFFE_PN0P_
+ _01880_ net265 clknet_leaf_87_clk cs_registers_i.dscratch0_q\[28\]
+ _13861_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[29\]$_DFFE_PN0P_
+ _01881_ net144 clknet_leaf_89_clk cs_registers_i.dscratch0_q\[29\]
+ _13860_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[2\]$_DFFE_PN0P_ _01882_
+ net262 clknet_leaf_98_clk cs_registers_i.dscratch0_q\[2\]
+ _13859_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[30\]$_DFFE_PN0P_
+ _01883_ net262 clknet_leaf_89_clk cs_registers_i.dscratch0_q\[30\]
+ _13858_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[31\]$_DFFE_PN0P_
+ _01884_ net265 clknet_leaf_84_clk cs_registers_i.dscratch0_q\[31\]
+ _13857_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[3\]$_DFFE_PN0P_ _01885_
+ net262 clknet_leaf_98_clk cs_registers_i.dscratch0_q\[3\]
+ _13856_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[4\]$_DFFE_PN0P_ _01886_
+ net262 clknet_leaf_98_clk cs_registers_i.dscratch0_q\[4\]
+ _13855_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[5\]$_DFFE_PN0P_ _01887_
+ net262 clknet_leaf_97_clk cs_registers_i.dscratch0_q\[5\]
+ _13854_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[6\]$_DFFE_PN0P_ _01888_
+ net262 clknet_leaf_98_clk cs_registers_i.dscratch0_q\[6\]
+ _13853_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[7\]$_DFFE_PN0P_ _01889_
+ net262 clknet_leaf_96_clk cs_registers_i.dscratch0_q\[7\]
+ _13852_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[8\]$_DFFE_PN0P_ _01890_
+ net262 clknet_leaf_95_clk cs_registers_i.dscratch0_q\[8\]
+ _13851_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch0_csr.rdata_q\[9\]$_DFFE_PN0P_ _01891_
+ net262 clknet_leaf_94_clk cs_registers_i.dscratch0_q\[9\]
+ _13850_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[0\]$_DFFE_PN0P_ _01892_
+ net262 clknet_leaf_108_clk cs_registers_i.dscratch1_q\[0\]
+ _13849_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[10\]$_DFFE_PN0P_
+ _01893_ net144 clknet_leaf_91_clk cs_registers_i.dscratch1_q\[10\]
+ _13848_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[11\]$_DFFE_PN0P_
+ _01894_ net262 clknet_leaf_97_clk cs_registers_i.dscratch1_q\[11\]
+ _13847_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[12\]$_DFFE_PN0P_
+ _01895_ net265 clknet_leaf_82_clk cs_registers_i.dscratch1_q\[12\]
+ _13846_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[13\]$_DFFE_PN0P_
+ _01896_ net265 clknet_leaf_84_clk cs_registers_i.dscratch1_q\[13\]
+ _13845_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[14\]$_DFFE_PN0P_
+ _01897_ net265 clknet_leaf_84_clk cs_registers_i.dscratch1_q\[14\]
+ _13844_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[15\]$_DFFE_PN0P_
+ _01898_ net262 clknet_leaf_97_clk cs_registers_i.dscratch1_q\[15\]
+ _13843_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[16\]$_DFFE_PN0P_
+ _01899_ net262 clknet_leaf_85_clk cs_registers_i.dscratch1_q\[16\]
+ _13842_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[17\]$_DFFE_PN0P_
+ _01900_ net144 clknet_leaf_92_clk cs_registers_i.dscratch1_q\[17\]
+ _13841_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[18\]$_DFFE_PN0P_
+ _01901_ net265 clknet_leaf_84_clk cs_registers_i.dscratch1_q\[18\]
+ _13840_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[19\]$_DFFE_PN0P_
+ _01902_ net144 clknet_leaf_92_clk cs_registers_i.dscratch1_q\[19\]
+ _13839_ VDD VSS DFFR_X2
Xcs_registers_i.u_dscratch1_csr.rdata_q\[1\]$_DFFE_PN0P_ _01903_
+ net144 clknet_leaf_94_clk cs_registers_i.dscratch1_q\[1\]
+ _13838_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[20\]$_DFFE_PN0P_
+ _01904_ net144 clknet_leaf_91_clk cs_registers_i.dscratch1_q\[20\]
+ _13837_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[21\]$_DFFE_PN0P_
+ _01905_ net262 clknet_leaf_96_clk cs_registers_i.dscratch1_q\[21\]
+ _13836_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[22\]$_DFFE_PN0P_
+ _01906_ net144 clknet_leaf_90_clk cs_registers_i.dscratch1_q\[22\]
+ _13835_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[23\]$_DFFE_PN0P_
+ _01907_ net262 clknet_leaf_110_clk cs_registers_i.dscratch1_q\[23\]
+ _13834_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[24\]$_DFFE_PN0P_
+ _01908_ net265 clknet_leaf_87_clk cs_registers_i.dscratch1_q\[24\]
+ _13833_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[25\]$_DFFE_PN0P_
+ _01909_ net265 clknet_leaf_88_clk cs_registers_i.dscratch1_q\[25\]
+ _13832_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[26\]$_DFFE_PN0P_
+ _01910_ net144 clknet_leaf_90_clk cs_registers_i.dscratch1_q\[26\]
+ _13831_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[27\]$_DFFE_PN0P_
+ _01911_ net265 clknet_leaf_90_clk cs_registers_i.dscratch1_q\[27\]
+ _13830_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[28\]$_DFFE_PN0P_
+ _01912_ net265 clknet_leaf_87_clk cs_registers_i.dscratch1_q\[28\]
+ _13829_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[29\]$_DFFE_PN0P_
+ _01913_ net265 clknet_leaf_90_clk cs_registers_i.dscratch1_q\[29\]
+ _13828_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[2\]$_DFFE_PN0P_ _01914_
+ net262 clknet_leaf_98_clk cs_registers_i.dscratch1_q\[2\]
+ _13827_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[30\]$_DFFE_PN0P_
+ _01915_ net144 clknet_leaf_91_clk cs_registers_i.dscratch1_q\[30\]
+ _13826_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[31\]$_DFFE_PN0P_
+ _01916_ net265 clknet_leaf_95_clk cs_registers_i.dscratch1_q\[31\]
+ _13825_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[3\]$_DFFE_PN0P_ _01917_
+ net262 clknet_leaf_98_clk cs_registers_i.dscratch1_q\[3\]
+ _13824_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[4\]$_DFFE_PN0P_ _01918_
+ net262 clknet_leaf_96_clk cs_registers_i.dscratch1_q\[4\]
+ _13823_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[5\]$_DFFE_PN0P_ _01919_
+ net262 clknet_leaf_96_clk cs_registers_i.dscratch1_q\[5\]
+ _13822_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[6\]$_DFFE_PN0P_ _01920_
+ net262 clknet_leaf_99_clk cs_registers_i.dscratch1_q\[6\]
+ _13821_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[7\]$_DFFE_PN0P_ _01921_
+ net262 clknet_leaf_96_clk cs_registers_i.dscratch1_q\[7\]
+ _13820_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[8\]$_DFFE_PN0P_ _01922_
+ net262 clknet_leaf_95_clk cs_registers_i.dscratch1_q\[8\]
+ _13819_ VDD VSS DFFR_X1
Xcs_registers_i.u_dscratch1_csr.rdata_q\[9\]$_DFFE_PN0P_ _01923_
+ net144 clknet_leaf_91_clk cs_registers_i.dscratch1_q\[9\]
+ _13818_ VDD VSS DFFR_X1
Xcs_registers_i.u_mcause_csr.rdata_q\[0\]$_DFFE_PN0P_ _01924_
+ net262 clknet_leaf_67_clk cs_registers_i.mcause_q\[0\] _13817_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mcause_csr.rdata_q\[1\]$_DFFE_PN0P_ _01925_
+ net262 clknet_leaf_64_clk cs_registers_i.mcause_q\[1\] _13816_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mcause_csr.rdata_q\[2\]$_DFFE_PN0P_ _01926_
+ net262 clknet_leaf_67_clk cs_registers_i.mcause_q\[2\] _13815_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mcause_csr.rdata_q\[3\]$_DFFE_PN0P_ _01927_
+ net265 clknet_leaf_66_clk cs_registers_i.mcause_q\[3\] _13814_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mcause_csr.rdata_q\[4\]$_DFFE_PN0P_ _01928_
+ net262 clknet_leaf_68_clk cs_registers_i.mcause_q\[4\] _13813_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mcause_csr.rdata_q\[5\]$_DFFE_PN0P_ _01929_
+ net265 clknet_leaf_70_clk cs_registers_i.mcause_q\[5\] _13812_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mepc_csr.rdata_q\[0\]$_DFFE_PN0P_ _01930_
+ net262 clknet_leaf_68_clk cs_registers_i.csr_mepc_o\[0\] _13811_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mepc_csr.rdata_q\[10\]$_DFFE_PN0P_ _01931_
+ net264 clknet_leaf_74_clk cs_registers_i.csr_mepc_o\[10\]
+ _13810_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[11\]$_DFFE_PN0P_ _01932_
+ net264 clknet_leaf_60_clk cs_registers_i.csr_mepc_o\[11\]
+ _13809_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[12\]$_DFFE_PN0P_ _01933_
+ net264 clknet_leaf_75_clk cs_registers_i.csr_mepc_o\[12\]
+ _13808_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[13\]$_DFFE_PN0P_ _01934_
+ net264 clknet_leaf_54_clk cs_registers_i.csr_mepc_o\[13\]
+ _13807_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[14\]$_DFFE_PN0P_ _01935_
+ net264 clknet_leaf_54_clk cs_registers_i.csr_mepc_o\[14\]
+ _13806_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[15\]$_DFFE_PN0P_ _01936_
+ net265 clknet_leaf_72_clk cs_registers_i.csr_mepc_o\[15\]
+ _13805_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[16\]$_DFFE_PN0P_ _01937_
+ net264 clknet_leaf_53_clk cs_registers_i.csr_mepc_o\[16\]
+ _13804_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[17\]$_DFFE_PN0P_ _01938_
+ net265 clknet_leaf_70_clk cs_registers_i.csr_mepc_o\[17\]
+ _13803_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[18\]$_DFFE_PN0P_ _01939_
+ net264 clknet_leaf_75_clk cs_registers_i.csr_mepc_o\[18\]
+ _13802_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[19\]$_DFFE_PN0P_ _01940_
+ net264 clknet_leaf_54_clk cs_registers_i.csr_mepc_o\[19\]
+ _13801_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[1\]$_DFFE_PN0P_ _01941_
+ net262 clknet_leaf_64_clk cs_registers_i.csr_mepc_o\[1\] _13800_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[20\]$_DFFE_PN0P_ _01942_
+ net265 clknet_leaf_52_clk cs_registers_i.csr_mepc_o\[20\]
+ _13799_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[21\]$_DFFE_PN0P_ _01943_
+ net265 clknet_leaf_51_clk cs_registers_i.csr_mepc_o\[21\]
+ _13798_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[22\]$_DFFE_PN0P_ _01944_
+ net265 clknet_leaf_77_clk cs_registers_i.csr_mepc_o\[22\]
+ _13797_ VDD VSS DFFR_X1
Xcs_registers_i.u_mepc_csr.rdata_q\[23\]$_DFFE_PN0P_ _01945_
+ net265 clknet_leaf_52_clk cs_registers_i.csr_mepc_o\[23\]
+ _13796_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[24\]$_DFFE_PN0P_ _01946_
+ net265 clknet_leaf_51_clk cs_registers_i.csr_mepc_o\[24\]
+ _13795_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[25\]$_DFFE_PN0P_ _01947_
+ net265 clknet_leaf_53_clk cs_registers_i.csr_mepc_o\[25\]
+ _13794_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[26\]$_DFFE_PN0P_ _01948_
+ net265 clknet_leaf_77_clk cs_registers_i.csr_mepc_o\[26\]
+ _13793_ VDD VSS DFFR_X1
Xcs_registers_i.u_mepc_csr.rdata_q\[27\]$_DFFE_PN0P_ _01949_
+ net265 clknet_leaf_78_clk cs_registers_i.csr_mepc_o\[27\]
+ _13792_ VDD VSS DFFR_X1
Xcs_registers_i.u_mepc_csr.rdata_q\[28\]$_DFFE_PN0P_ _01950_
+ net264 clknet_leaf_74_clk cs_registers_i.csr_mepc_o\[28\]
+ _13791_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[29\]$_DFFE_PN0P_ _01951_
+ net265 clknet_leaf_79_clk cs_registers_i.csr_mepc_o\[29\]
+ _13790_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[2\]$_DFFE_PN0P_ _01952_
+ net262 clknet_leaf_66_clk cs_registers_i.csr_mepc_o\[2\] _13789_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[30\]$_DFFE_PN0P_ _01953_
+ net264 clknet_leaf_79_clk cs_registers_i.csr_mepc_o\[30\]
+ _13788_ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[31\]$_DFFE_PN0P_ _01954_
+ net264 clknet_leaf_70_clk cs_registers_i.csr_mepc_o\[31\]
+ _13787_ VDD VSS DFFR_X1
Xcs_registers_i.u_mepc_csr.rdata_q\[3\]$_DFFE_PN0P_ _01955_
+ net265 clknet_leaf_66_clk cs_registers_i.csr_mepc_o\[3\] _13786_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mepc_csr.rdata_q\[4\]$_DFFE_PN0P_ _01956_
+ net265 clknet_leaf_68_clk cs_registers_i.csr_mepc_o\[4\] _13785_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mepc_csr.rdata_q\[5\]$_DFFE_PN0P_ _01957_
+ net265 clknet_leaf_70_clk cs_registers_i.csr_mepc_o\[5\] _13784_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mepc_csr.rdata_q\[6\]$_DFFE_PN0P_ _01958_
+ net265 clknet_leaf_65_clk cs_registers_i.csr_mepc_o\[6\] _13783_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[7\]$_DFFE_PN0P_ _01959_
+ net264 clknet_leaf_73_clk cs_registers_i.csr_mepc_o\[7\] _13782_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[8\]$_DFFE_PN0P_ _01960_
+ net264 clknet_leaf_73_clk cs_registers_i.csr_mepc_o\[8\] _13781_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mepc_csr.rdata_q\[9\]$_DFFE_PN0P_ _01961_
+ net264 clknet_leaf_61_clk cs_registers_i.csr_mepc_o\[9\] _13780_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[0\]$_DFFE_PN0P_ _01962_
+ net262 clknet_leaf_85_clk cs_registers_i.mie_q\[0\] _13779_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[10\]$_DFFE_PN0P_ _01963_
+ net265 clknet_leaf_90_clk cs_registers_i.mie_q\[10\] _13778_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[11\]$_DFFE_PN0P_ _01964_
+ net265 clknet_leaf_90_clk cs_registers_i.mie_q\[11\] _13777_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[12\]$_DFFE_PN0P_ _01965_
+ net265 clknet_leaf_90_clk cs_registers_i.mie_q\[12\] _13776_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[13\]$_DFFE_PN0P_ _01966_
+ net265 clknet_leaf_88_clk cs_registers_i.mie_q\[13\] _13775_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[14\]$_DFFE_PN0P_ _01967_
+ net262 clknet_leaf_89_clk cs_registers_i.mie_q\[14\] _13774_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[15\]$_DFFE_PN0P_ _01968_
+ net262 clknet_leaf_91_clk cs_registers_i.mie_q\[15\] _13773_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[16\]$_DFFE_PN0P_ _01969_
+ net262 clknet_leaf_95_clk cs_registers_i.mie_q\[16\] _13772_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[17\]$_DFFE_PN0P_ _01970_
+ net265 clknet_leaf_85_clk cs_registers_i.mie_q\[17\] _13771_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[1\]$_DFFE_PN0P_ _01971_
+ net144 clknet_leaf_89_clk cs_registers_i.mie_q\[1\] _13770_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[2\]$_DFFE_PN0P_ _01972_
+ net265 clknet_leaf_86_clk cs_registers_i.mie_q\[2\] _13769_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[3\]$_DFFE_PN0P_ _01973_
+ net262 clknet_leaf_89_clk cs_registers_i.mie_q\[3\] _13768_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[4\]$_DFFE_PN0P_ _01974_
+ net144 clknet_leaf_89_clk cs_registers_i.mie_q\[4\] _13767_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[5\]$_DFFE_PN0P_ _01975_
+ net265 clknet_leaf_85_clk cs_registers_i.mie_q\[5\] _13766_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[6\]$_DFFE_PN0P_ _01976_
+ net144 clknet_leaf_88_clk cs_registers_i.mie_q\[6\] _13765_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[7\]$_DFFE_PN0P_ _01977_
+ net265 clknet_leaf_86_clk cs_registers_i.mie_q\[7\] _13764_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[8\]$_DFFE_PN0P_ _01978_
+ net265 clknet_leaf_87_clk cs_registers_i.mie_q\[8\] _13763_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mie_csr.rdata_q\[9\]$_DFFE_PN0P_ _01979_
+ net265 clknet_leaf_87_clk cs_registers_i.mie_q\[9\] _13762_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mscratch_csr.rdata_q\[0\]$_DFFE_PN0P_ _01980_
+ net262 clknet_leaf_97_clk cs_registers_i.mscratch_q\[0\] _13761_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[10\]$_DFFE_PN0P_ _01981_
+ net265 clknet_leaf_95_clk cs_registers_i.mscratch_q\[10\]
+ _13760_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[11\]$_DFFE_PN0P_ _01982_
+ net265 clknet_leaf_81_clk cs_registers_i.mscratch_q\[11\]
+ _13759_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[12\]$_DFFE_PN0P_ _01983_
+ net265 clknet_leaf_82_clk cs_registers_i.mscratch_q\[12\]
+ _13758_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[13\]$_DFFE_PN0P_ _01984_
+ net265 clknet_leaf_84_clk cs_registers_i.mscratch_q\[13\]
+ _13757_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[14\]$_DFFE_PN0P_ _01985_
+ net264 clknet_leaf_81_clk cs_registers_i.mscratch_q\[14\]
+ _13756_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[15\]$_DFFE_PN0P_ _01986_
+ net262 clknet_leaf_97_clk cs_registers_i.mscratch_q\[15\]
+ _13755_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[16\]$_DFFE_PN0P_ _01987_
+ net265 clknet_leaf_86_clk cs_registers_i.mscratch_q\[16\]
+ _13754_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[17\]$_DFFE_PN0P_ _01988_
+ net262 clknet_leaf_95_clk cs_registers_i.mscratch_q\[17\]
+ _13753_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[18\]$_DFFE_PN0P_ _01989_
+ net265 clknet_leaf_86_clk cs_registers_i.mscratch_q\[18\]
+ _13752_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[19\]$_DFFE_PN0P_ _01990_
+ net262 clknet_leaf_95_clk cs_registers_i.mscratch_q\[19\]
+ _13751_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[1\]$_DFFE_PN0P_ _01991_
+ net262 clknet_leaf_95_clk cs_registers_i.mscratch_q\[1\] _13750_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[20\]$_DFFE_PN0P_ _01992_
+ net265 clknet_leaf_88_clk cs_registers_i.mscratch_q\[20\]
+ _13749_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[21\]$_DFFE_PN0P_ _01993_
+ net265 clknet_leaf_80_clk cs_registers_i.mscratch_q\[21\]
+ _13748_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[22\]$_DFFE_PN0P_ _01994_
+ net265 clknet_leaf_88_clk cs_registers_i.mscratch_q\[22\]
+ _13747_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[23\]$_DFFE_PN0P_ _01995_
+ net265 clknet_leaf_81_clk cs_registers_i.mscratch_q\[23\]
+ _13746_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[24\]$_DFFE_PN0P_ _01996_
+ net265 clknet_leaf_80_clk cs_registers_i.mscratch_q\[24\]
+ _13745_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[25\]$_DFFE_PN0P_ _01997_
+ net265 clknet_leaf_80_clk cs_registers_i.mscratch_q\[25\]
+ _13744_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[26\]$_DFFE_PN0P_ _01998_
+ net265 clknet_leaf_88_clk cs_registers_i.mscratch_q\[26\]
+ _13743_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[27\]$_DFFE_PN0P_ _01999_
+ net265 clknet_leaf_88_clk cs_registers_i.mscratch_q\[27\]
+ _13742_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[28\]$_DFFE_PN0P_ _02000_
+ net265 clknet_leaf_87_clk cs_registers_i.mscratch_q\[28\]
+ _13741_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[29\]$_DFFE_PN0P_ _02001_
+ net265 clknet_leaf_88_clk cs_registers_i.mscratch_q\[29\]
+ _13740_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[2\]$_DFFE_PN0P_ _02002_
+ net262 clknet_leaf_109_clk cs_registers_i.mscratch_q\[2\]
+ _13739_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[30\]$_DFFE_PN0P_ _02003_
+ net265 clknet_leaf_85_clk cs_registers_i.mscratch_q\[30\]
+ _13738_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[31\]$_DFFE_PN0P_ _02004_
+ net262 clknet_leaf_98_clk cs_registers_i.mscratch_q\[31\]
+ _13737_ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[3\]$_DFFE_PN0P_ _02005_
+ net262 clknet_leaf_96_clk cs_registers_i.mscratch_q\[3\] _13736_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[4\]$_DFFE_PN0P_ _02006_
+ net262 clknet_leaf_97_clk cs_registers_i.mscratch_q\[4\] _13735_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[5\]$_DFFE_PN0P_ _02007_
+ net262 clknet_leaf_96_clk cs_registers_i.mscratch_q\[5\] _13734_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[6\]$_DFFE_PN0P_ _02008_
+ net262 clknet_leaf_98_clk cs_registers_i.mscratch_q\[6\] _13733_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[7\]$_DFFE_PN0P_ _02009_
+ net262 clknet_leaf_96_clk cs_registers_i.mscratch_q\[7\] _13732_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[8\]$_DFFE_PN0P_ _02010_
+ net262 clknet_leaf_83_clk cs_registers_i.mscratch_q\[8\] _13731_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mscratch_csr.rdata_q\[9\]$_DFFE_PN0P_ _02011_
+ net265 clknet_leaf_84_clk cs_registers_i.mscratch_q\[9\] _13730_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_cause_csr.rdata_q\[0\]$_DFFE_PN0P_
+ _02012_ net262 clknet_leaf_64_clk cs_registers_i.mstack_cause_q\[0\]
+ _13729_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_cause_csr.rdata_q\[1\]$_DFFE_PN0P_
+ _02013_ net262 clknet_leaf_64_clk cs_registers_i.mstack_cause_q\[1\]
+ _13728_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_cause_csr.rdata_q\[2\]$_DFFE_PN0P_
+ _02014_ net262 clknet_leaf_67_clk cs_registers_i.mstack_cause_q\[2\]
+ _13727_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_cause_csr.rdata_q\[3\]$_DFFE_PN0P_
+ _02015_ net265 clknet_leaf_66_clk cs_registers_i.mstack_cause_q\[3\]
+ _13726_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_cause_csr.rdata_q\[4\]$_DFFE_PN0P_
+ _02016_ net265 clknet_leaf_68_clk cs_registers_i.mstack_cause_q\[4\]
+ _13725_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_cause_csr.rdata_q\[5\]$_DFFE_PN0P_
+ _02017_ net265 clknet_leaf_70_clk cs_registers_i.mstack_cause_q\[5\]
+ _13724_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_csr.rdata_q\[0\]$_DFFE_PN0P_ _02018_
+ net262 clknet_leaf_111_clk cs_registers_i.mstack_q\[0\] _13723_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_csr.rdata_q\[1\]$_DFFE_PN0P_ _02019_
+ net262 clknet_leaf_64_clk cs_registers_i.mstack_q\[1\] _13722_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_csr.rdata_q\[2\]$_DFFE_PN1P_ _02020_
+ net262 clknet_leaf_110_clk cs_registers_i.mstack_q\[2\] _13721_
+ VDD VSS DFFS_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[0\]$_DFFE_PN0P_
+ _02021_ net262 clknet_leaf_68_clk cs_registers_i.mstack_epc_q\[0\]
+ _13720_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[10\]$_DFFE_PN0P_
+ _02022_ net264 clknet_leaf_73_clk cs_registers_i.mstack_epc_q\[10\]
+ _13719_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[11\]$_DFFE_PN0P_
+ _02023_ net264 clknet_leaf_61_clk cs_registers_i.mstack_epc_q\[11\]
+ _13718_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[12\]$_DFFE_PN0P_
+ _02024_ net264 clknet_leaf_75_clk cs_registers_i.mstack_epc_q\[12\]
+ _13717_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[13\]$_DFFE_PN0P_
+ _02025_ net264 clknet_leaf_54_clk cs_registers_i.mstack_epc_q\[13\]
+ _13716_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[14\]$_DFFE_PN0P_
+ _02026_ net264 clknet_leaf_53_clk cs_registers_i.mstack_epc_q\[14\]
+ _13715_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[15\]$_DFFE_PN0P_
+ _02027_ net264 clknet_leaf_72_clk cs_registers_i.mstack_epc_q\[15\]
+ _13714_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[16\]$_DFFE_PN0P_
+ _02028_ net264 clknet_leaf_54_clk cs_registers_i.mstack_epc_q\[16\]
+ _13713_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[17\]$_DFFE_PN0P_
+ _02029_ net264 clknet_leaf_71_clk cs_registers_i.mstack_epc_q\[17\]
+ _13712_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[18\]$_DFFE_PN0P_
+ _02030_ net264 clknet_leaf_75_clk cs_registers_i.mstack_epc_q\[18\]
+ _13711_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[19\]$_DFFE_PN0P_
+ _02031_ net264 clknet_leaf_60_clk cs_registers_i.mstack_epc_q\[19\]
+ _13710_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[1\]$_DFFE_PN0P_
+ _02032_ net262 clknet_leaf_64_clk cs_registers_i.mstack_epc_q\[1\]
+ _13709_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[20\]$_DFFE_PN0P_
+ _02033_ net265 clknet_leaf_51_clk cs_registers_i.mstack_epc_q\[20\]
+ _13708_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[21\]$_DFFE_PN0P_
+ _02034_ net265 clknet_leaf_50_clk cs_registers_i.mstack_epc_q\[21\]
+ _13707_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[22\]$_DFFE_PN0P_
+ _02035_ net265 clknet_leaf_51_clk cs_registers_i.mstack_epc_q\[22\]
+ _13706_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[23\]$_DFFE_PN0P_
+ _02036_ net265 clknet_leaf_52_clk cs_registers_i.mstack_epc_q\[23\]
+ _13705_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[24\]$_DFFE_PN0P_
+ _02037_ net265 clknet_leaf_51_clk cs_registers_i.mstack_epc_q\[24\]
+ _13704_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[25\]$_DFFE_PN0P_
+ _02038_ net265 clknet_leaf_52_clk cs_registers_i.mstack_epc_q\[25\]
+ _13703_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[26\]$_DFFE_PN0P_
+ _02039_ net265 clknet_leaf_77_clk cs_registers_i.mstack_epc_q\[26\]
+ _13702_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[27\]$_DFFE_PN0P_
+ _02040_ net265 clknet_leaf_78_clk cs_registers_i.mstack_epc_q\[27\]
+ _13701_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[28\]$_DFFE_PN0P_
+ _02041_ net264 clknet_leaf_74_clk cs_registers_i.mstack_epc_q\[28\]
+ _13700_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[29\]$_DFFE_PN0P_
+ _02042_ net265 clknet_leaf_80_clk cs_registers_i.mstack_epc_q\[29\]
+ _13699_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[2\]$_DFFE_PN0P_
+ _02043_ net262 clknet_leaf_66_clk cs_registers_i.mstack_epc_q\[2\]
+ _13698_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[30\]$_DFFE_PN0P_
+ _02044_ net264 clknet_leaf_79_clk cs_registers_i.mstack_epc_q\[30\]
+ _13697_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[31\]$_DFFE_PN0P_
+ _02045_ net264 clknet_leaf_71_clk cs_registers_i.mstack_epc_q\[31\]
+ _13696_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[3\]$_DFFE_PN0P_
+ _02046_ net264 clknet_leaf_73_clk cs_registers_i.mstack_epc_q\[3\]
+ _13695_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[4\]$_DFFE_PN0P_
+ _02047_ net265 clknet_leaf_68_clk cs_registers_i.mstack_epc_q\[4\]
+ _13694_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[5\]$_DFFE_PN0P_
+ _02048_ net265 clknet_leaf_70_clk cs_registers_i.mstack_epc_q\[5\]
+ _13693_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[6\]$_DFFE_PN0P_
+ _02049_ net262 clknet_leaf_65_clk cs_registers_i.mstack_epc_q\[6\]
+ _13692_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[7\]$_DFFE_PN0P_
+ _02050_ net265 clknet_leaf_65_clk cs_registers_i.mstack_epc_q\[7\]
+ _13691_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[8\]$_DFFE_PN0P_
+ _02051_ net264 clknet_leaf_61_clk cs_registers_i.mstack_epc_q\[8\]
+ _13690_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstack_epc_csr.rdata_q\[9\]$_DFFE_PN0P_
+ _02052_ net264 clknet_leaf_61_clk cs_registers_i.mstack_epc_q\[9\]
+ _13689_ VDD VSS DFFR_X1
Xcs_registers_i.u_mstatus_csr.rdata_q\[0\]$_DFFE_PN0P_ _02053_
+ net262 clknet_leaf_110_clk cs_registers_i.csr_mstatus_tw_o
+ _13688_ VDD VSS DFFR_X2
Xcs_registers_i.u_mstatus_csr.rdata_q\[1\]$_DFFE_PN0P_ _02054_
+ net262 clknet_leaf_111_clk cs_registers_i.mstatus_q\[1\] _13687_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mstatus_csr.rdata_q\[2\]$_DFFE_PN0P_ _02055_
+ net262 clknet_leaf_110_clk cs_registers_i.mstack_d\[0\] _13686_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mstatus_csr.rdata_q\[3\]$_DFFE_PN0P_ _02056_
+ net262 clknet_leaf_111_clk cs_registers_i.mstack_d\[1\] _13685_
+ VDD VSS DFFR_X2
Xcs_registers_i.u_mstatus_csr.rdata_q\[4\]$_DFFE_PN1P_ _02057_
+ net262 clknet_leaf_110_clk cs_registers_i.mstack_d\[2\] _13684_
+ VDD VSS DFFS_X2
Xcs_registers_i.u_mstatus_csr.rdata_q\[5\]$_DFFE_PN0P_ _02058_
+ net262 clknet_leaf_110_clk cs_registers_i.csr_mstatus_mie_o
+ _13683_ VDD VSS DFFR_X2
Xcs_registers_i.u_mtval_csr.rdata_q\[0\]$_DFFE_PN0P_ _02059_
+ net262 clknet_leaf_108_clk cs_registers_i.mtval_q\[0\] _13682_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[10\]$_DFFE_PN0P_ _02060_
+ net265 clknet_leaf_70_clk cs_registers_i.mtval_q\[10\] _13681_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[11\]$_DFFE_PN0P_ _02061_
+ net262 clknet_leaf_69_clk cs_registers_i.mtval_q\[11\] _13680_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[12\]$_DFFE_PN0P_ _02062_
+ net265 clknet_leaf_69_clk cs_registers_i.mtval_q\[12\] _13679_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[13\]$_DFFE_PN0P_ _02063_
+ net262 clknet_leaf_83_clk cs_registers_i.mtval_q\[13\] _13678_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[14\]$_DFFE_PN0P_ _02064_
+ net262 clknet_leaf_83_clk cs_registers_i.mtval_q\[14\] _13677_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[15\]$_DFFE_PN0P_ _02065_
+ net262 clknet_leaf_109_clk cs_registers_i.mtval_q\[15\] _13676_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[16\]$_DFFE_PN0P_ _02066_
+ net262 clknet_leaf_83_clk cs_registers_i.mtval_q\[16\] _13675_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[17\]$_DFFE_PN0P_ _02067_
+ net262 clknet_leaf_109_clk cs_registers_i.mtval_q\[17\] _13674_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[18\]$_DFFE_PN0P_ _02068_
+ net262 clknet_leaf_83_clk cs_registers_i.mtval_q\[18\] _13673_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[19\]$_DFFE_PN0P_ _02069_
+ net262 clknet_leaf_69_clk cs_registers_i.mtval_q\[19\] _13672_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[1\]$_DFFE_PN0P_ _02070_
+ net262 clknet_leaf_109_clk cs_registers_i.mtval_q\[1\] _13671_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[20\]$_DFFE_PN0P_ _02071_
+ net262 clknet_leaf_97_clk cs_registers_i.mtval_q\[20\] _13670_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[21\]$_DFFE_PN0P_ _02072_
+ net265 clknet_leaf_83_clk cs_registers_i.mtval_q\[21\] _13669_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[22\]$_DFFE_PN0P_ _02073_
+ net265 clknet_leaf_86_clk cs_registers_i.mtval_q\[22\] _13668_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[23\]$_DFFE_PN0P_ _02074_
+ net262 clknet_leaf_109_clk cs_registers_i.mtval_q\[23\] _13667_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[24\]$_DFFE_PN0P_ _02075_
+ net264 clknet_leaf_81_clk cs_registers_i.mtval_q\[24\] _13666_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[25\]$_DFFE_PN0P_ _02076_
+ net264 clknet_leaf_79_clk cs_registers_i.mtval_q\[25\] _13665_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[26\]$_DFFE_PN0P_ _02077_
+ net265 clknet_leaf_87_clk cs_registers_i.mtval_q\[26\] _13664_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[27\]$_DFFE_PN0P_ _02078_
+ net265 clknet_leaf_80_clk cs_registers_i.mtval_q\[27\] _13663_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[28\]$_DFFE_PN0P_ _02079_
+ net265 clknet_leaf_86_clk cs_registers_i.mtval_q\[28\] _13662_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[29\]$_DFFE_PN0P_ _02080_
+ net265 clknet_leaf_80_clk cs_registers_i.mtval_q\[29\] _13661_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[2\]$_DFFE_PN0P_ _02081_
+ net262 clknet_leaf_109_clk cs_registers_i.mtval_q\[2\] _13660_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[30\]$_DFFE_PN0P_ _02082_
+ net265 clknet_leaf_82_clk cs_registers_i.mtval_q\[30\] _13659_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[31\]$_DFFE_PN0P_ _02083_
+ net265 clknet_leaf_69_clk cs_registers_i.mtval_q\[31\] _13658_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[3\]$_DFFE_PN0P_ _02084_
+ net262 clknet_leaf_69_clk cs_registers_i.mtval_q\[3\] _13657_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[4\]$_DFFE_PN0P_ _02085_
+ net262 clknet_leaf_68_clk cs_registers_i.mtval_q\[4\] _13656_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[5\]$_DFFE_PN0P_ _02086_
+ net262 clknet_leaf_97_clk cs_registers_i.mtval_q\[5\] _13655_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[6\]$_DFFE_PN0P_ _02087_
+ net262 clknet_leaf_109_clk cs_registers_i.mtval_q\[6\] _13654_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[7\]$_DFFE_PN0P_ _02088_
+ net262 clknet_leaf_69_clk cs_registers_i.mtval_q\[7\] _13653_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[8\]$_DFFE_PN0P_ _02089_
+ net262 clknet_leaf_69_clk cs_registers_i.mtval_q\[8\] _13652_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtval_csr.rdata_q\[9\]$_DFFE_PN0P_ _02090_
+ net262 clknet_leaf_67_clk cs_registers_i.mtval_q\[9\] _13651_
+ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[10\]$_DFFE_PN0P_ _02091_
+ net265 clknet_leaf_76_clk cs_registers_i.csr_mtvec_o\[10\]
+ _01169_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[11\]$_DFFE_PN0P_ _02092_
+ net264 clknet_leaf_75_clk cs_registers_i.csr_mtvec_o\[11\]
+ _00550_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[12\]$_DFFE_PN0P_ _02093_
+ net264 clknet_leaf_81_clk cs_registers_i.csr_mtvec_o\[12\]
+ _00549_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[13\]$_DFFE_PN0P_ _02094_
+ net264 clknet_leaf_74_clk cs_registers_i.csr_mtvec_o\[13\]
+ _01170_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[14\]$_DFFE_PN0P_ _02095_
+ net265 clknet_leaf_52_clk cs_registers_i.csr_mtvec_o\[14\]
+ _01171_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[15\]$_DFFE_PN0P_ _02096_
+ net264 clknet_leaf_82_clk cs_registers_i.csr_mtvec_o\[15\]
+ _01172_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[16\]$_DFFE_PN0P_ _02097_
+ net265 clknet_leaf_76_clk cs_registers_i.csr_mtvec_o\[16\]
+ _01173_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[17\]$_DFFE_PN0P_ _02098_
+ net264 clknet_leaf_75_clk cs_registers_i.csr_mtvec_o\[17\]
+ _01174_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[18\]$_DFFE_PN0P_ _02099_
+ net264 clknet_leaf_81_clk cs_registers_i.csr_mtvec_o\[18\]
+ _01175_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[19\]$_DFFE_PN0P_ _02100_
+ net265 clknet_leaf_76_clk cs_registers_i.csr_mtvec_o\[19\]
+ _01176_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[20\]$_DFFE_PN0P_ _02101_
+ net265 clknet_leaf_76_clk cs_registers_i.csr_mtvec_o\[20\]
+ _01177_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[21\]$_DFFE_PN0P_ _02102_
+ net265 clknet_leaf_80_clk cs_registers_i.csr_mtvec_o\[21\]
+ _01178_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[22\]$_DFFE_PN0P_ _02103_
+ net265 clknet_leaf_77_clk cs_registers_i.csr_mtvec_o\[22\]
+ _01179_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[23\]$_DFFE_PN0P_ _02104_
+ net265 clknet_leaf_79_clk cs_registers_i.csr_mtvec_o\[23\]
+ _01180_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[24\]$_DFFE_PN0P_ _02105_
+ net265 clknet_leaf_77_clk cs_registers_i.csr_mtvec_o\[24\]
+ _01181_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[25\]$_DFFE_PN0P_ _02106_
+ net265 clknet_leaf_51_clk cs_registers_i.csr_mtvec_o\[25\]
+ _01182_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[26\]$_DFFE_PN0P_ _02107_
+ net265 clknet_leaf_77_clk cs_registers_i.csr_mtvec_o\[26\]
+ _01183_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[27\]$_DFFE_PN0P_ _02108_
+ net265 clknet_leaf_77_clk cs_registers_i.csr_mtvec_o\[27\]
+ _00007_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[28\]$_DFFE_PN0P_ _02109_
+ net265 clknet_leaf_51_clk cs_registers_i.csr_mtvec_o\[28\]
+ _00008_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[29\]$_DFFE_PN0P_ _02110_
+ net265 clknet_leaf_78_clk cs_registers_i.csr_mtvec_o\[29\]
+ _00009_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[30\]$_DFFE_PN0P_ _02111_
+ net264 clknet_leaf_78_clk cs_registers_i.csr_mtvec_o\[30\]
+ _00010_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[31\]$_DFFE_PN0P_ _02112_
+ net264 clknet_leaf_71_clk cs_registers_i.csr_mtvec_o\[31\]
+ _00011_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[8\]$_DFFE_PN0P_ _02113_
+ net264 clknet_leaf_71_clk cs_registers_i.csr_mtvec_o\[8\]
+ _01167_ VDD VSS DFFR_X1
Xcs_registers_i.u_mtvec_csr.rdata_q\[9\]$_DFFE_PN0P_ _02114_
+ net264 clknet_leaf_75_clk cs_registers_i.csr_mtvec_o\[9\]
+ _01168_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_by_zero_q$_DFFE_PN0P_
+ _02115_ net263 clknet_leaf_24_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_by_zero_q
+ _13650_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]$_DFFE_PN0P_
+ _02116_ net264 clknet_leaf_38_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]
+ _15538_ VDD VSS DFFR_X2
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]$_DFFE_PN0P_
+ _02117_ net264 clknet_leaf_37_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]
+ _15539_ VDD VSS DFFR_X2
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[2\]$_DFFE_PN0P_
+ _02118_ net264 clknet_leaf_33_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[2\]
+ _00066_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]$_DFFE_PN0P_
+ _02119_ net264 clknet_leaf_34_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ _00067_ VDD VSS DFFR_X2
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[4\]$_DFFE_PN0P_
+ _02120_ net264 clknet_leaf_37_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_counter_q\[4\]
+ _01158_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]$_DFF_PN1_
+ _00000_ net263 clknet_leaf_23_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]
+ _14051_ VDD VSS DFFS_X2
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[3\]$_DFF_PN0_
+ _00001_ net263 clknet_leaf_23_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[3\]
+ _00555_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[1\]$_DFF_PN0_
+ _00002_ net264 clknet_leaf_33_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[1\]
+ _14052_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[3\]$_DFF_PN0_
+ _00003_ net264 clknet_leaf_33_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.div_valid
+ _14053_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[4\]$_DFF_PN0_
+ _00004_ net264 clknet_leaf_33_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[4\]
+ _00178_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[6\]$_DFF_PN0_
+ _00005_ net264 clknet_leaf_34_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.md_state_q\[6\]
+ _13649_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[0\]$_DFFE_PN0P_
+ _02121_ net263 clknet_leaf_16_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[0\]
+ _00101_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[10\]$_DFFE_PN0P_
+ _02122_ net263 clknet_leaf_20_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[10\]
+ _00111_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[11\]$_DFFE_PN0P_
+ _02123_ net263 clknet_leaf_18_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[11\]
+ _00110_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[12\]$_DFFE_PN0P_
+ _02124_ net263 clknet_leaf_20_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[12\]
+ _00113_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[13\]$_DFFE_PN0P_
+ _02125_ net263 clknet_leaf_16_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[13\]
+ _00112_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[14\]$_DFFE_PN0P_
+ _02126_ net263 clknet_leaf_20_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[14\]
+ _00115_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[15\]$_DFFE_PN0P_
+ _02127_ net263 clknet_leaf_16_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[15\]
+ _00114_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[16\]$_DFFE_PN0P_
+ _02128_ net263 clknet_leaf_21_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[16\]
+ _00117_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[17\]$_DFFE_PN0P_
+ _02129_ net263 clknet_leaf_21_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[17\]
+ _00116_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[18\]$_DFFE_PN0P_
+ _02130_ net263 clknet_leaf_21_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[18\]
+ _00119_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[19\]$_DFFE_PN0P_
+ _02131_ net263 clknet_leaf_21_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[19\]
+ _00118_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[1\]$_DFFE_PN0P_
+ _02132_ net263 clknet_leaf_16_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[1\]
+ _00100_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[20\]$_DFFE_PN0P_
+ _02133_ net263 clknet_leaf_20_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[20\]
+ _00121_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[21\]$_DFFE_PN0P_
+ _02134_ net263 clknet_leaf_20_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[21\]
+ _00120_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[22\]$_DFFE_PN0P_
+ _02135_ net263 clknet_leaf_20_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[22\]
+ _00123_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[23\]$_DFFE_PN0P_
+ _02136_ net263 clknet_leaf_21_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[23\]
+ _00122_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[24\]$_DFFE_PN0P_
+ _02137_ net263 clknet_leaf_15_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[24\]
+ _00125_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[25\]$_DFFE_PN0P_
+ _02138_ net263 clknet_leaf_15_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[25\]
+ _00124_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[26\]$_DFFE_PN0P_
+ _02139_ net263 clknet_leaf_15_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[26\]
+ _00127_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[27\]$_DFFE_PN0P_
+ _02140_ net263 clknet_leaf_15_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[27\]
+ _00126_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[28\]$_DFFE_PN0P_
+ _02141_ net263 clknet_leaf_16_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[28\]
+ _00129_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[29\]$_DFFE_PN0P_
+ _02142_ net263 clknet_leaf_20_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[29\]
+ _00128_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[2\]$_DFFE_PN0P_
+ _02143_ net263 clknet_leaf_17_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[2\]
+ _00103_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[30\]$_DFFE_PN0P_
+ _02144_ net263 clknet_leaf_16_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[30\]
+ _00131_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[31\]$_DFFE_PN0P_
+ _02145_ net263 clknet_leaf_19_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[31\]
+ _00130_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[3\]$_DFFE_PN0P_
+ _02146_ net263 clknet_leaf_16_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[3\]
+ _00102_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[4\]$_DFFE_PN0P_
+ _02147_ net263 clknet_leaf_17_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[4\]
+ _00105_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[5\]$_DFFE_PN0P_
+ _02148_ net263 clknet_leaf_17_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[5\]
+ _00104_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[6\]$_DFFE_PN0P_
+ _02149_ net263 clknet_leaf_17_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[6\]
+ _00107_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[7\]$_DFFE_PN0P_
+ _02150_ net263 clknet_leaf_17_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[7\]
+ _00106_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[8\]$_DFFE_PN0P_
+ _02151_ net263 clknet_leaf_19_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[8\]
+ _00109_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[9\]$_DFFE_PN0P_
+ _02152_ net263 clknet_leaf_18_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_numerator_q\[9\]
+ _00108_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[0\]$_DFFE_PN0P_
+ _02153_ net264 clknet_leaf_36_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[0\]
+ _00068_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[10\]$_DFFE_PN0P_
+ _02154_ net264 clknet_leaf_43_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[10\]
+ _00078_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[11\]$_DFFE_PN0P_
+ _02155_ net264 clknet_leaf_35_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[11\]
+ _00079_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[12\]$_DFFE_PN0P_
+ _02156_ net264 clknet_leaf_36_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[12\]
+ _00080_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[13\]$_DFFE_PN0P_
+ _02157_ net264 clknet_leaf_36_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[13\]
+ _00081_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[14\]$_DFFE_PN0P_
+ _02158_ net264 clknet_leaf_36_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[14\]
+ _00082_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[15\]$_DFFE_PN0P_
+ _02159_ net264 clknet_leaf_36_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[15\]
+ _00083_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[16\]$_DFFE_PN0P_
+ _02160_ net264 clknet_leaf_34_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[16\]
+ _00084_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[17\]$_DFFE_PN0P_
+ _02161_ net264 clknet_leaf_43_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[17\]
+ _00085_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[18\]$_DFFE_PN0P_
+ _02162_ net264 clknet_leaf_39_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[18\]
+ _00086_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[19\]$_DFFE_PN0P_
+ _02163_ net264 clknet_leaf_37_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[19\]
+ _00087_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[1\]$_DFFE_PN0P_
+ _02164_ net264 clknet_leaf_35_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[1\]
+ _00069_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[20\]$_DFFE_PN0P_
+ _02165_ net264 clknet_leaf_37_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[20\]
+ _00088_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[21\]$_DFFE_PN0P_
+ _02166_ net264 clknet_leaf_37_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[21\]
+ _00089_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[22\]$_DFFE_PN0P_
+ _02167_ net264 clknet_leaf_38_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[22\]
+ _00090_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[23\]$_DFFE_PN0P_
+ _02168_ net264 clknet_leaf_38_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[23\]
+ _00091_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[24\]$_DFFE_PN0P_
+ _02169_ net264 clknet_leaf_37_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[24\]
+ _00092_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[25\]$_DFFE_PN0P_
+ _02170_ net264 clknet_leaf_38_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[25\]
+ _00093_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[26\]$_DFFE_PN0P_
+ _02171_ net264 clknet_leaf_38_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[26\]
+ _00094_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[27\]$_DFFE_PN0P_
+ _02172_ net264 clknet_leaf_34_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[27\]
+ _00095_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[28\]$_DFFE_PN0P_
+ _02173_ net264 clknet_leaf_36_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[28\]
+ _00096_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[29\]$_DFFE_PN0P_
+ _02174_ net264 clknet_leaf_38_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[29\]
+ _00097_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[2\]$_DFFE_PN0P_
+ _02175_ net264 clknet_leaf_43_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[2\]
+ _00070_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[30\]$_DFFE_PN0P_
+ _02176_ net264 clknet_leaf_38_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[30\]
+ _00098_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[31\]$_DFFE_PN0P_
+ _02177_ net264 clknet_leaf_37_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[31\]
+ _00099_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[3\]$_DFFE_PN0P_
+ _02178_ net264 clknet_leaf_35_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[3\]
+ _00071_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[4\]$_DFFE_PN0P_
+ _02179_ net264 clknet_leaf_35_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[4\]
+ _00072_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[5\]$_DFFE_PN0P_
+ _02180_ net264 clknet_leaf_44_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[5\]
+ _00073_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[6\]$_DFFE_PN0P_
+ _02181_ net264 clknet_leaf_36_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[6\]
+ _00074_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[7\]$_DFFE_PN0P_
+ _02182_ net264 clknet_leaf_35_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[7\]
+ _00075_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[8\]$_DFFE_PN0P_
+ _02183_ net264 clknet_leaf_35_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[8\]
+ _00076_ VDD VSS DFFR_X1
Xex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[9\]$_DFFE_PN0P_
+ _02184_ net264 clknet_leaf_35_clk ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.op_quotient_q\[9\]
+ _00077_ VDD VSS DFFR_X1
Xfetch_enable_q$_DFFE_PN0P_ _02185_ net144 clknet_leaf_118_clk_i_regs
+ fetch_enable_q _13648_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[0\]$_DFFE_PN0P_
+ _02186_ net257 clknet_leaf_107_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[32\]
+ _13647_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[100\]$_DFFE_PN0P_
+ _02187_ net258 clknet_leaf_105_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[132\]
+ _00311_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[101\]$_DFFE_PN0P_
+ _02188_ net257 clknet_leaf_85_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[133\]
+ _00341_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[102\]$_DFFE_PN0P_
+ _02189_ net256 clknet_leaf_90_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[134\]
+ _00371_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[103\]$_DFFE_PN0P_
+ _02190_ net256 clknet_leaf_95_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[135\]
+ _00401_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[104\]$_DFFE_PN0P_
+ _02191_ net258 clknet_leaf_80_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[136\]
+ _00431_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[105\]$_DFFE_PN0P_
+ _02192_ net256 clknet_leaf_91_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[137\]
+ _00461_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[106\]$_DFFE_PN0P_
+ _02193_ net256 clknet_leaf_64_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[138\]
+ _00491_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[107\]$_DFFE_PN0P_
+ _02194_ net256 clknet_leaf_93_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[139\]
+ _00521_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[108\]$_DFFE_PN0P_
+ _02195_ net255 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[140\]
+ _00220_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[109\]$_DFFE_PN0P_
+ _02196_ net256 clknet_leaf_61_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[141\]
+ _00569_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[10\]$_DFFE_PN0P_
+ _02197_ net256 clknet_leaf_67_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[42\]
+ _13646_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[110\]$_DFFE_PN0P_
+ _02198_ net255 clknet_leaf_49_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[142\]
+ _00600_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[111\]$_DFFE_PN0P_
+ _02199_ net255 clknet_leaf_50_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[143\]
+ _00631_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[112\]$_DFFE_PN0P_
+ _02200_ net255 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[144\]
+ _00662_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[113\]$_DFFE_PN0P_
+ _02201_ net255 clknet_leaf_55_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[145\]
+ _00693_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[114\]$_DFFE_PN0P_
+ _02202_ net256 clknet_leaf_52_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[146\]
+ _00724_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[115\]$_DFFE_PN0P_
+ _02203_ net261 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[147\]
+ _00755_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[116\]$_DFFE_PN0P_
+ _02204_ net259 clknet_leaf_39_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[148\]
+ _00786_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[117\]$_DFFE_PN0P_
+ _02205_ net259 clknet_leaf_36_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[149\]
+ _00817_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[118\]$_DFFE_PN0P_
+ _02206_ net260 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[150\]
+ _00848_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[119\]$_DFFE_PN0P_
+ _02207_ net259 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[151\]
+ _00879_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[11\]$_DFFE_PN0P_
+ _02208_ net256 clknet_leaf_92_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[43\]
+ _13645_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[120\]$_DFFE_PN0P_
+ _02209_ net259 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[152\]
+ _00910_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[121\]$_DFFE_PN0P_
+ _02210_ net259 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[153\]
+ _00941_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[122\]$_DFFE_PN0P_
+ _02211_ net260 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[154\]
+ _00972_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[123\]$_DFFE_PN0P_
+ _02212_ net259 clknet_leaf_36_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[155\]
+ _01003_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[124\]$_DFFE_PN0P_
+ _02213_ net259 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[156\]
+ _01034_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[125\]$_DFFE_PN0P_
+ _02214_ net259 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[157\]
+ _01065_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[126\]$_DFFE_PN0P_
+ _02215_ net259 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[158\]
+ _01096_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[127\]$_DFFE_PN0P_
+ _02216_ net261 clknet_leaf_124_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[159\]
+ _01127_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[128\]$_DFFE_PN0P_
+ _02217_ net257 clknet_leaf_107_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[160\]
+ _00189_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[129\]$_DFFE_PN0P_
+ _02218_ net258 clknet_leaf_108_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[161\]
+ _00144_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[12\]$_DFFE_PN0P_
+ _02219_ net258 clknet_leaf_73_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[44\]
+ _13644_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[130\]$_DFFE_PN0P_
+ _02220_ net261 clknet_leaf_123_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[162\]
+ _00251_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[131\]$_DFFE_PN0P_
+ _02221_ net261 clknet_leaf_123_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[163\]
+ _00282_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[132\]$_DFFE_PN0P_
+ _02222_ net258 clknet_leaf_106_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[164\]
+ _00312_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[133\]$_DFFE_PN0P_
+ _02223_ net257 clknet_leaf_85_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[165\]
+ _00342_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[134\]$_DFFE_PN0P_
+ _02224_ net256 clknet_leaf_90_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[166\]
+ _00372_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[135\]$_DFFE_PN0P_
+ _02225_ net256 clknet_leaf_95_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[167\]
+ _00402_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[136\]$_DFFE_PN0P_
+ _02226_ net256 clknet_leaf_81_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[168\]
+ _00432_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[137\]$_DFFE_PN0P_
+ _02227_ net256 clknet_leaf_91_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[169\]
+ _00462_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[138\]$_DFFE_PN0P_
+ _02228_ net256 clknet_leaf_93_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[170\]
+ _00492_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[139\]$_DFFE_PN0P_
+ _02229_ net256 clknet_leaf_94_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[171\]
+ _00522_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[13\]$_DFFE_PN0P_
+ _02230_ net256 clknet_leaf_69_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[45\]
+ _13643_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[140\]$_DFFE_PN0P_
+ _02231_ net255 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[172\]
+ _00221_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[141\]$_DFFE_PN0P_
+ _02232_ net256 clknet_leaf_61_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[173\]
+ _00570_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[142\]$_DFFE_PN0P_
+ _02233_ net255 clknet_leaf_49_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[174\]
+ _00601_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[143\]$_DFFE_PN0P_
+ _02234_ net255 clknet_leaf_51_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[175\]
+ _00632_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[144\]$_DFFE_PN0P_
+ _02235_ net255 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[176\]
+ _00663_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[145\]$_DFFE_PN0P_
+ _02236_ net258 clknet_leaf_54_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[177\]
+ _00694_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[146\]$_DFFE_PN0P_
+ _02237_ net256 clknet_leaf_53_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[178\]
+ _00725_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[147\]$_DFFE_PN0P_
+ _02238_ net258 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[179\]
+ _00756_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[148\]$_DFFE_PN0P_
+ _02239_ net259 clknet_leaf_39_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[180\]
+ _00787_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[149\]$_DFFE_PN0P_
+ _02240_ net259 clknet_leaf_36_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[181\]
+ _00818_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[14\]$_DFFE_PN0P_
+ _02241_ net255 clknet_leaf_56_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[46\]
+ _13642_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[150\]$_DFFE_PN0P_
+ _02242_ net260 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[182\]
+ _00849_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[151\]$_DFFE_PN0P_
+ _02243_ net259 clknet_leaf_35_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[183\]
+ _00880_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[152\]$_DFFE_PN0P_
+ _02244_ net259 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[184\]
+ _00911_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[153\]$_DFFE_PN0P_
+ _02245_ net259 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[185\]
+ _00942_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[154\]$_DFFE_PN0P_
+ _02246_ net260 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[186\]
+ _00973_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[155\]$_DFFE_PN0P_
+ _02247_ net259 clknet_leaf_36_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[187\]
+ _01004_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[156\]$_DFFE_PN0P_
+ _02248_ net259 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[188\]
+ _01035_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[157\]$_DFFE_PN0P_
+ _02249_ net259 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[189\]
+ _01066_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[158\]$_DFFE_PN0P_
+ _02250_ net259 clknet_leaf_35_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[190\]
+ _01097_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[159\]$_DFFE_PN0P_
+ _02251_ net261 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[191\]
+ _01128_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[15\]$_DFFE_PN0P_
+ _02252_ net258 clknet_leaf_58_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[47\]
+ _13641_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[160\]$_DFFE_PN0P_
+ _02253_ net257 clknet_leaf_107_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[192\]
+ _00190_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[161\]$_DFFE_PN0P_
+ _02254_ net258 clknet_leaf_103_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[193\]
+ _00145_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[162\]$_DFFE_PN0P_
+ _02255_ net261 clknet_leaf_123_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[194\]
+ _00252_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[163\]$_DFFE_PN0P_
+ _02256_ net261 clknet_leaf_123_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[195\]
+ _00283_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[164\]$_DFFE_PN0P_
+ _02257_ net258 clknet_leaf_102_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[196\]
+ _00313_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[165\]$_DFFE_PN0P_
+ _02258_ net257 clknet_leaf_105_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[197\]
+ _00343_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[166\]$_DFFE_PN0P_
+ _02259_ net256 clknet_leaf_90_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[198\]
+ _00373_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[167\]$_DFFE_PN0P_
+ _02260_ net256 clknet_leaf_95_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[199\]
+ _00403_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[168\]$_DFFE_PN0P_
+ _02261_ net256 clknet_leaf_112_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[200\]
+ _00433_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[169\]$_DFFE_PN0P_
+ _02262_ net256 clknet_leaf_90_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[201\]
+ _00463_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[16\]$_DFFE_PN0P_
+ _02263_ net258 clknet_leaf_72_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[48\]
+ _13640_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[170\]$_DFFE_PN0P_
+ _02264_ net256 clknet_leaf_64_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[202\]
+ _00493_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[171\]$_DFFE_PN0P_
+ _02265_ net256 clknet_leaf_94_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[203\]
+ _00523_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[172\]$_DFFE_PN0P_
+ _02266_ net255 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[204\]
+ _00222_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[173\]$_DFFE_PN0P_
+ _02267_ net256 clknet_leaf_61_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[205\]
+ _00571_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[174\]$_DFFE_PN0P_
+ _02268_ net255 clknet_leaf_48_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[206\]
+ _00602_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[175\]$_DFFE_PN0P_
+ _02269_ net255 clknet_leaf_46_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[207\]
+ _00633_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[176\]$_DFFE_PN0P_
+ _02270_ net255 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[208\]
+ _00664_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[177\]$_DFFE_PN0P_
+ _02271_ net255 clknet_leaf_55_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[209\]
+ _00695_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[178\]$_DFFE_PN0P_
+ _02272_ net256 clknet_leaf_52_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[210\]
+ _00726_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[179\]$_DFFE_PN0P_
+ _02273_ net259 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[211\]
+ _00757_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[17\]$_DFFE_PN0P_
+ _02274_ net258 clknet_leaf_71_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[49\]
+ _13639_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[180\]$_DFFE_PN0P_
+ _02275_ net259 clknet_leaf_40_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[212\]
+ _00788_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[181\]$_DFFE_PN0P_
+ _02276_ net259 clknet_leaf_36_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[213\]
+ _00819_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[182\]$_DFFE_PN0P_
+ _02277_ net260 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[214\]
+ _00850_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[183\]$_DFFE_PN0P_
+ _02278_ net259 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[215\]
+ _00881_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[184\]$_DFFE_PN0P_
+ _02279_ net259 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[216\]
+ _00912_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[185\]$_DFFE_PN0P_
+ _02280_ net259 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[217\]
+ _00943_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[186\]$_DFFE_PN0P_
+ _02281_ net260 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[218\]
+ _00974_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[187\]$_DFFE_PN0P_
+ _02282_ net259 clknet_leaf_36_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[219\]
+ _01005_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[188\]$_DFFE_PN0P_
+ _02283_ net259 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[220\]
+ _01036_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[189\]$_DFFE_PN0P_
+ _02284_ net259 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[221\]
+ _01067_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[18\]$_DFFE_PN0P_
+ _02285_ net258 clknet_leaf_57_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[50\]
+ _13638_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[190\]$_DFFE_PN0P_
+ _02286_ net259 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[222\]
+ _01098_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[191\]$_DFFE_PN0P_
+ _02287_ net261 clknet_leaf_125_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[223\]
+ _01129_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[192\]$_DFFE_PN0P_
+ _02288_ net257 clknet_leaf_107_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[224\]
+ _00191_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[193\]$_DFFE_PN0P_
+ _02289_ net258 clknet_leaf_103_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[225\]
+ _00146_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[194\]$_DFFE_PN0P_
+ _02290_ net261 clknet_leaf_114_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[226\]
+ _00253_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[195\]$_DFFE_PN0P_
+ _02291_ net261 clknet_leaf_114_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[227\]
+ _00284_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[196\]$_DFFE_PN0P_
+ _02292_ net258 clknet_leaf_104_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[228\]
+ _00314_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[197\]$_DFFE_PN0P_
+ _02293_ net257 clknet_leaf_106_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[229\]
+ _00344_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[198\]$_DFFE_PN0P_
+ _02294_ net256 clknet_leaf_90_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[230\]
+ _00374_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[199\]$_DFFE_PN0P_
+ _02295_ net256 clknet_leaf_94_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[231\]
+ _00404_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[19\]$_DFFE_PN0P_
+ _02296_ net258 clknet_leaf_80_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[51\]
+ _13637_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[1\]$_DFFE_PN0P_
+ _02297_ net256 clknet_leaf_110_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[33\]
+ _13636_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[200\]$_DFFE_PN0P_
+ _02298_ net256 clknet_leaf_81_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[232\]
+ _00434_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[201\]$_DFFE_PN0P_
+ _02299_ net256 clknet_leaf_91_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[233\]
+ _00464_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[202\]$_DFFE_PN0P_
+ _02300_ net256 clknet_leaf_94_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[234\]
+ _00494_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[203\]$_DFFE_PN0P_
+ _02301_ net256 clknet_leaf_94_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[235\]
+ _00524_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[204\]$_DFFE_PN0P_
+ _02302_ net255 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[236\]
+ _00223_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[205\]$_DFFE_PN0P_
+ _02303_ net256 clknet_leaf_63_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[237\]
+ _00572_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[206\]$_DFFE_PN0P_
+ _02304_ net255 clknet_leaf_46_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[238\]
+ _00603_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[207\]$_DFFE_PN0P_
+ _02305_ net255 clknet_leaf_50_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[239\]
+ _00634_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[208\]$_DFFE_PN0P_
+ _02306_ net255 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[240\]
+ _00665_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[209\]$_DFFE_PN0P_
+ _02307_ net258 clknet_leaf_55_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[241\]
+ _00696_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[20\]$_DFFE_PN0P_
+ _02308_ net255 clknet_leaf_44_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[52\]
+ _13635_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[210\]$_DFFE_PN0P_
+ _02309_ net256 clknet_leaf_53_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[242\]
+ _00727_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[211\]$_DFFE_PN0P_
+ _02310_ net258 clknet_leaf_79_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[243\]
+ _00758_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[212\]$_DFFE_PN0P_
+ _02311_ net259 clknet_leaf_39_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[244\]
+ _00789_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[213\]$_DFFE_PN0P_
+ _02312_ net259 clknet_leaf_36_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[245\]
+ _00820_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[214\]$_DFFE_PN0P_
+ _02313_ net260 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[246\]
+ _00851_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[215\]$_DFFE_PN0P_
+ _02314_ net259 clknet_leaf_35_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[247\]
+ _00882_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[216\]$_DFFE_PN0P_
+ _02315_ net259 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[248\]
+ _00913_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[217\]$_DFFE_PN0P_
+ _02316_ net259 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[249\]
+ _00944_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[218\]$_DFFE_PN0P_
+ _02317_ net260 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[250\]
+ _00975_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[219\]$_DFFE_PN0P_
+ _02318_ net259 clknet_leaf_36_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[251\]
+ _01006_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[21\]$_DFFE_PN0P_
+ _02319_ net255 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[53\]
+ _13634_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[220\]$_DFFE_PN0P_
+ _02320_ net259 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[252\]
+ _01037_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[221\]$_DFFE_PN0P_
+ _02321_ net259 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[253\]
+ _01068_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[222\]$_DFFE_PN0P_
+ _02322_ net259 clknet_leaf_35_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[254\]
+ _01099_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[223\]$_DFFE_PN0P_
+ _02323_ net261 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[255\]
+ _01130_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[224\]$_DFFE_PN0P_
+ _02324_ net258 clknet_leaf_106_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[256\]
+ _00192_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[225\]$_DFFE_PN0P_
+ _02325_ net258 clknet_leaf_103_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[257\]
+ _00147_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[226\]$_DFFE_PN0P_
+ _02326_ net261 clknet_leaf_114_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[258\]
+ _00254_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[227\]$_DFFE_PN0P_
+ _02327_ net261 clknet_leaf_113_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[259\]
+ _00285_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[228\]$_DFFE_PN0P_
+ _02328_ net258 clknet_leaf_102_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[260\]
+ _00315_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[229\]$_DFFE_PN0P_
+ _02329_ net257 clknet_leaf_84_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[261\]
+ _00345_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[22\]$_DFFE_PN0P_
+ _02330_ net259 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[54\]
+ _13633_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[230\]$_DFFE_PN0P_
+ _02331_ net256 clknet_leaf_68_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[262\]
+ _00375_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[231\]$_DFFE_PN0P_
+ _02332_ net256 clknet_leaf_92_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[263\]
+ _00405_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[232\]$_DFFE_PN0P_
+ _02333_ net255 clknet_leaf_79_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[264\]
+ _00435_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[233\]$_DFFE_PN0P_
+ _02334_ net257 clknet_leaf_88_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[265\]
+ _00465_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[234\]$_DFFE_PN0P_
+ _02335_ net256 clknet_leaf_92_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[266\]
+ _00495_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[235\]$_DFFE_PN0P_
+ _02336_ net257 clknet_leaf_95_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[267\]
+ _00525_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[236\]$_DFFE_PN0P_
+ _02337_ net258 clknet_leaf_69_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[268\]
+ _00224_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[237\]$_DFFE_PN0P_
+ _02338_ net256 clknet_leaf_58_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[269\]
+ _00573_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[238\]$_DFFE_PN0P_
+ _02339_ net258 clknet_leaf_56_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[270\]
+ _00604_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[239\]$_DFFE_PN0P_
+ _02340_ net258 clknet_leaf_55_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[271\]
+ _00635_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[23\]$_DFFE_PN0P_
+ _02341_ net259 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[55\]
+ _13632_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[240\]$_DFFE_PN0P_
+ _02342_ net258 clknet_leaf_71_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[272\]
+ _00666_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[241\]$_DFFE_PN0P_
+ _02343_ net258 clknet_leaf_56_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[273\]
+ _00697_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[242\]$_DFFE_PN0P_
+ _02344_ net256 clknet_leaf_60_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[274\]
+ _00728_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[243\]$_DFFE_PN0P_
+ _02345_ net261 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[275\]
+ _00759_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[244\]$_DFFE_PN0P_
+ _02346_ net255 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[276\]
+ _00790_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[245\]$_DFFE_PN0P_
+ _02347_ net259 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[277\]
+ _00821_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[246\]$_DFFE_PN0P_
+ _02348_ net259 clknet_leaf_34_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[278\]
+ _00852_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[247\]$_DFFE_PN0P_
+ _02349_ net259 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[279\]
+ _00883_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[248\]$_DFFE_PN0P_
+ _02350_ net261 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[280\]
+ _00914_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[249\]$_DFFE_PN0P_
+ _02351_ net261 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[281\]
+ _00945_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[24\]$_DFFE_PN0P_
+ _02352_ net261 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[56\]
+ _13631_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[250\]$_DFFE_PN0P_
+ _02353_ net260 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[282\]
+ _00976_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[251\]$_DFFE_PN0P_
+ _02354_ net259 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[283\]
+ _01007_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[252\]$_DFFE_PN0P_
+ _02355_ net259 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[284\]
+ _01038_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[253\]$_DFFE_PN0P_
+ _02356_ net259 clknet_leaf_125_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[285\]
+ _01069_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[254\]$_DFFE_PN0P_
+ _02357_ net259 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[286\]
+ _01100_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[255\]$_DFFE_PN0P_
+ _02358_ net261 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[287\]
+ _01131_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[256\]$_DFFE_PN0P_
+ _02359_ net258 clknet_leaf_106_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[288\]
+ _00193_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[257\]$_DFFE_PN0P_
+ _02360_ net258 clknet_leaf_109_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[289\]
+ _00148_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[258\]$_DFFE_PN0P_
+ _02361_ net261 clknet_leaf_116_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[290\]
+ _00255_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[259\]$_DFFE_PN0P_
+ _02362_ net261 clknet_leaf_114_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[291\]
+ _00286_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[25\]$_DFFE_PN0P_
+ _02363_ net258 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[57\]
+ _13630_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[260\]$_DFFE_PN0P_
+ _02364_ net257 clknet_leaf_87_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[292\]
+ _00316_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[261\]$_DFFE_PN0P_
+ _02365_ net257 clknet_leaf_86_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[293\]
+ _00346_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[262\]$_DFFE_PN0P_
+ _02366_ net256 clknet_leaf_67_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[294\]
+ _00376_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[263\]$_DFFE_PN0P_
+ _02367_ net257 clknet_leaf_99_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[295\]
+ _00406_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[264\]$_DFFE_PN0P_
+ _02368_ net255 clknet_leaf_78_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[296\]
+ _00436_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[265\]$_DFFE_PN0P_
+ _02369_ net257 clknet_leaf_89_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[297\]
+ _00466_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[266\]$_DFFE_PN0P_
+ _02370_ net256 clknet_leaf_65_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[298\]
+ _00496_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[267\]$_DFFE_PN0P_
+ _02371_ net257 clknet_leaf_96_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[299\]
+ _00526_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[268\]$_DFFE_PN0P_
+ _02372_ net258 clknet_leaf_71_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[300\]
+ _00225_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[269\]$_DFFE_PN0P_
+ _02373_ net256 clknet_leaf_58_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[301\]
+ _00574_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[26\]$_DFFE_PN0P_
+ _02374_ net259 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[58\]
+ _13629_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[270\]$_DFFE_PN0P_
+ _02375_ net258 clknet_leaf_57_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[302\]
+ _00605_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[271\]$_DFFE_PN0P_
+ _02376_ net258 clknet_leaf_57_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[303\]
+ _00636_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[272\]$_DFFE_PN0P_
+ _02377_ net258 clknet_leaf_71_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[304\]
+ _00667_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[273\]$_DFFE_PN0P_
+ _02378_ net258 clknet_leaf_57_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[305\]
+ _00698_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[274\]$_DFFE_PN0P_
+ _02379_ net256 clknet_leaf_58_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[306\]
+ _00729_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[275\]$_DFFE_PN0P_
+ _02380_ net261 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[307\]
+ _00760_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[276\]$_DFFE_PN0P_
+ _02381_ net255 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[308\]
+ _00791_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[277\]$_DFFE_PN0P_
+ _02382_ net259 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[309\]
+ _00822_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[278\]$_DFFE_PN0P_
+ _02383_ net259 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[310\]
+ _00853_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[279\]$_DFFE_PN0P_
+ _02384_ net259 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[311\]
+ _00884_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[27\]$_DFFE_PN0P_
+ _02385_ net259 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[59\]
+ _13628_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[280\]$_DFFE_PN0P_
+ _02386_ net261 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[312\]
+ _00915_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[281\]$_DFFE_PN0P_
+ _02387_ net261 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[313\]
+ _00946_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[282\]$_DFFE_PN0P_
+ _02388_ net260 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[314\]
+ _00977_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[283\]$_DFFE_PN0P_
+ _02389_ net259 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[315\]
+ _01008_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[284\]$_DFFE_PN0P_
+ _02390_ net259 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[316\]
+ _01039_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[285\]$_DFFE_PN0P_
+ _02391_ net259 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[317\]
+ _01070_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[286\]$_DFFE_PN0P_
+ _02392_ net259 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[318\]
+ _01101_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[287\]$_DFFE_PN0P_
+ _02393_ net258 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[319\]
+ _01132_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[288\]$_DFFE_PN0P_
+ _02394_ net258 clknet_leaf_104_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[320\]
+ _00194_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[289\]$_DFFE_PN0P_
+ _02395_ net258 clknet_leaf_103_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[321\]
+ _00149_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[28\]$_DFFE_PN0P_
+ _02396_ net259 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[60\]
+ _13627_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[290\]$_DFFE_PN0P_
+ _02397_ net261 clknet_leaf_115_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[322\]
+ _00256_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[291\]$_DFFE_PN0P_
+ _02398_ net261 clknet_leaf_115_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[323\]
+ _00287_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[292\]$_DFFE_PN0P_
+ _02399_ net258 clknet_leaf_102_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[324\]
+ _00317_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[293\]$_DFFE_PN0P_
+ _02400_ net257 clknet_leaf_105_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[325\]
+ _00347_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[294\]$_DFFE_PN0P_
+ _02401_ net256 clknet_leaf_68_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[326\]
+ _00377_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[295\]$_DFFE_PN0P_
+ _02402_ net257 clknet_leaf_95_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[327\]
+ _00407_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[296\]$_DFFE_PN0P_
+ _02403_ net255 clknet_leaf_79_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[328\]
+ _00437_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[297\]$_DFFE_PN0P_
+ _02404_ net257 clknet_leaf_87_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[329\]
+ _00467_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[298\]$_DFFE_PN0P_
+ _02405_ net256 clknet_leaf_65_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[330\]
+ _00497_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[299\]$_DFFE_PN0P_
+ _02406_ net257 clknet_leaf_96_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[331\]
+ _00527_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[29\]$_DFFE_PN0P_
+ _02407_ net261 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[61\]
+ _13626_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[2\]$_DFFE_PN0P_
+ _02408_ net258 clknet_leaf_115_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[34\]
+ _13625_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[300\]$_DFFE_PN0P_
+ _02409_ net258 clknet_leaf_69_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[332\]
+ _00226_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[301\]$_DFFE_PN0P_
+ _02410_ net256 clknet_leaf_58_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[333\]
+ _00575_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[302\]$_DFFE_PN0P_
+ _02411_ net258 clknet_leaf_71_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[334\]
+ _00606_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[303\]$_DFFE_PN0P_
+ _02412_ net258 clknet_leaf_54_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[335\]
+ _00637_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[304\]$_DFFE_PN0P_
+ _02413_ net258 clknet_leaf_71_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[336\]
+ _00668_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[305\]$_DFFE_PN0P_
+ _02414_ net258 clknet_leaf_56_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[337\]
+ _00699_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[306\]$_DFFE_PN0P_
+ _02415_ net256 clknet_leaf_60_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[338\]
+ _00730_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[307\]$_DFFE_PN0P_
+ _02416_ net261 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[339\]
+ _00761_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[308\]$_DFFE_PN0P_
+ _02417_ net255 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[340\]
+ _00792_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[309\]$_DFFE_PN0P_
+ _02418_ net259 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[341\]
+ _00823_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[30\]$_DFFE_PN0P_
+ _02419_ net259 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[62\]
+ _13624_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[310\]$_DFFE_PN0P_
+ _02420_ net259 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[342\]
+ _00854_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[311\]$_DFFE_PN0P_
+ _02421_ net259 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[343\]
+ _00885_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[312\]$_DFFE_PN0P_
+ _02422_ net261 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[344\]
+ _00916_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[313\]$_DFFE_PN0P_
+ _02423_ net261 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[345\]
+ _00947_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[314\]$_DFFE_PN0P_
+ _02424_ net260 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[346\]
+ _00978_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[315\]$_DFFE_PN0P_
+ _02425_ net259 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[347\]
+ _01009_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[316\]$_DFFE_PN0P_
+ _02426_ net259 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[348\]
+ _01040_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[317\]$_DFFE_PN0P_
+ _02427_ net259 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[349\]
+ _01071_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[318\]$_DFFE_PN0P_
+ _02428_ net259 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[350\]
+ _01102_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[319\]$_DFFE_PN0P_
+ _02429_ net258 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[351\]
+ _01133_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[31\]$_DFFE_PN0P_
+ _02430_ net261 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[63\]
+ _13623_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[320\]$_DFFE_PN0P_
+ _02431_ net258 clknet_leaf_104_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[352\]
+ _00195_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[321\]$_DFFE_PN0P_
+ _02432_ net258 clknet_leaf_103_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[353\]
+ _00150_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[322\]$_DFFE_PN0P_
+ _02433_ net261 clknet_leaf_114_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[354\]
+ _00257_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[323\]$_DFFE_PN0P_
+ _02434_ net261 clknet_leaf_114_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[355\]
+ _00288_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[324\]$_DFFE_PN0P_
+ _02435_ net258 clknet_leaf_102_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[356\]
+ _00318_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[325\]$_DFFE_PN0P_
+ _02436_ net257 clknet_leaf_86_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[357\]
+ _00348_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[326\]$_DFFE_PN0P_
+ _02437_ net256 clknet_leaf_68_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[358\]
+ _00378_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[327\]$_DFFE_PN0P_
+ _02438_ net257 clknet_leaf_99_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[359\]
+ _00408_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[328\]$_DFFE_PN0P_
+ _02439_ net255 clknet_leaf_79_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[360\]
+ _00438_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[329\]$_DFFE_PN0P_
+ _02440_ net257 clknet_leaf_89_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[361\]
+ _00468_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[32\]$_DFFE_PN0P_
+ _02441_ net257 clknet_leaf_107_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[64\]
+ _00186_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[330\]$_DFFE_PN0P_
+ _02442_ net256 clknet_leaf_65_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[362\]
+ _00498_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[331\]$_DFFE_PN0P_
+ _02443_ net257 clknet_leaf_95_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[363\]
+ _00528_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[332\]$_DFFE_PN0P_
+ _02444_ net258 clknet_leaf_69_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[364\]
+ _00227_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[333\]$_DFFE_PN0P_
+ _02445_ net256 clknet_leaf_58_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[365\]
+ _00576_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[334\]$_DFFE_PN0P_
+ _02446_ net258 clknet_leaf_57_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[366\]
+ _00607_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[335\]$_DFFE_PN0P_
+ _02447_ net258 clknet_leaf_59_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[367\]
+ _00638_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[336\]$_DFFE_PN0P_
+ _02448_ net258 clknet_leaf_72_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[368\]
+ _00669_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[337\]$_DFFE_PN0P_
+ _02449_ net258 clknet_leaf_57_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[369\]
+ _00700_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[338\]$_DFFE_PN0P_
+ _02450_ net256 clknet_leaf_61_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[370\]
+ _00731_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[339\]$_DFFE_PN0P_
+ _02451_ net261 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[371\]
+ _00762_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[33\]$_DFFE_PN0P_
+ _02452_ net257 clknet_leaf_115_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[65\]
+ _00141_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[340\]$_DFFE_PN0P_
+ _02453_ net255 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[372\]
+ _00793_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[341\]$_DFFE_PN0P_
+ _02454_ net259 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[373\]
+ _00824_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[342\]$_DFFE_PN0P_
+ _02455_ net259 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[374\]
+ _00855_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[343\]$_DFFE_PN0P_
+ _02456_ net259 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[375\]
+ _00886_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[344\]$_DFFE_PN0P_
+ _02457_ net261 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[376\]
+ _00917_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[345\]$_DFFE_PN0P_
+ _02458_ net261 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[377\]
+ _00948_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[346\]$_DFFE_PN0P_
+ _02459_ net260 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[378\]
+ _00979_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[347\]$_DFFE_PN0P_
+ _02460_ net259 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[379\]
+ _01010_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[348\]$_DFFE_PN0P_
+ _02461_ net259 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[380\]
+ _01041_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[349\]$_DFFE_PN0P_
+ _02462_ net259 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[381\]
+ _01072_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[34\]$_DFFE_PN0P_
+ _02463_ net261 clknet_leaf_114_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[66\]
+ _00248_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[350\]$_DFFE_PN0P_
+ _02464_ net259 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[382\]
+ _01103_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[351\]$_DFFE_PN0P_
+ _02465_ net258 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[383\]
+ _01134_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[352\]$_DFFE_PN0P_
+ _02466_ net258 clknet_leaf_104_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[384\]
+ _00196_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[353\]$_DFFE_PN0P_
+ _02467_ net258 clknet_leaf_116_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[385\]
+ _00151_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[354\]$_DFFE_PN0P_
+ _02468_ net258 clknet_leaf_113_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[386\]
+ _00258_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[355\]$_DFFE_PN0P_
+ _02469_ net261 clknet_leaf_124_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[387\]
+ _00289_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[356\]$_DFFE_PN0P_
+ _02470_ net263 clknet_leaf_100_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[388\]
+ _00319_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[357\]$_DFFE_PN0P_
+ _02471_ net257 clknet_leaf_85_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[389\]
+ _00349_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[358\]$_DFFE_PN0P_
+ _02472_ net257 clknet_leaf_88_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[390\]
+ _00379_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[359\]$_DFFE_PN0P_
+ _02473_ net263 clknet_leaf_98_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[391\]
+ _00409_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[35\]$_DFFE_PN0P_
+ _02474_ net261 clknet_leaf_114_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[67\]
+ _00279_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[360\]$_DFFE_PN0P_
+ _02475_ net258 clknet_leaf_81_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[392\]
+ _00439_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[361\]$_DFFE_PN0P_
+ _02476_ net263 clknet_leaf_100_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[393\]
+ _00469_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[362\]$_DFFE_PN0P_
+ _02477_ net256 clknet_leaf_93_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[394\]
+ _00499_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[363\]$_DFFE_PN0P_
+ _02478_ net263 clknet_leaf_101_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[395\]
+ _00529_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[364\]$_DFFE_PN0P_
+ _02479_ net255 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[396\]
+ _00228_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[365\]$_DFFE_PN0P_
+ _02480_ net256 clknet_leaf_61_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[397\]
+ _00577_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[366\]$_DFFE_PN0P_
+ _02481_ net255 clknet_leaf_48_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[398\]
+ _00608_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[367\]$_DFFE_PN0P_
+ _02482_ net255 clknet_leaf_49_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[399\]
+ _00639_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[368\]$_DFFE_PN0P_
+ _02483_ net255 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[400\]
+ _00670_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[369\]$_DFFE_PN0P_
+ _02484_ net255 clknet_leaf_48_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[401\]
+ _00701_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[36\]$_DFFE_PN0P_
+ _02485_ net257 clknet_leaf_84_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[68\]
+ _00309_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[370\]$_DFFE_PN0P_
+ _02486_ net255 clknet_leaf_50_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[402\]
+ _00732_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[371\]$_DFFE_PN0P_
+ _02487_ net261 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[403\]
+ _00763_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[372\]$_DFFE_PN0P_
+ _02488_ net259 clknet_leaf_40_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[404\]
+ _00794_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[373\]$_DFFE_PN0P_
+ _02489_ net259 clknet_leaf_39_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[405\]
+ _00825_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[374\]$_DFFE_PN0P_
+ _02490_ net259 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[406\]
+ _00856_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[375\]$_DFFE_PN0P_
+ _02491_ net259 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[407\]
+ _00887_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[376\]$_DFFE_PN0P_
+ _02492_ net259 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[408\]
+ _00918_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[377\]$_DFFE_PN0P_
+ _02493_ net259 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[409\]
+ _00949_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[378\]$_DFFE_PN0P_
+ _02494_ net260 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[410\]
+ _00980_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[379\]$_DFFE_PN0P_
+ _02495_ net259 clknet_leaf_35_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[411\]
+ _01011_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[37\]$_DFFE_PN0P_
+ _02496_ net256 clknet_leaf_76_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[69\]
+ _00339_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[380\]$_DFFE_PN0P_
+ _02497_ net259 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[412\]
+ _01042_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[381\]$_DFFE_PN0P_
+ _02498_ net259 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[413\]
+ _01073_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[382\]$_DFFE_PN0P_
+ _02499_ net259 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[414\]
+ _01104_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[383\]$_DFFE_PN0P_
+ _02500_ net261 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[415\]
+ _01135_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[384\]$_DFFE_PN0P_
+ _02501_ net258 clknet_leaf_104_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[416\]
+ _00197_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[385\]$_DFFE_PN0P_
+ _02502_ net258 clknet_leaf_116_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[417\]
+ _00152_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[386\]$_DFFE_PN0P_
+ _02503_ net258 clknet_leaf_113_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[418\]
+ _00259_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[387\]$_DFFE_PN0P_
+ _02504_ net261 clknet_leaf_124_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[419\]
+ _00290_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[388\]$_DFFE_PN0P_
+ _02505_ net257 clknet_leaf_100_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[420\]
+ _00320_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[389\]$_DFFE_PN0P_
+ _02506_ net257 clknet_leaf_86_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[421\]
+ _00350_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[38\]$_DFFE_PN0P_
+ _02507_ net256 clknet_leaf_75_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[70\]
+ _00369_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[390\]$_DFFE_PN0P_
+ _02508_ net257 clknet_leaf_87_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[422\]
+ _00380_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[391\]$_DFFE_PN0P_
+ _02509_ net257 clknet_leaf_98_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[423\]
+ _00410_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[392\]$_DFFE_PN0P_
+ _02510_ net258 clknet_leaf_79_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[424\]
+ _00440_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[393\]$_DFFE_PN0P_
+ _02511_ net257 clknet_leaf_89_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[425\]
+ _00470_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[394\]$_DFFE_PN0P_
+ _02512_ net256 clknet_leaf_64_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[426\]
+ _00500_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[395\]$_DFFE_PN0P_
+ _02513_ net257 clknet_leaf_97_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[427\]
+ _00530_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[396\]$_DFFE_PN0P_
+ _02514_ net261 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[428\]
+ _00229_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[397\]$_DFFE_PN0P_
+ _02515_ net256 clknet_leaf_61_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[429\]
+ _00578_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[398\]$_DFFE_PN0P_
+ _02516_ net255 clknet_leaf_48_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[430\]
+ _00609_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[399\]$_DFFE_PN0P_
+ _02517_ net255 clknet_leaf_49_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[431\]
+ _00640_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[39\]$_DFFE_PN0P_
+ _02518_ net256 clknet_leaf_67_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[71\]
+ _00399_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[3\]$_DFFE_PN0P_
+ _02519_ net258 clknet_leaf_115_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[35\]
+ _13622_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[400\]$_DFFE_PN0P_
+ _02520_ net261 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[432\]
+ _00671_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[401\]$_DFFE_PN0P_
+ _02521_ net255 clknet_leaf_47_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[433\]
+ _00702_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[402\]$_DFFE_PN0P_
+ _02522_ net255 clknet_leaf_50_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[434\]
+ _00733_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[403\]$_DFFE_PN0P_
+ _02523_ net261 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[435\]
+ _00764_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[404\]$_DFFE_PN0P_
+ _02524_ net259 clknet_leaf_40_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[436\]
+ _00795_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[405\]$_DFFE_PN0P_
+ _02525_ net259 clknet_leaf_39_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[437\]
+ _00826_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[406\]$_DFFE_PN0P_
+ _02526_ net260 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[438\]
+ _00857_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[407\]$_DFFE_PN0P_
+ _02527_ net259 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[439\]
+ _00888_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[408\]$_DFFE_PN0P_
+ _02528_ net259 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[440\]
+ _00919_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[409\]$_DFFE_PN0P_
+ _02529_ net259 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[441\]
+ _00950_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[40\]$_DFFE_PN0P_
+ _02530_ net256 clknet_leaf_82_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[72\]
+ _00429_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[410\]$_DFFE_PN0P_
+ _02531_ net260 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[442\]
+ _00981_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[411\]$_DFFE_PN0P_
+ _02532_ net259 clknet_leaf_35_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[443\]
+ _01012_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[412\]$_DFFE_PN0P_
+ _02533_ net259 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[444\]
+ _01043_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[413\]$_DFFE_PN0P_
+ _02534_ net259 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[445\]
+ _01074_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[414\]$_DFFE_PN0P_
+ _02535_ net259 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[446\]
+ _01105_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[415\]$_DFFE_PN0P_
+ _02536_ net258 clknet_leaf_80_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[447\]
+ _01136_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[416\]$_DFFE_PN0P_
+ _02537_ net258 clknet_leaf_104_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[448\]
+ _00198_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[417\]$_DFFE_PN0P_
+ _02538_ net258 clknet_leaf_103_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[449\]
+ _00153_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[418\]$_DFFE_PN0P_
+ _02539_ net258 clknet_leaf_113_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[450\]
+ _00260_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[419\]$_DFFE_PN0P_
+ _02540_ net261 clknet_leaf_113_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[451\]
+ _00291_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[41\]$_DFFE_PN0P_
+ _02541_ net256 clknet_leaf_68_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[73\]
+ _00459_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[420\]$_DFFE_PN0P_
+ _02542_ net263 clknet_leaf_100_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[452\]
+ _00321_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[421\]$_DFFE_PN0P_
+ _02543_ net257 clknet_leaf_84_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[453\]
+ _00351_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[422\]$_DFFE_PN0P_
+ _02544_ net257 clknet_leaf_87_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[454\]
+ _00381_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[423\]$_DFFE_PN0P_
+ _02545_ net257 clknet_leaf_98_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[455\]
+ _00411_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[424\]$_DFFE_PN0P_
+ _02546_ net258 clknet_leaf_79_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[456\]
+ _00441_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[425\]$_DFFE_PN0P_
+ _02547_ net257 clknet_leaf_100_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[457\]
+ _00471_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[426\]$_DFFE_PN0P_
+ _02548_ net256 clknet_leaf_65_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[458\]
+ _00501_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[427\]$_DFFE_PN0P_
+ _02549_ net263 clknet_leaf_101_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[459\]
+ _00531_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[428\]$_DFFE_PN0P_
+ _02550_ net261 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[460\]
+ _00230_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[429\]$_DFFE_PN0P_
+ _02551_ net256 clknet_leaf_61_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[461\]
+ _00579_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[42\]$_DFFE_PN0P_
+ _02552_ net256 clknet_leaf_91_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[74\]
+ _00489_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[430\]$_DFFE_PN0P_
+ _02553_ net255 clknet_leaf_48_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[462\]
+ _00610_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[431\]$_DFFE_PN0P_
+ _02554_ net255 clknet_leaf_49_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[463\]
+ _00641_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[432\]$_DFFE_PN0P_
+ _02555_ net261 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[464\]
+ _00672_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[433\]$_DFFE_PN0P_
+ _02556_ net255 clknet_leaf_48_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[465\]
+ _00703_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[434\]$_DFFE_PN0P_
+ _02557_ net255 clknet_leaf_50_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[466\]
+ _00734_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[435\]$_DFFE_PN0P_
+ _02558_ net255 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[467\]
+ _00765_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[436\]$_DFFE_PN0P_
+ _02559_ net259 clknet_leaf_40_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[468\]
+ _00796_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[437\]$_DFFE_PN0P_
+ _02560_ net259 clknet_leaf_39_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[469\]
+ _00827_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[438\]$_DFFE_PN0P_
+ _02561_ net259 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[470\]
+ _00858_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[439\]$_DFFE_PN0P_
+ _02562_ net259 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[471\]
+ _00889_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[43\]$_DFFE_PN0P_
+ _02563_ net256 clknet_leaf_92_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[75\]
+ _00519_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[440\]$_DFFE_PN0P_
+ _02564_ net259 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[472\]
+ _00920_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[441\]$_DFFE_PN0P_
+ _02565_ net259 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[473\]
+ _00951_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[442\]$_DFFE_PN0P_
+ _02566_ net260 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[474\]
+ _00982_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[443\]$_DFFE_PN0P_
+ _02567_ net259 clknet_leaf_35_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[475\]
+ _01013_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[444\]$_DFFE_PN0P_
+ _02568_ net259 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[476\]
+ _01044_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[445\]$_DFFE_PN0P_
+ _02569_ net259 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[477\]
+ _01075_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[446\]$_DFFE_PN0P_
+ _02570_ net259 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[478\]
+ _01106_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[447\]$_DFFE_PN0P_
+ _02571_ net258 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[479\]
+ _01137_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[448\]$_DFFE_PN0P_
+ _02572_ net258 clknet_leaf_104_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[480\]
+ _00199_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[449\]$_DFFE_PN0P_
+ _02573_ net258 clknet_leaf_117_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[481\]
+ _00154_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[44\]$_DFFE_PN0P_
+ _02574_ net258 clknet_leaf_74_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[76\]
+ _00218_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[450\]$_DFFE_PN0P_
+ _02575_ net258 clknet_leaf_112_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[482\]
+ _00261_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[451\]$_DFFE_PN0P_
+ _02576_ net261 clknet_leaf_123_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[483\]
+ _00292_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[452\]$_DFFE_PN0P_
+ _02577_ net263 clknet_leaf_100_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[484\]
+ _00322_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[453\]$_DFFE_PN0P_
+ _02578_ net257 clknet_leaf_86_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[485\]
+ _00352_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[454\]$_DFFE_PN0P_
+ _02579_ net257 clknet_leaf_88_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[486\]
+ _00382_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[455\]$_DFFE_PN0P_
+ _02580_ net257 clknet_leaf_98_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[487\]
+ _00412_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[456\]$_DFFE_PN0P_
+ _02581_ net258 clknet_leaf_79_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[488\]
+ _00442_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[457\]$_DFFE_PN0P_
+ _02582_ net257 clknet_leaf_88_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[489\]
+ _00472_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[458\]$_DFFE_PN0P_
+ _02583_ net256 clknet_leaf_65_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[490\]
+ _00502_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[459\]$_DFFE_PN0P_
+ _02584_ net263 clknet_leaf_101_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[491\]
+ _00532_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[45\]$_DFFE_PN0P_
+ _02585_ net256 clknet_leaf_70_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[77\]
+ _00567_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[460\]$_DFFE_PN0P_
+ _02586_ net261 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[492\]
+ _00231_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[461\]$_DFFE_PN0P_
+ _02587_ net256 clknet_leaf_62_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[493\]
+ _00580_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[462\]$_DFFE_PN0P_
+ _02588_ net255 clknet_leaf_48_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[494\]
+ _00611_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[463\]$_DFFE_PN0P_
+ _02589_ net255 clknet_leaf_49_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[495\]
+ _00642_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[464\]$_DFFE_PN0P_
+ _02590_ net261 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[496\]
+ _00673_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[465\]$_DFFE_PN0P_
+ _02591_ net255 clknet_leaf_48_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[497\]
+ _00704_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[466\]$_DFFE_PN0P_
+ _02592_ net255 clknet_leaf_50_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[498\]
+ _00735_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[467\]$_DFFE_PN0P_
+ _02593_ net261 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[499\]
+ _00766_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[468\]$_DFFE_PN0P_
+ _02594_ net259 clknet_leaf_40_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[500\]
+ _00797_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[469\]$_DFFE_PN0P_
+ _02595_ net259 clknet_leaf_39_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[501\]
+ _00828_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[46\]$_DFFE_PN0P_
+ _02596_ net255 clknet_leaf_56_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[78\]
+ _00598_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[470\]$_DFFE_PN0P_
+ _02597_ net260 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[502\]
+ _00859_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[471\]$_DFFE_PN0P_
+ _02598_ net259 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[503\]
+ _00890_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[472\]$_DFFE_PN0P_
+ _02599_ net259 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[504\]
+ _00921_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[473\]$_DFFE_PN0P_
+ _02600_ net259 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[505\]
+ _00952_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[474\]$_DFFE_PN0P_
+ _02601_ net260 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[506\]
+ _00983_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[475\]$_DFFE_PN0P_
+ _02602_ net259 clknet_leaf_35_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[507\]
+ _01014_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[476\]$_DFFE_PN0P_
+ _02603_ net259 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[508\]
+ _01045_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[477\]$_DFFE_PN0P_
+ _02604_ net259 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[509\]
+ _01076_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[478\]$_DFFE_PN0P_
+ _02605_ net259 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[510\]
+ _01107_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[479\]$_DFFE_PN0P_
+ _02606_ net258 clknet_leaf_80_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[511\]
+ _01138_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[47\]$_DFFE_PN0P_
+ _02607_ net258 clknet_leaf_54_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[79\]
+ _00629_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[480\]$_DFFE_PN0P_
+ _02608_ net256 clknet_leaf_81_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[512\]
+ _00200_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[481\]$_DFFE_PN0P_
+ _02609_ net256 clknet_leaf_112_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[513\]
+ _00155_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[482\]$_DFFE_PN0P_
+ _02610_ net261 clknet_leaf_121_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[514\]
+ _00262_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[483\]$_DFFE_PN0P_
+ _02611_ net261 clknet_leaf_123_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[515\]
+ _00293_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[484\]$_DFFE_PN0P_
+ _02612_ net257 clknet_leaf_85_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[516\]
+ _00323_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[485\]$_DFFE_PN0P_
+ _02613_ net258 clknet_leaf_75_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[517\]
+ _00353_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[486\]$_DFFE_PN0P_
+ _02614_ net256 clknet_leaf_75_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[518\]
+ _00383_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[487\]$_DFFE_PN0P_
+ _02615_ net256 clknet_leaf_66_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[519\]
+ _00413_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[488\]$_DFFE_PN0P_
+ _02616_ net256 clknet_leaf_112_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[520\]
+ _00443_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[489\]$_DFFE_PN0P_
+ _02617_ net256 clknet_leaf_68_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[521\]
+ _00473_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[48\]$_DFFE_PN0P_
+ _02618_ net258 clknet_leaf_72_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[80\]
+ _00660_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[490\]$_DFFE_PN0P_
+ _02619_ net256 clknet_leaf_66_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[522\]
+ _00503_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[491\]$_DFFE_PN0P_
+ _02620_ net256 clknet_leaf_66_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[523\]
+ _00533_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[492\]$_DFFE_PN0P_
+ _02621_ net255 clknet_leaf_73_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[524\]
+ _00232_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[493\]$_DFFE_PN0P_
+ _02622_ net258 clknet_leaf_71_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[525\]
+ _00581_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[494\]$_DFFE_PN0P_
+ _02623_ net255 clknet_leaf_45_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[526\]
+ _00612_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[495\]$_DFFE_PN0P_
+ _02624_ net255 clknet_leaf_51_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[527\]
+ _00643_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[496\]$_DFFE_PN0P_
+ _02625_ net258 clknet_leaf_72_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[528\]
+ _00674_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[497\]$_DFFE_PN0P_
+ _02626_ net255 clknet_leaf_44_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[529\]
+ _00705_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[498\]$_DFFE_PN0P_
+ _02627_ net258 clknet_leaf_59_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[530\]
+ _00736_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[499\]$_DFFE_PN0P_
+ _02628_ net259 clknet_leaf_126_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[531\]
+ _00767_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[49\]$_DFFE_PN0P_
+ _02629_ net255 clknet_leaf_44_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[81\]
+ _00691_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[4\]$_DFFE_PN0P_
+ _02630_ net256 clknet_leaf_83_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[36\]
+ _13621_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[500\]$_DFFE_PN0P_
+ _02631_ net255 clknet_leaf_41_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[532\]
+ _00798_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[501\]$_DFFE_PN0P_
+ _02632_ net259 clknet_leaf_38_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[533\]
+ _00829_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[502\]$_DFFE_PN0P_
+ _02633_ net260 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[534\]
+ _00860_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[503\]$_DFFE_PN0P_
+ _02634_ net260 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[535\]
+ _00891_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[504\]$_DFFE_PN0P_
+ _02635_ net260 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[536\]
+ _00922_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[505\]$_DFFE_PN0P_
+ _02636_ net260 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[537\]
+ _00953_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[506\]$_DFFE_PN0P_
+ _02637_ net260 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[538\]
+ _00984_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[507\]$_DFFE_PN0P_
+ _02638_ net259 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[539\]
+ _01015_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[508\]$_DFFE_PN0P_
+ _02639_ net260 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[540\]
+ _01046_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[509\]$_DFFE_PN0P_
+ _02640_ net260 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[541\]
+ _01077_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[50\]$_DFFE_PN0P_
+ _02641_ net256 clknet_leaf_58_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[82\]
+ _00722_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[510\]$_DFFE_PN0P_
+ _02642_ net260 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[542\]
+ _01108_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[511\]$_DFFE_PN0P_
+ _02643_ net261 clknet_leaf_127_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[543\]
+ _01139_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[512\]$_DFFE_PN0P_
+ _02644_ net256 clknet_leaf_82_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[544\]
+ _00201_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[513\]$_DFFE_PN0P_
+ _02645_ net256 clknet_leaf_110_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[545\]
+ _00156_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[514\]$_DFFE_PN0P_
+ _02646_ net261 clknet_leaf_121_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[546\]
+ _00263_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[515\]$_DFFE_PN0P_
+ _02647_ net261 clknet_leaf_123_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[547\]
+ _00294_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[516\]$_DFFE_PN0P_
+ _02648_ net256 clknet_leaf_82_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[548\]
+ _00324_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[517\]$_DFFE_PN0P_
+ _02649_ net258 clknet_leaf_75_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[549\]
+ _00354_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[518\]$_DFFE_PN0P_
+ _02650_ net256 clknet_leaf_76_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[550\]
+ _00384_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[519\]$_DFFE_PN0P_
+ _02651_ net256 clknet_leaf_66_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[551\]
+ _00414_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[51\]$_DFFE_PN0P_
+ _02652_ net259 clknet_leaf_126_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[83\]
+ _00753_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[520\]$_DFFE_PN0P_
+ _02653_ net256 clknet_leaf_112_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[552\]
+ _00444_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[521\]$_DFFE_PN0P_
+ _02654_ net256 clknet_leaf_69_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[553\]
+ _00474_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[522\]$_DFFE_PN0P_
+ _02655_ net256 clknet_leaf_62_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[554\]
+ _00504_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[523\]$_DFFE_PN0P_
+ _02656_ net256 clknet_leaf_65_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[555\]
+ _00534_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[524\]$_DFFE_PN0P_
+ _02657_ net255 clknet_leaf_74_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[556\]
+ _00233_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[525\]$_DFFE_PN0P_
+ _02658_ net258 clknet_leaf_69_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[557\]
+ _00582_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[526\]$_DFFE_PN0P_
+ _02659_ net255 clknet_leaf_45_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[558\]
+ _00613_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[527\]$_DFFE_PN0P_
+ _02660_ net255 clknet_leaf_51_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[559\]
+ _00644_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[528\]$_DFFE_PN0P_
+ _02661_ net258 clknet_leaf_72_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[560\]
+ _00675_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[529\]$_DFFE_PN0P_
+ _02662_ net255 clknet_leaf_43_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[561\]
+ _00706_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[52\]$_DFFE_PN0P_
+ _02663_ net255 clknet_leaf_43_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[84\]
+ _00784_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[530\]$_DFFE_PN0P_
+ _02664_ net258 clknet_leaf_59_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[562\]
+ _00737_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[531\]$_DFFE_PN0P_
+ _02665_ net259 clknet_leaf_126_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[563\]
+ _00768_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[532\]$_DFFE_PN0P_
+ _02666_ net255 clknet_leaf_41_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[564\]
+ _00799_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[533\]$_DFFE_PN0P_
+ _02667_ net255 clknet_leaf_42_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[565\]
+ _00830_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[534\]$_DFFE_PN0P_
+ _02668_ net260 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[566\]
+ _00861_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[535\]$_DFFE_PN0P_
+ _02669_ net260 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[567\]
+ _00892_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[536\]$_DFFE_PN0P_
+ _02670_ net260 clknet_leaf_130_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[568\]
+ _00923_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[537\]$_DFFE_PN0P_
+ _02671_ net260 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[569\]
+ _00954_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[538\]$_DFFE_PN0P_
+ _02672_ net260 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[570\]
+ _00985_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[539\]$_DFFE_PN0P_
+ _02673_ net259 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[571\]
+ _01016_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[53\]$_DFFE_PN0P_
+ _02674_ net259 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[85\]
+ _00815_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[540\]$_DFFE_PN0P_
+ _02675_ net260 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[572\]
+ _01047_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[541\]$_DFFE_PN0P_
+ _02676_ net260 clknet_leaf_130_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[573\]
+ _01078_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[542\]$_DFFE_PN0P_
+ _02677_ net259 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[574\]
+ _01109_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[543\]$_DFFE_PN0P_
+ _02678_ net261 clknet_leaf_127_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[575\]
+ _01140_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[544\]$_DFFE_PN0P_
+ _02679_ net256 clknet_leaf_111_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[576\]
+ _00202_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[545\]$_DFFE_PN0P_
+ _02680_ net256 clknet_leaf_110_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[577\]
+ _00157_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[546\]$_DFFE_PN0P_
+ _02681_ net261 clknet_leaf_122_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[578\]
+ _00264_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[547\]$_DFFE_PN0P_
+ _02682_ net261 clknet_leaf_122_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[579\]
+ _00295_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[548\]$_DFFE_PN0P_
+ _02683_ net256 clknet_leaf_83_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[580\]
+ _00325_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[549\]$_DFFE_PN0P_
+ _02684_ net258 clknet_leaf_75_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[581\]
+ _00355_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[54\]$_DFFE_PN0P_
+ _02685_ net259 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[86\]
+ _00846_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[550\]$_DFFE_PN0P_
+ _02686_ net256 clknet_leaf_75_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[582\]
+ _00385_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[551\]$_DFFE_PN0P_
+ _02687_ net256 clknet_leaf_67_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[583\]
+ _00415_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[552\]$_DFFE_PN0P_
+ _02688_ net256 clknet_leaf_111_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[584\]
+ _00445_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[553\]$_DFFE_PN0P_
+ _02689_ net256 clknet_leaf_68_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[585\]
+ _00475_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[554\]$_DFFE_PN0P_
+ _02690_ net256 clknet_leaf_65_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[586\]
+ _00505_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[555\]$_DFFE_PN0P_
+ _02691_ net256 clknet_leaf_66_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[587\]
+ _00535_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[556\]$_DFFE_PN0P_
+ _02692_ net255 clknet_leaf_74_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[588\]
+ _00234_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[557\]$_DFFE_PN0P_
+ _02693_ net258 clknet_leaf_71_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[589\]
+ _00583_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[558\]$_DFFE_PN0P_
+ _02694_ net255 clknet_leaf_45_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[590\]
+ _00614_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[559\]$_DFFE_PN0P_
+ _02695_ net255 clknet_leaf_51_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[591\]
+ _00645_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[55\]$_DFFE_PN0P_
+ _02696_ net260 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[87\]
+ _00877_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[560\]$_DFFE_PN0P_
+ _02697_ net258 clknet_leaf_74_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[592\]
+ _00676_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[561\]$_DFFE_PN0P_
+ _02698_ net255 clknet_leaf_43_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[593\]
+ _00707_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[562\]$_DFFE_PN0P_
+ _02699_ net258 clknet_leaf_59_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[594\]
+ _00738_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[563\]$_DFFE_PN0P_
+ _02700_ net259 clknet_leaf_126_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[595\]
+ _00769_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[564\]$_DFFE_PN0P_
+ _02701_ net255 clknet_leaf_41_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[596\]
+ _00800_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[565\]$_DFFE_PN0P_
+ _02702_ net259 clknet_leaf_38_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[597\]
+ _00831_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[566\]$_DFFE_PN0P_
+ _02703_ net260 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[598\]
+ _00862_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[567\]$_DFFE_PN0P_
+ _02704_ net260 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[599\]
+ _00893_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[568\]$_DFFE_PN0P_
+ _02705_ net260 clknet_leaf_130_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[600\]
+ _00924_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[569\]$_DFFE_PN0P_
+ _02706_ net260 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[601\]
+ _00955_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[56\]$_DFFE_PN0P_
+ _02707_ net259 clknet_leaf_129_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[88\]
+ _00908_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[570\]$_DFFE_PN0P_
+ _02708_ net260 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[602\]
+ _00986_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[571\]$_DFFE_PN0P_
+ _02709_ net259 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[603\]
+ _01017_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[572\]$_DFFE_PN0P_
+ _02710_ net260 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[604\]
+ _01048_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[573\]$_DFFE_PN0P_
+ _02711_ net260 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[605\]
+ _01079_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[574\]$_DFFE_PN0P_
+ _02712_ net260 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[606\]
+ _01110_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[575\]$_DFFE_PN0P_
+ _02713_ net261 clknet_leaf_127_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[607\]
+ _01141_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[576\]$_DFFE_PN0P_
+ _02714_ net257 clknet_leaf_82_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[608\]
+ _00203_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[577\]$_DFFE_PN0P_
+ _02715_ net257 clknet_leaf_110_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[609\]
+ _00158_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[578\]$_DFFE_PN0P_
+ _02716_ net261 clknet_leaf_121_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[610\]
+ _00265_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[579\]$_DFFE_PN0P_
+ _02717_ net261 clknet_leaf_121_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[611\]
+ _00296_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[57\]$_DFFE_PN0P_
+ _02718_ net259 clknet_leaf_129_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[89\]
+ _00939_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[580\]$_DFFE_PN0P_
+ _02719_ net256 clknet_leaf_82_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[612\]
+ _00326_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[581\]$_DFFE_PN0P_
+ _02720_ net258 clknet_leaf_75_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[613\]
+ _00356_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[582\]$_DFFE_PN0P_
+ _02721_ net256 clknet_leaf_83_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[614\]
+ _00386_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[583\]$_DFFE_PN0P_
+ _02722_ net256 clknet_leaf_66_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[615\]
+ _00416_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[584\]$_DFFE_PN0P_
+ _02723_ net256 clknet_leaf_110_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[616\]
+ _00446_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[585\]$_DFFE_PN0P_
+ _02724_ net256 clknet_leaf_67_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[617\]
+ _00476_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[586\]$_DFFE_PN0P_
+ _02725_ net256 clknet_leaf_66_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[618\]
+ _00506_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[587\]$_DFFE_PN0P_
+ _02726_ net256 clknet_leaf_65_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[619\]
+ _00536_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[588\]$_DFFE_PN0P_
+ _02727_ net255 clknet_leaf_77_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[620\]
+ _00235_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[589\]$_DFFE_PN0P_
+ _02728_ net258 clknet_leaf_69_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[621\]
+ _00584_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[58\]$_DFFE_PN0P_
+ _02729_ net260 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[90\]
+ _00970_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[590\]$_DFFE_PN0P_
+ _02730_ net255 clknet_leaf_56_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[622\]
+ _00615_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[591\]$_DFFE_PN0P_
+ _02731_ net255 clknet_leaf_51_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[623\]
+ _00646_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[592\]$_DFFE_PN0P_
+ _02732_ net258 clknet_leaf_72_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[624\]
+ _00677_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[593\]$_DFFE_PN0P_
+ _02733_ net255 clknet_leaf_43_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[625\]
+ _00708_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[594\]$_DFFE_PN0P_
+ _02734_ net258 clknet_leaf_59_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[626\]
+ _00739_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[595\]$_DFFE_PN0P_
+ _02735_ net261 clknet_leaf_127_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[627\]
+ _00770_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[596\]$_DFFE_PN0P_
+ _02736_ net255 clknet_leaf_41_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[628\]
+ _00801_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[597\]$_DFFE_PN0P_
+ _02737_ net255 clknet_leaf_42_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[629\]
+ _00832_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[598\]$_DFFE_PN0P_
+ _02738_ net260 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[630\]
+ _00863_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[599\]$_DFFE_PN0P_
+ _02739_ net260 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[631\]
+ _00894_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[59\]$_DFFE_PN0P_
+ _02740_ net259 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[91\]
+ _01001_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[5\]$_DFFE_PN0P_
+ _02741_ net256 clknet_leaf_83_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[37\]
+ _13620_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[600\]$_DFFE_PN0P_
+ _02742_ net260 clknet_leaf_129_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[632\]
+ _00925_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[601\]$_DFFE_PN0P_
+ _02743_ net260 clknet_leaf_130_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[633\]
+ _00956_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[602\]$_DFFE_PN0P_
+ _02744_ net260 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[634\]
+ _00987_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[603\]$_DFFE_PN0P_
+ _02745_ net259 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[635\]
+ _01018_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[604\]$_DFFE_PN0P_
+ _02746_ net260 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[636\]
+ _01049_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[605\]$_DFFE_PN0P_
+ _02747_ net260 clknet_leaf_129_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[637\]
+ _01080_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[606\]$_DFFE_PN0P_
+ _02748_ net260 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[638\]
+ _01111_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[607\]$_DFFE_PN0P_
+ _02749_ net261 clknet_leaf_127_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[639\]
+ _01142_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[608\]$_DFFE_PN0P_
+ _02750_ net257 clknet_leaf_111_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[640\]
+ _00204_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[609\]$_DFFE_PN0P_
+ _02751_ net257 clknet_leaf_109_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[641\]
+ _00159_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[60\]$_DFFE_PN0P_
+ _02752_ net260 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[92\]
+ _01032_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[610\]$_DFFE_PN0P_
+ _02753_ net261 clknet_leaf_120_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[642\]
+ _00266_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[611\]$_DFFE_PN0P_
+ _02754_ net261 clknet_leaf_120_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[643\]
+ _00297_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[612\]$_DFFE_PN0P_
+ _02755_ net257 clknet_leaf_105_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[644\]
+ _00327_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[613\]$_DFFE_PN0P_
+ _02756_ net257 clknet_leaf_85_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[645\]
+ _00357_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[614\]$_DFFE_PN0P_
+ _02757_ net256 clknet_leaf_84_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[646\]
+ _00387_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[615\]$_DFFE_PN0P_
+ _02758_ net256 clknet_leaf_92_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[647\]
+ _00417_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[616\]$_DFFE_PN0P_
+ _02759_ net261 clknet_leaf_121_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[648\]
+ _00447_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[617\]$_DFFE_PN0P_
+ _02760_ net257 clknet_leaf_89_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[649\]
+ _00477_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[618\]$_DFFE_PN0P_
+ _02761_ net256 clknet_leaf_63_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[650\]
+ _00507_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[619\]$_DFFE_PN0P_
+ _02762_ net257 clknet_leaf_96_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[651\]
+ _00537_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[61\]$_DFFE_PN0P_
+ _02763_ net259 clknet_leaf_126_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[93\]
+ _01063_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[620\]$_DFFE_PN0P_
+ _02764_ net255 clknet_leaf_73_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[652\]
+ _00236_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[621\]$_DFFE_PN0P_
+ _02765_ net256 clknet_leaf_63_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[653\]
+ _00585_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[622\]$_DFFE_PN0P_
+ _02766_ net255 clknet_leaf_46_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[654\]
+ _00616_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[623\]$_DFFE_PN0P_
+ _02767_ net255 clknet_leaf_51_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[655\]
+ _00647_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[624\]$_DFFE_PN0P_
+ _02768_ net255 clknet_leaf_73_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[656\]
+ _00678_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[625\]$_DFFE_PN0P_
+ _02769_ net255 clknet_leaf_47_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[657\]
+ _00709_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[626\]$_DFFE_PN0P_
+ _02770_ net258 clknet_leaf_53_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[658\]
+ _00740_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[627\]$_DFFE_PN0P_
+ _02771_ net260 clknet_leaf_134_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[659\]
+ _00771_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[628\]$_DFFE_PN0P_
+ _02772_ net255 clknet_leaf_38_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[660\]
+ _00802_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[629\]$_DFFE_PN0P_
+ _02773_ net259 clknet_leaf_37_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[661\]
+ _00833_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[62\]$_DFFE_PN0P_
+ _02774_ net259 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[94\]
+ _01094_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[630\]$_DFFE_PN0P_
+ _02775_ net260 clknet_leaf_136_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[662\]
+ _00864_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[631\]$_DFFE_PN0P_
+ _02776_ net260 clknet_leaf_138_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[663\]
+ _00895_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[632\]$_DFFE_PN0P_
+ _02777_ net260 clknet_leaf_132_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[664\]
+ _00926_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[633\]$_DFFE_PN0P_
+ _02778_ net260 clknet_leaf_133_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[665\]
+ _00957_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[634\]$_DFFE_PN0P_
+ _02779_ net260 clknet_leaf_137_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[666\]
+ _00988_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[635\]$_DFFE_PN0P_
+ _02780_ net259 clknet_leaf_37_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[667\]
+ _01019_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[636\]$_DFFE_PN0P_
+ _02781_ net260 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[668\]
+ _01050_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[637\]$_DFFE_PN0P_
+ _02782_ net260 clknet_leaf_133_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[669\]
+ _01081_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[638\]$_DFFE_PN0P_
+ _02783_ net260 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[670\]
+ _01112_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[639\]$_DFFE_PN0P_
+ _02784_ net260 clknet_leaf_135_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[671\]
+ _01143_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[63\]$_DFFE_PN0P_
+ _02785_ net261 clknet_leaf_125_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[95\]
+ _01125_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[640\]$_DFFE_PN0P_
+ _02786_ net257 clknet_leaf_111_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[672\]
+ _00205_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[641\]$_DFFE_PN0P_
+ _02787_ net257 clknet_leaf_109_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[673\]
+ _00160_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[642\]$_DFFE_PN0P_
+ _02788_ net260 clknet_leaf_120_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[674\]
+ _00267_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[643\]$_DFFE_PN0P_
+ _02789_ net260 clknet_leaf_119_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[675\]
+ _00298_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[644\]$_DFFE_PN0P_
+ _02790_ net257 clknet_leaf_106_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[676\]
+ _00328_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[645\]$_DFFE_PN0P_
+ _02791_ net257 clknet_leaf_85_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[677\]
+ _00358_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[646\]$_DFFE_PN0P_
+ _02792_ net256 clknet_leaf_90_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[678\]
+ _00388_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[647\]$_DFFE_PN0P_
+ _02793_ net257 clknet_leaf_94_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[679\]
+ _00418_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[648\]$_DFFE_PN0P_
+ _02794_ net258 clknet_leaf_112_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[680\]
+ _00448_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[649\]$_DFFE_PN0P_
+ _02795_ net257 clknet_leaf_89_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[681\]
+ _00478_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[64\]$_DFFE_PN0P_
+ _02796_ net257 clknet_leaf_111_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[96\]
+ _00187_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[650\]$_DFFE_PN0P_
+ _02797_ net256 clknet_leaf_64_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[682\]
+ _00508_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[651\]$_DFFE_PN0P_
+ _02798_ net263 clknet_leaf_96_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[683\]
+ _00538_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[652\]$_DFFE_PN0P_
+ _02799_ net255 clknet_leaf_77_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[684\]
+ _00237_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[653\]$_DFFE_PN0P_
+ _02800_ net256 clknet_leaf_63_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[685\]
+ _00586_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[654\]$_DFFE_PN0P_
+ _02801_ net255 clknet_leaf_46_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[686\]
+ _00617_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[655\]$_DFFE_PN0P_
+ _02802_ net255 clknet_leaf_52_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[687\]
+ _00648_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[656\]$_DFFE_PN0P_
+ _02803_ net255 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[688\]
+ _00679_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[657\]$_DFFE_PN0P_
+ _02804_ net255 clknet_leaf_47_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[689\]
+ _00710_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[658\]$_DFFE_PN0P_
+ _02805_ net256 clknet_leaf_60_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[690\]
+ _00741_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[659\]$_DFFE_PN0P_
+ _02806_ net260 clknet_leaf_133_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[691\]
+ _00772_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[65\]$_DFFE_PN0P_
+ _02807_ net257 clknet_leaf_115_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[97\]
+ _00142_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[660\]$_DFFE_PN0P_
+ _02808_ net255 clknet_leaf_41_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[692\]
+ _00803_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[661\]$_DFFE_PN0P_
+ _02809_ net259 clknet_leaf_37_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[693\]
+ _00834_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[662\]$_DFFE_PN0P_
+ _02810_ net260 clknet_leaf_136_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[694\]
+ _00865_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[663\]$_DFFE_PN0P_
+ _02811_ net260 clknet_leaf_138_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[695\]
+ _00896_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[664\]$_DFFE_PN0P_
+ _02812_ net260 clknet_leaf_132_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[696\]
+ _00927_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[665\]$_DFFE_PN0P_
+ _02813_ net260 clknet_leaf_133_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[697\]
+ _00958_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[666\]$_DFFE_PN0P_
+ _02814_ net260 clknet_leaf_137_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[698\]
+ _00989_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[667\]$_DFFE_PN0P_
+ _02815_ net259 clknet_leaf_37_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[699\]
+ _01020_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[668\]$_DFFE_PN0P_
+ _02816_ net260 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[700\]
+ _01051_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[669\]$_DFFE_PN0P_
+ _02817_ net260 clknet_leaf_132_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[701\]
+ _01082_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[66\]$_DFFE_PN0P_
+ _02818_ net261 clknet_leaf_115_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[98\]
+ _00249_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[670\]$_DFFE_PN0P_
+ _02819_ net260 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[702\]
+ _01113_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[671\]$_DFFE_PN0P_
+ _02820_ net260 clknet_leaf_135_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[703\]
+ _01144_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[672\]$_DFFE_PN0P_
+ _02821_ net257 clknet_leaf_111_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[704\]
+ _00206_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[673\]$_DFFE_PN0P_
+ _02822_ net257 clknet_leaf_109_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[705\]
+ _00161_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[674\]$_DFFE_PN0P_
+ _02823_ net261 clknet_leaf_120_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[706\]
+ _00268_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[675\]$_DFFE_PN0P_
+ _02824_ net261 clknet_leaf_120_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[707\]
+ _00299_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[676\]$_DFFE_PN0P_
+ _02825_ net257 clknet_leaf_106_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[708\]
+ _00329_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[677\]$_DFFE_PN0P_
+ _02826_ net257 clknet_leaf_82_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[709\]
+ _00359_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[678\]$_DFFE_PN0P_
+ _02827_ net256 clknet_leaf_84_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[710\]
+ _00389_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[679\]$_DFFE_PN0P_
+ _02828_ net257 clknet_leaf_94_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[711\]
+ _00419_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[67\]$_DFFE_PN0P_
+ _02829_ net261 clknet_leaf_113_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[99\]
+ _00280_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[680\]$_DFFE_PN0P_
+ _02830_ net258 clknet_leaf_112_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[712\]
+ _00449_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[681\]$_DFFE_PN0P_
+ _02831_ net257 clknet_leaf_92_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[713\]
+ _00479_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[682\]$_DFFE_PN0P_
+ _02832_ net256 clknet_leaf_64_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[714\]
+ _00509_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[683\]$_DFFE_PN0P_
+ _02833_ net263 clknet_leaf_96_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[715\]
+ _00539_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[684\]$_DFFE_PN0P_
+ _02834_ net255 clknet_leaf_73_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[716\]
+ _00238_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[685\]$_DFFE_PN0P_
+ _02835_ net256 clknet_leaf_66_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[717\]
+ _00587_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[686\]$_DFFE_PN0P_
+ _02836_ net255 clknet_leaf_46_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[718\]
+ _00618_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[687\]$_DFFE_PN0P_
+ _02837_ net255 clknet_leaf_52_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[719\]
+ _00649_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[688\]$_DFFE_PN0P_
+ _02838_ net255 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[720\]
+ _00680_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[689\]$_DFFE_PN0P_
+ _02839_ net255 clknet_leaf_47_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[721\]
+ _00711_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[68\]$_DFFE_PN0P_
+ _02840_ net256 clknet_leaf_83_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[100\]
+ _00310_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[690\]$_DFFE_PN0P_
+ _02841_ net256 clknet_leaf_53_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[722\]
+ _00742_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[691\]$_DFFE_PN0P_
+ _02842_ net260 clknet_leaf_134_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[723\]
+ _00773_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[692\]$_DFFE_PN0P_
+ _02843_ net255 clknet_leaf_39_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[724\]
+ _00804_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[693\]$_DFFE_PN0P_
+ _02844_ net259 clknet_leaf_37_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[725\]
+ _00835_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[694\]$_DFFE_PN0P_
+ _02845_ net260 clknet_leaf_136_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[726\]
+ _00866_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[695\]$_DFFE_PN0P_
+ _02846_ net260 clknet_leaf_138_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[727\]
+ _00897_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[696\]$_DFFE_PN0P_
+ _02847_ net260 clknet_leaf_132_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[728\]
+ _00928_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[697\]$_DFFE_PN0P_
+ _02848_ net260 clknet_leaf_133_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[729\]
+ _00959_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[698\]$_DFFE_PN0P_
+ _02849_ net260 clknet_leaf_137_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[730\]
+ _00990_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[699\]$_DFFE_PN0P_
+ _02850_ net259 clknet_leaf_37_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[731\]
+ _01021_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[69\]$_DFFE_PN0P_
+ _02851_ net258 clknet_leaf_76_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[101\]
+ _00340_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[6\]$_DFFE_PN0P_
+ _02852_ net256 clknet_leaf_75_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[38\]
+ _13619_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[700\]$_DFFE_PN0P_
+ _02853_ net260 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[732\]
+ _01052_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[701\]$_DFFE_PN0P_
+ _02854_ net260 clknet_leaf_133_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[733\]
+ _01083_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[702\]$_DFFE_PN0P_
+ _02855_ net260 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[734\]
+ _01114_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[703\]$_DFFE_PN0P_
+ _02856_ net260 clknet_leaf_135_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[735\]
+ _01145_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[704\]$_DFFE_PN0P_
+ _02857_ net257 clknet_leaf_107_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[736\]
+ _00207_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[705\]$_DFFE_PN0P_
+ _02858_ net257 clknet_leaf_109_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[737\]
+ _00162_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[706\]$_DFFE_PN0P_
+ _02859_ net261 clknet_leaf_120_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[738\]
+ _00269_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[707\]$_DFFE_PN0P_
+ _02860_ net260 clknet_leaf_120_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[739\]
+ _00300_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[708\]$_DFFE_PN0P_
+ _02861_ net257 clknet_leaf_106_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[740\]
+ _00330_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[709\]$_DFFE_PN0P_
+ _02862_ net257 clknet_leaf_85_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[741\]
+ _00360_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[70\]$_DFFE_PN0P_
+ _02863_ net256 clknet_leaf_68_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[102\]
+ _00370_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[710\]$_DFFE_PN0P_
+ _02864_ net256 clknet_leaf_84_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[742\]
+ _00390_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[711\]$_DFFE_PN0P_
+ _02865_ net257 clknet_leaf_95_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[743\]
+ _00420_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[712\]$_DFFE_PN0P_
+ _02866_ net256 clknet_leaf_112_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[744\]
+ _00450_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[713\]$_DFFE_PN0P_
+ _02867_ net257 clknet_leaf_89_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[745\]
+ _00480_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[714\]$_DFFE_PN0P_
+ _02868_ net256 clknet_leaf_64_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[746\]
+ _00510_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[715\]$_DFFE_PN0P_
+ _02869_ net263 clknet_leaf_96_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[747\]
+ _00540_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[716\]$_DFFE_PN0P_
+ _02870_ net255 clknet_leaf_77_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[748\]
+ _00239_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[717\]$_DFFE_PN0P_
+ _02871_ net256 clknet_leaf_62_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[749\]
+ _00588_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[718\]$_DFFE_PN0P_
+ _02872_ net255 clknet_leaf_45_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[750\]
+ _00619_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[719\]$_DFFE_PN0P_
+ _02873_ net256 clknet_leaf_52_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[751\]
+ _00650_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[71\]$_DFFE_PN0P_
+ _02874_ net256 clknet_leaf_67_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[103\]
+ _00400_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[720\]$_DFFE_PN0P_
+ _02875_ net255 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[752\]
+ _00681_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[721\]$_DFFE_PN0P_
+ _02876_ net255 clknet_leaf_45_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[753\]
+ _00712_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[722\]$_DFFE_PN0P_
+ _02877_ net256 clknet_leaf_60_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[754\]
+ _00743_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[723\]$_DFFE_PN0P_
+ _02878_ net260 clknet_leaf_134_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[755\]
+ _00774_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[724\]$_DFFE_PN0P_
+ _02879_ net255 clknet_leaf_42_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[756\]
+ _00805_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[725\]$_DFFE_PN0P_
+ _02880_ net259 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[757\]
+ _00836_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[726\]$_DFFE_PN0P_
+ _02881_ net260 clknet_leaf_131_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[758\]
+ _00867_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[727\]$_DFFE_PN0P_
+ _02882_ net260 clknet_leaf_138_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[759\]
+ _00898_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[728\]$_DFFE_PN0P_
+ _02883_ net260 clknet_leaf_132_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[760\]
+ _00929_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[729\]$_DFFE_PN0P_
+ _02884_ net260 clknet_leaf_133_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[761\]
+ _00960_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[72\]$_DFFE_PN0P_
+ _02885_ net258 clknet_leaf_77_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[104\]
+ _00430_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[730\]$_DFFE_PN0P_
+ _02886_ net260 clknet_leaf_137_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[762\]
+ _00991_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[731\]$_DFFE_PN0P_
+ _02887_ net259 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[763\]
+ _01022_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[732\]$_DFFE_PN0P_
+ _02888_ net260 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[764\]
+ _01053_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[733\]$_DFFE_PN0P_
+ _02889_ net260 clknet_leaf_133_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[765\]
+ _01084_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[734\]$_DFFE_PN0P_
+ _02890_ net260 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[766\]
+ _01115_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[735\]$_DFFE_PN0P_
+ _02891_ net260 clknet_leaf_135_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[767\]
+ _01146_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[736\]$_DFFE_PN0P_
+ _02892_ net257 clknet_leaf_108_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[768\]
+ _00208_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[737\]$_DFFE_PN0P_
+ _02893_ net257 clknet_leaf_110_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[769\]
+ _00163_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[738\]$_DFFE_PN0P_
+ _02894_ net261 clknet_leaf_122_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[770\]
+ _00270_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[739\]$_DFFE_PN0P_
+ _02895_ net261 clknet_leaf_122_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[771\]
+ _00301_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[73\]$_DFFE_PN0P_
+ _02896_ net256 clknet_leaf_67_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[105\]
+ _00460_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[740\]$_DFFE_PN0P_
+ _02897_ net257 clknet_leaf_105_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[772\]
+ _00331_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[741\]$_DFFE_PN0P_
+ _02898_ net258 clknet_leaf_76_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[773\]
+ _00361_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[742\]$_DFFE_PN0P_
+ _02899_ net256 clknet_leaf_90_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[774\]
+ _00391_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[743\]$_DFFE_PN0P_
+ _02900_ net256 clknet_leaf_92_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[775\]
+ _00421_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[744\]$_DFFE_PN0P_
+ _02901_ net256 clknet_leaf_81_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[776\]
+ _00451_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[745\]$_DFFE_PN0P_
+ _02902_ net257 clknet_leaf_88_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[777\]
+ _00481_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[746\]$_DFFE_PN0P_
+ _02903_ net256 clknet_leaf_63_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[778\]
+ _00511_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[747\]$_DFFE_PN0P_
+ _02904_ net263 clknet_leaf_96_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[779\]
+ _00541_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[748\]$_DFFE_PN0P_
+ _02905_ net255 clknet_leaf_74_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[780\]
+ _00240_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[749\]$_DFFE_PN0P_
+ _02906_ net258 clknet_leaf_70_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[781\]
+ _00589_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[74\]$_DFFE_PN0P_
+ _02907_ net256 clknet_leaf_67_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[106\]
+ _00490_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[750\]$_DFFE_PN0P_
+ _02908_ net255 clknet_leaf_45_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[782\]
+ _00620_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[751\]$_DFFE_PN0P_
+ _02909_ net256 clknet_leaf_52_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[783\]
+ _00651_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[752\]$_DFFE_PN0P_
+ _02910_ net255 clknet_leaf_73_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[784\]
+ _00682_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[753\]$_DFFE_PN0P_
+ _02911_ net255 clknet_leaf_44_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[785\]
+ _00713_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[754\]$_DFFE_PN0P_
+ _02912_ net256 clknet_leaf_60_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[786\]
+ _00744_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[755\]$_DFFE_PN0P_
+ _02913_ net260 clknet_leaf_134_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[787\]
+ _00775_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[756\]$_DFFE_PN0P_
+ _02914_ net255 clknet_leaf_40_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[788\]
+ _00806_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[757\]$_DFFE_PN0P_
+ _02915_ net259 clknet_leaf_38_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[789\]
+ _00837_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[758\]$_DFFE_PN0P_
+ _02916_ net260 clknet_leaf_136_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[790\]
+ _00868_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[759\]$_DFFE_PN0P_
+ _02917_ net260 clknet_leaf_138_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[791\]
+ _00899_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[75\]$_DFFE_PN0P_
+ _02918_ net256 clknet_leaf_91_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[107\]
+ _00520_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[760\]$_DFFE_PN0P_
+ _02919_ net260 clknet_leaf_130_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[792\]
+ _00930_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[761\]$_DFFE_PN0P_
+ _02920_ net260 clknet_leaf_131_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[793\]
+ _00961_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[762\]$_DFFE_PN0P_
+ _02921_ net260 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[794\]
+ _00992_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[763\]$_DFFE_PN0P_
+ _02922_ net259 clknet_leaf_34_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[795\]
+ _01023_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[764\]$_DFFE_PN0P_
+ _02923_ net260 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[796\]
+ _01054_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[765\]$_DFFE_PN0P_
+ _02924_ net260 clknet_leaf_131_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[797\]
+ _01085_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[766\]$_DFFE_PN0P_
+ _02925_ net259 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[798\]
+ _01116_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[767\]$_DFFE_PN0P_
+ _02926_ net260 clknet_leaf_128_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[799\]
+ _01147_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[768\]$_DFFE_PN0P_
+ _02927_ net257 clknet_leaf_108_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[800\]
+ _00209_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[769\]$_DFFE_PN0P_
+ _02928_ net257 clknet_leaf_108_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[801\]
+ _00164_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[76\]$_DFFE_PN0P_
+ _02929_ net258 clknet_leaf_73_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[108\]
+ _00219_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[770\]$_DFFE_PN0P_
+ _02930_ net260 clknet_leaf_119_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[802\]
+ _00271_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[771\]$_DFFE_PN0P_
+ _02931_ net260 clknet_leaf_119_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[803\]
+ _00302_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[772\]$_DFFE_PN0P_
+ _02932_ net257 clknet_leaf_86_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[804\]
+ _00332_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[773\]$_DFFE_PN0P_
+ _02933_ net258 clknet_leaf_76_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[805\]
+ _00362_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[774\]$_DFFE_PN0P_
+ _02934_ net257 clknet_leaf_88_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[806\]
+ _00392_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[775\]$_DFFE_PN0P_
+ _02935_ net256 clknet_leaf_94_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[807\]
+ _00422_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[776\]$_DFFE_PN0P_
+ _02936_ net256 clknet_leaf_81_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[808\]
+ _00452_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[777\]$_DFFE_PN0P_
+ _02937_ net257 clknet_leaf_99_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[809\]
+ _00482_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[778\]$_DFFE_PN0P_
+ _02938_ net256 clknet_leaf_62_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[810\]
+ _00512_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[779\]$_DFFE_PN0P_
+ _02939_ net263 clknet_leaf_96_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[811\]
+ _00542_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[77\]$_DFFE_PN0P_
+ _02940_ net256 clknet_leaf_70_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[109\]
+ _00568_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[780\]$_DFFE_PN0P_
+ _02941_ net258 clknet_leaf_74_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[812\]
+ _00241_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[781\]$_DFFE_PN0P_
+ _02942_ net256 clknet_leaf_57_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[813\]
+ _00590_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[782\]$_DFFE_PN0P_
+ _02943_ net255 clknet_leaf_55_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[814\]
+ _00621_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[783\]$_DFFE_PN0P_
+ _02944_ net256 clknet_leaf_52_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[815\]
+ _00652_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[784\]$_DFFE_PN0P_
+ _02945_ net255 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[816\]
+ _00683_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[785\]$_DFFE_PN0P_
+ _02946_ net255 clknet_leaf_44_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[817\]
+ _00714_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[786\]$_DFFE_PN0P_
+ _02947_ net256 clknet_leaf_60_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[818\]
+ _00745_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[787\]$_DFFE_PN0P_
+ _02948_ net260 clknet_leaf_134_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[819\]
+ _00776_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[788\]$_DFFE_PN0P_
+ _02949_ net255 clknet_leaf_41_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[820\]
+ _00807_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[789\]$_DFFE_PN0P_
+ _02950_ net259 clknet_leaf_38_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[821\]
+ _00838_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[78\]$_DFFE_PN0P_
+ _02951_ net255 clknet_leaf_44_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[110\]
+ _00599_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[790\]$_DFFE_PN0P_
+ _02952_ net260 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[822\]
+ _00869_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[791\]$_DFFE_PN0P_
+ _02953_ net260 clknet_leaf_139_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[823\]
+ _00900_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[792\]$_DFFE_PN0P_
+ _02954_ net260 clknet_leaf_132_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[824\]
+ _00931_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[793\]$_DFFE_PN0P_
+ _02955_ net260 clknet_leaf_131_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[825\]
+ _00962_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[794\]$_DFFE_PN0P_
+ _02956_ net260 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[826\]
+ _00993_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[795\]$_DFFE_PN0P_
+ _02957_ net259 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[827\]
+ _01024_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[796\]$_DFFE_PN0P_
+ _02958_ net260 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[828\]
+ _01055_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[797\]$_DFFE_PN0P_
+ _02959_ net260 clknet_leaf_131_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[829\]
+ _01086_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[798\]$_DFFE_PN0P_
+ _02960_ net260 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[830\]
+ _01117_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[799\]$_DFFE_PN0P_
+ _02961_ net260 clknet_leaf_134_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[831\]
+ _01148_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[79\]$_DFFE_PN0P_
+ _02962_ net258 clknet_leaf_55_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[111\]
+ _00630_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[7\]$_DFFE_PN0P_
+ _02963_ net256 clknet_leaf_91_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[39\]
+ _13618_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[800\]$_DFFE_PN0P_
+ _02964_ net257 clknet_leaf_108_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[832\]
+ _00210_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[801\]$_DFFE_PN0P_
+ _02965_ net257 clknet_leaf_110_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[833\]
+ _00165_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[802\]$_DFFE_PN0P_
+ _02966_ net260 clknet_leaf_119_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[834\]
+ _00272_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[803\]$_DFFE_PN0P_
+ _02967_ net260 clknet_leaf_119_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[835\]
+ _00303_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[804\]$_DFFE_PN0P_
+ _02968_ net257 clknet_leaf_86_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[836\]
+ _00333_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[805\]$_DFFE_PN0P_
+ _02969_ net258 clknet_leaf_77_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[837\]
+ _00363_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[806\]$_DFFE_PN0P_
+ _02970_ net257 clknet_leaf_87_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[838\]
+ _00393_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[807\]$_DFFE_PN0P_
+ _02971_ net256 clknet_leaf_93_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[839\]
+ _00423_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[808\]$_DFFE_PN0P_
+ _02972_ net256 clknet_leaf_82_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[840\]
+ _00453_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[809\]$_DFFE_PN0P_
+ _02973_ net257 clknet_leaf_100_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[841\]
+ _00483_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[80\]$_DFFE_PN0P_
+ _02974_ net258 clknet_leaf_72_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[112\]
+ _00661_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[810\]$_DFFE_PN0P_
+ _02975_ net256 clknet_leaf_62_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[842\]
+ _00513_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[811\]$_DFFE_PN0P_
+ _02976_ net263 clknet_leaf_96_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[843\]
+ _00543_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[812\]$_DFFE_PN0P_
+ _02977_ net255 clknet_leaf_74_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[844\]
+ _00242_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[813\]$_DFFE_PN0P_
+ _02978_ net258 clknet_leaf_70_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[845\]
+ _00591_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[814\]$_DFFE_PN0P_
+ _02979_ net258 clknet_leaf_56_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[846\]
+ _00622_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[815\]$_DFFE_PN0P_
+ _02980_ net258 clknet_leaf_53_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[847\]
+ _00653_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[816\]$_DFFE_PN0P_
+ _02981_ net255 clknet_leaf_73_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[848\]
+ _00684_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[817\]$_DFFE_PN0P_
+ _02982_ net255 clknet_leaf_44_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[849\]
+ _00715_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[818\]$_DFFE_PN0P_
+ _02983_ net256 clknet_leaf_59_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[850\]
+ _00746_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[819\]$_DFFE_PN0P_
+ _02984_ net260 clknet_leaf_135_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[851\]
+ _00777_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[81\]$_DFFE_PN0P_
+ _02985_ net255 clknet_leaf_44_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[113\]
+ _00692_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[820\]$_DFFE_PN0P_
+ _02986_ net255 clknet_leaf_41_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[852\]
+ _00808_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[821\]$_DFFE_PN0P_
+ _02987_ net259 clknet_leaf_38_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[853\]
+ _00839_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[822\]$_DFFE_PN0P_
+ _02988_ net260 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[854\]
+ _00870_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[823\]$_DFFE_PN0P_
+ _02989_ net260 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[855\]
+ _00901_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[824\]$_DFFE_PN0P_
+ _02990_ net260 clknet_leaf_132_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[856\]
+ _00932_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[825\]$_DFFE_PN0P_
+ _02991_ net260 clknet_leaf_131_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[857\]
+ _00963_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[826\]$_DFFE_PN0P_
+ _02992_ net260 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[858\]
+ _00994_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[827\]$_DFFE_PN0P_
+ _02993_ net259 clknet_leaf_34_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[859\]
+ _01025_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[828\]$_DFFE_PN0P_
+ _02994_ net260 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[860\]
+ _01056_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[829\]$_DFFE_PN0P_
+ _02995_ net260 clknet_leaf_136_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[861\]
+ _01087_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[82\]$_DFFE_PN0P_
+ _02996_ net258 clknet_leaf_59_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[114\]
+ _00723_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[830\]$_DFFE_PN0P_
+ _02997_ net259 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[862\]
+ _01118_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[831\]$_DFFE_PN0P_
+ _02998_ net260 clknet_leaf_135_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[863\]
+ _01149_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[832\]$_DFFE_PN0P_
+ _02999_ net258 clknet_leaf_108_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[864\]
+ _00211_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[833\]$_DFFE_PN0P_
+ _03000_ net257 clknet_leaf_109_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[865\]
+ _00166_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[834\]$_DFFE_PN0P_
+ _03001_ net260 clknet_leaf_119_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[866\]
+ _00273_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[835\]$_DFFE_PN0P_
+ _03002_ net260 clknet_leaf_119_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[867\]
+ _00304_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[836\]$_DFFE_PN0P_
+ _03003_ net258 clknet_leaf_105_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[868\]
+ _00334_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[837\]$_DFFE_PN0P_
+ _03004_ net256 clknet_leaf_76_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[869\]
+ _00364_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[838\]$_DFFE_PN0P_
+ _03005_ net257 clknet_leaf_88_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[870\]
+ _00394_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[839\]$_DFFE_PN0P_
+ _03006_ net256 clknet_leaf_93_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[871\]
+ _00424_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[83\]$_DFFE_PN0P_
+ _03007_ net261 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[115\]
+ _00754_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[840\]$_DFFE_PN0P_
+ _03008_ net258 clknet_leaf_81_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[872\]
+ _00454_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[841\]$_DFFE_PN0P_
+ _03009_ net257 clknet_leaf_99_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[873\]
+ _00484_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[842\]$_DFFE_PN0P_
+ _03010_ net256 clknet_leaf_63_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[874\]
+ _00514_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[843\]$_DFFE_PN0P_
+ _03011_ net263 clknet_leaf_97_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[875\]
+ _00544_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[844\]$_DFFE_PN0P_
+ _03012_ net258 clknet_leaf_74_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[876\]
+ _00243_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[845\]$_DFFE_PN0P_
+ _03013_ net256 clknet_leaf_70_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[877\]
+ _00592_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[846\]$_DFFE_PN0P_
+ _03014_ net258 clknet_leaf_55_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[878\]
+ _00623_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[847\]$_DFFE_PN0P_
+ _03015_ net258 clknet_leaf_53_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[879\]
+ _00654_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[848\]$_DFFE_PN0P_
+ _03016_ net255 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[880\]
+ _00685_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[849\]$_DFFE_PN0P_
+ _03017_ net255 clknet_leaf_44_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[881\]
+ _00716_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[84\]$_DFFE_PN0P_
+ _03018_ net255 clknet_leaf_43_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[116\]
+ _00785_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[850\]$_DFFE_PN0P_
+ _03019_ net256 clknet_leaf_60_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[882\]
+ _00747_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[851\]$_DFFE_PN0P_
+ _03020_ net260 clknet_leaf_134_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[883\]
+ _00778_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[852\]$_DFFE_PN0P_
+ _03021_ net255 clknet_leaf_40_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[884\]
+ _00809_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[853\]$_DFFE_PN0P_
+ _03022_ net259 clknet_leaf_38_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[885\]
+ _00840_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[854\]$_DFFE_PN0P_
+ _03023_ net260 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[886\]
+ _00871_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[855\]$_DFFE_PN0P_
+ _03024_ net260 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[887\]
+ _00902_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[856\]$_DFFE_PN0P_
+ _03025_ net260 clknet_leaf_131_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[888\]
+ _00933_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[857\]$_DFFE_PN0P_
+ _03026_ net260 clknet_leaf_131_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[889\]
+ _00964_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[858\]$_DFFE_PN0P_
+ _03027_ net260 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[890\]
+ _00995_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[859\]$_DFFE_PN0P_
+ _03028_ net259 clknet_leaf_34_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[891\]
+ _01026_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[85\]$_DFFE_PN0P_
+ _03029_ net255 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[117\]
+ _00816_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[860\]$_DFFE_PN0P_
+ _03030_ net260 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[892\]
+ _01057_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[861\]$_DFFE_PN0P_
+ _03031_ net260 clknet_leaf_132_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[893\]
+ _01088_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[862\]$_DFFE_PN0P_
+ _03032_ net260 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[894\]
+ _01119_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[863\]$_DFFE_PN0P_
+ _03033_ net260 clknet_leaf_135_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[895\]
+ _01150_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[864\]$_DFFE_PN0P_
+ _03034_ net257 clknet_leaf_106_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[896\]
+ _00212_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[865\]$_DFFE_PN0P_
+ _03035_ net258 clknet_leaf_116_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[897\]
+ _00167_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[866\]$_DFFE_PN0P_
+ _03036_ net261 clknet_leaf_122_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[898\]
+ _00274_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[867\]$_DFFE_PN0P_
+ _03037_ net261 clknet_leaf_124_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[899\]
+ _00305_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[868\]$_DFFE_PN0P_
+ _03038_ net257 clknet_leaf_87_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[900\]
+ _00335_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[869\]$_DFFE_PN0P_
+ _03039_ net256 clknet_leaf_76_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[901\]
+ _00365_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[86\]$_DFFE_PN0P_
+ _03040_ net259 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[118\]
+ _00847_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[870\]$_DFFE_PN0P_
+ _03041_ net257 clknet_leaf_86_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[902\]
+ _00395_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[871\]$_DFFE_PN0P_
+ _03042_ net257 clknet_leaf_97_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[903\]
+ _00425_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[872\]$_DFFE_PN0P_
+ _03043_ net258 clknet_leaf_80_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[904\]
+ _00455_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[873\]$_DFFE_PN0P_
+ _03044_ net257 clknet_leaf_99_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[905\]
+ _00485_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[874\]$_DFFE_PN0P_
+ _03045_ net256 clknet_leaf_63_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[906\]
+ _00515_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[875\]$_DFFE_PN0P_
+ _03046_ net263 clknet_leaf_97_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[907\]
+ _00545_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[876\]$_DFFE_PN0P_
+ _03047_ net255 clknet_leaf_78_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[908\]
+ _00244_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[877\]$_DFFE_PN0P_
+ _03048_ net256 clknet_leaf_70_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[909\]
+ _00593_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[878\]$_DFFE_PN0P_
+ _03049_ net255 clknet_leaf_46_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[910\]
+ _00624_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[879\]$_DFFE_PN0P_
+ _03050_ net255 clknet_leaf_51_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[911\]
+ _00655_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[87\]$_DFFE_PN0P_
+ _03051_ net259 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[119\]
+ _00878_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[880\]$_DFFE_PN0P_
+ _03052_ net255 clknet_leaf_78_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[912\]
+ _00686_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[881\]$_DFFE_PN0P_
+ _03053_ net255 clknet_leaf_47_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[913\]
+ _00717_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[882\]$_DFFE_PN0P_
+ _03054_ net258 clknet_leaf_53_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[914\]
+ _00748_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[883\]$_DFFE_PN0P_
+ _03055_ net261 clknet_leaf_129_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[915\]
+ _00779_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[884\]$_DFFE_PN0P_
+ _03056_ net255 clknet_leaf_42_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[916\]
+ _00810_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[885\]$_DFFE_PN0P_
+ _03057_ net259 clknet_leaf_38_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[917\]
+ _00841_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[886\]$_DFFE_PN0P_
+ _03058_ net260 clknet_leaf_139_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[918\]
+ _00872_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[887\]$_DFFE_PN0P_
+ _03059_ net260 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[919\]
+ _00903_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[888\]$_DFFE_PN0P_
+ _03060_ net260 clknet_leaf_129_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[920\]
+ _00934_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[889\]$_DFFE_PN0P_
+ _03061_ net261 clknet_leaf_129_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[921\]
+ _00965_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[88\]$_DFFE_PN0P_
+ _03062_ net261 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[120\]
+ _00909_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[890\]$_DFFE_PN0P_
+ _03063_ net260 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[922\]
+ _00996_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[891\]$_DFFE_PN0P_
+ _03064_ net259 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[923\]
+ _01027_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[892\]$_DFFE_PN0P_
+ _03065_ net260 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[924\]
+ _01058_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[893\]$_DFFE_PN0P_
+ _03066_ net259 clknet_leaf_126_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[925\]
+ _01089_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[894\]$_DFFE_PN0P_
+ _03067_ net260 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[926\]
+ _01120_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[895\]$_DFFE_PN0P_
+ _03068_ net261 clknet_leaf_125_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[927\]
+ _01151_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[896\]$_DFFE_PN0P_
+ _03069_ net257 clknet_leaf_108_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[928\]
+ _00213_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[897\]$_DFFE_PN0P_
+ _03070_ net257 clknet_leaf_116_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[929\]
+ _00168_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[898\]$_DFFE_PN0P_
+ _03071_ net261 clknet_leaf_127_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[930\]
+ _00275_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[899\]$_DFFE_PN0P_
+ _03072_ net261 clknet_leaf_124_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[931\]
+ _00306_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[89\]$_DFFE_PN0P_
+ _03073_ net261 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[121\]
+ _00940_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[8\]$_DFFE_PN0P_
+ _03074_ net258 clknet_leaf_77_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[40\]
+ _13617_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[900\]$_DFFE_PN0P_
+ _03075_ net257 clknet_leaf_105_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[932\]
+ _00336_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[901\]$_DFFE_PN0P_
+ _03076_ net256 clknet_leaf_83_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[933\]
+ _00366_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[902\]$_DFFE_PN0P_
+ _03077_ net257 clknet_leaf_84_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[934\]
+ _00396_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[903\]$_DFFE_PN0P_
+ _03078_ net257 clknet_leaf_98_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[935\]
+ _00426_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[904\]$_DFFE_PN0P_
+ _03079_ net255 clknet_leaf_79_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[936\]
+ _00456_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[905\]$_DFFE_PN0P_
+ _03080_ net257 clknet_leaf_89_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[937\]
+ _00486_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[906\]$_DFFE_PN0P_
+ _03081_ net256 clknet_leaf_93_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[938\]
+ _00516_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[907\]$_DFFE_PN0P_
+ _03082_ net263 clknet_leaf_97_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[939\]
+ _00546_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[908\]$_DFFE_PN0P_
+ _03083_ net255 clknet_leaf_78_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[940\]
+ _00245_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[909\]$_DFFE_PN0P_
+ _03084_ net256 clknet_leaf_62_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[941\]
+ _00594_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[90\]$_DFFE_PN0P_
+ _03085_ net259 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[122\]
+ _00971_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[910\]$_DFFE_PN0P_
+ _03086_ net255 clknet_leaf_46_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[942\]
+ _00625_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[911\]$_DFFE_PN0P_
+ _03087_ net258 clknet_leaf_54_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[943\]
+ _00656_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[912\]$_DFFE_PN0P_
+ _03088_ net255 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[944\]
+ _00687_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[913\]$_DFFE_PN0P_
+ _03089_ net255 clknet_leaf_43_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[945\]
+ _00718_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[914\]$_DFFE_PN0P_
+ _03090_ net258 clknet_leaf_58_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[946\]
+ _00749_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[915\]$_DFFE_PN0P_
+ _03091_ net261 clknet_leaf_128_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[947\]
+ _00780_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[916\]$_DFFE_PN0P_
+ _03092_ net255 clknet_leaf_42_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[948\]
+ _00811_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[917\]$_DFFE_PN0P_
+ _01184_ net259 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[949\]
+ _00842_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[918\]$_DFFE_PN0P_
+ _01185_ net260 clknet_leaf_136_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[950\]
+ _00873_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[919\]$_DFFE_PN0P_
+ _01186_ net260 clknet_leaf_137_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[951\]
+ _00904_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[91\]$_DFFE_PN0P_
+ _01187_ net259 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[123\]
+ _01002_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[920\]$_DFFE_PN0P_
+ _01188_ net260 clknet_leaf_130_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[952\]
+ _00935_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[921\]$_DFFE_PN0P_
+ _01189_ net260 clknet_leaf_128_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[953\]
+ _00966_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[922\]$_DFFE_PN0P_
+ _01190_ net260 clknet_leaf_137_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[954\]
+ _00997_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[923\]$_DFFE_PN0P_
+ _01191_ net259 clknet_leaf_34_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[955\]
+ _01028_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[924\]$_DFFE_PN0P_
+ _01192_ net260 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[956\]
+ _01059_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[925\]$_DFFE_PN0P_
+ _01193_ net259 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[957\]
+ _01090_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[926\]$_DFFE_PN0P_
+ _01194_ net259 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[958\]
+ _01121_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[927\]$_DFFE_PN0P_
+ _01195_ net261 clknet_leaf_125_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[959\]
+ _01152_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[928\]$_DFFE_PN0P_
+ _01196_ net258 clknet_leaf_108_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[960\]
+ _00214_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[929\]$_DFFE_PN0P_
+ _01197_ net258 clknet_leaf_116_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[961\]
+ _00169_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[92\]$_DFFE_PN0P_
+ _01198_ net259 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[124\]
+ _01033_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[930\]$_DFFE_PN0P_
+ _01199_ net261 clknet_leaf_127_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[962\]
+ _00276_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[931\]$_DFFE_PN0P_
+ _01200_ net261 clknet_leaf_124_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[963\]
+ _00307_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[932\]$_DFFE_PN0P_
+ _01201_ net258 clknet_leaf_102_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[964\]
+ _00337_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[933\]$_DFFE_PN0P_
+ _01202_ net256 clknet_leaf_76_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[965\]
+ _00367_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[934\]$_DFFE_PN0P_
+ _01203_ net257 clknet_leaf_87_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[966\]
+ _00397_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[935\]$_DFFE_PN0P_
+ _01204_ net257 clknet_leaf_98_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[967\]
+ _00427_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[936\]$_DFFE_PN0P_
+ _01205_ net258 clknet_leaf_80_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[968\]
+ _00457_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[937\]$_DFFE_PN0P_
+ _01206_ net263 clknet_leaf_100_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[969\]
+ _00487_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[938\]$_DFFE_PN0P_
+ _01207_ net256 clknet_leaf_64_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[970\]
+ _00517_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[939\]$_DFFE_PN0P_
+ _01208_ net263 clknet_leaf_97_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[971\]
+ _00547_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[93\]$_DFFE_PN0P_
+ _01209_ net259 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[125\]
+ _01064_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[940\]$_DFFE_PN0P_
+ _01210_ net255 clknet_leaf_78_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[972\]
+ _00246_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[941\]$_DFFE_PN0P_
+ _01211_ net256 clknet_leaf_70_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[973\]
+ _00595_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[942\]$_DFFE_PN0P_
+ _01212_ net255 clknet_leaf_47_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[974\]
+ _00626_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[943\]$_DFFE_PN0P_
+ _01213_ net255 clknet_leaf_51_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[975\]
+ _00657_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[944\]$_DFFE_PN0P_
+ _01214_ net255 clknet_leaf_78_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[976\]
+ _00688_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[945\]$_DFFE_PN0P_
+ _01215_ net255 clknet_leaf_40_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[977\]
+ _00719_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[946\]$_DFFE_PN0P_
+ _01216_ net258 clknet_leaf_54_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[978\]
+ _00750_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[947\]$_DFFE_PN0P_
+ _01217_ net261 clknet_leaf_127_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[979\]
+ _00781_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[948\]$_DFFE_PN0P_
+ _01218_ net255 clknet_leaf_42_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[980\]
+ _00812_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[949\]$_DFFE_PN0P_
+ _01219_ net259 clknet_leaf_37_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[981\]
+ _00843_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[94\]$_DFFE_PN0P_
+ _01220_ net259 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[126\]
+ _01095_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[950\]$_DFFE_PN0P_
+ _01221_ net260 clknet_leaf_139_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[982\]
+ _00874_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[951\]$_DFFE_PN0P_
+ _01222_ net260 clknet_leaf_137_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[983\]
+ _00905_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[952\]$_DFFE_PN0P_
+ _01223_ net260 clknet_leaf_128_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[984\]
+ _00936_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[953\]$_DFFE_PN0P_
+ _01224_ net260 clknet_leaf_128_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[985\]
+ _00967_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[954\]$_DFFE_PN0P_
+ _01225_ net260 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[986\]
+ _00998_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[955\]$_DFFE_PN0P_
+ _01226_ net259 clknet_leaf_34_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[987\]
+ _01029_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[956\]$_DFFE_PN0P_
+ _01227_ net260 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[988\]
+ _01060_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[957\]$_DFFE_PN0P_
+ _01228_ net259 clknet_leaf_126_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[989\]
+ _01091_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[958\]$_DFFE_PN0P_
+ _01229_ net260 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[990\]
+ _01122_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[959\]$_DFFE_PN0P_
+ _01230_ net261 clknet_leaf_125_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[991\]
+ _01153_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[95\]$_DFFE_PN0P_
+ _01231_ net261 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[127\]
+ _01126_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[960\]$_DFFE_PN0P_
+ _01232_ net258 clknet_leaf_103_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[992\]
+ _00215_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[961\]$_DFFE_PN0P_
+ _01233_ net258 clknet_leaf_116_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[993\]
+ _00170_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[962\]$_DFFE_PN0P_
+ _01234_ net261 clknet_leaf_122_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[994\]
+ _00277_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[963\]$_DFFE_PN0P_
+ _01235_ net261 clknet_leaf_124_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[995\]
+ _00308_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[964\]$_DFFE_PN0P_
+ _01236_ net258 clknet_leaf_102_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[996\]
+ _00338_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[965\]$_DFFE_PN0P_
+ _01237_ net256 clknet_leaf_83_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[997\]
+ _00368_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[966\]$_DFFE_PN0P_
+ _01238_ net257 clknet_leaf_86_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[998\]
+ _00398_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[967\]$_DFFE_PN0P_
+ _01239_ net263 clknet_leaf_101_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[999\]
+ _00428_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[968\]$_DFFE_PN0P_
+ _01240_ net258 clknet_leaf_80_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1000\]
+ _00458_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[969\]$_DFFE_PN0P_
+ _01241_ net257 clknet_leaf_99_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1001\]
+ _00488_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[96\]$_DFFE_PN0P_
+ _01242_ net257 clknet_leaf_107_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[128\]
+ _00188_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[970\]$_DFFE_PN0P_
+ _01243_ net256 clknet_leaf_93_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1002\]
+ _00518_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[971\]$_DFFE_PN0P_
+ _01244_ net263 clknet_leaf_97_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1003\]
+ _00548_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[972\]$_DFFE_PN0P_
+ _01245_ net255 clknet_leaf_78_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1004\]
+ _00247_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[973\]$_DFFE_PN0P_
+ _01246_ net256 clknet_leaf_62_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1005\]
+ _00596_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[974\]$_DFFE_PN0P_
+ _01247_ net255 clknet_leaf_46_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1006\]
+ _00627_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[975\]$_DFFE_PN0P_
+ _01248_ net255 clknet_leaf_54_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1007\]
+ _00658_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[976\]$_DFFE_PN0P_
+ _01249_ net255 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1008\]
+ _00689_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[977\]$_DFFE_PN0P_
+ _01250_ net255 clknet_leaf_47_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1009\]
+ _00720_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[978\]$_DFFE_PN0P_
+ _01251_ net258 clknet_leaf_54_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1010\]
+ _00751_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[979\]$_DFFE_PN0P_
+ _01252_ net261 clknet_leaf_128_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1011\]
+ _00782_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[97\]$_DFFE_PN0P_
+ _01253_ net258 clknet_leaf_109_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[129\]
+ _00143_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[980\]$_DFFE_PN0P_
+ _01254_ net255 clknet_leaf_43_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1012\]
+ _00813_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[981\]$_DFFE_PN0P_
+ _01255_ net259 clknet_leaf_37_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1013\]
+ _00844_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[982\]$_DFFE_PN0P_
+ _01256_ net260 clknet_leaf_139_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1014\]
+ _00875_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[983\]$_DFFE_PN0P_
+ _01257_ net260 clknet_leaf_138_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1015\]
+ _00906_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[984\]$_DFFE_PN0P_
+ _01258_ net260 clknet_leaf_130_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1016\]
+ _00937_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[985\]$_DFFE_PN0P_
+ _01259_ net260 clknet_leaf_128_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1017\]
+ _00968_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[986\]$_DFFE_PN0P_
+ _01260_ net260 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1018\]
+ _00999_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[987\]$_DFFE_PN0P_
+ _01261_ net259 clknet_leaf_34_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1019\]
+ _01030_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[988\]$_DFFE_PN0P_
+ _01262_ net260 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1020\]
+ _01061_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[989\]$_DFFE_PN0P_
+ _01263_ net259 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1021\]
+ _01092_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[98\]$_DFFE_PN0P_
+ _01264_ net261 clknet_leaf_123_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[130\]
+ _00250_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[990\]$_DFFE_PN0P_
+ _01265_ net259 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1022\]
+ _01123_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[991\]$_DFFE_PN0P_
+ _01266_ net261 clknet_leaf_125_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1023\]
+ _01154_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[99\]$_DFFE_PN0P_
+ _01267_ net261 clknet_leaf_123_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[131\]
+ _00281_ VDD VSS DFFR_X1
Xgen_regfile_ff.register_file_i.rf_reg_q\[9\]$_DFFE_PN0P_
+ _01268_ net256 clknet_leaf_90_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[41\]
+ _13616_ VDD VSS DFFR_X1
Xid_stage_i.controller_i.ctrl_fsm_cs\[0\]$_DFFE_PN0P_ _01269_
+ net262 clknet_leaf_115_clk id_stage_i.controller_i.ctrl_fsm_cs\[0\]
+ _13615_ VDD VSS DFFR_X2
Xid_stage_i.controller_i.ctrl_fsm_cs\[1\]$_DFFE_PN0P_ _01270_
+ net262 clknet_leaf_115_clk id_stage_i.controller_i.ctrl_fsm_cs\[1\]
+ _13614_ VDD VSS DFFR_X1
Xid_stage_i.controller_i.ctrl_fsm_cs\[2\]$_DFFE_PN0P_ _01271_
+ net262 clknet_leaf_115_clk id_stage_i.controller_i.ctrl_fsm_cs\[2\]
+ _13613_ VDD VSS DFFR_X1
Xid_stage_i.controller_i.ctrl_fsm_cs\[3\]$_DFFE_PN0P_ _01272_
+ net262 clknet_leaf_113_clk id_stage_i.controller_i.ctrl_fsm_cs\[3\]
+ _13612_ VDD VSS DFFR_X2
Xid_stage_i.controller_i.debug_mode_q$_DFFE_PN0P_ _01273_
+ net262 clknet_leaf_112_clk cs_registers_i.debug_mode_i _01156_
+ VDD VSS DFFR_X1
Xid_stage_i.controller_i.exc_req_q$_DFF_PN0_ id_stage_i.controller_i.exc_req_d
+ net262 clknet_leaf_113_clk id_stage_i.controller_i.exc_req_q
+ _14054_ VDD VSS DFFR_X1
Xid_stage_i.controller_i.illegal_insn_q$_DFF_PN0_ id_stage_i.controller_i.illegal_insn_d
+ net262 clknet_leaf_113_clk id_stage_i.controller_i.illegal_insn_q
+ _01157_ VDD VSS DFFR_X1
Xid_stage_i.controller_i.load_err_q$_DFF_PN0_ id_stage_i.controller_i.load_err_d
+ net262 clknet_leaf_13_clk id_stage_i.controller_i.load_err_q
+ _13611_ VDD VSS DFFR_X1
Xid_stage_i.controller_i.nmi_mode_q$_DFFE_PN0P_ _01274_ net264
+ clknet_leaf_79_clk cs_registers_i.nmi_mode_i _14055_ VDD VSS
+ DFFR_X1
Xid_stage_i.controller_i.store_err_q$_DFF_PN0_ id_stage_i.controller_i.store_err_d
+ net262 clknet_leaf_115_clk id_stage_i.controller_i.store_err_q
+ _14056_ VDD VSS DFFR_X1
Xid_stage_i.g_branch_set_flop.branch_set_q$_DFF_PN0_ id_stage_i.branch_set_d
+ net262 clknet_leaf_14_clk id_stage_i.branch_set _13610_ VDD
+ VSS DFFR_X1
Xid_stage_i.id_fsm_q$_DFFE_PN0P_ _01275_ net262 clknet_leaf_13_clk
+ id_stage_i.id_fsm_q _13609_ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[0\]$_DFFE_PN0P_ _01276_ net263 clknet_leaf_26_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[0\] _13608_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[10\]$_DFFE_PN0P_ _01277_ net263 clknet_leaf_27_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[10\] _13607_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[11\]$_DFFE_PN0P_ _01278_ net263 clknet_leaf_19_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[11\] _13606_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[12\]$_DFFE_PN0P_ _01279_ net263 clknet_leaf_25_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[12\] _13605_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[13\]$_DFFE_PN0P_ _01280_ net263 clknet_leaf_19_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[13\] _13604_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[14\]$_DFFE_PN0P_ _01281_ net263 clknet_leaf_26_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[14\] _13603_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[15\]$_DFFE_PN0P_ _01282_ net263 clknet_leaf_26_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[15\] _13602_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[16\]$_DFFE_PN0P_ _01283_ net263 clknet_leaf_25_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[16\] _13601_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[17\]$_DFFE_PN0P_ _01284_ net263 clknet_leaf_25_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[17\] _13600_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[18\]$_DFFE_PN0P_ _01285_ net263 clknet_leaf_24_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[18\] _13599_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[19\]$_DFFE_PN0P_ _01286_ net263 clknet_leaf_19_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[19\] _13598_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[1\]$_DFFE_PN0P_ _01287_ net263 clknet_leaf_26_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[1\] _13597_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[20\]$_DFFE_PN0P_ _01288_ net263 clknet_leaf_24_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[20\] _13596_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[21\]$_DFFE_PN0P_ _01289_ net263 clknet_leaf_19_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[21\] _13595_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[22\]$_DFFE_PN0P_ _01290_ net263 clknet_leaf_19_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[22\] _13594_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[23\]$_DFFE_PN0P_ _01291_ net263 clknet_leaf_22_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[23\] _13593_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[24\]$_DFFE_PN0P_ _01292_ net263 clknet_leaf_22_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[24\] _13592_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[25\]$_DFFE_PN0P_ _01293_ net263 clknet_leaf_22_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[25\] _13591_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[26\]$_DFFE_PN0P_ _01294_ net263 clknet_leaf_22_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[26\] _13590_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[27\]$_DFFE_PN0P_ _01295_ net263 clknet_leaf_21_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[27\] _13589_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[28\]$_DFFE_PN0P_ _01296_ net263 clknet_leaf_22_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[28\] _13588_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[29\]$_DFFE_PN0P_ _01297_ net263 clknet_leaf_22_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[29\] _13587_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[2\]$_DFFE_PN0P_ _01298_ net263 clknet_leaf_25_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[2\] _13586_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[30\]$_DFFE_PN0P_ _01299_ net263 clknet_leaf_18_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[30\] _13585_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[31\]$_DFFE_PN0P_ _01300_ net263 clknet_leaf_18_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[31\] _13584_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[34\]$_DFFE_PN0P_ _01301_ net263 clknet_leaf_25_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[32\] _00217_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[35\]$_DFFE_PN0P_ _01302_ net263 clknet_leaf_30_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[33\] _00185_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[36\]$_DFFE_PN0P_ _01303_ net263 clknet_leaf_30_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[34\] _00556_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[37\]$_DFFE_PN0P_ _01304_ net263 clknet_leaf_29_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[35\] _00557_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[38\]$_DFFE_PN0P_ _01305_ net264 clknet_leaf_29_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[36\] _00558_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[39\]$_DFFE_PN0P_ _01306_ net264 clknet_leaf_35_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[37\] _00559_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[3\]$_DFFE_PN0P_ _01307_ net263 clknet_leaf_18_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[3\] _13583_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[40\]$_DFFE_PN0P_ _01308_ net264 clknet_leaf_29_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[38\] _00560_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[41\]$_DFFE_PN0P_ _01309_ net263 clknet_leaf_29_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[39\] _00561_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[42\]$_DFFE_PN0P_ _01310_ net263 clknet_leaf_30_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[40\] _00562_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[43\]$_DFFE_PN0P_ _01311_ net263 clknet_leaf_30_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[41\] _00563_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[44\]$_DFFE_PN0P_ _01312_ net263 clknet_leaf_30_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[42\] _00564_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[45\]$_DFFE_PN0P_ _01313_ net263 clknet_leaf_24_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[43\] _00565_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[46\]$_DFFE_PN0P_ _01314_ net263 clknet_leaf_30_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[44\] _00566_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[47\]$_DFFE_PN0P_ _01315_ net263 clknet_leaf_31_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[45\] _00597_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[48\]$_DFFE_PN0P_ _01316_ net263 clknet_leaf_30_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[46\] _00628_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[49\]$_DFFE_PN0P_ _01317_ net263 clknet_leaf_31_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[47\] _00659_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[4\]$_DFFE_PN0P_ _01318_ net263 clknet_leaf_17_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[4\] _13582_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[50\]$_DFFE_PN0P_ _01319_ net263 clknet_leaf_31_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[48\] _00690_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[51\]$_DFFE_PN0P_ _01320_ net263 clknet_leaf_30_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[49\] _00721_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[52\]$_DFFE_PN0P_ _01321_ net263 clknet_leaf_34_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[50\] _00752_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[53\]$_DFFE_PN0P_ _01322_ net263 clknet_leaf_34_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[51\] _00783_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[54\]$_DFFE_PN0P_ _01323_ net263 clknet_leaf_32_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[52\] _00814_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[55\]$_DFFE_PN0P_ _01324_ net263 clknet_leaf_33_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[53\] _00845_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[56\]$_DFFE_PN0P_ _01325_ net263 clknet_leaf_32_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[54\] _00876_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[57\]$_DFFE_PN0P_ _01326_ net263 clknet_leaf_32_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[55\] _00907_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[58\]$_DFFE_PN0P_ _01327_ net263 clknet_leaf_31_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[56\] _00938_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[59\]$_DFFE_PN0P_ _01328_ net263 clknet_leaf_32_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[57\] _00969_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[5\]$_DFFE_PN0P_ _01329_ net263 clknet_leaf_18_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[5\] _13581_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[60\]$_DFFE_PN0P_ _01330_ net263 clknet_leaf_31_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[58\] _01000_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[61\]$_DFFE_PN0P_ _01331_ net263 clknet_leaf_32_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[59\] _01031_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[62\]$_DFFE_PN0P_ _01332_ net263 clknet_leaf_31_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[60\] _01062_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[63\]$_DFFE_PN0P_ _01333_ net263 clknet_leaf_24_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[61\] _01093_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[64\]$_DFFE_PN0P_ _01334_ net263 clknet_leaf_24_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[62\] _01124_
+ VDD VSS DFFR_X2
Xid_stage_i.imd_val_q\[65\]$_DFFE_PN0P_ _01335_ net263 clknet_leaf_23_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[63\] _01155_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[66\]$_DFFE_PN0P_ _01336_ net263 clknet_leaf_23_clk
+ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.imd_val_q_i\[66\]
+ _13580_ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[67\]$_DFFE_PN0P_ _01337_ net263 clknet_leaf_23_clk
+ ex_block_i.genblk3.gen_multdiv_fast.multdiv_i.imd_val_q_i\[67\]
+ _00132_ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[6\]$_DFFE_PN0P_ _01338_ net263 clknet_leaf_18_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[6\] _13579_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[7\]$_DFFE_PN0P_ _01339_ net263 clknet_leaf_18_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[7\] _13578_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[8\]$_DFFE_PN0P_ _01340_ net263 clknet_leaf_26_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[8\] _13577_
+ VDD VSS DFFR_X1
Xid_stage_i.imd_val_q\[9\]$_DFFE_PN0P_ _01341_ net263 clknet_leaf_26_clk
+ ex_block_i.alu_i.g_no_alu_rvb.unused_imd_val_q\[9\] _14057_
+ VDD VSS DFFR_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[0\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_s\[0\]
+ net261 clknet_leaf_118_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[0\]
+ _14058_ VDD VSS DFFR_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[1\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_s\[1\]
+ net261 clknet_leaf_116_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[1\]
+ _14059_ VDD VSS DFFR_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_q$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_d
+ net262 clknet_leaf_115_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_q
+ _13576_ VDD VSS DFFR_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[10\]$_DFFE_PP_
+ _01342_ clknet_leaf_46_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[10\]
+ _13575_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[11\]$_DFFE_PP_
+ _01343_ clknet_leaf_47_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[11\]
+ _13574_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[12\]$_DFFE_PP_
+ _01344_ clknet_leaf_50_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[12\]
+ _13573_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[13\]$_DFFE_PP_
+ _01345_ clknet_leaf_47_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[13\]
+ _13572_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[14\]$_DFFE_PP_
+ _01346_ clknet_leaf_45_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[14\]
+ _13571_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[15\]$_DFFE_PP_
+ _01347_ clknet_leaf_44_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[15\]
+ _13570_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[16\]$_DFFE_PP_
+ _01348_ clknet_leaf_44_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[16\]
+ _13569_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[17\]$_DFFE_PP_
+ _01349_ clknet_leaf_45_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[17\]
+ _13568_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[18\]$_DFFE_PP_
+ _01350_ clknet_leaf_44_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[18\]
+ _13567_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[19\]$_DFFE_PP_
+ _01351_ clknet_leaf_47_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[19\]
+ _13566_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[20\]$_DFFE_PP_
+ _01352_ clknet_leaf_44_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[20\]
+ _13565_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[21\]$_DFFE_PP_
+ _01353_ clknet_leaf_44_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[21\]
+ _13564_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[22\]$_DFFE_PP_
+ _01354_ clknet_leaf_42_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[22\]
+ _13563_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[23\]$_DFFE_PP_
+ _01355_ clknet_leaf_42_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[23\]
+ _13562_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[24\]$_DFFE_PP_
+ _01356_ clknet_leaf_41_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[24\]
+ _13561_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[25\]$_DFFE_PP_
+ _01357_ clknet_leaf_43_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[25\]
+ _13560_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[26\]$_DFFE_PP_
+ _01358_ clknet_leaf_39_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[26\]
+ _13559_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[27\]$_DFFE_PP_
+ _01359_ clknet_leaf_42_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[27\]
+ _13558_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[28\]$_DFFE_PP_
+ _01360_ clknet_leaf_43_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[28\]
+ _13557_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[29\]$_DFFE_PP_
+ _01361_ clknet_leaf_42_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[29\]
+ _13556_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[2\]$_DFFE_PP_
+ _01362_ clknet_leaf_45_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[2\]
+ _13555_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[30\]$_DFFE_PP_
+ _01363_ clknet_leaf_43_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[30\]
+ _13554_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[31\]$_DFFE_PP_
+ _01364_ clknet_leaf_43_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[31\]
+ _13553_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[3\]$_DFFE_PP_
+ _01365_ clknet_leaf_45_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[3\]
+ _13552_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[4\]$_DFFE_PP_
+ _01366_ clknet_leaf_47_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[4\]
+ _13551_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[5\]$_DFFE_PP_
+ _01367_ clknet_leaf_47_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[5\]
+ _13550_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[6\]$_DFFE_PP_
+ _01368_ clknet_leaf_49_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[6\]
+ _13549_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[7\]$_DFFE_PP_
+ _01369_ clknet_leaf_49_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[7\]
+ _13548_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[8\]$_DFFE_PP_
+ _01370_ clknet_leaf_48_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[8\]
+ _13547_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[9\]$_DFFE_PP_
+ _01371_ clknet_leaf_48_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[9\]
+ _13546_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[0\]$_DFFE_PP_
+ _01372_ clknet_leaf_129_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[0\]
+ _13545_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]$_DFFE_PP_
+ _01373_ clknet_leaf_125_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ _13544_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[2\]$_DFFE_PP_
+ _01374_ clknet_leaf_125_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[2\]
+ _13543_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[0\]$_DFFE_PP_
+ _01375_ clknet_leaf_115_clk cs_registers_i.pc_if_i\[1\] _00137_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[10\]$_DFFE_PP_
+ _01376_ clknet_leaf_49_clk cs_registers_i.pc_if_i\[11\] _13542_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[11\]$_DFFE_PP_
+ _01377_ clknet_leaf_50_clk cs_registers_i.pc_if_i\[12\] _13541_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[12\]$_DFFE_PP_
+ _01378_ clknet_leaf_46_clk cs_registers_i.pc_if_i\[13\] _13540_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[13\]$_DFFE_PP_
+ _01379_ clknet_leaf_57_clk cs_registers_i.pc_if_i\[14\] _13539_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[14\]$_DFFE_PP_
+ _01380_ clknet_leaf_44_clk cs_registers_i.pc_if_i\[15\] _13538_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[15\]$_DFFE_PP_
+ _01381_ clknet_leaf_45_clk cs_registers_i.pc_if_i\[16\] _13537_
+ VDD VSS DFF_X2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[16\]$_DFFE_PP_
+ _01382_ clknet_leaf_45_clk cs_registers_i.pc_if_i\[17\] _13536_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[17\]$_DFFE_PP_
+ _01383_ clknet_leaf_45_clk cs_registers_i.pc_if_i\[18\] _13535_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[18\]$_DFFE_PP_
+ _01384_ clknet_leaf_56_clk cs_registers_i.pc_if_i\[19\] _13534_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[19\]$_DFFE_PP_
+ _01385_ clknet_leaf_45_clk cs_registers_i.pc_if_i\[20\] _13533_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[1\]$_DFFE_PP_
+ _01386_ clknet_leaf_55_clk cs_registers_i.pc_if_i\[2\] _15352_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[20\]$_DFFE_PP_
+ _01387_ clknet_leaf_46_clk cs_registers_i.pc_if_i\[21\] _13532_
+ VDD VSS DFF_X2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[21\]$_DFFE_PP_
+ _01388_ clknet_leaf_46_clk cs_registers_i.pc_if_i\[22\] _13531_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[22\]$_DFFE_PP_
+ _01389_ clknet_leaf_46_clk cs_registers_i.pc_if_i\[23\] _13530_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[23\]$_DFFE_PP_
+ _01390_ clknet_leaf_49_clk cs_registers_i.pc_if_i\[24\] _13529_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[24\]$_DFFE_PP_
+ _01391_ clknet_leaf_46_clk cs_registers_i.pc_if_i\[25\] _13528_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[25\]$_DFFE_PP_
+ _01392_ clknet_leaf_49_clk cs_registers_i.pc_if_i\[26\] _13527_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[26\]$_DFFE_PP_
+ _01393_ clknet_leaf_56_clk cs_registers_i.pc_if_i\[27\] _13526_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[27\]$_DFFE_PP_
+ _01394_ clknet_leaf_49_clk cs_registers_i.pc_if_i\[28\] _13525_
+ VDD VSS DFF_X2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[28\]$_DFFE_PP_
+ _01395_ clknet_leaf_55_clk cs_registers_i.pc_if_i\[29\] _13524_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[29\]$_DFFE_PP_
+ _01396_ clknet_leaf_52_clk cs_registers_i.pc_if_i\[30\] _13523_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[2\]$_DFFE_PP_
+ _01397_ clknet_leaf_53_clk cs_registers_i.pc_if_i\[3\] _13522_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[30\]$_DFFE_PP_
+ _01398_ clknet_leaf_53_clk cs_registers_i.pc_if_i\[31\] _13521_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[3\]$_DFFE_PP_
+ _01399_ clknet_leaf_52_clk cs_registers_i.pc_if_i\[4\] _13520_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[4\]$_DFFE_PP_
+ _01400_ clknet_leaf_53_clk cs_registers_i.pc_if_i\[5\] _13519_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[5\]$_DFFE_PP_
+ _01401_ clknet_leaf_50_clk cs_registers_i.pc_if_i\[6\] _13518_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[6\]$_DFFE_PP_
+ _01402_ clknet_leaf_50_clk cs_registers_i.pc_if_i\[7\] _13517_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[7\]$_DFFE_PP_
+ _01403_ clknet_leaf_50_clk cs_registers_i.pc_if_i\[8\] _13516_
+ VDD VSS DFF_X2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[8\]$_DFFE_PP_
+ _01404_ clknet_leaf_50_clk cs_registers_i.pc_if_i\[9\] _13515_
+ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[9\]$_DFFE_PP_
+ _01405_ clknet_leaf_50_clk cs_registers_i.pc_if_i\[10\] _13514_
+ VDD VSS DFF_X2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[0\]$_DFFE_PP_
+ _01406_ clknet_leaf_128_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[0\]
+ _13513_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[10\]$_DFFE_PP_
+ _01407_ clknet_leaf_133_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[10\]
+ _13512_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[11\]$_DFFE_PP_
+ _01408_ clknet_leaf_133_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[11\]
+ _13511_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[12\]$_DFFE_PP_
+ _01409_ clknet_leaf_133_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[12\]
+ _13510_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[13\]$_DFFE_PP_
+ _01410_ clknet_leaf_4_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[13\]
+ _13509_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[14\]$_DFFE_PP_
+ _01411_ clknet_leaf_4_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[14\]
+ _13508_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[15\]$_DFFE_PP_
+ _01412_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[15\]
+ _13507_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[16\]$_DFFE_PP_
+ _01413_ clknet_leaf_133_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[16\]
+ _13506_ VDD VSS DFF_X2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]$_DFFE_PP_
+ _01414_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]
+ _13505_ VDD VSS DFF_X2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[18\]$_DFFE_PP_
+ _01415_ clknet_leaf_134_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[18\]
+ _13504_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[19\]$_DFFE_PP_
+ _01416_ clknet_leaf_131_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[19\]
+ _13503_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[1\]$_DFFE_PP_
+ _01417_ clknet_leaf_128_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[1\]
+ _13502_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[20\]$_DFFE_PP_
+ _01418_ clknet_leaf_131_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[20\]
+ _13501_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[21\]$_DFFE_PP_
+ _01419_ clknet_leaf_126_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[21\]
+ _13500_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[22\]$_DFFE_PP_
+ _01420_ clknet_leaf_130_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[22\]
+ _13499_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[23\]$_DFFE_PP_
+ _01421_ clknet_leaf_124_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[23\]
+ _13498_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[24\]$_DFFE_PP_
+ _01422_ clknet_leaf_126_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[24\]
+ _13497_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[25\]$_DFFE_PP_
+ _01423_ clknet_leaf_132_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[25\]
+ _13496_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[26\]$_DFFE_PP_
+ _01424_ clknet_leaf_132_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[26\]
+ _13495_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[27\]$_DFFE_PP_
+ _01425_ clknet_leaf_134_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[27\]
+ _13494_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[28\]$_DFFE_PP_
+ _01426_ clknet_leaf_132_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[28\]
+ _13493_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[29\]$_DFFE_PP_
+ _01427_ clknet_leaf_4_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[29\]
+ _13492_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[2\]$_DFFE_PP_
+ _01428_ clknet_leaf_133_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[2\]
+ _13491_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[30\]$_DFFE_PP_
+ _01429_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[30\]
+ _13490_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[31\]$_DFFE_PP_
+ _01430_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[31\]
+ _13489_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[32\]$_DFFE_PP_
+ _01431_ clknet_leaf_124_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[32\]
+ _13488_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[33\]$_DFFE_PP_
+ _01432_ clknet_leaf_127_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[33\]
+ _13487_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[34\]$_DFFE_PP_
+ _01433_ clknet_leaf_133_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[34\]
+ _13486_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[35\]$_DFFE_PP_
+ _01434_ clknet_leaf_130_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[35\]
+ _13485_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[36\]$_DFFE_PP_
+ _01435_ clknet_leaf_130_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[36\]
+ _13484_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[37\]$_DFFE_PP_
+ _01436_ clknet_leaf_127_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[37\]
+ _13483_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[38\]$_DFFE_PP_
+ _01437_ clknet_leaf_127_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[38\]
+ _13482_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[39\]$_DFFE_PP_
+ _01438_ clknet_leaf_124_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[39\]
+ _13481_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[3\]$_DFFE_PP_
+ _01439_ clknet_leaf_130_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[3\]
+ _13480_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[40\]$_DFFE_PP_
+ _01440_ clknet_leaf_128_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[40\]
+ _13479_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[41\]$_DFFE_PP_
+ _01441_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[41\]
+ _13478_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[42\]$_DFFE_PP_
+ _01442_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[42\]
+ _13477_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[43\]$_DFFE_PP_
+ _01443_ clknet_leaf_133_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[43\]
+ _13476_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[44\]$_DFFE_PP_
+ _01444_ clknet_leaf_135_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[44\]
+ _13475_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[45\]$_DFFE_PP_
+ _01445_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[45\]
+ _13474_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[46\]$_DFFE_PP_
+ _01446_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[46\]
+ _13473_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[47\]$_DFFE_PP_
+ _01447_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[47\]
+ _13472_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[48\]$_DFFE_PP_
+ _01448_ clknet_leaf_134_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[48\]
+ _13471_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[49\]$_DFFE_PP_
+ _01449_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[49\]
+ _13470_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[4\]$_DFFE_PP_
+ _01450_ clknet_leaf_130_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[4\]
+ _13469_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[50\]$_DFFE_PP_
+ _01451_ clknet_leaf_134_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[50\]
+ _13468_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[51\]$_DFFE_PP_
+ _01452_ clknet_leaf_132_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[51\]
+ _13467_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[52\]$_DFFE_PP_
+ _01453_ clknet_leaf_131_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[52\]
+ _13466_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[53\]$_DFFE_PP_
+ _01454_ clknet_leaf_126_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[53\]
+ _13465_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[54\]$_DFFE_PP_
+ _01455_ clknet_leaf_131_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[54\]
+ _13464_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[55\]$_DFFE_PP_
+ _01456_ clknet_leaf_125_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[55\]
+ _13463_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[56\]$_DFFE_PP_
+ _01457_ clknet_leaf_125_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[56\]
+ _13462_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[57\]$_DFFE_PP_
+ _01458_ clknet_leaf_132_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[57\]
+ _13461_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[58\]$_DFFE_PP_
+ _01459_ clknet_leaf_134_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[58\]
+ _13460_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[59\]$_DFFE_PP_
+ _01460_ clknet_leaf_134_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[59\]
+ _13459_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[5\]$_DFFE_PP_
+ _01461_ clknet_leaf_127_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[5\]
+ _13458_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[60\]$_DFFE_PP_
+ _01462_ clknet_leaf_132_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[60\]
+ _13457_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[61\]$_DFFE_PP_
+ _01463_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[61\]
+ _13456_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[62\]$_DFFE_PP_
+ _01464_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[62\]
+ _13455_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[63\]$_DFFE_PP_
+ _01465_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[63\]
+ _13454_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[64\]$_DFFE_PP_
+ _01466_ clknet_leaf_125_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[64\]
+ _13453_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[65\]$_DFFE_PP_
+ _01467_ clknet_leaf_127_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[65\]
+ _13452_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[66\]$_DFFE_PP_
+ _01468_ clknet_leaf_131_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[66\]
+ _13451_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[67\]$_DFFE_PP_
+ _01469_ clknet_leaf_131_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[67\]
+ _13450_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[68\]$_DFFE_PP_
+ _01470_ clknet_leaf_131_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[68\]
+ _13449_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[69\]$_DFFE_PP_
+ _01471_ clknet_leaf_127_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[69\]
+ _13448_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[6\]$_DFFE_PP_
+ _01472_ clknet_leaf_130_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[6\]
+ _13447_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[70\]$_DFFE_PP_
+ _01473_ clknet_leaf_126_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[70\]
+ _13446_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[71\]$_DFFE_PP_
+ _01474_ clknet_leaf_125_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[71\]
+ _13445_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[72\]$_DFFE_PP_
+ _01475_ clknet_leaf_127_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[72\]
+ _13444_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[73\]$_DFFE_PP_
+ _01476_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[73\]
+ _13443_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[74\]$_DFFE_PP_
+ _01477_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[74\]
+ _13442_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[75\]$_DFFE_PP_
+ _01478_ clknet_leaf_135_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[75\]
+ _13441_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[76\]$_DFFE_PP_
+ _01479_ clknet_leaf_135_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[76\]
+ _13440_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[77\]$_DFFE_PP_
+ _01480_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[77\]
+ _13439_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[78\]$_DFFE_PP_
+ _01481_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[78\]
+ _13438_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[79\]$_DFFE_PP_
+ _01482_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[79\]
+ _13437_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[7\]$_DFFE_PP_
+ _01483_ clknet_leaf_124_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[7\]
+ _13436_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[80\]$_DFFE_PP_
+ _01484_ clknet_leaf_135_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[80\]
+ _13435_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[81\]$_DFFE_PP_
+ _01485_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[81\]
+ _13434_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[82\]$_DFFE_PP_
+ _01486_ clknet_leaf_134_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[82\]
+ _13433_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[83\]$_DFFE_PP_
+ _01487_ clknet_leaf_132_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[83\]
+ _13432_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[84\]$_DFFE_PP_
+ _01488_ clknet_leaf_131_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[84\]
+ _13431_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[85\]$_DFFE_PP_
+ _01489_ clknet_leaf_126_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[85\]
+ _13430_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[86\]$_DFFE_PP_
+ _01490_ clknet_leaf_126_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[86\]
+ _13429_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[87\]$_DFFE_PP_
+ _01491_ clknet_leaf_125_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[87\]
+ _13428_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[88\]$_DFFE_PP_
+ _01492_ clknet_leaf_126_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[88\]
+ _13427_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[89\]$_DFFE_PP_
+ _01493_ clknet_leaf_132_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[89\]
+ _13426_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[8\]$_DFFE_PP_
+ _01494_ clknet_leaf_128_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[8\]
+ _13425_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[90\]$_DFFE_PP_
+ _01495_ clknet_leaf_134_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[90\]
+ _13424_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[91\]$_DFFE_PP_
+ _01496_ clknet_leaf_134_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[91\]
+ _13423_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[92\]$_DFFE_PP_
+ _01497_ clknet_leaf_132_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[92\]
+ _13422_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[93\]$_DFFE_PP_
+ _01498_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[93\]
+ _13421_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[94\]$_DFFE_PP_
+ _01499_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[94\]
+ _13420_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[95\]$_DFFE_PP_
+ _01500_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[95\]
+ _13419_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[9\]$_DFFE_PP_
+ _01501_ clknet_leaf_130_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[9\]
+ _14060_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[0\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[0\]
+ net261 clknet_leaf_129_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[0\]
+ _00136_ VDD VSS DFFR_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[1\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[1\]
+ net261 clknet_leaf_118_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[0\]
+ _00135_ VDD VSS DFFR_X2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[2\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[2\]
+ net261 clknet_leaf_118_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[1\]
+ _14061_ VDD VSS DFFR_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_s\[0\]
+ net262 clknet_leaf_114_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ _14062_ VDD VSS DFFR_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_s\[1\]
+ net262 clknet_leaf_116_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]
+ _00134_ VDD VSS DFFR_X2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[10\]$_DFFE_PP_
+ _01502_ clknet_leaf_41_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[10\]
+ _13418_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[11\]$_DFFE_PP_
+ _01503_ clknet_leaf_41_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[11\]
+ _13417_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[12\]$_DFFE_PP_
+ _01504_ clknet_leaf_41_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[12\]
+ _13416_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[13\]$_DFFE_PP_
+ _01505_ clknet_leaf_41_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[13\]
+ _13415_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[14\]$_DFFE_PP_
+ _01506_ clknet_leaf_40_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[14\]
+ _13414_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[15\]$_DFFE_PP_
+ _01507_ clknet_leaf_42_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[15\]
+ _13413_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[16\]$_DFFE_PP_
+ _01508_ clknet_leaf_40_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[16\]
+ _13412_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[17\]$_DFFE_PP_
+ _01509_ clknet_leaf_40_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[17\]
+ _13411_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[18\]$_DFFE_PP_
+ _01510_ clknet_leaf_40_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[18\]
+ _13410_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[19\]$_DFFE_PP_
+ _01511_ clknet_leaf_41_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[19\]
+ _13409_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[20\]$_DFFE_PP_
+ _01512_ clknet_leaf_39_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[20\]
+ _13408_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[21\]$_DFFE_PP_
+ _01513_ clknet_leaf_39_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[21\]
+ _13407_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[22\]$_DFFE_PP_
+ _01514_ clknet_leaf_39_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[22\]
+ _13406_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[23\]$_DFFE_PP_
+ _01515_ clknet_leaf_39_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[23\]
+ _13405_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[24\]$_DFFE_PP_
+ _01516_ clknet_leaf_39_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[24\]
+ _13404_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[25\]$_DFFE_PP_
+ _01517_ clknet_leaf_40_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[25\]
+ _13403_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[26\]$_DFFE_PP_
+ _01518_ clknet_leaf_39_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[26\]
+ _13402_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[27\]$_DFFE_PP_
+ _01519_ clknet_leaf_40_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[27\]
+ _13401_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[28\]$_DFFE_PP_
+ _01520_ clknet_leaf_40_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[28\]
+ _13400_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[29\]$_DFFE_PP_
+ _01521_ clknet_leaf_42_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[29\]
+ _13399_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[2\]$_DFFE_PP_
+ _01522_ clknet_leaf_48_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[2\]
+ _13398_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[30\]$_DFFE_PP_
+ _01523_ clknet_leaf_41_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[30\]
+ _13397_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[31\]$_DFFE_PP_
+ _01524_ clknet_leaf_41_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[31\]
+ _13396_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[3\]$_DFFE_PP_
+ _01525_ clknet_leaf_47_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[3\]
+ _13395_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[4\]$_DFFE_PP_
+ _01526_ clknet_leaf_48_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[4\]
+ _13394_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[5\]$_DFFE_PP_
+ _01527_ clknet_leaf_48_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[5\]
+ _13393_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[6\]$_DFFE_PP_
+ _01528_ clknet_leaf_49_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[6\]
+ _13392_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[7\]$_DFFE_PP_
+ _01529_ clknet_leaf_48_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[7\]
+ _13391_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[8\]$_DFFE_PP_
+ _01530_ clknet_leaf_48_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[8\]
+ _13390_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[9\]$_DFFE_PP_
+ _01531_ clknet_leaf_47_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[9\]
+ _14063_ VDD VSS DFF_X1
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_q$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_d
+ net262 clknet_leaf_115_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_q
+ _00133_ VDD VSS DFFR_X2
Xif_stage_i.illegal_c_insn_id_o$_DFFE_PN_ _01532_ clknet_leaf_12_clk
+ id_stage_i.decoder_i.illegal_c_insn_i _13389_ VDD VSS DFF_X1
Xif_stage_i.instr_fetch_err_o$_DFFE_PN_ _01533_ clknet_leaf_115_clk
+ id_stage_i.controller_i.instr_fetch_err_i _13388_ VDD VSS
+ DFF_X1
Xif_stage_i.instr_fetch_err_plus2_o$_SDFFCE_PN0N_ _01534_
+ clknet_leaf_116_clk id_stage_i.controller_i.instr_fetch_err_plus2_i
+ _13387_ VDD VSS DFF_X1
Xif_stage_i.instr_is_compressed_id_o$_DFFE_PN_ _01535_ clknet_leaf_10_clk
+ id_stage_i.controller_i.instr_is_compressed_i _00278_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[0\]$_DFFE_PN_ _01536_ clknet_leaf_12_clk
+ id_stage_i.controller_i.instr_i\[0\] _13386_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[10\]$_DFFE_PN_ _01537_ clknet_leaf_12_clk
+ gen_regfile_ff.register_file_i.waddr_a_i\[3\] _00036_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[11\]$_DFFE_PN_ _01538_ clknet_leaf_8_clk
+ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _00039_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[12\]$_DFFE_PN_ _01539_ clknet_leaf_9_clk
+ id_stage_i.controller_i.instr_i\[12\] _00176_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[13\]$_DFFE_PN_ _01540_ clknet_leaf_10_clk
+ id_stage_i.controller_i.instr_i\[13\] _00175_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[14\]$_DFFE_PN_ _01541_ clknet_leaf_9_clk
+ id_stage_i.controller_i.instr_i\[14\] _00173_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[15\]$_DFFE_PN_ _01542_ clknet_leaf_8_clk
+ gen_regfile_ff.register_file_i.raddr_a_i\[0\] _00184_ VDD
+ VSS DFF_X2
Xif_stage_i.instr_rdata_alu_id_o\[16\]$_DFFE_PN_ _01543_ clknet_leaf_8_clk
+ gen_regfile_ff.register_file_i.raddr_a_i\[1\] _00183_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[17\]$_DFFE_PN_ _01544_ clknet_leaf_8_clk
+ gen_regfile_ff.register_file_i.raddr_a_i\[2\] _00182_ VDD
+ VSS DFF_X2
Xif_stage_i.instr_rdata_alu_id_o\[18\]$_DFFE_PN_ _01545_ clknet_leaf_14_clk
+ gen_regfile_ff.register_file_i.raddr_a_i\[3\] _00181_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[19\]$_DFFE_PN_ _01546_ clknet_leaf_8_clk
+ gen_regfile_ff.register_file_i.raddr_a_i\[4\] _00180_ VDD
+ VSS DFF_X2
Xif_stage_i.instr_rdata_alu_id_o\[1\]$_DFFE_PN_ _01547_ clknet_leaf_13_clk
+ id_stage_i.controller_i.instr_i\[1\] _00013_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[20\]$_DFFE_PN_ _01548_ clknet_leaf_8_clk
+ gen_regfile_ff.register_file_i.raddr_b_i\[0\] _00140_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[21\]$_DFFE_PN_ _01549_ clknet_leaf_15_clk
+ gen_regfile_ff.register_file_i.raddr_b_i\[1\] _13385_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[22\]$_DFFE_PN_ _01550_ clknet_leaf_8_clk
+ gen_regfile_ff.register_file_i.raddr_b_i\[2\] _13384_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[23\]$_DFFE_PN_ _01551_ clknet_leaf_8_clk
+ gen_regfile_ff.register_file_i.raddr_b_i\[3\] _00139_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[24\]$_DFFE_PN_ _01552_ clknet_leaf_9_clk
+ gen_regfile_ff.register_file_i.raddr_b_i\[4\] _00138_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[25\]$_DFFE_PN_ _01553_ clknet_leaf_8_clk
+ id_stage_i.controller_i.instr_i\[25\] _13383_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[26\]$_DFFE_PN_ _01554_ clknet_leaf_9_clk
+ id_stage_i.controller_i.instr_i\[26\] _00177_ VDD VSS DFF_X2
Xif_stage_i.instr_rdata_alu_id_o\[27\]$_DFFE_PN_ _01555_ clknet_leaf_5_clk
+ id_stage_i.controller_i.instr_i\[27\] _13382_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[28\]$_DFFE_PN_ _01556_ clknet_leaf_11_clk
+ id_stage_i.controller_i.instr_i\[28\] _13381_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[29\]$_DFFE_PN_ _01557_ clknet_leaf_11_clk
+ id_stage_i.controller_i.instr_i\[29\] _13380_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[2\]$_DFFE_PN_ _01558_ clknet_leaf_117_clk
+ id_stage_i.controller_i.instr_i\[2\] _00015_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[30\]$_DFFE_PN_ _01559_ clknet_leaf_9_clk
+ id_stage_i.controller_i.instr_i\[30\] _13379_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[31\]$_DFFE_PN_ _01560_ clknet_leaf_9_clk
+ id_stage_i.controller_i.instr_i\[31\] _00174_ VDD VSS DFF_X2
Xif_stage_i.instr_rdata_alu_id_o\[3\]$_DFFE_PN_ _01561_ clknet_leaf_116_clk
+ id_stage_i.controller_i.instr_i\[3\] _00017_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[4\]$_DFFE_PN_ _01562_ clknet_leaf_13_clk
+ id_stage_i.controller_i.instr_i\[4\] _00020_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[5\]$_DFFE_PN_ _01563_ clknet_leaf_13_clk
+ id_stage_i.controller_i.instr_i\[5\] _00023_ VDD VSS DFF_X2
Xif_stage_i.instr_rdata_alu_id_o\[6\]$_DFFE_PN_ _01564_ clknet_leaf_13_clk
+ id_stage_i.controller_i.instr_i\[6\] _00172_ VDD VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[7\]$_DFFE_PN_ _01565_ clknet_leaf_10_clk
+ gen_regfile_ff.register_file_i.waddr_a_i\[0\] _00216_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[8\]$_DFFE_PN_ _01566_ clknet_leaf_12_clk
+ gen_regfile_ff.register_file_i.waddr_a_i\[1\] _00030_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_alu_id_o\[9\]$_DFFE_PN_ _01567_ clknet_leaf_11_clk
+ gen_regfile_ff.register_file_i.waddr_a_i\[2\] _00033_ VDD
+ VSS DFF_X2
Xif_stage_i.instr_rdata_c_id_o\[0\]$_DFFE_PN_ _01568_ clknet_leaf_117_clk
+ id_stage_i.controller_i.instr_compressed_i\[0\] _13378_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[10\]$_DFFE_PN_ _01569_ clknet_leaf_5_clk
+ id_stage_i.controller_i.instr_compressed_i\[10\] _00037_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[11\]$_DFFE_PN_ _01570_ clknet_leaf_5_clk
+ id_stage_i.controller_i.instr_compressed_i\[11\] _00040_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[12\]$_DFFE_PN_ _01571_ clknet_leaf_12_clk
+ id_stage_i.controller_i.instr_compressed_i\[12\] _00042_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[13\]$_DFFE_PN_ _01572_ clknet_leaf_12_clk
+ id_stage_i.controller_i.instr_compressed_i\[13\] _00044_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[14\]$_DFFE_PN_ _01573_ clknet_leaf_12_clk
+ id_stage_i.controller_i.instr_compressed_i\[14\] _00046_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[15\]$_DFFE_PN_ _01574_ clknet_leaf_116_clk
+ id_stage_i.controller_i.instr_compressed_i\[15\] _00048_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[1\]$_DFFE_PN_ _01575_ clknet_leaf_117_clk
+ id_stage_i.controller_i.instr_compressed_i\[1\] _00014_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[2\]$_DFFE_PN_ _01576_ clknet_leaf_117_clk
+ id_stage_i.controller_i.instr_compressed_i\[2\] _00016_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[3\]$_DFFE_PN_ _01577_ clknet_leaf_116_clk
+ id_stage_i.controller_i.instr_compressed_i\[3\] _00018_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[4\]$_DFFE_PN_ _01578_ clknet_leaf_117_clk
+ id_stage_i.controller_i.instr_compressed_i\[4\] _00021_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[5\]$_DFFE_PN_ _01579_ clknet_leaf_117_clk
+ id_stage_i.controller_i.instr_compressed_i\[5\] _00024_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[6\]$_DFFE_PN_ _01580_ clknet_leaf_117_clk
+ id_stage_i.controller_i.instr_compressed_i\[6\] _00026_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[7\]$_DFFE_PN_ _01581_ clknet_leaf_116_clk
+ id_stage_i.controller_i.instr_compressed_i\[7\] _00028_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[8\]$_DFFE_PN_ _01582_ clknet_leaf_117_clk
+ id_stage_i.controller_i.instr_compressed_i\[8\] _00031_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_rdata_c_id_o\[9\]$_DFFE_PN_ _01583_ clknet_leaf_12_clk
+ id_stage_i.controller_i.instr_compressed_i\[9\] _00034_ VDD
+ VSS DFF_X1
Xif_stage_i.instr_valid_id_q$_DFF_PN0_ if_stage_i.instr_valid_id_d
+ net262 clknet_leaf_113_clk id_stage_i.controller_i.instr_valid_i
+ _01161_ VDD VSS DFFR_X2
Xif_stage_i.pc_id_o\[10\]$_DFFE_PN_ _01584_ clknet_leaf_59_clk
+ cs_registers_i.pc_id_i\[10\] _00038_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[11\]$_DFFE_PN_ _01585_ clknet_leaf_59_clk
+ cs_registers_i.pc_id_i\[11\] _00041_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[12\]$_DFFE_PN_ _01586_ clknet_leaf_59_clk
+ cs_registers_i.pc_id_i\[12\] _00043_ VDD VSS DFF_X2
Xif_stage_i.pc_id_o\[13\]$_DFFE_PN_ _01587_ clknet_leaf_58_clk
+ cs_registers_i.pc_id_i\[13\] _00045_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[14\]$_DFFE_PN_ _01588_ clknet_leaf_57_clk
+ cs_registers_i.pc_id_i\[14\] _00047_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[15\]$_DFFE_PN_ _01589_ clknet_leaf_57_clk
+ cs_registers_i.pc_id_i\[15\] _00049_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[16\]$_DFFE_PN_ _01590_ clknet_leaf_57_clk
+ cs_registers_i.pc_id_i\[16\] _00050_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[17\]$_DFFE_PN_ _01591_ clknet_leaf_57_clk
+ cs_registers_i.pc_id_i\[17\] _00051_ VDD VSS DFF_X2
Xif_stage_i.pc_id_o\[18\]$_DFFE_PN_ _01592_ clknet_leaf_56_clk
+ cs_registers_i.pc_id_i\[18\] _00052_ VDD VSS DFF_X2
Xif_stage_i.pc_id_o\[19\]$_DFFE_PN_ _01593_ clknet_leaf_58_clk
+ cs_registers_i.pc_id_i\[19\] _00053_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[1\]$_DFFE_PN_ _01594_ clknet_leaf_65_clk
+ cs_registers_i.pc_id_i\[1\] _13377_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[20\]$_DFFE_PN_ _01595_ clknet_leaf_57_clk
+ cs_registers_i.pc_id_i\[20\] _00054_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[21\]$_DFFE_PN_ _01596_ clknet_leaf_57_clk
+ cs_registers_i.pc_id_i\[21\] _00055_ VDD VSS DFF_X2
Xif_stage_i.pc_id_o\[22\]$_DFFE_PN_ _01597_ clknet_leaf_56_clk
+ cs_registers_i.pc_id_i\[22\] _00056_ VDD VSS DFF_X2
Xif_stage_i.pc_id_o\[23\]$_DFFE_PN_ _01598_ clknet_leaf_56_clk
+ cs_registers_i.pc_id_i\[23\] _00057_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[24\]$_DFFE_PN_ _01599_ clknet_leaf_56_clk
+ cs_registers_i.pc_id_i\[24\] _00058_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[25\]$_DFFE_PN_ _01600_ clknet_leaf_57_clk
+ cs_registers_i.pc_id_i\[25\] _00059_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[26\]$_DFFE_PN_ _01601_ clknet_leaf_56_clk
+ cs_registers_i.pc_id_i\[26\] _00060_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[27\]$_DFFE_PN_ _01602_ clknet_leaf_55_clk
+ cs_registers_i.pc_id_i\[27\] _00061_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[28\]$_DFFE_PN_ _01603_ clknet_leaf_60_clk
+ cs_registers_i.pc_id_i\[28\] _00062_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[29\]$_DFFE_PN_ _01604_ clknet_leaf_55_clk
+ cs_registers_i.pc_id_i\[29\] _00063_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[2\]$_DFFE_PN_ _01605_ clknet_leaf_60_clk
+ cs_registers_i.pc_id_i\[2\] _00012_ VDD VSS DFF_X2
Xif_stage_i.pc_id_o\[30\]$_DFFE_PN_ _01606_ clknet_leaf_55_clk
+ cs_registers_i.pc_id_i\[30\] _00064_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[31\]$_DFFE_PN_ _01607_ clknet_leaf_55_clk
+ cs_registers_i.pc_id_i\[31\] _00065_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[3\]$_DFFE_PN_ _01608_ clknet_leaf_54_clk
+ cs_registers_i.pc_id_i\[3\] _00019_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[4\]$_DFFE_PN_ _01609_ clknet_leaf_60_clk
+ cs_registers_i.pc_id_i\[4\] _00022_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[5\]$_DFFE_PN_ _01610_ clknet_leaf_62_clk
+ cs_registers_i.pc_id_i\[5\] _00025_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[6\]$_DFFE_PN_ _01611_ clknet_leaf_60_clk
+ cs_registers_i.pc_id_i\[6\] _00027_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[7\]$_DFFE_PN_ _01612_ clknet_leaf_60_clk
+ cs_registers_i.pc_id_i\[7\] _00029_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[8\]$_DFFE_PN_ _01613_ clknet_leaf_60_clk
+ cs_registers_i.pc_id_i\[8\] _00032_ VDD VSS DFF_X1
Xif_stage_i.pc_id_o\[9\]$_DFFE_PN_ _01614_ clknet_leaf_59_clk
+ cs_registers_i.pc_id_i\[9\] _00035_ VDD VSS DFF_X1
Xload_store_unit_i.addr_last_q\[0\]$_DFFE_PN0P_ _01615_ net264
+ clknet_leaf_62_clk id_stage_i.controller_i.lsu_addr_last_i\[0\]
+ _13376_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[10\]$_DFFE_PN0P_ _01616_ net264
+ clknet_leaf_59_clk id_stage_i.controller_i.lsu_addr_last_i\[10\]
+ _13375_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[11\]$_DFFE_PN0P_ _01617_ net264
+ clknet_leaf_62_clk id_stage_i.controller_i.lsu_addr_last_i\[11\]
+ _13374_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[12\]$_DFFE_PN0P_ _01618_ net264
+ clknet_leaf_59_clk id_stage_i.controller_i.lsu_addr_last_i\[12\]
+ _13373_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[13\]$_DFFE_PN0P_ _01619_ net264
+ clknet_leaf_27_clk id_stage_i.controller_i.lsu_addr_last_i\[13\]
+ _13372_ VDD VSS DFFR_X2
Xload_store_unit_i.addr_last_q\[14\]$_DFFE_PN0P_ _01620_ net264
+ clknet_leaf_28_clk id_stage_i.controller_i.lsu_addr_last_i\[14\]
+ _13371_ VDD VSS DFFR_X2
Xload_store_unit_i.addr_last_q\[15\]$_DFFE_PN0P_ _01621_ net264
+ clknet_leaf_29_clk id_stage_i.controller_i.lsu_addr_last_i\[15\]
+ _13370_ VDD VSS DFFR_X2
Xload_store_unit_i.addr_last_q\[16\]$_DFFE_PN0P_ _01622_ net264
+ clknet_leaf_28_clk id_stage_i.controller_i.lsu_addr_last_i\[16\]
+ _13369_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[17\]$_DFFE_PN0P_ _01623_ net264
+ clknet_leaf_58_clk id_stage_i.controller_i.lsu_addr_last_i\[17\]
+ _13368_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[18\]$_DFFE_PN0P_ _01624_ net264
+ clknet_leaf_58_clk id_stage_i.controller_i.lsu_addr_last_i\[18\]
+ _13367_ VDD VSS DFFR_X2
Xload_store_unit_i.addr_last_q\[19\]$_DFFE_PN0P_ _01625_ net264
+ clknet_leaf_28_clk id_stage_i.controller_i.lsu_addr_last_i\[19\]
+ _13366_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[1\]$_DFFE_PN0P_ _01626_ net264
+ clknet_leaf_63_clk id_stage_i.controller_i.lsu_addr_last_i\[1\]
+ _13365_ VDD VSS DFFR_X2
Xload_store_unit_i.addr_last_q\[20\]$_DFFE_PN0P_ _01627_ net264
+ clknet_leaf_29_clk id_stage_i.controller_i.lsu_addr_last_i\[20\]
+ _13364_ VDD VSS DFFR_X2
Xload_store_unit_i.addr_last_q\[21\]$_DFFE_PN0P_ _01628_ net264
+ clknet_leaf_28_clk id_stage_i.controller_i.lsu_addr_last_i\[21\]
+ _13363_ VDD VSS DFFR_X2
Xload_store_unit_i.addr_last_q\[22\]$_DFFE_PN0P_ _01629_ net264
+ clknet_leaf_28_clk id_stage_i.controller_i.lsu_addr_last_i\[22\]
+ _13362_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[23\]$_DFFE_PN0P_ _01630_ net264
+ clknet_leaf_28_clk id_stage_i.controller_i.lsu_addr_last_i\[23\]
+ _13361_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[24\]$_DFFE_PN0P_ _01631_ net264
+ clknet_leaf_27_clk id_stage_i.controller_i.lsu_addr_last_i\[24\]
+ _13360_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[25\]$_DFFE_PN0P_ _01632_ net264
+ clknet_leaf_28_clk id_stage_i.controller_i.lsu_addr_last_i\[25\]
+ _13359_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[26\]$_DFFE_PN0P_ _01633_ net264
+ clknet_leaf_58_clk id_stage_i.controller_i.lsu_addr_last_i\[26\]
+ _13358_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[27\]$_DFFE_PN0P_ _01634_ net264
+ clknet_leaf_58_clk id_stage_i.controller_i.lsu_addr_last_i\[27\]
+ _13357_ VDD VSS DFFR_X2
Xload_store_unit_i.addr_last_q\[28\]$_DFFE_PN0P_ _01635_ net264
+ clknet_leaf_27_clk id_stage_i.controller_i.lsu_addr_last_i\[28\]
+ _13356_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[29\]$_DFFE_PN0P_ _01636_ net264
+ clknet_leaf_62_clk id_stage_i.controller_i.lsu_addr_last_i\[29\]
+ _13355_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[2\]$_DFFE_PN0P_ _01637_ net264
+ clknet_leaf_61_clk id_stage_i.controller_i.lsu_addr_last_i\[2\]
+ _13354_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[30\]$_DFFE_PN0P_ _01638_ net264
+ clknet_leaf_59_clk id_stage_i.controller_i.lsu_addr_last_i\[30\]
+ _13353_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[31\]$_DFFE_PN0P_ _01639_ net264
+ clknet_leaf_62_clk id_stage_i.controller_i.lsu_addr_last_i\[31\]
+ _13352_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[3\]$_DFFE_PN0P_ _01640_ net264
+ clknet_leaf_62_clk id_stage_i.controller_i.lsu_addr_last_i\[3\]
+ _13351_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[4\]$_DFFE_PN0P_ _01641_ net264
+ clknet_leaf_61_clk id_stage_i.controller_i.lsu_addr_last_i\[4\]
+ _13350_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[5\]$_DFFE_PN0P_ _01642_ net264
+ clknet_leaf_63_clk id_stage_i.controller_i.lsu_addr_last_i\[5\]
+ _13349_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[6\]$_DFFE_PN0P_ _01643_ net264
+ clknet_leaf_62_clk id_stage_i.controller_i.lsu_addr_last_i\[6\]
+ _13348_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[7\]$_DFFE_PN0P_ _01644_ net264
+ clknet_leaf_63_clk id_stage_i.controller_i.lsu_addr_last_i\[7\]
+ _13347_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[8\]$_DFFE_PN0P_ _01645_ net264
+ clknet_leaf_63_clk id_stage_i.controller_i.lsu_addr_last_i\[8\]
+ _13346_ VDD VSS DFFR_X1
Xload_store_unit_i.addr_last_q\[9\]$_DFFE_PN0P_ _01646_ net264
+ clknet_leaf_63_clk id_stage_i.controller_i.lsu_addr_last_i\[9\]
+ _13345_ VDD VSS DFFR_X1
Xload_store_unit_i.data_sign_ext_q$_DFFE_PN0P_ _01647_ net258
+ clknet_leaf_11_clk load_store_unit_i.data_sign_ext_q _13344_
+ VDD VSS DFFR_X2
Xload_store_unit_i.data_we_q$_DFFE_PN0P_ _01648_ net258 clknet_leaf_11_clk
+ load_store_unit_i.data_we_q _01160_ VDD VSS DFFR_X1
Xload_store_unit_i.handle_misaligned_q$_DFFE_PN0P_ _01649_
+ net258 clknet_leaf_10_clk load_store_unit_i.handle_misaligned_q
+ _16085_ VDD VSS DFFR_X2
Xload_store_unit_i.ls_fsm_cs\[0\]$_DFFE_PN0P_ _01650_ net258
+ clknet_leaf_10_clk load_store_unit_i.ls_fsm_cs\[0\] _13343_
+ VDD VSS DFFR_X1
Xload_store_unit_i.ls_fsm_cs\[1\]$_DFFE_PN0P_ _01651_ net258
+ clknet_leaf_10_clk load_store_unit_i.ls_fsm_cs\[1\] _13342_
+ VDD VSS DFFR_X1
Xload_store_unit_i.ls_fsm_cs\[2\]$_DFFE_PN0P_ _01652_ net258
+ clknet_leaf_11_clk load_store_unit_i.ls_fsm_cs\[2\] _00171_
+ VDD VSS DFFR_X1
Xload_store_unit_i.lsu_err_q$_DFFE_PN0P_ _01653_ net258 clknet_leaf_11_clk
+ load_store_unit_i.lsu_err_q _13341_ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_offset_q\[0\]$_DFFE_PN0P_ _01654_
+ net258 clknet_leaf_10_clk load_store_unit_i.rdata_offset_q\[0\]
+ _13340_ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_offset_q\[1\]$_DFFE_PN0P_ _01655_
+ net258 clknet_leaf_11_clk load_store_unit_i.rdata_offset_q\[1\]
+ _13339_ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[0\]$_DFFE_PN0P_ _01656_ net261
+ clknet_leaf_3_clk load_store_unit_i.rdata_q\[8\] _13338_ VDD
+ VSS DFFR_X1
Xload_store_unit_i.rdata_q\[10\]$_DFFE_PN0P_ _01657_ net261
+ clknet_leaf_7_clk load_store_unit_i.rdata_q\[18\] _13337_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[11\]$_DFFE_PN0P_ _01658_ net261
+ clknet_leaf_6_clk load_store_unit_i.rdata_q\[19\] _13336_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[12\]$_DFFE_PN0P_ _01659_ net261
+ clknet_leaf_3_clk load_store_unit_i.rdata_q\[20\] _13335_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[13\]$_DFFE_PN0P_ _01660_ net261
+ clknet_leaf_3_clk load_store_unit_i.rdata_q\[21\] _13334_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[14\]$_DFFE_PN0P_ _01661_ net261
+ clknet_leaf_6_clk load_store_unit_i.rdata_q\[22\] _13333_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[15\]$_DFFE_PN0P_ _01662_ net258
+ clknet_leaf_5_clk load_store_unit_i.rdata_q\[23\] _13332_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[16\]$_DFFE_PN0P_ _01663_ net261
+ clknet_leaf_4_clk load_store_unit_i.rdata_q\[24\] _13331_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[17\]$_DFFE_PN0P_ _01664_ net261
+ clknet_leaf_7_clk load_store_unit_i.rdata_q\[25\] _13330_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[18\]$_DFFE_PN0P_ _01665_ net261
+ clknet_leaf_7_clk load_store_unit_i.rdata_q\[26\] _13329_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[19\]$_DFFE_PN0P_ _01666_ net261
+ clknet_leaf_6_clk load_store_unit_i.rdata_q\[27\] _13328_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[1\]$_DFFE_PN0P_ _01667_ net261
+ clknet_leaf_7_clk load_store_unit_i.rdata_q\[9\] _13327_ VDD
+ VSS DFFR_X1
Xload_store_unit_i.rdata_q\[20\]$_DFFE_PN0P_ _01668_ net261
+ clknet_leaf_3_clk load_store_unit_i.rdata_q\[28\] _13326_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[21\]$_DFFE_PN0P_ _01669_ net261
+ clknet_leaf_4_clk load_store_unit_i.rdata_q\[29\] _13325_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[22\]$_DFFE_PN0P_ _01670_ net261
+ clknet_leaf_7_clk load_store_unit_i.rdata_q\[30\] _13324_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[23\]$_DFFE_PN0P_ _01671_ net258
+ clknet_leaf_6_clk load_store_unit_i.rdata_q\[31\] _13323_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[2\]$_DFFE_PN0P_ _01672_ net261
+ clknet_leaf_7_clk load_store_unit_i.rdata_q\[10\] _13322_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[3\]$_DFFE_PN0P_ _01673_ net261
+ clknet_leaf_6_clk load_store_unit_i.rdata_q\[11\] _13321_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[4\]$_DFFE_PN0P_ _01674_ net261
+ clknet_leaf_3_clk load_store_unit_i.rdata_q\[12\] _13320_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[5\]$_DFFE_PN0P_ _01675_ net261
+ clknet_leaf_3_clk load_store_unit_i.rdata_q\[13\] _13319_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[6\]$_DFFE_PN0P_ _01676_ net261
+ clknet_leaf_6_clk load_store_unit_i.rdata_q\[14\] _13318_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[7\]$_DFFE_PN0P_ _01677_ net261
+ clknet_leaf_6_clk load_store_unit_i.rdata_q\[15\] _13317_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[8\]$_DFFE_PN0P_ _01678_ net261
+ clknet_leaf_3_clk load_store_unit_i.rdata_q\[16\] _13316_
+ VDD VSS DFFR_X1
Xload_store_unit_i.rdata_q\[9\]$_DFFE_PN0P_ _01679_ net261
+ clknet_leaf_7_clk load_store_unit_i.rdata_q\[17\] _13315_
+ VDD VSS DFFR_X1
Xclone1 _03792_ _03662_ net1 VDD VSS NOR2_X4
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Right_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Right_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Right_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Right_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Right_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Right_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Right_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Right_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Right_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Right_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Right_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Right_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Right_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Right_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Right_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Right_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Right_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Right_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Right_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Right_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Right_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Right_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Right_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Right_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Right_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Right_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Right_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Right_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Right_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Right_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Right_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Right_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Right_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Right_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Right_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Right_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Right_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Right_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Right_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Right_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Right_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Right_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Right_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Right_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Right_89 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Right_90 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Right_91 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Right_92 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Right_93 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Right_94 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Right_95 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Right_96 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Right_97 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Right_98 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Right_99 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Right_100 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Right_101 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Right_102 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Right_103 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Right_104 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Right_105 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Right_106 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Right_107 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Right_108 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Right_109 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Right_110 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Right_111 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Right_112 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Right_113 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Right_114 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Right_115 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Right_116 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Right_117 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Right_118 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Right_119 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Right_120 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Right_121 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Right_122 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Right_123 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Right_124 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Right_125 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Right_126 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Right_127 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Right_128 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Right_129 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Right_130 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Right_131 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Right_132 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_133_Right_133 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_134_Right_134 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_135_Right_135 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_136_Right_136 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_137_Right_137 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_138_Right_138 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_139_Right_139 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_140_Right_140 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_141_Right_141 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_142_Right_142 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_143_Right_143 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_144_Right_144 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_145_Right_145 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_146_Right_146 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_147_Right_147 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_148_Right_148 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_149_Right_149 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_150_Right_150 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_151_Right_151 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_152_Right_152 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_153_Right_153 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_154_Right_154 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_155_Right_155 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_156_Right_156 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_157_Right_157 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_158_Right_158 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_159_Right_159 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_160_Right_160 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_161_Right_161 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_162_Right_162 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_163_Right_163 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_164_Right_164 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_165_Right_165 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_166_Right_166 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_167_Right_167 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_168_Right_168 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_169_Right_169 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_170 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_171 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_172 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_173 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_174 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_175 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_176 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_177 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_178 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_179 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_180 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_181 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_182 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_183 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_184 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_185 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_186 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_187 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_188 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_189 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_190 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_191 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_192 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_193 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_194 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_195 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_196 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_197 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_198 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_199 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_200 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_201 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_202 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_203 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_204 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_205 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_206 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_207 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_208 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_209 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_210 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_211 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_212 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_213 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_214 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Left_215 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Left_216 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Left_217 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Left_218 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Left_219 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Left_220 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Left_221 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Left_222 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Left_223 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Left_224 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Left_225 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Left_226 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Left_227 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Left_228 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Left_229 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Left_230 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Left_231 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Left_232 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Left_233 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Left_234 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Left_235 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Left_236 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Left_237 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Left_238 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Left_239 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Left_240 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Left_241 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Left_242 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Left_243 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Left_244 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Left_245 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Left_246 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Left_247 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Left_248 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Left_249 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Left_250 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Left_251 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Left_252 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Left_253 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Left_254 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Left_255 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Left_256 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Left_257 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Left_258 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Left_259 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Left_260 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Left_261 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Left_262 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Left_263 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Left_264 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Left_265 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Left_266 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Left_267 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Left_268 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Left_269 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Left_270 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Left_271 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Left_272 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Left_273 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Left_274 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Left_275 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Left_276 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Left_277 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Left_278 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Left_279 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Left_280 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Left_281 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Left_282 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Left_283 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Left_284 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Left_285 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Left_286 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Left_287 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Left_288 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Left_289 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Left_290 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Left_291 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Left_292 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Left_293 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Left_294 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Left_295 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Left_296 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Left_297 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Left_298 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Left_299 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Left_300 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Left_301 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Left_302 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_133_Left_303 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_134_Left_304 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_135_Left_305 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_136_Left_306 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_137_Left_307 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_138_Left_308 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_139_Left_309 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_140_Left_310 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_141_Left_311 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_142_Left_312 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_143_Left_313 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_144_Left_314 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_145_Left_315 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_146_Left_316 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_147_Left_317 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_148_Left_318 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_149_Left_319 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_150_Left_320 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_151_Left_321 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_152_Left_322 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_153_Left_323 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_154_Left_324 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_155_Left_325 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_156_Left_326 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_157_Left_327 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_158_Left_328 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_159_Left_329 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_160_Left_330 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_161_Left_331 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_162_Left_332 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_163_Left_333 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_164_Left_334 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_165_Left_335 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_166_Left_336 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_167_Left_337 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_168_Left_338 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_169_Left_339 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_340 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_2_341 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_4_342 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_6_343 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_8_344 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_10_345 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_12_346 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_14_347 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_16_348 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_18_349 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_20_350 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_22_351 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_24_352 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_26_353 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_28_354 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_30_355 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_32_356 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_34_357 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_36_358 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_38_359 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_40_360 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_42_361 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_44_362 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_46_363 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_48_364 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_50_365 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_52_366 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_54_367 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_56_368 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_58_369 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_60_370 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_62_371 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_64_372 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_66_373 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_68_374 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_70_375 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_72_376 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_74_377 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_76_378 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_78_379 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_80_380 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_82_381 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_84_382 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_86_383 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_88_384 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_90_385 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_92_386 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_94_387 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_96_388 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_98_389 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_100_390 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_102_391 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_104_392 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_106_393 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_108_394 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_110_395 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_112_396 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_114_397 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_116_398 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_118_399 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_120_400 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_122_401 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_124_402 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_126_403 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_128_404 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_130_405 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_132_406 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_134_407 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_136_408 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_138_409 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_140_410 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_142_411 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_144_412 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_146_413 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_148_414 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_150_415 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_152_416 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_154_417 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_156_418 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_158_419 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_160_420 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_162_421 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_164_422 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_166_423 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_168_424 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_169_425 VDD VSS TAPCELL_X1
Xinput1 boot_addr_i[10] net3 VDD VSS BUF_X1
Xinput2 boot_addr_i[11] net4 VDD VSS BUF_X1
Xinput3 boot_addr_i[12] net5 VDD VSS CLKBUF_X2
Xinput4 boot_addr_i[13] net6 VDD VSS BUF_X1
Xinput5 boot_addr_i[14] net7 VDD VSS BUF_X1
Xinput6 boot_addr_i[15] net8 VDD VSS CLKBUF_X2
Xinput7 boot_addr_i[16] net9 VDD VSS BUF_X1
Xinput8 boot_addr_i[17] net10 VDD VSS BUF_X1
Xinput9 boot_addr_i[18] net11 VDD VSS BUF_X2
Xinput10 boot_addr_i[19] net12 VDD VSS BUF_X1
Xinput11 boot_addr_i[20] net13 VDD VSS BUF_X1
Xinput12 boot_addr_i[21] net14 VDD VSS BUF_X1
Xinput13 boot_addr_i[22] net15 VDD VSS BUF_X1
Xinput14 boot_addr_i[23] net16 VDD VSS BUF_X1
Xinput15 boot_addr_i[24] net17 VDD VSS BUF_X1
Xinput16 boot_addr_i[25] net18 VDD VSS BUF_X1
Xinput17 boot_addr_i[26] net19 VDD VSS BUF_X1
Xinput18 boot_addr_i[27] net20 VDD VSS BUF_X1
Xinput19 boot_addr_i[28] net21 VDD VSS BUF_X1
Xinput20 boot_addr_i[29] net22 VDD VSS BUF_X1
Xinput21 boot_addr_i[30] net23 VDD VSS BUF_X1
Xinput22 boot_addr_i[31] net24 VDD VSS BUF_X1
Xinput23 boot_addr_i[8] net25 VDD VSS BUF_X1
Xinput24 boot_addr_i[9] net26 VDD VSS BUF_X1
Xinput25 data_err_i net27 VDD VSS BUF_X2
Xinput26 data_gnt_i net28 VDD VSS CLKBUF_X3
Xinput27 data_rdata_i[0] net29 VDD VSS CLKBUF_X2
Xinput28 data_rdata_i[10] net30 VDD VSS BUF_X2
Xinput29 data_rdata_i[11] net31 VDD VSS BUF_X2
Xinput30 data_rdata_i[12] net32 VDD VSS BUF_X1
Xinput31 data_rdata_i[13] net33 VDD VSS BUF_X1
Xinput32 data_rdata_i[14] net34 VDD VSS BUF_X2
Xinput33 data_rdata_i[15] net35 VDD VSS BUF_X2
Xinput34 data_rdata_i[16] net36 VDD VSS BUF_X1
Xinput35 data_rdata_i[17] net37 VDD VSS BUF_X2
Xinput36 data_rdata_i[18] net38 VDD VSS BUF_X2
Xinput37 data_rdata_i[19] net39 VDD VSS BUF_X2
Xinput38 data_rdata_i[1] net40 VDD VSS BUF_X2
Xinput39 data_rdata_i[20] net41 VDD VSS BUF_X1
Xinput40 data_rdata_i[21] net42 VDD VSS BUF_X1
Xinput41 data_rdata_i[22] net43 VDD VSS BUF_X2
Xinput42 data_rdata_i[24] net44 VDD VSS CLKBUF_X2
Xinput43 data_rdata_i[25] net45 VDD VSS BUF_X2
Xinput44 data_rdata_i[26] net46 VDD VSS BUF_X2
Xinput45 data_rdata_i[27] net47 VDD VSS BUF_X2
Xinput46 data_rdata_i[28] net48 VDD VSS CLKBUF_X2
Xinput47 data_rdata_i[29] net49 VDD VSS CLKBUF_X2
Xinput48 data_rdata_i[2] net50 VDD VSS BUF_X2
Xinput49 data_rdata_i[30] net51 VDD VSS BUF_X2
Xinput50 data_rdata_i[31] net52 VDD VSS BUF_X2
Xinput51 data_rdata_i[3] net53 VDD VSS BUF_X2
Xinput52 data_rdata_i[4] net54 VDD VSS BUF_X1
Xinput53 data_rdata_i[5] net55 VDD VSS BUF_X1
Xinput54 data_rdata_i[6] net56 VDD VSS BUF_X2
Xinput55 data_rdata_i[7] net57 VDD VSS BUF_X2
Xinput56 data_rdata_i[8] net58 VDD VSS BUF_X2
Xinput57 data_rdata_i[9] net59 VDD VSS BUF_X2
Xinput58 debug_req_i net60 VDD VSS BUF_X2
Xinput59 fetch_enable_i net61 VDD VSS BUF_X1
Xinput60 hart_id_i[0] net62 VDD VSS BUF_X1
Xinput61 hart_id_i[10] net63 VDD VSS BUF_X1
Xinput62 hart_id_i[11] net64 VDD VSS BUF_X1
Xinput63 hart_id_i[12] net65 VDD VSS BUF_X1
Xinput64 hart_id_i[13] net66 VDD VSS BUF_X1
Xinput65 hart_id_i[14] net67 VDD VSS BUF_X1
Xinput66 hart_id_i[15] net68 VDD VSS BUF_X1
Xinput67 hart_id_i[16] net69 VDD VSS BUF_X1
Xinput68 hart_id_i[17] net70 VDD VSS BUF_X1
Xinput69 hart_id_i[18] net71 VDD VSS BUF_X1
Xinput70 hart_id_i[19] net72 VDD VSS BUF_X1
Xinput71 hart_id_i[1] net73 VDD VSS BUF_X1
Xinput72 hart_id_i[20] net74 VDD VSS BUF_X1
Xinput73 hart_id_i[21] net75 VDD VSS BUF_X1
Xinput74 hart_id_i[22] net76 VDD VSS BUF_X1
Xinput75 hart_id_i[23] net77 VDD VSS BUF_X1
Xinput76 hart_id_i[24] net78 VDD VSS BUF_X1
Xinput77 hart_id_i[25] net79 VDD VSS BUF_X1
Xinput78 hart_id_i[26] net80 VDD VSS BUF_X1
Xinput79 hart_id_i[27] net81 VDD VSS BUF_X1
Xinput80 hart_id_i[28] net82 VDD VSS BUF_X1
Xinput81 hart_id_i[29] net83 VDD VSS BUF_X1
Xinput82 hart_id_i[2] net84 VDD VSS BUF_X1
Xinput83 hart_id_i[30] net85 VDD VSS BUF_X1
Xinput84 hart_id_i[31] net86 VDD VSS BUF_X1
Xinput85 hart_id_i[3] net87 VDD VSS BUF_X1
Xinput86 hart_id_i[4] net88 VDD VSS BUF_X1
Xinput87 hart_id_i[5] net89 VDD VSS BUF_X1
Xinput88 hart_id_i[6] net90 VDD VSS BUF_X1
Xinput89 hart_id_i[7] net91 VDD VSS BUF_X1
Xinput90 hart_id_i[8] net92 VDD VSS BUF_X1
Xinput91 hart_id_i[9] net93 VDD VSS BUF_X1
Xinput92 instr_gnt_i net94 VDD VSS CLKBUF_X3
Xinput93 instr_rdata_i[0] net95 VDD VSS BUF_X1
Xinput94 instr_rdata_i[10] net96 VDD VSS BUF_X1
Xinput95 instr_rdata_i[11] net97 VDD VSS BUF_X1
Xinput96 instr_rdata_i[12] net98 VDD VSS BUF_X1
Xinput97 instr_rdata_i[13] net99 VDD VSS BUF_X1
Xinput98 instr_rdata_i[14] net100 VDD VSS BUF_X1
Xinput99 instr_rdata_i[15] net101 VDD VSS BUF_X1
Xinput100 instr_rdata_i[18] net102 VDD VSS BUF_X1
Xinput101 instr_rdata_i[19] net103 VDD VSS BUF_X1
Xinput102 instr_rdata_i[1] net104 VDD VSS BUF_X1
Xinput103 instr_rdata_i[20] net105 VDD VSS BUF_X1
Xinput104 instr_rdata_i[21] net106 VDD VSS BUF_X1
Xinput105 instr_rdata_i[22] net107 VDD VSS BUF_X1
Xinput106 instr_rdata_i[23] net108 VDD VSS BUF_X1
Xinput107 instr_rdata_i[24] net109 VDD VSS BUF_X1
Xinput108 instr_rdata_i[25] net110 VDD VSS BUF_X1
Xinput109 instr_rdata_i[26] net111 VDD VSS BUF_X1
Xinput110 instr_rdata_i[27] net112 VDD VSS BUF_X1
Xinput111 instr_rdata_i[28] net113 VDD VSS BUF_X1
Xinput112 instr_rdata_i[29] net114 VDD VSS BUF_X1
Xinput113 instr_rdata_i[2] net115 VDD VSS BUF_X1
Xinput114 instr_rdata_i[30] net116 VDD VSS BUF_X1
Xinput115 instr_rdata_i[31] net117 VDD VSS BUF_X1
Xinput116 instr_rdata_i[3] net118 VDD VSS BUF_X1
Xinput117 instr_rdata_i[4] net119 VDD VSS BUF_X1
Xinput118 instr_rdata_i[5] net120 VDD VSS BUF_X1
Xinput119 instr_rdata_i[6] net121 VDD VSS BUF_X1
Xinput120 instr_rdata_i[7] net122 VDD VSS BUF_X1
Xinput121 instr_rdata_i[8] net123 VDD VSS BUF_X1
Xinput122 instr_rdata_i[9] net124 VDD VSS BUF_X1
Xinput123 instr_rvalid_i net125 VDD VSS CLKBUF_X2
Xinput124 irq_external_i net126 VDD VSS BUF_X2
Xinput125 irq_fast_i[0] net127 VDD VSS BUF_X1
Xinput126 irq_fast_i[10] net128 VDD VSS BUF_X1
Xinput127 irq_fast_i[11] net129 VDD VSS BUF_X1
Xinput128 irq_fast_i[12] net130 VDD VSS BUF_X2
Xinput129 irq_fast_i[13] net131 VDD VSS BUF_X2
Xinput130 irq_fast_i[14] net132 VDD VSS BUF_X1
Xinput131 irq_fast_i[1] net133 VDD VSS CLKBUF_X2
Xinput132 irq_fast_i[2] net134 VDD VSS BUF_X2
Xinput133 irq_fast_i[3] net135 VDD VSS BUF_X2
Xinput134 irq_fast_i[4] net136 VDD VSS BUF_X2
Xinput135 irq_fast_i[5] net137 VDD VSS CLKBUF_X2
Xinput136 irq_fast_i[6] net138 VDD VSS BUF_X2
Xinput137 irq_fast_i[7] net139 VDD VSS BUF_X2
Xinput138 irq_fast_i[8] net140 VDD VSS BUF_X1
Xinput139 irq_fast_i[9] net141 VDD VSS CLKBUF_X2
Xinput140 irq_software_i net142 VDD VSS BUF_X2
Xinput141 irq_timer_i net143 VDD VSS BUF_X1
Xinput142 net405 net144 VDD VSS BUF_X32
Xinput143 test_en_i net145 VDD VSS BUF_X1
Xoutput144 net146 core_sleep_o VDD VSS BUF_X1
Xoutput145 net147 data_addr_o[10] VDD VSS BUF_X1
Xoutput146 net148 data_addr_o[11] VDD VSS BUF_X1
Xoutput147 net149 data_addr_o[12] VDD VSS BUF_X1
Xoutput148 net150 data_addr_o[13] VDD VSS BUF_X1
Xoutput149 net151 data_addr_o[14] VDD VSS BUF_X1
Xoutput150 net152 data_addr_o[15] VDD VSS BUF_X1
Xoutput151 net153 data_addr_o[16] VDD VSS BUF_X1
Xoutput152 net154 data_addr_o[17] VDD VSS BUF_X1
Xoutput153 net155 data_addr_o[18] VDD VSS BUF_X1
Xoutput154 net156 data_addr_o[19] VDD VSS BUF_X1
Xoutput155 net157 data_addr_o[20] VDD VSS BUF_X1
Xoutput156 net158 data_addr_o[21] VDD VSS BUF_X1
Xoutput157 net159 data_addr_o[22] VDD VSS BUF_X1
Xoutput158 net160 data_addr_o[23] VDD VSS BUF_X1
Xoutput159 net161 data_addr_o[24] VDD VSS BUF_X1
Xoutput160 net162 data_addr_o[25] VDD VSS BUF_X1
Xoutput161 net163 data_addr_o[26] VDD VSS BUF_X1
Xoutput162 net164 data_addr_o[27] VDD VSS BUF_X1
Xoutput163 net165 data_addr_o[28] VDD VSS BUF_X1
Xoutput164 net166 data_addr_o[29] VDD VSS BUF_X1
Xoutput165 net167 data_addr_o[2] VDD VSS BUF_X1
Xoutput166 net168 data_addr_o[30] VDD VSS BUF_X1
Xoutput167 net169 data_addr_o[31] VDD VSS BUF_X1
Xoutput168 net170 data_addr_o[3] VDD VSS BUF_X1
Xoutput169 net171 data_addr_o[4] VDD VSS BUF_X1
Xoutput170 net172 data_addr_o[5] VDD VSS BUF_X1
Xoutput171 net173 data_addr_o[6] VDD VSS BUF_X1
Xoutput172 net174 data_addr_o[7] VDD VSS BUF_X1
Xoutput173 net175 data_addr_o[8] VDD VSS BUF_X1
Xoutput174 net176 data_addr_o[9] VDD VSS BUF_X1
Xoutput175 net177 data_be_o[0] VDD VSS BUF_X1
Xoutput176 net178 data_be_o[1] VDD VSS BUF_X1
Xoutput177 net179 data_be_o[2] VDD VSS BUF_X1
Xoutput178 net180 data_be_o[3] VDD VSS BUF_X1
Xoutput179 net181 data_req_o VDD VSS BUF_X1
Xoutput180 net182 data_wdata_o[0] VDD VSS BUF_X1
Xoutput181 net183 data_wdata_o[10] VDD VSS BUF_X1
Xoutput182 net184 data_wdata_o[11] VDD VSS BUF_X1
Xoutput183 net185 data_wdata_o[12] VDD VSS BUF_X1
Xoutput184 net186 data_wdata_o[13] VDD VSS BUF_X1
Xoutput185 net187 data_wdata_o[14] VDD VSS BUF_X1
Xoutput186 net188 data_wdata_o[15] VDD VSS BUF_X1
Xoutput187 net189 data_wdata_o[16] VDD VSS BUF_X1
Xoutput188 net190 data_wdata_o[17] VDD VSS BUF_X1
Xoutput189 net191 data_wdata_o[18] VDD VSS BUF_X1
Xoutput190 net192 data_wdata_o[19] VDD VSS BUF_X1
Xoutput191 net193 data_wdata_o[1] VDD VSS BUF_X1
Xoutput192 net194 data_wdata_o[20] VDD VSS BUF_X1
Xoutput193 net195 data_wdata_o[21] VDD VSS BUF_X1
Xoutput194 net196 data_wdata_o[22] VDD VSS BUF_X1
Xoutput195 net197 data_wdata_o[23] VDD VSS BUF_X1
Xoutput196 net198 data_wdata_o[24] VDD VSS BUF_X1
Xoutput197 net199 data_wdata_o[25] VDD VSS BUF_X1
Xoutput198 net200 data_wdata_o[26] VDD VSS BUF_X1
Xoutput199 net201 data_wdata_o[27] VDD VSS BUF_X1
Xoutput200 net202 data_wdata_o[28] VDD VSS BUF_X1
Xoutput201 net203 data_wdata_o[29] VDD VSS BUF_X1
Xoutput202 net204 data_wdata_o[2] VDD VSS BUF_X1
Xoutput203 net205 data_wdata_o[30] VDD VSS BUF_X1
Xoutput204 net206 data_wdata_o[31] VDD VSS BUF_X1
Xoutput205 net207 data_wdata_o[3] VDD VSS BUF_X1
Xoutput206 net208 data_wdata_o[4] VDD VSS BUF_X1
Xoutput207 net209 data_wdata_o[5] VDD VSS BUF_X1
Xoutput208 net210 data_wdata_o[6] VDD VSS BUF_X1
Xoutput209 net211 data_wdata_o[7] VDD VSS BUF_X1
Xoutput210 net212 data_wdata_o[8] VDD VSS BUF_X1
Xoutput211 net213 data_wdata_o[9] VDD VSS BUF_X1
Xoutput212 net214 data_we_o VDD VSS BUF_X1
Xoutput213 net215 instr_addr_o[10] VDD VSS BUF_X1
Xoutput214 net216 instr_addr_o[11] VDD VSS BUF_X1
Xoutput215 net217 instr_addr_o[12] VDD VSS BUF_X1
Xoutput216 net218 instr_addr_o[13] VDD VSS BUF_X1
Xoutput217 net219 instr_addr_o[14] VDD VSS BUF_X1
Xoutput218 net220 instr_addr_o[15] VDD VSS BUF_X1
Xoutput219 net221 instr_addr_o[16] VDD VSS BUF_X1
Xoutput220 net222 instr_addr_o[17] VDD VSS BUF_X1
Xoutput221 net223 instr_addr_o[18] VDD VSS BUF_X1
Xoutput222 net224 instr_addr_o[19] VDD VSS BUF_X1
Xoutput223 net225 instr_addr_o[20] VDD VSS BUF_X1
Xoutput224 net226 instr_addr_o[21] VDD VSS BUF_X1
Xoutput225 net227 instr_addr_o[22] VDD VSS BUF_X1
Xoutput226 net228 instr_addr_o[23] VDD VSS BUF_X1
Xoutput227 net229 instr_addr_o[24] VDD VSS BUF_X1
Xoutput228 net230 instr_addr_o[25] VDD VSS BUF_X1
Xoutput229 net231 instr_addr_o[26] VDD VSS BUF_X1
Xoutput230 net232 instr_addr_o[27] VDD VSS BUF_X1
Xoutput231 net233 instr_addr_o[28] VDD VSS BUF_X1
Xoutput232 net234 instr_addr_o[29] VDD VSS BUF_X1
Xoutput233 net235 instr_addr_o[2] VDD VSS BUF_X1
Xoutput234 net236 instr_addr_o[30] VDD VSS BUF_X1
Xoutput235 net237 instr_addr_o[31] VDD VSS BUF_X1
Xoutput236 net238 instr_addr_o[3] VDD VSS BUF_X1
Xoutput237 net239 instr_addr_o[4] VDD VSS BUF_X1
Xoutput238 net240 instr_addr_o[5] VDD VSS BUF_X1
Xoutput239 net241 instr_addr_o[6] VDD VSS BUF_X1
Xoutput240 net242 instr_addr_o[7] VDD VSS BUF_X1
Xoutput241 net243 instr_addr_o[8] VDD VSS BUF_X1
Xoutput242 net244 instr_addr_o[9] VDD VSS BUF_X1
Xoutput243 net245 instr_req_o VDD VSS BUF_X1
Xmax_cap244 alu_adder_result_ex\[29\] net246 VDD VSS BUF_X4
Xmax_cap245 alu_adder_result_ex\[1\] net247 VDD VSS BUF_X8
Xmax_cap246 _04510_ net248 VDD VSS BUF_X4
Xmax_cap247 _05198_ net249 VDD VSS BUF_X4
Xmax_cap248 net251 net250 VDD VSS BUF_X2
Xmax_cap249 _10391_ net251 VDD VSS BUF_X2
Xmax_cap250 net275 net252 VDD VSS BUF_X1
Xwire251 _11489_ net253 VDD VSS BUF_X2
Xmax_cap252 _03437_ net254 VDD VSS BUF_X4
Xmax_length253 net258 net255 VDD VSS BUF_X32
Xwire254 net257 net256 VDD VSS BUF_X32
Xmax_length255 net258 net257 VDD VSS BUF_X32
Xwire256 net262 net258 VDD VSS BUF_X32
Xmax_length257 net261 net259 VDD VSS BUF_X32
Xmax_length258 net261 net260 VDD VSS BUF_X32
Xmax_length259 net262 net261 VDD VSS BUF_X32
Xmax_length260 net144 net262 VDD VSS BUF_X32
Xmax_length261 net264 net263 VDD VSS BUF_X32
Xmax_length262 net265 net264 VDD VSS BUF_X32
Xmax_length263 net144 net265 VDD VSS BUF_X32
X_29849__264 net266 VDD VSS LOGIC0_X1
X_29850__265 net267 VDD VSS LOGIC0_X1
X_29851__266 net268 VDD VSS LOGIC0_X1
X_29852__267 net269 VDD VSS LOGIC0_X1
X_29883__268 net270 VDD VSS LOGIC0_X1
X_29884__269 net271 VDD VSS LOGIC0_X1
Xclkbuf_0_clk_i clk_i clknet_0_clk_i VDD VSS CLKBUF_X3
Xclkbuf_1_0__f_clk_i clknet_0_clk_i clknet_1_0__leaf_clk_i
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_0_clk_i_regs clknet_4_1_0_clk_i_regs clknet_leaf_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_1_clk_i_regs clknet_4_0_0_clk_i_regs clknet_leaf_1_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_2_clk_i_regs clknet_4_0_0_clk_i_regs clknet_leaf_2_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_3_clk_i_regs clknet_4_0_0_clk_i_regs clknet_leaf_3_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_4_clk_i_regs clknet_4_0_0_clk_i_regs clknet_leaf_4_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_5_clk_i_regs clknet_4_0_0_clk_i_regs clknet_leaf_5_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_6_clk_i_regs clknet_4_2_0_clk_i_regs clknet_leaf_6_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_7_clk_i_regs clknet_4_2_0_clk_i_regs clknet_leaf_7_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_8_clk_i_regs clknet_4_2_0_clk_i_regs clknet_leaf_8_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_9_clk_i_regs clknet_4_2_0_clk_i_regs clknet_leaf_9_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_10_clk_i_regs clknet_4_2_0_clk_i_regs clknet_leaf_10_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_11_clk_i_regs clknet_4_3_0_clk_i_regs clknet_leaf_11_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_12_clk_i_regs clknet_4_1_0_clk_i_regs clknet_leaf_12_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_13_clk_i_regs clknet_4_1_0_clk_i_regs clknet_leaf_13_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_14_clk_i_regs clknet_4_1_0_clk_i_regs clknet_leaf_14_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_15_clk_i_regs clknet_4_1_0_clk_i_regs clknet_leaf_15_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_16_clk_i_regs clknet_4_3_0_clk_i_regs clknet_leaf_16_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_17_clk_i_regs clknet_4_3_0_clk_i_regs clknet_leaf_17_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_18_clk_i_regs clknet_4_3_0_clk_i_regs clknet_leaf_18_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_19_clk_i_regs clknet_4_3_0_clk_i_regs clknet_leaf_19_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_20_clk_i_regs clknet_4_6_0_clk_i_regs clknet_leaf_20_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_21_clk_i_regs clknet_4_6_0_clk_i_regs clknet_leaf_21_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_22_clk_i_regs clknet_4_6_0_clk_i_regs clknet_leaf_22_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_23_clk_i_regs clknet_4_3_0_clk_i_regs clknet_leaf_23_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_24_clk_i_regs clknet_4_3_0_clk_i_regs clknet_leaf_24_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_25_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_25_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_26_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_26_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_27_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_27_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_28_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_28_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_29_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_29_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_30_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_30_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_31_clk_i_regs clknet_4_3_0_clk_i_regs clknet_leaf_31_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_32_clk_i_regs clknet_4_2_0_clk_i_regs clknet_leaf_32_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_33_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_33_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_34_clk_i_regs clknet_4_2_0_clk_i_regs clknet_leaf_34_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_35_clk_i_regs clknet_4_2_0_clk_i_regs clknet_leaf_35_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_36_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_36_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_37_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_37_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_38_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_38_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_39_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_39_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_40_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_40_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_41_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_41_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_42_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_42_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_43_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_43_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_44_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_44_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_45_clk_i_regs clknet_4_10_0_clk_i_regs clknet_leaf_45_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_46_clk_i_regs clknet_4_10_0_clk_i_regs clknet_leaf_46_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_47_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_47_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_48_clk_i_regs clknet_4_8_0_clk_i_regs clknet_leaf_48_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_49_clk_i_regs clknet_4_10_0_clk_i_regs clknet_leaf_49_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_50_clk_i_regs clknet_4_10_0_clk_i_regs clknet_leaf_50_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_51_clk_i_regs clknet_4_10_0_clk_i_regs clknet_leaf_51_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_52_clk_i_regs clknet_4_10_0_clk_i_regs clknet_leaf_52_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_53_clk_i_regs clknet_4_10_0_clk_i_regs clknet_leaf_53_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_54_clk_i_regs clknet_4_10_0_clk_i_regs clknet_leaf_54_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_55_clk_i_regs clknet_4_10_0_clk_i_regs clknet_leaf_55_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_56_clk_i_regs clknet_4_10_0_clk_i_regs clknet_leaf_56_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_57_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_57_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_58_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_58_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_59_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_59_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_60_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_60_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_61_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_61_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_62_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_62_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_63_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_63_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_64_clk_i_regs clknet_4_14_0_clk_i_regs clknet_leaf_64_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_65_clk_i_regs clknet_4_14_0_clk_i_regs clknet_leaf_65_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_66_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_66_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_67_clk_i_regs clknet_4_14_0_clk_i_regs clknet_leaf_67_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_68_clk_i_regs clknet_4_14_0_clk_i_regs clknet_leaf_68_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_69_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_69_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_70_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_70_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_71_clk_i_regs clknet_4_11_0_clk_i_regs clknet_leaf_71_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_72_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_72_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_73_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_73_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_74_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_74_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_75_clk_i_regs clknet_4_12_0_clk_i_regs clknet_leaf_75_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_76_clk_i_regs clknet_4_12_0_clk_i_regs clknet_leaf_76_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_77_clk_i_regs clknet_4_12_0_clk_i_regs clknet_leaf_77_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_78_clk_i_regs clknet_4_9_0_clk_i_regs clknet_leaf_78_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_79_clk_i_regs clknet_4_12_0_clk_i_regs clknet_leaf_79_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_80_clk_i_regs clknet_4_12_0_clk_i_regs clknet_leaf_80_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_81_clk_i_regs clknet_4_12_0_clk_i_regs clknet_leaf_81_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_82_clk_i_regs clknet_4_12_0_clk_i_regs clknet_leaf_82_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_83_clk_i_regs clknet_4_12_0_clk_i_regs clknet_leaf_83_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_84_clk_i_regs clknet_4_12_0_clk_i_regs clknet_leaf_84_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_85_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_85_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_86_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_86_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_87_clk_i_regs clknet_4_15_0_clk_i_regs clknet_leaf_87_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_88_clk_i_regs clknet_4_15_0_clk_i_regs clknet_leaf_88_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_89_clk_i_regs clknet_4_15_0_clk_i_regs clknet_leaf_89_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_90_clk_i_regs clknet_4_14_0_clk_i_regs clknet_leaf_90_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_91_clk_i_regs clknet_4_14_0_clk_i_regs clknet_leaf_91_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_92_clk_i_regs clknet_4_14_0_clk_i_regs clknet_leaf_92_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_93_clk_i_regs clknet_4_14_0_clk_i_regs clknet_leaf_93_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_94_clk_i_regs clknet_4_14_0_clk_i_regs clknet_leaf_94_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_95_clk_i_regs clknet_4_14_0_clk_i_regs clknet_leaf_95_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_96_clk_i_regs clknet_4_15_0_clk_i_regs clknet_leaf_96_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_97_clk_i_regs clknet_4_15_0_clk_i_regs clknet_leaf_97_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_98_clk_i_regs clknet_4_15_0_clk_i_regs clknet_leaf_98_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_99_clk_i_regs clknet_4_15_0_clk_i_regs clknet_leaf_99_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_100_clk_i_regs clknet_4_15_0_clk_i_regs clknet_leaf_100_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_101_clk_i_regs clknet_4_15_0_clk_i_regs clknet_leaf_101_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_102_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_102_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_103_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_103_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_104_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_104_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_105_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_105_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_106_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_106_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_107_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_107_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_108_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_108_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_109_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_109_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_110_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_110_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_111_clk_i_regs clknet_4_13_0_clk_i_regs clknet_leaf_111_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_112_clk_i_regs clknet_4_12_0_clk_i_regs clknet_leaf_112_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_113_clk_i_regs clknet_4_7_0_clk_i_regs clknet_leaf_113_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_114_clk_i_regs clknet_4_7_0_clk_i_regs clknet_leaf_114_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_115_clk_i_regs clknet_4_7_0_clk_i_regs clknet_leaf_115_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_116_clk_i_regs clknet_4_7_0_clk_i_regs clknet_leaf_116_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_117_clk_i_regs clknet_4_5_0_clk_i_regs clknet_leaf_117_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_118_clk_i_regs clknet_4_5_0_clk_i_regs clknet_leaf_118_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_119_clk_i_regs clknet_4_5_0_clk_i_regs clknet_leaf_119_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_120_clk_i_regs clknet_4_5_0_clk_i_regs clknet_leaf_120_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_121_clk_i_regs clknet_4_5_0_clk_i_regs clknet_leaf_121_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_122_clk_i_regs clknet_4_4_0_clk_i_regs clknet_leaf_122_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_123_clk_i_regs clknet_4_7_0_clk_i_regs clknet_leaf_123_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_124_clk_i_regs clknet_4_6_0_clk_i_regs clknet_leaf_124_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_125_clk_i_regs clknet_4_6_0_clk_i_regs clknet_leaf_125_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_126_clk_i_regs clknet_4_6_0_clk_i_regs clknet_leaf_126_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_127_clk_i_regs clknet_4_4_0_clk_i_regs clknet_leaf_127_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_128_clk_i_regs clknet_4_4_0_clk_i_regs clknet_leaf_128_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_129_clk_i_regs clknet_4_4_0_clk_i_regs clknet_leaf_129_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_130_clk_i_regs clknet_4_4_0_clk_i_regs clknet_leaf_130_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_131_clk_i_regs clknet_4_4_0_clk_i_regs clknet_leaf_131_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_132_clk_i_regs clknet_4_4_0_clk_i_regs clknet_leaf_132_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_133_clk_i_regs clknet_4_4_0_clk_i_regs clknet_leaf_133_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_134_clk_i_regs clknet_4_4_0_clk_i_regs clknet_leaf_134_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_135_clk_i_regs clknet_4_4_0_clk_i_regs clknet_leaf_135_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_136_clk_i_regs clknet_4_1_0_clk_i_regs clknet_leaf_136_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_137_clk_i_regs clknet_4_0_0_clk_i_regs clknet_leaf_137_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_138_clk_i_regs clknet_4_1_0_clk_i_regs clknet_leaf_138_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_139_clk_i_regs clknet_4_1_0_clk_i_regs clknet_leaf_139_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_0_clk_i_regs clk_i_regs clknet_0_clk_i_regs VDD VSS
+ CLKBUF_X3
Xclkbuf_4_0_0_clk_i_regs clknet_0_clk_i_regs clknet_4_0_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_1_0_clk_i_regs clknet_0_clk_i_regs clknet_4_1_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_2_0_clk_i_regs clknet_0_clk_i_regs clknet_4_2_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_3_0_clk_i_regs clknet_0_clk_i_regs clknet_4_3_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_4_0_clk_i_regs clknet_0_clk_i_regs clknet_4_4_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_5_0_clk_i_regs clknet_0_clk_i_regs clknet_4_5_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_6_0_clk_i_regs clknet_0_clk_i_regs clknet_4_6_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_7_0_clk_i_regs clknet_0_clk_i_regs clknet_4_7_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_8_0_clk_i_regs clknet_0_clk_i_regs clknet_4_8_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_9_0_clk_i_regs clknet_0_clk_i_regs clknet_4_9_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_10_0_clk_i_regs clknet_0_clk_i_regs clknet_4_10_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_11_0_clk_i_regs clknet_0_clk_i_regs clknet_4_11_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_12_0_clk_i_regs clknet_0_clk_i_regs clknet_4_12_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_13_0_clk_i_regs clknet_0_clk_i_regs clknet_4_13_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_14_0_clk_i_regs clknet_0_clk_i_regs clknet_4_14_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkbuf_4_15_0_clk_i_regs clknet_0_clk_i_regs clknet_4_15_0_clk_i_regs
+ VDD VSS CLKBUF_X3
Xclkload0 clknet_4_0_0_clk_i_regs _unconnected_0 VDD VSS INV_X4
Xclkload1 clknet_4_1_0_clk_i_regs _unconnected_1 VDD VSS INV_X4
Xclkload2 clknet_4_2_0_clk_i_regs _unconnected_2 VDD VSS INV_X4
Xclkload3 clknet_4_3_0_clk_i_regs _unconnected_3 VDD VSS INV_X4
Xclkload4 clknet_4_4_0_clk_i_regs _unconnected_4 VDD VSS INV_X2
Xclkload5 clknet_4_5_0_clk_i_regs _unconnected_5 VDD VSS INV_X8
Xclkload6 clknet_4_6_0_clk_i_regs _unconnected_6 VDD VSS INV_X4
Xclkload7 clknet_4_7_0_clk_i_regs _unconnected_7 VDD VSS INV_X8
Xclkload8 clknet_4_8_0_clk_i_regs _unconnected_8 VDD VSS CLKBUF_X3
Xclkload9 clknet_4_9_0_clk_i_regs _unconnected_9 VDD VSS CLKBUF_X3
Xclkload10 clknet_4_10_0_clk_i_regs _unconnected_10 VDD VSS
+ INV_X2
Xclkload11 clknet_4_11_0_clk_i_regs _unconnected_11 VDD VSS
+ CLKBUF_X3
Xclkload12 clknet_4_12_0_clk_i_regs _unconnected_12 VDD VSS
+ INV_X2
Xclkload13 clknet_4_14_0_clk_i_regs _unconnected_13 VDD VSS
+ INV_X2
Xclkload14 clknet_4_15_0_clk_i_regs _unconnected_14 VDD VSS
+ INV_X2
Xclkload15 clknet_leaf_1_clk_i_regs _unconnected_15 VDD VSS
+ CLKBUF_X1
Xclkload16 clknet_leaf_2_clk_i_regs _unconnected_16 VDD VSS
+ CLKBUF_X1
Xclkload17 clknet_leaf_4_clk_i_regs _unconnected_17 VDD VSS
+ CLKBUF_X1
Xclkload18 clknet_leaf_5_clk_i_regs _unconnected_18 VDD VSS
+ INV_X1
Xclkload19 clknet_leaf_137_clk_i_regs _unconnected_19 VDD
+ VSS INV_X1
Xclkload20 clknet_leaf_0_clk_i_regs _unconnected_20 VDD VSS
+ CLKBUF_X1
Xclkload21 clknet_leaf_15_clk_i_regs _unconnected_21 VDD VSS
+ INV_X1
Xclkload22 clknet_leaf_136_clk_i_regs _unconnected_22 VDD
+ VSS INV_X1
Xclkload23 clknet_leaf_138_clk_i_regs _unconnected_23 VDD
+ VSS INV_X1
Xclkload24 clknet_leaf_139_clk_i_regs _unconnected_24 VDD
+ VSS INV_X2
Xclkload25 clknet_leaf_7_clk_i_regs _unconnected_25 VDD VSS
+ CLKBUF_X1
Xclkload26 clknet_leaf_9_clk_i_regs _unconnected_26 VDD VSS
+ INV_X1
Xclkload27 clknet_leaf_32_clk_i_regs _unconnected_27 VDD VSS
+ CLKBUF_X1
Xclkload28 clknet_leaf_34_clk_i_regs _unconnected_28 VDD VSS
+ CLKBUF_X1
Xclkload29 clknet_leaf_11_clk_i_regs _unconnected_29 VDD VSS
+ INV_X1
Xclkload30 clknet_leaf_16_clk_i_regs _unconnected_30 VDD VSS
+ INV_X2
Xclkload31 clknet_leaf_17_clk_i_regs _unconnected_31 VDD VSS
+ CLKBUF_X1
Xclkload32 clknet_leaf_18_clk_i_regs _unconnected_32 VDD VSS
+ INV_X2
Xclkload33 clknet_leaf_19_clk_i_regs _unconnected_33 VDD VSS
+ INV_X2
Xclkload34 clknet_leaf_24_clk_i_regs _unconnected_34 VDD VSS
+ INV_X1
Xclkload35 clknet_leaf_31_clk_i_regs _unconnected_35 VDD VSS
+ INV_X1
Xclkload36 clknet_leaf_122_clk_i_regs _unconnected_36 VDD
+ VSS INV_X1
Xclkload37 clknet_leaf_128_clk_i_regs _unconnected_37 VDD
+ VSS CLKBUF_X1
Xclkload38 clknet_leaf_129_clk_i_regs _unconnected_38 VDD
+ VSS CLKBUF_X1
Xclkload39 clknet_leaf_130_clk_i_regs _unconnected_39 VDD
+ VSS CLKBUF_X1
Xclkload40 clknet_leaf_134_clk_i_regs _unconnected_40 VDD
+ VSS CLKBUF_X1
Xclkload41 clknet_leaf_135_clk_i_regs _unconnected_41 VDD
+ VSS CLKBUF_X1
Xclkload42 clknet_leaf_117_clk_i_regs _unconnected_42 VDD
+ VSS INV_X4
Xclkload43 clknet_leaf_118_clk_i_regs _unconnected_43 VDD
+ VSS INV_X4
Xclkload44 clknet_leaf_121_clk_i_regs _unconnected_44 VDD
+ VSS INV_X1
Xclkload45 clknet_leaf_21_clk_i_regs _unconnected_45 VDD VSS
+ CLKBUF_X1
Xclkload46 clknet_leaf_22_clk_i_regs _unconnected_46 VDD VSS
+ INV_X1
Xclkload47 clknet_leaf_124_clk_i_regs _unconnected_47 VDD
+ VSS CLKBUF_X1
Xclkload48 clknet_leaf_125_clk_i_regs _unconnected_48 VDD
+ VSS CLKBUF_X1
Xclkload49 clknet_leaf_126_clk_i_regs _unconnected_49 VDD
+ VSS CLKBUF_X1
Xclkload50 clknet_leaf_113_clk_i_regs _unconnected_50 VDD
+ VSS INV_X2
Xclkload51 clknet_leaf_114_clk_i_regs _unconnected_51 VDD
+ VSS CLKBUF_X1
Xclkload52 clknet_leaf_115_clk_i_regs _unconnected_52 VDD
+ VSS INV_X1
Xclkload53 clknet_leaf_116_clk_i_regs _unconnected_53 VDD
+ VSS INV_X1
Xclkload54 clknet_leaf_33_clk_i_regs _unconnected_54 VDD VSS
+ INV_X1
Xclkload55 clknet_leaf_41_clk_i_regs _unconnected_55 VDD VSS
+ CLKBUF_X1
Xclkload56 clknet_leaf_42_clk_i_regs _unconnected_56 VDD VSS
+ INV_X1
Xclkload57 clknet_leaf_43_clk_i_regs _unconnected_57 VDD VSS
+ CLKBUF_X1
Xclkload58 clknet_leaf_47_clk_i_regs _unconnected_58 VDD VSS
+ CLKBUF_X1
Xclkload59 clknet_leaf_25_clk_i_regs _unconnected_59 VDD VSS
+ CLKBUF_X1
Xclkload60 clknet_leaf_26_clk_i_regs _unconnected_60 VDD VSS
+ INV_X1
Xclkload61 clknet_leaf_27_clk_i_regs _unconnected_61 VDD VSS
+ INV_X1
Xclkload62 clknet_leaf_28_clk_i_regs _unconnected_62 VDD VSS
+ INV_X2
Xclkload63 clknet_leaf_29_clk_i_regs _unconnected_63 VDD VSS
+ CLKBUF_X1
Xclkload64 clknet_leaf_30_clk_i_regs _unconnected_64 VDD VSS
+ CLKBUF_X1
Xclkload65 clknet_leaf_72_clk_i_regs _unconnected_65 VDD VSS
+ INV_X1
Xclkload66 clknet_leaf_73_clk_i_regs _unconnected_66 VDD VSS
+ CLKBUF_X1
Xclkload67 clknet_leaf_74_clk_i_regs _unconnected_67 VDD VSS
+ CLKBUF_X1
Xclkload68 clknet_leaf_78_clk_i_regs _unconnected_68 VDD VSS
+ INV_X1
Xclkload69 clknet_leaf_45_clk_i_regs _unconnected_69 VDD VSS
+ INV_X1
Xclkload70 clknet_leaf_49_clk_i_regs _unconnected_70 VDD VSS
+ INV_X1
Xclkload71 clknet_leaf_50_clk_i_regs _unconnected_71 VDD VSS
+ INV_X1
Xclkload72 clknet_leaf_52_clk_i_regs _unconnected_72 VDD VSS
+ CLKBUF_X1
Xclkload73 clknet_leaf_53_clk_i_regs _unconnected_73 VDD VSS
+ CLKBUF_X1
Xclkload74 clknet_leaf_54_clk_i_regs _unconnected_74 VDD VSS
+ CLKBUF_X1
Xclkload75 clknet_leaf_55_clk_i_regs _unconnected_75 VDD VSS
+ CLKBUF_X1
Xclkload76 clknet_leaf_56_clk_i_regs _unconnected_76 VDD VSS
+ CLKBUF_X1
Xclkload77 clknet_leaf_57_clk_i_regs _unconnected_77 VDD VSS
+ CLKBUF_X1
Xclkload78 clknet_leaf_59_clk_i_regs _unconnected_78 VDD VSS
+ CLKBUF_X1
Xclkload79 clknet_leaf_60_clk_i_regs _unconnected_79 VDD VSS
+ CLKBUF_X1
Xclkload80 clknet_leaf_61_clk_i_regs _unconnected_80 VDD VSS
+ CLKBUF_X1
Xclkload81 clknet_leaf_62_clk_i_regs _unconnected_81 VDD VSS
+ CLKBUF_X1
Xclkload82 clknet_leaf_63_clk_i_regs _unconnected_82 VDD VSS
+ CLKBUF_X1
Xclkload83 clknet_leaf_69_clk_i_regs _unconnected_83 VDD VSS
+ CLKBUF_X1
Xclkload84 clknet_leaf_70_clk_i_regs _unconnected_84 VDD VSS
+ CLKBUF_X1
Xclkload85 clknet_leaf_77_clk_i_regs _unconnected_85 VDD VSS
+ INV_X1
Xclkload86 clknet_leaf_80_clk_i_regs _unconnected_86 VDD VSS
+ CLKBUF_X1
Xclkload87 clknet_leaf_81_clk_i_regs _unconnected_87 VDD VSS
+ CLKBUF_X1
Xclkload88 clknet_leaf_82_clk_i_regs _unconnected_88 VDD VSS
+ CLKBUF_X1
Xclkload89 clknet_leaf_83_clk_i_regs _unconnected_89 VDD VSS
+ CLKBUF_X1
Xclkload90 clknet_leaf_84_clk_i_regs _unconnected_90 VDD VSS
+ CLKBUF_X1
Xclkload91 clknet_leaf_85_clk_i_regs _unconnected_91 VDD VSS
+ CLKBUF_X1
Xclkload92 clknet_leaf_102_clk_i_regs _unconnected_92 VDD
+ VSS INV_X1
Xclkload93 clknet_leaf_103_clk_i_regs _unconnected_93 VDD
+ VSS CLKBUF_X1
Xclkload94 clknet_leaf_104_clk_i_regs _unconnected_94 VDD
+ VSS CLKBUF_X1
Xclkload95 clknet_leaf_105_clk_i_regs _unconnected_95 VDD
+ VSS CLKBUF_X1
Xclkload96 clknet_leaf_107_clk_i_regs _unconnected_96 VDD
+ VSS CLKBUF_X1
Xclkload97 clknet_leaf_109_clk_i_regs _unconnected_97 VDD
+ VSS CLKBUF_X1
Xclkload98 clknet_leaf_110_clk_i_regs _unconnected_98 VDD
+ VSS CLKBUF_X1
Xclkload99 clknet_leaf_111_clk_i_regs _unconnected_99 VDD
+ VSS INV_X1
Xclkload100 clknet_leaf_64_clk_i_regs _unconnected_100 VDD
+ VSS CLKBUF_X1
Xclkload101 clknet_leaf_68_clk_i_regs _unconnected_101 VDD
+ VSS CLKBUF_X1
Xclkload102 clknet_leaf_91_clk_i_regs _unconnected_102 VDD
+ VSS INV_X1
Xclkload103 clknet_leaf_92_clk_i_regs _unconnected_103 VDD
+ VSS CLKBUF_X1
Xclkload104 clknet_leaf_93_clk_i_regs _unconnected_104 VDD
+ VSS CLKBUF_X1
Xclkload105 clknet_leaf_95_clk_i_regs _unconnected_105 VDD
+ VSS CLKBUF_X1
Xclkload106 clknet_leaf_87_clk_i_regs _unconnected_106 VDD
+ VSS INV_X1
Xclkload107 clknet_leaf_88_clk_i_regs _unconnected_107 VDD
+ VSS INV_X1
Xclkload108 clknet_leaf_89_clk_i_regs _unconnected_108 VDD
+ VSS INV_X1
Xclkload109 clknet_leaf_97_clk_i_regs _unconnected_109 VDD
+ VSS INV_X1
Xclkload110 clknet_leaf_98_clk_i_regs _unconnected_110 VDD
+ VSS INV_X2
Xclkload111 clknet_leaf_99_clk_i_regs _unconnected_111 VDD
+ VSS INV_X2
Xclkload112 clknet_leaf_100_clk_i_regs _unconnected_112 VDD
+ VSS CLKBUF_X1
Xclkload113 clknet_leaf_101_clk_i_regs _unconnected_113 VDD
+ VSS INV_X4
Xclkbuf_leaf_0_clk clknet_4_0_0_clk clknet_leaf_0_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_1_clk clknet_4_0_0_clk clknet_leaf_1_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_2_clk clknet_4_0_0_clk clknet_leaf_2_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_3_clk clknet_4_0_0_clk clknet_leaf_3_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_4_clk clknet_4_0_0_clk clknet_leaf_4_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_5_clk clknet_4_2_0_clk clknet_leaf_5_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_6_clk clknet_4_2_0_clk clknet_leaf_6_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_7_clk clknet_4_2_0_clk clknet_leaf_7_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_8_clk clknet_4_2_0_clk clknet_leaf_8_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_9_clk clknet_4_2_0_clk clknet_leaf_9_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_10_clk clknet_4_2_0_clk clknet_leaf_10_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_11_clk clknet_4_2_0_clk clknet_leaf_11_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_12_clk clknet_4_3_0_clk clknet_leaf_12_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_13_clk clknet_4_3_0_clk clknet_leaf_13_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_14_clk clknet_4_2_0_clk clknet_leaf_14_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_15_clk clknet_4_10_0_clk clknet_leaf_15_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_16_clk clknet_4_10_0_clk clknet_leaf_16_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_17_clk clknet_4_10_0_clk clknet_leaf_17_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_18_clk clknet_4_10_0_clk clknet_leaf_18_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_19_clk clknet_4_10_0_clk clknet_leaf_19_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_20_clk clknet_4_10_0_clk clknet_leaf_20_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_21_clk clknet_4_10_0_clk clknet_leaf_21_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_22_clk clknet_4_11_0_clk clknet_leaf_22_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_23_clk clknet_4_11_0_clk clknet_leaf_23_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_24_clk clknet_4_11_0_clk clknet_leaf_24_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_25_clk clknet_4_11_0_clk clknet_leaf_25_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_26_clk clknet_4_10_0_clk clknet_leaf_26_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_27_clk clknet_4_8_0_clk clknet_leaf_27_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_28_clk clknet_4_8_0_clk clknet_leaf_28_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_29_clk clknet_4_8_0_clk clknet_leaf_29_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_30_clk clknet_4_9_0_clk clknet_leaf_30_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_31_clk clknet_4_9_0_clk clknet_leaf_31_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_32_clk clknet_4_11_0_clk clknet_leaf_32_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_33_clk clknet_4_9_0_clk clknet_leaf_33_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_34_clk clknet_4_9_0_clk clknet_leaf_34_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_35_clk clknet_4_9_0_clk clknet_leaf_35_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_36_clk clknet_4_14_0_clk clknet_leaf_36_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_37_clk clknet_4_14_0_clk clknet_leaf_37_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_38_clk clknet_4_14_0_clk clknet_leaf_38_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_39_clk clknet_4_15_0_clk clknet_leaf_39_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_40_clk clknet_4_15_0_clk clknet_leaf_40_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_41_clk clknet_4_15_0_clk clknet_leaf_41_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_42_clk clknet_4_15_0_clk clknet_leaf_42_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_43_clk clknet_4_14_0_clk clknet_leaf_43_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_44_clk clknet_4_14_0_clk clknet_leaf_44_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_45_clk clknet_4_14_0_clk clknet_leaf_45_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_46_clk clknet_4_14_0_clk clknet_leaf_46_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_47_clk clknet_4_15_0_clk clknet_leaf_47_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_48_clk clknet_4_15_0_clk clknet_leaf_48_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_49_clk clknet_4_13_0_clk clknet_leaf_49_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_50_clk clknet_4_13_0_clk clknet_leaf_50_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_51_clk clknet_4_13_0_clk clknet_leaf_51_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_52_clk clknet_4_13_0_clk clknet_leaf_52_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_53_clk clknet_4_13_0_clk clknet_leaf_53_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_54_clk clknet_4_12_0_clk clknet_leaf_54_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_55_clk clknet_4_12_0_clk clknet_leaf_55_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_56_clk clknet_4_13_0_clk clknet_leaf_56_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_57_clk clknet_4_12_0_clk clknet_leaf_57_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_58_clk clknet_4_12_0_clk clknet_leaf_58_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_59_clk clknet_4_12_0_clk clknet_leaf_59_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_60_clk clknet_4_12_0_clk clknet_leaf_60_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_61_clk clknet_4_12_0_clk clknet_leaf_61_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_62_clk clknet_4_12_0_clk clknet_leaf_62_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_63_clk clknet_4_8_0_clk clknet_leaf_63_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_64_clk clknet_4_12_0_clk clknet_leaf_64_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_65_clk clknet_4_12_0_clk clknet_leaf_65_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_66_clk clknet_4_6_0_clk clknet_leaf_66_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_67_clk clknet_4_6_0_clk clknet_leaf_67_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_68_clk clknet_4_6_0_clk clknet_leaf_68_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_69_clk clknet_4_6_0_clk clknet_leaf_69_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_70_clk clknet_4_7_0_clk clknet_leaf_70_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_71_clk clknet_4_7_0_clk clknet_leaf_71_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_72_clk clknet_4_7_0_clk clknet_leaf_72_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_73_clk clknet_4_12_0_clk clknet_leaf_73_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_74_clk clknet_4_13_0_clk clknet_leaf_74_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_75_clk clknet_4_7_0_clk clknet_leaf_75_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_76_clk clknet_4_13_0_clk clknet_leaf_76_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_77_clk clknet_4_13_0_clk clknet_leaf_77_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_78_clk clknet_4_7_0_clk clknet_leaf_78_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_79_clk clknet_4_7_0_clk clknet_leaf_79_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_80_clk clknet_4_7_0_clk clknet_leaf_80_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_81_clk clknet_4_7_0_clk clknet_leaf_81_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_82_clk clknet_4_7_0_clk clknet_leaf_82_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_83_clk clknet_4_7_0_clk clknet_leaf_83_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_84_clk clknet_4_5_0_clk clknet_leaf_84_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_85_clk clknet_4_5_0_clk clknet_leaf_85_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_86_clk clknet_4_5_0_clk clknet_leaf_86_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_87_clk clknet_4_5_0_clk clknet_leaf_87_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_88_clk clknet_4_5_0_clk clknet_leaf_88_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_89_clk clknet_4_5_0_clk clknet_leaf_89_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_90_clk clknet_4_5_0_clk clknet_leaf_90_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_91_clk clknet_4_5_0_clk clknet_leaf_91_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_92_clk clknet_4_5_0_clk clknet_leaf_92_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_93_clk clknet_4_4_0_clk clknet_leaf_93_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_94_clk clknet_4_5_0_clk clknet_leaf_94_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_95_clk clknet_4_5_0_clk clknet_leaf_95_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_96_clk clknet_4_5_0_clk clknet_leaf_96_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_97_clk clknet_4_5_0_clk clknet_leaf_97_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_98_clk clknet_4_4_0_clk clknet_leaf_98_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_99_clk clknet_4_4_0_clk clknet_leaf_99_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_leaf_100_clk clknet_4_4_0_clk clknet_leaf_100_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_101_clk clknet_4_4_0_clk clknet_leaf_101_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_102_clk clknet_4_4_0_clk clknet_leaf_102_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_103_clk clknet_4_4_0_clk clknet_leaf_103_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_104_clk clknet_4_4_0_clk clknet_leaf_104_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_105_clk clknet_4_4_0_clk clknet_leaf_105_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_106_clk clknet_4_4_0_clk clknet_leaf_106_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_107_clk clknet_4_4_0_clk clknet_leaf_107_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_108_clk clknet_4_4_0_clk clknet_leaf_108_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_109_clk clknet_4_6_0_clk clknet_leaf_109_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_110_clk clknet_4_6_0_clk clknet_leaf_110_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_111_clk clknet_4_6_0_clk clknet_leaf_111_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_112_clk clknet_4_6_0_clk clknet_leaf_112_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_113_clk clknet_4_3_0_clk clknet_leaf_113_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_114_clk clknet_4_3_0_clk clknet_leaf_114_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_115_clk clknet_4_3_0_clk clknet_leaf_115_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_116_clk clknet_4_3_0_clk clknet_leaf_116_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_117_clk clknet_4_3_0_clk clknet_leaf_117_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_118_clk clknet_4_3_0_clk clknet_leaf_118_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_119_clk clknet_4_1_0_clk clknet_leaf_119_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_120_clk clknet_4_1_0_clk clknet_leaf_120_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_121_clk clknet_4_1_0_clk clknet_leaf_121_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_122_clk clknet_4_1_0_clk clknet_leaf_122_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_123_clk clknet_4_1_0_clk clknet_leaf_123_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_124_clk clknet_4_1_0_clk clknet_leaf_124_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_125_clk clknet_4_1_0_clk clknet_leaf_125_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_126_clk clknet_4_1_0_clk clknet_leaf_126_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_127_clk clknet_4_1_0_clk clknet_leaf_127_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_128_clk clknet_4_1_0_clk clknet_leaf_128_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_129_clk clknet_4_1_0_clk clknet_leaf_129_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_130_clk clknet_4_0_0_clk clknet_leaf_130_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_131_clk clknet_4_0_0_clk clknet_leaf_131_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_132_clk clknet_4_0_0_clk clknet_leaf_132_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_133_clk clknet_4_0_0_clk clknet_leaf_133_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_134_clk clknet_4_0_0_clk clknet_leaf_134_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_135_clk clknet_4_0_0_clk clknet_leaf_135_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_0_0_clk clknet_0_clk clknet_4_0_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_1_0_clk clknet_0_clk clknet_4_1_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_2_0_clk clknet_0_clk clknet_4_2_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_3_0_clk clknet_0_clk clknet_4_3_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_4_0_clk clknet_0_clk clknet_4_4_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_5_0_clk clknet_0_clk clknet_4_5_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_6_0_clk clknet_0_clk clknet_4_6_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_7_0_clk clknet_0_clk clknet_4_7_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_8_0_clk clknet_0_clk clknet_4_8_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_9_0_clk clknet_0_clk clknet_4_9_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_10_0_clk clknet_0_clk clknet_4_10_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_11_0_clk clknet_0_clk clknet_4_11_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_12_0_clk clknet_0_clk clknet_4_12_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_13_0_clk clknet_0_clk clknet_4_13_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_14_0_clk clknet_0_clk clknet_4_14_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_15_0_clk clknet_0_clk clknet_4_15_0_clk VDD VSS
+ CLKBUF_X3
Xclkload114 clknet_4_0_0_clk _unconnected_114 VDD VSS INV_X2
Xclkload115 clknet_4_1_0_clk _unconnected_115 VDD VSS INV_X2
Xclkload116 clknet_4_2_0_clk _unconnected_116 VDD VSS INV_X4
Xclkload117 clknet_4_3_0_clk _unconnected_117 VDD VSS INV_X4
Xclkload118 clknet_4_4_0_clk _unconnected_118 VDD VSS CLKBUF_X3
Xclkload119 clknet_4_6_0_clk _unconnected_119 VDD VSS INV_X4
Xclkload120 clknet_4_7_0_clk _unconnected_120 VDD VSS INV_X2
Xclkload121 clknet_4_8_0_clk _unconnected_121 VDD VSS INV_X8
Xclkload122 clknet_4_9_0_clk _unconnected_122 VDD VSS INV_X8
Xclkload123 clknet_4_10_0_clk _unconnected_123 VDD VSS INV_X4
Xclkload124 clknet_4_11_0_clk _unconnected_124 VDD VSS INV_X8
Xclkload125 clknet_4_12_0_clk _unconnected_125 VDD VSS INV_X2
Xclkload126 clknet_4_13_0_clk _unconnected_126 VDD VSS INV_X4
Xclkload127 clknet_4_14_0_clk _unconnected_127 VDD VSS INV_X4
Xclkload128 clknet_4_15_0_clk _unconnected_128 VDD VSS INV_X8
Xclkload129 clknet_leaf_0_clk _unconnected_129 VDD VSS INV_X1
Xclkload130 clknet_leaf_1_clk _unconnected_130 VDD VSS INV_X1
Xclkload131 clknet_leaf_2_clk _unconnected_131 VDD VSS CLKBUF_X1
Xclkload132 clknet_leaf_3_clk _unconnected_132 VDD VSS INV_X1
Xclkload133 clknet_leaf_4_clk _unconnected_133 VDD VSS INV_X2
Xclkload134 clknet_leaf_130_clk _unconnected_134 VDD VSS INV_X1
Xclkload135 clknet_leaf_131_clk _unconnected_135 VDD VSS CLKBUF_X1
Xclkload136 clknet_leaf_133_clk _unconnected_136 VDD VSS INV_X1
Xclkload137 clknet_leaf_135_clk _unconnected_137 VDD VSS INV_X2
Xclkload138 clknet_leaf_119_clk _unconnected_138 VDD VSS CLKBUF_X1
Xclkload139 clknet_leaf_120_clk _unconnected_139 VDD VSS INV_X1
Xclkload140 clknet_leaf_121_clk _unconnected_140 VDD VSS INV_X1
Xclkload141 clknet_leaf_122_clk _unconnected_141 VDD VSS INV_X1
Xclkload142 clknet_leaf_124_clk _unconnected_142 VDD VSS CLKBUF_X1
Xclkload143 clknet_leaf_125_clk _unconnected_143 VDD VSS CLKBUF_X1
Xclkload144 clknet_leaf_126_clk _unconnected_144 VDD VSS CLKBUF_X2
Xclkload145 clknet_leaf_127_clk _unconnected_145 VDD VSS CLKBUF_X2
Xclkload146 clknet_leaf_128_clk _unconnected_146 VDD VSS CLKBUF_X1
Xclkload147 clknet_leaf_129_clk _unconnected_147 VDD VSS INV_X4
Xclkload148 clknet_leaf_5_clk _unconnected_148 VDD VSS INV_X2
Xclkload149 clknet_leaf_6_clk _unconnected_149 VDD VSS INV_X1
Xclkload150 clknet_leaf_7_clk _unconnected_150 VDD VSS INV_X1
Xclkload151 clknet_leaf_9_clk _unconnected_151 VDD VSS INV_X2
Xclkload152 clknet_leaf_10_clk _unconnected_152 VDD VSS INV_X1
Xclkload153 clknet_leaf_11_clk _unconnected_153 VDD VSS CLKBUF_X1
Xclkload154 clknet_leaf_14_clk _unconnected_154 VDD VSS INV_X4
Xclkload155 clknet_leaf_12_clk _unconnected_155 VDD VSS CLKBUF_X1
Xclkload156 clknet_leaf_13_clk _unconnected_156 VDD VSS INV_X1
Xclkload157 clknet_leaf_113_clk _unconnected_157 VDD VSS INV_X2
Xclkload158 clknet_leaf_114_clk _unconnected_158 VDD VSS CLKBUF_X1
Xclkload159 clknet_leaf_115_clk _unconnected_159 VDD VSS CLKBUF_X1
Xclkload160 clknet_leaf_116_clk _unconnected_160 VDD VSS CLKBUF_X1
Xclkload161 clknet_leaf_117_clk _unconnected_161 VDD VSS CLKBUF_X1
Xclkload162 clknet_leaf_93_clk _unconnected_162 VDD VSS CLKBUF_X1
Xclkload163 clknet_leaf_99_clk _unconnected_163 VDD VSS INV_X1
Xclkload164 clknet_leaf_100_clk _unconnected_164 VDD VSS CLKBUF_X1
Xclkload165 clknet_leaf_101_clk _unconnected_165 VDD VSS CLKBUF_X1
Xclkload166 clknet_leaf_102_clk _unconnected_166 VDD VSS INV_X1
Xclkload167 clknet_leaf_103_clk _unconnected_167 VDD VSS CLKBUF_X1
Xclkload168 clknet_leaf_104_clk _unconnected_168 VDD VSS CLKBUF_X1
Xclkload169 clknet_leaf_105_clk _unconnected_169 VDD VSS INV_X1
Xclkload170 clknet_leaf_106_clk _unconnected_170 VDD VSS INV_X1
Xclkload171 clknet_leaf_107_clk _unconnected_171 VDD VSS INV_X2
Xclkload172 clknet_leaf_108_clk _unconnected_172 VDD VSS CLKBUF_X1
Xclkload173 clknet_leaf_84_clk _unconnected_173 VDD VSS INV_X1
Xclkload174 clknet_leaf_85_clk _unconnected_174 VDD VSS INV_X1
Xclkload175 clknet_leaf_87_clk _unconnected_175 VDD VSS CLKBUF_X1
Xclkload176 clknet_leaf_88_clk _unconnected_176 VDD VSS CLKBUF_X1
Xclkload177 clknet_leaf_89_clk _unconnected_177 VDD VSS CLKBUF_X1
Xclkload178 clknet_leaf_90_clk _unconnected_178 VDD VSS INV_X1
Xclkload179 clknet_leaf_91_clk _unconnected_179 VDD VSS CLKBUF_X1
Xclkload180 clknet_leaf_92_clk _unconnected_180 VDD VSS INV_X1
Xclkload181 clknet_leaf_94_clk _unconnected_181 VDD VSS INV_X1
Xclkload182 clknet_leaf_95_clk _unconnected_182 VDD VSS CLKBUF_X1
Xclkload183 clknet_leaf_96_clk _unconnected_183 VDD VSS CLKBUF_X1
Xclkload184 clknet_leaf_97_clk _unconnected_184 VDD VSS CLKBUF_X1
Xclkload185 clknet_leaf_66_clk _unconnected_185 VDD VSS CLKBUF_X1
Xclkload186 clknet_leaf_67_clk _unconnected_186 VDD VSS CLKBUF_X1
Xclkload187 clknet_leaf_110_clk _unconnected_187 VDD VSS CLKBUF_X1
Xclkload188 clknet_leaf_111_clk _unconnected_188 VDD VSS CLKBUF_X1
Xclkload189 clknet_leaf_112_clk _unconnected_189 VDD VSS CLKBUF_X1
Xclkload190 clknet_leaf_72_clk _unconnected_190 VDD VSS CLKBUF_X1
Xclkload191 clknet_leaf_75_clk _unconnected_191 VDD VSS CLKBUF_X1
Xclkload192 clknet_leaf_78_clk _unconnected_192 VDD VSS INV_X1
Xclkload193 clknet_leaf_79_clk _unconnected_193 VDD VSS CLKBUF_X1
Xclkload194 clknet_leaf_80_clk _unconnected_194 VDD VSS CLKBUF_X1
Xclkload195 clknet_leaf_81_clk _unconnected_195 VDD VSS INV_X1
Xclkload196 clknet_leaf_82_clk _unconnected_196 VDD VSS INV_X1
Xclkload197 clknet_leaf_27_clk _unconnected_197 VDD VSS INV_X2
Xclkload198 clknet_leaf_29_clk _unconnected_198 VDD VSS CLKBUF_X1
Xclkload199 clknet_leaf_63_clk _unconnected_199 VDD VSS INV_X1
Xclkload200 clknet_leaf_30_clk _unconnected_200 VDD VSS CLKBUF_X1
Xclkload201 clknet_leaf_31_clk _unconnected_201 VDD VSS INV_X1
Xclkload202 clknet_leaf_33_clk _unconnected_202 VDD VSS CLKBUF_X1
Xclkload203 clknet_leaf_34_clk _unconnected_203 VDD VSS INV_X1
Xclkload204 clknet_leaf_15_clk _unconnected_204 VDD VSS INV_X2
Xclkload205 clknet_leaf_16_clk _unconnected_205 VDD VSS CLKBUF_X1
Xclkload206 clknet_leaf_17_clk _unconnected_206 VDD VSS INV_X1
Xclkload207 clknet_leaf_19_clk _unconnected_207 VDD VSS CLKBUF_X1
Xclkload208 clknet_leaf_20_clk _unconnected_208 VDD VSS CLKBUF_X1
Xclkload209 clknet_leaf_21_clk _unconnected_209 VDD VSS CLKBUF_X1
Xclkload210 clknet_leaf_26_clk _unconnected_210 VDD VSS INV_X1
Xclkload211 clknet_leaf_23_clk _unconnected_211 VDD VSS CLKBUF_X1
Xclkload212 clknet_leaf_24_clk _unconnected_212 VDD VSS CLKBUF_X1
Xclkload213 clknet_leaf_25_clk _unconnected_213 VDD VSS CLKBUF_X1
Xclkload214 clknet_leaf_32_clk _unconnected_214 VDD VSS CLKBUF_X1
Xclkload215 clknet_leaf_54_clk _unconnected_215 VDD VSS CLKBUF_X1
Xclkload216 clknet_leaf_55_clk _unconnected_216 VDD VSS INV_X1
Xclkload217 clknet_leaf_57_clk _unconnected_217 VDD VSS CLKBUF_X1
Xclkload218 clknet_leaf_58_clk _unconnected_218 VDD VSS INV_X1
Xclkload219 clknet_leaf_59_clk _unconnected_219 VDD VSS CLKBUF_X1
Xclkload220 clknet_leaf_61_clk _unconnected_220 VDD VSS INV_X1
Xclkload221 clknet_leaf_62_clk _unconnected_221 VDD VSS CLKBUF_X1
Xclkload222 clknet_leaf_64_clk _unconnected_222 VDD VSS CLKBUF_X1
Xclkload223 clknet_leaf_65_clk _unconnected_223 VDD VSS CLKBUF_X1
Xclkload224 clknet_leaf_73_clk _unconnected_224 VDD VSS INV_X1
Xclkload225 clknet_leaf_49_clk _unconnected_225 VDD VSS CLKBUF_X2
Xclkload226 clknet_leaf_50_clk _unconnected_226 VDD VSS CLKBUF_X1
Xclkload227 clknet_leaf_51_clk _unconnected_227 VDD VSS CLKBUF_X1
Xclkload228 clknet_leaf_52_clk _unconnected_228 VDD VSS CLKBUF_X1
Xclkload229 clknet_leaf_53_clk _unconnected_229 VDD VSS CLKBUF_X1
Xclkload230 clknet_leaf_56_clk _unconnected_230 VDD VSS CLKBUF_X2
Xclkload231 clknet_leaf_74_clk _unconnected_231 VDD VSS CLKBUF_X1
Xclkload232 clknet_leaf_77_clk _unconnected_232 VDD VSS CLKBUF_X1
Xclkload233 clknet_leaf_36_clk _unconnected_233 VDD VSS CLKBUF_X1
Xclkload234 clknet_leaf_37_clk _unconnected_234 VDD VSS CLKBUF_X1
Xclkload235 clknet_leaf_38_clk _unconnected_235 VDD VSS CLKBUF_X1
Xclkload236 clknet_leaf_43_clk _unconnected_236 VDD VSS CLKBUF_X1
Xclkload237 clknet_leaf_44_clk _unconnected_237 VDD VSS CLKBUF_X1
Xclkload238 clknet_leaf_46_clk _unconnected_238 VDD VSS INV_X1
Xclkload239 clknet_leaf_40_clk _unconnected_239 VDD VSS CLKBUF_X1
Xclkload240 clknet_leaf_41_clk _unconnected_240 VDD VSS CLKBUF_X1
Xclkload241 clknet_leaf_42_clk _unconnected_241 VDD VSS INV_X1
Xclkload242 clknet_leaf_47_clk _unconnected_242 VDD VSS CLKBUF_X1
Xclkload243 clknet_leaf_48_clk _unconnected_243 VDD VSS CLKBUF_X1
Xdelaybuf_0_core_clock delaynet_0_core_clock delaynet_1_core_clock
+ VDD VSS CLKBUF_X3
Xdelaybuf_1_core_clock delaynet_1_core_clock clk_i_regs VDD
+ VSS CLKBUF_X3
Xrebuffer1 _03392_ net272 VDD VSS BUF_X1
Xrebuffer2 net272 net273 VDD VSS BUF_X1
Xrebuffer3 net298 net274 VDD VSS BUF_X4
Xrebuffer4 _10391_ net275 VDD VSS BUF_X1
Xrebuffer5 net275 net276 VDD VSS BUF_X1
Xrebuffer6 _03417_ net277 VDD VSS BUF_X8
Xrebuffer7 net277 net278 VDD VSS BUF_X1
Xrebuffer8 _11500_ net279 VDD VSS BUF_X1
Xrebuffer10 _10511_ net281 VDD VSS BUF_X1
Xrebuffer11 _12896_ net282 VDD VSS BUF_X1
Xrebuffer12 _12823_ net283 VDD VSS BUF_X1
Xrebuffer13 _12392_ net284 VDD VSS BUF_X2
Xrebuffer15 net285 net286 VDD VSS BUF_X1
Xclone16 _12099_ net287 VDD VSS BUF_X4
Xrebuffer17 _10912_ net288 VDD VSS BUF_X1
Xrebuffer18 _12392_ net289 VDD VSS BUF_X1
Xrebuffer20 net290 net291 VDD VSS BUF_X1
Xrebuffer21 _11512_ net292 VDD VSS BUF_X1
Xrebuffer22 net292 net293 VDD VSS BUF_X2
Xrebuffer23 _11063_ net294 VDD VSS BUF_X1
Xrebuffer24 net329 net295 VDD VSS BUF_X1
Xrebuffer25 _11470_ net296 VDD VSS BUF_X4
Xrebuffer26 net296 net297 VDD VSS BUF_X1
Xrebuffer27 _10548_ net298 VDD VSS BUF_X1
Xrebuffer28 net298 net299 VDD VSS BUF_X1
Xclone29 _12144_ _03275_ _03655_ net300 VDD VSS MUX2_X1
Xrebuffer30 _15937_ net301 VDD VSS BUF_X1
Xrebuffer31 _10332_ net302 VDD VSS BUF_X1
Xrebuffer32 _10332_ net303 VDD VSS BUF_X1
Xrebuffer33 net303 net304 VDD VSS BUF_X1
Xclone34 _10310_ net305 VDD VSS BUF_X8
Xclone35 _10310_ net306 VDD VSS BUF_X8
Xrebuffer36 net251 net307 VDD VSS BUF_X1
Xrebuffer37 id_stage_i.controller_i.instr_i\[4\] net308 VDD
+ VSS BUF_X1
Xrebuffer38 _11486_ net309 VDD VSS BUF_X1
Xrebuffer39 _10487_ net310 VDD VSS BUF_X1
Xrebuffer40 _10487_ net311 VDD VSS BUF_X1
Xrebuffer41 _10487_ net312 VDD VSS BUF_X1
Xclone42 net314 net313 VDD VSS BUF_X4
Xrebuffer43 id_stage_i.controller_i.instr_i\[14\] net314 VDD
+ VSS BUF_X1
Xclone44 net316 net315 VDD VSS BUF_X4
Xrebuffer45 id_stage_i.controller_i.instr_i\[4\] net316 VDD
+ VSS BUF_X1
Xrebuffer46 _11554_ net317 VDD VSS BUF_X4
Xrebuffer47 net317 net318 VDD VSS BUF_X1
Xrebuffer48 net317 net319 VDD VSS BUF_X1
Xclone49 net321 net320 VDD VSS BUF_X4
Xrebuffer50 id_stage_i.controller_i.instr_i\[28\] net321 VDD
+ VSS BUF_X1
Xclone51 _04030_ net322 VDD VSS BUF_X8
Xclone52 net277 net323 VDD VSS INV_X8
Xrebuffer53 _10323_ net324 VDD VSS BUF_X1
Xrebuffer54 net410 net325 VDD VSS BUF_X1
Xrebuffer55 _15726_ net326 VDD VSS BUF_X2
Xrebuffer56 net326 net327 VDD VSS BUF_X1
Xrebuffer57 net365 net328 VDD VSS BUF_X1
Xrebuffer58 _11993_ net329 VDD VSS BUF_X4
Xrebuffer59 net329 net330 VDD VSS BUF_X1
Xrebuffer60 _13155_ net331 VDD VSS BUF_X1
Xrebuffer61 _12221_ net332 VDD VSS BUF_X1
Xrebuffer62 _13061_ net333 VDD VSS BUF_X1
Xrebuffer63 net654 net334 VDD VSS BUF_X16
Xclone65 net337 net336 VDD VSS BUF_X4
Xclone66 _11202_ _12896_ _03655_ net337 VDD VSS MUX2_X1
Xrebuffer67 _15700_ net338 VDD VSS BUF_X1
Xclone68 _03703_ net339 VDD VSS BUF_X4
Xclone69 net345 net408 _03655_ net340 VDD VSS MUX2_X1
Xrebuffer70 _12044_ net341 VDD VSS BUF_X4
Xrebuffer71 net341 net342 VDD VSS BUF_X1
Xclone72 _03697_ net343 VDD VSS BUF_X4
Xrebuffer73 _13224_ net344 VDD VSS BUF_X1
Xrebuffer76 _03675_ net347 VDD VSS BUF_X1
Xrebuffer77 _13258_ net348 VDD VSS BUF_X4
Xrebuffer78 net348 net349 VDD VSS BUF_X1
Xrebuffer79 net348 net350 VDD VSS BUF_X1
Xrebuffer80 net350 net351 VDD VSS BUF_X1
Xclone82 _03717_ net353 VDD VSS BUF_X4
Xclone83 _05210_ net354 VDD VSS BUF_X2
Xrebuffer84 _13187_ net355 VDD VSS BUF_X2
Xrebuffer85 _13187_ net356 VDD VSS BUF_X1
Xrebuffer86 net356 net357 VDD VSS BUF_X1
Xrebuffer87 _12683_ net358 VDD VSS BUF_X4
Xrebuffer88 net358 net359 VDD VSS BUF_X1
Xrebuffer89 net358 net360 VDD VSS BUF_X1
Xclone90 _03676_ net361 VDD VSS BUF_X4
Xclone91 _03675_ _12392_ _03656_ net362 VDD VSS MUX2_X1
Xclone92 net370 net363 VDD VSS BUF_X32
Xclone93 _10457_ net364 VDD VSS BUF_X16
Xclone95 _03689_ net366 VDD VSS BUF_X2
Xrebuffer96 _12482_ net367 VDD VSS BUF_X4
Xrebuffer97 _12553_ net368 VDD VSS BUF_X4
Xrebuffer98 net368 net369 VDD VSS BUF_X1
Xclone99 _10457_ net370 VDD VSS BUF_X32
Xclone100 net334 net371 VDD VSS BUF_X8
Xrebuffer102 net372 net373 VDD VSS BUF_X1
Xclone103 _10456_ net374 VDD VSS BUF_X16
Xrebuffer104 _12757_ net375 VDD VSS BUF_X4
Xrebuffer105 net375 net376 VDD VSS BUF_X1
Xrebuffer106 net375 net377 VDD VSS BUF_X1
Xrebuffer107 alu_adder_result_ex\[18\] net378 VDD VSS BUF_X1
Xrebuffer108 alu_adder_result_ex\[18\] net379 VDD VSS BUF_X1
Xrebuffer109 net379 net380 VDD VSS BUF_X1
Xrebuffer110 net380 net381 VDD VSS BUF_X1
Xrebuffer112 _03709_ net383 VDD VSS BUF_X2
Xclone113 _11933_ net384 VDD VSS BUF_X8
Xclone114 _11933_ net385 VDD VSS BUF_X8
Xclone115 _12771_ _12762_ net386 VDD VSS XNOR2_X1
Xclone116 net388 net387 VDD VSS INV_X2
Xrebuffer117 _13111_ net388 VDD VSS BUF_X1
Xrebuffer118 _13110_ net389 VDD VSS BUF_X2
Xrebuffer119 alu_adder_result_ex\[27\] net390 VDD VSS BUF_X1
Xrebuffer120 net390 net391 VDD VSS BUF_X1
Xrebuffer121 net393 net392 VDD VSS BUF_X1
Xrebuffer122 alu_adder_result_ex\[23\] net393 VDD VSS BUF_X1
Xrebuffer123 alu_adder_result_ex\[14\] net394 VDD VSS BUF_X2
Xrebuffer124 alu_adder_result_ex\[14\] net395 VDD VSS BUF_X1
Xclone125 _12949_ net396 VDD VSS BUF_X2
Xrebuffer126 alu_adder_result_ex\[26\] net397 VDD VSS BUF_X2
Xrebuffer127 net397 net398 VDD VSS BUF_X1
Xrebuffer128 net397 net399 VDD VSS BUF_X1
Xrebuffer129 _08049_ net400 VDD VSS BUF_X4
Xrebuffer130 net400 net401 VDD VSS BUF_X2
Xrebuffer131 alu_adder_result_ex\[19\] net402 VDD VSS BUF_X1
Xrebuffer132 net402 net403 VDD VSS BUF_X1
Xrebuffer133 alu_adder_result_ex\[10\] net404 VDD VSS BUF_X1
Xhold134 rst_ni net405 VDD VSS CLKBUF_X1
Xwire1 _11158_ net345 VDD VSS BUF_X4
Xrebuffer29 _12823_ net407 VDD VSS BUF_X4
Xrebuffer34 net407 net408 VDD VSS BUF_X1
Xclone36 _04849_ net409 VDD VSS BUF_X4
Xrebuffer42 _12725_ net410 VDD VSS BUF_X4
Xclone43 _10456_ net411 VDD VSS BUF_X16
Xrebuffer160 _05161_ net478 VDD VSS BUF_X4
Xclone200 _04849_ net518 VDD VSS BUF_X2
Xrebuffer336 _10335_ net654 VDD VSS BUF_X8
Xclone337 _06173_ net655 VDD VSS BUF_X4
Xclone350 _06173_ net668 VDD VSS BUF_X4
Xclone357 _05210_ net675 VDD VSS BUF_X4
Xclone358 net363 net676 VDD VSS BUF_X16
Xclone359 net363 net677 VDD VSS BUF_X16
Xclone360 net363 net678 VDD VSS BUF_X16
Xclone361 _06173_ net679 VDD VSS BUF_X4
Xclone362 _05259_ net680 VDD VSS BUF_X8
Xclone363 _05259_ net681 VDD VSS BUF_X8
Xclone364 _05259_ net682 VDD VSS BUF_X8
Xclone365 _04977_ net683 VDD VSS BUF_X8
Xclone366 _04765_ net684 VDD VSS BUF_X4
Xclone367 _04977_ net685 VDD VSS BUF_X8
Xclone368 _04765_ net686 VDD VSS BUF_X4
Xclone369 _05036_ net687 VDD VSS BUF_X2
.ENDS ibex_core
*
* ******************************************************************************
* *                                                                            *
* *                   Copyright (C) 2004-2010, Nangate Inc.                    *
* *                           All rights reserved.                             *
* *                                                                            *
* * Nangate and the Nangate logo are trademarks of Nangate Inc.                *
* *                                                                            *
* * All trademarks, logos, software marks, and trade names (collectively the   *
* * "Marks") in this program are proprietary to Nangate or other respective    *
* * owners that have granted Nangate the right and license to use such Marks.  *
* * You are not permitted to use the Marks without the prior written consent   *
* * of Nangate or such third party that may own the Marks.                     *
* *                                                                            *
* * This file has been provided pursuant to a License Agreement containing     *
* * restrictions on its use. This file contains valuable trade secrets and     *
* * proprietary information of Nangate Inc., and is protected by U.S. and      *
* * international laws and/or treaties.                                        *
* *                                                                            *
* * The copyright notice(s) in this file does not indicate actual or intended  *
* * publication of this file.                                                  *
* *                                                                            *
* *     NGLibraryCreator, v2010.08-HR32-SP3-2010-08-05 - build 1009061800      *
* *                                                                            *
* ******************************************************************************
*
*
* Running on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr).
* Local time is now Fri, 3 Dec 2010, 19:32:12.
* Main process id is 27821.
*
********************************************************************************
*                                                                              *
* Cellname:   AND2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:24:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 * A2)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 VSS A2 net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_neg A1 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_5 VDD A2 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:31 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 * A2)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND2_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:29 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 * A2)
M_i_3__m0_m2__m0 net_0__m0_0__m0_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m0 ZN_neg A1 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0_0__m1 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m1 VSS A2 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0_x2__m1 ZN_neg A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m0 VDD A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m1 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m0 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_0 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:35 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 * A2) * A3)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 VSS A3 net_1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VDD A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_6 ZN_neg A2 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD A3 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:26 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 * A2) * A3)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS A3 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VDD A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN_neg A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A3 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:25 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 * A2) * A3)
M_i_4__m0_m2__m0 net_1__m0_0__m0_0 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m0 net_0__m0_0__m0_0 A2 net_1__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m0 ZN_neg A1 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0_0__m1 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m1 net_1__m0_0__m1 A2 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0_m2__m1 VSS A3 net_1__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0_x2__m0 ZN_neg A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0_x2__m0 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m0 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m1 VDD A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0_x2__m1 ZN_neg A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0_x2__m1 VDD A3 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:41 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 * A2) * A3) * A4)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 net_2 A3 net_1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 VSS A4 net_2 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 ZN_neg A1 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD A2 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 ZN_neg A3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_9 VDD A4 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 * A2) * A3) * A4)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_2 A3 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS A4 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 ZN_neg A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD A4 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 * A2) * A3) * A4)
M_i_5__m0 net_2__m0_0 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 net_1__m0_0 A3 net_2__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 net_0__m0_0 A2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 x1 A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0__m1 A1 x1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_2__m1 A3 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m1 VSS A4 net_2__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN x1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS x1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN x1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS x1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9__m0 x1 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 VDD A3 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 x1 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 VDD A1 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 x1 A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A2 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 x1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD A4 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN x1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD x1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN x1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD x1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ANTENNA_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:30:15 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ANTENNA_X1 A VDD VSS
*.PININFO A:I VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:12 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X1 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + B) + A)
M_i_1 net_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 ZN C2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:11 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X2 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + B) + A)
M_i_2__m0 ZN B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN C1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS C2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 net_2__m0_0 B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD A net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2__m1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_1 B net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN C2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN C1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_1 C2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:03 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X4 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((C1 * C2) + B) + A)))
M_i_0 net_0 C1 ZN_3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN_3 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A ZN_3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_8_0 ZN_4 ZN_3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_8_1 VSS ZN_3 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0 ZN ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_1 VSS ZN_4 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_2 ZN ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_3 VSS ZN_4 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_3 C1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_1 C2 ZN_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9_0 ZN_4 ZN_3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9_1 VDD ZN_3 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_0 ZN ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1 VDD ZN_4 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_2 ZN ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_3 VDD ZN_4 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X1 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A + (B1 * B2))
M_i_1 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X2 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A + (B1 * B2))
M_i_2_0_x2_1 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0_x2_0 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m1 net_0__m0_0__m1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m1 ZN B1 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m0 net_0__m0_0__m0_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m0 VSS B2 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0_x2_0 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_0_x2_1 net_1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m0 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m1 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m0 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m1 net_1 B2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X4 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A + (B1 * B2))
M_i_2_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN B1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS B2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 net_0__m2 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 ZN B1 net_0__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 net_0__m3 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 VSS B2 net_0__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1 net_1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_2 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_3 net_1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_1 B2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m2 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m3 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 net_1 B2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:07:32 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X1 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + A) + (B1 * B2))
M_i_4 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN C2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_2 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:07:38 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X2 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + A) + (B1 * B2))
M_i_2_1 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 net_1__m0_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 VSS B2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_1__m1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 ZN B1 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN C1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS C2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7_1 net_3 A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 VDD B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_3 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 net_3 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_0 net_2 A net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN C2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2 C2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:07:31 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X4 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((C1 * C2) + A) + (B1 * B2))))
M_i_0 net_0 C1 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN_4 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B1 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_0 ZN_5 ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_1 VSS ZN_4 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_0 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_1 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_2 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_3 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 ZN_4 C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 C2 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_3 A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 VDD B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_1 ZN_5 ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_0 VDD ZN_4 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_0 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_1 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_2 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_3 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X1 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) + (B1 * B2)) + (C1 * C2))
M_i_5 net_2 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN C1 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_4 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 VDD C1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_4 B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_3 B2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN A2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_3 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X2 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) + (B1 * B2)) + (C1 * C2))
M_i_5__m1 net_2__m1 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 ZN C1 net_2__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 net_2__m0_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0 VSS C2 net_2__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 ZN B1 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_1__m0_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11__m0 VDD C2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10__m0 net_4 C1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10__m1 VDD C1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11__m1 net_4 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 net_3 B2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 net_4 B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_3 B1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_4 B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 ZN A1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_3 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 ZN A2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 net_3 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X4 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((A1 * A2) + (B1 * B2)) + (C1 * C2))))
M_i_0 net_0 A1 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN_5 B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_2 C1 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS C2 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x2_0 ZN_6 ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x2_1 VSS ZN_5 ZN_6 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_0 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_1 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_2 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_3 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 ZN_5 A1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_3 A2 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_4 B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 net_4 C1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11 VDD C2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_0 ZN_6 ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_1 VDD ZN_5 ZN_6 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_3 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_2 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_1 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_0 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X1 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) + (B1 * B2))
M_i_3 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:55 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X2 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) + (B1 * B2))
M_i_3__m0 net_1__m0_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 ZN B1 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_1__m1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS B2 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X4 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) + (B1 * B2))
M_i_3__m0 net_1__m0_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 ZN B1 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_1__m1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS B2 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m2 net_1__m2 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 ZN B1 net_1__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 net_1__m3 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m3 VSS B2 net_1__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 net_0__m2 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 ZN A1 net_0__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 net_0__m3 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 VSS A2 net_0__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m2 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m2 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m3 VDD B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m3 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 ZN A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 net_2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X1 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X16.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X16 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_4 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_5 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_6 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_7 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_4 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_5 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_6 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_7 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X2 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x2_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x2_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X32.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:31:57 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X32 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_4 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_5 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_6 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_7 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_8 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_9 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_10 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_11 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_12 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_13 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_14 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_15 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_16 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_17 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_18 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_19 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_20 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_21 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_22 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_23 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_24 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_25 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_26 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_27 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_28 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_29 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_30 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_31 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_4 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_5 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_6 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_7 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_8 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_9 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_10 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_11 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_12 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_13 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_14 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_15 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_16 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_17 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_18 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_19 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_20 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_21 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_22 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_23 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_24 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_25 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_26 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_27 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_28 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_29 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_30 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_31 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X4 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X8.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:28:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X8 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X1 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.095000U L=0.050000U
M_i_0 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:41 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X2 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X3.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:23 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X3 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X1.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:04:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X1 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_52 net_008 CK net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_57 VSS net_002 net_008 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X2.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:03:58 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X2 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_57 VSS net_002 net_008 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52 net_008 CK net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X4.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:03:50 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X4 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_52 net_008 CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57 net_007 net_002 net_008 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_77 net_007 net_002 net_008b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_76 net_008b CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_15 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_29 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_69 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_72 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_11 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_28 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X8.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:04:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X8 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_33_93 net_004 net_002 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_52 net_008 CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57 net_007 net_002 net_008 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_77 net_007 net_002 net_008b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_76 net_008b CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_150 net_008c CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_123 net_007 net_002 net_008c VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_77_169 net_007 net_002 net_008d VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_76_137 net_008d CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_15 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_29 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_12 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_55 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_15_27 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_29_4 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_101_94 net_004 net_002 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_69 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_72 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_163 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_158 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_69_164 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_72_145 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_11 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_28 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_38 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_20 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_11_14 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_28_7 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:03:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X1 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 VSS net_000 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_007 CK net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X2.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:02:42 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X2 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_007 CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45 VSS net_000 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X4.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:02:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X4 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 VSS net_000 net_007b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40 net_007b CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_75 net_007 CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_66 VSS net_000 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_10 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_25 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_71 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_74 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_24 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_19 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X8.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:02:20 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X8 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_174 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 VSS net_000 net_007b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40 net_007b CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_75 net_007 CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_66 VSS net_000 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_63 VSS net_000 net_007c VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_71 net_007c CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_75_82 net_007d CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_66_78 VSS net_000 net_007d VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_10 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_25 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_40 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_58 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_10_28 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_25_30 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_57_165 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_71 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_74 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_72 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_99 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_71_87 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_74_97 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_24 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_19 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_53 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_22 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_24_52 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_19_36 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFRS_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:01:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFRS_X1 D RN SN CK Q QN VDD VSS
*.PININFO D:I RN:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_MN81 QN z99 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN91_0_0 VSS z56 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_transistor_0 z99 z56 nn99 VSS NMOS_VTL W=0.210000U L=0.050000U
M_transistor_1 nn99 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN51 VSS z41 nn5 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN52 nn5 RN z56 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN63 VSS SN nn62 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN62 nn62 z56 nn61 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN61 nn61 ckn_i z41 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN41 z41 ck_i nn4 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN42 nn4 z37 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_0 VSS z37 nn2 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_1 nn2 SN z51 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN101 VSS ckn_i ck_i VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN33 VSS RN nn32 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN32 nn32 z51 nn31 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN31 nn31 ck_i z37 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z37 ckn_i nn1 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN12 nn1 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN91 ckn_i CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP81_0 QN z99 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_1 VDD z56 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_transistor_2 VDD z56 z99 VDD PMOS_VTL W=0.315000U L=0.050000U
M_transistor_3 z99 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP51 z56 z41 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP52 VDD RN z56 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP63 VDD SN np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP61 VDD z56 np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP62 np61 ck_i z41 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP41 np4 ckn_i z41 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP42 VDD z37 np4 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP21 VDD z37 z51 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP22 z51 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP101 ck_i ckn_i VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP33 VDD RN np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP31 VDD z51 np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP34 np32 ckn_i z37 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP12 np1 ck_i z37 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP11 VDD D np1 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP91 ckn_i CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFRS_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:01:53 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFRS_X2 D RN SN CK Q QN VDD VSS
*.PININFO D:I RN:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_MN81_53 QN z99 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN81 QN z99 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN91_0_0 VSS z56 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN91_0_0_58 VSS z56 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_transistor_0 z99 z56 nn99 VSS NMOS_VTL W=0.310000U L=0.050000U
M_transistor_1 nn99 SN VSS VSS NMOS_VTL W=0.310000U L=0.050000U
M_MN51 VSS RN nn5 VSS NMOS_VTL W=0.310000U L=0.050000U
M_MN52 nn5 z41 z56 VSS NMOS_VTL W=0.310000U L=0.050000U
M_MN63 VSS SN nn62 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN62 nn62 z56 nn61 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN61 nn61 ckn_i z41 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN41 z41 ck_i nn4 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN42 nn4 z37 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_0 VSS z37 nn2 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_1 nn2 SN z51 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN101 VSS ckn_i ck_i VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN33 VSS RN nn32 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN32 nn32 z51 nn31 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN31 nn31 ck_i z37 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z37 ckn_i nn1 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN12 nn1 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN91 ckn_i CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP81_0_51 QN z99 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_0 QN z99 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_1 VDD z56 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_1_55 VDD z56 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_transistor_2 VDD z56 z99 VDD PMOS_VTL W=0.485000U L=0.050000U
M_transistor_3 z99 SN VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_MP52 VDD RN z56 VDD PMOS_VTL W=0.485000U L=0.050000U
M_MP51 z56 z41 VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_MP63 VDD SN np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP61 VDD z56 np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP62 np61 ck_i z41 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP41 np4 ckn_i z41 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP42 VDD z37 np4 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP21 VDD z37 z51 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP22 z51 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP101 ck_i ckn_i VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP33 VDD RN np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP31 VDD z51 np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP34 np32 ckn_i z37 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP12 np1 ck_i z37 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP11 VDD D np1 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP91 ckn_i CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFR_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:01:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFR_X1 D RN CK Q QN VDD VSS
*.PININFO D:I RN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 net_005 net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_32 VSS RN net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_38 VSS net_003 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_003 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_49 net_008 net_001 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 net_009 net_000 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 VSS net_011 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_65 net_010 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_70 net_011 net_008 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_76 VSS net_008 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_83 Q net_011 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_89 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_96 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_108 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_114 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_119 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_125 net_013 RN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_136 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 net_015 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_147 net_008 net_000 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_153 net_016 net_001 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_159 VDD net_011 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 net_011 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_172 VDD net_008 net_011 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_180 VDD net_008 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_187 Q net_011 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFR_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:00:47 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFR_X2 D RN CK Q QN VDD VSS
*.PININFO D:I RN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 net_005 net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_32 VSS RN net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_38 VSS net_003 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_003 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_49 net_008 net_001 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 net_009 net_000 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 VSS net_011 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_65 net_010 RN VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_70 net_011 net_008 net_010 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_76_4 VSS net_008 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_76 VSS net_008 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_83 Q net_011 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_83_49 Q net_011 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_89 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_96 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_108 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_114 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_119 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_125 net_013 RN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_136 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 net_015 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_147 net_008 net_000 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_153 net_016 net_001 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_159 VDD net_011 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 net_011 RN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_172 VDD net_008 net_011 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_180_3 VDD net_008 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_180 VDD net_008 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_187 Q net_011 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_187_39 Q net_011 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFS_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:00:41 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFS_X1 D SN CK Q QN VDD VSS
*.PININFO D:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_15 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_19 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_25 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 VSS net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_36 net_005 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_003 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_73 VSS net_003 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 net_011 net_001 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_63 net_010 net_000 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 net_009 net_007 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_53 net_008 SN VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_46 VSS net_010 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_86 QN net_010 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_79 VSS net_007 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_99 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_106 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_111 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_118 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_122 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_128 net_006 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_134 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_92 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_171 net_016 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 net_010 net_000 net_016 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_015 net_001 net_010 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 VDD net_007 net_015 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_149 net_015 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_142 VDD net_010 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_189 QN net_010 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_182 VDD net_007 Q VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFS_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:00:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFS_X2 D SN CK Q QN VDD VSS
*.PININFO D:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_15 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_19 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_25 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 VSS net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_36 net_005 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_003 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_73 VSS net_003 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 net_011 net_001 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_63 net_010 net_000 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 net_009 net_007 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_53 net_008 SN VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_79_29 VSS net_007 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_79 VSS net_007 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_86 QN net_010 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_86_15 QN net_010 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_46 VSS net_010 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_99 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_106 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_111 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_118 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_122 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_128 net_006 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_134 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_92 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_171 net_016 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 net_010 net_000 net_016 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_015 net_001 net_010 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 VDD net_007 net_015 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_149 net_015 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_182_20 VDD net_007 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_182 VDD net_007 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_189 QN net_010 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_189_10 QN net_010 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_142 VDD net_010 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFF_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:59:45 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFF_X1 D CK Q QN VDD VSS
*.PININFO D:I CK:I Q:O QN:O VDD:P VSS:G
M_MN2 ci cni VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN6 VSS z4 z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN7 z3 ci z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN4 z2 cni z3 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN3 z2 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN5 z4 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN1 VSS CK cni VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN8 z12 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN9 z9 ci z12 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN12 z9 cni z8 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z8 z10 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN10 VSS z9 z10 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN14 QN z9 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN13 VSS z10 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MP2 ci cni VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP6 VDD z4 z1 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP7 z1 cni z3 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP4 z3 ci z5 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP3 z5 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP5 z4 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP1 VDD CK cni VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP8 z7 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP9 z9 cni z7 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP12 z9 ci z11 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP11 z11 z10 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP10 VDD z9 z10 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP14 QN z9 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP13 VDD z10 Q VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFF_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:59:42 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFF_X2 D CK Q QN VDD VSS
*.PININFO D:I CK:I Q:O QN:O VDD:P VSS:G
M_MN2 ci cni VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN6 VSS z4 z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN7 z3 ci z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN4 z2 cni z3 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN3 z2 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN5 z4 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN1 VSS CK cni VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN8 z12 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN9 z9 ci z12 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN12 z9 cni z8 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z8 z10 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN10 VSS z9 z10 VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN14_8 QN z9 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN14 QN z9 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN13 VSS z10 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN13_38 VSS z10 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MP2 ci cni VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP6 VDD z4 z1 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP7 z1 cni z3 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP4 z3 ci z5 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP3 z5 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP5 z4 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP1 VDD CK cni VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP8 z7 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP9 z9 cni z7 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP12 z9 ci z11 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP11 z11 z10 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP10 VDD z9 z10 VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP14_5 QN z9 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP14 QN z9 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP13 VDD z10 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP13_26 VDD z10 Q VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLH_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:59:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLH_X1 D G Q VDD VSS
*.PININFO D:I G:I Q:O VDD:P VSS:G
M_i_0 VSS G net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41_11 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_001 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24 net_004 net_000 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_34 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_48 VDD G net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_89_4 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_55 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_61 net_006 D VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_66 net_003 net_000 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_72 net_007 net_001 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_76 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_82 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLH_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:52 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLH_X2 D G Q VDD VSS
*.PININFO D:I G:I Q:O VDD:P VSS:G
M_i_0 VSS G net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_41_11 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_001 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_000 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_34 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_48 VDD G net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_89 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_89_4 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_55 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_61 net_006 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_66 net_003 net_000 net_006 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_72 net_007 net_001 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_76 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_82 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLL_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLL_X1 D GN Q VDD VSS
*.PININFO D:I GN:I Q:O VDD:P VSS:G
M_i_7 VSS net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_29 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_35 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_42 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_000 GN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 VDD net_000 net_001 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_62 net_006 D VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_67 net_003 net_001 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_73 net_007 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_79 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_85 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_92 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_000 GN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLL_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:19 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLL_X2 D GN Q VDD VSS
*.PININFO D:I GN:I Q:O VDD:P VSS:G
M_i_7 VSS net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_29 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_35 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_42_3 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_42 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_000 GN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 VDD net_000 net_001 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_62 net_006 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_67 net_003 net_001 net_006 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_73 net_007 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_79 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_85 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_92_11 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_92 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_000 GN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FA_X1.                                                           *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:24 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FA_X1 A B CI CO S VDD VSS
*.PININFO A:I B:I CI:I CO:O S:O VDD:P VSS:G
*.EQN CO=((A * B) + (CI * (A + B)));S=(CI ^ (A ^ B))
M_instance_159 CO net_001 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_instance_166 VSS B net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_170 net_000 A net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_176 net_001 CI net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_188 net_002 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_182 VSS B net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_227 net_006 B VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_215 VSS CI net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_221 net_006 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_209 net_005 net_001 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_203 net_004 CI net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_199 net_003 B net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_194 VSS A net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_233 S net_005 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_instance_239 CO net_001 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_instance_246 VDD B net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_251 net_007 A net_001 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_257 net_001 CI net_008 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_269 net_008 A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_263 VDD B net_008 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_309 net_011 B VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_297 VDD CI net_011 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_303 net_011 A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_290 net_005 net_001 net_011 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_284 net_010 CI net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_280 net_009 B net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_275 VDD A net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_315 S net_005 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X1.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X1 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TAPCELL_X1.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TAPCELL_X1 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X16.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:23 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X16 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X2.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X2 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X32.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:13 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X32 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X4.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:50 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X4 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X8.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X8 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   HA_X1.                                                           *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:27 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT HA_X1 A B CO S VDD VSS
*.PININFO A:I B:I CO:O S:O VDD:P VSS:G
*.EQN CO=(A * B);S=(A ^ B)
M_i_1 net_0 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 S A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS x1 S VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 x1 B VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_6 VSS A x1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_12 net_3 A CO_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 VSS B net_3 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_10 CO CO_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 S B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 net_1 A S VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD x1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_2 B VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 x1 A net_2 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_14 CO_neg A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_15 VDD B CO_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_11 CO CO_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:52 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X1 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X16.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:12 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X16 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X2 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0_x2_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0_x2_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x2_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X32.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:38 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X32 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_16 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_17 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_18 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_19 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_20 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_21 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_22 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_23 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_24 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_25 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_26 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_27 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_28 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_29 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_30 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_31 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_16 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_17 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_18 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_19 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_20 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_21 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_22 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_23 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_24 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_25 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_26 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_27 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_28 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_29 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_30 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_31 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X4 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0_x4_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0_x4_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X8.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:24:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X8 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0_x8_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_4 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_5 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_6 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_7 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0_x8_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_4 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_6 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LOGIC0_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:24:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LOGIC0_X1 Z VDD VSS
*.PININFO Z:O VDD:P VSS:G
M_n_tran_1 VSS A Z VSS NMOS_VTL W=0.090000U L=0.050000U
M_transistor_0 VDD A A VDD PMOS_VTL W=0.090000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LOGIC1_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:59 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LOGIC1_X1 Z VDD VSS
*.PININFO Z:O VDD:P VSS:G
M_n_tran_1 VSS A A VSS NMOS_VTL W=0.090000U L=0.050000U
M_p_tran_2 VDD A Z VDD PMOS_VTL W=0.135000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   MUX2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT MUX2_X1 A B S Z VDD VSS
*.PININFO A:I B:I S:I Z:O VDD:P VSS:G
*.EQN Z=((S * B) + (A * !S))
M_i_10 VSS S x1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 net_1 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 Z_neg x1 net_1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_2 Z_neg S net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 net_0 B VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 VDD S x1 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 VDD A net_2 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_6 net_2 S Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_9 net_3 x1 Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD B net_3 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   MUX2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:57 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT MUX2_X2 A B S Z VDD VSS
*.PININFO A:I B:I S:I Z:O VDD:P VSS:G
*.EQN Z=((S * B) + (A * !S))
M_i_4 net_1 A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS x1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 Z_neg S net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10 VSS S x1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_8 VDD A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_2 x1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 Z_neg B net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 S Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11 VDD S x1 VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 * A2)
M_i_1 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:47 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 * A2)
M_i_1__m0_m2__m0 net_0__m0__m0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m0 ZN A1 net_0__m0__m0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m1 net_0__m0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m1 VSS A2 net_0__m0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_x2__m0 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_x2__m0 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_x2__m1 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m1 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:44 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 * A2)
M_i_1_0 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_1 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_2 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_3 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_0 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_1 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_2 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_3 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:24 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) * A3)
M_i_2 net_1 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:17 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) * A3)
M_i_2__m0_m2__m0 net_1__m0_0__m0_0 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m0 net_0__m0_0__m0_0 A2 net_1__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m0 ZN A1 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m1 net_0__m0_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m1 net_1__m0_0__m1 A2 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m1 VSS A3 net_1__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0_x2__m0 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m0 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m0 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m1 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m1 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m1 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:27 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) * A3)
M_i_2__m0 net_1__m0_0 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_1__m1 A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS A3 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 net_1__m2 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 net_0__m2 A2 net_1__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 ZN A1 net_0__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 net_0__m3 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_1__m3 A2 net_0__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 VSS A3 net_1__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m2 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m3 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:11:28 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) * A3) * A4)
M_i_3 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:11:18 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) * A3) * A4)
M_i_3__m0 net_2__m0_0 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_1__m0_0 A3 net_2__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_1__m1 A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_2__m1 A3 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS A4 net_2__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A4 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:11:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) * A3) * A4)
M_i_0_187 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_85 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_34 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_177 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_24 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_75 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_196 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_94 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_43 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_170 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_68 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_17 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4_168 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_66 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_15 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_189 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_36 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_87 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_202 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_100 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_49 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_154 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_52 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:22 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 + A2)
M_i_1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:11 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 + A2)
M_i_1__m0_x2__m0 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m1 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m0 net_0__m0__m0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m0 ZN A1 net_0__m0__m0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m1 VDD A2 net_0__m0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 + A2)
M_i_1__m0_x2__m0_16 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m0_35 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m1_57 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m1_23 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m0 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m1 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m0_38 net_0__m0__m3 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m0_52 ZN A1 net_0__m0__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m1_45 net_0__m0__m2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m1_58 VDD A2 net_0__m0__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m0 net_0__m0__m0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m0 ZN A1 net_0__m0__m0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m1 VDD A2 net_0__m0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:39 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) + A3)
M_i_2 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:33 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) + A3)
M_i_2_0_x2__m0 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_1_x2__m0 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2__m0 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2__m1 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_1_x2__m1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0_x2__m1 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_1_m2__m0 net_1_0__m0_0 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_0_m2__m0 net_0_0__m0_0 A2 net_1_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1_m2__m0 ZN A1 net_0_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1_m2__m1 net_0_0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_0_m2__m1 net_1_0__m1 A2 net_0_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1_m2__m1 VDD A3 net_1_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) + A3)
M_i_0_28 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_19 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_31 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_40 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_49 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_58 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_67 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_85 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_24 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_15 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_6 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_34 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_43 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_52 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_56 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_65 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_83 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:10:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) + A4)
M_i_3 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:10:31 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) + A4)
M_i_3__m0 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS A4 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_2__m0_0 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_1__m0_0 A3 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_0__m0_0 A2 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN A1 net_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_1__m1 A2 net_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2__m1 A3 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A4 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:10:50 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) + A4)
M_i_0_22 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_22_71 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_77 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_13 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_13_89 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_79 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_29 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_52 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_29_45 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_8 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_109 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_8_108 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4_6 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_6_75 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_68 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_24 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_24_95 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_88 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_34 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_56 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_34_44 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_102 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1_96 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X1 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * B)
M_i_1 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS B net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_2 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:59 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X2 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * B)
M_i_2__m0 net_1__m0_0 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0 A net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD B ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_2__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN C1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_2__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD C2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:10 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X4 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * B)
M_i_2__m0 net_1__m0_0 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0 A net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 net_1__m2 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m2 VSS B net_1__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m3 net_1__m3 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 net_0 A net_1__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD B ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m2 VDD B ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m3 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_2__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN C1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_2__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD C2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 net_2__m2 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 ZN C1 net_2__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 net_2__m3 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 VDD C2 net_2__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X1 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A * (B1 + B2))
M_i_1 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_1 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:55 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X2 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A * (B1 + B2))
M_i_2_0 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 net_0 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 B2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_1__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 ZN B1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 net_1__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 VDD B2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:03 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X4 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A * (B1 + B2))
M_i_2_0 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 net_0 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 net_0 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 B2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_0 B2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_1__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 ZN B1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 net_1__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 VDD B2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 net_1__m2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m2 ZN B1 net_1__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m3 net_1__m3 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 VDD B2 net_1__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X1 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * (B1 + B2))
M_i_4 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_0 A net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9 net_3 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 ZN B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 ZN C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:53 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X2 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * (B1 + B2))
M_i_1__m0 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 net_1 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0 net_0 A net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 net_2__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN C1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD C2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_3__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD B2 net_3__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_3__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 ZN B1 net_3__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:43 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X4 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((C1 + C2) * A) * (B1 + B2))))
M_i_0 ZN_4 C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 C2 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_0 ZN_5 ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_1 VSS ZN_4 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_0 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_1 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_2 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_3 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_2 C1 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD C2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN_4 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_1 ZN_5 ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_0 VDD ZN_4 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_3 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_2 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_1 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_0 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X1 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) * (B1 + B2)) * (C1 + C2))
M_i_5 net_1 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS C1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_4 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 ZN C1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X2 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) * (B1 + B2)) * (C1 + C2))
M_i_4__m0 VSS C1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m1 net_1 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0 VSS C2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_1 C1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0 B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 net_1 B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_0 B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_1 B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10__m1 net_4__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11__m1 VDD C2 net_4__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11__m0 net_4__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10__m0 ZN C1 net_4__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_3__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD B2 net_3__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_3__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 ZN B1 net_3__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_2__m0_0 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD A2 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2__m1 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 ZN A1 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:04:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X4 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((A1 + A2) * (B1 + B2)) * (C1 + C2))))
M_i_0 ZN_5 A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_0 B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_1 C1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS C2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_1_x2_1 ZN_6 ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_1_x2_0 VSS ZN_5 ZN_6 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_0 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_2 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_1 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_3 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 net_2 A1 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_3 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 ZN_5 B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 net_4 C1 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11 VDD C2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_0 ZN_6 ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_1 VDD ZN_5 ZN_6 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_3 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_2 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_0 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_1 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X1 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) * (B1 + B2))
M_i_3 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:44 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X2 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) * (B1 + B2))
M_i_3__m0 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_2__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN B1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD B2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_1__m0_0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN A1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_1__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:56 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X4 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) * (B1 + B2))
M_i_3__m0 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m2 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 VSS B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m3 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_2__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN B1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD B2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m2 net_2__m2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m2 ZN B1 net_2__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m3 net_2__m3 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m3 VDD B2 net_2__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_1__m0_0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN A1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_1__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 net_1__m2 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 ZN A1 net_1__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 net_1__m3 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 VDD A2 net_1__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI33_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:27 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI33_X1 A1 A2 A3 B1 B2 B3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I B1:I B2:I B3:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) * ((B1 + B2) + B3))
M_i_5 net_0 B3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN A3 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_4 B3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 net_3 B2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 ZN B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 VDD A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 + A2)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_0 A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_5 VDD A2 net_0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 + A2)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A2 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 + A2)
M_i_3__m0_x2__m1 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_x2__m1 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_x2__m0 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_x2__m0 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0_m2__m1 net_0__m0_0__m1 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_m2__m1 ZN_neg A1 net_0__m0_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_m2__m0 net_0__m0_0__m0_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_m2__m0 VDD A2 net_0__m0_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:16 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 + A2) + A3)
M_i_2 VSS A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 ZN_neg A2 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 VSS A3 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_0 A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_6 net_1 A2 net_0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD A3 net_1 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:13 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 + A2) + A3)
M_i_2 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS A3 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A2 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A3 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:20 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 + A2) + A3)
M_i_4__m0 ZN_neg A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 VSS A3 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_1__m0_0 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_0__m0_0 A2 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN_neg A1 net_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_0__m1 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_1__m1 A2 net_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A3 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:17 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 + A2) + A3) + A4)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 ZN_neg A3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 VSS A4 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 net_0 A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 net_1 A2 net_0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 net_2 A3 net_1 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_9 VDD A4 net_2 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:10 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 + A2) + A3) + A4)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_neg A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS A4 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 net_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_1 A2 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_2 A3 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD A4 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 + A2) + A3) + A4)
M_i_5__m0 ZN_neg A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 VSS A3 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 ZN_neg A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m1 VSS A4 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9__m0 net_2__m0_0 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 net_1__m0_0 A3 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 net_0__m0_0 A2 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN_neg A1 net_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_0__m1 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_1__m1 A2 net_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_2__m1 A3 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD A4 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFRS_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:05 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFRS_X1 D RN SE SI SN CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_132 Q net_019 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_125 VSS net_017 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_119 net_019 net_017 net_018 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_114 net_018 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_101 net_016 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_106 net_017 net_013 net_016 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_28 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_95 VSS RN net_015 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_91 net_015 net_017 net_014 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 net_014 net_004 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_81 net_013 net_005 net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_71 VSS net_007 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_66 net_011 RN net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_52 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_46 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_12 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_22 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_290 Q net_019 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_277 VDD net_017 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_284 VDD net_017 net_019 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_270 net_019 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_255 net_017 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_262 VDD net_013 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_165 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_248 VDD RN net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_234 net_026 net_017 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_238 net_013 net_005 net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_223 net_025 net_004 net_013 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_228 VDD net_007 net_025 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_217 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_211 net_010 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_172 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD SN net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 net_023 net_010 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_007 net_004 net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_022 net_005 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_183 VDD net_002 net_022 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_159 VDD SI net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 net_021 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_002 SE net_020 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_145 net_020 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_138 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFRS_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFRS_X2 D RN SE SI SN CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_132_2 Q net_019 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_132 Q net_019 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_125 VSS net_017 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_125_68 VSS net_017 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_114 net_018 net_017 VSS VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_119 net_019 RN net_018 VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_106 net_017 SN net_016 VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_101 net_016 net_013 VSS VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_28 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_95 VSS RN net_015 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_91 net_015 net_017 net_014 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 net_014 net_004 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_81 net_013 net_005 net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_71 VSS net_007 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_66 net_011 RN net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_52 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_46 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_12 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_22 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_290_11 Q net_019 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_290 Q net_019 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_277 VDD net_017 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_277_67 VDD net_017 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_284 VDD net_017 net_019 VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_270 net_019 RN VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_255 net_017 SN VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_262 VDD net_013 net_017 VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_165 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_248 VDD RN net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_234 net_026 net_017 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_238 net_013 net_005 net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_223 net_025 net_004 net_013 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_228 VDD net_007 net_025 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_217 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_211 net_010 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_172 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD SN net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 net_023 net_010 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_007 net_004 net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_022 net_005 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_183 VDD net_002 net_022 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_159 VDD SI net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 net_021 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_002 SE net_020 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_145 net_020 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_138 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFR_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:57:35 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFR_X1 D RN SE SI CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS net_000 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13 VSS net_003 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 net_001 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_25 net_002 net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_29 net_003 net_011 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_004 net_005 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_009 net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_011 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_005 net_011 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_62 net_008 net_006 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_009 net_005 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_72 net_010 net_011 net_009 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 VSS net_013 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_007 net_009 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 VSS RN net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_104 VSS SI net_014 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_100 net_014 SE net_013 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_94 net_013 net_015 net_012 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_89 net_012 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_110 net_015 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_116 VDD net_000 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_123 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_129 VDD net_003 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_136 net_017 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_151 VDD net_000 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_146 net_017 net_005 net_003 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_003 net_011 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_209 net_011 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_167 VDD net_011 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_188 net_019 net_006 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_009 net_011 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_199 net_020 net_005 net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD net_013 net_020 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_174 net_006 net_009 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_181 VDD RN net_006 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_215 net_021 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_220 net_013 net_015 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_226 net_022 SE net_013 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_230 VDD D net_022 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_236 net_015 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFR_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:56:45 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFR_X2 D RN SE SI CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_13 VSS net_003 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7_145 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS net_000 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 VSS net_000 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_21 net_001 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_25 net_002 net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_29 net_003 net_011 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_004 net_005 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_009 net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_011 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_005 net_011 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_62 net_008 net_006 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_009 net_005 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_72 net_010 net_011 net_009 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 VSS net_013 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_007 net_009 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 VSS RN net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_104 VSS SI net_014 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_100 net_014 SE net_013 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_94 net_013 net_015 net_012 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_89 net_012 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_110 net_015 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_129 VDD net_003 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_123_146 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_123 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_116 VDD net_000 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_116_1 VDD net_000 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_136 net_017 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_151 VDD net_000 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_146 net_017 net_005 net_003 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_003 net_011 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_209 net_011 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_167 VDD net_011 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_188 net_019 net_006 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_009 net_011 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_199 net_020 net_005 net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD net_013 net_020 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_174 net_006 net_009 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_181 VDD RN net_006 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_215 net_021 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_220 net_013 net_015 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_226 net_022 SE net_013 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_230 VDD D net_022 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_236 net_015 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFS_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:56:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFS_X1 D SE SI SN CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_11 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_27 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_010 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_73 net_011 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_005 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_013 net_004 net_012 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 VSS net_015 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_93 net_014 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_97 net_015 net_012 net_014 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_110 Q net_012 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_103 VSS net_015 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_116 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_123 net_016 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_127 net_002 SE net_016 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_133 net_017 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_137 VDD SI net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_150 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_007 net_005 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_168 net_019 net_004 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 VDD net_010 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_019 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_197 net_021 net_007 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_201 net_012 net_004 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_208 net_022 net_005 net_012 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_212 VDD net_015 net_022 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_218 net_015 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_224 VDD net_012 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_237 Q net_012 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_230 VDD net_015 QN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFS_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:56:22 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFS_X2 D SE SI SN CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_11 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_27 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_73 net_011 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_005 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_013 net_004 net_012 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 VSS net_015 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_010 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_93 net_014 SN net_015 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_97 VSS net_012 net_014 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_110_2 Q net_012 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_110 Q net_012 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_103 VSS net_015 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_103_26 VSS net_015 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_116 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_123 net_016 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_127 net_002 SE net_016 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_133 net_017 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_137 VDD SI net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_150 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_007 net_005 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_168 net_019 net_004 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 VDD net_010 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_019 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_197 net_021 net_007 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_201 net_012 net_004 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_208 net_022 net_005 net_012 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_212 VDD net_015 net_022 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_218 net_015 SN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_224 VDD net_012 net_015 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_237_1 Q net_012 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_237 Q net_012 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_230 VDD net_015 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_230_17 VDD net_015 QN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFF_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:55:24 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFF_X1 D SE SI CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_7 QN net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS net_002 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13 VSS net_002 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_20 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_24 net_002 net_009 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 net_003 net_004 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 VSS net_007 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_004 net_009 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_75 net_009 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_54 net_006 net_005 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_58 net_007 net_004 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_009 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 VSS net_011 net_008 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_47 VSS net_007 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_96 VSS SI net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_92 net_012 SE net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_86 net_011 net_013 net_010 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_81 net_010 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_102 net_013 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_115 QN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_108 VDD net_002 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_121 VDD net_002 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_128 net_014 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_132 net_002 net_004 net_014 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_138 net_015 net_009 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD net_007 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_004 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_182 net_009 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_016 net_005 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_166 net_007 net_009 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 net_017 net_004 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 VDD net_011 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 VDD net_007 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_189 net_018 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_194 net_011 net_013 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_200 net_019 SE net_011 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_204 VDD D net_019 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_210 net_013 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFF_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:55:29 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFF_X2 D SE SI CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_13 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_50 VSS net_002 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS net_002 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 QN net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7_4 QN net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_20 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_24 net_002 net_009 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 net_003 net_004 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 VSS net_007 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_004 net_009 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_75 net_009 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_54 net_006 net_005 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_58 net_007 net_004 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_009 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 VSS net_011 net_008 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_47 VSS net_007 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_96 VSS SI net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_92 net_012 SE net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_86 net_011 net_013 net_010 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_81 net_010 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_102 net_013 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_121 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_108_51 VDD net_002 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_108 VDD net_002 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_115 QN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_115_2 QN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_128 net_014 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_132 net_002 net_004 net_014 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_138 net_015 net_009 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD net_007 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_004 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_182 net_009 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_016 net_005 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_166 net_007 net_009 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 net_017 net_004 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 VDD net_011 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 VDD net_007 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_189 net_018 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_194 net_011 net_013 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_200 net_019 SE net_011 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_204 VDD D net_019 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_210 net_013 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X1 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_15_63 dummy1 A y VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24_0 VDD A dummy0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24_1 dummy0 EN x VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X16.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:20:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X16 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6_6_40_125 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_45_122 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_37_112 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_42_108 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6_43 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_120 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_106 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_116 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6_40 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_45 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_37 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_42 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1a VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1a A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63_69 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_47_77 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_113 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_129 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24_3_19_50_12 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_39_66 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_18_103 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_9_17 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19_51 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_42 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_83 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_10 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19_50 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_39 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_18 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_9 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64_92 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_48_94 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_114 dummy0a EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_130 x A dummy0a VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 x A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1 dummy0 EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X2 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1 dummy0 EN x VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 VDD A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:20:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X4 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24_3_19 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 x A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1 dummy0 EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X8.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:20:37 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X8 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6_6_40 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_45 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_37 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_42 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1a VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1a A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63_69 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_47_77 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_113 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_129 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24_3_19_50 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_39 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_18 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_9 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64_92 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_48_94 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_114 dummy0a EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_130 x A dummy0a VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 x A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1 dummy0 EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TINV_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TINV_X1 EN I ZN VDD VSS
*.PININFO EN:I I:I ZN:O VDD:P VSS:G
*.EQN ZN=!I
M_i_0 VSS EN net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 I VSS VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_11 ZN net_000 net_001 VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_17 VDD EN net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24 net_002 I VDD VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_29 ZN EN net_002 VDD PMOS_VTL W=0.540000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TLAT_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:55:08 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TLAT_X1 D G OE Q VDD VSS
*.PININFO D:I G:I OE:I Q:O VDD:P VSS:G
M_i_0 VSS G net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_001 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_000 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 VSS net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_40 VSS net_003 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_34 net_005 OE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_47 net_007 net_003 VSS VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_51 Q OE net_007 VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_57 VDD G net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_64 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_70 net_008 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_75 net_003 net_000 net_008 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_81 net_009 net_001 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_85 VDD net_006 net_009 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_99 VDD net_003 net_006 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_91 net_005 OE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_106 net_010 net_003 VDD VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_111 Q net_005 net_010 VDD PMOS_VTL W=0.540000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XNOR2_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XNOR2_X1 A B ZN VDD VSS
*.PININFO A:I B:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A ^ B)
M_i_0 net_001 A net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 VSS B net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_11 net_002 net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 ZN A net_002 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_23 net_002 B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_29 net_000 A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_36 VDD B net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_42 ZN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_003 A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 VDD B net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XNOR2_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:17 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XNOR2_X2 A B ZN VDD VSS
*.PININFO A:I B:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A ^ B)
M_i_11_23 net_002 net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_002 net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS B net_001 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_001 A net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17_20 ZN A net_002 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 ZN A net_002 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_23_12 net_002 B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_23 net_002 B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_42_14 ZN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 ZN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_36 VDD B net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_29 net_000 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_003 A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48_8 net_003b A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53_25 VDD B net_003b VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 VDD B net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XOR2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:03 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XOR2_X1 A B Z VDD VSS
*.PININFO A:I B:I Z:O VDD:P VSS:G
*.EQN Z=(A ^ B)
M_i_0 net_000 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS B net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 Z net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_19 net_001 A Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24 VSS B net_001 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_30 net_002 A net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_35 VDD B net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_41 net_003 net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_47 Z A net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 net_003 B Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XOR2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XOR2_X2 A B Z VDD VSS
*.PININFO A:I B:I Z:O VDD:P VSS:G
*.EQN Z=(A ^ B)
M_i_0 net_000 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 VSS B net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13 Z net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_19 net_001 A Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24 VSS B net_001 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24_4 VSS B net_001b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_19_23 net_001b A Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13_35 Z net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_30 net_002 A net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_35 VDD B net_002 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_41 net_003 net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_47 Z A net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 net_003 B Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53_18 net_003 B Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_47_27 Z A net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_41_29 net_003 net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*
* END
*
********************************************************************************
