* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT configurable_prng clk enable random[0] random[10]
+ random[11] random[12] random[13] random[14] random[15] random[1]
+ random[2] random[3] random[4] random[5] random[6] random[7]
+ random[8] random[9] reseed rst_n seed_in[0] seed_in[10] seed_in[11]
+ seed_in[12] seed_in[13] seed_in[14] seed_in[15] seed_in[1]
+ seed_in[2] seed_in[3] seed_in[4] seed_in[5] seed_in[6] seed_in[7]
+ seed_in[8] seed_in[9] valid
X_057_ reseed VSS VSS VDD VDD _023_ sky130_fd_sc_hd__buf_2
X_058_ net18 net17 net5 net8 VSS VSS VDD VDD _024_ sky130_fd_sc_hd__nor4_1
X_059_ net4 net7 net6 net9 VSS VSS VDD VDD _025_ sky130_fd_sc_hd__nor4_1
X_060_ net10 net3 net12 net15 VSS VSS VDD VDD _026_ sky130_fd_sc_hd__nor4_1
X_061_ net11 net14 net13 net16 VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nor4_1
X_062_ _024_ _025_ _026_ _027_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__nand4_1
X_063_ _023_ _028_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__nand2_4
X_064_ enable VSS VSS VDD VDD _030_ sky130_fd_sc_hd__buf_4
X_065_ _030_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__buf_6
X_066_ net25 net20 VSS VSS VDD VDD _032_ sky130_fd_sc_hd__xnor2_1
X_067_ net23 net22 VSS VSS VDD VDD _033_ sky130_fd_sc_hd__xnor2_1
X_068_ _032_ _033_ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__xnor2_1
X_069_ _030_ net19 VSS VSS VDD VDD _035_ sky130_fd_sc_hd__nor2_1
X_070_ _031_ _034_ _035_ VSS VSS VDD VDD _036_ sky130_fd_sc_hd__a21oi_1
X_071_ _023_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__buf_2
X_072_ net3 _029_ _036_ _037_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__o22a_1
X_073_ net20 net34 _030_ VSS VSS VDD VDD _038_ sky130_fd_sc_hd__mux2_1
X_074_ _023_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__buf_2
X_075_ net4 _029_ _038_ _039_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__o22a_1
X_076_ net21 net20 _030_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__mux2_1
X_077_ net5 _029_ _040_ _039_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__o22a_1
X_078_ net22 net21 _031_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__mux2i_1
X_079_ _037_ net6 VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nand2_1
X_080_ _039_ _041_ _042_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__o21ai_0
X_081_ net23 net22 _030_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__mux2_1
X_082_ net7 _029_ _043_ _039_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__o22a_1
X_083_ net24 net23 _031_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__mux2i_1
X_084_ _037_ net8 VSS VSS VDD VDD _045_ sky130_fd_sc_hd__nand2_1
X_085_ _039_ _044_ _045_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__o21ai_0
X_086_ net25 net24 _030_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__mux2_1
X_087_ net9 _029_ _046_ _039_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__o22a_1
X_088_ net26 net19 _031_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__mux2i_1
X_089_ _037_ net10 VSS VSS VDD VDD _048_ sky130_fd_sc_hd__nand2_1
X_090_ _039_ _047_ _048_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__o21ai_0
X_091_ net27 net26 _031_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__mux2i_1
X_092_ _037_ net11 VSS VSS VDD VDD _050_ sky130_fd_sc_hd__nand2_1
X_093_ _023_ _049_ _050_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__o21ai_0
X_094_ net28 net27 _031_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__mux2i_1
X_095_ _037_ net12 VSS VSS VDD VDD _052_ sky130_fd_sc_hd__nand2_1
X_096_ _023_ _051_ _052_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__o21ai_0
X_097_ net29 net28 _031_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__mux2i_1
X_098_ _037_ net13 VSS VSS VDD VDD _054_ sky130_fd_sc_hd__nand2_1
X_099_ _023_ _053_ _054_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__o21ai_0
X_100_ net30 net29 _030_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__mux2_1
X_101_ net14 _029_ _055_ _039_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__o22a_1
X_102_ net31 net30 _030_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__mux2_1
X_103_ net15 _029_ _056_ _039_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__o22a_1
X_104_ net32 net31 _030_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__mux2_1
X_105_ net16 _029_ _017_ _039_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__o22a_1
X_106_ net33 net32 _031_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__mux2i_1
X_107_ _037_ net17 VSS VSS VDD VDD _019_ sky130_fd_sc_hd__nand2_1
X_108_ _023_ _018_ _019_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__o21ai_0
X_109_ net34 net33 _031_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__mux2i_1
X_110_ _037_ net18 VSS VSS VDD VDD _021_ sky130_fd_sc_hd__nand2_1
X_111_ _023_ _020_ _021_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__o21ai_0
X_112_ _031_ net35 VSS VSS VDD VDD _022_ sky130_fd_sc_hd__nor2_1
X_113_ _037_ _022_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__nor2_1
Xlfsr_reg\[0\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _000_ net2
+ VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[10\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _001_ net2
+ VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[11\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _002_ net2
+ VSS VSS VDD VDD net21 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[12\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _003_ net1
+ VSS VSS VDD VDD net22 sky130_fd_sc_hd__dfrtp_1
Xlfsr_reg\[13\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _004_ net2
+ VSS VSS VDD VDD net23 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[14\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _005_ net1
+ VSS VSS VDD VDD net24 sky130_fd_sc_hd__dfrtp_1
Xlfsr_reg\[15\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _006_ net2
+ VSS VSS VDD VDD net25 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _007_ net1
+ VSS VSS VDD VDD net26 sky130_fd_sc_hd__dfrtp_1
Xlfsr_reg\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _008_ net1
+ VSS VSS VDD VDD net27 sky130_fd_sc_hd__dfrtp_1
Xlfsr_reg\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _009_ net1
+ VSS VSS VDD VDD net28 sky130_fd_sc_hd__dfrtp_1
Xlfsr_reg\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _010_ net1
+ VSS VSS VDD VDD net29 sky130_fd_sc_hd__dfrtp_1
Xlfsr_reg\[5\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _011_ net2
+ VSS VSS VDD VDD net30 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[6\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _012_ net2
+ VSS VSS VDD VDD net31 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[7\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _013_ net2
+ VSS VSS VDD VDD net32 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[8\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _014_ net1
+ VSS VSS VDD VDD net33 sky130_fd_sc_hd__dfrtp_1
Xlfsr_reg\[9\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _015_ net1
+ VSS VSS VDD VDD net34 sky130_fd_sc_hd__dfrtp_1
Xvalid_reg$_DFFE_PN0P_ clknet_1_0__leaf_clk _016_ net1 VSS
+ VSS VDD VDD net35 sky130_fd_sc_hd__dfrtp_1
Xhold1 net2 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 net36 VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_4
Xinput2 seed_in[0] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 seed_in[10] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 seed_in[11] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 seed_in[12] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 seed_in[13] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 seed_in[14] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 seed_in[15] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 seed_in[1] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 seed_in[2] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 seed_in[3] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput12 seed_in[4] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput13 seed_in[5] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput14 seed_in[6] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput15 seed_in[7] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput16 seed_in[8] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput17 seed_in[9] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD random[0] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD random[10] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net21 VSS VSS VDD VDD random[11] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net22 VSS VSS VDD VDD random[12] sky130_fd_sc_hd__clkbuf_1
Xoutput22 net23 VSS VSS VDD VDD random[13] sky130_fd_sc_hd__clkbuf_1
Xoutput23 net24 VSS VSS VDD VDD random[14] sky130_fd_sc_hd__clkbuf_1
Xoutput24 net25 VSS VSS VDD VDD random[15] sky130_fd_sc_hd__clkbuf_1
Xoutput25 net26 VSS VSS VDD VDD random[1] sky130_fd_sc_hd__clkbuf_1
Xoutput26 net27 VSS VSS VDD VDD random[2] sky130_fd_sc_hd__clkbuf_1
Xoutput27 net28 VSS VSS VDD VDD random[3] sky130_fd_sc_hd__clkbuf_1
Xoutput28 net29 VSS VSS VDD VDD random[4] sky130_fd_sc_hd__clkbuf_1
Xoutput29 net30 VSS VSS VDD VDD random[5] sky130_fd_sc_hd__clkbuf_1
Xoutput30 net31 VSS VSS VDD VDD random[6] sky130_fd_sc_hd__clkbuf_1
Xoutput31 net32 VSS VSS VDD VDD random[7] sky130_fd_sc_hd__clkbuf_1
Xoutput32 net33 VSS VSS VDD VDD random[8] sky130_fd_sc_hd__clkbuf_1
Xoutput33 net34 VSS VSS VDD VDD random[9] sky130_fd_sc_hd__clkbuf_1
Xoutput34 net35 VSS VSS VDD VDD valid sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net36 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS configurable_prng
