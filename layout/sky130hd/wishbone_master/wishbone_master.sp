* cell wishbone_master
* pin wb_dat_i[14]
* pin read_data[14]
* pin VSS,wb_tgd_o[0]
* pin wb_dat_i[12]
* pin read_data[12]
* pin wb_dat_i[15]
* pin wb_ack_i
* pin read_data[15]
* pin wb_dat_i[11]
* pin read_data[11]
* pin read_err
* pin wb_we_o
* pin read_req
* pin wb_err_i
* pin wb_rty_i
* pin write_done
* pin read_addr[13]
* pin write_addr[13]
* pin write_req
* pin read_addr[14]
* pin write_addr[14]
* pin read_addr[12]
* pin wb_adr_o[13]
* pin write_addr[12]
* pin wb_adr_o[14]
* pin wb_adr_o[12]
* pin read_addr[10]
* pin write_addr[10]
* pin read_addr[16]
* pin wb_cyc_o
* pin write_addr[16]
* pin wb_stb_o
* pin wb_adr_o[10]
* pin write_sel[2]
* pin read_addr[11]
* pin write_sel[3]
* pin wb_adr_o[16]
* pin write_addr[11]
* pin read_addr[0]
* pin wb_adr_o[11]
* pin wb_adr_o[17]
* pin write_addr[15]
* pin write_addr[0]
* pin read_addr[18]
* pin write_addr[18]
* pin read_addr[15]
* pin wb_adr_o[15]
* pin wb_adr_o[18]
* pin read_addr[17]
* pin write_addr[17]
* pin wb_adr_o[25]
* pin read_sel[3]
* pin write_addr[21]
* pin wb_adr_o[20]
* pin read_data[0]
* pin VDD
* pin write_addr[19]
* pin read_addr[20]
* pin write_addr[1]
* pin wb_adr_o[0]
* pin read_data[10]
* pin read_addr[21]
* pin write_addr[25]
* pin wb_dat_i[10]
* pin wb_adr_o[21]
* pin write_addr[20]
* pin read_addr[1]
* pin read_data[13]
* pin wb_dat_i[16]
* pin read_addr[19]
* pin read_data[7]
* pin write_addr[23]
* pin wb_dat_i[13]
* pin read_data[16]
* pin wb_adr_o[22]
* pin write_data[12]
* pin wb_adr_o[19]
* pin wb_adr_o[1]
* pin write_addr[22]
* pin wb_dat_i[0]
* pin read_addr[22]
* pin read_addr[23]
* pin read_data[6]
* pin wb_sel_o[3]
* pin write_addr[24]
* pin read_done
* pin read_data[8]
* pin wb_adr_o[23]
* pin wb_dat_i[8]
* pin write_err
* pin read_addr[25]
* pin wb_dat_o[12]
* pin wb_dat_i[7]
* pin wb_sel_o[2]
* pin read_addr[24]
* pin write_data[10]
* pin write_data[16]
* pin read_sel[2]
* pin read_data[9]
* pin wb_dat_o[16]
* pin wb_dat_i[6]
* pin wb_dat_o[10]
* pin write_addr[26]
* pin read_addr[26]
* pin write_data[15]
* pin wb_adr_o[24]
* pin wb_adr_o[27]
* pin wb_dat_i[9]
* pin wb_dat_o[15]
* pin read_addr[27]
* pin write_addr[27]
* pin wb_sel_o[0]
* pin wb_adr_o[9]
* pin write_sel[0]
* pin read_sel[1]
* pin read_data[17]
* pin read_addr[9]
* pin read_sel[0]
* pin write_data[11]
* pin wb_dat_o[11]
* pin wb_dat_i[1]
* pin wb_adr_o[26]
* pin read_data[1]
* pin write_data[13]
* pin wb_sel_o[1]
* pin wb_dat_i[25]
* pin wb_dat_o[23]
* pin wb_adr_o[8]
* pin wb_adr_o[28]
* pin wb_adr_o[31]
* pin read_data[25]
* pin write_sel[1]
* pin wb_dat_o[13]
* pin write_data[14]
* pin wb_dat_o[21]
* pin wb_adr_o[7]
* pin write_addr[9]
* pin wb_dat_o[3]
* pin wb_dat_o[14]
* pin clk
* pin read_data[23]
* pin read_addr[28]
* pin write_data[1]
* pin wb_dat_i[22]
* pin wb_dat_i[23]
* pin write_data[5]
* pin read_addr[7]
* pin wb_dat_o[27]
* pin write_data[27]
* pin wb_dat_i[26]
* pin read_addr[31]
* pin read_addr[29]
* pin write_addr[7]
* pin write_data[3]
* pin read_data[24]
* pin read_data[26]
* pin read_addr[6]
* pin wb_adr_o[4]
* pin wb_adr_o[29]
* pin wb_dat_i[17]
* pin wb_dat_o[17]
* pin wb_dat_i[3]
* pin read_data[3]
* pin wb_dat_o[5]
* pin write_addr[31]
* pin wb_dat_i[24]
* pin wb_dat_i[18]
* pin wb_dat_i[4]
* pin read_addr[5]
* pin wb_adr_o[6]
* pin write_addr[28]
* pin write_addr[6]
* pin write_addr[8]
* pin write_data[26]
* pin read_data[18]
* pin wb_dat_o[0]
* pin read_addr[30]
* pin write_addr[29]
* pin write_data[2]
* pin wb_dat_o[2]
* pin wb_dat_o[26]
* pin read_addr[8]
* pin read_data[21]
* pin read_data[22]
* pin wb_dat_i[21]
* pin write_addr[2]
* pin write_addr[30]
* pin wb_dat_i[20]
* pin read_data[20]
* pin write_addr[3]
* pin read_addr[4]
* pin wb_dat_o[20]
* pin wb_adr_o[5]
* pin wb_adr_o[3]
* pin wb_dat_o[24]
* pin wb_dat_i[27]
* pin read_addr[3]
* pin wb_dat_i[29]
* pin wb_dat_i[19]
* pin write_data[24]
* pin write_addr[4]
* pin write_data[20]
* pin wb_dat_o[28]
* pin read_data[19]
* pin write_data[30]
* pin wb_adr_o[2]
* pin wb_adr_o[30]
* pin wb_dat_o[18]
* pin write_addr[5]
* pin wb_dat_o[22]
* pin wb_dat_o[19]
* pin read_data[5]
* pin write_data[31]
* pin wb_dat_o[1]
* pin wb_dat_i[5]
* pin write_data[22]
* pin write_data[17]
* pin wb_dat_o[4]
* pin write_data[28]
* pin write_data[29]
* pin wb_dat_o[30]
* pin wb_dat_o[31]
* pin write_data[0]
* pin read_data[31]
* pin wb_dat_o[29]
* pin read_addr[2]
* pin write_data[21]
* pin wb_dat_o[25]
* pin wb_dat_o[6]
* pin write_data[23]
* pin write_data[8]
* pin write_data[4]
* pin wb_dat_i[30]
* pin wb_dat_i[31]
* pin read_data[29]
* pin write_data[6]
* pin write_data[9]
* pin rst_n
* pin wb_dat_i[28]
* pin read_data[30]
* pin wb_dat_i[2]
* pin write_data[18]
* pin write_data[19]
* pin wb_dat_o[9]
* pin write_data[7]
* pin read_data[4]
* pin read_data[28]
* pin read_data[2]
* pin read_data[27]
* pin wb_dat_o[8]
* pin wb_dat_o[7]
* pin write_data[25]
.SUBCKT wishbone_master 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47
+ 48 49 50 52 53 60 62 63 65 68 86 90 103 116 121 122 135 142 143 145 156 158
+ 167 168 171 184 185 191 192 211 212 216 226 231 233 238 243 244 249 250 258
+ 270 285 289 293 300 305 306 315 316 320 336 342 343 344 349 350 351 355 362
+ 373 374 377 378 384 387 388 392 393 398 401 404 413 414 417 419 423 426 427
+ 428 437 438 441 445 453 455 456 461 464 468 469 471 472 474 481 484 488 489
+ 490 495 507 508 511 514 516 520 524 528 529 532 533 535 538 540 541 542 543
+ 546 549 550 552 556 557 558 560 568 570 571 573 575 578 585 586 587 588 590
+ 591 592 600 601 614 615 618 619 623 624 625 627 629 633 634 635 639 649 651
+ 652 653 654 659 660 668 669 670 671 673 677 682 685 687 688 690 692 694 695
+ 696 697 698 703 704 707 715 716 723 730 732 733 734 735 736 739 741 745 746
+ 748 750 753 754 755 758 759 760 761 762 763 764
* net 1 wb_dat_i[14]
* net 2 read_data[14]
* net 3 VSS,wb_tgd_o[0]
* net 4 wb_dat_i[12]
* net 5 read_data[12]
* net 6 wb_dat_i[15]
* net 7 wb_ack_i
* net 8 read_data[15]
* net 9 wb_dat_i[11]
* net 10 read_data[11]
* net 11 read_err
* net 12 wb_we_o
* net 13 read_req
* net 14 wb_err_i
* net 15 wb_rty_i
* net 16 write_done
* net 17 read_addr[13]
* net 18 write_addr[13]
* net 19 write_req
* net 20 read_addr[14]
* net 21 write_addr[14]
* net 22 read_addr[12]
* net 23 wb_adr_o[13]
* net 24 write_addr[12]
* net 25 wb_adr_o[14]
* net 26 wb_adr_o[12]
* net 27 read_addr[10]
* net 28 write_addr[10]
* net 29 read_addr[16]
* net 30 wb_cyc_o
* net 31 write_addr[16]
* net 32 wb_stb_o
* net 33 wb_adr_o[10]
* net 34 write_sel[2]
* net 35 read_addr[11]
* net 36 write_sel[3]
* net 37 wb_adr_o[16]
* net 38 write_addr[11]
* net 39 read_addr[0]
* net 40 wb_adr_o[11]
* net 41 wb_adr_o[17]
* net 42 write_addr[15]
* net 43 write_addr[0]
* net 44 read_addr[18]
* net 45 write_addr[18]
* net 46 read_addr[15]
* net 47 wb_adr_o[15]
* net 48 wb_adr_o[18]
* net 49 read_addr[17]
* net 50 write_addr[17]
* net 52 wb_adr_o[25]
* net 53 read_sel[3]
* net 60 write_addr[21]
* net 62 wb_adr_o[20]
* net 63 read_data[0]
* net 65 VDD
* net 68 write_addr[19]
* net 86 read_addr[20]
* net 90 write_addr[1]
* net 103 wb_adr_o[0]
* net 116 read_data[10]
* net 121 read_addr[21]
* net 122 write_addr[25]
* net 135 wb_dat_i[10]
* net 142 wb_adr_o[21]
* net 143 write_addr[20]
* net 145 read_addr[1]
* net 156 read_data[13]
* net 158 wb_dat_i[16]
* net 167 read_addr[19]
* net 168 read_data[7]
* net 171 write_addr[23]
* net 184 wb_dat_i[13]
* net 185 read_data[16]
* net 191 wb_adr_o[22]
* net 192 write_data[12]
* net 211 wb_adr_o[19]
* net 212 wb_adr_o[1]
* net 216 write_addr[22]
* net 226 wb_dat_i[0]
* net 231 read_addr[22]
* net 233 read_addr[23]
* net 238 read_data[6]
* net 243 wb_sel_o[3]
* net 244 write_addr[24]
* net 249 read_done
* net 250 read_data[8]
* net 258 wb_adr_o[23]
* net 270 wb_dat_i[8]
* net 285 write_err
* net 289 read_addr[25]
* net 293 wb_dat_o[12]
* net 300 wb_dat_i[7]
* net 305 wb_sel_o[2]
* net 306 read_addr[24]
* net 315 write_data[10]
* net 316 write_data[16]
* net 320 read_sel[2]
* net 336 read_data[9]
* net 342 wb_dat_o[16]
* net 343 wb_dat_i[6]
* net 344 wb_dat_o[10]
* net 349 write_addr[26]
* net 350 read_addr[26]
* net 351 write_data[15]
* net 355 wb_adr_o[24]
* net 362 wb_adr_o[27]
* net 373 wb_dat_i[9]
* net 374 wb_dat_o[15]
* net 377 read_addr[27]
* net 378 write_addr[27]
* net 384 wb_sel_o[0]
* net 387 wb_adr_o[9]
* net 388 write_sel[0]
* net 392 read_sel[1]
* net 393 read_data[17]
* net 398 read_addr[9]
* net 401 read_sel[0]
* net 404 write_data[11]
* net 413 wb_dat_o[11]
* net 414 wb_dat_i[1]
* net 417 wb_adr_o[26]
* net 419 read_data[1]
* net 423 write_data[13]
* net 426 wb_sel_o[1]
* net 427 wb_dat_i[25]
* net 428 wb_dat_o[23]
* net 437 wb_adr_o[8]
* net 438 wb_adr_o[28]
* net 441 wb_adr_o[31]
* net 445 read_data[25]
* net 453 write_sel[1]
* net 455 wb_dat_o[13]
* net 456 write_data[14]
* net 461 wb_dat_o[21]
* net 464 wb_adr_o[7]
* net 468 write_addr[9]
* net 469 wb_dat_o[3]
* net 471 wb_dat_o[14]
* net 472 clk
* net 474 read_data[23]
* net 481 read_addr[28]
* net 484 write_data[1]
* net 488 wb_dat_i[22]
* net 489 wb_dat_i[23]
* net 490 write_data[5]
* net 495 read_addr[7]
* net 507 wb_dat_o[27]
* net 508 write_data[27]
* net 511 wb_dat_i[26]
* net 514 read_addr[31]
* net 516 read_addr[29]
* net 520 write_addr[7]
* net 524 write_data[3]
* net 528 read_data[24]
* net 529 read_data[26]
* net 532 read_addr[6]
* net 533 wb_adr_o[4]
* net 535 wb_adr_o[29]
* net 538 wb_dat_i[17]
* net 540 wb_dat_o[17]
* net 541 wb_dat_i[3]
* net 542 read_data[3]
* net 543 wb_dat_o[5]
* net 546 write_addr[31]
* net 549 wb_dat_i[24]
* net 550 wb_dat_i[18]
* net 552 wb_dat_i[4]
* net 556 read_addr[5]
* net 557 wb_adr_o[6]
* net 558 write_addr[28]
* net 560 write_addr[6]
* net 568 write_addr[8]
* net 570 write_data[26]
* net 571 read_data[18]
* net 573 wb_dat_o[0]
* net 575 read_addr[30]
* net 578 write_addr[29]
* net 585 write_data[2]
* net 586 wb_dat_o[2]
* net 587 wb_dat_o[26]
* net 588 read_addr[8]
* net 590 read_data[21]
* net 591 read_data[22]
* net 592 wb_dat_i[21]
* net 600 write_addr[2]
* net 601 write_addr[30]
* net 614 wb_dat_i[20]
* net 615 read_data[20]
* net 618 write_addr[3]
* net 619 read_addr[4]
* net 623 wb_dat_o[20]
* net 624 wb_adr_o[5]
* net 625 wb_adr_o[3]
* net 627 wb_dat_o[24]
* net 629 wb_dat_i[27]
* net 633 read_addr[3]
* net 634 wb_dat_i[29]
* net 635 wb_dat_i[19]
* net 639 write_data[24]
* net 649 write_addr[4]
* net 651 write_data[20]
* net 652 wb_dat_o[28]
* net 653 read_data[19]
* net 654 write_data[30]
* net 659 wb_adr_o[2]
* net 660 wb_adr_o[30]
* net 668 wb_dat_o[18]
* net 669 write_addr[5]
* net 670 wb_dat_o[22]
* net 671 wb_dat_o[19]
* net 673 read_data[5]
* net 677 write_data[31]
* net 682 wb_dat_o[1]
* net 685 wb_dat_i[5]
* net 687 write_data[22]
* net 688 write_data[17]
* net 690 wb_dat_o[4]
* net 692 write_data[28]
* net 694 write_data[29]
* net 695 wb_dat_o[30]
* net 696 wb_dat_o[31]
* net 697 write_data[0]
* net 698 read_data[31]
* net 703 wb_dat_o[29]
* net 704 read_addr[2]
* net 707 write_data[21]
* net 715 wb_dat_o[25]
* net 716 wb_dat_o[6]
* net 723 write_data[23]
* net 730 write_data[8]
* net 732 write_data[4]
* net 733 wb_dat_i[30]
* net 734 wb_dat_i[31]
* net 735 read_data[29]
* net 736 write_data[6]
* net 739 write_data[9]
* net 741 rst_n
* net 745 wb_dat_i[28]
* net 746 read_data[30]
* net 748 wb_dat_i[2]
* net 750 write_data[18]
* net 753 write_data[19]
* net 754 wb_dat_o[9]
* net 755 write_data[7]
* net 758 read_data[4]
* net 759 read_data[28]
* net 760 read_data[2]
* net 761 read_data[27]
* net 762 wb_dat_o[8]
* net 763 wb_dat_o[7]
* net 764 write_data[25]
* cell instance $7 m0 *1 29.44,13.6
X$7 65 1 3 65 124 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $10 r0 *1 20.24,8.16
X$10 65 97 3 65 2 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22 r0 *1 3.68,2.72
X$22 65 226 3 65 64 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23 r0 *1 7.36,2.72
X$23 65 144 3 65 63 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25 r0 *1 11.5,2.72
X$25 65 55 3 65 5 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $30 r0 *1 17.94,2.72
X$30 65 66 3 65 8 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31 r0 *1 21.62,2.72
X$31 65 56 3 65 10 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32 r0 *1 25.3,2.72
X$32 65 9 3 65 67 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34 r0 *1 29.44,2.72
X$34 65 69 3 65 12 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37 r0 *1 35.42,2.72
X$37 65 14 3 65 76 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38 r0 *1 39.1,2.72
X$38 65 18 3 65 73 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42 r0 *1 44.16,2.72
X$42 65 74 87 178 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $43 r0 *1 45.54,2.72
X$43 65 74 3 65 23 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44 r0 *1 49.22,2.72
X$44 65 21 3 65 78 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45 r0 *1 52.9,2.72
X$45 65 27 3 65 80 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47 r0 *1 57.04,2.72
X$47 65 79 3 65 30 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50 r0 *1 62.1,2.72
X$50 65 35 3 65 77 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52 r0 *1 66.7,2.72
X$52 65 36 3 65 75 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55 r0 *1 70.84,2.72
X$55 65 38 3 65 57 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56 r0 *1 74.52,2.72
X$56 65 42 3 65 70 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57 r0 *1 78.2,2.72
X$57 3 71 51 70 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $61 r0 *1 84.64,2.72
X$61 65 46 3 65 51 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64 r0 *1 91.08,2.72
X$64 65 68 3 65 61 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $76 m0 *1 3.68,8.16
X$76 3 104 54 105 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $78 m0 *1 9.66,8.16
X$78 3 82 97 81 106 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $80 m0 *1 19.32,8.16
X$80 3 82 66 81 128 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $84 m0 *1 31.28,8.16
X$84 65 13 3 65 114 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $85 m0 *1 34.96,8.16
X$85 65 15 3 65 72 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $86 m0 *1 38.64,8.16
X$86 3 82 83 94 95 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $87 m0 *1 47.84,8.16
X$87 65 83 3 65 25 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $88 m0 *1 51.52,8.16
X$88 65 19 3 84 65 3 sky130_fd_sc_hd__buf_2
* cell instance $89 m0 *1 53.36,8.16
X$89 65 84 65 3 88 3 sky130_fd_sc_hd__buf_4
* cell instance $94 m0 *1 58.42,8.16
X$94 65 79 3 65 32 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $95 m0 *1 62.1,8.16
X$95 3 96 77 57 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $97 m0 *1 66.24,8.16
X$97 3 58 282 85 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $98 m0 *1 69.92,8.16
X$98 65 49 3 65 113 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $99 m0 *1 73.6,8.16
X$99 65 39 3 65 112 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $100 m0 *1 77.28,8.16
X$100 65 43 3 65 110 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $101 m0 *1 80.96,8.16
X$101 65 87 58 93 65 109 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $102 m0 *1 82.8,8.16
X$102 65 59 87 93 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $104 m0 *1 84.64,8.16
X$104 65 45 3 65 108 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $105 m0 *1 88.32,8.16
X$105 65 167 3 65 91 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $106 m0 *1 92,8.16
X$106 65 90 3 65 89 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $107 r0 *1 1.38,8.16
X$107 3 136 105 81 104 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $109 r0 *1 11.04,8.16
X$109 3 106 124 97 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $115 r0 *1 16.1,8.16
X$115 3 126 98 55 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $117 r0 *1 24.38,8.16
X$117 3 82 56 94 172 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $118 r0 *1 33.58,8.16
X$118 3 82 74 94 129 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $124 r0 *1 44.16,8.16
X$124 65 87 99 151 65 95 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $125 r0 *1 46,8.16
X$125 65 20 3 65 115 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $126 r0 *1 49.68,8.16
X$126 3 99 115 78 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $127 r0 *1 53.36,8.16
X$127 65 24 3 65 132 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $128 r0 *1 57.04,8.16
X$128 3 134 80 133 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $130 r0 *1 61.18,8.16
X$130 65 28 3 65 133 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $132 r0 *1 65.78,8.16
X$132 3 131 130 75 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $138 r0 *1 70.84,8.16
X$138 65 50 3 65 100 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $139 r0 *1 74.52,8.16
X$139 3 248 113 100 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $140 r0 *1 78.2,8.16
X$140 3 111 112 110 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $141 r0 *1 81.88,8.16
X$141 3 82 59 101 109 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $143 r0 *1 92,8.16
X$143 65 102 3 65 211 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $145 m0 *1 2.3,13.6
X$145 3 136 125 81 123 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $147 m0 *1 13.34,13.6
X$147 3 82 55 81 126 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $150 m0 *1 24.84,13.6
X$150 3 128 147 66 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $152 m0 *1 33.12,13.6
X$152 65 4 3 65 98 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $153 m0 *1 36.8,13.6
X$153 65 7 3 65 149 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $154 m0 *1 40.48,13.6
X$154 65 17 3 65 150 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $155 m0 *1 44.16,13.6
X$155 3 138 150 73 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $157 m0 *1 48.3,13.6
X$157 65 22 3 65 154 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $158 m0 *1 51.98,13.6
X$158 3 153 154 132 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $164 m0 *1 60.26,13.6
X$164 65 155 3 65 52 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $165 m0 *1 63.94,13.6
X$165 65 53 3 65 130 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $166 m0 *1 67.62,13.6
X$166 65 87 117 139 65 3 152 3 sky130_fd_sc_hd__o21ai_1
* cell instance $167 m0 *1 69.46,13.6
X$167 65 140 3 65 37 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $168 m0 *1 73.14,13.6
X$168 3 82 107 101 118 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $169 m0 *1 82.34,13.6
X$169 65 87 111 119 65 118 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $172 m0 *1 85.1,13.6
X$172 3 139 148 108 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $173 m0 *1 88.78,13.6
X$173 65 87 141 120 65 127 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $174 m0 *1 90.62,13.6
X$174 65 107 87 119 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $175 m0 *1 92,13.6
X$175 65 145 3 65 146 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $179 r0 *1 4.6,13.6
X$179 3 213 64 144 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $181 r0 *1 10.58,13.6
X$181 3 123 195 125 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $186 r0 *1 19.32,13.6
X$186 65 125 3 65 156 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $187 r0 *1 23,13.6
X$187 65 6 3 65 147 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $188 r0 *1 26.68,13.6
X$188 3 172 67 56 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $189 r0 *1 30.82,13.6
X$189 65 137 3 65 11 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $190 r0 *1 34.5,13.6
X$190 65 174 149 160 3 65 200 3 sky130_fd_sc_hd__a21oi_1
* cell instance $192 r0 *1 37.26,13.6
X$192 65 161 3 65 16 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $193 r0 *1 40.94,13.6
X$193 65 114 65 3 177 3 sky130_fd_sc_hd__inv_1
* cell instance $197 r0 *1 43.24,13.6
X$197 65 87 178 138 65 3 129 3 sky130_fd_sc_hd__o21ai_1
* cell instance $198 r0 *1 45.08,13.6
X$198 65 83 87 151 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $200 r0 *1 50.14,13.6
X$200 65 87 153 180 65 176 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $201 r0 *1 51.98,13.6
X$201 65 179 87 180 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $203 r0 *1 53.82,13.6
X$203 65 179 3 65 26 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $204 r0 *1 57.5,13.6
X$204 65 182 87 181 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $205 r0 *1 58.88,13.6
X$205 65 182 3 65 33 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $206 r0 *1 62.56,13.6
X$206 65 31 3 65 183 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $208 r0 *1 66.7,13.6
X$208 65 44 3 65 148 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $211 r0 *1 70.84,13.6
X$211 65 140 87 163 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $212 r0 *1 72.22,13.6
X$212 65 164 3 65 48 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $213 r0 *1 75.9,13.6
X$213 3 82 166 101 127 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $214 r0 *1 85.1,13.6
X$214 65 171 3 65 170 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $215 r0 *1 88.78,13.6
X$215 65 193 3 65 212 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $216 r0 *1 92.46,13.6
X$216 65 166 87 120 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $224 m0 *1 1.38,19.04
X$224 65 192 3 65 307 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $225 m0 *1 5.06,19.04
X$225 65 157 3 65 168 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $226 m0 *1 8.74,19.04
X$226 65 158 3 65 196 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $227 m0 *1 12.42,19.04
X$227 3 169 196 186 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $231 m0 *1 19.78,19.04
X$231 3 136 137 81 187 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $233 m0 *1 29.44,19.04
X$233 65 159 160 92 218 3 65 187 3 sky130_fd_sc_hd__a31oi_1
* cell instance $235 m0 *1 32.66,19.04
X$235 3 136 161 94 201 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $236 m0 *1 41.86,19.04
X$236 3 205 161 175 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $237 m0 *1 45.54,19.04
X$237 3 82 179 94 176 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $238 m0 *1 54.74,19.04
X$238 65 87 134 181 65 204 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $241 m0 *1 57.5,19.04
X$241 65 29 3 65 203 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $243 m0 *1 61.64,19.04
X$243 65 87 162 163 65 202 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $244 m0 *1 63.48,19.04
X$244 3 162 203 183 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $246 m0 *1 67.62,19.04
X$246 3 82 164 101 152 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $247 m0 *1 76.82,19.04
X$247 65 164 87 117 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $248 m0 *1 78.2,19.04
X$248 65 189 3 65 47 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $249 m0 *1 81.88,19.04
X$249 65 189 87 198 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $253 m0 *1 85.56,19.04
X$253 3 173 197 170 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $255 m0 *1 89.7,19.04
X$255 3 194 146 89 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $256 m0 *1 93.38,19.04
X$256 65 102 87 165 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $259 r0 *1 2.3,19.04
X$259 3 136 144 81 213 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $260 r0 *1 11.5,19.04
X$260 65 184 3 65 195 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $264 r0 *1 15.64,19.04
X$264 65 186 3 65 185 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $265 r0 *1 19.32,19.04
X$265 3 136 174 81 232 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $266 r0 *1 28.52,19.04
X$266 65 69 65 3 199 3 sky130_fd_sc_hd__inv_1
* cell instance $267 r0 *1 29.9,19.04
X$267 65 175 188 206 3 65 219 3 sky130_fd_sc_hd__a21oi_1
* cell instance $268 r0 *1 31.74,19.04
X$268 65 105 3 65 116 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $269 r0 *1 35.42,19.04
X$269 65 207 220 221 3 65 3 sky130_fd_sc_hd__nor2_1
* cell instance $270 r0 *1 36.8,19.04
X$270 3 88 208 114 225 65 65 3 sky130_fd_sc_hd__o21ai_4
* cell instance $274 r0 *1 43.24,19.04
X$274 65 225 65 3 87 3 sky130_fd_sc_hd__buf_4
* cell instance $275 r0 *1 46,19.04
X$275 65 149 76 206 3 65 3 sky130_fd_sc_hd__nor2_1
* cell instance $278 r0 *1 49.68,19.04
X$278 3 82 182 209 204 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $279 r0 *1 58.88,19.04
X$279 3 82 140 209 202 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $280 r0 *1 68.08,19.04
X$280 65 223 87 224 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $285 r0 *1 70.84,19.04
X$285 65 223 3 65 41 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $286 r0 *1 74.52,19.04
X$286 65 87 71 198 65 222 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $287 r0 *1 76.36,19.04
X$287 3 82 193 101 190 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $288 r0 *1 85.56,19.04
X$288 65 87 217 194 65 3 190 3 sky130_fd_sc_hd__o21ai_1
* cell instance $290 r0 *1 87.86,19.04
X$290 65 216 3 65 215 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $291 r0 *1 91.54,19.04
X$291 3 210 214 215 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $298 m0 *1 2.76,24.48
X$298 65 300 3 65 277 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $301 m0 *1 8.74,24.48
X$301 65 135 3 65 54 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $302 m0 *1 12.42,24.48
X$302 3 136 186 81 169 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $304 m0 *1 22.08,24.48
X$304 65 200 340 232 3 65 3 sky130_fd_sc_hd__nor2_1
* cell instance $305 m0 *1 23.46,24.48
X$305 65 259 175 188 159 3 65 3 sky130_fd_sc_hd__nor3_1
* cell instance $306 m0 *1 25.3,24.48
X$306 65 174 3 65 249 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $308 m0 *1 29.44,24.48
X$308 3 218 234 160 137 219 92 65 65 3 sky130_fd_sc_hd__a41oi_1
* cell instance $309 m0 *1 32.66,24.48
X$309 65 88 114 208 332 3 65 3 sky130_fd_sc_hd__nand3b_1
* cell instance $311 m0 *1 36.34,24.48
X$311 65 161 149 175 3 65 237 3 sky130_fd_sc_hd__a21oi_1
* cell instance $312 m0 *1 38.18,24.48
X$312 65 237 208 205 3 65 201 3 sky130_fd_sc_hd__a21oi_1
* cell instance $313 m0 *1 40.02,24.48
X$313 65 208 228 227 3 65 241 3 sky130_fd_sc_hd__a21o_1
* cell instance $314 m0 *1 42.78,24.48
X$314 65 114 88 228 3 65 3 sky130_fd_sc_hd__nor2_1
* cell instance $315 m0 *1 44.16,24.48
X$315 65 269 208 228 3 65 236 3 sky130_fd_sc_hd__a21oi_1
* cell instance $316 m0 *1 46,24.48
X$316 3 82 79 94 236 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $321 m0 *1 58.88,24.48
X$321 65 229 87 261 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $322 m0 *1 60.26,24.48
X$322 3 82 223 209 235 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $323 m0 *1 69.46,24.48
X$323 3 82 189 101 222 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $324 m0 *1 78.66,24.48
X$324 65 87 165 230 65 3 246 3 sky130_fd_sc_hd__o21ai_1
* cell instance $325 m0 *1 80.5,24.48
X$325 65 233 3 65 197 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $327 m0 *1 84.64,24.48
X$327 65 193 87 217 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $328 m0 *1 86.02,24.48
X$328 65 166 3 65 142 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $329 m0 *1 89.7,24.48
X$329 65 231 3 65 214 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $332 r0 *1 1.38,24.48
X$332 65 316 3 65 255 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $333 r0 *1 5.06,24.48
X$333 3 136 251 81 245 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $337 r0 *1 15.64,24.48
X$337 65 251 3 65 238 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $339 r0 *1 19.78,24.48
X$339 3 136 260 94 247 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $340 r0 *1 28.98,24.48
X$340 3 3 188 92 149 65 65 sky130_fd_sc_hd__nand2_2
* cell instance $341 r0 *1 31.28,24.48
X$341 65 72 206 262 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $342 r0 *1 32.66,24.48
X$342 65 114 208 239 65 3 3 sky130_fd_sc_hd__and2_1
* cell instance $343 r0 *1 34.96,24.48
X$343 65 76 149 297 3 65 3 sky130_fd_sc_hd__nand2b_1
* cell instance $344 r0 *1 37.26,24.48
X$344 65 177 208 88 65 3 160 3 sky130_fd_sc_hd__o21ai_1
* cell instance $346 r0 *1 39.56,24.48
X$346 65 227 266 267 240 65 3 268 3 sky130_fd_sc_hd__o31ai_1
* cell instance $350 r0 *1 43.24,24.48
X$350 65 242 241 240 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $352 r0 *1 45.54,24.48
X$352 3 769 175 242 253 65 65 3 sky130_fd_sc_hd__ha_1
* cell instance $353 r0 *1 50.14,24.48
X$353 65 302 69 265 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $356 r0 *1 57.04,24.48
X$356 3 82 229 209 263 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $358 r0 *1 66.7,24.48
X$358 65 286 3 65 258 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $361 r0 *1 70.84,24.48
X$361 65 229 3 65 40 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $362 r0 *1 74.52,24.48
X$362 65 87 248 224 65 235 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $363 r0 *1 76.36,24.48
X$363 3 82 102 101 246 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $364 r0 *1 85.56,24.48
X$364 65 122 3 65 257 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $367 r0 *1 92,24.48
X$367 65 244 3 65 256 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $374 m0 *1 1.38,29.92
X$374 3 136 157 81 271 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $376 m0 *1 11.5,29.92
X$376 65 260 3 65 250 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $377 m0 *1 15.18,29.92
X$377 65 270 3 65 279 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $378 m0 *1 18.86,29.92
X$378 3 247 279 260 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $379 m0 *1 23,29.92
X$379 3 273 81 65 65 3 sky130_fd_sc_hd__clkbuf_8
* cell instance $382 m0 *1 29.44,29.92
X$382 65 274 272 175 259 3 220 65 3 sky130_fd_sc_hd__a211oi_1
* cell instance $384 m0 *1 33.12,29.92
X$384 65 88 208 267 3 65 3 sky130_fd_sc_hd__nor2b_1
* cell instance $385 m0 *1 35.42,29.92
X$385 3 227 149 72 76 252 65 65 3 sky130_fd_sc_hd__nor4b_4
* cell instance $386 m0 *1 44.16,29.92
X$386 65 208 227 283 269 3 65 3 sky130_fd_sc_hd__nor3_1
* cell instance $387 m0 *1 46,29.92
X$387 3 252 208 284 253 65 65 3 sky130_fd_sc_hd__ha_1
* cell instance $388 m0 *1 50.6,29.92
X$388 3 766 188 284 264 65 65 3 sky130_fd_sc_hd__ha_1
* cell instance $394 m0 *1 58.42,29.92
X$394 65 87 96 261 65 263 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $395 m0 *1 60.26,29.92
X$395 3 82 254 209 298 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $396 m0 *1 69.46,29.92
X$396 65 254 87 281 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $397 m0 *1 70.84,29.92
X$397 65 254 3 65 243 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $398 m0 *1 74.52,29.92
X$398 65 143 3 65 85 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $399 m0 *1 78.2,29.92
X$399 65 59 3 65 62 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $400 m0 *1 81.88,29.92
X$400 65 276 87 295 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $403 m0 *1 84.64,29.92
X$403 65 107 3 65 103 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $405 m0 *1 88.78,29.92
X$405 3 280 278 257 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $411 r0 *1 4.14,29.92
X$411 3 271 277 157 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $412 r0 *1 8.28,29.92
X$412 3 245 291 251 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $418 r0 *1 15.64,29.92
X$418 65 290 3 65 293 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $419 r0 *1 19.32,29.92
X$419 65 272 3 65 285 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $420 r0 *1 23,29.92
X$420 3 136 272 94 221 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $421 r0 *1 32.2,29.92
X$421 65 272 275 207 3 65 3 sky130_fd_sc_hd__nor2_1
* cell instance $422 r0 *1 33.58,29.92
X$422 3 267 275 175 297 265 259 65 65 3 sky130_fd_sc_hd__a221oi_2
* cell instance $423 r0 *1 39.1,29.92
X$423 65 94 3 65 3 sky130_fd_sc_hd__clkinv_4
* cell instance $428 r0 *1 43.24,29.92
X$428 3 136 242 94 268 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $429 r0 *1 52.44,29.92
X$429 65 242 65 3 284 3 sky130_fd_sc_hd__inv_1
* cell instance $430 r0 *1 53.82,29.92
X$430 65 264 65 3 253 3 sky130_fd_sc_hd__inv_1
* cell instance $432 r0 *1 55.66,29.92
X$432 65 34 3 65 299 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $433 r0 *1 59.34,29.92
X$433 3 209 65 65 3 sky130_fd_sc_hd__inv_8
* cell instance $435 r0 *1 63.94,29.92
X$435 65 86 3 65 282 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $441 r0 *1 70.84,29.92
X$441 3 82 276 209 287 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $442 r0 *1 80.04,29.92
X$442 65 87 295 210 65 3 287 3 sky130_fd_sc_hd__o21ai_1
* cell instance $443 r0 *1 81.88,29.92
X$443 65 276 3 65 191 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $445 r0 *1 86.02,29.92
X$445 65 289 3 65 278 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $446 r0 *1 89.7,29.92
X$446 65 87 280 352 65 294 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $448 r0 *1 92,29.92
X$448 3 288 292 256 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $455 m0 *1 4.6,35.36
X$455 3 274 307 290 301 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $457 m0 *1 10.58,35.36
X$457 3 136 290 81 301 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $458 m0 *1 19.78,35.36
X$458 3 136 69 81 309 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $461 m0 *1 30.36,35.36
X$461 65 302 259 283 3 65 3 sky130_fd_sc_hd__nor2b_1
* cell instance $462 m0 *1 32.66,35.36
X$462 3 266 283 252 208 69 206 65 65 3 sky130_fd_sc_hd__a221oi_1
* cell instance $463 m0 *1 35.88,35.36
X$463 3 273 94 65 65 3 sky130_fd_sc_hd__clkbuf_8
* cell instance $464 m0 *1 40.94,35.36
X$464 3 303 283 252 208 199 206 65 65 3 sky130_fd_sc_hd__a221oi_1
* cell instance $466 m0 *1 45.08,35.36
X$466 3 136 264 94 314 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $472 m0 *1 59.34,35.36
X$472 3 273 209 65 65 3 sky130_fd_sc_hd__clkbuf_8
* cell instance $473 m0 *1 64.4,35.36
X$473 65 87 131 281 65 298 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $476 m0 *1 67.62,35.36
X$476 3 82 286 101 296 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $477 m0 *1 76.82,35.36
X$477 65 87 312 288 65 3 313 3 sky130_fd_sc_hd__o21ai_1
* cell instance $478 m0 *1 78.66,35.36
X$478 65 87 173 311 65 296 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $479 m0 *1 80.5,35.36
X$479 65 121 3 65 310 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $481 m0 *1 84.64,35.36
X$481 65 286 87 311 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $482 m0 *1 86.02,35.36
X$482 65 306 3 65 292 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $483 m0 *1 89.7,35.36
X$483 3 322 338 308 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $487 r0 *1 1.84,35.36
X$487 65 373 3 65 321 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $488 r0 *1 5.52,35.36
X$488 65 315 3 65 337 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $490 r0 *1 9.66,35.36
X$490 3 274 255 317 323 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $493 r0 *1 15.64,35.36
X$493 65 343 3 65 291 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $494 r0 *1 19.32,35.36
X$494 3 136 317 81 323 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $495 r0 *1 28.52,35.36
X$495 65 318 69 259 65 234 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $496 r0 *1 30.36,35.36
X$496 65 365 318 356 324 325 3 65 3 sky130_fd_sc_hd__o22ai_1
* cell instance $498 r0 *1 33.58,35.36
X$498 65 199 239 274 65 309 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $499 r0 *1 35.42,35.36
X$499 65 259 252 262 3 65 326 3 sky130_fd_sc_hd__a21oi_1
* cell instance $501 r0 *1 38.18,35.36
X$501 3 333 149 76 72 65 65 3 sky130_fd_sc_hd__nor3b_2
* cell instance $505 r0 *1 43.7,35.36
X$505 65 274 241 328 3 65 3 sky130_fd_sc_hd__nand2b_1
* cell instance $506 r0 *1 46,35.36
X$506 65 303 328 329 65 314 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $507 r0 *1 47.84,35.36
X$507 65 264 241 329 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $509 r0 *1 49.68,35.36
X$509 3 3 208 330 88 65 65 sky130_fd_sc_hd__nand2_2
* cell instance $510 r0 *1 51.98,35.36
X$510 65 330 65 3 274 3 sky130_fd_sc_hd__buf_4
* cell instance $513 r0 *1 56.12,35.36
X$513 3 82 319 209 327 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $516 r0 *1 66.7,35.36
X$516 65 319 3 65 305 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $519 r0 *1 70.84,35.36
X$519 3 273 101 65 65 3 sky130_fd_sc_hd__clkbuf_8
* cell instance $520 r0 *1 75.9,35.36
X$520 65 304 87 312 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $521 r0 *1 77.28,35.36
X$521 3 82 155 101 294 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $522 r0 *1 86.48,35.36
X$522 65 87 402 322 65 3 399 3 sky130_fd_sc_hd__o21ai_1
* cell instance $524 r0 *1 88.78,35.36
X$524 65 349 3 65 308 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $536 m0 *1 2.76,40.8
X$536 65 351 3 65 403 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $537 m0 *1 6.44,40.8
X$537 65 353 3 65 336 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $539 m0 *1 10.58,40.8
X$539 3 274 337 331 354 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $541 m0 *1 17.02,40.8
X$541 3 136 331 81 354 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $543 m0 *1 27.14,40.8
X$543 65 188 174 332 3 65 340 3 sky130_fd_sc_hd__a21oi_1
* cell instance $545 m0 *1 29.44,40.8
X$545 3 136 302 81 325 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $546 m0 *1 38.64,40.8
X$546 65 259 333 252 357 3 65 3 sky130_fd_sc_hd__nand3b_1
* cell instance $547 m0 *1 41.4,40.8
X$547 65 345 341 358 333 65 324 3 3 sky130_fd_sc_hd__nand4_1
* cell instance $548 m0 *1 43.7,40.8
X$548 65 422 333 346 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $549 m0 *1 45.08,40.8
X$549 3 767 259 242 264 65 65 3 sky130_fd_sc_hd__ha_1
* cell instance $555 m0 *1 57.04,40.8
X$555 65 87 334 335 65 327 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $556 m0 *1 58.88,40.8
X$556 3 334 347 299 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $559 m0 *1 63.94,40.8
X$559 65 319 87 335 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $561 m0 *1 66.24,40.8
X$561 3 82 304 101 313 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $562 m0 *1 75.44,40.8
X$562 65 320 3 65 347 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $563 m0 *1 79.12,40.8
X$563 65 60 3 65 339 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $564 m0 *1 82.8,40.8
X$564 65 155 87 352 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $566 m0 *1 84.64,40.8
X$566 3 141 310 339 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $567 m0 *1 88.32,40.8
X$567 65 350 3 65 338 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $568 m0 *1 92,40.8
X$568 3 230 91 61 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $569 r0 *1 1.38,40.8
X$569 3 136 353 81 379 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $571 r0 *1 11.5,40.8
X$571 65 317 3 65 342 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $575 r0 *1 16.1,40.8
X$575 65 331 3 65 344 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $577 r0 *1 20.7,40.8
X$577 3 136 367 81 364 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $579 r0 *1 30.36,40.8
X$579 65 259 252 324 3 65 365 3 sky130_fd_sc_hd__a21oi_1
* cell instance $580 r0 *1 32.2,40.8
X$580 65 252 359 356 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $581 r0 *1 33.58,40.8
X$581 3 136 345 94 370 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $584 r0 *1 43.24,40.8
X$584 65 259 252 346 3 65 360 3 sky130_fd_sc_hd__a21oi_1
* cell instance $585 r0 *1 45.08,40.8
X$585 65 360 410 412 346 372 3 65 3 sky130_fd_sc_hd__o22ai_1
* cell instance $586 r0 *1 47.38,40.8
X$586 65 259 341 396 3 65 3 sky130_fd_sc_hd__nor2_1
* cell instance $589 r0 *1 52.9,40.8
X$589 3 82 369 209 371 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $593 r0 *1 67.16,40.8
X$593 65 101 3 65 3 sky130_fd_sc_hd__clkinv_4
* cell instance $596 r0 *1 70.84,40.8
X$596 65 87 408 366 65 368 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $597 r0 *1 72.68,40.8
X$597 65 376 87 366 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $598 r0 *1 74.06,40.8
X$598 65 304 3 65 355 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $599 r0 *1 77.74,40.8
X$599 3 82 363 101 361 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $600 r0 *1 86.94,40.8
X$600 65 87 348 385 65 361 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $602 r0 *1 89.7,40.8
X$602 3 348 386 380 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $613 m0 *1 3.68,46.24
X$613 3 379 321 353 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $615 m0 *1 8.74,46.24
X$615 3 136 381 81 382 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $616 m0 *1 17.94,46.24
X$616 65 404 3 65 383 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $617 m0 *1 21.62,46.24
X$617 3 274 383 367 364 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $619 m0 *1 27.6,46.24
X$619 65 302 65 3 318 3 sky130_fd_sc_hd__inv_1
* cell instance $623 m0 *1 30.82,46.24
X$623 65 259 302 359 3 65 3 sky130_fd_sc_hd__nor2_1
* cell instance $624 m0 *1 32.2,46.24
X$624 65 357 407 326 375 370 3 65 3 sky130_fd_sc_hd__o22ai_1
* cell instance $625 m0 *1 34.5,46.24
X$625 3 136 358 94 409 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $626 m0 *1 43.7,46.24
X$626 3 136 341 94 372 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $627 m0 *1 52.9,46.24
X$627 65 388 3 65 390 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $629 m0 *1 57.04,46.24
X$629 3 389 411 390 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $632 m0 *1 62.1,46.24
X$632 65 392 3 65 391 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $633 m0 *1 65.78,46.24
X$633 65 369 3 65 384 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $634 m0 *1 69.46,46.24
X$634 3 82 376 101 368 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $636 m0 *1 79.12,46.24
X$636 65 376 3 65 387 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $640 m0 *1 84.64,46.24
X$640 65 363 87 385 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $641 m0 *1 86.02,46.24
X$641 65 377 3 65 386 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $642 m0 *1 89.7,46.24
X$642 65 378 3 65 380 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $646 r0 *1 1.84,46.24
X$646 65 489 3 65 418 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $648 r0 *1 6.44,46.24
X$648 3 274 403 381 382 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $655 r0 *1 16.56,46.24
X$655 65 405 3 65 393 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $656 r0 *1 20.24,46.24
X$656 65 367 3 65 413 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $657 r0 *1 23.92,46.24
X$657 65 406 3 65 419 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $660 r0 *1 33.12,46.24
X$660 65 394 65 3 407 3 sky130_fd_sc_hd__inv_1
* cell instance $661 r0 *1 34.5,46.24
X$661 3 409 326 357 395 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $662 r0 *1 38.18,46.24
X$662 3 394 770 395 375 65 65 3 sky130_fd_sc_hd__ha_1
* cell instance $665 r0 *1 43.24,46.24
X$665 65 358 65 3 395 3 sky130_fd_sc_hd__inv_1
* cell instance $666 r0 *1 44.62,46.24
X$666 65 341 65 3 410 3 sky130_fd_sc_hd__inv_1
* cell instance $667 r0 *1 46,46.24
X$667 65 252 396 412 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $671 r0 *1 53.82,46.24
X$671 65 401 3 65 411 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $672 r0 *1 57.5,46.24
X$672 65 87 389 421 65 371 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $673 r0 *1 59.34,46.24
X$673 65 369 87 421 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $674 r0 *1 60.72,46.24
X$674 3 82 430 209 420 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $678 r0 *1 70.84,46.24
X$678 3 408 397 450 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $679 r0 *1 74.52,46.24
X$679 65 398 3 65 397 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $680 r0 *1 78.2,46.24
X$680 3 82 400 101 399 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $681 r0 *1 87.4,46.24
X$681 65 400 87 402 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $683 r0 *1 89.7,46.24
X$683 65 400 3 65 417 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $694 m0 *1 3.68,51.68
X$694 65 381 3 65 374 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $695 m0 *1 7.36,51.68
X$695 65 427 3 65 443 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $696 m0 *1 11.04,51.68
X$696 65 423 3 65 446 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $697 m0 *1 14.72,51.68
X$697 65 414 3 65 447 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $698 m0 *1 18.4,51.68
X$698 3 136 433 415 448 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $702 m0 *1 29.44,51.68
X$702 3 136 434 415 451 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $703 m0 *1 38.64,51.68
X$703 65 345 65 3 375 3 sky130_fd_sc_hd__inv_1
* cell instance $704 m0 *1 40.02,51.68
X$704 3 768 422 358 345 65 65 3 sky130_fd_sc_hd__ha_1
* cell instance $708 m0 *1 47.84,51.68
X$708 3 472 273 65 65 3 sky130_fd_sc_hd__clkbuf_8
* cell instance $709 m0 *1 52.9,51.68
X$709 65 424 65 3 136 3 sky130_fd_sc_hd__buf_4
* cell instance $712 m0 *1 57.04,51.68
X$712 65 87 531 432 65 454 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $713 m0 *1 58.88,51.68
X$713 65 436 87 432 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $716 m0 *1 62.56,51.68
X$716 65 87 416 431 65 420 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $718 m0 *1 64.86,51.68
X$718 3 416 391 452 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $719 m0 *1 68.54,51.68
X$719 65 430 87 431 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $720 m0 *1 69.92,51.68
X$720 65 430 3 65 426 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $723 m0 *1 75.9,51.68
X$723 65 87 485 429 65 449 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $725 m0 *1 78.2,51.68
X$725 65 460 87 429 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $727 m0 *1 80.5,51.68
X$727 65 496 3 65 428 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $731 m0 *1 86.02,51.68
X$731 65 363 3 65 362 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $732 m0 *1 89.7,51.68
X$732 65 87 500 440 65 442 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $734 m0 *1 92,51.68
X$734 65 425 3 65 438 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $736 r0 *1 1.84,51.68
X$736 3 424 462 415 457 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $737 r0 *1 11.04,51.68
X$737 65 444 3 65 445 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $741 r0 *1 15.64,51.68
X$741 3 274 446 433 448 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $742 r0 *1 21.16,51.68
X$742 65 433 3 65 455 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $745 r0 *1 27.6,51.68
X$745 3 274 470 434 451 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $747 r0 *1 33.58,51.68
X$747 3 136 435 415 473 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $750 r0 *1 43.24,51.68
X$750 3 274 505 435 473 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $752 r0 *1 49.22,51.68
X$752 3 82 436 458 454 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $754 r0 *1 58.88,51.68
X$754 65 436 3 65 437 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $756 r0 *1 63.02,51.68
X$756 65 453 3 65 452 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $757 r0 *1 66.7,51.68
X$757 65 468 3 65 450 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $760 r0 *1 70.84,51.68
X$760 3 82 460 466 449 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $762 r0 *1 80.96,51.68
X$762 3 82 425 466 442 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $764 r0 *1 90.62,51.68
X$764 65 425 87 440 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $765 r0 *1 92,51.68
X$765 65 439 3 65 461 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $772 m0 *1 1.38,57.12
X$772 3 457 418 462 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $773 m0 *1 5.52,57.12
X$773 3 424 475 415 483 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $774 m0 *1 14.72,57.12
X$774 3 465 501 487 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $775 m0 *1 18.86,57.12
X$775 3 424 406 415 476 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $780 m0 *1 30.82,57.12
X$780 65 434 3 65 471 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $782 m0 *1 38.18,57.12
X$782 3 136 491 415 504 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $783 m0 *1 47.38,57.12
X$783 3 136 478 458 477 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $785 m0 *1 57.04,57.12
X$785 65 478 3 65 469 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $788 m0 *1 62.1,57.12
X$788 65 87 459 479 65 510 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $789 m0 *1 63.94,57.12
X$789 3 459 522 547 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $792 m0 *1 71.76,57.12
X$792 65 486 3 65 441 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $793 m0 *1 75.44,57.12
X$793 3 485 506 467 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $794 m0 *1 79.12,57.12
X$794 65 460 3 65 464 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $798 m0 *1 84.64,57.12
X$798 65 484 3 65 463 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $800 m0 *1 90.16,57.12
X$800 65 87 517 502 65 480 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $801 m0 *1 92,57.12
X$801 65 481 3 65 482 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $803 r0 *1 3.22,57.12
X$803 65 462 3 65 474 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $804 r0 *1 6.9,57.12
X$804 3 483 498 475 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $805 r0 *1 11.04,57.12
X$805 65 488 3 65 501 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $809 r0 *1 15.64,57.12
X$809 3 476 447 406 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $810 r0 *1 19.78,57.12
X$810 3 273 415 65 65 3 sky130_fd_sc_hd__clkbuf_8
* cell instance $813 r0 *1 27.6,57.12
X$813 65 456 3 65 470 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $815 r0 *1 31.74,57.12
X$815 65 490 3 65 503 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $816 r0 *1 35.42,57.12
X$816 3 274 503 491 504 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $821 r0 *1 43.7,57.12
X$821 65 435 3 65 507 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $823 r0 *1 48.3,57.12
X$823 65 508 3 65 505 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $825 r0 *1 52.44,57.12
X$825 3 274 492 478 477 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $827 r0 *1 58.88,57.12
X$827 3 82 486 458 510 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $828 r0 *1 68.08,57.12
X$828 65 486 87 479 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $832 r0 *1 70.84,57.12
X$832 65 493 87 509 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $833 r0 *1 72.22,57.12
X$833 65 87 494 509 65 521 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $834 r0 *1 74.06,57.12
X$834 65 495 3 65 506 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $835 r0 *1 77.74,57.12
X$835 65 520 3 65 467 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $836 r0 *1 81.42,57.12
X$836 3 82 497 466 480 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $837 r0 *1 90.62,57.12
X$837 65 497 87 502 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $838 r0 *1 92,57.12
X$838 3 500 482 499 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $845 m0 *1 1.38,62.56
X$845 65 475 3 65 529 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $848 m0 *1 7.36,62.56
X$848 3 424 519 415 536 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $849 m0 *1 16.56,62.56
X$849 3 424 487 415 465 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $850 m0 *1 25.76,62.56
X$850 65 415 65 3 3 sky130_fd_sc_hd__inv_6
* cell instance $852 m0 *1 29.44,62.56
X$852 65 554 3 65 542 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $855 m0 *1 35.88,62.56
X$855 3 274 512 525 527 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $856 m0 *1 41.4,62.56
X$856 65 491 3 65 543 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $858 m0 *1 45.54,62.56
X$858 3 136 526 458 545 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $861 m0 *1 57.04,62.56
X$861 65 87 513 523 65 548 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $862 m0 *1 58.88,62.56
X$862 65 524 3 65 492 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $863 m0 *1 62.56,62.56
X$863 65 514 3 65 522 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $866 m0 *1 69,62.56
X$866 3 82 493 466 521 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $867 m0 *1 78.2,62.56
X$867 65 518 3 65 540 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $869 m0 *1 82.8,62.56
X$869 65 515 87 539 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $871 m0 *1 84.64,62.56
X$871 65 493 3 65 557 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $872 m0 *1 88.32,62.56
X$872 65 497 3 65 535 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $873 m0 *1 92,62.56
X$873 3 517 537 576 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $874 r0 *1 1.38,62.56
X$874 65 511 3 65 498 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $875 r0 *1 5.06,62.56
X$875 65 519 3 65 528 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $877 r0 *1 9.66,62.56
X$877 3 536 577 519 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $883 r0 *1 16.1,62.56
X$883 65 538 3 65 720 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $885 r0 *1 20.24,62.56
X$885 3 424 553 530 561 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $886 r0 *1 29.44,62.56
X$886 65 541 3 65 565 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $888 r0 *1 33.58,62.56
X$888 3 136 525 530 527 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $892 r0 *1 43.7,62.56
X$892 3 274 569 526 545 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $895 r0 *1 53.82,62.56
X$895 3 531 589 567 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $896 r0 *1 57.5,62.56
X$896 65 458 3 65 3 sky130_fd_sc_hd__clkinv_4
* cell instance $897 r0 *1 60.72,62.56
X$897 65 87 612 611 65 566 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $898 r0 *1 62.56,62.56
X$898 65 546 3 65 547 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $900 r0 *1 66.7,62.56
X$900 65 544 3 65 533 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $903 r0 *1 70.84,62.56
X$903 3 466 765 65 65 3 sky130_fd_sc_hd__clkbuf_8
* cell instance $904 r0 *1 75.9,62.56
X$904 65 532 3 65 563 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $906 r0 *1 81.42,62.56
X$906 3 82 515 466 534 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $907 r0 *1 90.62,62.56
X$907 65 516 3 65 537 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $918 m0 *1 2.76,68
X$918 3 424 572 415 602 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $919 m0 *1 11.96,68
X$919 65 552 3 65 581 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $921 m0 *1 16.1,68
X$921 65 550 3 65 562 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $922 m0 *1 19.78,68
X$922 3 561 562 553 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $923 m0 *1 23.92,68
X$923 3 273 530 65 65 3 sky130_fd_sc_hd__clkbuf_8
* cell instance $926 m0 *1 30.36,68
X$926 3 584 565 554 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $927 m0 *1 34.5,68
X$927 65 697 3 65 551 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $930 m0 *1 40.94,68
X$930 65 525 3 65 586 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $932 m0 *1 46.46,68
X$932 65 570 3 65 569 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $935 m0 *1 51.52,68
X$935 65 568 3 65 567 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $941 m0 *1 58.42,68
X$941 3 82 544 466 548 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $943 m0 *1 68.54,68
X$943 3 82 583 466 564 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $944 m0 *1 77.74,68
X$944 3 494 563 559 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $946 m0 *1 82.34,68
X$946 65 87 555 539 65 534 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $948 m0 *1 84.64,68
X$948 65 560 3 65 559 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $949 m0 *1 88.32,68
X$949 65 575 3 65 580 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $950 m0 *1 92,68
X$950 65 558 3 65 499 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $954 r0 *1 4.6,68
X$954 3 602 603 572 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $955 r0 *1 8.74,68
X$955 65 549 3 65 577 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $962 r0 *1 17.94,68
X$962 65 487 3 65 591 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $963 r0 *1 21.62,68
X$963 65 582 3 65 735 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $964 r0 *1 25.3,68
X$964 3 424 554 530 584 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $965 r0 *1 34.5,68
X$965 65 594 3 65 573 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $966 r0 *1 38.18,68
X$966 65 585 3 65 512 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $972 r0 *1 45.54,68
X$972 65 526 3 65 587 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $973 r0 *1 49.22,68
X$973 65 588 3 65 589 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $974 r0 *1 52.9,68
X$974 3 273 458 65 65 3 sky130_fd_sc_hd__clkbuf_8
* cell instance $975 r0 *1 57.96,68
X$975 3 82 596 466 566 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $976 r0 *1 67.16,68
X$976 65 544 87 523 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $977 r0 *1 68.54,68
X$977 65 87 598 607 65 564 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $980 r0 *1 70.84,68
X$980 3 273 466 65 65 3 sky130_fd_sc_hd__clkbuf_8
* cell instance $983 r0 *1 78.66,68
X$983 3 82 579 466 574 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $984 r0 *1 87.86,68
X$984 3 555 580 599 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $986 r0 *1 92,68
X$986 65 578 3 65 576 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $993 m0 *1 1.38,73.44
X$993 65 592 3 65 603 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $994 m0 *1 5.06,73.44
X$994 3 424 593 530 642 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $995 m0 *1 14.26,73.44
X$995 3 424 582 530 628 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $996 m0 *1 23.46,73.44
X$996 65 530 65 3 3 sky130_fd_sc_hd__clkinv_2
* cell instance $997 m0 *1 25.3,73.44
X$997 65 553 3 65 571 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1000 m0 *1 30.36,73.44
X$1000 3 606 630 616 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1003 m0 *1 35.88,73.44
X$1003 3 274 608 617 609 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1005 m0 *1 41.86,73.44
X$1005 3 136 617 458 609 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1007 m0 *1 52.9,73.44
X$1007 3 612 595 613 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $1010 m0 *1 57.5,73.44
X$1010 65 596 87 611 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $1012 m0 *1 59.8,73.44
X$1012 65 619 3 65 610 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1013 m0 *1 63.48,73.44
X$1013 3 513 610 597 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $1015 m0 *1 67.62,73.44
X$1015 3 82 622 466 621 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1016 m0 *1 76.82,73.44
X$1016 65 556 3 65 605 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1017 m0 *1 80.5,73.44
X$1017 3 598 605 665 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $1019 m0 *1 84.64,73.44
X$1019 65 583 3 65 624 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1021 m0 *1 89.24,73.44
X$1021 65 604 65 3 424 3 sky130_fd_sc_hd__buf_4
* cell instance $1022 m0 *1 92,73.44
X$1022 65 601 3 65 599 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1023 r0 *1 1.38,73.44
X$1023 65 572 3 65 590 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1025 r0 *1 5.98,73.44
X$1025 3 424 645 530 644 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1030 r0 *1 17.02,73.44
X$1030 3 628 646 582 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1031 r0 *1 21.16,73.44
X$1031 3 424 616 530 606 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1033 r0 *1 30.82,73.44
X$1033 65 629 3 65 630 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1035 r0 *1 34.96,73.44
X$1035 65 631 3 65 652 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1041 r0 *1 45.08,73.44
X$1041 3 136 637 458 632 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1042 r0 *1 54.28,73.44
X$1042 65 618 3 65 613 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1043 r0 *1 57.96,73.44
X$1043 65 633 3 65 595 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1044 r0 *1 61.64,73.44
X$1044 65 596 3 65 625 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1045 r0 *1 65.32,73.44
X$1045 65 620 3 65 627 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1047 r0 *1 69,73.44
X$1047 65 583 87 607 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $1049 r0 *1 70.84,73.44
X$1049 65 649 3 65 597 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1050 r0 *1 74.52,73.44
X$1050 3 274 648 622 621 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1053 r0 *1 81.42,73.44
X$1053 3 82 439 466 626 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1055 r0 *1 91.54,73.44
X$1055 65 515 3 65 660 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1066 m0 *1 4.6,78.88
X$1066 3 642 643 593 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1067 m0 *1 8.74,78.88
X$1067 3 644 662 645 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1068 m0 *1 12.88,78.88
X$1068 65 634 3 65 646 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1069 m0 *1 16.56,78.88
X$1069 3 664 743 666 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1071 m0 *1 21.16,78.88
X$1071 65 424 65 3 82 3 sky130_fd_sc_hd__buf_4
* cell instance $1073 m0 *1 24.84,78.88
X$1073 3 647 686 636 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1075 m0 *1 29.44,78.88
X$1075 65 636 3 65 673 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1077 m0 *1 36.8,78.88
X$1077 3 424 631 458 674 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1079 m0 *1 46.92,78.88
X$1079 3 274 675 637 632 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1081 m0 *1 52.9,78.88
X$1081 65 638 3 65 668 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1084 m0 *1 57.5,78.88
X$1084 3 424 658 458 656 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1085 m0 *1 66.7,78.88
X$1085 65 639 3 65 672 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1086 m0 *1 70.38,78.88
X$1086 65 650 3 65 670 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1087 m0 *1 74.06,78.88
X$1087 65 651 3 65 648 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1088 m0 *1 77.74,78.88
X$1088 65 622 3 65 623 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1090 m0 *1 82.34,78.88
X$1090 65 87 640 641 65 574 3 3 sky130_fd_sc_hd__o21ai_0
* cell instance $1092 m0 *1 84.64,78.88
X$1092 3 274 708 439 626 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1093 m0 *1 90.16,78.88
X$1093 65 579 87 641 65 3 3 sky130_fd_sc_hd__nand2_1
* cell instance $1095 m0 *1 92,78.88
X$1095 3 640 747 661 88 65 65 3 sky130_fd_sc_hd__mux2i_1
* cell instance $1097 r0 *1 2.3,78.88
X$1097 65 593 3 65 615 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1098 r0 *1 5.98,78.88
X$1098 3 424 444 530 663 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1101 r0 *1 15.64,78.88
X$1101 3 424 666 530 664 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1102 r0 *1 24.84,78.88
X$1102 3 424 636 530 647 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1105 r0 *1 36.34,78.88
X$1105 3 274 691 631 674 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1110 r0 *1 44.16,78.88
X$1110 65 654 3 65 675 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1111 r0 *1 47.84,78.88
X$1111 3 424 676 458 655 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1113 r0 *1 58.88,78.88
X$1113 3 274 719 676 655 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1114 r0 *1 64.4,78.88
X$1114 3 274 657 658 656 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1118 r0 *1 70.84,78.88
X$1118 65 658 3 65 671 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1121 r0 *1 75.9,78.88
X$1121 65 669 3 65 665 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1122 r0 *1 79.58,78.88
X$1122 3 82 496 466 667 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1124 r0 *1 89.7,78.88
X$1124 65 600 3 65 661 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1133 m0 *1 1.38,84.32
X$1133 65 635 3 65 662 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1134 m0 *1 5.06,84.32
X$1134 65 645 3 65 653 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1135 m0 *1 8.74,84.32
X$1135 3 663 443 444 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1137 m0 *1 13.8,84.32
X$1137 3 424 405 415 684 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1140 m0 *1 25.3,84.32
X$1140 65 685 3 65 686 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1143 m0 *1 29.9,84.32
X$1143 65 616 3 65 761 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1144 m0 *1 33.58,84.32
X$1144 65 677 3 65 608 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1145 m0 *1 37.26,84.32
X$1145 65 692 3 65 691 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1148 m0 *1 42.32,84.32
X$1148 65 617 3 65 696 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1151 m0 *1 47.38,84.32
X$1151 65 637 3 65 695 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1152 m0 *1 51.06,84.32
X$1152 3 274 679 700 693 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1154 m0 *1 57.04,84.32
X$1154 65 694 3 65 679 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1155 m0 *1 60.72,84.32
X$1155 65 680 3 65 682 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1158 m0 *1 66.7,84.32
X$1158 65 676 3 65 690 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1160 m0 *1 70.84,84.32
X$1160 65 688 3 65 689 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1161 m0 *1 74.52,84.32
X$1161 65 687 3 65 702 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1163 m0 *1 78.66,84.32
X$1163 3 274 681 496 667 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1165 m0 *1 84.64,84.32
X$1165 3 82 680 466 683 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1169 r0 *1 5.98,84.32
X$1169 3 424 705 530 742 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1174 r0 *1 17.94,84.32
X$1174 65 666 3 65 698 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1176 r0 *1 22.08,84.32
X$1176 3 424 709 530 706 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1179 r0 *1 33.58,84.32
X$1179 3 424 678 530 712 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1182 r0 *1 43.24,84.32
X$1182 65 678 3 65 716 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1184 r0 *1 48.76,84.32
X$1184 3 718 756 699 274 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1185 r0 *1 52.9,84.32
X$1185 3 424 700 458 693 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1186 r0 *1 62.1,84.32
X$1186 65 700 3 65 703 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1187 r0 *1 65.78,84.32
X$1187 65 701 3 65 715 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1192 r0 *1 71.3,84.32
X$1192 3 424 650 466 713 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1193 r0 *1 80.5,84.32
X$1193 65 707 3 65 708 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1195 r0 *1 86.02,84.32
X$1195 3 274 463 680 683 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1197 r0 *1 92,84.32
X$1197 65 741 65 604 3 3 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1204 m0 *1 1.38,89.76
X$1204 3 424 594 415 724 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1205 m0 *1 10.58,89.76
X$1205 3 684 720 405 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1206 m0 *1 14.72,89.76
X$1206 3 424 722 530 744 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1207 m0 *1 23.92,89.76
X$1207 3 706 725 709 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1210 m0 *1 29.44,89.76
X$1210 3 710 749 727 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1213 m0 *1 36.34,89.76
X$1213 3 424 714 530 728 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1215 m0 *1 47.38,89.76
X$1215 3 424 699 458 718 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1218 m0 *1 57.5,89.76
X$1218 65 732 3 65 719 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1220 m0 *1 61.64,89.76
X$1220 3 274 717 701 757 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1221 m0 *1 67.16,89.76
X$1221 3 274 702 650 713 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1223 m0 *1 73.6,89.76
X$1223 3 424 518 466 711 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1228 m0 *1 85.56,89.76
X$1228 3 274 672 620 726 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1230 m0 *1 91.54,89.76
X$1230 65 723 3 65 681 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1233 r0 *1 1.84,89.76
X$1233 65 614 3 65 643 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1234 r0 *1 5.52,89.76
X$1234 3 274 551 594 724 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1235 r0 *1 11.04,89.76
X$1235 3 742 581 705 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1238 r0 *1 15.64,89.76
X$1238 3 744 721 722 92 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1240 r0 *1 20.7,89.76
X$1240 65 722 3 65 746 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1243 r0 *1 25.76,89.76
X$1243 3 424 727 530 710 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1244 r0 *1 34.96,89.76
X$1244 65 730 3 65 729 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1245 r0 *1 38.64,89.76
X$1245 3 728 729 714 274 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1249 r0 *1 45.08,89.76
X$1249 3 424 738 458 752 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1252 r0 *1 57.04,89.76
X$1252 3 424 701 458 757 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1253 r0 *1 66.24,89.76
X$1253 65 764 3 65 717 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1257 r0 *1 70.84,89.76
X$1257 3 274 689 518 711 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1259 r0 *1 77.28,89.76
X$1259 3 424 638 466 731 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1260 r0 *1 86.48,89.76
X$1260 3 424 620 466 726 65 65 3 sky130_fd_sc_hd__dfrtp_1
* cell instance $1269 m0 *1 4.14,95.2
X$1269 65 733 3 65 721 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1270 m0 *1 7.82,95.2
X$1270 65 705 3 65 758 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1271 m0 *1 11.5,95.2
X$1271 65 734 3 65 743 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1273 m0 *1 15.64,95.2
X$1273 65 709 3 65 759 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1276 m0 *1 20.7,95.2
X$1276 65 745 3 65 725 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1278 m0 *1 24.84,95.2
X$1278 65 727 3 65 760 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1281 m0 *1 29.44,95.2
X$1281 65 748 3 65 749 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1284 m0 *1 34.5,95.2
X$1284 65 736 3 65 751 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1285 m0 *1 38.18,95.2
X$1285 3 712 751 678 274 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1288 m0 *1 43.24,95.2
X$1288 65 714 3 65 762 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1289 m0 *1 46.92,95.2
X$1289 65 755 3 65 756 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1290 m0 *1 50.6,95.2
X$1290 3 752 737 738 274 65 65 3 sky130_fd_sc_hd__mux2_2
* cell instance $1293 m0 *1 57.04,95.2
X$1293 65 699 3 65 763 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1294 m0 *1 60.72,95.2
X$1294 65 739 3 65 737 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1295 m0 *1 64.4,95.2
X$1295 65 738 3 65 754 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1299 m0 *1 70.84,95.2
X$1299 65 753 3 65 657 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1302 m0 *1 76.82,95.2
X$1302 3 274 740 638 731 65 65 3 sky130_fd_sc_hd__mux2_4
* cell instance $1305 m0 *1 84.64,95.2
X$1305 65 750 3 65 740 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1306 m0 *1 88.32,95.2
X$1306 65 704 3 65 747 3 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1307 m0 *1 92,95.2
X$1307 65 579 3 65 659 3 sky130_fd_sc_hd__clkdlybuf4s50_1
.ENDS wishbone_master

* cell sky130_fd_sc_hd__buf_2
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__buf_2 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.125 pfet_01v8_hvt
M$1 2 3 6 1 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P AD=166400000000P
+ PS=1325000U PD=1800000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=284000000000P
+ AD=400000000000P PS=2595000U PD=3800000U
* device instance $4 r0 *1 0.47,0.445 nfet_01v8
M$4 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $5 r0 *1 0.945,0.56 nfet_01v8
M$5 5 2 4 7 nfet_01v8 L=150000U W=1300000U AS=184750000000P AD=260000000000P
+ PS=1895000U PD=2750000U
.ENDS sky130_fd_sc_hd__buf_2

* cell sky130_fd_sc_hd__inv_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__inv_8 1 2 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.635,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=8000000U AS=1.205e+12P AD=1.205e+12P
+ PS=11410000U PD=11410000U
* device instance $9 r0 *1 0.635,0.56 nfet_01v8
M$9 3 2 1 6 nfet_01v8 L=150000U W=5200000U AS=783250000000P AD=783250000000P
+ PS=8260000U PD=8260000U
.ENDS sky130_fd_sc_hd__inv_8

* cell sky130_fd_sc_hd__o21ai_4
* pin VGND
* pin A2
* pin B1
* pin A1
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_4 1 2 3 5 6 7 8 10
* net 1 VGND
* net 2 A2
* net 3 B1
* net 5 A1
* net 6 Y
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.5,1.985 pfet_01v8_hvt
M$1 9 5 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=580000000000P PS=6370000U PD=5160000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 2 9 8 pfet_01v8_hvt L=150000U W=4000000U AS=560000000000P
+ AD=560000000000P PS=5120000U PD=5120000U
* device instance $9 r0 *1 3.98,1.985 pfet_01v8_hvt
M$9 6 3 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=580000000000P
+ AD=685000000000P PS=5160000U PD=6370000U
* device instance $13 r0 *1 0.5,0.56 nfet_01v8
M$13 1 5 4 10 nfet_01v8 L=150000U W=2600000U AS=458250000000P AD=364000000000P
+ PS=4660000U PD=3720000U
* device instance $16 r0 *1 1.79,0.56 nfet_01v8
M$16 4 2 1 10 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=377000000000P
+ PS=3720000U PD=3760000U
* device instance $21 r0 *1 3.98,0.56 nfet_01v8
M$21 6 3 4 10 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=458250000000P
+ PS=3720000U PD=4660000U
.ENDS sky130_fd_sc_hd__o21ai_4

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__a41oi_1
* pin VGND
* pin Y
* pin A3
* pin A2
* pin B1
* pin A4
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_1 1 2 3 4 8 9 10 11 12 14
* net 1 VGND
* net 2 Y
* net 3 A3
* net 4 A2
* net 8 B1
* net 9 A4
* net 10 A1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 13 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=212500000000P PS=2520000U PD=1425000U
* device instance $2 r0 *1 1.045,1.985 pfet_01v8_hvt
M$2 11 9 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=205000000000P PS=1425000U PD=1410000U
* device instance $3 r0 *1 1.605,1.985 pfet_01v8_hvt
M$3 13 3 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=155000000000P PS=1410000U PD=1310000U
* device instance $4 r0 *1 2.065,1.985 pfet_01v8_hvt
M$4 11 4 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=212500000000P PS=1310000U PD=1425000U
* device instance $5 r0 *1 2.64,1.985 pfet_01v8_hvt
M$5 13 10 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=370000000000P PS=1425000U PD=2740000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 8 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=169000000000P
+ PS=1175000U PD=1820000U
* device instance $7 r0 *1 1.105,0.56 nfet_01v8
M$7 5 9 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=113750000000P
+ PS=1175000U PD=1000000U
* device instance $8 r0 *1 1.605,0.56 nfet_01v8
M$8 7 3 5 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $9 r0 *1 2.065,0.56 nfet_01v8
M$9 6 4 7 14 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=138125000000P
+ PS=960000U PD=1075000U
* device instance $10 r0 *1 2.64,0.56 nfet_01v8
M$10 2 10 6 14 nfet_01v8 L=150000U W=650000U AS=138125000000P AD=240500000000P
+ PS=1075000U PD=2040000U
.ENDS sky130_fd_sc_hd__a41oi_1

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__nor4b_4
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_4 1 3 4 6 7 8 9 12 13
* net 1 VGND
* net 3 Y
* net 4 A
* net 6 B
* net 7 C
* net 8 D_N
* net 9 VPWR
* net 12 VPB
* device instance $1 r0 *1 8.23,1.985 pfet_01v8_hvt
M$1 9 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=280000000000P PS=2520000U PD=2560000U
* device instance $2 r0 *1 4.35,1.985 pfet_01v8_hvt
M$2 10 7 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $6 r0 *1 6.03,1.985 pfet_01v8_hvt
M$6 3 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $10 r0 *1 0.47,1.985 pfet_01v8_hvt
M$10 9 4 5 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $14 r0 *1 2.15,1.985 pfet_01v8_hvt
M$14 10 6 5 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $18 r0 *1 8.23,0.56 nfet_01v8
M$18 1 8 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=182000000000P
+ PS=1820000U PD=1860000U
* device instance $19 r0 *1 0.47,0.56 nfet_01v8
M$19 3 4 1 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $23 r0 *1 2.15,0.56 nfet_01v8
M$23 3 6 1 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $27 r0 *1 4.35,0.56 nfet_01v8
M$27 3 7 1 13 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $31 r0 *1 6.03,0.56 nfet_01v8
M$31 3 2 1 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor4b_4

* cell sky130_fd_sc_hd__nor3b_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_2 1 2 3 4 6 9 10 11
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 6 C_N
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 2 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=415000000000P PS=3830000U PD=3830000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 9 3 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 4.13,1.695 pfet_01v8_hvt
M$7 9 6 5 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $8 r0 *1 4.13,0.675 nfet_01v8
M$8 1 6 5 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=269750000000P
+ PS=2740000U PD=2780000U
* device instance $11 r0 *1 0.49,0.56 nfet_01v8
M$11 2 3 1 11 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $13 r0 *1 1.33,0.56 nfet_01v8
M$13 2 4 1 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3b_2

* cell sky130_fd_sc_hd__a211oi_1
* pin VPB
* pin A2
* pin A1
* pin C1
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A2
* net 3 A1
* net 4 C1
* net 5 B1
* net 6 VGND
* net 7 Y
* net 9 VPWR
* device instance $1 r0 *1 0.62,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.05,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 1.48,1.985 pfet_01v8_hvt
M$3 11 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 1.94,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.62,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=266500000000P AD=91000000000P
+ PS=2120000U PD=930000U
* device instance $6 r0 *1 1.05,0.56 nfet_01v8
M$6 7 3 12 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $7 r0 *1 1.48,0.56 nfet_01v8
M$7 6 5 7 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $8 r0 *1 1.94,0.56 nfet_01v8
M$8 7 4 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211oi_1

* cell sky130_fd_sc_hd__a221oi_2
* pin VGND
* pin C1
* pin Y
* pin B2
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_2 1 2 3 4 6 7 9 10 11 14
* net 1 VGND
* net 2 C1
* net 3 Y
* net 4 B2
* net 6 B1
* net 7 A2
* net 9 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.84,1.985 pfet_01v8_hvt
M$1 12 4 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=310000000000P PS=3790000U PD=2620000U
* device instance $2 r0 *1 2.26,1.985 pfet_01v8_hvt
M$2 13 6 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 3.6,1.985 pfet_01v8_hvt
M$5 10 7 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=310000000000P
+ AD=420000000000P PS=2620000U PD=3840000U
* device instance $6 r0 *1 4.02,1.985 pfet_01v8_hvt
M$6 13 9 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 0.48,1.985 pfet_01v8_hvt
M$9 3 2 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=395000000000P PS=3810000U PD=3790000U
* device instance $11 r0 *1 0.48,0.56 nfet_01v8
M$11 3 2 1 14 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=344500000000P
+ PS=2760000U PD=2360000U
* device instance $13 r0 *1 1.84,0.56 nfet_01v8
M$13 5 4 1 14 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=201500000000P
+ PS=2360000U PD=1920000U
* device instance $14 r0 *1 2.26,0.56 nfet_01v8
M$14 3 6 5 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 3.6,0.56 nfet_01v8
M$17 8 7 1 14 nfet_01v8 L=150000U W=1300000U AS=201500000000P AD=256750000000P
+ PS=1920000U PD=2740000U
* device instance $18 r0 *1 4.02,0.56 nfet_01v8
M$18 3 9 8 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
.ENDS sky130_fd_sc_hd__a221oi_2

* cell sky130_fd_sc_hd__nand3b_1
* pin VPB
* pin A_N
* pin C
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand3b_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A_N
* net 3 C
* net 4 B
* net 5 Y
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 8 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 8 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 5 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=280000000000P PS=1385000U PD=2560000U
* device instance $5 r0 *1 0.6,0.675 nfet_01v8
M$5 6 2 7 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $6 r0 *1 1.085,0.56 nfet_01v8
M$6 11 3 7 9 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $7 r0 *1 1.505,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $8 r0 *1 2.04,0.56 nfet_01v8
M$8 5 6 10 9 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=182000000000P
+ PS=1035000U PD=1860000U
.ENDS sky130_fd_sc_hd__nand3b_1

* cell sky130_fd_sc_hd__a221oi_1
* pin VGND
* pin Y
* pin B1
* pin A1
* pin C1
* pin B2
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_1 1 2 3 4 5 6 7 10 11 14
* net 1 VGND
* net 2 Y
* net 3 B1
* net 4 A1
* net 5 C1
* net 6 B2
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 13 4 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=152500000000P PS=2520000U PD=1305000U
* device instance $2 r0 *1 2.705,1.985 pfet_01v8_hvt
M$2 11 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=305000000000P PS=1305000U PD=2610000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 12 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 13 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 12 3 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 2.25,0.56 nfet_01v8
M$6 9 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=99125000000P
+ PS=1820000U PD=955000U
* device instance $7 r0 *1 2.705,0.56 nfet_01v8
M$7 1 7 9 14 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=198250000000P
+ PS=955000U PD=1910000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $9 r0 *1 0.945,0.56 nfet_01v8
M$9 8 6 1 14 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=69875000000P
+ PS=975000U PD=865000U
* device instance $10 r0 *1 1.31,0.56 nfet_01v8
M$10 2 3 8 14 nfet_01v8 L=150000U W=650000U AS=69875000000P AD=169000000000P
+ PS=865000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221oi_1

* cell sky130_fd_sc_hd__nand4_1
* pin VPB
* pin C
* pin A
* pin B
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 C
* net 3 A
* net 4 B
* net 5 D
* net 6 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=300000000000P PS=1330000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 5 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 11 2 12 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.79,0.56 nfet_01v8
M$8 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=195000000000P
+ PS=980000U PD=1900000U
.ENDS sky130_fd_sc_hd__nand4_1

* cell sky130_fd_sc_hd__o22ai_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 7 Y
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=112500000000P PS=2520000U PD=1225000U
* device instance $2 r0 *1 0.845,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=232500000000P PS=1225000U PD=1465000U
* device instance $3 r0 *1 1.46,1.985 pfet_01v8_hvt
M$3 11 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=232500000000P
+ AD=105000000000P PS=1465000U PD=1210000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=270000000000P PS=1210000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=92625000000P
+ PS=1820000U PD=935000U
* device instance $6 r0 *1 0.905,0.56 nfet_01v8
M$6 6 3 7 10 nfet_01v8 L=150000U W=650000U AS=92625000000P AD=115375000000P
+ PS=935000U PD=1005000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 8 4 6 10 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=87750000000P
+ PS=1005000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 5 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22ai_1

* cell sky130_fd_sc_hd__nor3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 6 4 5 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $6 r0 *1 1.31,0.56 nfet_01v8
M$6 6 2 5 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor3_1

* cell sky130_fd_sc_hd__and2_1
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_1 1 2 3 4 5 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 X
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.65,2.065 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $2 r0 *1 1.07,2.065 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=166550000000P AD=56700000000P
+ PS=1390000U PD=690000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=166550000000P
+ AD=475000000000P PS=1390000U PD=2950000U
* device instance $4 r0 *1 0.65,0.585 nfet_01v8
M$4 9 2 6 8 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $5 r0 *1 1.07,0.585 nfet_01v8
M$5 9 3 7 8 nfet_01v8 L=150000U W=420000U AS=111800000000P AD=56700000000P
+ PS=1040000U PD=690000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 4 6 7 8 nfet_01v8 L=150000U W=650000U AS=111800000000P AD=182000000000P
+ PS=1040000U PD=1860000U
.ENDS sky130_fd_sc_hd__and2_1

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__o31ai_1
* pin VPB
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 B1
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=392500000000P PS=1270000U PD=1785000U
* device instance $4 r0 *1 2.245,1.985 pfet_01v8_hvt
M$4 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=392500000000P
+ AD=300000000000P PS=1785000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 8 2 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 7 3 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 8 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $8 r0 *1 2.07,0.56 nfet_01v8
M$8 9 5 8 10 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=221000000000P
+ PS=1260000U PD=1980000U
.ENDS sky130_fd_sc_hd__o31ai_1

* cell sky130_fd_sc_hd__o21ai_1
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 VGND
* net 8 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 8 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=174000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.37,2.135 pfet_01v8_hvt
M$3 5 3 8 1 pfet_01v8_hvt L=150000U W=700000U AS=174000000000P AD=182000000000P
+ PS=1390000U PD=1920000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $5 r0 *1 0.95,0.56 nfet_01v8
M$5 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 8 3 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21ai_1

* cell sky130_fd_sc_hd__nand2_2
* pin VGND
* pin
* pin B
* pin Y
* pin A
* pin VPB
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nand2_2 1 2 4 5 6 7 8
* net 1 VGND
* net 4 B
* net 5 Y
* net 6 A
* net 7 VPB
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 5 6 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 1 4 3 2 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 5 6 3 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand2_2

* cell sky130_fd_sc_hd__inv_6
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__inv_6 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 3 2 4 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.105e+12P AD=945000000000P
+ PS=9210000U PD=8890000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 3 2 5 6 nfet_01v8 L=150000U W=3900000U AS=685750000000P AD=614250000000P
+ PS=6660000U PD=6440000U
.ENDS sky130_fd_sc_hd__inv_6

* cell sky130_fd_sc_hd__clkinv_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_2 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 4 2 3 1 pfet_01v8_hvt L=150000U W=3000000U AS=545000000000P
+ AD=545000000000P PS=5090000U PD=5090000U
* device instance $4 r0 *1 0.94,0.445 nfet_01v8
M$4 3 2 5 6 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=168000000000P
+ PS=2070000U PD=2060000U
.ENDS sky130_fd_sc_hd__clkinv_2

* cell sky130_fd_sc_hd__clkinv_4
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_4 1 2 3 5 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 Y
* net 5 VPWR
* device instance $1 r0 *1 0.515,1.985 pfet_01v8_hvt
M$1 4 2 5 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.005e+12P AD=1.045e+12P
+ PS=9010000U PD=9090000U
* device instance $7 r0 *1 0.945,0.445 nfet_01v8
M$7 4 2 3 6 nfet_01v8 L=150000U W=1680000U AS=315000000000P AD=342300000000P
+ PS=3600000U PD=3730000U
.ENDS sky130_fd_sc_hd__clkinv_4

* cell sky130_fd_sc_hd__mux2_2
* pin VGND
* pin X
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_2 1 2 4 5 6 10 11 14
* net 1 VGND
* net 2 X
* net 4 A0
* net 5 A1
* net 6 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=312800000000P PS=3790000U PD=2685000U
* device instance $3 r0 *1 1.455,2.165 pfet_01v8_hvt
M$3 12 9 10 11 pfet_01v8_hvt L=150000U W=640000U AS=177800000000P
+ AD=228800000000P PS=1415000U PD=1355000U
* device instance $4 r0 *1 2.32,2.165 pfet_01v8_hvt
M$4 3 5 12 11 pfet_01v8_hvt L=150000U W=640000U AS=228800000000P
+ AD=131200000000P PS=1355000U PD=1050000U
* device instance $5 r0 *1 2.88,2.165 pfet_01v8_hvt
M$5 13 4 3 11 pfet_01v8_hvt L=150000U W=640000U AS=131200000000P
+ AD=67200000000P PS=1050000U PD=850000U
* device instance $6 r0 *1 3.24,2.165 pfet_01v8_hvt
M$6 10 6 13 11 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P
+ AD=86400000000P PS=850000U PD=910000U
* device instance $7 r0 *1 3.66,2.165 pfet_01v8_hvt
M$7 9 6 10 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=172800000000P PS=910000U PD=1820000U
* device instance $8 r0 *1 1.365,0.445 nfet_01v8
M$8 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=68250000000P
+ PS=975000U PD=745000U
* device instance $9 r0 *1 1.84,0.445 nfet_01v8
M$9 3 4 7 14 nfet_01v8 L=150000U W=420000U AS=68250000000P AD=173250000000P
+ PS=745000U PD=1245000U
* device instance $10 r0 *1 2.815,0.445 nfet_01v8
M$10 8 5 3 14 nfet_01v8 L=150000U W=420000U AS=173250000000P AD=57750000000P
+ PS=1245000U PD=695000U
* device instance $11 r0 *1 3.24,0.445 nfet_01v8
M$11 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=57750000000P AD=56700000000P
+ PS=695000U PD=690000U
* device instance $12 r0 *1 3.66,0.445 nfet_01v8
M$12 9 6 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=113400000000P
+ PS=690000U PD=1380000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 2 3 1 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=184750000000P
+ PS=2740000U PD=1895000U
.ENDS sky130_fd_sc_hd__mux2_2

* cell sky130_fd_sc_hd__dlygate4sd3_1
* pin VPB
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 1 3 5 7 8 9
* net 1 VPB
* net 3 A
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.465,2.275 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=500000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 7 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.58,2.275 pfet_01v8_hvt
M$3 5 3 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 1.175,2.275 pfet_01v8_hvt
M$4 2 4 5 1 pfet_01v8_hvt L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 2.465,0.445 nfet_01v8
M$5 8 2 6 9 nfet_01v8 L=500000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $6 r0 *1 3.115,0.56 nfet_01v8
M$6 7 6 8 9 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $7 r0 *1 0.58,0.445 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 1.175,0.445 nfet_01v8
M$8 2 4 8 9 nfet_01v8 L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd3_1

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 0.47,0.445 nfet_01v8
M$16 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 0.89,0.445 nfet_01v8
M$17 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $18 r0 *1 2.64,0.415 nfet_01v8
M$18 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $19 r0 *1 3.12,0.415 nfet_01v8
M$19 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $20 r0 *1 5.465,0.415 nfet_01v8
M$20 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $21 r0 *1 6.01,0.415 nfet_01v8
M$21 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $22 r0 *1 2.165,0.445 nfet_01v8
M$22 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $23 r0 *1 3.95,0.445 nfet_01v8
M$23 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $24 r0 *1 4.31,0.445 nfet_01v8
M$24 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $25 r0 *1 6.49,0.445 nfet_01v8
M$25 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $26 r0 *1 7.235,0.445 nfet_01v8
M$26 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $27 r0 *1 7.69,0.445 nfet_01v8
M$27 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $28 r0 *1 4.97,0.555 nfet_01v8
M$28 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__buf_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__buf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VPWR
* net 5 VGND
* net 6 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 5 3 2 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 6 2 5 7 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__buf_4

* cell sky130_fd_sc_hd__clkdlybuf4s50_1
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkdlybuf4s50_1 1 2 4 7 8 9
* net 1 VPB
* net 2 A
* net 4 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 2.465,2.075 pfet_01v8_hvt
M$1 6 5 7 1 pfet_01v8_hvt L=500000U W=820000U AS=155750000000P AD=217300000000P
+ PS=1325000U PD=2170000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=155750000000P
+ AD=355000000000P PS=1325000U PD=2710000U
* device instance $3 r0 *1 0.48,1.985 pfet_01v8_hvt
M$3 7 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=170100000000P PS=2540000U PD=1360000U
* device instance $4 r0 *1 1.165,2.075 pfet_01v8_hvt
M$4 5 3 7 1 pfet_01v8_hvt L=500000U W=820000U AS=170100000000P AD=217300000000P
+ PS=1360000U PD=2170000U
* device instance $5 r0 *1 3.115,0.445 nfet_01v8
M$5 8 6 4 9 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=149100000000P
+ PS=975000U PD=1550000U
* device instance $6 r0 *1 2.465,0.56 nfet_01v8
M$6 4 5 6 9 nfet_01v8 L=500000U W=650000U AS=172250000000P AD=97000000000P
+ PS=1830000U PD=975000U
* device instance $7 r0 *1 0.48,0.445 nfet_01v8
M$7 4 2 3 9 nfet_01v8 L=150000U W=420000U AS=113400000000P AD=104350000000P
+ PS=1380000U PD=1010000U
* device instance $8 r0 *1 1.165,0.56 nfet_01v8
M$8 5 3 4 9 nfet_01v8 L=500000U W=650000U AS=104350000000P AD=169000000000P
+ PS=1010000U PD=1820000U
.ENDS sky130_fd_sc_hd__clkdlybuf4s50_1

* cell sky130_fd_sc_hd__clkbuf_8
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_8 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 1.335,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.12e+12P AD=1.245e+12P
+ PS=10240000U PD=11490000U
* device instance $11 r0 *1 0.475,0.445 nfet_01v8
M$11 3 2 1 7 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=117600000000P
+ PS=2070000U PD=1400000U
* device instance $13 r0 *1 1.335,0.445 nfet_01v8
M$13 4 3 1 7 nfet_01v8 L=150000U W=3360000U AS=470400000000P AD=525000000000P
+ PS=5600000U PD=6280000U
.ENDS sky130_fd_sc_hd__clkbuf_8

* cell sky130_fd_sc_hd__ha_1
* pin VGND
* pin SUM
* pin COUT
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_1 1 2 5 8 9 10 11 13
* net 1 VGND
* net 2 SUM
* net 5 COUT
* net 8 A
* net 9 B
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=236050000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,2.275 pfet_01v8_hvt
M$2 3 7 10 11 pfet_01v8_hvt L=150000U W=420000U AS=236050000000P
+ AD=56700000000P PS=1765000U PD=690000U
* device instance $3 r0 *1 1.805,2.275 pfet_01v8_hvt
M$3 12 9 3 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=84000000000P
+ PS=690000U PD=820000U
* device instance $4 r0 *1 2.355,2.275 pfet_01v8_hvt
M$4 10 8 12 11 pfet_01v8_hvt L=150000U W=420000U AS=84000000000P
+ AD=149100000000P PS=820000U PD=1130000U
* device instance $5 r0 *1 3.215,2.275 pfet_01v8_hvt
M$5 7 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=149100000000P
+ AD=60900000000P PS=1130000U PD=710000U
* device instance $6 r0 *1 3.655,2.275 pfet_01v8_hvt
M$6 7 8 10 11 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=60900000000P PS=1325000U PD=710000U
* device instance $7 r0 *1 4.13,1.985 pfet_01v8_hvt
M$7 5 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $8 r0 *1 3.295,0.445 nfet_01v8
M$8 6 9 7 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 3.655,0.445 nfet_01v8
M$9 1 8 6 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $10 r0 *1 4.13,0.56 nfet_01v8
M$10 5 7 1 13 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 1.41,0.445 nfet_01v8
M$11 4 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $12 r0 *1 1.83,0.445 nfet_01v8
M$12 1 9 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $13 r0 *1 2.25,0.445 nfet_01v8
M$13 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__ha_1

* cell sky130_fd_sc_hd__mux2_4
* pin VGND
* pin S
* pin A0
* pin A1
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_4 1 3 4 6 7 10 11 14
* net 1 VGND
* net 3 S
* net 4 A0
* net 6 A1
* net 7 X
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.37,1.985 pfet_01v8_hvt
M$1 10 3 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 3.79,1.985 pfet_01v8_hvt
M$2 7 5 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 1.905,1.985 pfet_01v8_hvt
M$6 5 4 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=160000000000P PS=2520000U PD=1320000U
* device instance $7 r0 *1 2.375,1.985 pfet_01v8_hvt
M$7 12 6 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=300000000000P PS=1320000U PD=2600000U
* device instance $8 r0 *1 0.47,1.985 pfet_01v8_hvt
M$8 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=162500000000P PS=2520000U PD=1325000U
* device instance $9 r0 *1 0.945,1.985 pfet_01v8_hvt
M$9 12 2 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=280000000000P PS=1325000U PD=2560000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 3 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=108875000000P
+ PS=1820000U PD=985000U
* device instance $11 r0 *1 0.955,0.56 nfet_01v8
M$11 8 2 1 14 nfet_01v8 L=150000U W=650000U AS=108875000000P AD=260000000000P
+ PS=985000U PD=1450000U
* device instance $12 r0 *1 1.905,0.56 nfet_01v8
M$12 5 4 8 14 nfet_01v8 L=150000U W=650000U AS=260000000000P AD=104000000000P
+ PS=1450000U PD=970000U
* device instance $13 r0 *1 2.375,0.56 nfet_01v8
M$13 9 6 5 14 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=274625000000P
+ PS=970000U PD=1495000U
* device instance $14 r0 *1 3.37,0.56 nfet_01v8
M$14 1 3 9 14 nfet_01v8 L=150000U W=650000U AS=274625000000P AD=87750000000P
+ PS=1495000U PD=920000U
* device instance $15 r0 *1 3.79,0.56 nfet_01v8
M$15 7 5 1 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__mux2_4

* cell sky130_fd_sc_hd__mux2i_1
* pin VGND
* pin Y
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_1 1 3 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 6 A0
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.21,1.985 pfet_01v8_hvt
M$1 10 8 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=260000000000P PS=2580000U PD=2520000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 3 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=152500000000P PS=2560000U PD=1305000U
* device instance $3 r0 *1 0.945,1.985 pfet_01v8_hvt
M$3 12 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=197500000000P PS=1305000U PD=1395000U
* device instance $4 r0 *1 1.49,1.985 pfet_01v8_hvt
M$4 10 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=300000000000P PS=1395000U PD=1600000U
* device instance $5 r0 *1 2.24,1.985 pfet_01v8_hvt
M$5 9 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=260000000000P PS=1600000U PD=2520000U
* device instance $6 r0 *1 3.21,0.56 nfet_01v8
M$6 1 8 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $7 r0 *1 1.85,0.56 nfet_01v8
M$7 1 5 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.27,0.56 nfet_01v8
M$8 4 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 6 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $10 r0 *1 0.89,0.56 nfet_01v8
M$10 4 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
.ENDS sky130_fd_sc_hd__mux2i_1

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1
