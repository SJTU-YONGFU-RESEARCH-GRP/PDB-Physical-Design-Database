* cell wishbone_master
* pin write_done
* pin wb_we_o
* pin write_err
* pin write_data[10]
* pin wb_dat_o[10]
* pin write_data[16]
* pin wb_sel_o[1]
* pin wb_cyc_o
* pin write_sel[3]
* pin wb_dat_o[16]
* pin wb_sel_o[3]
* pin read_sel[3]
* pin write_sel[1]
* pin wb_stb_o
* pin write_data[13]
* pin write_data[11]
* pin read_sel[1]
* pin wb_dat_o[11]
* pin wb_dat_o[13]
* pin wb_adr_o[9]
* pin write_data[0]
* pin wb_dat_o[0]
* pin wb_dat_o[15]
* pin write_data[15]
* pin write_addr[9]
* pin write_data[14]
* pin write_data[12]
* pin read_addr[9]
* pin write_addr[8]
* pin wb_adr_o[8]
* pin write_sel[2]
* pin read_addr[8]
* pin wb_sel_o[2]
* pin read_sel[2]
* pin wb_dat_o[14]
* pin wb_dat_o[12]
* pin write_sel[0]
* pin wb_sel_o[0]
* pin read_sel[0]
* pin wb_adr_o[0]
* pin wb_adr_o[17]
* pin rst_n
* pin write_addr[13]
* pin wb_adr_o[13]
* pin read_addr[13]
* pin write_addr[14]
* pin write_addr[0]
* pin wb_adr_o[14]
* pin read_addr[14]
* pin write_addr[17]
* pin read_addr[0]
* pin read_addr[17]
* pin wb_adr_o[18]
* pin wb_adr_o[10]
* pin write_addr[10]
* pin write_addr[16]
* pin write_addr[18]
* pin wb_adr_o[16]
* pin read_addr[10]
* pin read_addr[16]
* pin read_addr[18]
* pin write_addr[12]
* pin wb_rty_i
* pin read_addr[12]
* pin wb_adr_o[12]
* pin write_addr[7]
* pin write_addr[29]
* pin read_addr[29]
* pin read_addr[11]
* pin read_addr[15]
* pin wb_err_i
* pin wb_adr_o[3]
* pin write_addr[3]
* pin wb_adr_o[15]
* pin wb_adr_o[11]
* pin write_addr[15]
* pin read_err
* pin wb_adr_o[7]
* pin wb_ack_i
* pin write_addr[11]
* pin read_addr[25]
* pin wb_adr_o[25]
* pin wb_adr_o[29]
* pin read_addr[3]
* pin read_addr[7]
* pin write_addr[4]
* pin wb_adr_o[5]
* pin read_done
* pin read_addr[4]
* pin read_addr[5]
* pin read_req
* pin write_addr[5]
* pin write_req
* pin read_addr[2]
* pin read_addr[21]
* pin read_addr[22]
* pin write_addr[25]
* pin wb_adr_o[21]
* pin write_addr[21]
* pin write_addr[22]
* pin write_addr[2]
* pin wb_adr_o[4]
* pin wb_adr_o[2]
* pin clk
* pin write_addr[20]
* pin wb_adr_o[22]
* pin write_addr[28]
* pin write_addr[30]
* pin read_addr[30]
* pin read_addr[28]
* pin wb_adr_o[30]
* pin read_addr[1]
* pin read_addr[20]
* pin write_addr[1]
* pin write_addr[23]
* pin wb_dat_o[9]
* pin read_addr[23]
* pin write_addr[31]
* pin write_addr[6]
* pin read_addr[31]
* pin read_addr[6]
* pin wb_adr_o[28]
* pin read_addr[24]
* pin write_data[9]
* pin write_data[8]
* pin wb_dat_o[6]
* pin wb_adr_o[20]
* pin wb_dat_o[8]
* pin wb_adr_o[1]
* pin wb_adr_o[6]
* pin wb_adr_o[31]
* pin wb_adr_o[23]
* pin wb_dat_o[7]
* pin write_data[6]
* pin read_addr[26]
* pin write_addr[26]
* pin write_addr[19]
* pin read_addr[19]
* pin read_addr[27]
* pin write_addr[24]
* pin write_data[7]
* pin wb_adr_o[26]
* pin wb_dat_o[3]
* pin wb_adr_o[19]
* pin write_addr[27]
* pin write_data[3]
* pin wb_adr_o[27]
* pin wb_dat_i[28]
* pin wb_dat_o[29]
* pin write_data[29]
* pin wb_adr_o[24]
* pin wb_dat_o[30]
* pin write_data[25]
* pin write_data[30]
* pin wb_dat_o[17]
* pin write_data[17]
* pin wb_dat_o[19]
* pin wb_dat_o[24]
* pin write_data[19]
* pin wb_dat_o[18]
* pin write_data[24]
* pin write_data[31]
* pin write_data[18]
* pin wb_dat_o[28]
* pin wb_dat_o[25]
* pin write_data[22]
* pin wb_dat_o[31]
* pin wb_dat_o[22]
* pin write_data[1]
* pin wb_dat_o[23]
* pin write_data[20]
* pin write_data[23]
* pin wb_dat_o[1]
* pin wb_dat_o[21]
* pin write_data[21]
* pin wb_dat_o[20]
* pin wb_tgd_o
* pin wb_dat_i[2]
* pin read_data[5]
* pin wb_dat_i[27]
* pin read_data[8]
* pin wb_dat_i[15]
* pin read_data[17]
* pin wb_dat_i[22]
* pin wb_dat_i[17]
* pin wb_dat_i[29]
* pin wb_dat_i[6]
* pin wb_dat_i[9]
* pin wb_dat_i[24]
* pin read_data[12]
* pin wb_dat_i[14]
* pin write_data[28]
* pin wb_dat_o[27]
* pin read_data[18]
* pin read_data[24]
* pin wb_dat_i[26]
* pin wb_dat_i[3]
* pin read_data[27]
* pin read_data[4]
* pin read_data[2]
* pin wb_dat_i[30]
* pin wb_dat_i[5]
* pin read_data[25]
* pin wb_dat_i[20]
* pin read_data[26]
* pin wb_dat_i[0]
* pin wb_dat_i[16]
* pin write_data[4]
* pin write_data[5]
* pin read_data[30]
* pin wb_dat_i[11]
* pin wb_dat_i[18]
* pin read_data[21]
* pin wb_dat_i[7]
* pin read_data[31]
* pin wb_dat_i[4]
* pin wb_dat_i[13]
* pin read_data[13]
* pin read_data[1]
* pin write_data[2]
* pin read_data[3]
* pin read_data[7]
* pin read_data[29]
* pin wb_dat_i[25]
* pin read_data[9]
* pin wb_dat_i[8]
* pin wb_dat_o[26]
* pin wb_dat_o[5]
* pin wb_dat_i[12]
* pin wb_dat_i[1]
* pin wb_dat_o[2]
* pin read_data[16]
* pin read_data[10]
* pin read_data[20]
* pin read_data[28]
* pin wb_dat_i[31]
* pin wb_dat_i[21]
* pin read_data[6]
* pin read_data[15]
* pin wb_dat_i[10]
* pin wb_dat_i[19]
* pin wb_dat_i[23]
* pin read_data[22]
* pin read_data[14]
* pin read_data[11]
* pin read_data[0]
* pin read_data[19]
* pin read_data[23]
* pin write_data[27]
* pin wb_dat_o[4]
* pin write_data[26]
* pin PWELL,gf180mcu_gnd
* pin NWELL
.SUBCKT wishbone_master 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47
+ 48 49 50 51 52 53 54 55 56 57 58 59 60 61 221 233 241 242 249 250 251 271 272
+ 281 284 285 292 295 296 303 304 305 314 315 318 324 325 326 327 329 332 343
+ 344 345 346 347 348 355 356 358 359 360 361 369 370 371 374 379 380 388 389
+ 390 391 392 396 400 401 402 403 404 412 413 414 415 416 425 426 428 429 430
+ 431 432 436 437 444 447 448 449 450 451 452 462 466 467 468 469 470 471 472
+ 473 478 487 488 489 490 500 501 502 503 515 516 518 519 520 521 522 523 524
+ 535 538 539 545 546 547 548 549 550 551 552 567 599 620 623 629 630 633 640
+ 641 647 649 650 654 655 657 659 662 666 669 672 673 674 676 677 680 681 686
+ 687 688 690 691 693 698 703 705 707 708 710 711 712 713 714 717 721 724 725
+ 726 727 729 730 731 732 733 734 735 737 738 739 741 742 743 744 745 746 747
+ 748 749 750 751 752 753 754 755 756 757 758 759
* net 1 write_done
* net 2 wb_we_o
* net 3 write_err
* net 4 write_data[10]
* net 5 wb_dat_o[10]
* net 6 write_data[16]
* net 7 wb_sel_o[1]
* net 8 wb_cyc_o
* net 9 write_sel[3]
* net 10 wb_dat_o[16]
* net 11 wb_sel_o[3]
* net 12 read_sel[3]
* net 13 write_sel[1]
* net 14 wb_stb_o
* net 15 write_data[13]
* net 16 write_data[11]
* net 17 read_sel[1]
* net 18 wb_dat_o[11]
* net 19 wb_dat_o[13]
* net 20 wb_adr_o[9]
* net 21 write_data[0]
* net 22 wb_dat_o[0]
* net 23 wb_dat_o[15]
* net 24 write_data[15]
* net 25 write_addr[9]
* net 26 write_data[14]
* net 27 write_data[12]
* net 28 read_addr[9]
* net 29 write_addr[8]
* net 30 wb_adr_o[8]
* net 31 write_sel[2]
* net 32 read_addr[8]
* net 33 wb_sel_o[2]
* net 34 read_sel[2]
* net 35 wb_dat_o[14]
* net 36 wb_dat_o[12]
* net 37 write_sel[0]
* net 38 wb_sel_o[0]
* net 39 read_sel[0]
* net 40 wb_adr_o[0]
* net 41 wb_adr_o[17]
* net 42 rst_n
* net 43 write_addr[13]
* net 44 wb_adr_o[13]
* net 45 read_addr[13]
* net 46 write_addr[14]
* net 47 write_addr[0]
* net 48 wb_adr_o[14]
* net 49 read_addr[14]
* net 50 write_addr[17]
* net 51 read_addr[0]
* net 52 read_addr[17]
* net 53 wb_adr_o[18]
* net 54 wb_adr_o[10]
* net 55 write_addr[10]
* net 56 write_addr[16]
* net 57 write_addr[18]
* net 58 wb_adr_o[16]
* net 59 read_addr[10]
* net 60 read_addr[16]
* net 61 read_addr[18]
* net 221 write_addr[12]
* net 233 wb_rty_i
* net 241 read_addr[12]
* net 242 wb_adr_o[12]
* net 249 write_addr[7]
* net 250 write_addr[29]
* net 251 read_addr[29]
* net 271 read_addr[11]
* net 272 read_addr[15]
* net 281 wb_err_i
* net 284 wb_adr_o[3]
* net 285 write_addr[3]
* net 292 wb_adr_o[15]
* net 295 wb_adr_o[11]
* net 296 write_addr[15]
* net 303 read_err
* net 304 wb_adr_o[7]
* net 305 wb_ack_i
* net 314 write_addr[11]
* net 315 read_addr[25]
* net 318 wb_adr_o[25]
* net 324 wb_adr_o[29]
* net 325 read_addr[3]
* net 326 read_addr[7]
* net 327 write_addr[4]
* net 329 wb_adr_o[5]
* net 332 read_done
* net 343 read_addr[4]
* net 344 read_addr[5]
* net 345 read_req
* net 346 write_addr[5]
* net 347 write_req
* net 348 read_addr[2]
* net 355 read_addr[21]
* net 356 read_addr[22]
* net 358 write_addr[25]
* net 359 wb_adr_o[21]
* net 360 write_addr[21]
* net 361 write_addr[22]
* net 369 write_addr[2]
* net 370 wb_adr_o[4]
* net 371 wb_adr_o[2]
* net 374 clk
* net 379 write_addr[20]
* net 380 wb_adr_o[22]
* net 388 write_addr[28]
* net 389 write_addr[30]
* net 390 read_addr[30]
* net 391 read_addr[28]
* net 392 wb_adr_o[30]
* net 396 read_addr[1]
* net 400 read_addr[20]
* net 401 write_addr[1]
* net 402 write_addr[23]
* net 403 wb_dat_o[9]
* net 404 read_addr[23]
* net 412 write_addr[31]
* net 413 write_addr[6]
* net 414 read_addr[31]
* net 415 read_addr[6]
* net 416 wb_adr_o[28]
* net 425 read_addr[24]
* net 426 write_data[9]
* net 428 write_data[8]
* net 429 wb_dat_o[6]
* net 430 wb_adr_o[20]
* net 431 wb_dat_o[8]
* net 432 wb_adr_o[1]
* net 436 wb_adr_o[6]
* net 437 wb_adr_o[31]
* net 444 wb_adr_o[23]
* net 447 wb_dat_o[7]
* net 448 write_data[6]
* net 449 read_addr[26]
* net 450 write_addr[26]
* net 451 write_addr[19]
* net 452 read_addr[19]
* net 462 read_addr[27]
* net 466 write_addr[24]
* net 467 write_data[7]
* net 468 wb_adr_o[26]
* net 469 wb_dat_o[3]
* net 470 wb_adr_o[19]
* net 471 write_addr[27]
* net 472 write_data[3]
* net 473 wb_adr_o[27]
* net 478 wb_dat_i[28]
* net 487 wb_dat_o[29]
* net 488 write_data[29]
* net 489 wb_adr_o[24]
* net 490 wb_dat_o[30]
* net 500 write_data[25]
* net 501 write_data[30]
* net 502 wb_dat_o[17]
* net 503 write_data[17]
* net 515 wb_dat_o[19]
* net 516 wb_dat_o[24]
* net 518 write_data[19]
* net 519 wb_dat_o[18]
* net 520 write_data[24]
* net 521 write_data[31]
* net 522 write_data[18]
* net 523 wb_dat_o[28]
* net 524 wb_dat_o[25]
* net 535 write_data[22]
* net 538 wb_dat_o[31]
* net 539 wb_dat_o[22]
* net 545 write_data[1]
* net 546 wb_dat_o[23]
* net 547 write_data[20]
* net 548 write_data[23]
* net 549 wb_dat_o[1]
* net 550 wb_dat_o[21]
* net 551 write_data[21]
* net 552 wb_dat_o[20]
* net 567 wb_tgd_o
* net 599 wb_dat_i[2]
* net 620 read_data[5]
* net 623 wb_dat_i[27]
* net 629 read_data[8]
* net 630 wb_dat_i[15]
* net 633 read_data[17]
* net 640 wb_dat_i[22]
* net 641 wb_dat_i[17]
* net 647 wb_dat_i[29]
* net 649 wb_dat_i[6]
* net 650 wb_dat_i[9]
* net 654 wb_dat_i[24]
* net 655 read_data[12]
* net 657 wb_dat_i[14]
* net 659 write_data[28]
* net 662 wb_dat_o[27]
* net 666 read_data[18]
* net 669 read_data[24]
* net 672 wb_dat_i[26]
* net 673 wb_dat_i[3]
* net 674 read_data[27]
* net 676 read_data[4]
* net 677 read_data[2]
* net 680 wb_dat_i[30]
* net 681 wb_dat_i[5]
* net 686 read_data[25]
* net 687 wb_dat_i[20]
* net 688 read_data[26]
* net 690 wb_dat_i[0]
* net 691 wb_dat_i[16]
* net 693 write_data[4]
* net 698 write_data[5]
* net 703 read_data[30]
* net 705 wb_dat_i[11]
* net 707 wb_dat_i[18]
* net 708 read_data[21]
* net 710 wb_dat_i[7]
* net 711 read_data[31]
* net 712 wb_dat_i[4]
* net 713 wb_dat_i[13]
* net 714 read_data[13]
* net 717 read_data[1]
* net 721 write_data[2]
* net 724 read_data[3]
* net 725 read_data[7]
* net 726 read_data[29]
* net 727 wb_dat_i[25]
* net 729 read_data[9]
* net 730 wb_dat_i[8]
* net 731 wb_dat_o[26]
* net 732 wb_dat_o[5]
* net 733 wb_dat_i[12]
* net 734 wb_dat_i[1]
* net 735 wb_dat_o[2]
* net 737 read_data[16]
* net 738 read_data[10]
* net 739 read_data[20]
* net 741 read_data[28]
* net 742 wb_dat_i[31]
* net 743 wb_dat_i[21]
* net 744 read_data[6]
* net 745 read_data[15]
* net 746 wb_dat_i[10]
* net 747 wb_dat_i[19]
* net 748 wb_dat_i[23]
* net 749 read_data[22]
* net 750 read_data[14]
* net 751 read_data[11]
* net 752 read_data[0]
* net 753 read_data[19]
* net 754 read_data[23]
* net 755 write_data[27]
* net 756 wb_dat_o[4]
* net 757 write_data[26]
* net 758 PWELL,gf180mcu_gnd
* net 759 NWELL
* cell instance $3 r0 *1 927.36,5.04
X$3 72 759 758 1 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8 m0 *1 922.88,15.12
X$8 101 759 758 2 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11 r0 *1 950.88,5.04
X$11 75 759 758 3 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16 r0 *1 959.84,5.04
X$16 4 759 758 62 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $19 r0 *1 968.8,5.04
X$19 63 759 758 5 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $24 m0 *1 999.04,15.12
X$24 6 759 758 108 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $28 m0 *1 981.12,15.12
X$28 79 759 758 7 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32 r0 *1 977.2,5.04
X$32 77 759 758 8 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $36 r0 *1 987.84,5.04
X$36 9 759 758 81 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $39 m0 *1 965.44,25.2
X$39 112 759 758 10 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $43 r0 *1 979.44,15.12
X$43 113 759 758 11 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $48 r0 *1 999.04,5.04
X$48 12 759 758 71 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $51 r0 *1 1015.84,5.04
X$51 13 759 758 64 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $54 r0 *1 982.8,25.2
X$54 132 759 758 14 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $60 m0 *1 989.52,15.12
X$60 15 759 758 107 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64 m0 *1 1024.24,15.12
X$64 16 759 758 110 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68 r0 *1 1007.44,5.04
X$68 17 759 758 65 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $71 m0 *1 1015.84,15.12
X$71 84 759 758 18 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $75 r0 *1 992.32,25.2
X$75 78 759 758 19 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $79 r0 *1 1000.16,15.12
X$79 114 759 758 20 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $83 r0 *1 1024.24,5.04
X$83 21 759 758 85 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $88 r0 *1 1018.64,15.12
X$88 115 759 758 22 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $91 m0 *1 999.04,35.28
X$91 143 759 758 23 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $96 r0 *1 1005.76,35.28
X$96 24 759 758 142 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $102 m0 *1 1049.44,15.12
X$102 25 759 758 104 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $106 m0 *1 1007.44,35.28
X$106 26 759 758 155 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $110 m0 *1 1024.24,35.28
X$110 27 759 758 117 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $114 r0 *1 1049.44,5.04
X$114 28 759 758 70 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $118 m0 *1 1041.04,15.12
X$118 29 759 758 106 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $122 r0 *1 1014.16,35.28
X$122 144 759 758 30 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $126 m0 *1 1032.64,15.12
X$126 31 759 758 87 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $130 r0 *1 1041.04,5.04
X$130 32 759 758 66 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $134 m0 *1 1017.52,45.36
X$134 146 759 758 33 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $138 r0 *1 1032.08,35.28
X$138 34 759 758 120 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $141 r0 *1 1044.96,15.12
X$141 116 759 758 35 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $145 r0 *1 1032.64,5.04
X$145 86 759 758 36 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $150 r0 *1 1023.12,25.2
X$150 37 759 758 137 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $154 r0 *1 1017.52,45.36
X$154 157 759 758 38 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $158 m0 *1 1057.84,15.12
X$158 39 759 758 89 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $162 m0 *1 1032.64,35.28
X$162 141 759 758 40 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $165 m0 *1 1066.24,15.12
X$165 100 759 758 41 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $170 r0 *1 1078,5.04
X$170 758 69 42 759 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $174 r0 *1 1066.24,5.04
X$174 43 759 758 68 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $177 m0 *1 1042.16,45.36
X$177 148 759 758 44 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $182 m0 *1 1083.04,15.12
X$182 45 759 758 99 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $186 r0 *1 1063.44,15.12
X$186 46 759 758 136 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $190 m0 *1 1052.24,35.28
X$190 47 759 758 121 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $194 m0 *1 1067.36,25.2
X$194 123 759 758 48 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $197 r0 *1 1098.72,5.04
X$197 49 759 758 98 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $202 r0 *1 1043.84,35.28
X$202 50 759 758 150 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $205 r0 *1 1052.8,25.2
X$205 51 759 758 140 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $210 r0 *1 1057.84,5.04
X$210 52 759 758 67 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $214 r0 *1 1107.12,5.04
X$214 96 759 758 53 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $218 r0 *1 1060.64,35.28
X$218 94 759 758 54 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $222 m0 *1 1099.84,15.12
X$222 55 759 758 93 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $226 m0 *1 1092.56,25.2
X$226 56 759 758 128 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $230 m0 *1 1091.44,15.12
X$230 57 759 758 95 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $233 m0 *1 1070.16,35.28
X$233 124 759 758 58 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $237 r0 *1 1089.2,25.2
X$237 59 759 758 126 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $242 r0 *1 1102.64,15.12
X$242 60 759 758 97 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $246 r0 *1 1075.76,35.28
X$246 61 759 758 152 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $249 m0 *1 961.52,15.12
X$249 758 759 103 62 76 63 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $253 m0 *1 931.84,15.12
X$253 758 74 63 73 103 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $260 m0 *1 1007.44,15.12
X$260 758 759 109 64 82 65 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $265 r0 *1 1027.04,15.12
X$265 758 759 111 106 82 66 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $270 r0 *1 1052.24,35.28
X$270 758 759 149 150 92 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $275 m0 *1 1074.64,15.12
X$275 758 759 90 68 92 99 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $279 r0 *1 1115.52,5.04
X$279 758 69 74 759 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $284 r0 *1 1036.56,15.12
X$284 758 759 88 104 82 70 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $287 r0 *1 990.64,15.12
X$287 758 759 80 81 82 71 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $292 r0 *1 913.36,851.76
X$292 758 74 72 167 172 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $294 r0 *1 915.6,871.92
X$294 758 72 759 173 203 204 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $299 r0 *1 922.88,861.84
X$299 758 174 759 178 179 72 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $301 m0 *1 1001.84,65.52
X$301 758 74 144 73 164 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $304 r0 *1 1002.4,25.2
X$304 758 74 116 73 135 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $306 r0 *1 959.28,45.36
X$306 758 74 113 73 160 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $308 r0 *1 987.84,45.36
X$308 758 74 143 73 161 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $310 m0 *1 978.88,65.52
X$310 758 74 114 73 163 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $313 r0 *1 986.72,35.28
X$313 758 74 115 73 154 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $316 r0 *1 931.84,15.12
X$316 758 74 112 73 130 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $319 m0 *1 973.84,25.2
X$319 758 74 84 73 83 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $321 r0 *1 1078.56,15.12
X$321 758 74 94 73 91 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $323 r0 *1 960.4,15.12
X$323 758 74 78 73 105 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $336 m0 *1 963.2,45.36
X$336 758 74 79 73 153 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $338 r0 *1 968.8,105.84
X$338 758 165 73 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $344 r0 *1 988.96,1033.2
X$344 758 74 510 167 509 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $347 m0 *1 889.28,952.56
X$347 758 74 334 167 367 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $350 m0 *1 955.92,882
X$350 758 74 77 167 226 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $352 r0 *1 939.68,861.84
X$352 758 74 75 167 175 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $357 r0 *1 855.12,922.32
X$357 758 74 287 167 299 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $359 m0 *1 911.68,851.76
X$359 758 74 101 167 171 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $488 r0 *1 1909.6,1083.6
X$488 758 74 561 312 565 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $490 m0 *1 1909.6,1083.6
X$490 758 74 560 312 557 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $493 r0 *1 10.64,982.8
X$493 758 74 395 282 406 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $495 r0 *1 10.64,1002.96
X$495 758 74 459 282 474 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $497 m0 *1 25.76,1002.96
X$497 758 74 441 282 440 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $500 m0 *1 923.44,902.16
X$500 758 74 240 167 238 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $502 m0 *1 1872.08,1033.2
X$502 758 74 513 245 511 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $505 r0 *1 1050.56,45.36
X$505 758 74 100 119 159 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $507 r0 *1 1032.64,25.2
X$507 758 74 141 119 138 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $509 r0 *1 851.2,1910.16
X$509 758 74 684 570 670 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $512 m0 *1 1909.04,942.48
X$512 758 74 316 312 313 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $514 m0 *1 1895.04,1073.52
X$514 758 74 555 312 556 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $517 m0 *1 1907.92,922.32
X$517 758 74 269 245 293 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $521 r0 *1 1907.92,1063.44
X$521 758 74 559 312 554 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $523 m0 *1 1883.28,1063.44
X$523 758 74 542 312 541 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $526 m0 *1 863.52,1920.24
X$526 758 74 624 569 622 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $529 r0 *1 836.08,1920.24
X$529 758 74 682 570 679 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $531 r0 *1 1900.64,942.48
X$531 758 74 337 245 336 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $535 m0 *1 1876.56,962.64
X$535 758 74 375 245 387 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $537 r0 *1 1876,942.48
X$537 758 74 335 312 341 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $540 r0 *1 1906.8,1043.28
X$540 758 74 537 245 536 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $543 r0 *1 1901.2,912.24
X$543 758 74 268 312 278 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $545 m0 *1 917.84,1869.84
X$545 758 74 587 570 585 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $548 m0 *1 1871.52,1053.36
X$548 758 74 531 312 530 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $550 m0 *1 944.72,1849.68
X$550 758 74 576 570 574 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $552 r0 *1 1070.16,45.36
X$552 758 74 96 119 158 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $554 m0 *1 837.2,1920.24
X$554 758 74 619 570 644 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $556 r0 *1 879.2,1910.16
X$556 758 74 627 570 626 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $558 m0 *1 871.92,1910.16
X$558 758 74 648 570 646 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $561 m0 *1 1907.92,1033.2
X$561 758 74 517 245 527 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $563 m0 *1 1893.36,1043.28
X$563 758 74 533 245 532 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $565 m0 *1 1039.92,25.2
X$565 758 74 123 119 122 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $567 m0 *1 884.24,1920.24
X$567 758 74 653 570 704 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $569 m0 *1 1882.72,972.72
X$569 758 74 376 245 386 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $571 r0 *1 836.64,882
X$571 758 74 198 167 228 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $575 m0 *1 1879.36,982.8
X$575 758 74 424 312 435 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $580 r0 *1 852.32,861.84
X$580 758 74 168 167 177 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $583 r0 *1 1907.92,992.88
X$583 758 74 427 312 464 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $586 m0 *1 899.36,1910.16
X$586 758 74 652 569 678 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $588 m0 *1 1020.88,55.44
X$588 758 74 157 119 162 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $591 r0 *1 906.08,1910.16
X$591 758 74 632 570 631 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $594 r0 *1 1016.4,55.44
X$594 758 74 146 119 145 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $596 r0 *1 1863.68,1002.96
X$596 758 74 460 312 479 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $599 m0 *1 958.72,1879.92
X$599 758 74 589 570 615 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $601 m0 *1 1877.12,1002.96
X$601 758 74 461 245 477 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $603 m0 *1 977.76,1890
X$603 758 74 611 569 613 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $605 r0 *1 969.36,1879.92
X$605 758 74 610 569 609 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $607 m0 *1 1874.88,1013.04
X$607 758 74 484 312 481 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $609 m0 *1 978.88,1900.08
X$609 758 74 638 569 637 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $611 r0 *1 956.48,1900.08
X$611 758 74 656 569 663 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $613 m0 *1 1039.92,55.44
X$613 758 74 148 119 147 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $618 m0 *1 1868.72,992.88
X$618 758 74 443 245 442 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $620 r0 *1 1875.44,982.8
X$620 758 74 423 245 422 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $622 m0 *1 888.72,1879.92
X$622 758 74 583 570 614 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $624 r0 *1 845.04,902.16
X$624 758 74 199 167 234 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $626 r0 *1 948.08,1869.84
X$626 758 74 588 569 594 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $628 m0 *1 35.84,962.64
X$628 758 74 363 282 350 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $630 r0 *1 14.56,962.64
X$630 758 74 373 282 372 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $633 r0 *1 879.2,1890
X$633 758 74 628 570 625 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $635 m0 *1 31.36,952.56
X$635 758 74 328 282 362 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $637 m0 *1 35.84,942.48
X$637 758 74 309 282 323 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $639 m0 *1 1004.08,25.2
X$639 758 74 86 119 134 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $642 m0 *1 1906.8,972.72
X$642 758 74 399 245 397 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $645 r0 *1 872.48,1879.92
X$645 758 74 598 569 596 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $647 m0 *1 6.16,922.32
X$647 758 74 255 282 275 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $649 m0 *1 926.24,1920.24
X$649 758 74 715 569 709 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $651 r0 *1 6.72,922.32
X$651 758 74 283 282 252 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $653 r0 *1 933.52,1910.16
X$653 758 74 658 570 665 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $655 r0 *1 871.36,1869.84
X$655 758 74 582 569 591 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $657 m0 *1 893.76,1849.68
X$657 758 74 571 570 577 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $659 m0 *1 932.96,922.32
X$659 758 74 267 167 266 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $661 r0 *1 921.2,1879.92
X$661 758 74 605 569 616 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $663 r0 *1 900.48,1849.68
X$663 758 74 572 570 578 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $666 m0 *1 1860.32,982.8
X$666 758 74 421 312 411 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $668 r0 *1 1899.52,892.08
X$668 758 74 222 245 225 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $670 r0 *1 988.96,1910.16
X$670 758 74 697 569 694 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $672 r0 *1 879.2,861.84
X$672 758 74 190 167 169 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $675 r0 *1 1008,1910.16
X$675 758 74 661 569 699 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $679 r0 *1 996.8,1920.24
X$679 758 74 696 569 736 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $682 m0 *1 899.92,1890
X$682 758 74 604 570 602 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $686 m0 *1 31.36,982.8
X$686 758 74 419 282 420 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $688 r0 *1 949.76,1890
X$688 758 74 635 570 634 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $690 r0 *1 1033.76,1920.24
X$690 758 74 722 569 728 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $692 r0 *1 823.76,1879.92
X$692 758 74 595 167 612 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $694 m0 *1 847.28,1900.08
X$694 758 74 621 570 618 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $696 r0 *1 1064.56,25.2
X$696 758 74 124 119 131 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $698 r0 *1 962.64,1910.16
X$698 758 74 692 570 718 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $700 r0 *1 1902.88,1002.96
X$700 758 74 486 312 493 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $702 r0 *1 927.92,1849.68
X$702 758 74 573 570 580 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $704 m0 *1 1879.36,1023.12
X$704 758 74 496 312 507 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $706 m0 *1 957.04,1920.24
X$706 758 74 720 570 740 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $708 r0 *1 1859.2,1013.04
X$708 758 74 480 312 508 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $710 r0 *1 1896.16,1023.12
X$710 758 74 498 312 497 759 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $713 m0 *1 942.48,861.84
X$713 758 759 75 176 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $725 r0 *1 1010.24,15.12
X$725 758 759 83 110 76 84 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $727 r0 *1 930.16,861.84
X$727 758 759 76 179 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $750 m0 *1 1015.84,35.28
X$750 758 759 135 155 76 116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $753 m0 *1 999.04,45.36
X$753 758 759 161 142 76 143 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $756 m0 *1 910.56,861.84
X$756 758 76 170 759 171 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $758 m0 *1 952,25.2
X$758 758 759 130 108 76 112 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $760 m0 *1 972.72,15.12
X$760 758 759 105 107 76 78 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $763 r0 *1 1022.56,35.28
X$763 758 759 154 85 76 115 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $767 m0 *1 976.64,871.92
X$767 758 220 76 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $769 m0 *1 1023.12,25.2
X$769 758 759 134 117 76 86 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $773 r0 *1 977.76,25.2
X$773 77 759 758 132 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $782 m0 *1 982.24,45.36
X$782 758 759 153 79 156 109 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $788 r0 *1 978.32,45.36
X$788 758 759 160 113 156 80 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $795 r0 *1 1861.44,942.48
X$795 758 82 365 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $798 m0 *1 1122.24,25.2
X$798 758 82 92 759 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $800 m0 *1 913.36,932.4
X$800 758 759 82 263 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $803 m0 *1 907.2,912.24
X$803 262 758 82 218 759 280 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $805 m0 *1 916.16,952.56
X$805 758 307 82 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $821 r0 *1 1053.92,15.12
X$821 758 759 102 137 82 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $825 m0 *1 1031.52,25.2
X$825 758 759 118 87 82 120 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $846 r0 *1 992.88,55.44
X$846 758 759 163 114 156 88 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $853 m0 *1 1050.56,45.36
X$853 758 759 147 148 129 90 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $858 m0 *1 1079.68,35.28
X$858 758 759 91 94 129 125 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $862 m0 *1 1088.08,35.28
X$862 758 759 125 93 92 126 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $871 r0 *1 1918.56,922.32
X$871 758 759 270 294 92 243 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $875 r0 *1 1920.24,912.24
X$875 758 759 276 277 92 273 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $877 r0 *1 1088.08,35.28
X$877 758 759 151 95 92 152 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $880 m0 *1 1058.96,25.2
X$880 758 759 139 121 92 140 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $882 m0 *1 1102.64,25.2
X$882 758 759 127 128 92 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $885 r0 *1 1918.56,892.08
X$885 758 759 224 223 92 244 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $887 m0 *1 1075.76,25.2
X$887 758 759 133 136 92 98 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $907 m0 *1 1081.92,45.36
X$907 758 759 158 96 129 151 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $925 m0 *1 1058.96,55.44
X$925 758 759 159 100 129 149 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $929 r0 *1 914.48,882
X$929 758 759 101 202 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $932 r0 *1 913.36,892.08
X$932 758 101 759 201 208 216 237 215 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $941 r0 *1 926.8,882
X$941 190 758 200 101 759 207 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $943 m0 *1 922.32,882
X$943 759 190 101 758 191 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $948 r0 *1 1025.92,45.36
X$948 758 759 162 157 156 102 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $985 r0 *1 1008,55.44
X$985 758 759 164 144 156 111 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1020 m0 *1 1026.48,45.36
X$1020 758 759 145 146 156 118 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1028 m0 *1 1004.08,146.16
X$1028 758 165 119 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1038 m0 *1 999.6,146.16
X$1038 758 759 119 761 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $1058 m0 *1 1061.2,35.28
X$1058 758 759 122 123 129 133 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1071 m0 *1 1084.16,25.2
X$1071 758 759 131 124 129 127 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1086 m0 *1 1066.24,65.52
X$1086 758 156 129 759 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $1090 m0 *1 1910.16,912.24
X$1090 758 759 278 268 129 270 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1092 r0 *1 1908.48,922.32
X$1092 758 759 293 269 129 276 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1094 m0 *1 1907.36,892.08
X$1094 758 759 225 222 129 224 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1110 m0 *1 1043.84,35.28
X$1110 758 759 138 141 129 139 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1232 m0 *1 908.88,942.48
X$1232 758 208 156 218 307 759 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $1237 m0 *1 1852.48,942.48
X$1237 758 156 352 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1239 r0 *1 845.04,932.4
X$1239 758 156 258 759 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $1288 r0 *1 863.52,660.24
X$1288 758 166 165 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1295 m0 *1 1212.96,1224.72
X$1295 758 166 540 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1298 r0 *1 766.64,660.24
X$1298 758 166 286 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1301 m0 *1 1112.16,1224.72
X$1301 758 166 568 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1305 m0 *1 960.4,972.72
X$1305 758 374 166 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1322 m0 *1 803.04,952.56
X$1322 758 286 167 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1349 m0 *1 861.28,871.92
X$1349 759 168 197 758 194 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1351 m0 *1 852.32,882
X$1351 168 759 198 199 758 186 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1353 m0 *1 868,882
X$1353 758 759 168 182 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1361 m0 *1 881.44,871.92
X$1361 196 758 187 188 759 169 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1363 r0 *1 905.52,882
X$1363 758 202 759 170 218 208 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1369 r0 *1 917.28,861.84
X$1369 758 759 172 173 178 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1377 m0 *1 931.28,871.92
X$1377 758 759 192 174 197 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1379 r0 *1 932.96,902.16
X$1379 758 174 240 265 759 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1381 r0 *1 918.96,882
X$1381 759 174 758 209 206 204 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1384 r0 *1 936.88,871.92
X$1384 758 205 759 192 175 193 176 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1391 m0 *1 866.32,871.92
X$1391 194 758 195 181 759 177 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1401 r0 *1 874.16,871.92
X$1401 182 180 184 185 758 759 195 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1403 r0 *1 864.64,871.92
X$1403 184 180 182 181 183 759 758 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1408 m0 *1 858.48,882
X$1408 180 758 759 198 199 764 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1418 r0 *1 870.8,892.08
X$1418 758 183 759 213 216 214 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1420 r0 *1 883.12,892.08
X$1420 204 217 214 183 759 758 219 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1422 r0 *1 881.44,871.92
X$1422 186 184 189 188 183 759 758 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1425 r0 *1 878.64,892.08
X$1425 758 759 215 183 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $1432 m0 *1 876.96,882
X$1432 189 184 185 186 758 759 187 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1442 m0 *1 882,892.08
X$1442 759 214 216 758 184 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1446 r0 *1 875.84,882
X$1446 759 200 215 758 185 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1458 r0 *1 900.48,882
X$1458 759 189 197 758 201 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1461 r0 *1 894.88,871.92
X$1461 758 759 190 189 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1472 r0 *1 890.96,882
X$1472 758 200 759 261 202 190 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1474 m0 *1 894.88,871.92
X$1474 759 190 197 758 196 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1478 m0 *1 927.36,882
X$1478 759 191 193 200 206 205 758 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1502 m0 *1 910,882
X$1502 758 759 197 200 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1506 r0 *1 881.44,912.24
X$1506 759 259 758 301 215 197 260 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $1517 m0 *1 862.4,892.08
X$1517 758 197 213 759 231 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1519 m0 *1 936.88,912.24
X$1519 758 760 240 267 197 759 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $1521 m0 *1 859.04,902.16
X$1521 759 199 758 213 248 197 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1525 m0 *1 857.92,892.08
X$1525 758 759 198 210 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1534 m0 *1 854.56,892.08
X$1534 758 759 199 211 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1547 m0 *1 873.04,892.08
X$1547 200 214 215 216 758 759 212 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1556 m0 *1 902.72,892.08
X$1556 758 759 229 208 201 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1567 m0 *1 908.32,892.08
X$1567 758 759 232 218 203 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1569 m0 *1 913.36,902.16
X$1569 758 759 203 246 219 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1577 m0 *1 917.28,912.24
X$1577 758 759 208 203 263 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1579 r0 *1 2.24,932.4
X$1579 758 305 204 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1581 m0 *1 888.72,902.16
X$1581 758 759 217 204 216 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $1583 r0 *1 891.52,912.24
X$1583 758 759 204 279 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1585 m0 *1 899.92,932.4
X$1585 759 290 204 528 758 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $1596 r0 *1 925.68,912.24
X$1596 758 264 759 205 263 208 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1606 m0 *1 931.84,892.08
X$1606 758 220 759 239 207 227 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1611 m0 *1 913.92,892.08
X$1611 758 208 759 227 216 215 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1614 m0 *1 902.16,912.24
X$1614 758 759 208 262 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1617 r0 *1 917.28,942.48
X$1617 759 208 307 758 342 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1634 r0 *1 918.4,922.32
X$1634 758 291 208 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1638 r0 *1 899.36,942.48
X$1638 758 351 759 367 333 208 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1641 m0 *1 893.76,892.08
X$1641 758 759 217 209 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1646 m0 *1 846.16,892.08
X$1646 758 759 228 212 210 231 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1649 r0 *1 845.6,892.08
X$1649 765 758 759 210 211 230 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1657 r0 *1 855.68,892.08
X$1657 758 759 230 247 212 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1673 m0 *1 16.24,902.16
X$1673 758 759 233 214 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1683 r0 *1 879.76,922.32
X$1683 758 759 215 259 288 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1691 m0 *1 902.16,922.32
X$1691 758 215 236 265 291 759 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $1705 m0 *1 2.24,932.4
X$1705 758 281 217 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1707 m0 *1 884.24,922.32
X$1707 758 289 759 302 217 279 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1719 r0 *1 2.24,942.48
X$1719 758 345 218 759 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $1721 r0 *1 906.08,932.4
X$1721 758 759 263 311 218 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1724 r0 *1 903.28,912.24
X$1724 758 262 759 260 218 263 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1731 r0 *1 906.08,892.08
X$1731 758 232 759 226 229 219 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1734 r0 *1 915.04,902.16
X$1734 759 280 219 758 235 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1739 m0 *1 1915.2,1002.96
X$1739 758 759 464 465 220 427 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1742 r0 *1 1872.08,1023.12
X$1742 758 220 512 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1744 r0 *1 1915.76,972.72
X$1744 758 759 397 398 220 399 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1746 r0 *1 1837.92,1013.04
X$1746 758 220 482 759 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $1749 r0 *1 924,942.48
X$1749 758 342 220 759 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $1766 m0 *1 1898.4,982.8
X$1766 758 759 435 434 220 424 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1768 r0 *1 1878.24,992.88
X$1768 758 759 422 455 220 423 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1771 m0 *1 1915.76,892.08
X$1771 221 759 758 223 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1774 m0 *1 1924.16,892.08
X$1774 222 759 758 242 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1821 m0 *1 854,912.24
X$1821 758 759 247 234 248 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1828 r0 *1 920.08,902.16
X$1828 759 236 758 235 246 238 237 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $1831 r0 *1 936.32,912.24
X$1831 758 759 266 239 235 267 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1834 m0 *1 923.44,922.32
X$1834 290 758 759 236 267 762 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1837 m0 *1 924,912.24
X$1837 264 758 759 236 267 763 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1842 r0 *1 932.96,912.24
X$1842 758 759 240 236 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $1861 m0 *1 1923.6,902.16
X$1861 241 759 758 244 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1867 r0 *1 1924.16,902.16
X$1867 272 759 758 243 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1874 r0 *1 1697.92,1053.36
X$1874 758 540 245 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1909 m0 *1 1697.92,1053.36
X$1909 758 759 245 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $1924 r0 *1 2.24,912.24
X$1924 249 759 758 297 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1927 m0 *1 2.24,912.24
X$1927 250 759 758 254 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1930 r0 *1 4.48,902.16
X$1930 251 759 758 274 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1933 r0 *1 10.64,912.24
X$1933 758 759 252 283 258 256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1935 m0 *1 27.44,942.48
X$1935 758 759 323 309 258 253 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1939 m0 *1 10.64,912.24
X$1939 758 759 253 254 298 274 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1945 r0 *1 12.88,902.16
X$1945 255 759 758 284 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1947 r0 *1 19.04,912.24
X$1947 758 759 275 255 258 257 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1952 m0 *1 16.8,932.4
X$1952 758 759 256 297 298 306 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1954 r0 *1 27.44,932.4
X$1954 758 759 257 308 298 321 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1959 r0 *1 25.2,952.56
X$1959 758 759 362 328 258 330 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1973 m0 *1 17.36,1002.96
X$1973 758 759 474 459 258 454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1975 r0 *1 33.6,952.56
X$1975 758 759 350 363 258 320 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1978 m0 *1 22.96,962.64
X$1978 758 759 372 373 258 382 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1984 r0 *1 25.76,992.88
X$1984 758 759 440 441 258 453 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1986 r0 *1 29.68,982.8
X$1986 758 759 420 419 258 393 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1988 r0 *1 19.04,972.72
X$1988 758 759 406 395 258 407 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1998 m0 *1 891.52,922.32
X$1998 260 758 261 302 759 300 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2020 r0 *1 932.96,922.32
X$2020 758 759 267 265 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2046 m0 *1 1899.52,922.32
X$2046 268 759 758 292 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2054 r0 *1 1915.76,902.16
X$2054 269 759 758 295 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2059 m0 *1 1918.56,912.24
X$2059 271 759 758 273 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2080 m0 *1 1907.36,932.4
X$2080 314 759 758 277 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2105 r0 *1 374.64,922.32
X$2105 758 286 282 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2117 r0 *1 370.16,922.32
X$2117 758 759 282 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $2124 r0 *1 26.32,922.32
X$2124 283 759 758 304 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2130 m0 *1 25.2,922.32
X$2130 285 759 758 308 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2140 r0 *1 876.4,922.32
X$2140 758 759 287 288 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2144 m0 *1 43.12,932.4
X$2144 287 759 758 303 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2147 m0 *1 875.28,922.32
X$2147 758 288 759 300 299 301 289 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2156 r0 *1 902.72,922.32
X$2156 758 759 290 289 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2158 m0 *1 900.48,942.48
X$2158 758 759 333 310 311 289 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2172 m0 *1 1915.76,932.4
X$2172 296 759 758 294 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2182 m0 *1 25.2,932.4
X$2182 758 759 307 298 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2196 m0 *1 14,992.88
X$2196 758 759 454 439 298 438 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2199 m0 *1 5.6,992.88
X$2199 758 759 453 417 298 458 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2202 m0 *1 14.56,962.64
X$2202 758 759 382 381 298 349 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2204 r0 *1 25.76,942.48
X$2204 758 759 330 339 298 331 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2208 r0 *1 16.8,932.4
X$2208 758 759 320 319 298 322 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2212 m0 *1 20.72,982.8
X$2212 758 759 407 418 298 433 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2215 r0 *1 10.64,972.72
X$2215 758 759 393 394 298 405 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2239 m0 *1 10.64,942.48
X$2239 326 759 758 306 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2252 r0 *1 2.24,952.56
X$2252 758 347 307 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2261 r0 *1 42.56,942.48
X$2261 309 759 758 324 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2264 m0 *1 910.56,952.56
X$2264 758 759 334 310 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2316 r0 *1 1709.68,1063.44
X$2316 758 540 312 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2319 r0 *1 1907.92,932.4
X$2319 758 759 313 316 352 340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2324 r0 *1 1924.16,932.4
X$2324 315 759 758 317 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2328 m0 *1 1924.16,932.4
X$2328 316 759 758 318 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2333 r0 *1 1919.68,942.48
X$2333 758 759 340 338 365 317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2338 m0 *1 2.24,942.48
X$2338 327 759 758 319 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2349 m0 *1 19.04,942.48
X$2349 325 759 758 321 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2354 r0 *1 6.16,962.64
X$2354 343 759 758 322 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2372 r0 *1 16.8,942.48
X$2372 328 759 758 329 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2379 m0 *1 22.96,952.56
X$2379 344 759 758 331 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2383 r0 *1 34.16,942.48
X$2383 334 759 758 332 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2396 r0 *1 901.04,952.56
X$2396 758 759 351 334 368 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2402 r0 *1 1898.96,952.56
X$2402 335 759 758 380 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2404 m0 *1 1888.88,952.56
X$2404 758 759 341 335 352 366 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2407 m0 *1 1905.12,952.56
X$2407 758 759 336 337 352 353 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2414 m0 *1 1913.52,952.56
X$2414 337 759 758 359 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2417 r0 *1 1915.76,952.56
X$2417 358 759 758 338 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2420 m0 *1 2.24,952.56
X$2420 346 759 758 339 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2447 m0 *1 11.2,952.56
X$2447 348 759 758 349 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2455 m0 *1 1866.48,1013.04
X$2455 758 759 479 460 352 494 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2470 r0 *1 1901.76,962.64
X$2470 758 759 386 376 352 377 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2473 m0 *1 1895.6,962.64
X$2473 758 759 387 375 352 385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2476 r0 *1 1874.88,972.72
X$2476 758 759 411 421 352 410 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2478 r0 *1 1886.64,992.88
X$2478 758 759 477 461 352 476 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2481 r0 *1 1869.84,992.88
X$2481 758 759 442 443 352 463 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2484 r0 *1 1907.36,1013.04
X$2484 758 759 493 486 352 505 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2487 m0 *1 1907.36,962.64
X$2487 758 759 353 384 365 354 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2490 r0 *1 1907.36,952.56
X$2490 355 759 758 354 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2495 m0 *1 1924.16,962.64
X$2495 356 759 758 357 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2497 m0 *1 1921.92,952.56
X$2497 758 759 366 364 365 357 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2505 m0 *1 1915.76,962.64
X$2505 360 759 758 384 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2508 r0 *1 1924.16,952.56
X$2508 361 759 758 364 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2519 r0 *1 34.72,962.64
X$2519 363 759 758 370 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2544 r0 *1 1910.16,962.64
X$2544 758 759 385 383 365 378 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2546 m0 *1 1912.96,992.88
X$2546 758 759 410 456 365 457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2548 m0 *1 1893.92,1013.04
X$2548 758 759 494 485 365 475 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2550 r0 *1 1907.36,972.72
X$2550 758 759 377 408 365 409 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2552 r0 *1 1898.96,1013.04
X$2552 758 759 476 491 365 492 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2554 m0 *1 1915.2,1023.12
X$2554 758 759 505 499 365 446 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2557 m0 *1 1906.8,1023.12
X$2557 758 759 463 445 365 504 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2568 m0 *1 929.04,1890
X$2568 758 759 616 617 368 605 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2570 m0 *1 950.32,1879.92
X$2570 758 759 594 606 368 588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2575 r0 *1 907.76,1839.6
X$2575 758 528 368 759 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $2585 r0 *1 948.08,1849.68
X$2585 758 759 574 575 368 576 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2587 r0 *1 920.64,1869.84
X$2587 758 759 585 586 368 587 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2590 r0 *1 968.8,1890
X$2590 758 759 613 636 368 611 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2592 m0 *1 969.36,1890
X$2592 758 759 609 608 368 610 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2594 m0 *1 920.64,1859.76
X$2594 758 759 580 579 368 573 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2596 r0 *1 957.04,1879.92
X$2596 758 759 615 607 368 589 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2598 m0 *1 908.32,1859.76
X$2598 758 759 578 584 368 572 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2601 m0 *1 6.16,962.64
X$2601 369 759 758 381 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2605 m0 *1 20.16,972.72
X$2605 373 759 758 371 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2624 m0 *1 1902.32,1013.04
X$2624 375 759 758 430 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2628 m0 *1 1906.24,1002.96
X$2628 376 759 758 432 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2633 r0 *1 1910.16,982.8
X$2633 400 759 758 378 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2636 r0 *1 1922.48,962.64
X$2636 379 759 758 383 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2669 r0 *1 2.24,982.8
X$2669 388 759 758 418 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2672 r0 *1 2.24,972.72
X$2672 389 759 758 394 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2674 m0 *1 3.36,972.72
X$2674 390 759 758 405 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2678 m0 *1 11.2,982.8
X$2678 391 759 758 433 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2681 r0 *1 38.08,982.8
X$2681 419 759 758 392 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2692 r0 *1 29.68,1002.96
X$2692 395 759 758 416 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2696 r0 *1 1898.96,972.72
X$2696 396 759 758 409 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2705 m0 *1 1924.16,1002.96
X$2705 426 759 758 398 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2709 r0 *1 1924.16,1002.96
X$2709 399 759 758 403 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2714 r0 *1 1924.16,972.72
X$2714 401 759 758 408 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2717 m0 *1 1921.36,992.88
X$2717 402 759 758 456 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2722 r0 *1 1918.56,982.8
X$2722 404 759 758 457 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2753 m0 *1 2.24,982.8
X$2753 412 759 758 417 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2756 m0 *1 8.96,1002.96
X$2756 413 759 758 439 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2759 r0 *1 2.24,1002.96
X$2759 414 759 758 458 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2762 m0 *1 2.24,1013.04
X$2762 415 759 758 438 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2786 m0 *1 1892.24,992.88
X$2786 421 759 758 444 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2795 m0 *1 1911.28,1013.04
X$2795 423 759 758 429 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2801 r0 *1 1896.72,982.8
X$2801 424 759 758 431 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2804 m0 *1 1915.76,982.8
X$2804 425 759 758 446 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2812 m0 *1 1924.16,982.8
X$2812 427 759 758 447 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2815 m0 *1 1906.8,982.8
X$2815 428 759 758 434 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2840 r0 *1 17.36,1013.04
X$2840 459 759 758 436 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2843 r0 *1 10.08,992.88
X$2843 441 759 758 437 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2865 m0 *1 1898.96,1053.36
X$2865 443 759 758 468 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2872 m0 *1 1904.56,992.88
X$2872 450 759 758 445 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2880 r0 *1 1924.16,1013.04
X$2880 448 759 758 455 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2883 m0 *1 1924.16,1023.12
X$2883 449 759 758 504 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2888 r0 *1 1915.76,1013.04
X$2888 451 759 758 491 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2891 r0 *1 1912.96,1033.2
X$2891 452 759 758 492 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2924 m0 *1 1896.16,1002.96
X$2924 460 759 758 473 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2932 m0 *1 1898.4,1023.12
X$2932 461 759 758 470 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2935 r0 *1 1899.52,992.88
X$2935 462 759 758 475 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2947 m0 *1 1920.8,1013.04
X$2947 467 759 758 465 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2951 r0 *1 1921.36,1033.2
X$2951 466 759 758 499 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2964 r0 *1 1886.64,1023.12
X$2964 484 759 758 469 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2971 r0 *1 1915.76,1023.12
X$2971 471 759 758 485 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2976 m0 *1 1891.12,1033.2
X$2976 472 759 758 483 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2996 r0 *1 25.76,1013.04
X$2996 758 478 590 759 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3001 m0 *1 1870.96,1023.12
X$3001 758 759 508 495 482 480 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3006 r0 *1 1878.24,1013.04
X$3006 480 759 758 487 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3011 r0 *1 1883.84,1002.96
X$3011 758 759 481 483 482 484 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3014 r0 *1 1886.64,1013.04
X$3014 758 759 507 506 482 496 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3027 r0 *1 1876,1043.28
X$3027 758 759 530 534 482 531 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3031 m0 *1 989.52,1920.24
X$3031 758 759 694 701 482 697 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3033 r0 *1 992.88,1900.08
X$3033 758 759 637 660 482 638 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3035 m0 *1 999.04,1920.24
X$3035 758 759 736 695 482 696 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3037 r0 *1 1025.36,1920.24
X$3037 758 759 728 723 482 722 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3039 m0 *1 989.52,1043.28
X$3039 758 759 509 529 482 510 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3042 m0 *1 1013.6,1910.16
X$3042 758 759 699 700 482 661 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3063 m0 *1 1915.76,1053.36
X$3063 486 759 758 489 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3072 m0 *1 1890.56,1053.36
X$3072 488 759 758 495 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3077 m0 *1 1920.8,1043.28
X$3077 496 759 758 490 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3105 r0 *1 1896.16,1033.2
X$3105 758 759 497 526 512 498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3113 r0 *1 1924.16,1053.36
X$3113 498 759 758 524 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3121 r0 *1 1904.56,1033.2
X$3121 500 759 758 526 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3125 r0 *1 1899.52,1063.44
X$3125 501 759 758 506 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3129 m0 *1 1924.16,1053.36
X$3129 517 759 758 502 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3132 m0 *1 1907.36,1053.36
X$3132 503 759 758 514 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3163 m0 *1 1876.56,1043.28
X$3163 510 759 758 523 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3166 r0 *1 1878.24,1033.2
X$3166 758 759 511 525 512 513 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3169 m0 *1 1899.52,1033.2
X$3169 758 759 527 514 512 517 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3183 r0 *1 1901.2,1083.6
X$3183 758 759 565 563 512 561 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3186 m0 *1 1901.2,1083.6
X$3186 758 759 556 562 512 555 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3188 m0 *1 1911.28,1063.44
X$3188 758 759 536 544 512 537 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3190 r0 *1 1886.64,1053.36
X$3190 758 759 541 543 512 542 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3192 r0 *1 1898.96,1053.36
X$3192 758 759 532 553 512 533 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3194 m0 *1 1915.76,1093.68
X$3194 758 759 554 558 512 559 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3197 r0 *1 1915.76,1093.68
X$3197 758 759 557 564 512 560 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3203 r0 *1 1884.4,1043.28
X$3203 513 759 758 515 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3212 r0 *1 1898.4,1043.28
X$3212 533 759 758 516 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3222 r0 *1 1907.36,1073.52
X$3222 518 759 758 525 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3226 m0 *1 1924.16,1063.44
X$3226 537 759 758 519 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3230 r0 *1 1915.76,1053.36
X$3230 520 759 758 553 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3235 r0 *1 1898.96,1073.52
X$3235 521 759 758 534 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3238 m0 *1 1915.76,1073.52
X$3238 522 759 758 544 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3256 r0 *1 890.4,1869.84
X$3256 758 759 528 581 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3259 r0 *1 910,1879.92
X$3259 758 759 528 603 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3267 r0 *1 899.36,1879.92
X$3267 758 759 614 601 528 583 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3270 m0 *1 880.32,1879.92
X$3270 758 759 591 592 528 582 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3272 m0 *1 899.92,1859.76
X$3272 758 759 577 593 528 571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3274 r0 *1 985.04,1900.08
X$3274 758 759 659 529 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3282 r0 *1 1907.36,1053.36
X$3282 531 759 758 538 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3301 m0 *1 1902.32,1063.44
X$3301 535 759 758 543 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3313 m0 *1 1907.36,1093.68
X$3313 542 759 758 539 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3340 r0 *1 1886.64,1073.52
X$3340 545 759 758 563 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3343 r0 *1 1886.64,1063.44
X$3343 555 759 758 546 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3349 r0 *1 1907.36,1093.68
X$3349 547 759 758 564 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3352 r0 *1 1924.16,1093.68
X$3352 548 759 758 562 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3355 m0 *1 1924.16,1093.68
X$3355 561 759 758 549 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3358 m0 *1 1924.16,1073.52
X$3358 559 759 758 550 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3361 r0 *1 1915.76,1073.52
X$3361 551 759 758 558 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3364 r0 *1 1924.16,1073.52
X$3364 560 759 758 552 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3420 m0 *1 1921.92,1174.32
X$3420 566 567 759 758 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $3422 m0 *1 1919.68,1174.32
X$3422 758 759 566 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $3426 r0 *1 991.76,1748.88
X$3426 758 568 569 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $3429 r0 *1 970.48,1728.72
X$3429 758 568 570 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $3435 r0 *1 991.76,1758.96
X$3435 758 569 766 759 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $3529 m0 *1 906.64,1900.08
X$3529 571 759 758 629 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3534 m0 *1 889.84,1930.32
X$3534 572 759 758 745 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3546 m0 *1 911.68,1930.32
X$3546 573 759 758 714 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3552 m0 *1 943.04,1900.08
X$3552 657 759 758 575 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3562 m0 *1 945.28,1930.32
X$3562 576 759 758 750 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3574 r0 *1 912.8,1920.24
X$3574 713 759 758 579 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3596 r0 *1 834.4,1910.16
X$3596 758 759 679 702 581 682 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3598 r0 *1 847.84,1900.08
X$3598 758 759 618 645 581 621 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3600 m0 *1 838.32,1910.16
X$3600 758 759 644 667 581 619 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3602 m0 *1 888.72,1900.08
X$3602 758 759 626 600 581 627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3604 r0 *1 881.44,1900.08
X$3604 758 759 625 675 581 628 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3607 m0 *1 872.48,1890
X$3607 758 759 596 597 581 598 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3609 m0 *1 866.32,1900.08
X$3609 758 759 622 643 581 624 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3611 m0 *1 830.48,1879.92
X$3611 758 759 612 590 581 595 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3613 r0 *1 856.24,1900.08
X$3613 758 759 670 671 581 684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3615 m0 *1 863.52,1910.16
X$3615 758 759 646 683 581 648 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3621 r0 *1 864.64,1920.24
X$3621 582 759 758 725 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3628 r0 *1 881.44,1920.24
X$3628 583 759 758 729 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3634 r0 *1 913.36,1890
X$3634 630 759 758 584 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3640 m0 *1 903.28,1930.32
X$3640 733 759 758 586 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3647 r0 *1 927.92,1900.08
X$3647 587 759 758 655 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3650 r0 *1 954.8,1920.24
X$3650 588 759 758 751 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3660 m0 *1 970.48,1930.32
X$3660 589 759 758 752 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3671 r0 *1 873.04,1920.24
X$3671 710 759 758 592 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3679 r0 *1 889.84,1920.24
X$3679 730 759 758 593 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3686 m0 *1 839.44,1930.32
X$3686 595 759 758 741 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3694 m0 *1 879.2,1900.08
X$3694 673 759 758 597 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3702 m0 *1 831.04,1930.32
X$3702 598 759 758 724 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3707 m0 *1 888.16,1890
X$3707 599 759 758 600 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3714 r0 *1 900.48,1900.08
X$3714 650 759 758 601 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3717 r0 *1 904.96,1890
X$3717 758 759 602 685 603 604 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3720 m0 *1 959.84,1900.08
X$3720 758 759 634 639 603 635 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3735 r0 *1 925.12,1910.16
X$3735 758 759 709 689 603 715 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3737 m0 *1 906.64,1920.24
X$3737 758 759 704 706 603 653 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3739 m0 *1 915.04,1900.08
X$3739 758 759 631 642 603 632 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3742 r0 *1 946.4,1920.24
X$3742 758 759 740 716 603 720 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3744 m0 *1 946.4,1910.16
X$3744 758 759 665 664 603 658 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3746 r0 *1 937.44,1900.08
X$3746 758 759 663 668 603 656 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3748 r0 *1 963.2,1920.24
X$3748 758 759 718 719 603 692 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3751 r0 *1 910,1900.08
X$3751 758 759 678 651 603 652 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3758 r0 *1 904.4,1920.24
X$3758 604 759 758 686 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3761 m0 *1 932.4,1900.08
X$3761 605 759 758 633 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3765 m0 *1 946.96,1920.24
X$3765 705 759 758 606 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3768 r0 *1 954.24,1910.16
X$3768 690 759 758 607 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3772 m0 *1 960.96,1910.16
X$3772 691 759 758 608 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3781 r0 *1 980,1920.24
X$3781 610 759 758 737 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3788 m0 *1 981.12,1920.24
X$3788 611 759 758 738 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3812 r0 *1 930.16,1890
X$3812 641 759 758 617 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3821 r0 *1 857.92,1890
X$3821 619 759 758 620 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3830 m0 *1 856.24,1930.32
X$3830 621 759 758 711 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3837 r0 *1 870.8,1890
X$3837 623 759 758 643 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3844 r0 *1 873.04,1900.08
X$3844 624 759 758 674 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3853 m0 *1 897.12,1900.08
X$3853 627 759 758 677 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3861 m0 *1 873.04,1930.32
X$3861 628 759 758 744 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3879 m0 *1 923.44,1900.08
X$3879 632 759 758 669 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3893 m0 *1 962.08,1930.32
X$3893 635 759 758 749 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3898 m0 *1 928.48,1930.32
X$3898 746 759 758 636 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3906 m0 *1 999.04,1930.32
X$3906 638 759 758 735 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3908 m0 *1 951.44,1900.08
X$3908 640 759 758 639 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3921 r0 *1 918.96,1900.08
X$3921 654 759 758 642 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3930 m0 *1 847.84,1930.32
X$3930 742 759 758 645 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3939 r0 *1 864.64,1900.08
X$3939 647 759 758 671 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3945 m0 *1 890.96,1910.16
X$3945 648 759 758 676 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3950 r0 *1 889.84,1900.08
X$3950 649 759 758 675 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3957 m0 *1 864.64,1930.32
X$3957 743 759 758 651 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3962 m0 *1 915.04,1920.24
X$3962 652 759 758 708 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3971 m0 *1 918.4,1910.16
X$3971 653 759 758 688 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3984 r0 *1 938,1920.24
X$3984 656 759 758 717 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3994 r0 *1 945.84,1900.08
X$3994 658 759 758 666 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4000 r0 *1 988.4,1920.24
X$4000 721 759 758 660 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4003 r0 *1 1016.96,1920.24
X$4003 661 759 758 732 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4009 m0 *1 1005.2,1910.16
X$4009 696 759 758 662 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4016 m0 *1 938,1910.16
X$4016 707 759 758 664 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4028 m0 *1 846.72,1910.16
X$4028 681 759 758 667 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4035 m0 *1 920.08,1930.32
X$4035 734 759 758 668 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4054 m0 *1 926.8,1910.16
X$4054 672 759 758 706 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4089 r0 *1 842.8,1910.16
X$4089 680 759 758 702 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4097 m0 *1 855.12,1910.16
X$4097 682 759 758 703 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4102 r0 *1 856.24,1920.24
X$4102 712 759 758 683 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4110 r0 *1 870.24,1910.16
X$4110 684 759 758 726 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4113 m0 *1 881.44,1930.32
X$4113 727 759 758 685 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4123 r0 *1 921.2,1920.24
X$4123 687 759 758 689 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4140 m0 *1 978.88,1930.32
X$4140 692 759 758 754 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4145 m0 *1 983.92,1910.16
X$4145 693 759 758 701 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4150 m0 *1 989.52,1930.32
X$4150 755 759 758 695 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4162 m0 *1 1007.44,1930.32
X$4162 697 759 758 756 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4167 m0 *1 1010.24,1920.24
X$4167 698 759 758 700 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4225 r0 *1 929.6,1920.24
X$4225 715 759 758 739 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4230 m0 *1 936.88,1930.32
X$4230 747 759 758 716 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4241 m0 *1 953.68,1930.32
X$4241 748 759 758 719 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4247 r0 *1 971.6,1920.24
X$4247 720 759 758 753 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4257 m0 *1 1024.24,1930.32
X$4257 722 759 758 731 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4262 m0 *1 1015.84,1930.32
X$4262 757 759 758 723 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS wishbone_master

* cell gf180mcu_fd_sc_mcu9t5v0__buf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.673P PS=26.59U PD=24.5U
* device instance $11 r0 *1 12.07,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.346P AD=11.5839P PS=49U PD=51.09U
* device instance $31 r0 *1 0.92,1.005 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=13.2U AS=3.6696P AD=3.432P PS=20.08U PD=18.4U
* device instance $41 r0 *1 12.12,1.005 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=26.4U AS=6.864P AD=7.1016P PS=36.8U PD=38.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_20

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_2 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.732P PS=4.54U PD=2.63U
* device instance $2 r0 *1 2.17,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.2993P AD=1.3725P PS=5.08U PD=6.99U
* device instance $4 r0 *1 0.92,1.23 nmos_5p0
M$4 3 1 4 3 nmos_5p0 L=0.6U W=0.73U AS=0.3212P AD=0.2695P PS=2.34U PD=1.5U
* device instance $5 r0 *1 2.22,1.265 nmos_5p0
M$5 5 4 3 3 nmos_5p0 L=0.6U W=1.6U AS=0.4775P AD=0.56P PS=2.82U PD=3.8U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyc_2 1 7 11 13
* net 1 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* net 11 I
* net 13 NWELL,VDD
* device instance $1 r0 *1 8.34,3.365 pmos_5p0
M$1 6 5 17 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 8.34,4.085 pmos_5p0
M$2 17 5 13 13 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 10.14,3.785 pmos_5p0
M$3 7 6 13 13 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 4.34,3.365 pmos_5p0
M$5 4 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $6 r0 *1 6.18,3.365 pmos_5p0
M$6 16 4 5 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $7 r0 *1 4.34,4.085 pmos_5p0
M$7 13 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $8 r0 *1 6.18,4.085 pmos_5p0
M$8 13 4 16 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $9 r0 *1 2.18,3.365 pmos_5p0
M$9 15 2 3 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $10 r0 *1 0.87,4.085 pmos_5p0
M$10 13 11 2 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $11 r0 *1 2.18,4.085 pmos_5p0
M$11 13 2 15 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $12 r0 *1 0.92,0.795 nmos_5p0
M$12 1 11 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $13 r0 *1 2.23,0.795 nmos_5p0
M$13 12 2 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $14 r0 *1 2.23,1.515 nmos_5p0
M$14 3 2 12 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $15 r0 *1 4.39,0.52 nmos_5p0
M$15 1 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.2232P PS=1.98U PD=1.6U
* device instance $16 r0 *1 6.23,0.52 nmos_5p0
M$16 10 4 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.2232P AD=0.27P PS=1.6U PD=1.98U
* device instance $17 r0 *1 4.39,1.24 nmos_5p0
M$17 4 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $18 r0 *1 6.23,1.24 nmos_5p0
M$18 5 4 10 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $19 r0 *1 8.39,0.525 nmos_5p0
M$19 1 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $20 r0 *1 8.39,1.245 nmos_5p0
M$20 6 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $21 r0 *1 10.19,1.005 nmos_5p0
M$21 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyc_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_3 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=3.96U AS=1.2672P AD=1.2672P PS=7.2U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_3

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_2
* pin NWELL,VDD
* pin A2
* pin ZN
* pin A1
* pin B
* pin C
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 A2
* net 3 ZN
* net 4 A1
* net 5 B
* net 6 C
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $5 r0 *1 5.43,3.965 pmos_5p0
M$5 3 5 1 1 pmos_5p0 L=0.5U W=2.92U AS=0.9646P AD=1.022P PS=4.51U PD=5.78U
* device instance $6 r0 *1 6.45,3.965 pmos_5p0
M$6 1 6 3 1 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7062P PS=5.36U PD=3.71U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 7 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.43,1.005 nmos_5p0
M$13 11 5 8 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $14 r0 *1 6.4,1.005 nmos_5p0
M$14 7 6 11 7 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $15 r0 *1 7.52,1.005 nmos_5p0
M$15 12 6 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 8.44,1.005 nmos_5p0
M$16 8 5 12 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin C
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_2 1 3 4 5 6 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 NWELL,VDD
* net 5 B1
* net 6 C
* net 8 A2
* net 9 ZN
* net 10 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 2 6 7 4 pmos_5p0 L=0.5U W=3.66U AS=1.4457P AD=0.983625P PS=7.07U PD=4.735U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.1163P PS=4.7U PD=4.88U
* device instance $3 r0 *1 3.01,3.78 pmos_5p0
M$3 2 5 4 4 pmos_5p0 L=0.5U W=3.66U AS=0.9699P AD=0.9699P PS=4.72U PD=4.72U
* device instance $7 r0 *1 7.325,3.78 pmos_5p0
M$7 9 10 7 4 pmos_5p0 L=0.5U W=3.66U AS=0.983625P AD=1.281P PS=4.735U PD=6.89U
* device instance $8 r0 *1 8.345,3.78 pmos_5p0
M$8 7 8 9 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $11 r0 *1 6.32,0.875 nmos_5p0
M$11 9 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.711P AD=0.709025P PS=3.77U PD=4.36U
* device instance $13 r0 *1 2.22,1.072 nmos_5p0
M$13 14 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1422P PS=1.885U PD=1.425U
* device instance $14 r0 *1 3.06,1.072 nmos_5p0
M$14 9 5 14 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 4.18,1.072 nmos_5p0
M$15 12 5 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 5.02,1.072 nmos_5p0
M$16 1 3 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
* device instance $17 r0 *1 7.635,1.072 nmos_5p0
M$17 13 10 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.361425P AD=0.1422P PS=1.9U
+ PD=1.425U
* device instance $18 r0 *1 8.475,1.072 nmos_5p0
M$18 1 8 13 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $19 r0 *1 9.595,1.072 nmos_5p0
M$19 11 8 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $20 r0 *1 10.435,1.072 nmos_5p0
M$20 9 10 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.5214P PS=1.425U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* pin A2
* pin A1
* pin B
* pin ZN
* pin C
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_2 1 2 4 5 6 7 8
* net 1 A2
* net 2 A1
* net 4 B
* net 5 ZN
* net 6 C
* net 7 NWELL,VDD
* net 8 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 5 1 3 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.3359P PS=6.89U PD=5.12U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 3 2 5 7 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.37,3.78 pmos_5p0
M$5 10 4 3 7 pmos_5p0 L=0.5U W=1.83U AS=0.8601P AD=0.2196P PS=2.77U PD=2.07U
* device instance $6 r0 *1 6.11,3.78 pmos_5p0
M$6 7 6 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.549P PS=2.07U PD=2.43U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 9 6 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.549P AD=0.4392P PS=2.43U PD=2.31U
* device instance $8 r0 *1 8.19,3.78 pmos_5p0
M$8 3 4 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.4392P AD=0.8052P PS=2.31U PD=4.54U
* device instance $9 r0 *1 5.02,0.745 nmos_5p0
M$9 5 4 8 8 nmos_5p0 L=0.6U W=1.58U AS=0.5609P AD=0.553P PS=3.195U PD=3.77U
* device instance $10 r0 *1 6.14,0.745 nmos_5p0
M$10 8 6 5 8 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $13 r0 *1 0.92,0.942 nmos_5p0
M$13 12 1 8 8 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.1422P PS=3.25U PD=1.425U
* device instance $14 r0 *1 1.76,0.942 nmos_5p0
M$14 5 2 12 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 2.88,0.942 nmos_5p0
M$15 11 2 5 8 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 3.72,0.942 nmos_5p0
M$16 8 1 11 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__and4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_2 1 2 3 4 5 6 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.925,4.055 pmos_5p0
M$1 7 1 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3328P PS=3.44U PD=1.8U
* device instance $2 r0 *1 1.945,4.055 pmos_5p0
M$2 6 2 7 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $3 r0 *1 2.965,4.055 pmos_5p0
M$3 7 3 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $4 r0 *1 3.985,4.055 pmos_5p0
M$4 7 4 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.558P AD=0.3328P PS=2.53U PD=1.8U
* device instance $5 r0 *1 5.185,3.78 pmos_5p0
M$5 8 7 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.0338P AD=1.281P PS=4.88U PD=6.89U
* device instance $7 r0 *1 0.975,1.005 nmos_5p0
M$7 11 1 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $8 r0 *1 1.895,1.005 nmos_5p0
M$8 10 2 11 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $9 r0 *1 2.915,1.005 nmos_5p0
M$9 9 3 10 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $10 r0 *1 3.935,1.005 nmos_5p0
M$10 5 4 9 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $11 r0 *1 5.055,1.005 nmos_5p0
M$11 8 7 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_2

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A2
* pin A1
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A2
* net 4 A1
* net 5 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.61305P PS=4.54U PD=2.5U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 5 4 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 3 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 5 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 6 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 2 3 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $9 r0 *1 0.92,1.04 nmos_5p0
M$9 5 3 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1224P AD=1.1224P PS=7.04U PD=7.04U
* device instance $10 r0 *1 2.04,1.04 nmos_5p0
M$10 1 4 5 1 nmos_5p0 L=0.6U W=3.68U AS=0.9568P AD=0.9568P PS=5.76U PD=5.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,0.995 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=2.19U AS=0.7008P AD=0.7008P PS=4.84U PD=4.84U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_3

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_2 1 2 3 4 5 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 NWELL,VDD
* net 4 B1
* net 5 ZN
* net 7 A2
* net 8 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 6 3 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.9516P PS=6.89U PD=4.7U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 6 4 3 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 4.95,3.78 pmos_5p0
M$5 5 7 6 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.281P PS=4.7U PD=6.89U
* device instance $6 r0 *1 5.97,3.78 pmos_5p0
M$6 6 8 5 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 12 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 5 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 11 4 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 1 2 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 10 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 5 8 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 9 8 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 A3
* device instance $1 r0 *1 0.92,3.872 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.93765P PS=6.72U PD=4.43U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 11 5 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 4 6 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 6 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 9 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 7 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $11 r0 *1 3.16,1.005 nmos_5p0
M$11 4 7 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2342P PS=3.68U PD=5.83U
* device instance $12 r0 *1 4.28,1.005 nmos_5p0
M$12 8 5 4 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 4 6 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 4 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 10 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 7 5 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 9 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 4 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 11 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 7 5 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6292P PS=2.4U PD=2.55U
* device instance $9 r0 *1 9.93,3.872 pmos_5p0
M$9 4 2 7 7 pmos_5p0 L=0.5U W=6.58U AS=2.117925P AD=2.212525P PS=9.295U
+ PD=10.915U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 4 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 2.04,1.005 nmos_5p0
M$14 3 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $21 r0 *1 9.88,1.005 nmos_5p0
M$21 1 2 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_4

* cell gf180mcu_fd_sc_mcu9t5v0__inv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.7385P PS=7.02U PD=7.39U
* device instance $3 r0 *1 0.92,1.005 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.9438P AD=0.9438P PS=5.39U PD=5.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_16 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7031P PS=21.69U PD=19.78U
* device instance $9 r0 *1 10.01,3.78 pmos_5p0
M$9 4 3 5 5 pmos_5p0 L=0.5U W=29.28U AS=9.2415P AD=9.3147P PS=39.38U PD=41.29U
* device instance $25 r0 *1 0.92,1.3 nmos_5p0
M$25 3 2 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.7295P AD=1.5184P PS=11.34U PD=10U
* device instance $33 r0 *1 10.06,1.265 nmos_5p0
M$33 4 3 1 1 nmos_5p0 L=0.6U W=12.8U AS=3.3895P AD=3.472P PS=21.3U PD=22.28U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16

* cell gf180mcu_fd_sc_mcu9t5v0__addh_2
* pin PWELL,VSS,gf180mcu_gnd
* pin CO
* pin A
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_2 1 2 7 8 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 CO
* net 6 S
* net 7 A
* net 8 B
* net 10 NWELL,VDD
* device instance $1 r0 *1 5.99,3.78 pmos_5p0
M$1 11 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 7.06,3.78 pmos_5p0
M$2 5 7 11 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.52155P PS=2.4U PD=2.4U
* device instance $3 r0 *1 8.13,3.78 pmos_5p0
M$3 10 3 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8784P PS=2.4U PD=2.79U
* device instance $4 r0 *1 9.59,3.78 pmos_5p0
M$4 6 5 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.32675P PS=5.19U PD=6.94U
* device instance $6 r0 *1 0.94,3.78 pmos_5p0
M$6 2 3 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.08885P PS=6.99U PD=4.85U
* device instance $8 r0 *1 3.13,3.78 pmos_5p0
M$8 3 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.4758P PS=2.4U PD=2.35U
* device instance $9 r0 *1 4.15,3.78 pmos_5p0
M$9 10 8 3 10 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 5.94,1.005 nmos_5p0
M$10 5 8 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $11 r0 *1 7.06,1.005 nmos_5p0
M$11 4 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $12 r0 *1 8.18,1.005 nmos_5p0
M$12 1 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5016P PS=1.84U PD=2.08U
* device instance $13 r0 *1 9.54,1.005 nmos_5p0
M$13 6 5 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.8448P AD=0.924P PS=3.92U PD=5.36U
* device instance $15 r0 *1 0.94,1.005 nmos_5p0
M$15 2 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $17 r0 *1 3.18,1.005 nmos_5p0
M$17 9 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 4.1,1.005 nmos_5p0
M$18 3 8 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_2

* cell gf180mcu_fd_sc_mcu9t5v0__addh_4
* pin PWELL,VSS,gf180mcu_gnd
* pin S
* pin A
* pin B
* pin CO
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_4 1 4 5 6 8 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 4 S
* net 5 A
* net 6 B
* net 8 CO
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 2 5 11 11 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.16205P PS=6.89U PD=4.93U
* device instance $2 r0 *1 1.94,3.78 pmos_5p0
M$2 11 6 2 11 pmos_5p0 L=0.5U W=3.66U AS=0.99735P AD=0.99735P PS=4.75U PD=4.75U
* device instance $5 r0 *1 5.28,3.78 pmos_5p0
M$5 7 2 11 11 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.25355P PS=5.03U PD=5.03U
* device instance $6 r0 *1 6.35,3.78 pmos_5p0
M$6 12 5 7 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 7.52,3.78 pmos_5p0
M$7 11 6 12 11 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.5673P PS=2.5U PD=2.45U
* device instance $8 r0 *1 8.64,3.78 pmos_5p0
M$8 13 6 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 9.76,3.78 pmos_5p0
M$9 7 5 13 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 12.18,3.78 pmos_5p0
M$11 8 2 11 11 pmos_5p0 L=0.5U W=7.32U AS=2.38815P AD=2.22345P PS=9.93U PD=9.75U
* device instance $15 r0 *1 16.61,3.78 pmos_5p0
M$15 4 7 11 11 pmos_5p0 L=0.5U W=7.32U AS=2.24175P AD=2.47965P PS=9.77U
+ PD=11.86U
* device instance $19 r0 *1 0.92,1 nmos_5p0
M$19 9 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2772P PS=3.52U PD=1.74U
* device instance $20 r0 *1 1.94,1 nmos_5p0
M$20 2 6 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $21 r0 *1 3.06,1 nmos_5p0
M$21 10 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 3.98,1 nmos_5p0
M$22 1 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.396P PS=1.64U PD=2.02U
* device instance $23 r0 *1 5.28,1.22 nmos_5p0
M$23 3 2 1 1 nmos_5p0 L=0.6U W=1.76U AS=0.792P AD=0.4576P PS=4.04U PD=2.8U
* device instance $24 r0 *1 6.4,1.22 nmos_5p0
M$24 7 5 3 1 nmos_5p0 L=0.6U W=1.76U AS=0.4576P AD=0.4576P PS=2.8U PD=2.8U
* device instance $25 r0 *1 7.52,1.22 nmos_5p0
M$25 3 6 7 1 nmos_5p0 L=0.6U W=1.76U AS=0.4576P AD=0.4576P PS=2.8U PD=2.8U
* device instance $29 r0 *1 12.18,1 nmos_5p0
M$29 8 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4256P AD=1.3728P PS=7.54U PD=7.36U
* device instance $33 r0 *1 16.66,1 nmos_5p0
M$33 4 7 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_2
* pin NWELL,VDD
* pin B2
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B2
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.4758P PS=4.54U PD=2.35U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 6 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $5 r0 *1 5.45,3.78 pmos_5p0
M$5 11 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 6 7 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 10 7 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 6 5 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $14 r0 *1 6.52,1.005 nmos_5p0
M$14 8 7 6 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_2

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_4
* pin NWELL,VDD
* pin A2
* pin A1
* pin Z
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_4 1 2 3 5 6
* net 1 NWELL,VDD
* net 2 A2
* net 3 A1
* net 5 Z
* net 6 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.875 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.28U AS=1.3336P AD=0.8528P PS=6.69U PD=4.32U
* device instance $2 r0 *1 1.89,3.875 pmos_5p0
M$2 1 3 4 1 pmos_5p0 L=0.5U W=3.28U AS=0.8528P AD=0.8528P PS=4.32U PD=4.32U
* device instance $5 r0 *1 5.13,3.78 pmos_5p0
M$5 5 4 1 1 pmos_5p0 L=0.5U W=7.32U AS=2.0394P AD=2.2326P PS=9.58U PD=11.59U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 8 2 6 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 3 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 7 3 4 6 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 6 2 7 6 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 5 4 6 6 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2

* cell gf180mcu_fd_sc_mcu9t5v0__addh_1
* pin CO
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A
* pin B
* pin S
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_1 1 2 3 4 5 9
* net 1 CO
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 NWELL,VDD
* net 4 A
* net 5 B
* net 9 S
* device instance $1 r0 *1 5.01,3.912 pmos_5p0
M$1 10 5 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 6.03,3.912 pmos_5p0
M$2 8 4 10 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.3294P PS=1.435U PD=1.635U
* device instance $3 r0 *1 7.25,3.912 pmos_5p0
M$3 8 6 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.50325P AD=0.3294P PS=2.53U PD=1.635U
* device instance $4 r0 *1 8.45,3.78 pmos_5p0
M$4 9 8 3 3 pmos_5p0 L=0.5U W=1.83U AS=0.50325P AD=0.8052P PS=2.53U PD=4.54U
* device instance $5 r0 *1 2.23,3.912 pmos_5p0
M$5 6 4 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.5307P AD=0.2379P PS=2.59U PD=1.435U
* device instance $6 r0 *1 3.25,3.912 pmos_5p0
M$6 3 5 6 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.4026P PS=1.435U PD=2.71U
* device instance $7 r0 *1 0.97,3.78 pmos_5p0
M$7 3 6 1 3 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5307P PS=4.54U PD=2.59U
* device instance $8 r0 *1 4.96,1.335 nmos_5p0
M$8 8 5 7 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $9 r0 *1 6.08,1.335 nmos_5p0
M$9 7 4 8 2 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.1716P PS=1.18U PD=1.18U
* device instance $10 r0 *1 7.2,1.335 nmos_5p0
M$10 7 6 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1716P PS=2.02U PD=1.18U
* device instance $11 r0 *1 8.5,1.005 nmos_5p0
M$11 9 8 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.5808P PS=2.02U PD=3.52U
* device instance $12 r0 *1 0.92,1.005 nmos_5p0
M$12 2 6 1 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3828P PS=3.52U PD=2.08U
* device instance $13 r0 *1 2.28,1.335 nmos_5p0
M$13 11 4 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.3828P AD=0.0792P PS=2.08U PD=0.9U
* device instance $14 r0 *1 3.12,1.335 nmos_5p0
M$14 6 5 11 2 nmos_5p0 L=0.6U W=0.66U AS=0.0792P AD=0.2904P PS=0.9U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_1

* cell gf180mcu_fd_sc_mcu9t5v0__buf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.2692P PS=11.89U PD=9.8U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.5384P AD=4.7763P PS=19.6U PD=21.69U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $17 r0 *1 5.4,1.005 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.7456P AD=2.9832P PS=14.72U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_8

* cell gf180mcu_fd_sc_mcu9t5v0__buf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.4038P PS=16.79U PD=14.7U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.8076P AD=7.0455P PS=29.4U PD=31.49U
* device instance $19 r0 *1 0.97,1.005 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=7.92U AS=2.2968P AD=2.0592P PS=12.72U PD=11.04U
* device instance $25 r0 *1 7.69,1.005 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=15.84U AS=4.1184P AD=4.356P PS=22.08U PD=23.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_12

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__inv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_4 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_4

* cell gf180mcu_fd_sc_mcu9t5v0__tiel
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__tiel 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.97,3.315 pmos_5p0
M$1 3 3 2 2 pmos_5p0 L=0.5U W=0.9U AS=0.396P AD=0.396P PS=2.68U PD=2.68U
* device instance $2 r0 *1 0.92,1.335 nmos_5p0
M$2 4 3 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.2904P PS=2.2U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__tiel

* cell gf180mcu_fd_sc_mcu9t5v0__dlya_4
* pin I
* pin Z
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlya_4 1 5 6 7
* net 1 I
* net 5 Z
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 3.885,3.61 pmos_5p0
M$1 4 3 6 6 pmos_5p0 L=0.5U W=0.36U AS=0.429P AD=0.1584P PS=2.58U PD=1.6U
* device instance $2 r0 *1 5.135,3.78 pmos_5p0
M$2 5 4 6 6 pmos_5p0 L=0.5U W=7.32U AS=2.1309P AD=2.5071P PS=9.93U PD=11.89U
* device instance $6 r0 *1 0.875,3.61 pmos_5p0
M$6 6 1 2 6 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1116P PS=1.6U PD=0.98U
* device instance $7 r0 *1 1.995,3.61 pmos_5p0
M$7 3 2 6 6 pmos_5p0 L=0.5U W=0.36U AS=0.1116P AD=0.1584P PS=0.98U PD=1.6U
* device instance $8 r0 *1 3.885,0.94 nmos_5p0
M$8 4 3 7 7 nmos_5p0 L=0.6U W=0.36U AS=0.318P AD=0.1584P PS=2.02U PD=1.6U
* device instance $9 r0 *1 5.185,1.005 nmos_5p0
M$9 5 4 7 7 nmos_5p0 L=0.6U W=5.28U AS=1.3476P AD=1.6104P PS=7.54U PD=9.04U
* device instance $13 r0 *1 0.925,0.94 nmos_5p0
M$13 7 1 2 7 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0936P PS=1.6U PD=0.88U
* device instance $14 r0 *1 2.045,0.94 nmos_5p0
M$14 3 2 7 7 nmos_5p0 L=0.6U W=0.36U AS=0.0936P AD=0.1584P PS=0.88U PD=1.6U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlya_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_4 1 3 4 5 6 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 RN
* net 4 Q
* net 5 CLK
* net 6 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 16.975,3.78 pmos_5p0
M$1 4 13 17 17 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U PD=11.59U
* device instance $5 r0 *1 9.55,3.71 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.285P PS=2.88U PD=1.57U
* device instance $6 r0 *1 10.62,3.71 pmos_5p0
M$6 11 2 10 17 pmos_5p0 L=0.5U W=1U AS=0.285P AD=0.26P PS=1.57U PD=1.52U
* device instance $7 r0 *1 11.64,3.71 pmos_5p0
M$7 12 8 11 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2875P PS=1.52U PD=1.575U
* device instance $8 r0 *1 12.715,3.71 pmos_5p0
M$8 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.5457P AD=0.2875P PS=2.57U PD=1.575U
* device instance $9 r0 *1 13.955,3.78 pmos_5p0
M$9 13 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5457P AD=0.4758P PS=2.57U PD=2.35U
* device instance $10 r0 *1 14.975,3.78 pmos_5p0
M$10 17 11 13 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $11 r0 *1 3.73,3.41 pmos_5p0
M$11 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $12 r0 *1 4.75,3.41 pmos_5p0
M$12 9 8 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 5.77,3.41 pmos_5p0
M$13 18 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $14 r0 *1 6.79,3.41 pmos_5p0
M$14 17 10 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $15 r0 *1 7.81,3.41 pmos_5p0
M$15 18 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $16 r0 *1 0.97,3.555 pmos_5p0
M$16 17 5 2 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $17 r0 *1 1.99,3.555 pmos_5p0
M$17 8 2 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $18 r0 *1 16.925,1.005 nmos_5p0
M$18 4 13 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $22 r0 *1 3.9,1.315 nmos_5p0
M$22 7 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $23 r0 *1 5.02,1.315 nmos_5p0
M$23 9 2 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $24 r0 *1 6.14,1.315 nmos_5p0
M$24 15 8 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0708P PS=1.11U PD=0.83U
* device instance $25 r0 *1 6.98,1.315 nmos_5p0
M$25 14 10 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.0826P PS=0.83U PD=0.87U
* device instance $26 r0 *1 7.86,1.315 nmos_5p0
M$26 1 3 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.0826P AD=0.2124P PS=0.87U PD=1.31U
* device instance $27 r0 *1 9.18,1.315 nmos_5p0
M$27 10 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2124P AD=0.190275P PS=1.31U PD=1.235U
* device instance $28 r0 *1 10.425,1.315 nmos_5p0
M$28 11 8 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.190275P AD=0.1534P PS=1.235U
+ PD=1.11U
* device instance $29 r0 *1 11.545,1.315 nmos_5p0
M$29 12 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $30 r0 *1 12.665,1.315 nmos_5p0
M$30 1 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 13.785,1.315 nmos_5p0
M$31 1 3 16 1 nmos_5p0 L=0.6U W=0.59U AS=0.3525P AD=0.1534P PS=2.02U PD=1.11U
* device instance $32 r0 *1 15.085,1.005 nmos_5p0
M$32 13 11 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3525P AD=0.5808P PS=2.02U PD=3.52U
* device instance $33 r0 *1 0.92,1.27 nmos_5p0
M$33 1 5 2 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $34 r0 *1 2.04,1.27 nmos_5p0
M$34 8 2 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 8 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 8 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 9 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 9 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 10 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 10 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.8377P PS=26.59U PD=24.68U
* device instance $11 r0 *1 12.25,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.5107P AD=11.5839P PS=49.18U PD=51.09U
* device instance $31 r0 *1 0.92,1.3 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=7.3U AS=2.1091P AD=1.898P PS=13.84U PD=12.5U
* device instance $41 r0 *1 12.3,1.265 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=16U AS=4.2215P AD=4.304P PS=26.58U PD=27.56U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 10 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 9 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 11 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2
