* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT floating_point_adder a[0] a[10] a[11] a[12] a[13]
+ a[14] a[15] a[16] a[17] a[18] a[19] a[1] a[20] a[21] a[22]
+ a[23] a[24] a[25] a[26] a[27] a[28] a[29] a[2] a[30] a[31]
+ a[3] a[4] a[5] a[6] a[7] a[8] a[9] b[0] b[10] b[11] b[12]
+ b[13] b[14] b[15] b[16] b[17] b[18] b[19] b[1] b[20] b[21]
+ b[22] b[23] b[24] b[25] b[26] b[27] b[28] b[29] b[2] b[30]
+ b[31] b[3] b[4] b[5] b[6] b[7] b[8] b[9] clk inexact invalid_op
+ overflow result[0] result[10] result[11] result[12] result[13]
+ result[14] result[15] result[16] result[17] result[18] result[19]
+ result[1] result[20] result[21] result[22] result[23] result[24]
+ result[25] result[26] result[27] result[28] result[29] result[2]
+ result[30] result[31] result[3] result[4] result[5] result[6]
+ result[7] result[8] result[9] rst_n underflow valid_in valid_out
X_1920_ _1267_ _1268_ _1354_ _1355_ VSS VSS VDD VDD _1356_
+ sky130_fd_sc_hd__o22ai_2
X_1921_ _1571_ _1269_ VSS VSS VDD VDD _1357_ sky130_fd_sc_hd__nor2b_1
X_1922_ _1269_ _1571_ VSS VSS VDD VDD _1358_ sky130_fd_sc_hd__nor2b_1
X_1923_ _1233_ VSS VSS VDD VDD _1359_ sky130_fd_sc_hd__clkbuf_4
X_1924_ _1248_ VSS VSS VDD VDD _1360_ sky130_fd_sc_hd__clkbuf_4
X_1925_ _1357_ _1358_ _1359_ _1360_ VSS VSS VDD VDD _1361_
+ sky130_fd_sc_hd__o211ai_2
X_1926_ _1356_ _1361_ VSS VSS VDD VDD _1362_ sky130_fd_sc_hd__and2_0
X_1927_ _1362_ VSS VSS VDD VDD _1363_ sky130_fd_sc_hd__clkbuf_4
X_1928_ _1299_ VSS VSS VDD VDD _1364_ sky130_fd_sc_hd__buf_4
X_1929_ _1331_ _1335_ _1347_ _1353_ _1363_ _1364_ VSS VSS
+ VDD VDD _1365_ sky130_fd_sc_hd__mux4_1
X_1930_ _1274_ _1365_ VSS VSS VDD VDD _1366_ sky130_fd_sc_hd__and2_0
X_1931_ _1269_ _1571_ VSS VSS VDD VDD _1367_ sky130_fd_sc_hd__nand2_1
X_1932_ _1269_ _1571_ VSS VSS VDD VDD _1368_ sky130_fd_sc_hd__or2_0
X_1933_ _1299_ _1572_ _1367_ _1368_ VSS VSS VDD VDD _1369_
+ sky130_fd_sc_hd__a22o_1
X_1934_ _1234_ _1235_ VSS VSS VDD VDD _1370_ sky130_fd_sc_hd__nand2_2
X_1935_ _1263_ _1370_ VSS VSS VDD VDD _1371_ sky130_fd_sc_hd__xnor2_1
X_1936_ _1310_ _1601_ VSS VSS VDD VDD _1372_ sky130_fd_sc_hd__nor2_1
X_1937_ _1271_ _1369_ _1371_ _1372_ _1238_ VSS VSS VDD VDD
+ _1373_ sky130_fd_sc_hd__a311o_1
X_1938_ _1204_ _1370_ _1607_ VSS VSS VDD VDD _1374_ sky130_fd_sc_hd__a21oi_1
X_1939_ _1271_ _1369_ _1371_ VSS VSS VDD VDD _1375_ sky130_fd_sc_hd__nand3b_1
X_1940_ _1239_ _1374_ _1375_ _1238_ VSS VSS VDD VDD _1376_
+ sky130_fd_sc_hd__o211ai_1
X_1941_ _1374_ _1372_ VSS VSS VDD VDD _1377_ sky130_fd_sc_hd__and2_0
X_1942_ _1310_ _1601_ _1373_ _1376_ _1377_ VSS VSS VDD VDD
+ _1378_ sky130_fd_sc_hd__a221o_2
X_1943_ _1359_ _1360_ _1328_ VSS VSS VDD VDD _1379_ sky130_fd_sc_hd__nand3_4
X_1944_ _1378_ _1341_ _1379_ VSS VSS VDD VDD _1380_ sky130_fd_sc_hd__nor3_4
X_1945_ _1370_ _1296_ _1249_ VSS VSS VDD VDD _1381_ sky130_fd_sc_hd__mux2i_4
X_1946_ _1204_ _1381_ VSS VSS VDD VDD _1382_ sky130_fd_sc_hd__xnor2_4
X_1947_ _1330_ _1293_ VSS VSS VDD VDD _1383_ sky130_fd_sc_hd__nor2_4
X_1948_ _1367_ _1368_ _1318_ _1267_ _1268_ VSS VSS VDD VDD
+ _1384_ sky130_fd_sc_hd__a2111oi_1
X_1949_ _1359_ _1360_ _1300_ _1301_ _1344_ VSS VSS VDD VDD
+ _1385_ sky130_fd_sc_hd__a221oi_1
X_1950_ _1384_ _1385_ VSS VSS VDD VDD _1386_ sky130_fd_sc_hd__nor2_2
X_1951_ net16 _1180_ _1299_ VSS VSS VDD VDD _1387_ sky130_fd_sc_hd__mux2_1
X_1952_ net48 _1298_ VSS VSS VDD VDD _1388_ sky130_fd_sc_hd__nand2_1
X_1953_ _1298_ _1192_ _1388_ VSS VSS VDD VDD _1389_ sky130_fd_sc_hd__o21ai_1
X_1954_ _1233_ _1248_ _1341_ _1292_ _1342_ VSS VSS VDD VDD
+ _1390_ sky130_fd_sc_hd__a2111o_1
X_1955_ _1390_ VSS VSS VDD VDD _1391_ sky130_fd_sc_hd__buf_6
X_1956_ _1387_ _1389_ _1391_ VSS VSS VDD VDD _1392_ sky130_fd_sc_hd__mux2i_4
X_1957_ _1383_ _1386_ _1392_ VSS VSS VDD VDD _1393_ sky130_fd_sc_hd__nor3_4
X_1958_ _1308_ _1273_ VSS VSS VDD VDD _1394_ sky130_fd_sc_hd__xnor2_2
X_1959_ _1393_ _1394_ VSS VSS VDD VDD _1395_ sky130_fd_sc_hd__nand2b_1
X_1960_ _1380_ _1382_ _1395_ VSS VSS VDD VDD _1396_ sky130_fd_sc_hd__nand3_1
X_1961_ _1263_ _1381_ VSS VSS VDD VDD _1397_ sky130_fd_sc_hd__xnor2_4
X_1962_ _1380_ _1397_ VSS VSS VDD VDD _1398_ sky130_fd_sc_hd__nand2_2
X_1963_ _1394_ VSS VSS VDD VDD _1399_ sky130_fd_sc_hd__buf_4
X_1964_ _1364_ VSS VSS VDD VDD _1400_ sky130_fd_sc_hd__buf_4
X_1965_ _1363_ VSS VSS VDD VDD _1401_ sky130_fd_sc_hd__buf_4
X_1966_ _1401_ VSS VSS VDD VDD _1402_ sky130_fd_sc_hd__clkbuf_4
X_1967_ _1341_ _1342_ VSS VSS VDD VDD _1403_ sky130_fd_sc_hd__nor2_2
X_1968_ _1293_ _1403_ VSS VSS VDD VDD _1404_ sky130_fd_sc_hd__nand2_4
X_1969_ _1344_ VSS VSS VDD VDD _1405_ sky130_fd_sc_hd__clkbuf_4
X_1970_ net12 net15 _1405_ VSS VSS VDD VDD _1406_ sky130_fd_sc_hd__mux2i_2
X_1971_ _1318_ VSS VSS VDD VDD _1407_ sky130_fd_sc_hd__clkbuf_4
X_1972_ net44 net47 _1407_ VSS VSS VDD VDD _1408_ sky130_fd_sc_hd__mux2i_2
X_1973_ net44 net47 _1344_ VSS VSS VDD VDD _1409_ sky130_fd_sc_hd__mux2i_1
X_1974_ a_exp_larger _1292_ _1343_ _1409_ VSS VSS VDD VDD
+ _1410_ sky130_fd_sc_hd__or4_1
X_1975_ _1404_ _1406_ _1408_ _1379_ _1410_ VSS VSS VDD VDD
+ _1411_ sky130_fd_sc_hd__o221ai_4
X_1976_ _1293_ VSS VSS VDD VDD _1412_ sky130_fd_sc_hd__buf_4
X_1977_ _1294_ VSS VSS VDD VDD _1413_ sky130_fd_sc_hd__buf_4
X_1978_ net8 net10 _1413_ VSS VSS VDD VDD _1414_ sky130_fd_sc_hd__mux2i_1
X_1979_ _1295_ _1315_ _1414_ VSS VSS VDD VDD _1415_ sky130_fd_sc_hd__nand3_1
X_1980_ net42 _1413_ VSS VSS VDD VDD _1416_ sky130_fd_sc_hd__nand2_1
X_1981_ _1643_ _1413_ _1341_ _1342_ _1416_ VSS VSS VDD VDD
+ _1417_ sky130_fd_sc_hd__o221ai_4
X_1982_ net42 _1319_ VSS VSS VDD VDD _1418_ sky130_fd_sc_hd__nand2_1
X_1983_ _1643_ _1407_ _1418_ VSS VSS VDD VDD _1419_ sky130_fd_sc_hd__o21ai_1
X_1984_ _1412_ _1415_ _1417_ _1419_ _1330_ VSS VSS VDD VDD
+ _1420_ sky130_fd_sc_hd__a32oi_4
X_1985_ _1363_ _1420_ VSS VSS VDD VDD _1421_ sky130_fd_sc_hd__nand2_1
X_1986_ _1402_ _1411_ _1421_ VSS VSS VDD VDD _1422_ sky130_fd_sc_hd__o21a_1
X_1987_ _1319_ _1359_ _1360_ _1328_ VSS VSS VDD VDD _1423_
+ sky130_fd_sc_hd__nand4_1
X_1988_ _1294_ VSS VSS VDD VDD _1424_ sky130_fd_sc_hd__inv_1
X_1989_ _1359_ _1360_ _1292_ _1424_ VSS VSS VDD VDD _1425_
+ sky130_fd_sc_hd__a211o_1
X_1990_ net14 VSS VSS VDD VDD _1426_ sky130_fd_sc_hd__inv_1
X_1991_ _1423_ _1425_ _1426_ VSS VSS VDD VDD _1427_ sky130_fd_sc_hd__a21oi_1
X_1992_ _1318_ VSS VSS VDD VDD _1428_ sky130_fd_sc_hd__inv_1
X_1993_ _1428_ _1359_ _1360_ _1328_ VSS VSS VDD VDD _1429_
+ sky130_fd_sc_hd__nand4_2
X_1994_ _1359_ _1360_ _1292_ _1344_ VSS VSS VDD VDD _1430_
+ sky130_fd_sc_hd__a211o_1
X_1995_ net11 VSS VSS VDD VDD _1431_ sky130_fd_sc_hd__inv_1
X_1996_ _1429_ _1430_ _1431_ VSS VSS VDD VDD _1432_ sky130_fd_sc_hd__a21oi_1
X_1997_ _1427_ _1432_ _1337_ VSS VSS VDD VDD _1433_ sky130_fd_sc_hd__o21ai_2
X_1998_ _1429_ _1430_ _1670_ VSS VSS VDD VDD _1434_ sky130_fd_sc_hd__a21oi_1
X_1999_ _1423_ _1425_ _1685_ VSS VSS VDD VDD _1435_ sky130_fd_sc_hd__a21oi_1
X_2000_ _1434_ _1435_ _1404_ VSS VSS VDD VDD _1436_ sky130_fd_sc_hd__o21ai_2
X_2001_ _1356_ _1361_ VSS VSS VDD VDD _1437_ sky130_fd_sc_hd__nand2_4
X_2002_ _1437_ VSS VSS VDD VDD _1438_ sky130_fd_sc_hd__clkbuf_4
X_2003_ net41 _1413_ VSS VSS VDD VDD _1439_ sky130_fd_sc_hd__nand2_1
X_2004_ _1646_ _1413_ _1336_ _1316_ _1439_ VSS VSS VDD VDD
+ _1440_ sky130_fd_sc_hd__o221ai_4
X_2005_ net7 net9 _1413_ VSS VSS VDD VDD _1441_ sky130_fd_sc_hd__mux2i_1
X_2006_ _1293_ _1403_ _1441_ VSS VSS VDD VDD _1442_ sky130_fd_sc_hd__nand3_1
X_2007_ net39 net41 _1319_ VSS VSS VDD VDD _1443_ sky130_fd_sc_hd__mux2i_1
X_2008_ _1379_ _1443_ VSS VSS VDD VDD _1444_ sky130_fd_sc_hd__nor2_1
X_2009_ _1412_ _1440_ _1442_ _1444_ _1437_ VSS VSS VDD VDD
+ _1445_ sky130_fd_sc_hd__a311oi_2
X_2010_ _1433_ _1436_ _1438_ _1445_ _1400_ VSS VSS VDD VDD
+ _1446_ sky130_fd_sc_hd__a311oi_2
X_2011_ _1400_ _1422_ _1446_ VSS VSS VDD VDD _1447_ sky130_fd_sc_hd__a21oi_4
X_2012_ _1391_ VSS VSS VDD VDD _1448_ sky130_fd_sc_hd__buf_4
X_2013_ net60 _1448_ VSS VSS VDD VDD _1449_ sky130_fd_sc_hd__nand2_1
X_2014_ _1343_ VSS VSS VDD VDD _1450_ sky130_fd_sc_hd__buf_4
X_2015_ net28 _1450_ VSS VSS VDD VDD _1451_ sky130_fd_sc_hd__nand2_1
X_2016_ _1318_ _1359_ _1360_ VSS VSS VDD VDD _1452_ sky130_fd_sc_hd__nand3_2
X_2017_ _1267_ _1268_ _1344_ VSS VSS VDD VDD _1453_ sky130_fd_sc_hd__o21ai_2
X_2018_ _1452_ _1453_ VSS VSS VDD VDD _1454_ sky130_fd_sc_hd__and2_0
X_2019_ _1454_ VSS VSS VDD VDD _1455_ sky130_fd_sc_hd__buf_2
X_2020_ _1449_ _1451_ _1455_ VSS VSS VDD VDD _1456_ sky130_fd_sc_hd__a21oi_1
X_2021_ net56 _1448_ VSS VSS VDD VDD _1457_ sky130_fd_sc_hd__nand2_1
X_2022_ net24 _1450_ VSS VSS VDD VDD _1458_ sky130_fd_sc_hd__nand2_1
X_2023_ _1452_ _1453_ VSS VSS VDD VDD _1459_ sky130_fd_sc_hd__nand2_8
X_2024_ _1457_ _1458_ _1459_ VSS VSS VDD VDD _1460_ sky130_fd_sc_hd__a21oi_1
X_2025_ _1456_ _1460_ VSS VSS VDD VDD _1461_ sky130_fd_sc_hd__nor2_1
X_2026_ _1429_ _1430_ VSS VSS VDD VDD _1462_ sky130_fd_sc_hd__nand2_4
X_2027_ net27 net59 _1391_ VSS VSS VDD VDD _1463_ sky130_fd_sc_hd__mux2_1
X_2028_ net29 net61 _1391_ VSS VSS VDD VDD _1464_ sky130_fd_sc_hd__mux2_1
X_2029_ _1423_ _1425_ VSS VSS VDD VDD _1465_ sky130_fd_sc_hd__nand2_2
X_2030_ _1462_ _1463_ _1464_ _1465_ VSS VSS VDD VDD _1466_
+ sky130_fd_sc_hd__a22oi_2
X_2031_ _1298_ _1363_ VSS VSS VDD VDD _1467_ sky130_fd_sc_hd__nor2_1
X_2032_ _1466_ _1467_ VSS VSS VDD VDD _1468_ sky130_fd_sc_hd__nand2b_1
X_2033_ _1400_ _1383_ _1402_ _1461_ _1468_ VSS VSS VDD VDD
+ _1469_ sky130_fd_sc_hd__o41ai_1
X_2034_ _1274_ VSS VSS VDD VDD _1470_ sky130_fd_sc_hd__clkbuf_4
X_2035_ net13 net2 net45 net34 _1298_ _1404_ VSS VSS VDD VDD
+ _1471_ sky130_fd_sc_hd__mux4_1
X_2036_ _1465_ _1402_ _1471_ VSS VSS VDD VDD _1472_ sky130_fd_sc_hd__nand3_1
X_2037_ _1470_ _1472_ VSS VSS VDD VDD _1473_ sky130_fd_sc_hd__nand2_1
X_2038_ _1399_ _1447_ _1469_ _1473_ VSS VSS VDD VDD _1474_
+ sky130_fd_sc_hd__o2bb2ai_1
X_2039_ _1366_ _1396_ _1398_ _1474_ VSS VSS VDD VDD _0051_
+ sky130_fd_sc_hd__o22ai_1
X_2040_ _1379_ _1336_ VSS VSS VDD VDD _1475_ sky130_fd_sc_hd__nand2_4
X_2041_ net41 _1424_ VSS VSS VDD VDD _1476_ sky130_fd_sc_hd__nand2_1
X_2042_ net43 _1294_ VSS VSS VDD VDD _1477_ sky130_fd_sc_hd__nand2_1
X_2043_ _1359_ _1360_ _1476_ _1477_ VSS VSS VDD VDD _1478_
+ sky130_fd_sc_hd__a22oi_1
X_2044_ _1676_ _1318_ _1267_ _1268_ VSS VSS VDD VDD _1479_
+ sky130_fd_sc_hd__nor4_1
X_2045_ net43 _1318_ a_exp_larger _1478_ _1479_ VSS VSS VDD
+ VDD _1480_ sky130_fd_sc_hd__a311o_1
X_2046_ net9 _1424_ VSS VSS VDD VDD _1481_ sky130_fd_sc_hd__nand2_1
X_2047_ net11 _1344_ VSS VSS VDD VDD _1482_ sky130_fd_sc_hd__nand2_1
X_2048_ _1359_ _1360_ _1481_ _1482_ VSS VSS VDD VDD _1483_
+ sky130_fd_sc_hd__a22oi_1
X_2049_ net9 _1428_ VSS VSS VDD VDD _1484_ sky130_fd_sc_hd__nand2_1
X_2050_ net11 _1318_ VSS VSS VDD VDD _1485_ sky130_fd_sc_hd__nand2_1
X_2051_ _1484_ _1485_ _1267_ _1268_ VSS VSS VDD VDD _1486_
+ sky130_fd_sc_hd__a211oi_1
X_2052_ _1483_ _1486_ _1450_ VSS VSS VDD VDD _1487_ sky130_fd_sc_hd__o21a_1
X_2053_ _1475_ _1391_ _1480_ _1487_ VSS VSS VDD VDD _1488_
+ sky130_fd_sc_hd__a31oi_4
X_2054_ _1298_ VSS VSS VDD VDD _1489_ sky130_fd_sc_hd__clkbuf_4
X_2055_ _1489_ _1437_ VSS VSS VDD VDD _1490_ sky130_fd_sc_hd__nor2_1
X_2056_ _1298_ _1437_ VSS VSS VDD VDD _1491_ sky130_fd_sc_hd__nand2_1
X_2057_ _1491_ _1411_ _1421_ _1364_ VSS VSS VDD VDD _1492_
+ sky130_fd_sc_hd__o22ai_2
X_2058_ net14 net16 _1459_ VSS VSS VDD VDD _1493_ sky130_fd_sc_hd__mux2i_1
X_2059_ net46 net48 _1459_ VSS VSS VDD VDD _1494_ sky130_fd_sc_hd__mux2i_1
X_2060_ _1475_ _1448_ VSS VSS VDD VDD _1495_ sky130_fd_sc_hd__nand2_1
X_2061_ _1448_ _1493_ _1494_ _1495_ _1467_ VSS VSS VDD VDD
+ _1496_ sky130_fd_sc_hd__o221a_1
X_2062_ _1488_ _1490_ _1492_ _1496_ VSS VSS VDD VDD _1497_
+ sky130_fd_sc_hd__a211oi_4
X_2063_ net28 net30 _1405_ VSS VSS VDD VDD _1498_ sky130_fd_sc_hd__mux2i_1
X_2064_ _1412_ _1403_ _1498_ VSS VSS VDD VDD _1499_ sky130_fd_sc_hd__nand3_1
X_2065_ net62 _1405_ VSS VSS VDD VDD _1500_ sky130_fd_sc_hd__nand2_1
X_2066_ _1640_ _1405_ _1336_ _1316_ _1500_ VSS VSS VDD VDD
+ _1501_ sky130_fd_sc_hd__o221ai_1
X_2067_ net60 net62 _1407_ VSS VSS VDD VDD _1502_ sky130_fd_sc_hd__mux2i_1
X_2068_ _1379_ _1502_ VSS VSS VDD VDD _1503_ sky130_fd_sc_hd__nor2_1
X_2069_ _1412_ _1499_ _1501_ _1503_ VSS VSS VDD VDD _1504_
+ sky130_fd_sc_hd__a31oi_2
X_2070_ _1466_ _1504_ _1364_ VSS VSS VDD VDD _1505_ sky130_fd_sc_hd__mux2_1
X_2071_ net13 net24 net45 net56 _1364_ _1404_ VSS VSS VDD
+ VDD _1506_ sky130_fd_sc_hd__mux4_1
X_2072_ _1475_ _1506_ VSS VSS VDD VDD _1507_ sky130_fd_sc_hd__nand2_1
X_2073_ _1455_ _1437_ VSS VSS VDD VDD _1508_ sky130_fd_sc_hd__nor2_1
X_2074_ net2 net34 _1448_ VSS VSS VDD VDD _1509_ sky130_fd_sc_hd__mux2i_1
X_2075_ _1489_ _1383_ _1509_ VSS VSS VDD VDD _1510_ sky130_fd_sc_hd__nor3_1
X_2076_ _1386_ _1510_ _1274_ _1397_ VSS VSS VDD VDD _1511_
+ sky130_fd_sc_hd__o211ai_1
X_2077_ _1438_ _1505_ _1507_ _1508_ _1511_ VSS VSS VDD VDD
+ _1512_ sky130_fd_sc_hd__a221oi_1
X_2078_ _1489_ _1363_ VSS VSS VDD VDD _1513_ sky130_fd_sc_hd__nand2_1
X_2079_ _1491_ _1347_ _1353_ _1513_ VSS VSS VDD VDD _1514_
+ sky130_fd_sc_hd__o22ai_1
X_2080_ net35 _1405_ VSS VSS VDD VDD _1515_ sky130_fd_sc_hd__nand2_1
X_2081_ _1664_ _1405_ _1336_ _1316_ _1515_ VSS VSS VDD VDD
+ _1516_ sky130_fd_sc_hd__o221ai_2
X_2082_ net32 VSS VSS VDD VDD _1517_ sky130_fd_sc_hd__inv_1
X_2083_ net3 _1405_ VSS VSS VDD VDD _1518_ sky130_fd_sc_hd__nand2_1
X_2084_ _1517_ _1405_ _1412_ _1403_ _1518_ VSS VSS VDD VDD
+ _1519_ sky130_fd_sc_hd__o2111ai_2
X_2085_ net64 net35 _1407_ VSS VSS VDD VDD _1520_ sky130_fd_sc_hd__mux2i_1
X_2086_ _1379_ _1520_ VSS VSS VDD VDD _1521_ sky130_fd_sc_hd__nor2_1
X_2087_ _1412_ _1516_ _1519_ _1521_ VSS VSS VDD VDD _1522_
+ sky130_fd_sc_hd__a31oi_4
X_2088_ net5 net7 _1344_ VSS VSS VDD VDD _1523_ sky130_fd_sc_hd__mux2i_1
X_2089_ _1295_ _1315_ _1523_ VSS VSS VDD VDD _1524_ sky130_fd_sc_hd__nand3_1
X_2090_ net39 _1413_ VSS VSS VDD VDD _1525_ sky130_fd_sc_hd__nand2_1
X_2091_ _1652_ _1413_ _1341_ _1342_ _1525_ VSS VSS VDD VDD
+ _1526_ sky130_fd_sc_hd__o221ai_4
X_2092_ net39 _1319_ VSS VSS VDD VDD _1527_ sky130_fd_sc_hd__nand2_1
X_2093_ _1652_ _1407_ _1527_ VSS VSS VDD VDD _1528_ sky130_fd_sc_hd__o21ai_1
X_2094_ _1293_ _1524_ _1526_ _1528_ _1330_ VSS VSS VDD VDD
+ _1529_ sky130_fd_sc_hd__a32oi_4
X_2095_ _1437_ _1529_ VSS VSS VDD VDD _1530_ sky130_fd_sc_hd__and2_0
X_2096_ _1363_ _1522_ _1530_ _1489_ VSS VSS VDD VDD _1531_
+ sky130_fd_sc_hd__a211oi_1
X_2097_ _1178_ _1179_ VSS VSS VDD VDD _1532_ sky130_fd_sc_hd__and2_0
X_2098_ _1532_ _1192_ _1391_ VSS VSS VDD VDD _1533_ sky130_fd_sc_hd__mux2i_2
X_2099_ _1299_ _1383_ _1386_ _1533_ VSS VSS VDD VDD _1534_
+ sky130_fd_sc_hd__or4b_1
X_2100_ _1534_ VSS VSS VDD VDD _1535_ sky130_fd_sc_hd__buf_2
X_2101_ _1399_ _1535_ VSS VSS VDD VDD _1536_ sky130_fd_sc_hd__nand2_1
X_2102_ _1399_ _1514_ _1531_ _1536_ _1382_ VSS VSS VDD VDD
+ _1537_ sky130_fd_sc_hd__o311a_1
X_2103_ _1399_ _1397_ _1497_ _1512_ _1537_ VSS VSS VDD VDD
+ _1538_ sky130_fd_sc_hd__a311o_1
X_2104_ _1380_ _1538_ VSS VSS VDD VDD _0062_ sky130_fd_sc_hd__and2_0
X_2105_ net33 net4 _1405_ VSS VSS VDD VDD _1539_ sky130_fd_sc_hd__mux2_1
X_2106_ net36 _1407_ VSS VSS VDD VDD _1540_ sky130_fd_sc_hd__nand2_1
X_2107_ _1661_ _1407_ _1540_ VSS VSS VDD VDD _1541_ sky130_fd_sc_hd__o21ai_1
X_2108_ net65 net36 _1405_ VSS VSS VDD VDD _1542_ sky130_fd_sc_hd__mux2i_1
X_2109_ a_exp_larger _1292_ _1450_ _1542_ VSS VSS VDD VDD
+ _1543_ sky130_fd_sc_hd__nor4_1
X_2110_ _1337_ _1539_ _1541_ _1330_ _1543_ VSS VSS VDD VDD
+ _1544_ sky130_fd_sc_hd__a221oi_4
X_2111_ net6 net8 net38 net40 _1413_ _1316_ VSS VSS VDD VDD
+ _1545_ sky130_fd_sc_hd__mux4_1
X_2112_ net38 net40 _1407_ VSS VSS VDD VDD _1546_ sky130_fd_sc_hd__mux2i_1
X_2113_ _1379_ _1546_ VSS VSS VDD VDD _1547_ sky130_fd_sc_hd__nor2_1
X_2114_ _1412_ _1545_ _1547_ _1401_ VSS VSS VDD VDD _1548_
+ sky130_fd_sc_hd__a211oi_1
X_2115_ _1401_ _1544_ _1548_ VSS VSS VDD VDD _1549_ sky130_fd_sc_hd__a21oi_2
X_2116_ _1401_ _1522_ _1530_ _1400_ VSS VSS VDD VDD _1550_
+ sky130_fd_sc_hd__a211oi_2
X_2117_ _1400_ _1549_ _1550_ VSS VSS VDD VDD _1551_ sky130_fd_sc_hd__a21oi_4
X_2118_ _1380_ _1470_ _1382_ VSS VSS VDD VDD _1552_ sky130_fd_sc_hd__nand3_4
X_2119_ _1189_ _1250_ VSS VSS VDD VDD _1553_ sky130_fd_sc_hd__or2_0
X_2120_ _1553_ VSS VSS VDD VDD _1554_ sky130_fd_sc_hd__buf_2
X_2121_ _1399_ _1398_ VSS VSS VDD VDD _1555_ sky130_fd_sc_hd__nor2_4
X_2122_ _1475_ _1401_ VSS VSS VDD VDD _1556_ sky130_fd_sc_hd__nand2_2
X_2123_ net27 net24 net59 net56 _1298_ _1404_ VSS VSS VDD
+ VDD _1557_ sky130_fd_sc_hd__mux4_1
X_2124_ _1471_ _1557_ _1459_ VSS VSS VDD VDD _1558_ sky130_fd_sc_hd__mux2i_1
X_2125_ net29 net31 net61 net63 _1413_ _1316_ VSS VSS VDD
+ VDD _1559_ sky130_fd_sc_hd__mux4_1
X_2126_ net63 _1407_ VSS VSS VDD VDD _1560_ sky130_fd_sc_hd__nand2_1
X_2127_ _1637_ _1407_ _1560_ VSS VSS VDD VDD _1561_ sky130_fd_sc_hd__o21ai_1
X_2128_ _1412_ _1559_ _1561_ _1330_ VSS VSS VDD VDD _1562_
+ sky130_fd_sc_hd__a22oi_4
X_2129_ _1504_ _1562_ _1364_ VSS VSS VDD VDD _1563_ sky130_fd_sc_hd__mux2_1
X_2130_ _1556_ _1558_ _1563_ _1402_ VSS VSS VDD VDD _1564_
+ sky130_fd_sc_hd__o22ai_1
X_2131_ net34 _1554_ _1555_ _1564_ VSS VSS VDD VDD _0122_
+ sky130_fd_sc_hd__a22oi_1
X_2132_ net44 _1391_ VSS VSS VDD VDD _0123_ sky130_fd_sc_hd__nand2_1
X_2133_ net12 _1450_ VSS VSS VDD VDD _0124_ sky130_fd_sc_hd__nand2_1
X_2134_ _0123_ _0124_ _1455_ VSS VSS VDD VDD _0125_ sky130_fd_sc_hd__a21oi_1
X_2135_ net42 _1448_ VSS VSS VDD VDD _0126_ sky130_fd_sc_hd__nand2_1
X_2136_ net10 _1450_ VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__nand2_1
X_2137_ _0126_ _0127_ _1459_ VSS VSS VDD VDD _0128_ sky130_fd_sc_hd__a21oi_1
X_2138_ _0125_ _0128_ _1364_ _1475_ VSS VSS VDD VDD _0129_
+ sky130_fd_sc_hd__o211ai_2
X_2139_ _1364_ _1488_ VSS VSS VDD VDD _0130_ sky130_fd_sc_hd__or2_0
X_2140_ _1383_ _1392_ VSS VSS VDD VDD _0131_ sky130_fd_sc_hd__nor2_2
X_2141_ net15 net14 net47 net46 _1298_ _1391_ VSS VSS VDD
+ VDD _0132_ sky130_fd_sc_hd__mux4_2
X_2142_ _1459_ _0131_ _0132_ _1462_ _1363_ VSS VSS VDD VDD
+ _0133_ sky130_fd_sc_hd__a221oi_4
X_2143_ _1401_ _0129_ _0130_ _0133_ VSS VSS VDD VDD _0134_
+ sky130_fd_sc_hd__a31oi_4
X_2144_ _1470_ _1398_ VSS VSS VDD VDD _0135_ sky130_fd_sc_hd__nor2_2
X_2145_ _0134_ _0135_ VSS VSS VDD VDD _0136_ sky130_fd_sc_hd__nand2_1
X_2146_ _1551_ _1552_ _0122_ _0136_ VSS VSS VDD VDD _0069_
+ sky130_fd_sc_hd__o211ai_1
X_2147_ _0125_ _0128_ VSS VSS VDD VDD _0137_ sky130_fd_sc_hd__nor2_1
X_2148_ _1455_ _1533_ VSS VSS VDD VDD _0138_ sky130_fd_sc_hd__or2_0
X_2149_ net15 _1450_ VSS VSS VDD VDD _0139_ sky130_fd_sc_hd__nand2_1
X_2150_ _1682_ _1337_ _1455_ _0139_ VSS VSS VDD VDD _0140_
+ sky130_fd_sc_hd__o211ai_2
X_2151_ net16 net48 _1448_ VSS VSS VDD VDD _0141_ sky130_fd_sc_hd__mux2i_1
X_2152_ _1489_ _1459_ _0141_ VSS VSS VDD VDD _0142_ sky130_fd_sc_hd__nor3_1
X_2153_ _1489_ _0138_ _0140_ _0142_ VSS VSS VDD VDD _0143_
+ sky130_fd_sc_hd__a31oi_4
X_2154_ _1513_ _0137_ _0143_ _1402_ VSS VSS VDD VDD _0144_
+ sky130_fd_sc_hd__o22ai_2
X_2155_ _1489_ VSS VSS VDD VDD _0145_ sky130_fd_sc_hd__clkbuf_4
X_2156_ _1433_ _1436_ VSS VSS VDD VDD _0146_ sky130_fd_sc_hd__and2_0
X_2157_ _0145_ _0146_ _1438_ VSS VSS VDD VDD _0147_ sky130_fd_sc_hd__nor3_1
X_2158_ _1475_ _0144_ _0147_ VSS VSS VDD VDD _0148_ sky130_fd_sc_hd__a21oi_4
X_2159_ _1412_ _1440_ _1442_ _1444_ VSS VSS VDD VDD _0149_
+ sky130_fd_sc_hd__a31oi_2
X_2160_ _0145_ _1401_ _0149_ VSS VSS VDD VDD _0150_ sky130_fd_sc_hd__nor3_1
X_2161_ _0145_ _1438_ _1331_ VSS VSS VDD VDD _0151_ sky130_fd_sc_hd__nor3_1
X_2162_ _0145_ _1549_ _0150_ _0151_ VSS VSS VDD VDD _0152_
+ sky130_fd_sc_hd__a211oi_4
X_2163_ net27 net28 net59 net60 _1364_ _1404_ VSS VSS VDD
+ VDD _0153_ sky130_fd_sc_hd__mux4_1
X_2164_ _1506_ _0153_ _1459_ VSS VSS VDD VDD _0154_ sky130_fd_sc_hd__mux2i_1
X_2165_ _1335_ _1562_ _0145_ VSS VSS VDD VDD _0155_ sky130_fd_sc_hd__mux2i_1
X_2166_ _1556_ _0154_ _0155_ _1438_ VSS VSS VDD VDD _0156_
+ sky130_fd_sc_hd__a2bb2oi_1
X_2167_ _1380_ _1274_ _1397_ VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__nand3_1
X_2168_ _0157_ VSS VSS VDD VDD _0158_ sky130_fd_sc_hd__clkbuf_4
X_2169_ net45 _1554_ VSS VSS VDD VDD _0159_ sky130_fd_sc_hd__nand2_1
X_2170_ _1552_ _0152_ _0156_ _0158_ _0159_ VSS VSS VDD VDD
+ _0160_ sky130_fd_sc_hd__o221a_1
X_2171_ _1470_ _1398_ _0148_ _0160_ VSS VSS VDD VDD _0070_
+ sky130_fd_sc_hd__o31ai_1
X_2172_ _1438_ _1466_ VSS VSS VDD VDD _0161_ sky130_fd_sc_hd__nor2_1
X_2173_ _1402_ _1353_ _1400_ VSS VSS VDD VDD _0162_ sky130_fd_sc_hd__o21ai_0
X_2174_ _1461_ _1556_ _1335_ _1402_ VSS VSS VDD VDD _0163_
+ sky130_fd_sc_hd__o22ai_1
X_2175_ _0161_ _0162_ _0163_ _1400_ VSS VSS VDD VDD _0164_
+ sky130_fd_sc_hd__o22ai_2
X_2176_ _1554_ VSS VSS VDD VDD _0165_ sky130_fd_sc_hd__clkbuf_4
X_2177_ _1420_ _0149_ _1347_ _1331_ _1298_ _1363_ VSS VSS
+ VDD VDD _0166_ sky130_fd_sc_hd__mux4_2
X_2178_ _1552_ _0166_ VSS VSS VDD VDD _0167_ sky130_fd_sc_hd__nor2_1
X_2179_ net56 _0165_ _0167_ VSS VSS VDD VDD _0168_ sky130_fd_sc_hd__a21oi_1
X_2180_ _1489_ _1433_ _1436_ VSS VSS VDD VDD _0169_ sky130_fd_sc_hd__and3_1
X_2181_ _1489_ _1411_ VSS VSS VDD VDD _0170_ sky130_fd_sc_hd__nor2_1
X_2182_ _1455_ _1438_ _0131_ VSS VSS VDD VDD _0171_ sky130_fd_sc_hd__nand3_1
X_2183_ _1437_ _0169_ _0170_ _0171_ VSS VSS VDD VDD _0172_
+ sky130_fd_sc_hd__o31a_2
X_2184_ _0172_ _0135_ VSS VSS VDD VDD _0173_ sky130_fd_sc_hd__nand2b_1
X_2185_ _0158_ _0164_ _0168_ _0173_ VSS VSS VDD VDD _0071_
+ sky130_fd_sc_hd__o211ai_2
X_2186_ _0145_ _1475_ _1455_ _1533_ VSS VSS VDD VDD _0174_
+ sky130_fd_sc_hd__nand4_1
X_2187_ _1448_ _1493_ _1494_ _1495_ VSS VSS VDD VDD _0175_
+ sky130_fd_sc_hd__o22ai_1
X_2188_ _1489_ _1411_ _1437_ VSS VSS VDD VDD _0176_ sky130_fd_sc_hd__a21o_1
X_2189_ _1400_ _0175_ _0176_ VSS VSS VDD VDD _0177_ sky130_fd_sc_hd__a21oi_1
X_2190_ _1438_ _0174_ _0177_ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__a21oi_4
X_2191_ _1504_ _1522_ _1437_ VSS VSS VDD VDD _0179_ sky130_fd_sc_hd__mux2i_1
X_2192_ _1402_ _1353_ _0145_ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__o21ai_0
X_2193_ _0145_ _0179_ _0180_ _0161_ VSS VSS VDD VDD _0181_
+ sky130_fd_sc_hd__o22ai_1
X_2194_ _0158_ _0181_ VSS VSS VDD VDD _0182_ sky130_fd_sc_hd__nor2_1
X_2195_ _1380_ _1274_ _1382_ VSS VSS VDD VDD _0183_ sky130_fd_sc_hd__and3_1
X_2196_ _0183_ VSS VSS VDD VDD _0184_ sky130_fd_sc_hd__clkbuf_2
X_2197_ _1420_ _1347_ _1401_ VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__mux2i_1
X_2198_ _1488_ _1529_ _1401_ VSS VSS VDD VDD _0186_ sky130_fd_sc_hd__mux2i_2
X_2199_ _0185_ _0186_ _1364_ VSS VSS VDD VDD _0187_ sky130_fd_sc_hd__mux2_1
X_2200_ net59 _1554_ _0184_ _0187_ VSS VSS VDD VDD _0188_
+ sky130_fd_sc_hd__a22o_1
X_2201_ _0135_ _0178_ _0182_ _0188_ VSS VSS VDD VDD _0072_
+ sky130_fd_sc_hd__a211o_1
X_2202_ _0125_ _0128_ _1475_ VSS VSS VDD VDD _0189_ sky130_fd_sc_hd__o21ai_0
X_2203_ _1412_ _1545_ _1547_ _1437_ VSS VSS VDD VDD _0190_
+ sky130_fd_sc_hd__a211oi_1
X_2204_ _1438_ _0189_ _0190_ VSS VSS VDD VDD _0191_ sky130_fd_sc_hd__a21oi_1
X_2205_ _0186_ _0191_ _1400_ VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__mux2i_4
X_2206_ _1544_ _1562_ _1401_ VSS VSS VDD VDD _0193_ sky130_fd_sc_hd__mux2i_2
X_2207_ _0179_ _0193_ _1400_ VSS VSS VDD VDD _0194_ sky130_fd_sc_hd__mux2_1
X_2208_ _1462_ _1402_ _0132_ _1508_ _0131_ VSS VSS VDD VDD
+ _0195_ sky130_fd_sc_hd__a32o_4
X_2209_ net60 _1554_ _1555_ _0194_ _0195_ _0135_ VSS VSS VDD
+ VDD _0196_ sky130_fd_sc_hd__a222oi_1
X_2210_ _1552_ _0192_ _0196_ VSS VSS VDD VDD _0073_ sky130_fd_sc_hd__o21ai_0
X_2211_ _0146_ _1438_ _1445_ VSS VSS VDD VDD _0197_ sky130_fd_sc_hd__a21oi_1
X_2212_ _0197_ _0191_ _0145_ VSS VSS VDD VDD _0198_ sky130_fd_sc_hd__mux2_2
X_2213_ _1556_ _0143_ VSS VSS VDD VDD _0199_ sky130_fd_sc_hd__nor2_2
X_2214_ net61 _1554_ _0135_ _0199_ VSS VSS VDD VDD _0200_
+ sky130_fd_sc_hd__a22o_1
X_2215_ _1331_ _1335_ _1402_ VSS VSS VDD VDD _0201_ sky130_fd_sc_hd__mux2i_1
X_2216_ _0201_ _0193_ _0145_ VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__mux2i_2
X_2217_ _0158_ _0202_ VSS VSS VDD VDD _0203_ sky130_fd_sc_hd__nor2_1
X_2218_ _0184_ _0198_ _0200_ _0203_ VSS VSS VDD VDD _0074_
+ sky130_fd_sc_hd__a211o_1
X_2219_ _1366_ _1395_ VSS VSS VDD VDD _0204_ sky130_fd_sc_hd__nand2b_1
X_2220_ net62 _0165_ VSS VSS VDD VDD _0205_ sky130_fd_sc_hd__nand2_1
X_2221_ _0204_ _1398_ _1552_ _1447_ _0205_ VSS VSS VDD VDD
+ _0075_ sky130_fd_sc_hd__o221ai_2
X_2222_ _1497_ VSS VSS VDD VDD _0206_ sky130_fd_sc_hd__inv_1
X_2223_ _1514_ _1531_ VSS VSS VDD VDD _0207_ sky130_fd_sc_hd__nor2_1
X_2224_ _1274_ _1398_ _1535_ VSS VSS VDD VDD _0208_ sky130_fd_sc_hd__or3_1
X_2225_ _1631_ _1251_ _0207_ _0157_ _0208_ VSS VSS VDD VDD
+ _0209_ sky130_fd_sc_hd__o221a_1
X_2226_ _0206_ _1552_ _0209_ VSS VSS VDD VDD _0076_ sky130_fd_sc_hd__o21ai_0
X_2227_ _0134_ _0184_ VSS VSS VDD VDD _0210_ sky130_fd_sc_hd__nand2_1
X_2228_ _1664_ _1260_ _1551_ _0158_ _0210_ VSS VSS VDD VDD
+ _0052_ sky130_fd_sc_hd__o221ai_2
X_2229_ net65 _0165_ VSS VSS VDD VDD _0211_ sky130_fd_sc_hd__nand2_1
X_2230_ _0158_ _0152_ _0148_ _1552_ _0211_ VSS VSS VDD VDD
+ _0053_ sky130_fd_sc_hd__o221ai_1
X_2231_ _1192_ _1201_ VSS VSS VDD VDD _0212_ sky130_fd_sc_hd__nand2_1
X_2232_ _1189_ _1249_ VSS VSS VDD VDD _0213_ sky130_fd_sc_hd__nor2_1
X_2233_ _1378_ _1379_ _1336_ _1342_ VSS VSS VDD VDD _0214_
+ sky130_fd_sc_hd__o22ai_1
X_2234_ _1274_ _0214_ VSS VSS VDD VDD _0215_ sky130_fd_sc_hd__nand2_1
X_2235_ _1397_ _0166_ VSS VSS VDD VDD _0216_ sky130_fd_sc_hd__and2_0
X_2236_ _1382_ _0172_ _0215_ _0216_ VSS VSS VDD VDD _0217_
+ sky130_fd_sc_hd__a211oi_1
X_2237_ _0212_ _0213_ _0217_ _0165_ net35 VSS VSS VDD VDD
+ _0054_ sky130_fd_sc_hd__a32o_1
X_2238_ _1251_ VSS VSS VDD VDD _0218_ sky130_fd_sc_hd__clkbuf_4
X_2239_ _1655_ _0218_ VSS VSS VDD VDD _0219_ sky130_fd_sc_hd__nor2_1
X_2240_ _0184_ _0178_ _0187_ _1555_ _0219_ VSS VSS VDD VDD
+ _0055_ sky130_fd_sc_hd__a221o_1
X_2241_ net37 _0165_ _0184_ _0195_ VSS VSS VDD VDD _0220_
+ sky130_fd_sc_hd__a22oi_1
X_2242_ _0158_ _0192_ _0220_ VSS VSS VDD VDD _0056_ sky130_fd_sc_hd__o21ai_0
X_2243_ _1556_ _1552_ _0143_ VSS VSS VDD VDD _0221_ sky130_fd_sc_hd__nor3_1
X_2244_ net38 _1554_ _1555_ _0198_ _0221_ VSS VSS VDD VDD
+ _0057_ sky130_fd_sc_hd__a221o_1
X_2245_ net39 _0165_ _1393_ _0184_ VSS VSS VDD VDD _0222_
+ sky130_fd_sc_hd__a22oi_1
X_2246_ _1447_ _0158_ _0222_ VSS VSS VDD VDD _0058_ sky130_fd_sc_hd__o21ai_0
X_2247_ _1497_ _1555_ VSS VSS VDD VDD _0223_ sky130_fd_sc_hd__nand2_1
X_2248_ _1643_ _1260_ _1535_ _1552_ _0223_ VSS VSS VDD VDD
+ _0059_ sky130_fd_sc_hd__o221ai_1
X_2249_ _0134_ _1555_ VSS VSS VDD VDD _0224_ sky130_fd_sc_hd__nand2_1
X_2250_ _1676_ _1253_ _0224_ VSS VSS VDD VDD _0060_ sky130_fd_sc_hd__o21ai_0
X_2251_ _1673_ _1252_ _0158_ _0148_ VSS VSS VDD VDD _0061_
+ sky130_fd_sc_hd__o22ai_1
X_2252_ _1670_ _1252_ _0158_ _0172_ VSS VSS VDD VDD _0063_
+ sky130_fd_sc_hd__o22ai_1
X_2253_ net44 _0165_ _1555_ _0178_ VSS VSS VDD VDD _0064_
+ sky130_fd_sc_hd__a22o_1
X_2254_ _1555_ _0195_ VSS VSS VDD VDD _0225_ sky130_fd_sc_hd__nand2_1
X_2255_ _1685_ _1253_ _0225_ VSS VSS VDD VDD _0065_ sky130_fd_sc_hd__o21ai_0
X_2256_ _1555_ _0199_ VSS VSS VDD VDD _0226_ sky130_fd_sc_hd__nand2_1
X_2257_ _1682_ _1253_ _0226_ VSS VSS VDD VDD _0066_ sky130_fd_sc_hd__o21ai_0
X_2258_ _1393_ _1555_ VSS VSS VDD VDD _0227_ sky130_fd_sc_hd__nand2_1
X_2259_ _1679_ _1253_ _0227_ VSS VSS VDD VDD _0067_ sky130_fd_sc_hd__o21ai_0
X_2260_ _1197_ _1200_ _0213_ VSS VSS VDD VDD _0228_ sky130_fd_sc_hd__o21ai_0
X_2261_ _1382_ _1535_ _0215_ _0213_ VSS VSS VDD VDD _0229_
+ sky130_fd_sc_hd__o31a_1
X_2262_ _1192_ _0228_ _0229_ VSS VSS VDD VDD _0068_ sky130_fd_sc_hd__a21oi_1
X_2263_ _1450_ _1382_ _1395_ VSS VSS VDD VDD _0230_ sky130_fd_sc_hd__nand3_1
X_2264_ _1450_ _1397_ VSS VSS VDD VDD _0231_ sky130_fd_sc_hd__nand2_1
X_2265_ _1366_ _0230_ _0231_ _1474_ VSS VSS VDD VDD _0025_
+ sky130_fd_sc_hd__o22ai_1
X_2266_ _1337_ _1538_ VSS VSS VDD VDD _0036_ sky130_fd_sc_hd__and2_0
X_2267_ _1470_ _0231_ VSS VSS VDD VDD _0232_ sky130_fd_sc_hd__nor2_1
X_2268_ _1399_ _0231_ VSS VSS VDD VDD _0233_ sky130_fd_sc_hd__nor2_4
X_2269_ _1470_ _1450_ _1382_ VSS VSS VDD VDD _0234_ sky130_fd_sc_hd__nand3_2
X_2270_ _0233_ _1564_ _1551_ _0234_ VSS VSS VDD VDD _0235_
+ sky130_fd_sc_hd__o2bb2ai_1
X_2271_ net2 _0218_ _0134_ _0232_ _0235_ VSS VSS VDD VDD _0043_
+ sky130_fd_sc_hd__a221o_1
X_2272_ _1448_ _1382_ VSS VSS VDD VDD _0236_ sky130_fd_sc_hd__nor2_1
X_2273_ _1399_ _0236_ VSS VSS VDD VDD _0237_ sky130_fd_sc_hd__nand2_1
X_2274_ net13 _1260_ VSS VSS VDD VDD _0238_ sky130_fd_sc_hd__nand2_1
X_2275_ _1337_ _1397_ VSS VSS VDD VDD _0239_ sky130_fd_sc_hd__nand2_1
X_2276_ _1470_ _1337_ _1382_ VSS VSS VDD VDD _0240_ sky130_fd_sc_hd__nand3_1
X_2277_ _1399_ _0156_ _0239_ _0240_ _0152_ VSS VSS VDD VDD
+ _0241_ sky130_fd_sc_hd__o32a_1
X_2278_ _0148_ _0237_ _0238_ _0241_ VSS VSS VDD VDD _0044_
+ sky130_fd_sc_hd__o211ai_1
X_2279_ _1470_ _0236_ VSS VSS VDD VDD _0242_ sky130_fd_sc_hd__nand2_1
X_2280_ _0242_ VSS VSS VDD VDD _0243_ sky130_fd_sc_hd__clkbuf_4
X_2281_ net24 _1260_ VSS VSS VDD VDD _0244_ sky130_fd_sc_hd__nand2_1
X_2282_ _1470_ _0172_ _0239_ _0240_ _0166_ VSS VSS VDD VDD
+ _0245_ sky130_fd_sc_hd__o32a_1
X_2283_ _0164_ _0243_ _0244_ _0245_ VSS VSS VDD VDD _0045_
+ sky130_fd_sc_hd__o211ai_2
X_2284_ _1399_ _1448_ _1397_ VSS VSS VDD VDD _0246_ sky130_fd_sc_hd__nor3_4
X_2285_ _0187_ _0246_ _0242_ _0181_ VSS VSS VDD VDD _0247_
+ sky130_fd_sc_hd__o2bb2ai_1
X_2286_ net27 _1251_ _0178_ _0232_ _0247_ VSS VSS VDD VDD
+ _0046_ sky130_fd_sc_hd__a221o_1
X_2287_ net28 _1260_ VSS VSS VDD VDD _0248_ sky130_fd_sc_hd__nand2_1
X_2288_ _1470_ _0195_ _0236_ VSS VSS VDD VDD _0249_ sky130_fd_sc_hd__o21a_1
X_2289_ _1399_ _0194_ _0249_ VSS VSS VDD VDD _0250_ sky130_fd_sc_hd__o21ai_0
X_2290_ _0192_ _0234_ _0248_ _0250_ VSS VSS VDD VDD _0047_
+ sky130_fd_sc_hd__o211ai_1
X_2291_ _0199_ _0232_ _0242_ _0202_ VSS VSS VDD VDD _0251_
+ sky130_fd_sc_hd__o2bb2ai_1
X_2292_ net29 _1251_ _0198_ _0246_ _0251_ VSS VSS VDD VDD
+ _0048_ sky130_fd_sc_hd__a221o_1
X_2293_ net30 _1260_ VSS VSS VDD VDD _0252_ sky130_fd_sc_hd__nand2_1
X_2294_ _0204_ _0239_ _0240_ _1447_ _0252_ VSS VSS VDD VDD
+ _0049_ sky130_fd_sc_hd__o221ai_2
X_2295_ net31 _1251_ VSS VSS VDD VDD _0253_ sky130_fd_sc_hd__nand2_1
X_2296_ _0207_ _0243_ _0237_ _1535_ _0253_ VSS VSS VDD VDD
+ _0254_ sky130_fd_sc_hd__o221ai_1
X_2297_ _1497_ _0246_ _0254_ VSS VSS VDD VDD _0050_ sky130_fd_sc_hd__a21o_1
X_2298_ a_exp_larger _1341_ VSS VSS VDD VDD _0255_ sky130_fd_sc_hd__nor2_1
X_2299_ _1397_ _0215_ _0255_ _0134_ VSS VSS VDD VDD _0256_
+ sky130_fd_sc_hd__nand4bb_1
X_2300_ _1517_ _0165_ _1551_ _0243_ _0256_ VSS VSS VDD VDD
+ _0026_ sky130_fd_sc_hd__o221ai_2
X_2301_ _0152_ _0243_ net33 _0218_ VSS VSS VDD VDD _0257_
+ sky130_fd_sc_hd__a2bb2oi_1
X_2302_ _0148_ _0234_ _0257_ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__o21ai_1
X_2303_ net3 _0218_ _0217_ _0255_ VSS VSS VDD VDD _0028_ sky130_fd_sc_hd__a22o_1
X_2304_ net4 _1251_ VSS VSS VDD VDD _0258_ sky130_fd_sc_hd__and2_0
X_2305_ _0187_ _0233_ VSS VSS VDD VDD _0259_ sky130_fd_sc_hd__and2_0
X_2306_ _0178_ _0246_ _0258_ _0259_ VSS VSS VDD VDD _0029_
+ sky130_fd_sc_hd__a211o_1
X_2307_ net5 _0218_ _0195_ _0246_ VSS VSS VDD VDD _0260_ sky130_fd_sc_hd__a22oi_1
X_2308_ _0192_ _0243_ _0260_ VSS VSS VDD VDD _0030_ sky130_fd_sc_hd__o21ai_0
X_2309_ net6 _1251_ VSS VSS VDD VDD _0261_ sky130_fd_sc_hd__and2_0
X_2310_ _0199_ _0246_ _0233_ _0198_ _0261_ VSS VSS VDD VDD
+ _0031_ sky130_fd_sc_hd__a221o_1
X_2311_ net7 _0218_ _1393_ _0246_ VSS VSS VDD VDD _0262_ sky130_fd_sc_hd__a22oi_1
X_2312_ _1447_ _0243_ _0262_ VSS VSS VDD VDD _0032_ sky130_fd_sc_hd__o21ai_0
X_2313_ net8 _1260_ VSS VSS VDD VDD _0263_ sky130_fd_sc_hd__nand2_1
X_2314_ _1535_ _0234_ _0243_ _0206_ _0263_ VSS VSS VDD VDD
+ _0033_ sky130_fd_sc_hd__o221ai_1
X_2315_ net9 _0218_ _0134_ _0233_ VSS VSS VDD VDD _0034_ sky130_fd_sc_hd__a22o_1
X_2316_ net10 _1260_ VSS VSS VDD VDD _0264_ sky130_fd_sc_hd__nand2_1
X_2317_ _0148_ _0243_ _0264_ VSS VSS VDD VDD _0035_ sky130_fd_sc_hd__o21ai_0
X_2318_ _1431_ _0165_ _0172_ _0243_ VSS VSS VDD VDD _0037_
+ sky130_fd_sc_hd__o22ai_1
X_2319_ net12 _0218_ _0178_ _0233_ VSS VSS VDD VDD _0038_
+ sky130_fd_sc_hd__a22o_1
X_2320_ _0195_ _0233_ VSS VSS VDD VDD _0265_ sky130_fd_sc_hd__nand2_1
X_2321_ _1426_ _0165_ _0265_ VSS VSS VDD VDD _0039_ sky130_fd_sc_hd__o21ai_0
X_2322_ net15 _0218_ _0199_ _0233_ VSS VSS VDD VDD _0040_
+ sky130_fd_sc_hd__a22o_1
X_2323_ net16 _0218_ _1393_ _0233_ VSS VSS VDD VDD _0041_
+ sky130_fd_sc_hd__a22o_1
X_2324_ _1532_ _1250_ _1535_ _0243_ VSS VSS VDD VDD _0042_
+ sky130_fd_sc_hd__o22ai_1
X_2325_ add_result\[26\] VSS VSS VDD VDD _0266_ sky130_fd_sc_hd__buf_4
X_2326_ add_result\[22\] VSS VSS VDD VDD _0267_ sky130_fd_sc_hd__buf_2
X_2327_ add_result\[24\] VSS VSS VDD VDD _0268_ sky130_fd_sc_hd__buf_2
X_2328_ add_result\[23\] VSS VSS VDD VDD _0269_ sky130_fd_sc_hd__buf_2
X_2329_ _0267_ _0268_ _0269_ VSS VSS VDD VDD _0270_ sky130_fd_sc_hd__nor3_1
X_2330_ add_result\[4\] VSS VSS VDD VDD _0271_ sky130_fd_sc_hd__buf_4
X_2331_ _0271_ add_result\[17\] add_result\[19\] add_result\[25\]
+ VSS VSS VDD VDD _0272_ sky130_fd_sc_hd__nor4_1
X_2332_ add_result\[3\] VSS VSS VDD VDD _0273_ sky130_fd_sc_hd__buf_4
X_2333_ add_result\[9\] VSS VSS VDD VDD _0274_ sky130_fd_sc_hd__buf_4
X_2334_ add_result\[12\] VSS VSS VDD VDD _0275_ sky130_fd_sc_hd__clkbuf_4
X_2335_ _0273_ _0274_ _0275_ add_result\[11\] VSS VSS VDD
+ VDD _0276_ sky130_fd_sc_hd__nor4_1
X_2336_ add_result\[13\] VSS VSS VDD VDD _0277_ sky130_fd_sc_hd__clkbuf_4
X_2337_ add_result\[16\] VSS VSS VDD VDD _0278_ sky130_fd_sc_hd__clkbuf_4
X_2338_ add_result\[15\] VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__clkbuf_4
X_2339_ _0277_ _0278_ _0279_ add_result\[18\] VSS VSS VDD
+ VDD _0280_ sky130_fd_sc_hd__nor4_1
X_2340_ _0270_ _0272_ _0276_ _0280_ VSS VSS VDD VDD _0281_
+ sky130_fd_sc_hd__nand4_2
X_2341_ add_result\[5\] VSS VSS VDD VDD _0282_ sky130_fd_sc_hd__buf_4
X_2342_ add_result\[8\] VSS VSS VDD VDD _0283_ sky130_fd_sc_hd__buf_4
X_2343_ add_result\[7\] VSS VSS VDD VDD _0284_ sky130_fd_sc_hd__buf_4
X_2344_ _0282_ _0283_ _0284_ add_result\[10\] VSS VSS VDD
+ VDD _0285_ sky130_fd_sc_hd__nor4_1
X_2345_ add_result\[20\] VSS VSS VDD VDD _0286_ sky130_fd_sc_hd__buf_2
X_2346_ add_result\[21\] VSS VSS VDD VDD _0287_ sky130_fd_sc_hd__buf_2
X_2347_ _0286_ _0287_ VSS VSS VDD VDD _0288_ sky130_fd_sc_hd__nor2_2
X_2348_ add_result\[6\] VSS VSS VDD VDD _0289_ sky130_fd_sc_hd__buf_4
X_2349_ add_result\[14\] VSS VSS VDD VDD _0290_ sky130_fd_sc_hd__clkbuf_4
X_2350_ _0289_ _0290_ VSS VSS VDD VDD _0291_ sky130_fd_sc_hd__nor2_1
X_2351_ _0285_ _0288_ _0291_ VSS VSS VDD VDD _0292_ sky130_fd_sc_hd__nand3_1
X_2352_ _0266_ _0281_ _0292_ inexact_stage2 VSS VSS VDD VDD
+ _0108_ sky130_fd_sc_hd__o31a_1
X_2353_ add_result\[25\] add_result\[26\] VSS VSS VDD VDD
+ _0293_ sky130_fd_sc_hd__nor2_2
X_2354_ _0270_ _0293_ VSS VSS VDD VDD _0294_ sky130_fd_sc_hd__nand2_1
X_2355_ _0294_ VSS VSS VDD VDD _0295_ sky130_fd_sc_hd__inv_2
X_2356_ _0295_ VSS VSS VDD VDD _1695_ sky130_fd_sc_hd__clkbuf_4
X_2357_ add_result\[25\] add_result\[26\] VSS VSS VDD VDD
+ _0296_ sky130_fd_sc_hd__or2_0
X_2358_ _0268_ _0296_ VSS VSS VDD VDD _0297_ sky130_fd_sc_hd__nor2_2
X_2359_ _0267_ _0269_ _0288_ _0297_ VSS VSS VDD VDD _0298_
+ sky130_fd_sc_hd__o31ai_4
X_2360_ _0298_ VSS VSS VDD VDD _0299_ sky130_fd_sc_hd__buf_4
X_2361_ _0299_ VSS VSS VDD VDD _1702_ sky130_fd_sc_hd__clkinvlp_4
X_2362_ _0267_ VSS VSS VDD VDD _0300_ sky130_fd_sc_hd__inv_1
X_2363_ _0287_ _0286_ VSS VSS VDD VDD _0301_ sky130_fd_sc_hd__nand2b_1
X_2364_ _0300_ _0301_ _0269_ VSS VSS VDD VDD _0302_ sky130_fd_sc_hd__a21oi_1
X_2365_ add_result\[24\] _0302_ _0293_ VSS VSS VDD VDD _0303_
+ sky130_fd_sc_hd__o21ai_4
X_2366_ _0303_ VSS VSS VDD VDD _1711_ sky130_fd_sc_hd__buf_4
X_2367_ _1711_ VSS VSS VDD VDD _1708_ sky130_fd_sc_hd__inv_1
X_2368_ add_result\[25\] VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__buf_4
X_2369_ _0304_ VSS VSS VDD VDD _0305_ sky130_fd_sc_hd__clkbuf_4
X_2370_ add_result\[26\] VSS VSS VDD VDD _0306_ sky130_fd_sc_hd__inv_2
X_2371_ _0281_ _0292_ _0306_ VSS VSS VDD VDD _0307_ sky130_fd_sc_hd__o21ai_4
X_2372_ _0307_ VSS VSS VDD VDD _0308_ sky130_fd_sc_hd__buf_2
X_2373_ result_exp_stage2\[7\] VSS VSS VDD VDD _0309_ sky130_fd_sc_hd__buf_2
X_2374_ _1710_ _1712_ VSS VSS VDD VDD _0310_ sky130_fd_sc_hd__nand2b_1
X_2375_ _1704_ _0310_ _1703_ VSS VSS VDD VDD _0311_ sky130_fd_sc_hd__a21o_1
X_2376_ _1697_ _0311_ _1696_ VSS VSS VDD VDD _0312_ sky130_fd_sc_hd__a21oi_1
X_2377_ result_exp_stage2\[4\] VSS VSS VDD VDD _0313_ sky130_fd_sc_hd__clkbuf_4
X_2378_ result_exp_stage2\[5\] _0313_ result_exp_stage2\[3\]
+ VSS VSS VDD VDD _0314_ sky130_fd_sc_hd__nor3_1
X_2379_ result_exp_stage2\[6\] _0314_ VSS VSS VDD VDD _0315_
+ sky130_fd_sc_hd__nand2b_1
X_2380_ _0309_ _0312_ _0315_ VSS VSS VDD VDD _0316_ sky130_fd_sc_hd__or3_1
X_2381_ _0316_ VSS VSS VDD VDD _0317_ sky130_fd_sc_hd__clkbuf_4
X_2382_ _0317_ VSS VSS VDD VDD _0318_ sky130_fd_sc_hd__clkbuf_4
X_2383_ _0305_ _0308_ _0318_ VSS VSS VDD VDD _0120_ sky130_fd_sc_hd__nor3_1
X_2384_ result_exp_stage2\[0\] VSS VSS VDD VDD _0319_ sky130_fd_sc_hd__clkbuf_4
X_2385_ _0319_ VSS VSS VDD VDD _1707_ sky130_fd_sc_hd__inv_1
X_2386_ _0319_ VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__clkbuf_4
X_2387_ result_exp_stage2\[5\] VSS VSS VDD VDD _0321_ sky130_fd_sc_hd__buf_4
X_2388_ result_exp_stage2\[3\] VSS VSS VDD VDD _0322_ sky130_fd_sc_hd__buf_4
X_2389_ result_exp_stage2\[6\] _0321_ _0313_ _0322_ VSS VSS
+ VDD VDD _0323_ sky130_fd_sc_hd__nand4_2
X_2390_ result_exp_stage2\[2\] VSS VSS VDD VDD _0324_ sky130_fd_sc_hd__buf_6
X_2391_ _0309_ _0324_ _1716_ VSS VSS VDD VDD _0325_ sky130_fd_sc_hd__nand3_1
X_2392_ _0323_ _0325_ VSS VSS VDD VDD _0326_ sky130_fd_sc_hd__nor2_2
X_2393_ _0304_ VSS VSS VDD VDD _0327_ sky130_fd_sc_hd__buf_4
X_2394_ _0327_ _1710_ VSS VSS VDD VDD _0328_ sky130_fd_sc_hd__nor2_1
X_2395_ _0305_ _0320_ _0328_ VSS VSS VDD VDD _0329_ sky130_fd_sc_hd__a21oi_1
X_2396_ _0304_ _0317_ VSS VSS VDD VDD _0330_ sky130_fd_sc_hd__nor2_1
X_2397_ _0307_ _0330_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__or2_0
X_2398_ _0331_ VSS VSS VDD VDD _0332_ sky130_fd_sc_hd__buf_2
X_2399_ _0306_ _0320_ _0326_ _0329_ _0332_ VSS VSS VDD VDD
+ _0077_ sky130_fd_sc_hd__o32ai_1
X_2400_ result_exp_stage2\[1\] VSS VSS VDD VDD _1701_ sky130_fd_sc_hd__inv_1
X_2401_ _1715_ VSS VSS VDD VDD _0333_ sky130_fd_sc_hd__inv_1
X_2402_ _0333_ VSS VSS VDD VDD _0334_ sky130_fd_sc_hd__buf_2
X_2403_ _1576_ result_exp_stage2\[1\] _0327_ VSS VSS VDD VDD
+ _0335_ sky130_fd_sc_hd__mux2i_1
X_2404_ _0306_ _0334_ _0332_ _0335_ VSS VSS VDD VDD _0078_
+ sky130_fd_sc_hd__o22ai_1
X_2405_ _0324_ VSS VSS VDD VDD _1694_ sky130_fd_sc_hd__inv_1
X_2406_ _1697_ _1575_ VSS VSS VDD VDD _0336_ sky130_fd_sc_hd__xnor2_1
X_2407_ _0327_ _0336_ VSS VSS VDD VDD _0337_ sky130_fd_sc_hd__nor2_1
X_2408_ _0305_ _0324_ _0337_ VSS VSS VDD VDD _0338_ sky130_fd_sc_hd__a21oi_1
X_2409_ _0324_ _1718_ VSS VSS VDD VDD _0339_ sky130_fd_sc_hd__xor2_1
X_2410_ _0266_ VSS VSS VDD VDD _0340_ sky130_fd_sc_hd__clkbuf_4
X_2411_ _0326_ _0339_ _0340_ VSS VSS VDD VDD _0341_ sky130_fd_sc_hd__o21ai_0
X_2412_ _0332_ _0338_ _0341_ VSS VSS VDD VDD _0079_ sky130_fd_sc_hd__o21ai_0
X_2413_ _1709_ VSS VSS VDD VDD _1573_ sky130_fd_sc_hd__inv_1
X_2414_ _0304_ _1699_ VSS VSS VDD VDD _0342_ sky130_fd_sc_hd__nor2_1
X_2415_ _1709_ _1704_ VSS VSS VDD VDD _0343_ sky130_fd_sc_hd__nor2b_1
X_2416_ _1705_ _0343_ _1697_ VSS VSS VDD VDD _0344_ sky130_fd_sc_hd__o21ai_1
X_2417_ _0342_ _0344_ VSS VSS VDD VDD _0345_ sky130_fd_sc_hd__nand2_1
X_2418_ _0324_ result_exp_stage2\[1\] _0320_ VSS VSS VDD VDD
+ _0346_ sky130_fd_sc_hd__nand3_1
X_2419_ _0346_ VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__inv_1
X_2420_ _0307_ _0330_ VSS VSS VDD VDD _0348_ sky130_fd_sc_hd__nor2_1
X_2421_ _0348_ _0345_ VSS VSS VDD VDD _0349_ sky130_fd_sc_hd__nand2_1
X_2422_ _0306_ _0347_ _0349_ VSS VSS VDD VDD _0350_ sky130_fd_sc_hd__o21ai_0
X_2423_ _0322_ _0350_ VSS VSS VDD VDD _0351_ sky130_fd_sc_hd__nand2_1
X_2424_ _0322_ _0346_ VSS VSS VDD VDD _0352_ sky130_fd_sc_hd__nor2_1
X_2425_ _0326_ _0352_ _0340_ VSS VSS VDD VDD _0353_ sky130_fd_sc_hd__o21ai_0
X_2426_ _0322_ _0332_ _0345_ _0351_ _0353_ VSS VSS VDD VDD
+ _0080_ sky130_fd_sc_hd__o311ai_0
X_2427_ _0322_ _0324_ _1718_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__nand3_1
X_2428_ _0323_ _0325_ _0354_ _0313_ VSS VSS VDD VDD _0355_
+ sky130_fd_sc_hd__o22ai_1
X_2429_ _1697_ _1575_ _1699_ _0304_ VSS VSS VDD VDD _0356_
+ sky130_fd_sc_hd__a211oi_1
X_2430_ _0322_ _0356_ VSS VSS VDD VDD _0357_ sky130_fd_sc_hd__nor2b_1
X_2431_ _0266_ _0354_ VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__nand2_1
X_2432_ _0332_ _0357_ _0358_ VSS VSS VDD VDD _0359_ sky130_fd_sc_hd__o21ai_0
X_2433_ _0313_ _0332_ _0357_ VSS VSS VDD VDD _0360_ sky130_fd_sc_hd__nor3b_1
X_2434_ _0266_ _0355_ _0359_ _0313_ _0360_ VSS VSS VDD VDD
+ _0081_ sky130_fd_sc_hd__a221o_1
X_2435_ _0313_ result_exp_stage2\[3\] VSS VSS VDD VDD _0361_
+ sky130_fd_sc_hd__nor2_1
X_2436_ _0361_ _0342_ _0344_ VSS VSS VDD VDD _0362_ sky130_fd_sc_hd__nand3_1
X_2437_ _0313_ _0322_ _0347_ VSS VSS VDD VDD _0363_ sky130_fd_sc_hd__nand3_1
X_2438_ _0266_ _0363_ _0362_ _0348_ VSS VSS VDD VDD _0364_
+ sky130_fd_sc_hd__a22o_1
X_2439_ _0321_ _0364_ VSS VSS VDD VDD _0365_ sky130_fd_sc_hd__nand2_1
X_2440_ _0321_ _0363_ VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__nor2_1
X_2441_ _0326_ _0366_ _0340_ VSS VSS VDD VDD _0367_ sky130_fd_sc_hd__o21ai_0
X_2442_ _0321_ _0332_ _0362_ _0365_ _0367_ VSS VSS VDD VDD
+ _0082_ sky130_fd_sc_hd__o311ai_1
X_2443_ _0314_ _0356_ VSS VSS VDD VDD _0368_ sky130_fd_sc_hd__nand2_1
X_2444_ _0321_ _0313_ VSS VSS VDD VDD _0369_ sky130_fd_sc_hd__nand2_1
X_2445_ _0369_ _0354_ VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__or2_0
X_2446_ _0266_ _0370_ _0368_ _0348_ VSS VSS VDD VDD _0371_
+ sky130_fd_sc_hd__a22o_1
X_2447_ result_exp_stage2\[6\] _0371_ VSS VSS VDD VDD _0372_
+ sky130_fd_sc_hd__nand2_1
X_2448_ result_exp_stage2\[6\] _0370_ VSS VSS VDD VDD _0373_
+ sky130_fd_sc_hd__nor2_1
X_2449_ _0326_ _0373_ _0266_ VSS VSS VDD VDD _0374_ sky130_fd_sc_hd__o21ai_0
X_2450_ result_exp_stage2\[6\] _0332_ _0368_ _0372_ _0374_
+ VSS VSS VDD VDD _0083_ sky130_fd_sc_hd__o311ai_2
X_2451_ _0315_ _0345_ VSS VSS VDD VDD _0375_ sky130_fd_sc_hd__nor2_1
X_2452_ _0309_ _0375_ VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__xnor2_1
X_2453_ _0323_ _0346_ VSS VSS VDD VDD _0377_ sky130_fd_sc_hd__nor2_1
X_2454_ _0309_ _0377_ VSS VSS VDD VDD _0378_ sky130_fd_sc_hd__xor2_1
X_2455_ _0326_ _0378_ _0340_ VSS VSS VDD VDD _0379_ sky130_fd_sc_hd__o21ai_0
X_2456_ _0332_ _0376_ _0379_ VSS VSS VDD VDD _0084_ sky130_fd_sc_hd__o21ai_0
X_2457_ _0309_ _0312_ _0315_ VSS VSS VDD VDD _0380_ sky130_fd_sc_hd__nor3_2
X_2458_ _0309_ result_exp_stage2\[6\] VSS VSS VDD VDD _0381_
+ sky130_fd_sc_hd__nor2_1
X_2459_ _0381_ VSS VSS VDD VDD _0382_ sky130_fd_sc_hd__clkinvlp_4
X_2460_ _0313_ result_exp_stage2\[3\] result_exp_stage2\[2\]
+ _1714_ VSS VSS VDD VDD _0383_ sky130_fd_sc_hd__or4b_2
X_2461_ _0321_ _0382_ _0383_ VSS VSS VDD VDD _0384_ sky130_fd_sc_hd__nor3_4
X_2462_ _0380_ _0384_ _0304_ VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__a21o_1
X_2463_ _0385_ VSS VSS VDD VDD _0386_ sky130_fd_sc_hd__clkbuf_4
X_2464_ _0317_ VSS VSS VDD VDD _0387_ sky130_fd_sc_hd__buf_2
X_2465_ _1715_ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__clkbuf_4
X_2466_ _0388_ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__clkbuf_4
X_2467_ _0319_ VSS VSS VDD VDD _0390_ sky130_fd_sc_hd__buf_4
X_2468_ _0390_ add_result\[2\] VSS VSS VDD VDD _0391_ sky130_fd_sc_hd__and2_2
X_2469_ _0324_ result_exp_stage2\[1\] result_exp_stage2\[0\]
+ VSS VSS VDD VDD _0392_ sky130_fd_sc_hd__nor3_4
X_2470_ _0361_ _0392_ VSS VSS VDD VDD _0393_ sky130_fd_sc_hd__nand2_1
X_2471_ _0383_ _0393_ result_exp_stage2\[5\] VSS VSS VDD VDD
+ _0394_ sky130_fd_sc_hd__a21oi_2
X_2472_ result_exp_stage2\[6\] _0309_ VSS VSS VDD VDD _0395_
+ sky130_fd_sc_hd__nor2b_1
X_2473_ _0361_ _0383_ _0392_ _0395_ VSS VSS VDD VDD _0396_
+ sky130_fd_sc_hd__nand4_1
X_2474_ _0383_ _0309_ result_exp_stage2\[6\] VSS VSS VDD VDD
+ _0397_ sky130_fd_sc_hd__or3b_1
X_2475_ _0396_ _0397_ _0321_ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__a21oi_1
X_2476_ _0382_ _0394_ _0398_ VSS VSS VDD VDD _0399_ sky130_fd_sc_hd__o21bai_4
X_2477_ _0399_ VSS VSS VDD VDD _0400_ sky130_fd_sc_hd__clkbuf_4
X_2478_ _0324_ _1714_ VSS VSS VDD VDD _0401_ sky130_fd_sc_hd__xnor2_4
X_2479_ _0401_ VSS VSS VDD VDD _0402_ sky130_fd_sc_hd__buf_4
X_2480_ _0402_ VSS VSS VDD VDD _0403_ sky130_fd_sc_hd__clkbuf_4
X_2481_ _0389_ _0391_ _0400_ _0403_ VSS VSS VDD VDD _0404_
+ sky130_fd_sc_hd__nand4_2
X_2482_ _0322_ _0392_ VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__xnor2_2
X_2483_ _0405_ VSS VSS VDD VDD _0406_ sky130_fd_sc_hd__buf_2
X_2484_ _0322_ _0324_ _1714_ VSS VSS VDD VDD _0407_ sky130_fd_sc_hd__nor3b_2
X_2485_ _0313_ _0407_ VSS VSS VDD VDD _0408_ sky130_fd_sc_hd__xnor2_4
X_2486_ _0321_ _0393_ VSS VSS VDD VDD _0409_ sky130_fd_sc_hd__xor2_2
X_2487_ _0408_ _0409_ VSS VSS VDD VDD _0410_ sky130_fd_sc_hd__and2_0
X_2488_ _0410_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__buf_2
X_2489_ _0406_ _0411_ VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__nand2_1
X_2490_ _0304_ _0387_ _0404_ _0412_ VSS VSS VDD VDD _0413_
+ sky130_fd_sc_hd__nor4_1
X_2491_ add_result\[2\] _0386_ _0413_ VSS VSS VDD VDD _0414_
+ sky130_fd_sc_hd__a21oi_1
X_2492_ _0266_ VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__clkbuf_4
X_2493_ _0273_ _0415_ VSS VSS VDD VDD _0416_ sky130_fd_sc_hd__nand2_1
X_2494_ _0308_ _0414_ _0416_ VSS VSS VDD VDD _0085_ sky130_fd_sc_hd__o21ai_0
X_2495_ _0304_ VSS VSS VDD VDD _0417_ sky130_fd_sc_hd__clkbuf_4
X_2496_ _0380_ VSS VSS VDD VDD _0418_ sky130_fd_sc_hd__buf_2
X_2497_ add_result\[2\] _0273_ _0390_ VSS VSS VDD VDD _0419_
+ sky130_fd_sc_hd__mux2_1
X_2498_ _0389_ _0400_ _0403_ _0419_ VSS VSS VDD VDD _0420_
+ sky130_fd_sc_hd__nand4_2
X_2499_ _0384_ VSS VSS VDD VDD _0421_ sky130_fd_sc_hd__buf_2
X_2500_ _0273_ _0421_ VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__nand2_1
X_2501_ _0412_ _0420_ _0422_ VSS VSS VDD VDD _0423_ sky130_fd_sc_hd__o21ai_0
X_2502_ _0380_ VSS VSS VDD VDD _0424_ sky130_fd_sc_hd__clkbuf_4
X_2503_ add_result\[2\] _0273_ _1711_ VSS VSS VDD VDD _0425_
+ sky130_fd_sc_hd__mux2i_2
X_2504_ _0297_ _0424_ _0425_ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__nor3_1
X_2505_ _0418_ _0423_ _0426_ VSS VSS VDD VDD _0427_ sky130_fd_sc_hd__a21oi_1
X_2506_ _0417_ _0427_ VSS VSS VDD VDD _0428_ sky130_fd_sc_hd__nor2_1
X_2507_ _0273_ _0305_ _0428_ VSS VSS VDD VDD _0429_ sky130_fd_sc_hd__a21oi_1
X_2508_ _0271_ _0415_ VSS VSS VDD VDD _0430_ sky130_fd_sc_hd__nand2_1
X_2509_ _0308_ _0429_ _0430_ VSS VSS VDD VDD _0096_ sky130_fd_sc_hd__o21ai_0
X_2510_ _0304_ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__clkbuf_4
X_2511_ _0388_ VSS VSS VDD VDD _0432_ sky130_fd_sc_hd__buf_2
X_2512_ _0273_ _0271_ _0390_ VSS VSS VDD VDD _0433_ sky130_fd_sc_hd__mux2i_2
X_2513_ _0432_ _0433_ VSS VSS VDD VDD _0434_ sky130_fd_sc_hd__nand2_1
X_2514_ _0389_ _0391_ _0399_ _0402_ _0434_ VSS VSS VDD VDD
+ _0435_ sky130_fd_sc_hd__o2111ai_4
X_2515_ _0412_ _0435_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__nor2_1
X_2516_ _0271_ _0421_ _0436_ _0387_ VSS VSS VDD VDD _0437_
+ sky130_fd_sc_hd__a211oi_1
X_2517_ _0294_ VSS VSS VDD VDD _1698_ sky130_fd_sc_hd__buf_4
X_2518_ _0298_ VSS VSS VDD VDD _1574_ sky130_fd_sc_hd__buf_4
X_2519_ _0273_ _0271_ _1711_ VSS VSS VDD VDD _0438_ sky130_fd_sc_hd__mux2i_2
X_2520_ add_result\[2\] _1711_ _1574_ VSS VSS VDD VDD _0439_
+ sky130_fd_sc_hd__a21oi_1
X_2521_ _1574_ _0438_ _0439_ VSS VSS VDD VDD _0440_ sky130_fd_sc_hd__a21oi_1
X_2522_ _1698_ _0440_ _0418_ VSS VSS VDD VDD _0441_ sky130_fd_sc_hd__a21oi_1
X_2523_ _0431_ _0437_ _0441_ VSS VSS VDD VDD _0442_ sky130_fd_sc_hd__nor3_1
X_2524_ _0271_ _0305_ _0442_ VSS VSS VDD VDD _0443_ sky130_fd_sc_hd__a21oi_1
X_2525_ _0282_ _0415_ VSS VSS VDD VDD _0444_ sky130_fd_sc_hd__nand2_1
X_2526_ _0308_ _0443_ _0444_ VSS VSS VDD VDD _0100_ sky130_fd_sc_hd__o21ai_0
X_2527_ _0322_ _0392_ VSS VSS VDD VDD _0445_ sky130_fd_sc_hd__xor2_4
X_2528_ _0408_ _0409_ VSS VSS VDD VDD _0446_ sky130_fd_sc_hd__nand2_2
X_2529_ _0445_ _0446_ VSS VSS VDD VDD _0447_ sky130_fd_sc_hd__nor2_1
X_2530_ _0382_ _0394_ _0398_ VSS VSS VDD VDD _0448_ sky130_fd_sc_hd__o21ba_2
X_2531_ _0324_ _1714_ VSS VSS VDD VDD _0449_ sky130_fd_sc_hd__xor2_4
X_2532_ _0449_ VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__buf_2
X_2533_ _0388_ VSS VSS VDD VDD _0451_ sky130_fd_sc_hd__buf_2
X_2534_ _0271_ _0282_ _0390_ VSS VSS VDD VDD _0452_ sky130_fd_sc_hd__mux2i_2
X_2535_ _0451_ _0452_ VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__nand2_1
X_2536_ _0451_ _0419_ _0453_ VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__o21ai_0
X_2537_ _0448_ _0450_ _0454_ VSS VSS VDD VDD _0455_ sky130_fd_sc_hd__nor3_1
X_2538_ _0282_ _0421_ _0447_ _0455_ _0387_ VSS VSS VDD VDD
+ _0456_ sky130_fd_sc_hd__a221oi_1
X_2539_ _0271_ _0282_ _1711_ VSS VSS VDD VDD _0457_ sky130_fd_sc_hd__mux2i_1
X_2540_ _0425_ _0457_ _1574_ VSS VSS VDD VDD _0458_ sky130_fd_sc_hd__mux2i_1
X_2541_ _1698_ _0458_ _0424_ VSS VSS VDD VDD _0459_ sky130_fd_sc_hd__a21oi_1
X_2542_ _0431_ _0456_ _0459_ VSS VSS VDD VDD _0460_ sky130_fd_sc_hd__nor3_1
X_2543_ _0282_ _0305_ _0460_ VSS VSS VDD VDD _0461_ sky130_fd_sc_hd__a21oi_1
X_2544_ _0289_ _0415_ VSS VSS VDD VDD _0462_ sky130_fd_sc_hd__nand2_1
X_2545_ _0308_ _0461_ _0462_ VSS VSS VDD VDD _0101_ sky130_fd_sc_hd__o21ai_0
X_2546_ _0282_ _0289_ _1711_ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__mux2i_1
X_2547_ _0438_ _0463_ _0299_ VSS VSS VDD VDD _0464_ sky130_fd_sc_hd__mux2i_2
X_2548_ _1698_ _0464_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__nand2_1
X_2549_ add_result\[2\] _1695_ _1574_ _1711_ VSS VSS VDD VDD
+ _0466_ sky130_fd_sc_hd__nand4_1
X_2550_ _0391_ _0401_ VSS VSS VDD VDD _0467_ sky130_fd_sc_hd__nor2_1
X_2551_ _0282_ _0289_ _0319_ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__mux2_1
X_2552_ _0449_ _0468_ VSS VSS VDD VDD _0469_ sky130_fd_sc_hd__nor2_1
X_2553_ _0334_ _0467_ _0469_ VSS VSS VDD VDD _0470_ sky130_fd_sc_hd__nor3_1
X_2554_ _0432_ _0449_ _0433_ VSS VSS VDD VDD _0471_ sky130_fd_sc_hd__nor3_1
X_2555_ _0470_ _0471_ _0399_ VSS VSS VDD VDD _0472_ sky130_fd_sc_hd__o21ai_2
X_2556_ _0412_ _0472_ VSS VSS VDD VDD _0473_ sky130_fd_sc_hd__nor2_1
X_2557_ _0289_ _0421_ _0473_ _0387_ VSS VSS VDD VDD _0474_
+ sky130_fd_sc_hd__a211oi_1
X_2558_ _0318_ _0465_ _0466_ _0474_ _0431_ VSS VSS VDD VDD
+ _0475_ sky130_fd_sc_hd__a311oi_1
X_2559_ _0289_ _0305_ _0475_ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__a21oi_1
X_2560_ _0284_ _0415_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__nand2_1
X_2561_ _0308_ _0476_ _0477_ VSS VSS VDD VDD _0102_ sky130_fd_sc_hd__o21ai_0
X_2562_ _0294_ VSS VSS VDD VDD _0478_ sky130_fd_sc_hd__buf_2
X_2563_ _0303_ VSS VSS VDD VDD _0479_ sky130_fd_sc_hd__buf_4
X_2564_ _0289_ _0284_ _0479_ VSS VSS VDD VDD _0480_ sky130_fd_sc_hd__mux2i_1
X_2565_ _0457_ _0480_ _0299_ VSS VSS VDD VDD _0481_ sky130_fd_sc_hd__mux2i_1
X_2566_ _0478_ _1702_ _0425_ VSS VSS VDD VDD _0482_ sky130_fd_sc_hd__nor3_1
X_2567_ _0478_ _0481_ _0482_ _0424_ VSS VSS VDD VDD _0483_
+ sky130_fd_sc_hd__a211oi_1
X_2568_ _0273_ _0284_ add_result\[2\] _0289_ _0401_ _1707_
+ VSS VSS VDD VDD _0484_ sky130_fd_sc_hd__mux4_1
X_2569_ _0388_ _0449_ _0452_ VSS VSS VDD VDD _0485_ sky130_fd_sc_hd__nor3_1
X_2570_ _0432_ _0484_ _0485_ VSS VSS VDD VDD _0486_ sky130_fd_sc_hd__a21oi_1
X_2571_ _0448_ _0486_ VSS VSS VDD VDD _0487_ sky130_fd_sc_hd__nor2_1
X_2572_ _0284_ _0421_ _0447_ _0487_ _0387_ VSS VSS VDD VDD
+ _0488_ sky130_fd_sc_hd__a221oi_1
X_2573_ _0431_ _0483_ _0488_ VSS VSS VDD VDD _0489_ sky130_fd_sc_hd__nor3_1
X_2574_ _0284_ _0305_ _0489_ VSS VSS VDD VDD _0490_ sky130_fd_sc_hd__a21oi_1
X_2575_ _0283_ _0415_ VSS VSS VDD VDD _0491_ sky130_fd_sc_hd__nand2_1
X_2576_ _0308_ _0490_ _0491_ VSS VSS VDD VDD _0103_ sky130_fd_sc_hd__o21ai_0
X_2577_ _1695_ _0440_ VSS VSS VDD VDD _0492_ sky130_fd_sc_hd__nand2_1
X_2578_ _0284_ _0283_ _0479_ VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__mux2i_1
X_2579_ _0463_ _0493_ _1574_ VSS VSS VDD VDD _0494_ sky130_fd_sc_hd__mux2i_1
X_2580_ _1698_ _0494_ VSS VSS VDD VDD _0495_ sky130_fd_sc_hd__nand2_1
X_2581_ _0284_ _0283_ _0319_ VSS VSS VDD VDD _0496_ sky130_fd_sc_hd__mux2i_1
X_2582_ _0388_ _0496_ VSS VSS VDD VDD _0497_ sky130_fd_sc_hd__nand2_1
X_2583_ _0388_ _0468_ _0497_ _0399_ VSS VSS VDD VDD _0498_
+ sky130_fd_sc_hd__o211ai_2
X_2584_ _0432_ _0391_ _0399_ _0449_ _0434_ VSS VSS VDD VDD
+ _0499_ sky130_fd_sc_hd__o2111ai_1
X_2585_ _0449_ _0498_ _0499_ VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__o21ai_2
X_2586_ _0283_ _0421_ _0447_ _0500_ _0317_ VSS VSS VDD VDD
+ _0501_ sky130_fd_sc_hd__a221oi_1
X_2587_ _0318_ _0492_ _0495_ _0501_ _0431_ VSS VSS VDD VDD
+ _0502_ sky130_fd_sc_hd__a311oi_1
X_2588_ _0283_ _0305_ _0502_ VSS VSS VDD VDD _0503_ sky130_fd_sc_hd__a21oi_1
X_2589_ _0274_ _0415_ VSS VSS VDD VDD _0504_ sky130_fd_sc_hd__nand2_1
X_2590_ _0308_ _0503_ _0504_ VSS VSS VDD VDD _0104_ sky130_fd_sc_hd__o21ai_0
X_2591_ _1695_ _0458_ VSS VSS VDD VDD _0505_ sky130_fd_sc_hd__nand2_1
X_2592_ _0283_ _0274_ _0479_ VSS VSS VDD VDD _0506_ sky130_fd_sc_hd__mux2i_1
X_2593_ _0480_ _0506_ _0299_ VSS VSS VDD VDD _0507_ sky130_fd_sc_hd__mux2i_1
X_2594_ _1698_ _0507_ VSS VSS VDD VDD _0508_ sky130_fd_sc_hd__nand2_1
X_2595_ _0284_ _0390_ VSS VSS VDD VDD _0509_ sky130_fd_sc_hd__and2_0
X_2596_ _0319_ _0289_ VSS VSS VDD VDD _0510_ sky130_fd_sc_hd__nor2b_1
X_2597_ _0283_ _0274_ _0319_ VSS VSS VDD VDD _0511_ sky130_fd_sc_hd__mux2i_1
X_2598_ _0432_ _0511_ VSS VSS VDD VDD _0512_ sky130_fd_sc_hd__nand2_1
X_2599_ _0388_ _0509_ _0510_ _0512_ VSS VSS VDD VDD _0513_
+ sky130_fd_sc_hd__o31a_1
X_2600_ _0402_ _0513_ VSS VSS VDD VDD _0514_ sky130_fd_sc_hd__nand2_1
X_2601_ _0402_ _0454_ _0514_ VSS VSS VDD VDD _0515_ sky130_fd_sc_hd__o21ai_0
X_2602_ _0400_ _0515_ VSS VSS VDD VDD _0516_ sky130_fd_sc_hd__nand2_1
X_2603_ _0274_ _0384_ VSS VSS VDD VDD _0517_ sky130_fd_sc_hd__nand2_1
X_2604_ _0412_ _0516_ _0517_ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__o21ai_0
X_2605_ _0387_ _0518_ VSS VSS VDD VDD _0519_ sky130_fd_sc_hd__nor2_1
X_2606_ _0318_ _0505_ _0508_ _0519_ _0431_ VSS VSS VDD VDD
+ _0520_ sky130_fd_sc_hd__a311oi_1
X_2607_ _0274_ _0327_ _0520_ VSS VSS VDD VDD _0521_ sky130_fd_sc_hd__a21oi_1
X_2608_ add_result\[10\] _0415_ VSS VSS VDD VDD _0522_ sky130_fd_sc_hd__nand2_1
X_2609_ _0308_ _0521_ _0522_ VSS VSS VDD VDD _0105_ sky130_fd_sc_hd__o21ai_0
X_2610_ add_result\[26\] VSS VSS VDD VDD _0523_ sky130_fd_sc_hd__clkbuf_2
X_2611_ _0406_ VSS VSS VDD VDD _0524_ sky130_fd_sc_hd__clkbuf_2
X_2612_ _0334_ _0496_ VSS VSS VDD VDD _0525_ sky130_fd_sc_hd__nand2_1
X_2613_ _0274_ add_result\[10\] _0319_ VSS VSS VDD VDD _0526_
+ sky130_fd_sc_hd__mux2i_1
X_2614_ _0451_ _0526_ VSS VSS VDD VDD _0527_ sky130_fd_sc_hd__nand2_1
X_2615_ _0399_ _0525_ _0527_ VSS VSS VDD VDD _0528_ sky130_fd_sc_hd__nand3_1
X_2616_ _0451_ _0468_ VSS VSS VDD VDD _0529_ sky130_fd_sc_hd__nand2_1
X_2617_ _0451_ _0433_ _0529_ VSS VSS VDD VDD _0530_ sky130_fd_sc_hd__o21ai_1
X_2618_ _0400_ _0530_ _0402_ VSS VSS VDD VDD _0531_ sky130_fd_sc_hd__a21oi_1
X_2619_ _0403_ _0528_ _0531_ VSS VSS VDD VDD _0532_ sky130_fd_sc_hd__a21oi_1
X_2620_ _0524_ _0532_ VSS VSS VDD VDD _0533_ sky130_fd_sc_hd__nand2_1
X_2621_ _0404_ _0524_ _0533_ VSS VSS VDD VDD _0534_ sky130_fd_sc_hd__o21ai_0
X_2622_ _0295_ _0464_ VSS VSS VDD VDD _0535_ sky130_fd_sc_hd__nand2_1
X_2623_ _0274_ add_result\[10\] _0479_ VSS VSS VDD VDD _0536_
+ sky130_fd_sc_hd__mux2i_1
X_2624_ _0493_ _0536_ _0299_ VSS VSS VDD VDD _0537_ sky130_fd_sc_hd__mux2i_1
X_2625_ _0478_ _0537_ VSS VSS VDD VDD _0538_ sky130_fd_sc_hd__nand2_1
X_2626_ _0535_ _0538_ _0424_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__a21oi_1
X_2627_ _0418_ _0411_ _0534_ _0539_ VSS VSS VDD VDD _0540_
+ sky130_fd_sc_hd__a31oi_1
X_2628_ _0417_ _0540_ _0386_ add_result\[10\] VSS VSS VDD
+ VDD _0541_ sky130_fd_sc_hd__a2bb2oi_1
X_2629_ add_result\[11\] _0415_ VSS VSS VDD VDD _0542_ sky130_fd_sc_hd__nand2_1
X_2630_ _0523_ _0541_ _0542_ VSS VSS VDD VDD _0106_ sky130_fd_sc_hd__o21ai_0
X_2631_ _1695_ _0481_ VSS VSS VDD VDD _0543_ sky130_fd_sc_hd__nand2_1
X_2632_ add_result\[10\] add_result\[11\] _0479_ VSS VSS VDD
+ VDD _0544_ sky130_fd_sc_hd__mux2i_1
X_2633_ _0506_ _0544_ _0299_ VSS VSS VDD VDD _0545_ sky130_fd_sc_hd__mux2i_1
X_2634_ _0478_ _0545_ VSS VSS VDD VDD _0546_ sky130_fd_sc_hd__nand2_1
X_2635_ _0543_ _0546_ VSS VSS VDD VDD _0547_ sky130_fd_sc_hd__nand2_1
X_2636_ add_result\[10\] add_result\[11\] result_exp_stage2\[0\]
+ VSS VSS VDD VDD _0548_ sky130_fd_sc_hd__mux2_1
X_2637_ _0333_ _0548_ VSS VSS VDD VDD _0549_ sky130_fd_sc_hd__nor2_1
X_2638_ _0334_ _0511_ _0549_ VSS VSS VDD VDD _0550_ sky130_fd_sc_hd__a21oi_1
X_2639_ _0334_ _0509_ _0510_ VSS VSS VDD VDD _0551_ sky130_fd_sc_hd__nor3_1
X_2640_ _0334_ _0452_ _0551_ _0402_ VSS VSS VDD VDD _0552_
+ sky130_fd_sc_hd__a211oi_1
X_2641_ _0402_ _0550_ _0552_ VSS VSS VDD VDD _0553_ sky130_fd_sc_hd__a21oi_1
X_2642_ _0448_ _0553_ VSS VSS VDD VDD _0554_ sky130_fd_sc_hd__nor2_1
X_2643_ _0406_ _0420_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__nor2_1
X_2644_ _0524_ _0554_ _0555_ VSS VSS VDD VDD _0556_ sky130_fd_sc_hd__a21oi_1
X_2645_ _0387_ _0446_ _0556_ VSS VSS VDD VDD _0557_ sky130_fd_sc_hd__nor3_1
X_2646_ _0387_ _0547_ _0557_ VSS VSS VDD VDD _0558_ sky130_fd_sc_hd__a21oi_1
X_2647_ _0417_ _0558_ _0386_ add_result\[11\] VSS VSS VDD
+ VDD _0559_ sky130_fd_sc_hd__a2bb2oi_1
X_2648_ _0266_ VSS VSS VDD VDD _0560_ sky130_fd_sc_hd__buf_2
X_2649_ _0275_ _0560_ VSS VSS VDD VDD _0561_ sky130_fd_sc_hd__nand2_1
X_2650_ _0523_ _0559_ _0561_ VSS VSS VDD VDD _0107_ sky130_fd_sc_hd__o21ai_0
X_2651_ _1695_ _0494_ VSS VSS VDD VDD _0562_ sky130_fd_sc_hd__nand2_1
X_2652_ add_result\[11\] _0275_ _0479_ VSS VSS VDD VDD _0563_
+ sky130_fd_sc_hd__mux2i_1
X_2653_ _0536_ _0563_ _0299_ VSS VSS VDD VDD _0564_ sky130_fd_sc_hd__mux2i_1
X_2654_ _1698_ _0564_ VSS VSS VDD VDD _0565_ sky130_fd_sc_hd__nand2_1
X_2655_ add_result\[11\] _0275_ result_exp_stage2\[0\] VSS
+ VSS VDD VDD _0566_ sky130_fd_sc_hd__mux2_1
X_2656_ _0334_ _0526_ VSS VSS VDD VDD _0567_ sky130_fd_sc_hd__nand2_1
X_2657_ _0334_ _0566_ _0567_ _0399_ VSS VSS VDD VDD _0568_
+ sky130_fd_sc_hd__o211ai_1
X_2658_ _0498_ _0568_ _0401_ VSS VSS VDD VDD _0569_ sky130_fd_sc_hd__mux2_1
X_2659_ _0435_ _0569_ _0406_ VSS VSS VDD VDD _0570_ sky130_fd_sc_hd__mux2i_1
X_2660_ _0275_ _0384_ _0411_ _0570_ _0317_ VSS VSS VDD VDD
+ _0571_ sky130_fd_sc_hd__a221oi_2
X_2661_ _0318_ _0562_ _0565_ _0571_ _0431_ VSS VSS VDD VDD
+ _0572_ sky130_fd_sc_hd__a311oi_2
X_2662_ _0275_ _0327_ _0572_ VSS VSS VDD VDD _0573_ sky130_fd_sc_hd__a21oi_1
X_2663_ _0277_ _0560_ VSS VSS VDD VDD _0574_ sky130_fd_sc_hd__nand2_1
X_2664_ _0523_ _0573_ _0574_ VSS VSS VDD VDD _0086_ sky130_fd_sc_hd__o21ai_0
X_2665_ _0275_ _0277_ _0390_ VSS VSS VDD VDD _0575_ sky130_fd_sc_hd__mux2i_1
X_2666_ _0451_ _0575_ VSS VSS VDD VDD _0576_ sky130_fd_sc_hd__nand2_1
X_2667_ _0451_ _0548_ _0576_ VSS VSS VDD VDD _0577_ sky130_fd_sc_hd__o21ai_0
X_2668_ _0450_ _0513_ VSS VSS VDD VDD _0578_ sky130_fd_sc_hd__nand2_1
X_2669_ _0450_ _0577_ _0578_ VSS VSS VDD VDD _0579_ sky130_fd_sc_hd__o21ai_0
X_2670_ _0400_ _0579_ VSS VSS VDD VDD _0580_ sky130_fd_sc_hd__nand2_1
X_2671_ _0445_ _0455_ VSS VSS VDD VDD _0581_ sky130_fd_sc_hd__nand2_1
X_2672_ _0445_ _0580_ _0581_ VSS VSS VDD VDD _0582_ sky130_fd_sc_hd__o21ai_0
X_2673_ _0277_ _0421_ _0411_ _0582_ VSS VSS VDD VDD _0583_
+ sky130_fd_sc_hd__a22oi_1
X_2674_ _0295_ _0507_ VSS VSS VDD VDD _0584_ sky130_fd_sc_hd__nand2_1
X_2675_ _0275_ _0277_ _0303_ VSS VSS VDD VDD _0585_ sky130_fd_sc_hd__mux2i_1
X_2676_ _0544_ _0585_ _0298_ VSS VSS VDD VDD _0586_ sky130_fd_sc_hd__mux2i_1
X_2677_ _0478_ _0586_ VSS VSS VDD VDD _0587_ sky130_fd_sc_hd__nand2_1
X_2678_ _0317_ _0584_ _0587_ VSS VSS VDD VDD _0588_ sky130_fd_sc_hd__and3_1
X_2679_ _0418_ _0583_ _0588_ _0417_ VSS VSS VDD VDD _0589_
+ sky130_fd_sc_hd__a211oi_2
X_2680_ _0277_ _0327_ _0589_ VSS VSS VDD VDD _0590_ sky130_fd_sc_hd__a21oi_1
X_2681_ _0290_ _0560_ VSS VSS VDD VDD _0591_ sky130_fd_sc_hd__nand2_1
X_2682_ _0523_ _0590_ _0591_ VSS VSS VDD VDD _0087_ sky130_fd_sc_hd__o21ai_1
X_2683_ _0388_ _0566_ VSS VSS VDD VDD _0592_ sky130_fd_sc_hd__nor2_1
X_2684_ _0277_ _0290_ _0319_ VSS VSS VDD VDD _0593_ sky130_fd_sc_hd__mux2_1
X_2685_ _0333_ _0593_ VSS VSS VDD VDD _0594_ sky130_fd_sc_hd__nor2_1
X_2686_ _0448_ _0592_ _0594_ VSS VSS VDD VDD _0595_ sky130_fd_sc_hd__or3_1
X_2687_ _0528_ _0595_ _0402_ VSS VSS VDD VDD _0596_ sky130_fd_sc_hd__mux2i_1
X_2688_ _0406_ _0472_ VSS VSS VDD VDD _0597_ sky130_fd_sc_hd__nor2_1
X_2689_ _0406_ _0596_ _0597_ VSS VSS VDD VDD _0598_ sky130_fd_sc_hd__a21oi_1
X_2690_ _0446_ _0598_ _0290_ _0421_ VSS VSS VDD VDD _0599_
+ sky130_fd_sc_hd__a2bb2oi_1
X_2691_ _0295_ _0537_ VSS VSS VDD VDD _0600_ sky130_fd_sc_hd__nand2_1
X_2692_ _0277_ _0290_ _0303_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__mux2i_1
X_2693_ _0563_ _0601_ _0298_ VSS VSS VDD VDD _0602_ sky130_fd_sc_hd__mux2i_1
X_2694_ _0478_ _0602_ VSS VSS VDD VDD _0603_ sky130_fd_sc_hd__nand2_1
X_2695_ _0317_ _0600_ _0603_ VSS VSS VDD VDD _0604_ sky130_fd_sc_hd__and3_1
X_2696_ _0418_ _0599_ _0604_ _0417_ VSS VSS VDD VDD _0605_
+ sky130_fd_sc_hd__a211oi_1
X_2697_ _0290_ _0327_ _0605_ VSS VSS VDD VDD _0606_ sky130_fd_sc_hd__a21oi_1
X_2698_ _0279_ _0560_ VSS VSS VDD VDD _0607_ sky130_fd_sc_hd__nand2_1
X_2699_ _0523_ _0606_ _0607_ VSS VSS VDD VDD _0088_ sky130_fd_sc_hd__o21ai_0
X_2700_ _1695_ _0545_ VSS VSS VDD VDD _0608_ sky130_fd_sc_hd__nand2_1
X_2701_ _0290_ _0279_ _1711_ VSS VSS VDD VDD _0609_ sky130_fd_sc_hd__mux2i_1
X_2702_ _0585_ _0609_ _1574_ VSS VSS VDD VDD _0610_ sky130_fd_sc_hd__mux2i_1
X_2703_ _1698_ _0610_ VSS VSS VDD VDD _0611_ sky130_fd_sc_hd__nand2_1
X_2704_ _0290_ _0279_ _0390_ VSS VSS VDD VDD _0612_ sky130_fd_sc_hd__mux2i_1
X_2705_ _0575_ _0612_ _0388_ VSS VSS VDD VDD _0613_ sky130_fd_sc_hd__mux2i_1
X_2706_ _0401_ _0613_ VSS VSS VDD VDD _0614_ sky130_fd_sc_hd__nand2_1
X_2707_ _0449_ _0550_ VSS VSS VDD VDD _0615_ sky130_fd_sc_hd__nand2_1
X_2708_ _0614_ _0615_ _0448_ VSS VSS VDD VDD _0616_ sky130_fd_sc_hd__a21oi_1
X_2709_ _0487_ _0616_ _0405_ VSS VSS VDD VDD _0617_ sky130_fd_sc_hd__mux2_1
X_2710_ _0279_ _0384_ _0411_ _0617_ _0317_ VSS VSS VDD VDD
+ _0618_ sky130_fd_sc_hd__a221oi_2
X_2711_ _0318_ _0608_ _0611_ _0618_ _0431_ VSS VSS VDD VDD
+ _0619_ sky130_fd_sc_hd__a311oi_2
X_2712_ _0279_ _0327_ _0619_ VSS VSS VDD VDD _0620_ sky130_fd_sc_hd__a21oi_1
X_2713_ _0278_ _0560_ VSS VSS VDD VDD _0621_ sky130_fd_sc_hd__nand2_1
X_2714_ _0523_ _0620_ _0621_ VSS VSS VDD VDD _0089_ sky130_fd_sc_hd__o21ai_0
X_2715_ _0279_ _0278_ _0390_ VSS VSS VDD VDD _0622_ sky130_fd_sc_hd__mux2i_1
X_2716_ _0432_ _0622_ VSS VSS VDD VDD _0623_ sky130_fd_sc_hd__nand2_1
X_2717_ _0432_ _0593_ _0623_ _0399_ VSS VSS VDD VDD _0624_
+ sky130_fd_sc_hd__o211ai_1
X_2718_ _0568_ _0624_ _0402_ VSS VSS VDD VDD _0625_ sky130_fd_sc_hd__mux2i_2
X_2719_ _0500_ _0625_ _0405_ VSS VSS VDD VDD _0626_ sky130_fd_sc_hd__mux2_1
X_2720_ _0278_ _0421_ _0411_ _0626_ VSS VSS VDD VDD _0627_
+ sky130_fd_sc_hd__a22oi_1
X_2721_ _0295_ _0564_ VSS VSS VDD VDD _0628_ sky130_fd_sc_hd__nand2_1
X_2722_ _0279_ _0278_ _0303_ VSS VSS VDD VDD _0629_ sky130_fd_sc_hd__mux2i_2
X_2723_ _0601_ _0629_ _0298_ VSS VSS VDD VDD _0630_ sky130_fd_sc_hd__mux2i_1
X_2724_ _0478_ _0630_ VSS VSS VDD VDD _0631_ sky130_fd_sc_hd__nand2_1
X_2725_ _0317_ _0628_ _0631_ VSS VSS VDD VDD _0632_ sky130_fd_sc_hd__and3_1
X_2726_ _0418_ _0627_ _0632_ _0431_ VSS VSS VDD VDD _0633_
+ sky130_fd_sc_hd__a211oi_1
X_2727_ _0278_ _0327_ _0633_ VSS VSS VDD VDD _0634_ sky130_fd_sc_hd__a21oi_1
X_2728_ add_result\[17\] _0560_ VSS VSS VDD VDD _0635_ sky130_fd_sc_hd__nand2_1
X_2729_ _0523_ _0634_ _0635_ VSS VSS VDD VDD _0090_ sky130_fd_sc_hd__o21ai_0
X_2730_ _1695_ _0586_ VSS VSS VDD VDD _0636_ sky130_fd_sc_hd__nand2_1
X_2731_ _0278_ add_result\[17\] _0479_ VSS VSS VDD VDD _0637_
+ sky130_fd_sc_hd__mux2i_1
X_2732_ _0609_ _0637_ _0299_ VSS VSS VDD VDD _0638_ sky130_fd_sc_hd__mux2i_1
X_2733_ _1698_ _0638_ VSS VSS VDD VDD _0639_ sky130_fd_sc_hd__nand2_1
X_2734_ _0278_ add_result\[17\] _0319_ VSS VSS VDD VDD _0640_
+ sky130_fd_sc_hd__mux2_1
X_2735_ _0334_ _0640_ VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__nor2_1
X_2736_ _0334_ _0612_ _0641_ VSS VSS VDD VDD _0642_ sky130_fd_sc_hd__a21oi_1
X_2737_ _0402_ _0642_ VSS VSS VDD VDD _0643_ sky130_fd_sc_hd__nand2_1
X_2738_ _0403_ _0577_ _0643_ VSS VSS VDD VDD _0644_ sky130_fd_sc_hd__o21ai_0
X_2739_ _0400_ _0406_ _0644_ VSS VSS VDD VDD _0645_ sky130_fd_sc_hd__nand3_1
X_2740_ _0524_ _0516_ _0645_ VSS VSS VDD VDD _0646_ sky130_fd_sc_hd__o21ai_0
X_2741_ _0411_ _0646_ _0387_ VSS VSS VDD VDD _0647_ sky130_fd_sc_hd__a21oi_1
X_2742_ _0318_ _0636_ _0639_ _0647_ _0431_ VSS VSS VDD VDD
+ _0648_ sky130_fd_sc_hd__a311oi_2
X_2743_ add_result\[17\] _0386_ _0648_ VSS VSS VDD VDD _0649_
+ sky130_fd_sc_hd__a21oi_1
X_2744_ add_result\[18\] _0560_ VSS VSS VDD VDD _0650_ sky130_fd_sc_hd__nand2_1
X_2745_ _0523_ _0649_ _0650_ VSS VSS VDD VDD _0091_ sky130_fd_sc_hd__o21ai_1
X_2746_ add_result\[18\] _0390_ VSS VSS VDD VDD _0651_ sky130_fd_sc_hd__and2_0
X_2747_ _0390_ add_result\[17\] VSS VSS VDD VDD _0652_ sky130_fd_sc_hd__nor2b_1
X_2748_ _0651_ _0652_ _0451_ VSS VSS VDD VDD _0653_ sky130_fd_sc_hd__o21ai_0
X_2749_ _0451_ _0622_ _0653_ VSS VSS VDD VDD _0654_ sky130_fd_sc_hd__o21ai_1
X_2750_ _0400_ _0403_ _0654_ VSS VSS VDD VDD _0655_ sky130_fd_sc_hd__nand3_1
X_2751_ _0403_ _0595_ _0655_ _0406_ VSS VSS VDD VDD _0656_
+ sky130_fd_sc_hd__o211ai_1
X_2752_ _0524_ _0532_ _0656_ VSS VSS VDD VDD _0657_ sky130_fd_sc_hd__o21ai_0
X_2753_ _0408_ _0657_ VSS VSS VDD VDD _0658_ sky130_fd_sc_hd__nand2_1
X_2754_ _0321_ _0384_ _0445_ VSS VSS VDD VDD _0659_ sky130_fd_sc_hd__or3_1
X_2755_ _0404_ _0659_ _0446_ VSS VSS VDD VDD _0660_ sky130_fd_sc_hd__o21ai_0
X_2756_ _0295_ _0602_ VSS VSS VDD VDD _0661_ sky130_fd_sc_hd__nand2_1
X_2757_ add_result\[17\] add_result\[18\] _0303_ VSS VSS VDD
+ VDD _0662_ sky130_fd_sc_hd__mux2i_2
X_2758_ _0629_ _0662_ _0298_ VSS VSS VDD VDD _0663_ sky130_fd_sc_hd__mux2i_2
X_2759_ _0478_ _0663_ VSS VSS VDD VDD _0664_ sky130_fd_sc_hd__nand2_1
X_2760_ _0661_ _0664_ _0424_ VSS VSS VDD VDD _0665_ sky130_fd_sc_hd__a21oi_1
X_2761_ _0418_ _0658_ _0660_ _0665_ VSS VSS VDD VDD _0666_
+ sky130_fd_sc_hd__a31oi_1
X_2762_ _0417_ _0666_ _0386_ add_result\[18\] VSS VSS VDD
+ VDD _0667_ sky130_fd_sc_hd__a2bb2oi_1
X_2763_ add_result\[19\] _0560_ VSS VSS VDD VDD _0668_ sky130_fd_sc_hd__nand2_1
X_2764_ _0340_ _0667_ _0668_ VSS VSS VDD VDD _0092_ sky130_fd_sc_hd__o21ai_0
X_2765_ _1695_ _0610_ VSS VSS VDD VDD _0669_ sky130_fd_sc_hd__nand2_1
X_2766_ add_result\[18\] add_result\[19\] _0479_ VSS VSS VDD
+ VDD _0670_ sky130_fd_sc_hd__mux2i_1
X_2767_ _0637_ _0670_ _0299_ VSS VSS VDD VDD _0671_ sky130_fd_sc_hd__mux2i_1
X_2768_ _1698_ _0671_ VSS VSS VDD VDD _0672_ sky130_fd_sc_hd__nand2_1
X_2769_ add_result\[18\] add_result\[19\] _0320_ VSS VSS VDD
+ VDD _0673_ sky130_fd_sc_hd__mux2i_1
X_2770_ _0432_ _0673_ VSS VSS VDD VDD _0674_ sky130_fd_sc_hd__nand2_1
X_2771_ _0432_ _0640_ _0674_ VSS VSS VDD VDD _0675_ sky130_fd_sc_hd__o21ai_1
X_2772_ _0449_ _0675_ VSS VSS VDD VDD _0676_ sky130_fd_sc_hd__nor2_1
X_2773_ _0450_ _0613_ _0676_ VSS VSS VDD VDD _0677_ sky130_fd_sc_hd__a21oi_1
X_2774_ _0445_ _0554_ VSS VSS VDD VDD _0678_ sky130_fd_sc_hd__nand2_1
X_2775_ _0448_ _0445_ _0677_ _0678_ _0408_ VSS VSS VDD VDD
+ _0679_ sky130_fd_sc_hd__o311ai_1
X_2776_ _0420_ _0659_ _0446_ VSS VSS VDD VDD _0680_ sky130_fd_sc_hd__o21ai_0
X_2777_ _0679_ _0680_ _0387_ VSS VSS VDD VDD _0681_ sky130_fd_sc_hd__a21oi_1
X_2778_ _0318_ _0669_ _0672_ _0681_ _0304_ VSS VSS VDD VDD
+ _0682_ sky130_fd_sc_hd__a311oi_2
X_2779_ add_result\[19\] _0386_ _0682_ VSS VSS VDD VDD _0683_
+ sky130_fd_sc_hd__a21oi_1
X_2780_ _0286_ _0560_ VSS VSS VDD VDD _0684_ sky130_fd_sc_hd__nand2_1
X_2781_ _0340_ _0683_ _0684_ VSS VSS VDD VDD _0093_ sky130_fd_sc_hd__o21ai_0
X_2782_ _0445_ _0569_ VSS VSS VDD VDD _0685_ sky130_fd_sc_hd__and2_0
X_2783_ add_result\[19\] _0286_ _0320_ VSS VSS VDD VDD _0686_
+ sky130_fd_sc_hd__mux2i_1
X_2784_ _0432_ _0686_ VSS VSS VDD VDD _0687_ sky130_fd_sc_hd__nand2_1
X_2785_ _0388_ _0651_ _0652_ _0687_ _0399_ VSS VSS VDD VDD
+ _0688_ sky130_fd_sc_hd__o311a_1
X_2786_ _0403_ _0624_ VSS VSS VDD VDD _0689_ sky130_fd_sc_hd__nor2_1
X_2787_ _0403_ _0688_ _0689_ _0445_ VSS VSS VDD VDD _0690_
+ sky130_fd_sc_hd__a211oi_1
X_2788_ _0685_ _0690_ _0408_ VSS VSS VDD VDD _0691_ sky130_fd_sc_hd__o21ai_0
X_2789_ _0435_ _0659_ _0446_ VSS VSS VDD VDD _0692_ sky130_fd_sc_hd__o21ai_0
X_2790_ _0295_ _0630_ VSS VSS VDD VDD _0693_ sky130_fd_sc_hd__nand2_1
X_2791_ add_result\[19\] _0286_ _0479_ VSS VSS VDD VDD _0694_
+ sky130_fd_sc_hd__mux2i_2
X_2792_ _0662_ _0694_ _0299_ VSS VSS VDD VDD _0695_ sky130_fd_sc_hd__mux2i_2
X_2793_ _0478_ _0695_ VSS VSS VDD VDD _0696_ sky130_fd_sc_hd__nand2_1
X_2794_ _0693_ _0696_ _0424_ VSS VSS VDD VDD _0697_ sky130_fd_sc_hd__a21oi_1
X_2795_ _0418_ _0691_ _0692_ _0697_ VSS VSS VDD VDD _0698_
+ sky130_fd_sc_hd__a31oi_1
X_2796_ _0417_ _0698_ _0386_ _0286_ VSS VSS VDD VDD _0699_
+ sky130_fd_sc_hd__a2bb2oi_1
X_2797_ _0287_ _0560_ VSS VSS VDD VDD _0700_ sky130_fd_sc_hd__nand2_1
X_2798_ _0340_ _0699_ _0700_ VSS VSS VDD VDD _0094_ sky130_fd_sc_hd__o21ai_0
X_2799_ _0321_ _0384_ _0445_ VSS VSS VDD VDD _0701_ sky130_fd_sc_hd__nor3_1
X_2800_ _0455_ _0701_ VSS VSS VDD VDD _0702_ sky130_fd_sc_hd__nand2_1
X_2801_ _0446_ _0702_ VSS VSS VDD VDD _0703_ sky130_fd_sc_hd__nand2_1
X_2802_ _0286_ _0287_ _0320_ VSS VSS VDD VDD _0704_ sky130_fd_sc_hd__mux2_1
X_2803_ _0389_ _0673_ VSS VSS VDD VDD _0705_ sky130_fd_sc_hd__nor2_1
X_2804_ _0389_ _0704_ _0705_ VSS VSS VDD VDD _0706_ sky130_fd_sc_hd__a21oi_1
X_2805_ _0450_ _0642_ VSS VSS VDD VDD _0707_ sky130_fd_sc_hd__nand2_1
X_2806_ _0450_ _0706_ _0707_ VSS VSS VDD VDD _0708_ sky130_fd_sc_hd__o21ai_0
X_2807_ _0400_ _0524_ _0708_ VSS VSS VDD VDD _0709_ sky130_fd_sc_hd__nand3_1
X_2808_ _0524_ _0580_ _0709_ _0408_ VSS VSS VDD VDD _0710_
+ sky130_fd_sc_hd__o211ai_1
X_2809_ _0295_ _0638_ VSS VSS VDD VDD _0711_ sky130_fd_sc_hd__nand2_1
X_2810_ _1702_ _0670_ VSS VSS VDD VDD _0712_ sky130_fd_sc_hd__nand2_1
X_2811_ _0286_ _0287_ _1711_ VSS VSS VDD VDD _0713_ sky130_fd_sc_hd__mux2i_1
X_2812_ _1574_ _0713_ VSS VSS VDD VDD _0714_ sky130_fd_sc_hd__nand2_1
X_2813_ _0478_ _0712_ _0714_ VSS VSS VDD VDD _0715_ sky130_fd_sc_hd__nand3_1
X_2814_ _0711_ _0715_ _0424_ VSS VSS VDD VDD _0716_ sky130_fd_sc_hd__a21oi_1
X_2815_ _0424_ _0703_ _0710_ _0716_ VSS VSS VDD VDD _0717_
+ sky130_fd_sc_hd__a31oi_1
X_2816_ _0417_ _0717_ VSS VSS VDD VDD _0718_ sky130_fd_sc_hd__nor2_1
X_2817_ _0287_ _0386_ _0718_ _0266_ VSS VSS VDD VDD _0719_
+ sky130_fd_sc_hd__a211oi_1
X_2818_ _0300_ _0415_ _0719_ VSS VSS VDD VDD _0095_ sky130_fd_sc_hd__a21oi_1
X_2819_ _0287_ _0267_ _0320_ VSS VSS VDD VDD _0720_ sky130_fd_sc_hd__mux2_1
X_2820_ _0451_ _0686_ VSS VSS VDD VDD _0721_ sky130_fd_sc_hd__nor2_1
X_2821_ _0389_ _0720_ _0721_ VSS VSS VDD VDD _0722_ sky130_fd_sc_hd__a21oi_1
X_2822_ _0400_ _0450_ _0654_ VSS VSS VDD VDD _0723_ sky130_fd_sc_hd__nand3_1
X_2823_ _0448_ _0450_ _0722_ _0723_ _0406_ VSS VSS VDD VDD
+ _0724_ sky130_fd_sc_hd__o311ai_0
X_2824_ _0524_ _0596_ _0724_ VSS VSS VDD VDD _0725_ sky130_fd_sc_hd__o21ai_0
X_2825_ _0408_ _0725_ VSS VSS VDD VDD _0726_ sky130_fd_sc_hd__nand2_1
X_2826_ _0472_ _0659_ _0446_ VSS VSS VDD VDD _0727_ sky130_fd_sc_hd__o21ai_0
X_2827_ _0287_ _0267_ _0479_ VSS VSS VDD VDD _0728_ sky130_fd_sc_hd__mux2_1
X_2828_ _1574_ _0694_ VSS VSS VDD VDD _0729_ sky130_fd_sc_hd__nor2_1
X_2829_ _0295_ _0663_ _0728_ _1574_ _0729_ VSS VSS VDD VDD
+ _0730_ sky130_fd_sc_hd__a221oi_2
X_2830_ _0424_ _0730_ VSS VSS VDD VDD _0731_ sky130_fd_sc_hd__nor2_1
X_2831_ _0418_ _0726_ _0727_ _0731_ VSS VSS VDD VDD _0732_
+ sky130_fd_sc_hd__a31oi_1
X_2832_ _0417_ _0732_ _0386_ _0267_ VSS VSS VDD VDD _0733_
+ sky130_fd_sc_hd__a2bb2oi_1
X_2833_ _0269_ _0523_ VSS VSS VDD VDD _0734_ sky130_fd_sc_hd__nand2_1
X_2834_ _0340_ _0733_ _0734_ VSS VSS VDD VDD _0097_ sky130_fd_sc_hd__o21ai_0
X_2835_ _0445_ _0616_ VSS VSS VDD VDD _0735_ sky130_fd_sc_hd__nand2_1
X_2836_ _0269_ _0320_ VSS VSS VDD VDD _0736_ sky130_fd_sc_hd__nand2_1
X_2837_ _0300_ _0320_ _0736_ _0389_ VSS VSS VDD VDD _0737_
+ sky130_fd_sc_hd__o211ai_1
X_2838_ _0389_ _0704_ _0737_ _0403_ VSS VSS VDD VDD _0738_
+ sky130_fd_sc_hd__o211ai_1
X_2839_ _0403_ _0675_ _0738_ VSS VSS VDD VDD _0739_ sky130_fd_sc_hd__o21ai_0
X_2840_ _0400_ _0524_ _0739_ VSS VSS VDD VDD _0740_ sky130_fd_sc_hd__nand3_1
X_2841_ _0487_ _0701_ _0411_ VSS VSS VDD VDD _0741_ sky130_fd_sc_hd__a21oi_1
X_2842_ _0408_ _0735_ _0740_ _0741_ VSS VSS VDD VDD _0742_
+ sky130_fd_sc_hd__a31oi_1
X_2843_ _0268_ _0287_ VSS VSS VDD VDD _0743_ sky130_fd_sc_hd__nor2b_1
X_2844_ _0296_ _0743_ _0269_ VSS VSS VDD VDD _0744_ sky130_fd_sc_hd__o21ai_0
X_2845_ _0269_ _0286_ VSS VSS VDD VDD _0745_ sky130_fd_sc_hd__nor2b_1
X_2846_ _0268_ _0745_ _0293_ _0267_ VSS VSS VDD VDD _0746_
+ sky130_fd_sc_hd__o211ai_1
X_2847_ _0295_ _0671_ VSS VSS VDD VDD _0747_ sky130_fd_sc_hd__nand2_1
X_2848_ _0744_ _0746_ _0747_ _0424_ VSS VSS VDD VDD _0748_
+ sky130_fd_sc_hd__a31oi_1
X_2849_ _0418_ _0742_ _0748_ VSS VSS VDD VDD _0749_ sky130_fd_sc_hd__a21oi_1
X_2850_ _0417_ _0749_ VSS VSS VDD VDD _0750_ sky130_fd_sc_hd__nor2_1
X_2851_ _0269_ _0386_ _0750_ VSS VSS VDD VDD _0751_ sky130_fd_sc_hd__a21oi_1
X_2852_ _0268_ _0523_ VSS VSS VDD VDD _0752_ sky130_fd_sc_hd__nand2_1
X_2853_ _0340_ _0751_ _0752_ VSS VSS VDD VDD _0098_ sky130_fd_sc_hd__o21ai_0
X_2854_ _0269_ _0268_ _0320_ VSS VSS VDD VDD _0753_ sky130_fd_sc_hd__mux2i_1
X_2855_ _0389_ _0753_ VSS VSS VDD VDD _0754_ sky130_fd_sc_hd__nand2_1
X_2856_ _0389_ _0720_ _0754_ VSS VSS VDD VDD _0755_ sky130_fd_sc_hd__o21ai_0
X_2857_ _0450_ _0688_ VSS VSS VDD VDD _0756_ sky130_fd_sc_hd__nand2_1
X_2858_ _0448_ _0450_ _0755_ _0756_ _0406_ VSS VSS VDD VDD
+ _0757_ sky130_fd_sc_hd__o311ai_1
X_2859_ _0524_ _0625_ _0757_ VSS VSS VDD VDD _0758_ sky130_fd_sc_hd__o21ai_0
X_2860_ _0500_ _0701_ _0411_ VSS VSS VDD VDD _0759_ sky130_fd_sc_hd__a21oi_1
X_2861_ _0408_ _0758_ _0759_ VSS VSS VDD VDD _0760_ sky130_fd_sc_hd__a21oi_1
X_2862_ _0268_ _0421_ _0760_ _0318_ VSS VSS VDD VDD _0761_
+ sky130_fd_sc_hd__a211oi_1
X_2863_ _0268_ _0296_ _0743_ _0269_ VSS VSS VDD VDD _0762_
+ sky130_fd_sc_hd__a211oi_1
X_2864_ _0267_ _0293_ _0268_ VSS VSS VDD VDD _0763_ sky130_fd_sc_hd__a21oi_1
X_2865_ _0762_ _0763_ _0318_ VSS VSS VDD VDD _0764_ sky130_fd_sc_hd__o21ai_0
X_2866_ _1695_ _0695_ _0764_ VSS VSS VDD VDD _0765_ sky130_fd_sc_hd__a21oi_1
X_2867_ _0268_ _0340_ _0305_ VSS VSS VDD VDD _0766_ sky130_fd_sc_hd__o21ai_0
X_2868_ _0327_ _0308_ _0761_ _0765_ _0766_ VSS VSS VDD VDD
+ _0099_ sky130_fd_sc_hd__o41ai_1
X_2869_ net22 net21 net25 net23 VSS VSS VDD VDD _0767_ sky130_fd_sc_hd__nand4_4
X_2870_ net18 net17 net20 net19 VSS VSS VDD VDD _0768_ sky130_fd_sc_hd__nand4_2
X_2871_ net54 net53 net57 net55 VSS VSS VDD VDD _0769_ sky130_fd_sc_hd__nand4_1
X_2872_ net50 net49 VSS VSS VDD VDD _0770_ sky130_fd_sc_hd__nand2_1
X_2873_ _1606_ _1612_ _0769_ _0770_ VSS VSS VDD VDD _0771_
+ sky130_fd_sc_hd__or4_1
X_2874_ _0771_ VSS VSS VDD VDD _0772_ sky130_fd_sc_hd__clkbuf_2
X_2875_ _0767_ _0768_ _0772_ VSS VSS VDD VDD _0773_ sky130_fd_sc_hd__o21ai_4
X_2876_ _0773_ VSS VSS VDD VDD _0774_ sky130_fd_sc_hd__buf_2
X_2877_ _1730_ VSS VSS VDD VDD _0775_ sky130_fd_sc_hd__inv_1
X_2878_ aligned_a_mant\[0\] aligned_b_mant\[0\] _0775_ _1734_
+ VSS VSS VDD VDD _0776_ sky130_fd_sc_hd__a31oi_2
X_2879_ a_sign_stage1 b_sign_stage1 VSS VSS VDD VDD _0777_
+ sky130_fd_sc_hd__xnor2_4
X_2880_ _0777_ VSS VSS VDD VDD _0778_ sky130_fd_sc_hd__buf_4
X_2881_ _0778_ VSS VSS VDD VDD _0779_ sky130_fd_sc_hd__buf_4
X_2882_ is_a_larger_stage1 VSS VSS VDD VDD _0780_ sky130_fd_sc_hd__clkbuf_4
X_2883_ _0780_ VSS VSS VDD VDD _0781_ sky130_fd_sc_hd__clkbuf_4
X_2884_ _0781_ VSS VSS VDD VDD _0782_ sky130_fd_sc_hd__clkbuf_4
X_2885_ _1732_ _0781_ VSS VSS VDD VDD _0783_ sky130_fd_sc_hd__nand2b_1
X_2886_ _1729_ _0782_ _0783_ VSS VSS VDD VDD _0784_ sky130_fd_sc_hd__o21ai_0
X_2887_ aligned_b_mant\[0\] aligned_a_mant\[0\] VSS VSS VDD
+ VDD _0785_ sky130_fd_sc_hd__nand2b_1
X_2888_ _1729_ _0782_ _0785_ VSS VSS VDD VDD _0786_ sky130_fd_sc_hd__nor3_1
X_2889_ aligned_a_mant\[0\] aligned_b_mant\[0\] VSS VSS VDD
+ VDD _0787_ sky130_fd_sc_hd__nand2b_1
X_2890_ _0783_ _0787_ VSS VSS VDD VDD _0788_ sky130_fd_sc_hd__nor2_1
X_2891_ _0775_ _0784_ _0786_ _0788_ _0778_ VSS VSS VDD VDD
+ _0789_ sky130_fd_sc_hd__a2111oi_0
X_2892_ _0776_ _0779_ _0789_ VSS VSS VDD VDD _0790_ sky130_fd_sc_hd__a21oi_1
X_2893_ _1722_ _0790_ VSS VSS VDD VDD _0791_ sky130_fd_sc_hd__xor2_2
X_2894_ _0774_ _0791_ VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__nor2_1
X_2895_ _0777_ VSS VSS VDD VDD _0792_ sky130_fd_sc_hd__clkbuf_4
X_2896_ is_a_larger_stage1 VSS VSS VDD VDD _0793_ sky130_fd_sc_hd__clkinv_4
X_2897_ _1730_ _0787_ _1732_ VSS VSS VDD VDD _0794_ sky130_fd_sc_hd__a21o_1
X_2898_ _1722_ _0794_ _1724_ VSS VSS VDD VDD _0795_ sky130_fd_sc_hd__a21o_1
X_2899_ _0793_ _0795_ VSS VSS VDD VDD _0796_ sky130_fd_sc_hd__nor2_1
X_2900_ _0782_ VSS VSS VDD VDD _0797_ sky130_fd_sc_hd__buf_4
X_2901_ _1730_ _0785_ _1729_ VSS VSS VDD VDD _0798_ sky130_fd_sc_hd__a21o_1
X_2902_ _1722_ _0798_ _1721_ VSS VSS VDD VDD _0799_ sky130_fd_sc_hd__a21o_1
X_2903_ _0797_ _0799_ VSS VSS VDD VDD _0800_ sky130_fd_sc_hd__nor2_1
X_2904_ _0796_ _0800_ VSS VSS VDD VDD _0801_ sky130_fd_sc_hd__nor2_1
X_2905_ _1722_ _0776_ _1726_ VSS VSS VDD VDD _0802_ sky130_fd_sc_hd__o21bai_2
X_2906_ _0792_ _0802_ VSS VSS VDD VDD _0803_ sky130_fd_sc_hd__nand2_1
X_2907_ _0792_ _0801_ _0803_ VSS VSS VDD VDD _0804_ sky130_fd_sc_hd__o21ai_1
X_2908_ _1738_ _0804_ VSS VSS VDD VDD _0805_ sky130_fd_sc_hd__xor2_2
X_2909_ _0774_ _0805_ VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__nor2_1
X_2910_ _1746_ VSS VSS VDD VDD _0806_ sky130_fd_sc_hd__clkbuf_2
X_2911_ a_sign_stage1 b_sign_stage1 VSS VSS VDD VDD _0807_
+ sky130_fd_sc_hd__xor2_4
X_2912_ _0807_ VSS VSS VDD VDD _0808_ sky130_fd_sc_hd__buf_4
X_2913_ _1738_ _0802_ VSS VSS VDD VDD _0809_ sky130_fd_sc_hd__nor2b_1
X_2914_ _1738_ _0799_ _1737_ VSS VSS VDD VDD _0810_ sky130_fd_sc_hd__a21o_1
X_2915_ _1738_ _0795_ _1740_ VSS VSS VDD VDD _0811_ sky130_fd_sc_hd__a21oi_2
X_2916_ _0797_ _0811_ VSS VSS VDD VDD _0812_ sky130_fd_sc_hd__nand2_1
X_2917_ _0797_ _0810_ _0812_ _0808_ VSS VSS VDD VDD _0813_
+ sky130_fd_sc_hd__o211ai_1
X_2918_ _1742_ _0808_ _0809_ _0813_ VSS VSS VDD VDD _0814_
+ sky130_fd_sc_hd__o31ai_1
X_2919_ _0806_ _0814_ VSS VSS VDD VDD _0815_ sky130_fd_sc_hd__xnor2_1
X_2920_ _0774_ _0815_ VSS VSS VDD VDD _0019_ sky130_fd_sc_hd__nor2_1
X_2921_ _1754_ VSS VSS VDD VDD _0816_ sky130_fd_sc_hd__buf_2
X_2922_ _0806_ VSS VSS VDD VDD _0817_ sky130_fd_sc_hd__inv_1
X_2923_ _0817_ _0811_ _1748_ VSS VSS VDD VDD _0818_ sky130_fd_sc_hd__o21bai_1
X_2924_ _0806_ _0810_ _1745_ VSS VSS VDD VDD _0819_ sky130_fd_sc_hd__a21oi_1
X_2925_ _0797_ _0819_ VSS VSS VDD VDD _0820_ sky130_fd_sc_hd__nor2_1
X_2926_ _0797_ _0818_ _0820_ VSS VSS VDD VDD _0821_ sky130_fd_sc_hd__a21oi_1
X_2927_ _1738_ _0806_ VSS VSS VDD VDD _0822_ sky130_fd_sc_hd__nor2_1
X_2928_ _1742_ _0817_ _1750_ VSS VSS VDD VDD _0823_ sky130_fd_sc_hd__a21o_1
X_2929_ _0802_ _0822_ _0823_ VSS VSS VDD VDD _0824_ sky130_fd_sc_hd__a21oi_1
X_2930_ _0779_ _0824_ VSS VSS VDD VDD _0825_ sky130_fd_sc_hd__nand2_1
X_2931_ _0792_ _0821_ _0825_ VSS VSS VDD VDD _0826_ sky130_fd_sc_hd__o21ai_1
X_2932_ _0816_ _0826_ VSS VSS VDD VDD _0827_ sky130_fd_sc_hd__xnor2_1
X_2933_ _0774_ _0827_ VSS VSS VDD VDD _0020_ sky130_fd_sc_hd__nor2_1
X_2934_ _1762_ VSS VSS VDD VDD _0828_ sky130_fd_sc_hd__buf_2
X_2935_ _0816_ _0824_ VSS VSS VDD VDD _0829_ sky130_fd_sc_hd__nor2_1
X_2936_ _1758_ _0829_ VSS VSS VDD VDD _0830_ sky130_fd_sc_hd__nor2_1
X_2937_ _0782_ VSS VSS VDD VDD _0831_ sky130_fd_sc_hd__clkbuf_4
X_2938_ _1738_ _0806_ _0816_ VSS VSS VDD VDD _0832_ sky130_fd_sc_hd__and3_1
X_2939_ _0806_ _1737_ _1745_ VSS VSS VDD VDD _0833_ sky130_fd_sc_hd__a21oi_1
X_2940_ _0833_ _0816_ VSS VSS VDD VDD _0834_ sky130_fd_sc_hd__nor2b_1
X_2941_ _0799_ _0832_ _0834_ _1753_ VSS VSS VDD VDD _0835_
+ sky130_fd_sc_hd__a211o_1
X_2942_ _0831_ _0835_ VSS VSS VDD VDD _0836_ sky130_fd_sc_hd__nor2_1
X_2943_ _0816_ _0818_ _1756_ _0793_ VSS VSS VDD VDD _0837_
+ sky130_fd_sc_hd__a211oi_1
X_2944_ _0778_ _0836_ _0837_ VSS VSS VDD VDD _0838_ sky130_fd_sc_hd__nor3_1
X_2945_ _0779_ _0830_ _0838_ VSS VSS VDD VDD _0839_ sky130_fd_sc_hd__a21oi_1
X_2946_ _0828_ _0839_ VSS VSS VDD VDD _0840_ sky130_fd_sc_hd__xor2_1
X_2947_ _0774_ _0840_ VSS VSS VDD VDD _0021_ sky130_fd_sc_hd__nor2_1
X_2948_ _1770_ VSS VSS VDD VDD _0841_ sky130_fd_sc_hd__inv_1
X_2949_ _1766_ VSS VSS VDD VDD _0842_ sky130_fd_sc_hd__inv_1
X_2950_ _0828_ _0830_ _0842_ VSS VSS VDD VDD _0843_ sky130_fd_sc_hd__o21ai_0
X_2951_ _0808_ _0843_ VSS VSS VDD VDD _0844_ sky130_fd_sc_hd__nor2_1
X_2952_ _0806_ _0816_ _0828_ VSS VSS VDD VDD _0845_ sky130_fd_sc_hd__nand3_1
X_2953_ _0816_ _1748_ _0828_ VSS VSS VDD VDD _0846_ sky130_fd_sc_hd__nand3_1
X_2954_ _0828_ _1756_ VSS VSS VDD VDD _0847_ sky130_fd_sc_hd__nand2_1
X_2955_ _0846_ _0847_ VSS VSS VDD VDD _0848_ sky130_fd_sc_hd__and2_0
X_2956_ _1764_ VSS VSS VDD VDD _0849_ sky130_fd_sc_hd__inv_1
X_2957_ _0811_ _0845_ _0848_ _0849_ _0780_ VSS VSS VDD VDD
+ _0850_ sky130_fd_sc_hd__o2111a_1
X_2958_ _0828_ _0835_ _1761_ _0780_ VSS VSS VDD VDD _0851_
+ sky130_fd_sc_hd__a211oi_2
X_2959_ _0778_ _0850_ _0851_ VSS VSS VDD VDD _0852_ sky130_fd_sc_hd__nor3_1
X_2960_ _0844_ _0852_ VSS VSS VDD VDD _0853_ sky130_fd_sc_hd__nor2_1
X_2961_ _0841_ _0853_ VSS VSS VDD VDD _0854_ sky130_fd_sc_hd__xnor2_1
X_2962_ _0774_ _0854_ VSS VSS VDD VDD _0022_ sky130_fd_sc_hd__nor2_1
X_2963_ _1778_ VSS VSS VDD VDD _0855_ sky130_fd_sc_hd__clkbuf_4
X_2964_ _0841_ _0843_ _1774_ VSS VSS VDD VDD _0856_ sky130_fd_sc_hd__a21oi_1
X_2965_ _0806_ _0816_ _0828_ _1770_ VSS VSS VDD VDD _0857_
+ sky130_fd_sc_hd__nand4_1
X_2966_ _0849_ _0846_ _0847_ _0841_ VSS VSS VDD VDD _0858_
+ sky130_fd_sc_hd__a31oi_1
X_2967_ _1772_ _0858_ VSS VSS VDD VDD _0859_ sky130_fd_sc_hd__nor2_1
X_2968_ _0811_ _0857_ _0859_ VSS VSS VDD VDD _0860_ sky130_fd_sc_hd__o21ai_2
X_2969_ _0828_ _0835_ _1761_ VSS VSS VDD VDD _0861_ sky130_fd_sc_hd__a21oi_2
X_2970_ _0831_ _1769_ VSS VSS VDD VDD _0862_ sky130_fd_sc_hd__nor2_1
X_2971_ _0841_ _0861_ _0862_ VSS VSS VDD VDD _0863_ sky130_fd_sc_hd__o21ai_0
X_2972_ _0793_ _0860_ _0863_ _0808_ VSS VSS VDD VDD _0864_
+ sky130_fd_sc_hd__o211ai_1
X_2973_ _0792_ _0856_ _0864_ VSS VSS VDD VDD _0865_ sky130_fd_sc_hd__a21boi_0
X_2974_ _0855_ _0865_ VSS VSS VDD VDD _0866_ sky130_fd_sc_hd__xor2_1
X_2975_ _0774_ _0866_ VSS VSS VDD VDD _0023_ sky130_fd_sc_hd__nor2_1
X_2976_ _1786_ VSS VSS VDD VDD _0867_ sky130_fd_sc_hd__buf_2
X_2977_ _0867_ VSS VSS VDD VDD _0868_ sky130_fd_sc_hd__inv_1
X_2978_ _0855_ _0860_ _1780_ VSS VSS VDD VDD _0869_ sky130_fd_sc_hd__a21oi_2
X_2979_ _1770_ _0855_ VSS VSS VDD VDD _0870_ sky130_fd_sc_hd__nand2_1
X_2980_ _0855_ _1769_ _1777_ VSS VSS VDD VDD _0871_ sky130_fd_sc_hd__a21oi_2
X_2981_ _0861_ _0870_ _0871_ VSS VSS VDD VDD _0872_ sky130_fd_sc_hd__o21ai_0
X_2982_ _0797_ _0872_ VSS VSS VDD VDD _0873_ sky130_fd_sc_hd__nor2_1
X_2983_ _0797_ _0869_ _0873_ VSS VSS VDD VDD _0874_ sky130_fd_sc_hd__a21oi_1
X_2984_ _1758_ _1766_ _1774_ _1782_ VSS VSS VDD VDD _0875_
+ sky130_fd_sc_hd__nor4_1
X_2985_ _0828_ _0842_ _1770_ VSS VSS VDD VDD _0876_ sky130_fd_sc_hd__a21oi_1
X_2986_ _1758_ _1766_ _1774_ VSS VSS VDD VDD _0877_ sky130_fd_sc_hd__nor3_1
X_2987_ _0816_ _0877_ _0855_ VSS VSS VDD VDD _0878_ sky130_fd_sc_hd__a21oi_1
X_2988_ _1774_ _0876_ _0878_ VSS VSS VDD VDD _0879_ sky130_fd_sc_hd__o21ai_0
X_2989_ _1782_ _0879_ VSS VSS VDD VDD _0880_ sky130_fd_sc_hd__nor2b_1
X_2990_ _0824_ _0875_ _0880_ VSS VSS VDD VDD _0881_ sky130_fd_sc_hd__a21oi_1
X_2991_ _0779_ _0881_ VSS VSS VDD VDD _0882_ sky130_fd_sc_hd__nand2_1
X_2992_ _0792_ _0874_ _0882_ VSS VSS VDD VDD _0883_ sky130_fd_sc_hd__o21ai_0
X_2993_ _0868_ _0883_ VSS VSS VDD VDD _0884_ sky130_fd_sc_hd__xnor2_1
X_2994_ _0774_ _0884_ VSS VSS VDD VDD _0024_ sky130_fd_sc_hd__nor2_1
X_2995_ _1794_ VSS VSS VDD VDD _0885_ sky130_fd_sc_hd__clkbuf_4
X_2996_ _0868_ _0881_ _1790_ VSS VSS VDD VDD _0886_ sky130_fd_sc_hd__a21oi_1
X_2997_ _0867_ _0872_ _1785_ _0831_ VSS VSS VDD VDD _0887_
+ sky130_fd_sc_hd__a211oi_1
X_2998_ _1788_ VSS VSS VDD VDD _0888_ sky130_fd_sc_hd__inv_1
X_2999_ _0868_ _0869_ _0888_ _0831_ VSS VSS VDD VDD _0889_
+ sky130_fd_sc_hd__o211a_1
X_3000_ _0778_ _0887_ _0889_ VSS VSS VDD VDD _0890_ sky130_fd_sc_hd__nor3_1
X_3001_ _0779_ _0886_ _0890_ VSS VSS VDD VDD _0891_ sky130_fd_sc_hd__a21oi_1
X_3002_ _0885_ _0891_ VSS VSS VDD VDD _0892_ sky130_fd_sc_hd__xor2_1
X_3003_ _0774_ _0892_ VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__nor2_1
X_3004_ _1802_ VSS VSS VDD VDD _0893_ sky130_fd_sc_hd__buf_2
X_3005_ _1770_ _0855_ _0867_ _0885_ VSS VSS VDD VDD _0894_
+ sky130_fd_sc_hd__nand4_2
X_3006_ _0868_ _0871_ _1785_ VSS VSS VDD VDD _0895_ sky130_fd_sc_hd__o21bai_1
X_3007_ _0885_ _0895_ _1793_ _0780_ VSS VSS VDD VDD _0896_
+ sky130_fd_sc_hd__a211o_1
X_3008_ _0855_ _1772_ _1780_ VSS VSS VDD VDD _0897_ sky130_fd_sc_hd__a21oi_1
X_3009_ _0868_ _0897_ _0888_ VSS VSS VDD VDD _0898_ sky130_fd_sc_hd__o21ai_0
X_3010_ _0885_ _0898_ _1796_ _0793_ VSS VSS VDD VDD _0899_
+ sky130_fd_sc_hd__a211o_1
X_3011_ _0896_ _0899_ VSS VSS VDD VDD _0900_ sky130_fd_sc_hd__nand2_1
X_3012_ _0850_ _0851_ _0894_ _0900_ VSS VSS VDD VDD _0901_
+ sky130_fd_sc_hd__o31ai_4
X_3013_ _0885_ _0886_ VSS VSS VDD VDD _0902_ sky130_fd_sc_hd__nor2_1
X_3014_ _1798_ _0902_ _0778_ VSS VSS VDD VDD _0903_ sky130_fd_sc_hd__o21ai_0
X_3015_ _0792_ _0901_ _0903_ VSS VSS VDD VDD _0904_ sky130_fd_sc_hd__o21ai_0
X_3016_ _0893_ _0904_ VSS VSS VDD VDD _0905_ sky130_fd_sc_hd__xor2_1
X_3017_ _0774_ _0905_ VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__nor2_1
X_3018_ _0773_ VSS VSS VDD VDD _0906_ sky130_fd_sc_hd__buf_2
X_3019_ _1810_ VSS VSS VDD VDD _0907_ sky130_fd_sc_hd__buf_2
X_3020_ _1798_ VSS VSS VDD VDD _0908_ sky130_fd_sc_hd__inv_1
X_3021_ _1794_ _1790_ VSS VSS VDD VDD _0909_ sky130_fd_sc_hd__nand2b_1
X_3022_ _0908_ _0909_ _0893_ VSS VSS VDD VDD _0910_ sky130_fd_sc_hd__a21oi_1
X_3023_ _1806_ _0910_ _0875_ VSS VSS VDD VDD _0911_ sky130_fd_sc_hd__or3b_1
X_3024_ _0802_ _0822_ _0823_ _0911_ VSS VSS VDD VDD _0912_
+ sky130_fd_sc_hd__a211oi_2
X_3025_ _1806_ _0910_ VSS VSS VDD VDD _0913_ sky130_fd_sc_hd__nor2_1
X_3026_ _0867_ _1794_ _0893_ VSS VSS VDD VDD _0914_ sky130_fd_sc_hd__or3_1
X_3027_ _1782_ _1806_ _0910_ VSS VSS VDD VDD _0915_ sky130_fd_sc_hd__nor3_1
X_3028_ _0913_ _0914_ _0915_ _0879_ VSS VSS VDD VDD _0916_
+ sky130_fd_sc_hd__a22o_1
X_3029_ _0912_ _0916_ VSS VSS VDD VDD _0917_ sky130_fd_sc_hd__nor2_1
X_3030_ _0893_ _1796_ _1804_ VSS VSS VDD VDD _0918_ sky130_fd_sc_hd__a21o_1
X_3031_ _0793_ _1788_ _0918_ VSS VSS VDD VDD _0919_ sky130_fd_sc_hd__nor3_1
X_3032_ _0885_ _0893_ VSS VSS VDD VDD _0920_ sky130_fd_sc_hd__nand2_1
X_3033_ _0893_ _1793_ _1801_ VSS VSS VDD VDD _0921_ sky130_fd_sc_hd__a21o_1
X_3034_ _0921_ _0918_ is_a_larger_stage1 VSS VSS VDD VDD _0922_
+ sky130_fd_sc_hd__mux2i_1
X_3035_ is_a_larger_stage1 _1785_ _0921_ VSS VSS VDD VDD _0923_
+ sky130_fd_sc_hd__nor3_1
X_3036_ _0923_ _0919_ VSS VSS VDD VDD _0924_ sky130_fd_sc_hd__nor2_1
X_3037_ _0920_ _0922_ _0924_ _0867_ VSS VSS VDD VDD _0925_
+ sky130_fd_sc_hd__o2bb2ai_1
X_3038_ _0861_ _0870_ _0923_ _0871_ VSS VSS VDD VDD _0926_
+ sky130_fd_sc_hd__o211a_1
X_3039_ _0869_ _0919_ _0925_ _0926_ _0778_ VSS VSS VDD VDD
+ _0927_ sky130_fd_sc_hd__a2111o_1
X_3040_ _0808_ _0917_ _0927_ VSS VSS VDD VDD _0928_ sky130_fd_sc_hd__o21ai_0
X_3041_ _0907_ _0928_ VSS VSS VDD VDD _0929_ sky130_fd_sc_hd__xnor2_1
X_3042_ _0906_ _0929_ VSS VSS VDD VDD _0002_ sky130_fd_sc_hd__nor2_1
X_3043_ _1818_ VSS VSS VDD VDD _0930_ sky130_fd_sc_hd__buf_2
X_3044_ _0930_ VSS VSS VDD VDD _0931_ sky130_fd_sc_hd__inv_1
X_3045_ _0907_ VSS VSS VDD VDD _0932_ sky130_fd_sc_hd__inv_1
X_3046_ _0932_ _0917_ _1814_ VSS VSS VDD VDD _0933_ sky130_fd_sc_hd__a21oi_1
X_3047_ _0861_ _0894_ _0896_ VSS VSS VDD VDD _0934_ sky130_fd_sc_hd__o21bai_2
X_3048_ _0867_ _1780_ _0885_ VSS VSS VDD VDD _0935_ sky130_fd_sc_hd__nand3_1
X_3049_ _0780_ _0935_ VSS VSS VDD VDD _0936_ sky130_fd_sc_hd__nand2_1
X_3050_ _0855_ _0867_ _0885_ _0860_ _0936_ VSS VSS VDD VDD
+ _0937_ sky130_fd_sc_hd__a41o_1
X_3051_ _0893_ _0907_ _0934_ _0937_ VSS VSS VDD VDD _0938_
+ sky130_fd_sc_hd__nand4_1
X_3052_ _0885_ _1788_ _1796_ VSS VSS VDD VDD _0939_ sky130_fd_sc_hd__a21o_1
X_3053_ _0893_ _0939_ _1804_ VSS VSS VDD VDD _0940_ sky130_fd_sc_hd__a21oi_1
X_3054_ _0932_ _0940_ _1812_ VSS VSS VDD VDD _0941_ sky130_fd_sc_hd__o21bai_1
X_3055_ _0907_ _1801_ _1809_ VSS VSS VDD VDD _0942_ sky130_fd_sc_hd__a21oi_1
X_3056_ _0780_ _0942_ VSS VSS VDD VDD _0943_ sky130_fd_sc_hd__nor2_1
X_3057_ _0780_ _0941_ _0943_ VSS VSS VDD VDD _0944_ sky130_fd_sc_hd__a21oi_1
X_3058_ _0938_ _0944_ _0792_ VSS VSS VDD VDD _0945_ sky130_fd_sc_hd__a21oi_1
X_3059_ _0779_ _0933_ _0945_ VSS VSS VDD VDD _0946_ sky130_fd_sc_hd__a21oi_1
X_3060_ _0931_ _0946_ VSS VSS VDD VDD _0947_ sky130_fd_sc_hd__xnor2_1
X_3061_ _0906_ _0947_ VSS VSS VDD VDD _0003_ sky130_fd_sc_hd__nor2_1
X_3062_ _1826_ VSS VSS VDD VDD _0948_ sky130_fd_sc_hd__buf_2
X_3063_ _0930_ _0933_ VSS VSS VDD VDD _0949_ sky130_fd_sc_hd__nor2_1
X_3064_ _0907_ _0918_ _1812_ VSS VSS VDD VDD _0950_ sky130_fd_sc_hd__a21oi_1
X_3065_ _0893_ _0907_ VSS VSS VDD VDD _0951_ sky130_fd_sc_hd__nand2_1
X_3066_ _0885_ _0930_ VSS VSS VDD VDD _0952_ sky130_fd_sc_hd__nand2_1
X_3067_ _0951_ _0952_ VSS VSS VDD VDD _0953_ sky130_fd_sc_hd__nor2_1
X_3068_ _1788_ _0953_ _1820_ _0793_ VSS VSS VDD VDD _0954_
+ sky130_fd_sc_hd__a211oi_1
X_3069_ _0931_ _0950_ _0954_ VSS VSS VDD VDD _0955_ sky130_fd_sc_hd__o21ai_1
X_3070_ _0855_ _0860_ _0955_ _1780_ VSS VSS VDD VDD _0956_
+ sky130_fd_sc_hd__a211oi_2
X_3071_ _0907_ _0921_ _1809_ VSS VSS VDD VDD _0957_ sky130_fd_sc_hd__a21oi_1
X_3072_ _1785_ _0953_ _1817_ _0780_ VSS VSS VDD VDD _0958_
+ sky130_fd_sc_hd__a211oi_1
X_3073_ _0931_ _0957_ _0958_ VSS VSS VDD VDD _0959_ sky130_fd_sc_hd__o21ai_1
X_3074_ _0959_ VSS VSS VDD VDD _0960_ sky130_fd_sc_hd__inv_1
X_3075_ _0861_ _0870_ _0960_ _0871_ VSS VSS VDD VDD _0961_
+ sky130_fd_sc_hd__o211a_1
X_3076_ _0867_ _0953_ _0955_ _0959_ VSS VSS VDD VDD _0962_
+ sky130_fd_sc_hd__a22oi_2
X_3077_ _0777_ _0956_ _0961_ _0962_ VSS VSS VDD VDD _0963_
+ sky130_fd_sc_hd__or4_1
X_3078_ _1822_ _0808_ _0949_ _0963_ VSS VSS VDD VDD _0964_
+ sky130_fd_sc_hd__o31ai_1
X_3079_ _0948_ _0964_ VSS VSS VDD VDD _0965_ sky130_fd_sc_hd__xnor2_1
X_3080_ _0906_ _0965_ VSS VSS VDD VDD _0004_ sky130_fd_sc_hd__nor2_1
X_3081_ _1834_ VSS VSS VDD VDD _0966_ sky130_fd_sc_hd__buf_2
X_3082_ _0907_ _0930_ _0948_ VSS VSS VDD VDD _0967_ sky130_fd_sc_hd__or3_1
X_3083_ _0930_ _1814_ VSS VSS VDD VDD _0968_ sky130_fd_sc_hd__nor2b_1
X_3084_ _1822_ _0968_ _0948_ VSS VSS VDD VDD _0969_ sky130_fd_sc_hd__o21bai_1
X_3085_ _0912_ _0916_ _0967_ _0969_ VSS VSS VDD VDD _0970_
+ sky130_fd_sc_hd__o31ai_1
X_3086_ _1830_ _0970_ VSS VSS VDD VDD _0971_ sky130_fd_sc_hd__nor2_1
X_3087_ _0930_ _0948_ VSS VSS VDD VDD _0972_ sky130_fd_sc_hd__nand2_1
X_3088_ _0907_ _1804_ _1812_ VSS VSS VDD VDD _0973_ sky130_fd_sc_hd__a21oi_1
X_3089_ _0948_ _1820_ _1828_ VSS VSS VDD VDD _0974_ sky130_fd_sc_hd__a21oi_1
X_3090_ _0972_ _0973_ _0781_ _0974_ VSS VSS VDD VDD _0975_
+ sky130_fd_sc_hd__o211ai_2
X_3091_ _0948_ _1817_ _1825_ VSS VSS VDD VDD _0976_ sky130_fd_sc_hd__a21oi_1
X_3092_ _0942_ _0972_ _0976_ _0793_ VSS VSS VDD VDD _0977_
+ sky130_fd_sc_hd__o211ai_2
X_3093_ _0951_ _0972_ VSS VSS VDD VDD _0978_ sky130_fd_sc_hd__nor2_1
X_3094_ _0975_ _0977_ _0978_ _0901_ VSS VSS VDD VDD _0979_
+ sky130_fd_sc_hd__a22oi_4
X_3095_ _0778_ _0979_ VSS VSS VDD VDD _0980_ sky130_fd_sc_hd__nor2_1
X_3096_ _0779_ _0971_ _0980_ VSS VSS VDD VDD _0981_ sky130_fd_sc_hd__a21oi_1
X_3097_ _0966_ _0981_ VSS VSS VDD VDD _0982_ sky130_fd_sc_hd__xor2_1
X_3098_ _0906_ _0982_ VSS VSS VDD VDD _0005_ sky130_fd_sc_hd__nor2_1
X_3099_ _1842_ VSS VSS VDD VDD _0983_ sky130_fd_sc_hd__buf_2
X_3100_ _0948_ _0966_ VSS VSS VDD VDD _0984_ sky130_fd_sc_hd__nand2_1
X_3101_ _0930_ _1809_ _1817_ VSS VSS VDD VDD _0985_ sky130_fd_sc_hd__a21oi_1
X_3102_ _0966_ _1825_ _1833_ VSS VSS VDD VDD _0986_ sky130_fd_sc_hd__a21oi_1
X_3103_ _0984_ _0985_ _0986_ VSS VSS VDD VDD _0987_ sky130_fd_sc_hd__o21ai_0
X_3104_ _0930_ _1812_ _1820_ VSS VSS VDD VDD _0988_ sky130_fd_sc_hd__a21oi_1
X_3105_ _0966_ _1828_ _1836_ VSS VSS VDD VDD _0989_ sky130_fd_sc_hd__a21oi_1
X_3106_ _0984_ _0988_ _0781_ _0989_ VSS VSS VDD VDD _0990_
+ sky130_fd_sc_hd__o211ai_1
X_3107_ _0781_ _0987_ _0990_ VSS VSS VDD VDD _0991_ sky130_fd_sc_hd__o21ai_1
X_3108_ _0907_ _0930_ _0948_ _0966_ VSS VSS VDD VDD _0992_
+ sky130_fd_sc_hd__nand4_1
X_3109_ _0869_ _0919_ _0925_ _0992_ _0926_ VSS VSS VDD VDD
+ _0993_ sky130_fd_sc_hd__a2111o_1
X_3110_ _0991_ _0993_ _0792_ VSS VSS VDD VDD _0994_ sky130_fd_sc_hd__a21oi_1
X_3111_ _0966_ _0971_ VSS VSS VDD VDD _0995_ sky130_fd_sc_hd__nor2_1
X_3112_ _1838_ _0808_ _0995_ VSS VSS VDD VDD _0996_ sky130_fd_sc_hd__nor3_1
X_3113_ _0983_ _0994_ _0996_ VSS VSS VDD VDD _0997_ sky130_fd_sc_hd__nor3_1
X_3114_ _0994_ _0996_ _0983_ VSS VSS VDD VDD _0998_ sky130_fd_sc_hd__o21a_1
X_3115_ _0773_ _0997_ _0998_ VSS VSS VDD VDD _0006_ sky130_fd_sc_hd__nor3_1
X_3116_ _1850_ VSS VSS VDD VDD _0999_ sky130_fd_sc_hd__buf_2
X_3117_ _1830_ _1838_ _1846_ VSS VSS VDD VDD _1000_ sky130_fd_sc_hd__or3_1
X_3118_ _1838_ VSS VSS VDD VDD _1001_ sky130_fd_sc_hd__inv_1
X_3119_ _0966_ _1001_ _0983_ VSS VSS VDD VDD _1002_ sky130_fd_sc_hd__a21oi_1
X_3120_ _0970_ _1000_ _1002_ _1846_ VSS VSS VDD VDD _1003_
+ sky130_fd_sc_hd__o22a_2
X_3121_ _0930_ _0948_ _0966_ _0983_ VSS VSS VDD VDD _1004_
+ sky130_fd_sc_hd__nand4_1
X_3122_ _0951_ _1004_ VSS VSS VDD VDD _1005_ sky130_fd_sc_hd__nor2_1
X_3123_ _0966_ _0983_ VSS VSS VDD VDD _1006_ sky130_fd_sc_hd__nand2_1
X_3124_ _0983_ _1833_ _1841_ VSS VSS VDD VDD _1007_ sky130_fd_sc_hd__a21oi_1
X_3125_ _0976_ _1006_ _1007_ VSS VSS VDD VDD _1008_ sky130_fd_sc_hd__o21ai_0
X_3126_ _0983_ _1836_ _1844_ VSS VSS VDD VDD _1009_ sky130_fd_sc_hd__a21oi_1
X_3127_ _0974_ _1006_ _1009_ _0780_ VSS VSS VDD VDD _1010_
+ sky130_fd_sc_hd__o211ai_1
X_3128_ _0780_ _1008_ _1010_ VSS VSS VDD VDD _1011_ sky130_fd_sc_hd__o21ai_0
X_3129_ _0944_ _1004_ _1011_ VSS VSS VDD VDD _1012_ sky130_fd_sc_hd__o21ai_1
X_3130_ _0934_ _0937_ _1005_ _1012_ VSS VSS VDD VDD _1013_
+ sky130_fd_sc_hd__a31oi_4
X_3131_ _1003_ _1013_ _0808_ VSS VSS VDD VDD _1014_ sky130_fd_sc_hd__mux2i_1
X_3132_ _0999_ _1014_ VSS VSS VDD VDD _1015_ sky130_fd_sc_hd__xnor2_1
X_3133_ _0906_ _1015_ VSS VSS VDD VDD _0007_ sky130_fd_sc_hd__nor2_1
X_3134_ _1858_ VSS VSS VDD VDD _1016_ sky130_fd_sc_hd__buf_2
X_3135_ _1016_ VSS VSS VDD VDD _1017_ sky130_fd_sc_hd__inv_1
X_3136_ _0948_ _0966_ _0983_ _0999_ VSS VSS VDD VDD _1018_
+ sky130_fd_sc_hd__nand4_1
X_3137_ _0983_ _0999_ VSS VSS VDD VDD _1019_ sky130_fd_sc_hd__nand2_1
X_3138_ _1850_ _1841_ _1849_ VSS VSS VDD VDD _1020_ sky130_fd_sc_hd__a21oi_1
X_3139_ _0986_ _1019_ _1020_ VSS VSS VDD VDD _1021_ sky130_fd_sc_hd__o21ai_0
X_3140_ _0999_ _1844_ _1852_ VSS VSS VDD VDD _1022_ sky130_fd_sc_hd__a21oi_1
X_3141_ _0989_ _1019_ _1022_ _0782_ VSS VSS VDD VDD _1023_
+ sky130_fd_sc_hd__o211ai_1
X_3142_ _0782_ _1021_ _1023_ VSS VSS VDD VDD _1024_ sky130_fd_sc_hd__o21ai_1
X_3143_ _0956_ _0961_ _0962_ _1018_ _1024_ VSS VSS VDD VDD
+ _1025_ sky130_fd_sc_hd__o41ai_4
X_3144_ _0999_ VSS VSS VDD VDD _1026_ sky130_fd_sc_hd__inv_1
X_3145_ _1026_ _1003_ _1854_ VSS VSS VDD VDD _1027_ sky130_fd_sc_hd__a21oi_1
X_3146_ _1025_ _1027_ _0792_ VSS VSS VDD VDD _1028_ sky130_fd_sc_hd__mux2i_1
X_3147_ _1017_ _1028_ VSS VSS VDD VDD _1029_ sky130_fd_sc_hd__xnor2_1
X_3148_ _0906_ _1029_ VSS VSS VDD VDD _0008_ sky130_fd_sc_hd__nor2_1
X_3149_ _1866_ VSS VSS VDD VDD _1030_ sky130_fd_sc_hd__buf_2
X_3150_ _1026_ _1009_ _1852_ VSS VSS VDD VDD _1031_ sky130_fd_sc_hd__o21bai_1
X_3151_ _1016_ _1031_ _1860_ VSS VSS VDD VDD _1032_ sky130_fd_sc_hd__a21oi_1
X_3152_ _1007_ _0999_ VSS VSS VDD VDD _1033_ sky130_fd_sc_hd__nor2b_1
X_3153_ _1849_ _1033_ _1016_ VSS VSS VDD VDD _1034_ sky130_fd_sc_hd__o21ai_0
X_3154_ _1857_ _1034_ VSS VSS VDD VDD _1035_ sky130_fd_sc_hd__nand2b_1
X_3155_ _0831_ _1035_ VSS VSS VDD VDD _1036_ sky130_fd_sc_hd__nor2_1
X_3156_ _0831_ _1032_ _1036_ _0777_ VSS VSS VDD VDD _1037_
+ sky130_fd_sc_hd__a211oi_1
X_3157_ _1854_ VSS VSS VDD VDD _1038_ sky130_fd_sc_hd__inv_1
X_3158_ _0999_ _1038_ _1016_ VSS VSS VDD VDD _1039_ sky130_fd_sc_hd__a21oi_1
X_3159_ _1862_ _0807_ _1039_ VSS VSS VDD VDD _1040_ sky130_fd_sc_hd__nor3_1
X_3160_ _0999_ _1016_ _0807_ VSS VSS VDD VDD _1041_ sky130_fd_sc_hd__nand3_1
X_3161_ _0979_ _1006_ _1041_ VSS VSS VDD VDD _1042_ sky130_fd_sc_hd__nor3_1
X_3162_ _1854_ _1862_ _0807_ _1003_ VSS VSS VDD VDD _1043_
+ sky130_fd_sc_hd__nor4_1
X_3163_ _1037_ _1040_ _1042_ _1043_ VSS VSS VDD VDD _1044_
+ sky130_fd_sc_hd__nor4_1
X_3164_ _1030_ _1044_ VSS VSS VDD VDD _1045_ sky130_fd_sc_hd__xor2_1
X_3165_ _0906_ _1045_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__nor2_1
X_3166_ _1874_ VSS VSS VDD VDD _1046_ sky130_fd_sc_hd__clkinvlp_4
X_3167_ _1016_ _1030_ VSS VSS VDD VDD _1047_ sky130_fd_sc_hd__nand2_1
X_3168_ _0991_ _0993_ _1019_ _1047_ _0777_ VSS VSS VDD VDD
+ _1048_ sky130_fd_sc_hd__a2111oi_2
X_3169_ _1030_ _1860_ _1868_ VSS VSS VDD VDD _1049_ sky130_fd_sc_hd__a21oi_1
X_3170_ _1022_ _1047_ _1049_ VSS VSS VDD VDD _1050_ sky130_fd_sc_hd__o21ai_1
X_3171_ _0793_ _1050_ VSS VSS VDD VDD _1051_ sky130_fd_sc_hd__nor2_1
X_3172_ _1017_ _1020_ _1857_ VSS VSS VDD VDD _1052_ sky130_fd_sc_hd__o21bai_1
X_3173_ _1030_ _1052_ _1865_ VSS VSS VDD VDD _1053_ sky130_fd_sc_hd__a21o_1
X_3174_ _0831_ _1053_ VSS VSS VDD VDD _1054_ sky130_fd_sc_hd__nor2_1
X_3175_ _1051_ _1054_ _0808_ VSS VSS VDD VDD _1055_ sky130_fd_sc_hd__o21ai_0
X_3176_ _0999_ _1016_ _1866_ VSS VSS VDD VDD _1056_ sky130_fd_sc_hd__nor3_1
X_3177_ _1854_ _1017_ _1862_ VSS VSS VDD VDD _1057_ sky130_fd_sc_hd__a21oi_1
X_3178_ _1866_ _1057_ VSS VSS VDD VDD _1058_ sky130_fd_sc_hd__nor2_1
X_3179_ _1003_ _1056_ _1058_ _1870_ VSS VSS VDD VDD _1059_
+ sky130_fd_sc_hd__a211o_1
X_3180_ _0792_ _1059_ VSS VSS VDD VDD _1060_ sky130_fd_sc_hd__nand2_1
X_3181_ _1048_ _1055_ _1060_ VSS VSS VDD VDD _1061_ sky130_fd_sc_hd__o21ai_0
X_3182_ _1046_ _1061_ VSS VSS VDD VDD _1062_ sky130_fd_sc_hd__xnor2_1
X_3183_ _0906_ _1062_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__nor2_1
X_3184_ _1882_ VSS VSS VDD VDD _1063_ sky130_fd_sc_hd__buf_2
X_3185_ _1016_ _1852_ _1860_ VSS VSS VDD VDD _1064_ sky130_fd_sc_hd__a21o_1
X_3186_ _1030_ _1064_ _1868_ VSS VSS VDD VDD _1065_ sky130_fd_sc_hd__a21oi_1
X_3187_ _1046_ _1065_ VSS VSS VDD VDD _1066_ sky130_fd_sc_hd__nor2_1
X_3188_ _1876_ _1066_ VSS VSS VDD VDD _1067_ sky130_fd_sc_hd__nor2_1
X_3189_ _1016_ _1849_ _1857_ VSS VSS VDD VDD _1068_ sky130_fd_sc_hd__a21o_1
X_3190_ _1030_ _1068_ _1865_ VSS VSS VDD VDD _1069_ sky130_fd_sc_hd__a21oi_1
X_3191_ _1046_ _1069_ VSS VSS VDD VDD _1070_ sky130_fd_sc_hd__nor2_1
X_3192_ _0781_ _1873_ _1070_ VSS VSS VDD VDD _1071_ sky130_fd_sc_hd__nor3_1
X_3193_ _0781_ _1067_ _1071_ VSS VSS VDD VDD _1072_ sky130_fd_sc_hd__a21oi_1
X_3194_ _0999_ _1016_ _1030_ _1874_ VSS VSS VDD VDD _1073_
+ sky130_fd_sc_hd__nand4_1
X_3195_ _1013_ _1073_ VSS VSS VDD VDD _1074_ sky130_fd_sc_hd__nor2_1
X_3196_ _1046_ _1878_ VSS VSS VDD VDD _1075_ sky130_fd_sc_hd__nor2_1
X_3197_ _1003_ _1056_ _1058_ _1870_ _1878_ VSS VSS VDD VDD
+ _1076_ sky130_fd_sc_hd__a2111oi_4
X_3198_ _0807_ _1075_ _1076_ VSS VSS VDD VDD _1077_ sky130_fd_sc_hd__or3_1
X_3199_ _0778_ _1072_ _1074_ _1077_ VSS VSS VDD VDD _1078_
+ sky130_fd_sc_hd__o31ai_1
X_3200_ _1063_ _1078_ VSS VSS VDD VDD _1079_ sky130_fd_sc_hd__xor2_1
X_3201_ _0906_ _1079_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__nor2_1
X_3202_ _1890_ VSS VSS VDD VDD _1080_ sky130_fd_sc_hd__buf_2
X_3203_ _1886_ VSS VSS VDD VDD _1081_ sky130_fd_sc_hd__inv_1
X_3204_ _1063_ _1075_ _1076_ _1081_ VSS VSS VDD VDD _1082_
+ sky130_fd_sc_hd__o31ai_1
X_3205_ _1874_ _1063_ VSS VSS VDD VDD _1083_ sky130_fd_sc_hd__nand2_1
X_3206_ _1047_ _1083_ VSS VSS VDD VDD _1084_ sky130_fd_sc_hd__nor2_1
X_3207_ _1046_ _1049_ _1876_ VSS VSS VDD VDD _1085_ sky130_fd_sc_hd__o21bai_1
X_3208_ _1063_ _1085_ _1884_ VSS VSS VDD VDD _1086_ sky130_fd_sc_hd__a21oi_1
X_3209_ _0793_ _1086_ VSS VSS VDD VDD _1087_ sky130_fd_sc_hd__nor2_1
X_3210_ _1030_ _1857_ _1865_ VSS VSS VDD VDD _1088_ sky130_fd_sc_hd__a21oi_1
X_3211_ _1046_ _1088_ _1873_ VSS VSS VDD VDD _1089_ sky130_fd_sc_hd__o21bai_1
X_3212_ _1063_ _1089_ _1881_ VSS VSS VDD VDD _1090_ sky130_fd_sc_hd__a21oi_1
X_3213_ _0831_ _1090_ VSS VSS VDD VDD _1091_ sky130_fd_sc_hd__nor2_1
X_3214_ _1025_ _1084_ _1087_ _1091_ _0778_ VSS VSS VDD VDD
+ _1092_ sky130_fd_sc_hd__a2111oi_0
X_3215_ _0779_ _1082_ _1092_ VSS VSS VDD VDD _1093_ sky130_fd_sc_hd__a21oi_1
X_3216_ _1080_ _1093_ VSS VSS VDD VDD _1094_ sky130_fd_sc_hd__xnor2_1
X_3217_ _0906_ _1094_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__nor2_1
X_3218_ _1898_ VSS VSS VDD VDD _1095_ sky130_fd_sc_hd__clkbuf_2
X_3219_ _1080_ VSS VSS VDD VDD _1096_ sky130_fd_sc_hd__inv_1
X_3220_ _1886_ _1096_ _1894_ VSS VSS VDD VDD _1097_ sky130_fd_sc_hd__a21oi_1
X_3221_ _1882_ _1080_ _1075_ _1076_ _1097_ VSS VSS VDD VDD
+ _1098_ sky130_fd_sc_hd__o41ai_4
X_3222_ _1073_ VSS VSS VDD VDD _1099_ sky130_fd_sc_hd__inv_1
X_3223_ _1063_ _1080_ _1099_ VSS VSS VDD VDD _1100_ sky130_fd_sc_hd__nand3_1
X_3224_ _0979_ _1006_ _1100_ VSS VSS VDD VDD _1101_ sky130_fd_sc_hd__or3_1
X_3225_ _1080_ _1884_ _1892_ VSS VSS VDD VDD _1102_ sky130_fd_sc_hd__a21oi_1
X_3226_ _1080_ _1881_ _1889_ VSS VSS VDD VDD _1103_ sky130_fd_sc_hd__a21o_1
X_3227_ _0781_ _1103_ VSS VSS VDD VDD _1104_ sky130_fd_sc_hd__nor2_1
X_3228_ _0782_ _1102_ _1104_ VSS VSS VDD VDD _1105_ sky130_fd_sc_hd__a21oi_1
X_3229_ _1874_ _1868_ _1876_ _1892_ VSS VSS VDD VDD _1106_
+ sky130_fd_sc_hd__a211oi_1
X_3230_ _0782_ _1106_ VSS VSS VDD VDD _1107_ sky130_fd_sc_hd__nand2_1
X_3231_ _1063_ _1105_ _1107_ _1884_ VSS VSS VDD VDD _1108_
+ sky130_fd_sc_hd__o22ai_1
X_3232_ _1105_ _1107_ _1080_ VSS VSS VDD VDD _1109_ sky130_fd_sc_hd__a21oi_1
X_3233_ _1108_ _1109_ VSS VSS VDD VDD _1110_ sky130_fd_sc_hd__nor2_1
X_3234_ _1030_ _1035_ _1865_ VSS VSS VDD VDD _1111_ sky130_fd_sc_hd__a21oi_1
X_3235_ _0831_ _1873_ _1103_ VSS VSS VDD VDD _1112_ sky130_fd_sc_hd__nor3_1
X_3236_ _1046_ _1111_ _1112_ VSS VSS VDD VDD _1113_ sky130_fd_sc_hd__o21ai_0
X_3237_ _0831_ _1030_ _1080_ VSS VSS VDD VDD _1114_ sky130_fd_sc_hd__nand3_1
X_3238_ _1032_ _1083_ _1114_ _0807_ VSS VSS VDD VDD _1115_
+ sky130_fd_sc_hd__o31ai_1
X_3239_ _1110_ _1113_ _1115_ VSS VSS VDD VDD _1116_ sky130_fd_sc_hd__a21oi_1
X_3240_ _0779_ _1098_ _1101_ _1116_ VSS VSS VDD VDD _1117_
+ sky130_fd_sc_hd__a22oi_1
X_3241_ _1095_ _1117_ VSS VSS VDD VDD _1118_ sky130_fd_sc_hd__xnor2_1
X_3242_ _0773_ _1118_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__nor2_1
X_3243_ _1906_ VSS VSS VDD VDD _1119_ sky130_fd_sc_hd__inv_1
X_3244_ _1119_ _0773_ VSS VSS VDD VDD _1120_ sky130_fd_sc_hd__nor2_1
X_3245_ _1906_ _0773_ VSS VSS VDD VDD _1121_ sky130_fd_sc_hd__nor2_1
X_3246_ _1095_ VSS VSS VDD VDD _1122_ sky130_fd_sc_hd__inv_1
X_3247_ _1122_ _1098_ _1902_ VSS VSS VDD VDD _1123_ sky130_fd_sc_hd__a21oi_1
X_3248_ _1096_ _1122_ _1083_ VSS VSS VDD VDD _1124_ sky130_fd_sc_hd__nor3_1
X_3249_ _1900_ VSS VSS VDD VDD _1125_ sky130_fd_sc_hd__inv_1
X_3250_ _1874_ _1050_ _1876_ VSS VSS VDD VDD _1126_ sky130_fd_sc_hd__a21o_1
X_3251_ _1063_ _1126_ _1884_ VSS VSS VDD VDD _1127_ sky130_fd_sc_hd__a21oi_1
X_3252_ _1096_ _1127_ VSS VSS VDD VDD _1128_ sky130_fd_sc_hd__nor2_1
X_3253_ _1892_ _1128_ _1095_ VSS VSS VDD VDD _1129_ sky130_fd_sc_hd__o21ai_0
X_3254_ _1874_ _1053_ _1873_ VSS VSS VDD VDD _1130_ sky130_fd_sc_hd__a21o_1
X_3255_ _1882_ _1130_ _1881_ VSS VSS VDD VDD _1131_ sky130_fd_sc_hd__a21oi_1
X_3256_ _1096_ _1131_ _1889_ VSS VSS VDD VDD _1132_ sky130_fd_sc_hd__o21bai_1
X_3257_ _1095_ _1132_ _1897_ _0782_ VSS VSS VDD VDD _1133_
+ sky130_fd_sc_hd__a211oi_1
X_3258_ _0782_ _1125_ _1129_ _1133_ _0777_ VSS VSS VDD VDD
+ _1134_ sky130_fd_sc_hd__a311oi_1
X_3259_ _0777_ _1123_ _1124_ _1048_ _1134_ VSS VSS VDD VDD
+ _1135_ sky130_fd_sc_hd__a221o_1
X_3260_ _1120_ _1121_ _1135_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__mux2_1
X_3261_ _1122_ _1098_ _0807_ _1910_ _1902_ VSS VSS VDD VDD
+ _1136_ sky130_fd_sc_hd__a2111oi_1
X_3262_ _1096_ _1122_ _1119_ VSS VSS VDD VDD _1137_ sky130_fd_sc_hd__nor3_1
X_3263_ _1063_ _1099_ _1137_ VSS VSS VDD VDD _1138_ sky130_fd_sc_hd__nand3_1
X_3264_ _1908_ VSS VSS VDD VDD _1139_ sky130_fd_sc_hd__inv_1
X_3265_ _1122_ _1102_ _1125_ VSS VSS VDD VDD _1140_ sky130_fd_sc_hd__o21ai_0
X_3266_ _1906_ _1140_ VSS VSS VDD VDD _1141_ sky130_fd_sc_hd__nand2_1
X_3267_ _1095_ _1103_ _1897_ VSS VSS VDD VDD _1142_ sky130_fd_sc_hd__a21oi_1
X_3268_ _1119_ _1142_ VSS VSS VDD VDD _1143_ sky130_fd_sc_hd__nor2_1
X_3269_ _0781_ _1905_ _1143_ VSS VSS VDD VDD _1144_ sky130_fd_sc_hd__nor3_1
X_3270_ _0781_ _1139_ _1141_ _1144_ VSS VSS VDD VDD _1145_
+ sky130_fd_sc_hd__a31oi_1
X_3271_ _1063_ _1072_ _1137_ _1145_ VSS VSS VDD VDD _1146_
+ sky130_fd_sc_hd__a31oi_1
X_3272_ _1013_ _1138_ _1146_ VSS VSS VDD VDD _1147_ sky130_fd_sc_hd__o21ai_0
X_3273_ _1119_ _1910_ _0777_ VSS VSS VDD VDD _1148_ sky130_fd_sc_hd__o21ai_0
X_3274_ _0777_ _1147_ _1148_ VSS VSS VDD VDD _1149_ sky130_fd_sc_hd__o21a_1
X_3275_ _1136_ _1149_ _1914_ VSS VSS VDD VDD _1150_ sky130_fd_sc_hd__o21ai_0
X_3276_ _1914_ _1136_ _1149_ VSS VSS VDD VDD _1151_ sky130_fd_sc_hd__or3_1
X_3277_ _1150_ _1151_ _0773_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__a21o_1
X_3278_ _1025_ _1084_ _1091_ VSS VSS VDD VDD _1152_ sky130_fd_sc_hd__a21oi_1
X_3279_ _1914_ _1137_ VSS VSS VDD VDD _1153_ sky130_fd_sc_hd__nand2_1
X_3280_ _1095_ _1889_ _1897_ VSS VSS VDD VDD _1154_ sky130_fd_sc_hd__a21oi_1
X_3281_ _1119_ _1154_ _1905_ VSS VSS VDD VDD _1155_ sky130_fd_sc_hd__o21bai_1
X_3282_ _1914_ _1155_ _1913_ VSS VSS VDD VDD _1156_ sky130_fd_sc_hd__a21oi_1
X_3283_ _1914_ VSS VSS VDD VDD _1157_ sky130_fd_sc_hd__inv_1
X_3284_ _1096_ _1086_ _1892_ VSS VSS VDD VDD _1158_ sky130_fd_sc_hd__o21bai_1
X_3285_ _1095_ _1158_ _1900_ VSS VSS VDD VDD _1159_ sky130_fd_sc_hd__a21oi_1
X_3286_ _1119_ _1159_ VSS VSS VDD VDD _1160_ sky130_fd_sc_hd__nor2_1
X_3287_ _1908_ _1160_ VSS VSS VDD VDD _1161_ sky130_fd_sc_hd__nor2_1
X_3288_ _1157_ _1161_ VSS VSS VDD VDD _1162_ sky130_fd_sc_hd__nor2_1
X_3289_ _1916_ _1162_ _0797_ VSS VSS VDD VDD _1163_ sky130_fd_sc_hd__o21ai_0
X_3290_ _1152_ _1153_ _1156_ _0797_ _1163_ VSS VSS VDD VDD
+ _1164_ sky130_fd_sc_hd__o221ai_1
X_3291_ _1910_ _1157_ _1918_ VSS VSS VDD VDD _1165_ sky130_fd_sc_hd__a21oi_1
X_3292_ _1906_ _1914_ _1123_ _1165_ _0779_ VSS VSS VDD VDD
+ _1166_ sky130_fd_sc_hd__o311a_1
X_3293_ _0808_ _1164_ _1166_ _0773_ VSS VSS VDD VDD _0016_
+ sky130_fd_sc_hd__a211oi_1
X_3294_ _1185_ _1188_ VSS VSS VDD VDD _1167_ sky130_fd_sc_hd__nor2_1
X_3295_ _0767_ _0768_ VSS VSS VDD VDD _1168_ sky130_fd_sc_hd__nor2_1
X_3296_ _1577_ _1201_ VSS VSS VDD VDD _1169_ sky130_fd_sc_hd__nand2_1
X_3297_ net26 _0772_ VSS VSS VDD VDD _1170_ sky130_fd_sc_hd__nand2_1
X_3298_ _0772_ _1169_ _1170_ VSS VSS VDD VDD _1171_ sky130_fd_sc_hd__o21ai_0
X_3299_ b_sign_stage1 a_sign_stage1 _0797_ VSS VSS VDD VDD
+ _1172_ sky130_fd_sc_hd__mux2i_1
X_3300_ net58 _1201_ _0772_ VSS VSS VDD VDD _1173_ sky130_fd_sc_hd__a21oi_1
X_3301_ _0772_ _1172_ _1173_ _1168_ VSS VSS VDD VDD _1174_
+ sky130_fd_sc_hd__a211oi_1
X_3302_ _1167_ _1168_ _1171_ _1174_ VSS VSS VDD VDD _0119_
+ sky130_fd_sc_hd__a31o_1
X_3303_ _0306_ _0323_ _0325_ VSS VSS VDD VDD _0118_ sky130_fd_sc_hd__nor3_1
X_3304_ net25 VSS VSS VDD VDD _1579_ sky130_fd_sc_hd__inv_1
X_3305_ net23 VSS VSS VDD VDD _1585_ sky130_fd_sc_hd__inv_1
X_3306_ net22 VSS VSS VDD VDD _1591_ sky130_fd_sc_hd__inv_1
X_3307_ net21 VSS VSS VDD VDD _1597_ sky130_fd_sc_hd__inv_1
X_3308_ net20 VSS VSS VDD VDD _1603_ sky130_fd_sc_hd__inv_1
X_3309_ net19 VSS VSS VDD VDD _1609_ sky130_fd_sc_hd__inv_1
X_3310_ net18 VSS VSS VDD VDD _1565_ sky130_fd_sc_hd__inv_1
X_3311_ _1692_ VSS VSS VDD VDD _1566_ sky130_fd_sc_hd__inv_1
X_3312_ _1689_ VSS VSS VDD VDD _1570_ sky130_fd_sc_hd__inv_1
X_3313_ net17 VSS VSS VDD VDD _1688_ sky130_fd_sc_hd__inv_1
X_3314_ aligned_a_mant\[2\] VSS VSS VDD VDD _1720_ sky130_fd_sc_hd__inv_1
X_3315_ aligned_a_mant\[1\] VSS VSS VDD VDD _1728_ sky130_fd_sc_hd__inv_1
X_3316_ aligned_a_mant\[3\] VSS VSS VDD VDD _1736_ sky130_fd_sc_hd__inv_1
X_3317_ aligned_a_mant\[4\] VSS VSS VDD VDD _1744_ sky130_fd_sc_hd__inv_1
X_3318_ aligned_a_mant\[5\] VSS VSS VDD VDD _1752_ sky130_fd_sc_hd__inv_1
X_3319_ aligned_a_mant\[6\] VSS VSS VDD VDD _1760_ sky130_fd_sc_hd__inv_1
X_3320_ aligned_a_mant\[7\] VSS VSS VDD VDD _1768_ sky130_fd_sc_hd__inv_1
X_3321_ aligned_a_mant\[8\] VSS VSS VDD VDD _1776_ sky130_fd_sc_hd__inv_1
X_3322_ aligned_a_mant\[9\] VSS VSS VDD VDD _1784_ sky130_fd_sc_hd__inv_1
X_3323_ aligned_a_mant\[10\] VSS VSS VDD VDD _1792_ sky130_fd_sc_hd__inv_1
X_3324_ aligned_a_mant\[11\] VSS VSS VDD VDD _1800_ sky130_fd_sc_hd__inv_1
X_3325_ aligned_a_mant\[12\] VSS VSS VDD VDD _1808_ sky130_fd_sc_hd__inv_1
X_3326_ aligned_a_mant\[13\] VSS VSS VDD VDD _1816_ sky130_fd_sc_hd__inv_1
X_3327_ aligned_a_mant\[14\] VSS VSS VDD VDD _1824_ sky130_fd_sc_hd__inv_1
X_3328_ aligned_a_mant\[15\] VSS VSS VDD VDD _1832_ sky130_fd_sc_hd__inv_1
X_3329_ aligned_a_mant\[16\] VSS VSS VDD VDD _1840_ sky130_fd_sc_hd__inv_1
X_3330_ aligned_a_mant\[17\] VSS VSS VDD VDD _1848_ sky130_fd_sc_hd__inv_1
X_3331_ aligned_a_mant\[18\] VSS VSS VDD VDD _1856_ sky130_fd_sc_hd__inv_1
X_3332_ aligned_a_mant\[19\] VSS VSS VDD VDD _1864_ sky130_fd_sc_hd__inv_1
X_3333_ aligned_a_mant\[20\] VSS VSS VDD VDD _1872_ sky130_fd_sc_hd__inv_1
X_3334_ aligned_a_mant\[21\] VSS VSS VDD VDD _1880_ sky130_fd_sc_hd__inv_1
X_3335_ aligned_a_mant\[22\] VSS VSS VDD VDD _1888_ sky130_fd_sc_hd__inv_1
X_3336_ aligned_a_mant\[23\] VSS VSS VDD VDD _1896_ sky130_fd_sc_hd__inv_1
X_3337_ aligned_a_mant\[24\] VSS VSS VDD VDD _1904_ sky130_fd_sc_hd__inv_1
X_3338_ aligned_a_mant\[25\] VSS VSS VDD VDD _1912_ sky130_fd_sc_hd__inv_1
X_3339_ aligned_b_mant\[2\] VSS VSS VDD VDD _1723_ sky130_fd_sc_hd__inv_1
X_3340_ aligned_b_mant\[1\] VSS VSS VDD VDD _1731_ sky130_fd_sc_hd__inv_1
X_3341_ aligned_b_mant\[3\] VSS VSS VDD VDD _1739_ sky130_fd_sc_hd__inv_1
X_3342_ aligned_b_mant\[4\] VSS VSS VDD VDD _1747_ sky130_fd_sc_hd__inv_1
X_3343_ aligned_b_mant\[5\] VSS VSS VDD VDD _1755_ sky130_fd_sc_hd__inv_1
X_3344_ aligned_b_mant\[6\] VSS VSS VDD VDD _1763_ sky130_fd_sc_hd__inv_1
X_3345_ aligned_b_mant\[7\] VSS VSS VDD VDD _1771_ sky130_fd_sc_hd__inv_1
X_3346_ aligned_b_mant\[8\] VSS VSS VDD VDD _1779_ sky130_fd_sc_hd__inv_1
X_3347_ aligned_b_mant\[9\] VSS VSS VDD VDD _1787_ sky130_fd_sc_hd__inv_1
X_3348_ aligned_b_mant\[10\] VSS VSS VDD VDD _1795_ sky130_fd_sc_hd__inv_1
X_3349_ aligned_b_mant\[11\] VSS VSS VDD VDD _1803_ sky130_fd_sc_hd__inv_1
X_3350_ aligned_b_mant\[12\] VSS VSS VDD VDD _1811_ sky130_fd_sc_hd__inv_1
X_3351_ aligned_b_mant\[13\] VSS VSS VDD VDD _1819_ sky130_fd_sc_hd__inv_1
X_3352_ aligned_b_mant\[14\] VSS VSS VDD VDD _1827_ sky130_fd_sc_hd__inv_1
X_3353_ aligned_b_mant\[15\] VSS VSS VDD VDD _1835_ sky130_fd_sc_hd__inv_1
X_3354_ aligned_b_mant\[16\] VSS VSS VDD VDD _1843_ sky130_fd_sc_hd__inv_1
X_3355_ aligned_b_mant\[17\] VSS VSS VDD VDD _1851_ sky130_fd_sc_hd__inv_1
X_3356_ aligned_b_mant\[18\] VSS VSS VDD VDD _1859_ sky130_fd_sc_hd__inv_1
X_3357_ aligned_b_mant\[19\] VSS VSS VDD VDD _1867_ sky130_fd_sc_hd__inv_1
X_3358_ aligned_b_mant\[20\] VSS VSS VDD VDD _1875_ sky130_fd_sc_hd__inv_1
X_3359_ aligned_b_mant\[21\] VSS VSS VDD VDD _1883_ sky130_fd_sc_hd__inv_1
X_3360_ aligned_b_mant\[22\] VSS VSS VDD VDD _1891_ sky130_fd_sc_hd__inv_1
X_3361_ aligned_b_mant\[23\] VSS VSS VDD VDD _1899_ sky130_fd_sc_hd__inv_1
X_3362_ aligned_b_mant\[24\] VSS VSS VDD VDD _1907_ sky130_fd_sc_hd__inv_1
X_3363_ aligned_b_mant\[25\] VSS VSS VDD VDD _1915_ sky130_fd_sc_hd__inv_1
X_3364_ _1578_ _1168_ VSS VSS VDD VDD _1175_ sky130_fd_sc_hd__nand2_1
X_3365_ _1201_ _1175_ _0772_ VSS VSS VDD VDD _1176_ sky130_fd_sc_hd__a21oi_1
X_3366_ _1167_ _0767_ _0768_ VSS VSS VDD VDD _1177_ sky130_fd_sc_hd__nor3_1
X_3367_ invalid_op_stage2 _1176_ _1177_ VSS VSS VDD VDD _0121_
+ sky130_fd_sc_hd__or3_1
X_3368_ aligned_a_mant\[1\] aligned_a_mant\[0\] aligned_b_mant\[1\]
+ aligned_b_mant\[0\] VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__or4_2
X_3369_ net49 VSS VSS VDD VDD _1691_ sky130_fd_sc_hd__inv_1
X_3370_ net22 net21 net25 net23 VSS VSS VDD VDD _1178_ sky130_fd_sc_hd__nor4_2
X_3371_ net18 net17 net20 net19 VSS VSS VDD VDD _1179_ sky130_fd_sc_hd__nor4_1
X_3372_ _1178_ _1179_ VSS VSS VDD VDD _1180_ sky130_fd_sc_hd__nand2_2
X_3373_ net13 net2 net27 net16 VSS VSS VDD VDD _1181_ sky130_fd_sc_hd__nor4_2
X_3374_ net9 net11 net15 net14 VSS VSS VDD VDD _1182_ sky130_fd_sc_hd__nor4_1
X_3375_ net3 net7 net10 net12 VSS VSS VDD VDD _1183_ sky130_fd_sc_hd__nor4_1
X_3376_ net6 net5 net8 VSS VSS VDD VDD _1184_ sky130_fd_sc_hd__nor3_1
X_3377_ _1181_ _1182_ _1183_ _1184_ VSS VSS VDD VDD _1185_
+ sky130_fd_sc_hd__nand4_2
X_3378_ net28 net30 net33 net32 VSS VSS VDD VDD _1186_ sky130_fd_sc_hd__nor4_1
X_3379_ net24 net29 net31 net4 VSS VSS VDD VDD _1187_ sky130_fd_sc_hd__nor4_1
X_3380_ _1186_ _1187_ VSS VSS VDD VDD _1188_ sky130_fd_sc_hd__nand2_2
X_3381_ _1180_ _1185_ _1188_ VSS VSS VDD VDD _1189_ sky130_fd_sc_hd__nor3_4
X_3382_ net54 VSS VSS VDD VDD _1594_ sky130_fd_sc_hd__inv_1
X_3383_ net53 VSS VSS VDD VDD _1600_ sky130_fd_sc_hd__inv_1
X_3384_ net57 VSS VSS VDD VDD _1582_ sky130_fd_sc_hd__inv_1
X_3385_ net55 VSS VSS VDD VDD _1588_ sky130_fd_sc_hd__inv_1
X_3386_ _1594_ _1600_ _1582_ _1588_ VSS VSS VDD VDD _1190_
+ sky130_fd_sc_hd__nand4_2
X_3387_ net50 VSS VSS VDD VDD _1569_ sky130_fd_sc_hd__inv_1
X_3388_ net52 VSS VSS VDD VDD _1606_ sky130_fd_sc_hd__inv_1
X_3389_ net51 VSS VSS VDD VDD _1612_ sky130_fd_sc_hd__inv_1
X_3390_ _1569_ _1691_ _1606_ _1612_ VSS VSS VDD VDD _1191_
+ sky130_fd_sc_hd__nand4_1
X_3391_ _1190_ _1191_ VSS VSS VDD VDD _1192_ sky130_fd_sc_hd__nor2_4
X_3392_ net45 net34 net59 net48 VSS VSS VDD VDD _1193_ sky130_fd_sc_hd__nor4_2
X_3393_ net41 net43 net47 net46 VSS VSS VDD VDD _1194_ sky130_fd_sc_hd__nor4_1
X_3394_ net35 net39 net42 net44 VSS VSS VDD VDD _1195_ sky130_fd_sc_hd__nor4_1
X_3395_ net38 net37 net40 VSS VSS VDD VDD _1196_ sky130_fd_sc_hd__nor3_1
X_3396_ _1193_ _1194_ _1195_ _1196_ VSS VSS VDD VDD _1197_
+ sky130_fd_sc_hd__nand4_2
X_3397_ net60 net62 net65 net64 VSS VSS VDD VDD _1198_ sky130_fd_sc_hd__nor4_1
X_3398_ net56 net61 net63 net36 VSS VSS VDD VDD _1199_ sky130_fd_sc_hd__nor4_1
X_3399_ _1198_ _1199_ VSS VSS VDD VDD _1200_ sky130_fd_sc_hd__nand2_2
X_3400_ _1197_ _1200_ VSS VSS VDD VDD _1201_ sky130_fd_sc_hd__nor2_4
X_3401_ _1687_ _1668_ _1686_ VSS VSS VDD VDD _1202_ sky130_fd_sc_hd__a21o_1
X_3402_ _1684_ _1202_ _1683_ VSS VSS VDD VDD _1203_ sky130_fd_sc_hd__a21o_1
X_3403_ _1605_ VSS VSS VDD VDD _1204_ sky130_fd_sc_hd__buf_6
X_3404_ _1611_ _1204_ _1690_ _1616_ VSS VSS VDD VDD _1205_
+ sky130_fd_sc_hd__nand4_2
X_3405_ _1587_ _1599_ _1581_ _1593_ VSS VSS VDD VDD _1206_
+ sky130_fd_sc_hd__nand4_4
X_3406_ _1681_ _1203_ _1205_ _1206_ _1680_ VSS VSS VDD VDD
+ _1207_ sky130_fd_sc_hd__a2111oi_4
X_3407_ _1645_ _1672_ _1675_ _1678_ VSS VSS VDD VDD _1208_
+ sky130_fd_sc_hd__and4_1
X_3408_ _1648_ _1651_ _1654_ VSS VSS VDD VDD _1209_ sky130_fd_sc_hd__and3_1
X_3409_ _1633_ _1660_ _1663_ _1666_ VSS VSS VDD VDD _1210_
+ sky130_fd_sc_hd__and4_1
X_3410_ _1657_ _1208_ _1209_ _1210_ VSS VSS VDD VDD _1211_
+ sky130_fd_sc_hd__nand4_1
X_3411_ _1626_ _1642_ _1641_ VSS VSS VDD VDD _1212_ sky130_fd_sc_hd__a21oi_1
X_3412_ _1636_ _1639_ VSS VSS VDD VDD _1213_ sky130_fd_sc_hd__nand2_1
X_3413_ _1636_ _1638_ _1635_ VSS VSS VDD VDD _1214_ sky130_fd_sc_hd__a21oi_1
X_3414_ _1212_ _1213_ _1214_ VSS VSS VDD VDD _1215_ sky130_fd_sc_hd__o21a_1
X_3415_ _1660_ _1663_ VSS VSS VDD VDD _1216_ sky130_fd_sc_hd__nand2_1
X_3416_ _1632_ _1666_ _1665_ VSS VSS VDD VDD _1217_ sky130_fd_sc_hd__a21oi_1
X_3417_ _1662_ _1660_ _1659_ VSS VSS VDD VDD _1218_ sky130_fd_sc_hd__a21oi_1
X_3418_ _1216_ _1217_ _1218_ VSS VSS VDD VDD _1219_ sky130_fd_sc_hd__o21ai_1
X_3419_ _1657_ _1208_ _1209_ VSS VSS VDD VDD _1220_ sky130_fd_sc_hd__and3_1
X_3420_ _1211_ _1215_ _1219_ _1220_ VSS VSS VDD VDD _1221_
+ sky130_fd_sc_hd__a2bb2oi_2
X_3421_ _1644_ _1678_ _1677_ VSS VSS VDD VDD _1222_ sky130_fd_sc_hd__a21o_1
X_3422_ _1675_ _1222_ _1674_ VSS VSS VDD VDD _1223_ sky130_fd_sc_hd__a21o_1
X_3423_ _1672_ _1223_ _1671_ VSS VSS VDD VDD _1224_ sky130_fd_sc_hd__a21oi_1
X_3424_ _1624_ _1623_ VSS VSS VDD VDD _1225_ sky130_fd_sc_hd__nand2b_1
X_3425_ _1620_ _1630_ _1629_ VSS VSS VDD VDD _1226_ sky130_fd_sc_hd__a21o_1
X_3426_ _1621_ _1630_ _1225_ _1226_ VSS VSS VDD VDD _1227_
+ sky130_fd_sc_hd__a31oi_2
X_3427_ _1636_ _1627_ _1639_ _1642_ VSS VSS VDD VDD _1228_
+ sky130_fd_sc_hd__nand4_1
X_3428_ _1651_ _1653_ _1650_ VSS VSS VDD VDD _1229_ sky130_fd_sc_hd__a21o_1
X_3429_ _1656_ _1209_ _1229_ _1648_ _1647_ VSS VSS VDD VDD
+ _1230_ sky130_fd_sc_hd__a221oi_1
X_3430_ _1645_ _1672_ _1675_ _1678_ VSS VSS VDD VDD _1231_
+ sky130_fd_sc_hd__nand4_1
X_3431_ _1211_ _1227_ _1228_ _1230_ _1231_ VSS VSS VDD VDD
+ _1232_ sky130_fd_sc_hd__o32a_1
X_3432_ _1207_ _1221_ _1224_ _1232_ VSS VSS VDD VDD _1233_
+ sky130_fd_sc_hd__nand4_4
X_3433_ _1689_ _1616_ _1611_ VSS VSS VDD VDD _1234_ sky130_fd_sc_hd__nand3b_1
X_3434_ _1611_ _1617_ _1613_ VSS VSS VDD VDD _1235_ sky130_fd_sc_hd__a21oi_1
X_3435_ _1587_ _1599_ _1204_ _1593_ VSS VSS VDD VDD _1236_
+ sky130_fd_sc_hd__nand4_1
X_3436_ _1234_ _1235_ _1236_ VSS VSS VDD VDD _1237_ sky130_fd_sc_hd__a21oi_2
X_3437_ _1599_ VSS VSS VDD VDD _1238_ sky130_fd_sc_hd__buf_6
X_3438_ _1593_ VSS VSS VDD VDD _1239_ sky130_fd_sc_hd__buf_6
X_3439_ _1238_ _1239_ _1607_ VSS VSS VDD VDD _1240_ sky130_fd_sc_hd__nand3_1
X_3440_ _1239_ _1601_ _1595_ VSS VSS VDD VDD _1241_ sky130_fd_sc_hd__a21oi_1
X_3441_ _1587_ VSS VSS VDD VDD _1242_ sky130_fd_sc_hd__inv_1
X_3442_ _1240_ _1241_ _1242_ VSS VSS VDD VDD _1243_ sky130_fd_sc_hd__a21oi_1
X_3443_ _1589_ _1237_ _1243_ _1581_ VSS VSS VDD VDD _1244_
+ sky130_fd_sc_hd__o31ai_4
X_3444_ _1206_ _1205_ VSS VSS VDD VDD _1245_ sky130_fd_sc_hd__nor2_1
X_3445_ _1583_ _1245_ VSS VSS VDD VDD _1246_ sky130_fd_sc_hd__nor2_1
X_3446_ _1687_ _1681_ _1669_ _1684_ VSS VSS VDD VDD _1247_
+ sky130_fd_sc_hd__nand4_2
X_3447_ _1244_ _1246_ _1207_ _1247_ VSS VSS VDD VDD _1248_
+ sky130_fd_sc_hd__a22oi_4
X_3448_ _1233_ _1248_ VSS VSS VDD VDD _1249_ sky130_fd_sc_hd__nand2_4
X_3449_ _1249_ VSS VSS VDD VDD a_exp_larger sky130_fd_sc_hd__inv_2
X_3450_ _1192_ _1201_ a_exp_larger VSS VSS VDD VDD _1250_
+ sky130_fd_sc_hd__a21oi_2
X_3451_ _1189_ _1250_ VSS VSS VDD VDD _1251_ sky130_fd_sc_hd__nor2_4
X_3452_ _1251_ VSS VSS VDD VDD _1252_ sky130_fd_sc_hd__buf_2
X_3453_ _1251_ VSS VSS VDD VDD _1253_ sky130_fd_sc_hd__buf_2
X_3454_ net17 _1253_ VSS VSS VDD VDD _1254_ sky130_fd_sc_hd__nand2_1
X_3455_ _1691_ _1252_ _1254_ VSS VSS VDD VDD _0110_ sky130_fd_sc_hd__o21ai_0
X_3456_ net18 _1253_ VSS VSS VDD VDD _1255_ sky130_fd_sc_hd__nand2_1
X_3457_ _1569_ _1252_ _1255_ VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__o21ai_0
X_3458_ net19 _1253_ VSS VSS VDD VDD _1256_ sky130_fd_sc_hd__nand2_1
X_3459_ _1612_ _1252_ _1256_ VSS VSS VDD VDD _0112_ sky130_fd_sc_hd__o21ai_0
X_3460_ net20 _1253_ VSS VSS VDD VDD _1257_ sky130_fd_sc_hd__nand2_1
X_3461_ _1606_ _1252_ _1257_ VSS VSS VDD VDD _0113_ sky130_fd_sc_hd__o21ai_0
X_3462_ net21 _1253_ VSS VSS VDD VDD _1258_ sky130_fd_sc_hd__nand2_1
X_3463_ _1600_ _1252_ _1258_ VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__o21ai_0
X_3464_ net22 _1253_ VSS VSS VDD VDD _1259_ sky130_fd_sc_hd__nand2_1
X_3465_ _1594_ _1252_ _1259_ VSS VSS VDD VDD _0115_ sky130_fd_sc_hd__o21ai_0
X_3466_ _1251_ VSS VSS VDD VDD _1260_ sky130_fd_sc_hd__buf_4
X_3467_ net23 _1260_ VSS VSS VDD VDD _1261_ sky130_fd_sc_hd__nand2_1
X_3468_ _1588_ _1252_ _1261_ VSS VSS VDD VDD _0116_ sky130_fd_sc_hd__o21ai_0
X_3469_ net25 _1260_ VSS VSS VDD VDD _1262_ sky130_fd_sc_hd__nand2_1
X_3470_ _1582_ _1252_ _1262_ VSS VSS VDD VDD _0117_ sky130_fd_sc_hd__o21ai_0
X_3471_ net2 VSS VSS VDD VDD _1622_ sky130_fd_sc_hd__inv_1
X_3472_ net45 VSS VSS VDD VDD _1619_ sky130_fd_sc_hd__inv_1
X_3473_ net56 VSS VSS VDD VDD _1628_ sky130_fd_sc_hd__inv_1
X_3474_ net59 VSS VSS VDD VDD _1625_ sky130_fd_sc_hd__inv_1
X_3475_ net60 VSS VSS VDD VDD _1640_ sky130_fd_sc_hd__inv_1
X_3476_ net61 VSS VSS VDD VDD _1637_ sky130_fd_sc_hd__inv_1
X_3477_ net62 VSS VSS VDD VDD _1634_ sky130_fd_sc_hd__inv_1
X_3478_ net63 VSS VSS VDD VDD _1631_ sky130_fd_sc_hd__inv_1
X_3479_ net64 VSS VSS VDD VDD _1664_ sky130_fd_sc_hd__clkinvlp_4
X_3480_ net65 VSS VSS VDD VDD _1661_ sky130_fd_sc_hd__inv_1
X_3481_ net35 VSS VSS VDD VDD _1658_ sky130_fd_sc_hd__inv_1
X_3482_ net36 VSS VSS VDD VDD _1655_ sky130_fd_sc_hd__inv_1
X_3483_ net37 VSS VSS VDD VDD _1652_ sky130_fd_sc_hd__inv_1
X_3484_ net38 VSS VSS VDD VDD _1649_ sky130_fd_sc_hd__inv_1
X_3485_ net39 VSS VSS VDD VDD _1646_ sky130_fd_sc_hd__inv_1
X_3486_ net40 VSS VSS VDD VDD _1643_ sky130_fd_sc_hd__clkinv_2
X_3487_ net41 VSS VSS VDD VDD _1676_ sky130_fd_sc_hd__inv_1
X_3488_ net42 VSS VSS VDD VDD _1673_ sky130_fd_sc_hd__inv_1
X_3489_ net43 VSS VSS VDD VDD _1670_ sky130_fd_sc_hd__inv_1
X_3490_ net44 VSS VSS VDD VDD _1667_ sky130_fd_sc_hd__inv_1
X_3491_ net46 VSS VSS VDD VDD _1685_ sky130_fd_sc_hd__inv_1
X_3492_ net47 VSS VSS VDD VDD _1682_ sky130_fd_sc_hd__inv_1
X_3493_ net48 VSS VSS VDD VDD _1679_ sky130_fd_sc_hd__inv_1
X_3494_ _1204_ VSS VSS VDD VDD _1263_ sky130_fd_sc_hd__inv_2
X_3495_ _1611_ _1567_ _1610_ VSS VSS VDD VDD _1264_ sky130_fd_sc_hd__a21oi_1
X_3496_ _1263_ _1264_ _1604_ VSS VSS VDD VDD _1265_ sky130_fd_sc_hd__o21ba_2
X_3497_ _1207_ _1221_ _1224_ _1232_ VSS VSS VDD VDD _1266_
+ sky130_fd_sc_hd__and4_1
X_3498_ _1266_ VSS VSS VDD VDD _1267_ sky130_fd_sc_hd__clkbuf_2
X_3499_ _1244_ _1246_ _1207_ _1247_ VSS VSS VDD VDD _1268_
+ sky130_fd_sc_hd__a22o_2
X_3500_ _1611_ VSS VSS VDD VDD _1269_ sky130_fd_sc_hd__clkbuf_2
X_3501_ _1269_ _1571_ _1613_ VSS VSS VDD VDD _1270_ sky130_fd_sc_hd__a21oi_1
X_3502_ _1263_ _1270_ _1607_ VSS VSS VDD VDD _1271_ sky130_fd_sc_hd__o21bai_2
X_3503_ _1267_ _1268_ _1271_ VSS VSS VDD VDD _1272_ sky130_fd_sc_hd__nor3_1
X_3504_ _1249_ _1265_ _1272_ VSS VSS VDD VDD _1273_ sky130_fd_sc_hd__a21oi_4
X_3505_ _1238_ _1273_ VSS VSS VDD VDD _1274_ sky130_fd_sc_hd__xnor2_4
X_3506_ _1692_ _1616_ VSS VSS VDD VDD _1275_ sky130_fd_sc_hd__nand2b_1
X_3507_ _1610_ _1615_ VSS VSS VDD VDD _1276_ sky130_fd_sc_hd__nor2_1
X_3508_ _1611_ _1610_ VSS VSS VDD VDD _1277_ sky130_fd_sc_hd__nor2_1
X_3509_ _1275_ _1276_ _1277_ _1236_ VSS VSS VDD VDD _1278_
+ sky130_fd_sc_hd__a211oi_1
X_3510_ _1593_ _1598_ _1592_ VSS VSS VDD VDD _1279_ sky130_fd_sc_hd__a21oi_1
X_3511_ _1238_ _1593_ _1604_ VSS VSS VDD VDD _1280_ sky130_fd_sc_hd__nand3_1
X_3512_ _1279_ _1280_ _1242_ VSS VSS VDD VDD _1281_ sky130_fd_sc_hd__a21oi_1
X_3513_ _1586_ _1278_ _1281_ _1581_ VSS VSS VDD VDD _1282_
+ sky130_fd_sc_hd__o31ai_1
X_3514_ _1581_ _1586_ _1278_ _1281_ VSS VSS VDD VDD _1283_
+ sky130_fd_sc_hd__or4_1
X_3515_ _1238_ _1204_ _1239_ VSS VSS VDD VDD _1284_ sky130_fd_sc_hd__nand3_1
X_3516_ _1284_ _1264_ _1279_ _1280_ VSS VSS VDD VDD _1285_
+ sky130_fd_sc_hd__o211ai_1
X_3517_ _1242_ _1285_ VSS VSS VDD VDD _1286_ sky130_fd_sc_hd__xnor2_1
X_3518_ _1239_ _1598_ _1592_ _1586_ VSS VSS VDD VDD _1287_
+ sky130_fd_sc_hd__a211o_1
X_3519_ _1587_ _1586_ _1581_ VSS VSS VDD VDD _1288_ sky130_fd_sc_hd__o21a_1
X_3520_ _1287_ _1288_ _1580_ VSS VSS VDD VDD _1289_ sky130_fd_sc_hd__a21oi_1
X_3521_ _1206_ _1265_ _1289_ VSS VSS VDD VDD _1290_ sky130_fd_sc_hd__o21a_1
X_3522_ _1282_ _1283_ _1286_ _1290_ VSS VSS VDD VDD _1291_
+ sky130_fd_sc_hd__a211o_1
X_3523_ _1291_ VSS VSS VDD VDD _1292_ sky130_fd_sc_hd__buf_6
X_3524_ _1233_ _1248_ _1292_ VSS VSS VDD VDD _1293_ sky130_fd_sc_hd__a21oi_4
X_3525_ _1568_ VSS VSS VDD VDD _1294_ sky130_fd_sc_hd__clkbuf_4
X_3526_ _1192_ _1201_ _1189_ VSS VSS VDD VDD _1295_ sky130_fd_sc_hd__a21oi_4
X_3527_ _1275_ _1276_ _1277_ VSS VSS VDD VDD _1296_ sky130_fd_sc_hd__a21oi_2
X_3528_ _1204_ _1296_ VSS VSS VDD VDD _1297_ sky130_fd_sc_hd__nand2_1
X_3529_ _1690_ VSS VSS VDD VDD _1298_ sky130_fd_sc_hd__buf_4
X_3530_ _1298_ VSS VSS VDD VDD _1299_ sky130_fd_sc_hd__inv_1
X_3531_ _1269_ _1567_ VSS VSS VDD VDD _1300_ sky130_fd_sc_hd__nand2_1
X_3532_ _1269_ _1567_ VSS VSS VDD VDD _1301_ sky130_fd_sc_hd__or2_0
X_3533_ _1299_ _1294_ _1300_ _1301_ VSS VSS VDD VDD _1302_
+ sky130_fd_sc_hd__a22o_1
X_3534_ _1296_ _1263_ VSS VSS VDD VDD _1303_ sky130_fd_sc_hd__nand2b_1
X_3535_ _1238_ _1265_ VSS VSS VDD VDD _1304_ sky130_fd_sc_hd__xnor2_2
X_3536_ _1269_ _1610_ _1204_ VSS VSS VDD VDD _1305_ sky130_fd_sc_hd__o21ai_0
X_3537_ _1275_ _1276_ _1305_ VSS VSS VDD VDD _1306_ sky130_fd_sc_hd__a21oi_1
X_3538_ _1598_ _1239_ VSS VSS VDD VDD _1307_ sky130_fd_sc_hd__nand2b_1
X_3539_ _1238_ VSS VSS VDD VDD _1308_ sky130_fd_sc_hd__inv_1
X_3540_ _1275_ _1276_ _1305_ _1239_ _1308_ VSS VSS VDD VDD
+ _1309_ sky130_fd_sc_hd__a2111o_1
X_3541_ _1239_ VSS VSS VDD VDD _1310_ sky130_fd_sc_hd__inv_2
X_3542_ _1239_ _1238_ VSS VSS VDD VDD _1311_ sky130_fd_sc_hd__nor2b_1
X_3543_ _1238_ _1598_ _1239_ VSS VSS VDD VDD _1312_ sky130_fd_sc_hd__nor3b_1
X_3544_ _1310_ _1598_ _1604_ _1311_ _1312_ VSS VSS VDD VDD
+ _1313_ sky130_fd_sc_hd__a221oi_2
X_3545_ _1604_ _1306_ _1307_ _1309_ _1313_ VSS VSS VDD VDD
+ _1314_ sky130_fd_sc_hd__o311ai_4
X_3546_ _1297_ _1302_ _1303_ _1304_ _1314_ VSS VSS VDD VDD
+ _1315_ sky130_fd_sc_hd__a41oi_4
X_3547_ _1295_ _1315_ VSS VSS VDD VDD _1316_ sky130_fd_sc_hd__nand2_8
X_3548_ net3 net5 net35 net37 _1294_ _1316_ VSS VSS VDD VDD
+ _1317_ sky130_fd_sc_hd__mux4_1
X_3549_ _1572_ VSS VSS VDD VDD _1318_ sky130_fd_sc_hd__clkbuf_4
X_3550_ _1318_ VSS VSS VDD VDD _1319_ sky130_fd_sc_hd__clkbuf_4
X_3551_ net37 _1319_ VSS VSS VDD VDD _1320_ sky130_fd_sc_hd__nand2_1
X_3552_ _1658_ _1319_ _1320_ VSS VSS VDD VDD _1321_ sky130_fd_sc_hd__o21ai_1
X_3553_ _1581_ _1589_ _1237_ _1243_ VSS VSS VDD VDD _1322_
+ sky130_fd_sc_hd__or4_1
X_3554_ _1206_ VSS VSS VDD VDD _1323_ sky130_fd_sc_hd__inv_1
X_3555_ _1242_ _1241_ _1589_ VSS VSS VDD VDD _1324_ sky130_fd_sc_hd__o21bai_1
X_3556_ _1323_ _1271_ _1324_ _1581_ _1583_ VSS VSS VDD VDD
+ _1325_ sky130_fd_sc_hd__a221oi_2
X_3557_ _1284_ _1270_ _1241_ _1240_ VSS VSS VDD VDD _1326_
+ sky130_fd_sc_hd__o211ai_1
X_3558_ _1242_ _1326_ VSS VSS VDD VDD _1327_ sky130_fd_sc_hd__xnor2_1
X_3559_ _1244_ _1322_ _1325_ _1327_ VSS VSS VDD VDD _1328_
+ sky130_fd_sc_hd__a211oi_4
X_3560_ _1233_ _1248_ _1328_ VSS VSS VDD VDD _1329_ sky130_fd_sc_hd__and3_1
X_3561_ _1329_ VSS VSS VDD VDD _1330_ sky130_fd_sc_hd__buf_8
X_3562_ _1293_ _1317_ _1321_ _1330_ VSS VSS VDD VDD _1331_
+ sky130_fd_sc_hd__a22oi_4
X_3563_ net30 net32 net62 net64 _1294_ _1316_ VSS VSS VDD
+ VDD _1332_ sky130_fd_sc_hd__mux4_1
X_3564_ net64 _1319_ VSS VSS VDD VDD _1333_ sky130_fd_sc_hd__nand2_1
X_3565_ _1634_ _1319_ _1333_ VSS VSS VDD VDD _1334_ sky130_fd_sc_hd__o21ai_1
X_3566_ _1293_ _1332_ _1334_ _1330_ VSS VSS VDD VDD _1335_
+ sky130_fd_sc_hd__a22oi_4
X_3567_ _1233_ _1248_ _1292_ VSS VSS VDD VDD _1336_ sky130_fd_sc_hd__a21o_4
X_3568_ _1336_ _1316_ VSS VSS VDD VDD _1337_ sky130_fd_sc_hd__nor2_8
X_3569_ net4 net6 _1294_ VSS VSS VDD VDD _1338_ sky130_fd_sc_hd__mux2_1
X_3570_ net38 _1318_ VSS VSS VDD VDD _1339_ sky130_fd_sc_hd__nand2_1
X_3571_ _1655_ _1319_ _1339_ VSS VSS VDD VDD _1340_ sky130_fd_sc_hd__o21ai_1
X_3572_ _1192_ _1201_ _1189_ VSS VSS VDD VDD _1341_ sky130_fd_sc_hd__a21o_4
X_3573_ _1297_ _1302_ _1303_ _1304_ _1314_ VSS VSS VDD VDD
+ _1342_ sky130_fd_sc_hd__a41o_4
X_3574_ _1233_ _1248_ _1341_ _1292_ _1342_ VSS VSS VDD VDD
+ _1343_ sky130_fd_sc_hd__a2111oi_4
X_3575_ _1294_ VSS VSS VDD VDD _1344_ sky130_fd_sc_hd__clkbuf_4
X_3576_ net36 net38 _1344_ VSS VSS VDD VDD _1345_ sky130_fd_sc_hd__mux2i_1
X_3577_ a_exp_larger _1292_ _1343_ _1345_ VSS VSS VDD VDD
+ _1346_ sky130_fd_sc_hd__nor4_1
X_3578_ _1337_ _1338_ _1340_ _1330_ _1346_ VSS VSS VDD VDD
+ _1347_ sky130_fd_sc_hd__a221oi_4
X_3579_ net31 net33 _1344_ VSS VSS VDD VDD _1348_ sky130_fd_sc_hd__mux2_1
X_3580_ net65 _1318_ VSS VSS VDD VDD _1349_ sky130_fd_sc_hd__nand2_1
X_3581_ _1631_ _1319_ _1349_ VSS VSS VDD VDD _1350_ sky130_fd_sc_hd__o21ai_1
X_3582_ net63 net65 _1344_ VSS VSS VDD VDD _1351_ sky130_fd_sc_hd__mux2i_1
X_3583_ a_exp_larger _1292_ _1343_ _1351_ VSS VSS VDD VDD
+ _1352_ sky130_fd_sc_hd__nor4_1
X_3584_ _1337_ _1348_ _1350_ _1330_ _1352_ VSS VSS VDD VDD
+ _1353_ sky130_fd_sc_hd__a221oi_4
X_3585_ _1567_ _1269_ VSS VSS VDD VDD _1354_ sky130_fd_sc_hd__nor2b_1
X_3586_ _1269_ _1567_ VSS VSS VDD VDD _1355_ sky130_fd_sc_hd__nor2b_1
X_3587_ _1565_ net50 _1566_ VSS VSS VDD VDD _1567_ _1568_
+ sky130_fd_sc_hd__fa_1
X_3588_ net18 _1569_ _1570_ VSS VSS VDD VDD _1571_ _1572_
+ sky130_fd_sc_hd__fa_1
X_3589_ result_exp_stage2\[1\] _1573_ _1574_ VSS VSS VDD VDD
+ _1575_ _1576_ sky130_fd_sc_hd__fa_1
X_3590_ net26 net58 VSS VSS VDD VDD _1577_ _1578_ sky130_fd_sc_hd__ha_1
X_3591_ _1579_ net57 VSS VSS VDD VDD _1580_ _1581_ sky130_fd_sc_hd__ha_2
X_3592_ net25 _1582_ VSS VSS VDD VDD _1583_ _1584_ sky130_fd_sc_hd__ha_1
X_3593_ _1585_ net55 VSS VSS VDD VDD _1586_ _1587_ sky130_fd_sc_hd__ha_1
X_3594_ net23 _1588_ VSS VSS VDD VDD _1589_ _1590_ sky130_fd_sc_hd__ha_1
X_3595_ _1591_ net54 VSS VSS VDD VDD _1592_ _1593_ sky130_fd_sc_hd__ha_2
X_3596_ net22 _1594_ VSS VSS VDD VDD _1595_ _1596_ sky130_fd_sc_hd__ha_1
X_3597_ _1597_ net53 VSS VSS VDD VDD _1598_ _1599_ sky130_fd_sc_hd__ha_1
X_3598_ net21 _1600_ VSS VSS VDD VDD _1601_ _1602_ sky130_fd_sc_hd__ha_1
X_3599_ _1603_ net52 VSS VSS VDD VDD _1604_ _1605_ sky130_fd_sc_hd__ha_1
X_3600_ net20 _1606_ VSS VSS VDD VDD _1607_ _1608_ sky130_fd_sc_hd__ha_1
X_3601_ _1609_ net51 VSS VSS VDD VDD _1610_ _1611_ sky130_fd_sc_hd__ha_1
X_3602_ net19 _1612_ VSS VSS VDD VDD _1613_ _1614_ sky130_fd_sc_hd__ha_1
X_3603_ _1565_ net50 VSS VSS VDD VDD _1615_ _1616_ sky130_fd_sc_hd__ha_1
X_3604_ net18 _1569_ VSS VSS VDD VDD _1617_ _1618_ sky130_fd_sc_hd__ha_1
X_3605_ net13 _1619_ VSS VSS VDD VDD _1620_ _1621_ sky130_fd_sc_hd__ha_1
X_3606_ _1622_ net34 VSS VSS VDD VDD _1623_ _1624_ sky130_fd_sc_hd__ha_1
X_3607_ net27 _1625_ VSS VSS VDD VDD _1626_ _1627_ sky130_fd_sc_hd__ha_1
X_3608_ net24 _1628_ VSS VSS VDD VDD _1629_ _1630_ sky130_fd_sc_hd__ha_1
X_3609_ net31 _1631_ VSS VSS VDD VDD _1632_ _1633_ sky130_fd_sc_hd__ha_1
X_3610_ net30 _1634_ VSS VSS VDD VDD _1635_ _1636_ sky130_fd_sc_hd__ha_1
X_3611_ net29 _1637_ VSS VSS VDD VDD _1638_ _1639_ sky130_fd_sc_hd__ha_1
X_3612_ net28 _1640_ VSS VSS VDD VDD _1641_ _1642_ sky130_fd_sc_hd__ha_1
X_3613_ net8 _1643_ VSS VSS VDD VDD _1644_ _1645_ sky130_fd_sc_hd__ha_1
X_3614_ net7 _1646_ VSS VSS VDD VDD _1647_ _1648_ sky130_fd_sc_hd__ha_1
X_3615_ net6 _1649_ VSS VSS VDD VDD _1650_ _1651_ sky130_fd_sc_hd__ha_1
X_3616_ net5 _1652_ VSS VSS VDD VDD _1653_ _1654_ sky130_fd_sc_hd__ha_1
X_3617_ net4 _1655_ VSS VSS VDD VDD _1656_ _1657_ sky130_fd_sc_hd__ha_1
X_3618_ net3 _1658_ VSS VSS VDD VDD _1659_ _1660_ sky130_fd_sc_hd__ha_1
X_3619_ net33 _1661_ VSS VSS VDD VDD _1662_ _1663_ sky130_fd_sc_hd__ha_1
X_3620_ net32 _1664_ VSS VSS VDD VDD _1665_ _1666_ sky130_fd_sc_hd__ha_1
X_3621_ net12 _1667_ VSS VSS VDD VDD _1668_ _1669_ sky130_fd_sc_hd__ha_1
X_3622_ net11 _1670_ VSS VSS VDD VDD _1671_ _1672_ sky130_fd_sc_hd__ha_1
X_3623_ net10 _1673_ VSS VSS VDD VDD _1674_ _1675_ sky130_fd_sc_hd__ha_1
X_3624_ net9 _1676_ VSS VSS VDD VDD _1677_ _1678_ sky130_fd_sc_hd__ha_1
X_3625_ net16 _1679_ VSS VSS VDD VDD _1680_ _1681_ sky130_fd_sc_hd__ha_1
X_3626_ net15 _1682_ VSS VSS VDD VDD _1683_ _1684_ sky130_fd_sc_hd__ha_1
X_3627_ net14 _1685_ VSS VSS VDD VDD _1686_ _1687_ sky130_fd_sc_hd__ha_1
X_3628_ _1688_ net49 VSS VSS VDD VDD _1689_ _1690_ sky130_fd_sc_hd__ha_1
X_3629_ net17 _1691_ VSS VSS VDD VDD _1692_ _1693_ sky130_fd_sc_hd__ha_1
X_3630_ _1694_ _1695_ VSS VSS VDD VDD _1696_ _1697_ sky130_fd_sc_hd__ha_1
X_3631_ result_exp_stage2\[2\] _1698_ VSS VSS VDD VDD _1699_
+ _1700_ sky130_fd_sc_hd__ha_1
X_3632_ _1701_ _1702_ VSS VSS VDD VDD _1703_ _1704_ sky130_fd_sc_hd__ha_1
X_3633_ result_exp_stage2\[1\] _1574_ VSS VSS VDD VDD _1705_
+ _1706_ sky130_fd_sc_hd__ha_1
X_3634_ _1707_ _1708_ VSS VSS VDD VDD _1709_ _1710_ sky130_fd_sc_hd__ha_1
X_3635_ result_exp_stage2\[0\] _1711_ VSS VSS VDD VDD _1712_
+ _1713_ sky130_fd_sc_hd__ha_1
X_3636_ _1707_ _1701_ VSS VSS VDD VDD _1714_ _1715_ sky130_fd_sc_hd__ha_2
X_3637_ _1707_ result_exp_stage2\[1\] VSS VSS VDD VDD _1716_
+ _1717_ sky130_fd_sc_hd__ha_1
X_3638_ result_exp_stage2\[0\] result_exp_stage2\[1\] VSS
+ VSS VDD VDD _1718_ _1719_ sky130_fd_sc_hd__ha_1
X_3639_ _1720_ aligned_b_mant\[2\] VSS VSS VDD VDD _1721_
+ _1722_ sky130_fd_sc_hd__ha_1
X_3640_ aligned_a_mant\[2\] _1723_ VSS VSS VDD VDD _1724_
+ _1725_ sky130_fd_sc_hd__ha_1
X_3641_ aligned_a_mant\[2\] aligned_b_mant\[2\] VSS VSS VDD
+ VDD _1726_ _1727_ sky130_fd_sc_hd__ha_1
X_3642_ _1728_ aligned_b_mant\[1\] VSS VSS VDD VDD _1729_
+ _1730_ sky130_fd_sc_hd__ha_1
X_3643_ aligned_a_mant\[1\] _1731_ VSS VSS VDD VDD _1732_
+ _1733_ sky130_fd_sc_hd__ha_1
X_3644_ aligned_a_mant\[1\] aligned_b_mant\[1\] VSS VSS VDD
+ VDD _1734_ _1735_ sky130_fd_sc_hd__ha_1
X_3645_ _1736_ aligned_b_mant\[3\] VSS VSS VDD VDD _1737_
+ _1738_ sky130_fd_sc_hd__ha_2
X_3646_ aligned_a_mant\[3\] _1739_ VSS VSS VDD VDD _1740_
+ _1741_ sky130_fd_sc_hd__ha_1
X_3647_ aligned_a_mant\[3\] aligned_b_mant\[3\] VSS VSS VDD
+ VDD _1742_ _1743_ sky130_fd_sc_hd__ha_1
X_3648_ _1744_ aligned_b_mant\[4\] VSS VSS VDD VDD _1745_
+ _1746_ sky130_fd_sc_hd__ha_1
X_3649_ aligned_a_mant\[4\] _1747_ VSS VSS VDD VDD _1748_
+ _1749_ sky130_fd_sc_hd__ha_1
X_3650_ aligned_a_mant\[4\] aligned_b_mant\[4\] VSS VSS VDD
+ VDD _1750_ _1751_ sky130_fd_sc_hd__ha_1
X_3651_ _1752_ aligned_b_mant\[5\] VSS VSS VDD VDD _1753_
+ _1754_ sky130_fd_sc_hd__ha_1
X_3652_ aligned_a_mant\[5\] _1755_ VSS VSS VDD VDD _1756_
+ _1757_ sky130_fd_sc_hd__ha_1
X_3653_ aligned_a_mant\[5\] aligned_b_mant\[5\] VSS VSS VDD
+ VDD _1758_ _1759_ sky130_fd_sc_hd__ha_1
X_3654_ _1760_ aligned_b_mant\[6\] VSS VSS VDD VDD _1761_
+ _1762_ sky130_fd_sc_hd__ha_1
X_3655_ aligned_a_mant\[6\] _1763_ VSS VSS VDD VDD _1764_
+ _1765_ sky130_fd_sc_hd__ha_1
X_3656_ aligned_a_mant\[6\] aligned_b_mant\[6\] VSS VSS VDD
+ VDD _1766_ _1767_ sky130_fd_sc_hd__ha_1
X_3657_ _1768_ aligned_b_mant\[7\] VSS VSS VDD VDD _1769_
+ _1770_ sky130_fd_sc_hd__ha_2
X_3658_ aligned_a_mant\[7\] _1771_ VSS VSS VDD VDD _1772_
+ _1773_ sky130_fd_sc_hd__ha_1
X_3659_ aligned_a_mant\[7\] aligned_b_mant\[7\] VSS VSS VDD
+ VDD _1774_ _1775_ sky130_fd_sc_hd__ha_1
X_3660_ _1776_ aligned_b_mant\[8\] VSS VSS VDD VDD _1777_
+ _1778_ sky130_fd_sc_hd__ha_1
X_3661_ aligned_a_mant\[8\] _1779_ VSS VSS VDD VDD _1780_
+ _1781_ sky130_fd_sc_hd__ha_2
X_3662_ aligned_a_mant\[8\] aligned_b_mant\[8\] VSS VSS VDD
+ VDD _1782_ _1783_ sky130_fd_sc_hd__ha_1
X_3663_ _1784_ aligned_b_mant\[9\] VSS VSS VDD VDD _1785_
+ _1786_ sky130_fd_sc_hd__ha_1
X_3664_ aligned_a_mant\[9\] _1787_ VSS VSS VDD VDD _1788_
+ _1789_ sky130_fd_sc_hd__ha_1
X_3665_ aligned_a_mant\[9\] aligned_b_mant\[9\] VSS VSS VDD
+ VDD _1790_ _1791_ sky130_fd_sc_hd__ha_1
X_3666_ _1792_ aligned_b_mant\[10\] VSS VSS VDD VDD _1793_
+ _1794_ sky130_fd_sc_hd__ha_1
X_3667_ aligned_a_mant\[10\] _1795_ VSS VSS VDD VDD _1796_
+ _1797_ sky130_fd_sc_hd__ha_1
X_3668_ aligned_a_mant\[10\] aligned_b_mant\[10\] VSS VSS
+ VDD VDD _1798_ _1799_ sky130_fd_sc_hd__ha_1
X_3669_ _1800_ aligned_b_mant\[11\] VSS VSS VDD VDD _1801_
+ _1802_ sky130_fd_sc_hd__ha_1
X_3670_ aligned_a_mant\[11\] _1803_ VSS VSS VDD VDD _1804_
+ _1805_ sky130_fd_sc_hd__ha_1
X_3671_ aligned_a_mant\[11\] aligned_b_mant\[11\] VSS VSS
+ VDD VDD _1806_ _1807_ sky130_fd_sc_hd__ha_1
X_3672_ _1808_ aligned_b_mant\[12\] VSS VSS VDD VDD _1809_
+ _1810_ sky130_fd_sc_hd__ha_1
X_3673_ aligned_a_mant\[12\] _1811_ VSS VSS VDD VDD _1812_
+ _1813_ sky130_fd_sc_hd__ha_1
X_3674_ aligned_a_mant\[12\] aligned_b_mant\[12\] VSS VSS
+ VDD VDD _1814_ _1815_ sky130_fd_sc_hd__ha_1
X_3675_ _1816_ aligned_b_mant\[13\] VSS VSS VDD VDD _1817_
+ _1818_ sky130_fd_sc_hd__ha_1
X_3676_ aligned_a_mant\[13\] _1819_ VSS VSS VDD VDD _1820_
+ _1821_ sky130_fd_sc_hd__ha_1
X_3677_ aligned_a_mant\[13\] aligned_b_mant\[13\] VSS VSS
+ VDD VDD _1822_ _1823_ sky130_fd_sc_hd__ha_1
X_3678_ _1824_ aligned_b_mant\[14\] VSS VSS VDD VDD _1825_
+ _1826_ sky130_fd_sc_hd__ha_1
X_3679_ aligned_a_mant\[14\] _1827_ VSS VSS VDD VDD _1828_
+ _1829_ sky130_fd_sc_hd__ha_1
X_3680_ aligned_a_mant\[14\] aligned_b_mant\[14\] VSS VSS
+ VDD VDD _1830_ _1831_ sky130_fd_sc_hd__ha_1
X_3681_ _1832_ aligned_b_mant\[15\] VSS VSS VDD VDD _1833_
+ _1834_ sky130_fd_sc_hd__ha_1
X_3682_ aligned_a_mant\[15\] _1835_ VSS VSS VDD VDD _1836_
+ _1837_ sky130_fd_sc_hd__ha_1
X_3683_ aligned_a_mant\[15\] aligned_b_mant\[15\] VSS VSS
+ VDD VDD _1838_ _1839_ sky130_fd_sc_hd__ha_1
X_3684_ _1840_ aligned_b_mant\[16\] VSS VSS VDD VDD _1841_
+ _1842_ sky130_fd_sc_hd__ha_1
X_3685_ aligned_a_mant\[16\] _1843_ VSS VSS VDD VDD _1844_
+ _1845_ sky130_fd_sc_hd__ha_1
X_3686_ aligned_a_mant\[16\] aligned_b_mant\[16\] VSS VSS
+ VDD VDD _1846_ _1847_ sky130_fd_sc_hd__ha_1
X_3687_ _1848_ aligned_b_mant\[17\] VSS VSS VDD VDD _1849_
+ _1850_ sky130_fd_sc_hd__ha_1
X_3688_ aligned_a_mant\[17\] _1851_ VSS VSS VDD VDD _1852_
+ _1853_ sky130_fd_sc_hd__ha_1
X_3689_ aligned_a_mant\[17\] aligned_b_mant\[17\] VSS VSS
+ VDD VDD _1854_ _1855_ sky130_fd_sc_hd__ha_1
X_3690_ _1856_ aligned_b_mant\[18\] VSS VSS VDD VDD _1857_
+ _1858_ sky130_fd_sc_hd__ha_1
X_3691_ aligned_a_mant\[18\] _1859_ VSS VSS VDD VDD _1860_
+ _1861_ sky130_fd_sc_hd__ha_1
X_3692_ aligned_a_mant\[18\] aligned_b_mant\[18\] VSS VSS
+ VDD VDD _1862_ _1863_ sky130_fd_sc_hd__ha_1
X_3693_ _1864_ aligned_b_mant\[19\] VSS VSS VDD VDD _1865_
+ _1866_ sky130_fd_sc_hd__ha_1
X_3694_ aligned_a_mant\[19\] _1867_ VSS VSS VDD VDD _1868_
+ _1869_ sky130_fd_sc_hd__ha_1
X_3695_ aligned_a_mant\[19\] aligned_b_mant\[19\] VSS VSS
+ VDD VDD _1870_ _1871_ sky130_fd_sc_hd__ha_1
X_3696_ _1872_ aligned_b_mant\[20\] VSS VSS VDD VDD _1873_
+ _1874_ sky130_fd_sc_hd__ha_2
X_3697_ aligned_a_mant\[20\] _1875_ VSS VSS VDD VDD _1876_
+ _1877_ sky130_fd_sc_hd__ha_1
X_3698_ aligned_a_mant\[20\] aligned_b_mant\[20\] VSS VSS
+ VDD VDD _1878_ _1879_ sky130_fd_sc_hd__ha_1
X_3699_ _1880_ aligned_b_mant\[21\] VSS VSS VDD VDD _1881_
+ _1882_ sky130_fd_sc_hd__ha_1
X_3700_ aligned_a_mant\[21\] _1883_ VSS VSS VDD VDD _1884_
+ _1885_ sky130_fd_sc_hd__ha_1
X_3701_ aligned_a_mant\[21\] aligned_b_mant\[21\] VSS VSS
+ VDD VDD _1886_ _1887_ sky130_fd_sc_hd__ha_1
X_3702_ _1888_ aligned_b_mant\[22\] VSS VSS VDD VDD _1889_
+ _1890_ sky130_fd_sc_hd__ha_1
X_3703_ aligned_a_mant\[22\] _1891_ VSS VSS VDD VDD _1892_
+ _1893_ sky130_fd_sc_hd__ha_1
X_3704_ aligned_a_mant\[22\] aligned_b_mant\[22\] VSS VSS
+ VDD VDD _1894_ _1895_ sky130_fd_sc_hd__ha_1
X_3705_ _1896_ aligned_b_mant\[23\] VSS VSS VDD VDD _1897_
+ _1898_ sky130_fd_sc_hd__ha_1
X_3706_ aligned_a_mant\[23\] _1899_ VSS VSS VDD VDD _1900_
+ _1901_ sky130_fd_sc_hd__ha_1
X_3707_ aligned_a_mant\[23\] aligned_b_mant\[23\] VSS VSS
+ VDD VDD _1902_ _1903_ sky130_fd_sc_hd__ha_1
X_3708_ _1904_ aligned_b_mant\[24\] VSS VSS VDD VDD _1905_
+ _1906_ sky130_fd_sc_hd__ha_1
X_3709_ aligned_a_mant\[24\] _1907_ VSS VSS VDD VDD _1908_
+ _1909_ sky130_fd_sc_hd__ha_1
X_3710_ aligned_a_mant\[24\] aligned_b_mant\[24\] VSS VSS
+ VDD VDD _1910_ _1911_ sky130_fd_sc_hd__ha_1
X_3711_ _1912_ aligned_b_mant\[25\] VSS VSS VDD VDD _1913_
+ _1914_ sky130_fd_sc_hd__ha_1
X_3712_ aligned_a_mant\[25\] _1915_ VSS VSS VDD VDD _1916_
+ _1917_ sky130_fd_sc_hd__ha_1
X_3713_ aligned_a_mant\[25\] aligned_b_mant\[25\] VSS VSS
+ VDD VDD _1918_ _1919_ sky130_fd_sc_hd__ha_1
Xa_sign_stage1$_DFF_PN0_ clknet_4_6_0_clk net26 net1 VSS VSS
+ VDD VDD a_sign_stage1 sky130_fd_sc_hd__dfrtp_4
Xadd_result\[10\]$_DFF_PN0_ clknet_4_15_0_clk _0000_ net1
+ VSS VSS VDD VDD add_result\[10\] sky130_fd_sc_hd__dfrtp_4
Xadd_result\[11\]$_DFF_PN0_ clknet_4_15_0_clk _0001_ net1
+ VSS VSS VDD VDD add_result\[11\] sky130_fd_sc_hd__dfrtp_4
Xadd_result\[12\]$_DFF_PN0_ clknet_4_12_0_clk _0002_ net1
+ VSS VSS VDD VDD add_result\[12\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[13\]$_DFF_PN0_ clknet_4_12_0_clk _0003_ net1
+ VSS VSS VDD VDD add_result\[13\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[14\]$_DFF_PN0_ clknet_4_12_0_clk _0004_ net1
+ VSS VSS VDD VDD add_result\[14\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[15\]$_DFF_PN0_ clknet_4_12_0_clk _0005_ net1
+ VSS VSS VDD VDD add_result\[15\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[16\]$_DFF_PN0_ clknet_4_12_0_clk _0006_ net1
+ VSS VSS VDD VDD add_result\[16\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[17\]$_DFF_PN0_ clknet_4_12_0_clk _0007_ net1
+ VSS VSS VDD VDD add_result\[17\] sky130_fd_sc_hd__dfrtp_4
Xadd_result\[18\]$_DFF_PN0_ clknet_4_9_0_clk _0008_ net1 VSS
+ VSS VDD VDD add_result\[18\] sky130_fd_sc_hd__dfrtp_4
Xadd_result\[19\]$_DFF_PN0_ clknet_4_9_0_clk _0009_ net1 VSS
+ VSS VDD VDD add_result\[19\] sky130_fd_sc_hd__dfrtp_4
Xadd_result\[20\]$_DFF_PN0_ clknet_4_12_0_clk _0010_ net1
+ VSS VSS VDD VDD add_result\[20\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[21\]$_DFF_PN0_ clknet_4_12_0_clk _0011_ net1
+ VSS VSS VDD VDD add_result\[21\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[22\]$_DFF_PN0_ clknet_4_12_0_clk _0012_ net1
+ VSS VSS VDD VDD add_result\[22\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[23\]$_DFF_PN0_ clknet_4_9_0_clk _0013_ net1 VSS
+ VSS VDD VDD add_result\[23\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[24\]$_DFF_PN0_ clknet_4_6_0_clk _0014_ net1 VSS
+ VSS VDD VDD add_result\[24\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[25\]$_DFF_PN0_ clknet_4_6_0_clk _0015_ net1 VSS
+ VSS VDD VDD add_result\[25\] sky130_fd_sc_hd__dfrtp_2
Xadd_result\[26\]$_DFF_PN0_ clknet_4_6_0_clk _0016_ net1 VSS
+ VSS VDD VDD add_result\[26\] sky130_fd_sc_hd__dfrtp_2
Xadd_result\[2\]$_DFF_PN0_ clknet_4_15_0_clk _0017_ net1 VSS
+ VSS VDD VDD add_result\[2\] sky130_fd_sc_hd__dfrtp_4
Xadd_result\[3\]$_DFF_PN0_ clknet_4_15_0_clk _0018_ net1 VSS
+ VSS VDD VDD add_result\[3\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[4\]$_DFF_PN0_ clknet_4_15_0_clk _0019_ net1 VSS
+ VSS VDD VDD add_result\[4\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[5\]$_DFF_PN0_ clknet_4_15_0_clk _0020_ net1 VSS
+ VSS VDD VDD add_result\[5\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[6\]$_DFF_PN0_ clknet_4_15_0_clk _0021_ net1 VSS
+ VSS VDD VDD add_result\[6\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[7\]$_DFF_PN0_ clknet_4_15_0_clk _0022_ net1 VSS
+ VSS VDD VDD add_result\[7\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[8\]$_DFF_PN0_ clknet_4_15_0_clk _0023_ net1 VSS
+ VSS VDD VDD add_result\[8\] sky130_fd_sc_hd__dfrtp_1
Xadd_result\[9\]$_DFF_PN0_ clknet_4_14_0_clk _0024_ net1 VSS
+ VSS VDD VDD add_result\[9\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[0\]$_DFF_PN0_ clknet_4_10_0_clk _0025_ net1
+ VSS VSS VDD VDD aligned_a_mant\[0\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[10\]$_DFF_PN0_ clknet_4_11_0_clk _0026_ net1
+ VSS VSS VDD VDD aligned_a_mant\[10\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[11\]$_DFF_PN0_ clknet_4_11_0_clk _0027_ net1
+ VSS VSS VDD VDD aligned_a_mant\[11\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[12\]$_DFF_PN0_ clknet_4_8_0_clk _0028_ net1
+ VSS VSS VDD VDD aligned_a_mant\[12\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[13\]$_DFF_PN0_ clknet_4_9_0_clk _0029_ net1
+ VSS VSS VDD VDD aligned_a_mant\[13\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[14\]$_DFF_PN0_ clknet_4_8_0_clk _0030_ net1
+ VSS VSS VDD VDD aligned_a_mant\[14\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[15\]$_DFF_PN0_ clknet_4_8_0_clk _0031_ net1
+ VSS VSS VDD VDD aligned_a_mant\[15\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[16\]$_DFF_PN0_ clknet_4_8_0_clk _0032_ net1
+ VSS VSS VDD VDD aligned_a_mant\[16\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[17\]$_DFF_PN0_ clknet_4_10_0_clk _0033_ net1
+ VSS VSS VDD VDD aligned_a_mant\[17\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[18\]$_DFF_PN0_ clknet_4_8_0_clk _0034_ net1
+ VSS VSS VDD VDD aligned_a_mant\[18\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[19\]$_DFF_PN0_ clknet_4_8_0_clk _0035_ net1
+ VSS VSS VDD VDD aligned_a_mant\[19\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[1\]$_DFF_PN0_ clknet_4_10_0_clk _0036_ net1
+ VSS VSS VDD VDD aligned_a_mant\[1\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[20\]$_DFF_PN0_ clknet_4_2_0_clk _0037_ net1
+ VSS VSS VDD VDD aligned_a_mant\[20\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[21\]$_DFF_PN0_ clknet_4_2_0_clk _0038_ net1
+ VSS VSS VDD VDD aligned_a_mant\[21\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[22\]$_DFF_PN0_ clknet_4_2_0_clk _0039_ net1
+ VSS VSS VDD VDD aligned_a_mant\[22\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[23\]$_DFF_PN0_ clknet_4_2_0_clk _0040_ net1
+ VSS VSS VDD VDD aligned_a_mant\[23\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[24\]$_DFF_PN0_ clknet_4_3_0_clk _0041_ net1
+ VSS VSS VDD VDD aligned_a_mant\[24\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[25\]$_DFF_PN0_ clknet_4_3_0_clk _0042_ net1
+ VSS VSS VDD VDD aligned_a_mant\[25\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[2\]$_DFF_PN0_ clknet_4_10_0_clk _0043_ net1
+ VSS VSS VDD VDD aligned_a_mant\[2\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[3\]$_DFF_PN0_ clknet_4_10_0_clk _0044_ net1
+ VSS VSS VDD VDD aligned_a_mant\[3\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[4\]$_DFF_PN0_ clknet_4_11_0_clk _0045_ net1
+ VSS VSS VDD VDD aligned_a_mant\[4\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[5\]$_DFF_PN0_ clknet_4_11_0_clk _0046_ net1
+ VSS VSS VDD VDD aligned_a_mant\[5\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[6\]$_DFF_PN0_ clknet_4_11_0_clk _0047_ net1
+ VSS VSS VDD VDD aligned_a_mant\[6\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[7\]$_DFF_PN0_ clknet_4_14_0_clk _0048_ net1
+ VSS VSS VDD VDD aligned_a_mant\[7\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[8\]$_DFF_PN0_ clknet_4_11_0_clk _0049_ net1
+ VSS VSS VDD VDD aligned_a_mant\[8\] sky130_fd_sc_hd__dfrtp_1
Xaligned_a_mant\[9\]$_DFF_PN0_ clknet_4_11_0_clk _0050_ net1
+ VSS VSS VDD VDD aligned_a_mant\[9\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[0\]$_DFF_PN0_ clknet_4_10_0_clk _0051_ net1
+ VSS VSS VDD VDD aligned_b_mant\[0\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[10\]$_DFF_PN0_ clknet_4_11_0_clk _0052_ net1
+ VSS VSS VDD VDD aligned_b_mant\[10\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[11\]$_DFF_PN0_ clknet_4_10_0_clk _0053_ net1
+ VSS VSS VDD VDD aligned_b_mant\[11\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[12\]$_DFF_PN0_ clknet_4_9_0_clk _0054_ net1
+ VSS VSS VDD VDD aligned_b_mant\[12\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[13\]$_DFF_PN0_ clknet_4_9_0_clk _0055_ net1
+ VSS VSS VDD VDD aligned_b_mant\[13\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[14\]$_DFF_PN0_ clknet_4_10_0_clk _0056_ net1
+ VSS VSS VDD VDD aligned_b_mant\[14\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[15\]$_DFF_PN0_ clknet_4_8_0_clk _0057_ net1
+ VSS VSS VDD VDD aligned_b_mant\[15\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[16\]$_DFF_PN0_ clknet_4_8_0_clk _0058_ net1
+ VSS VSS VDD VDD aligned_b_mant\[16\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[17\]$_DFF_PN0_ clknet_4_8_0_clk _0059_ net1
+ VSS VSS VDD VDD aligned_b_mant\[17\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[18\]$_DFF_PN0_ clknet_4_8_0_clk _0060_ net1
+ VSS VSS VDD VDD aligned_b_mant\[18\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[19\]$_DFF_PN0_ clknet_4_8_0_clk _0061_ net1
+ VSS VSS VDD VDD aligned_b_mant\[19\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[1\]$_DFF_PN0_ clknet_4_10_0_clk _0062_ net1
+ VSS VSS VDD VDD aligned_b_mant\[1\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[20\]$_DFF_PN0_ clknet_4_2_0_clk _0063_ net1
+ VSS VSS VDD VDD aligned_b_mant\[20\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[21\]$_DFF_PN0_ clknet_4_2_0_clk _0064_ net1
+ VSS VSS VDD VDD aligned_b_mant\[21\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[22\]$_DFF_PN0_ clknet_4_2_0_clk _0065_ net1
+ VSS VSS VDD VDD aligned_b_mant\[22\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[23\]$_DFF_PN0_ clknet_4_2_0_clk _0066_ net1
+ VSS VSS VDD VDD aligned_b_mant\[23\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[24\]$_DFF_PN0_ clknet_4_2_0_clk _0067_ net1
+ VSS VSS VDD VDD aligned_b_mant\[24\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[25\]$_DFF_PN0_ clknet_4_3_0_clk _0068_ net1
+ VSS VSS VDD VDD aligned_b_mant\[25\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[2\]$_DFF_PN0_ clknet_4_10_0_clk _0069_ net1
+ VSS VSS VDD VDD aligned_b_mant\[2\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[3\]$_DFF_PN0_ clknet_4_10_0_clk _0070_ net1
+ VSS VSS VDD VDD aligned_b_mant\[3\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[4\]$_DFF_PN0_ clknet_4_10_0_clk _0071_ net1
+ VSS VSS VDD VDD aligned_b_mant\[4\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[5\]$_DFF_PN0_ clknet_4_11_0_clk _0072_ net1
+ VSS VSS VDD VDD aligned_b_mant\[5\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[6\]$_DFF_PN0_ clknet_4_10_0_clk _0073_ net1
+ VSS VSS VDD VDD aligned_b_mant\[6\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[7\]$_DFF_PN0_ clknet_4_15_0_clk _0074_ net1
+ VSS VSS VDD VDD aligned_b_mant\[7\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[8\]$_DFF_PN0_ clknet_4_11_0_clk _0075_ net1
+ VSS VSS VDD VDD aligned_b_mant\[8\] sky130_fd_sc_hd__dfrtp_1
Xaligned_b_mant\[9\]$_DFF_PN0_ clknet_4_10_0_clk _0076_ net1
+ VSS VSS VDD VDD aligned_b_mant\[9\] sky130_fd_sc_hd__dfrtp_1
Xb_sign_stage1$_DFF_PN0_ clknet_4_3_0_clk net58 net1 VSS VSS
+ VDD VDD b_sign_stage1 sky130_fd_sc_hd__dfrtp_4
Xfinal_exp\[0\]$_DFFE_PP_ clknet_4_1_0_clk _0077_ net66 VSS
+ VSS VDD VDD final_exp\[0\] sky130_fd_sc_hd__edfxtp_1
Xfinal_exp\[1\]$_DFFE_PP_ clknet_4_7_0_clk _0078_ net66 VSS
+ VSS VDD VDD final_exp\[1\] sky130_fd_sc_hd__edfxtp_1
Xfinal_exp\[2\]$_DFFE_PP_ clknet_4_1_0_clk _0079_ net66 VSS
+ VSS VDD VDD final_exp\[2\] sky130_fd_sc_hd__edfxtp_1
Xfinal_exp\[3\]$_DFFE_PP_ clknet_4_1_0_clk _0080_ net66 VSS
+ VSS VDD VDD final_exp\[3\] sky130_fd_sc_hd__edfxtp_1
Xfinal_exp\[4\]$_DFFE_PP_ clknet_4_0_0_clk _0081_ net66 VSS
+ VSS VDD VDD final_exp\[4\] sky130_fd_sc_hd__edfxtp_1
Xfinal_exp\[5\]$_DFFE_PP_ clknet_4_1_0_clk _0082_ net66 VSS
+ VSS VDD VDD final_exp\[5\] sky130_fd_sc_hd__edfxtp_1
Xfinal_exp\[6\]$_DFFE_PP_ clknet_4_0_0_clk _0083_ net66 VSS
+ VSS VDD VDD final_exp\[6\] sky130_fd_sc_hd__edfxtp_1
Xfinal_exp\[7\]$_DFFE_PP_ clknet_4_1_0_clk _0084_ net66 VSS
+ VSS VDD VDD final_exp\[7\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[0\]$_DFFE_PP_ clknet_4_7_0_clk _0085_ net66 VSS
+ VSS VDD VDD final_mant\[0\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[10\]$_DFFE_PP_ clknet_4_13_0_clk _0086_ net66
+ VSS VSS VDD VDD final_mant\[10\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[11\]$_DFFE_PP_ clknet_4_14_0_clk _0087_ net66
+ VSS VSS VDD VDD final_mant\[11\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[12\]$_DFFE_PP_ clknet_4_13_0_clk _0088_ net66
+ VSS VSS VDD VDD final_mant\[12\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[13\]$_DFFE_PP_ clknet_4_13_0_clk _0089_ net66
+ VSS VSS VDD VDD final_mant\[13\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[14\]$_DFFE_PP_ clknet_4_14_0_clk _0090_ net66
+ VSS VSS VDD VDD final_mant\[14\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[15\]$_DFFE_PP_ clknet_4_14_0_clk _0091_ net66
+ VSS VSS VDD VDD final_mant\[15\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[16\]$_DFFE_PP_ clknet_4_15_0_clk _0092_ net66
+ VSS VSS VDD VDD final_mant\[16\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[17\]$_DFFE_PP_ clknet_4_12_0_clk _0093_ net66
+ VSS VSS VDD VDD final_mant\[17\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[18\]$_DFFE_PP_ clknet_4_14_0_clk _0094_ net66
+ VSS VSS VDD VDD final_mant\[18\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[19\]$_DFFE_PP_ clknet_4_13_0_clk _0095_ net66
+ VSS VSS VDD VDD final_mant\[19\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[1\]$_DFFE_PP_ clknet_4_4_0_clk _0096_ net66 VSS
+ VSS VDD VDD final_mant\[1\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[20\]$_DFFE_PP_ clknet_4_13_0_clk _0097_ net66
+ VSS VSS VDD VDD final_mant\[20\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[21\]$_DFFE_PP_ clknet_4_13_0_clk _0098_ net66
+ VSS VSS VDD VDD final_mant\[21\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[22\]$_DFFE_PP_ clknet_4_5_0_clk _0099_ net66
+ VSS VSS VDD VDD final_mant\[22\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[2\]$_DFFE_PP_ clknet_4_4_0_clk _0100_ net66 VSS
+ VSS VDD VDD final_mant\[2\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[3\]$_DFFE_PP_ clknet_4_5_0_clk _0101_ net66 VSS
+ VSS VDD VDD final_mant\[3\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[4\]$_DFFE_PP_ clknet_4_4_0_clk _0102_ net66 VSS
+ VSS VDD VDD final_mant\[4\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[5\]$_DFFE_PP_ clknet_4_5_0_clk _0103_ net66 VSS
+ VSS VDD VDD final_mant\[5\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[6\]$_DFFE_PP_ clknet_4_5_0_clk _0104_ net66 VSS
+ VSS VDD VDD final_mant\[6\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[7\]$_DFFE_PP_ clknet_4_4_0_clk _0105_ net66 VSS
+ VSS VDD VDD final_mant\[7\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[8\]$_DFFE_PP_ clknet_4_13_0_clk _0106_ net66
+ VSS VSS VDD VDD final_mant\[8\] sky130_fd_sc_hd__edfxtp_1
Xfinal_mant\[9\]$_DFFE_PP_ clknet_4_13_0_clk _0107_ net66
+ VSS VSS VDD VDD final_mant\[9\] sky130_fd_sc_hd__edfxtp_1
Xinexact$_DFF_PN0_ clknet_4_7_0_clk _0108_ net1 VSS VSS VDD
+ VDD net68 sky130_fd_sc_hd__dfrtp_1
Xinexact_stage2$_DFF_PN0_ clknet_4_6_0_clk _0109_ net1 VSS
+ VSS VDD VDD inexact_stage2 sky130_fd_sc_hd__dfrtp_1
Xinvalid_op$_DFF_PN0_ clknet_4_1_0_clk invalid_op_stage2 net1
+ VSS VSS VDD VDD net69 sky130_fd_sc_hd__dfrtp_1
Xinvalid_op_stage2$_DFFE_PN0P_ clknet_4_3_0_clk _0121_ net1
+ VSS VSS VDD VDD invalid_op_stage2 sky130_fd_sc_hd__dfrtp_1
Xis_a_larger_stage1$_DFF_PN0_ clknet_4_10_0_clk a_exp_larger
+ net1 VSS VSS VDD VDD is_a_larger_stage1 sky130_fd_sc_hd__dfrtp_4
Xlarger_exp_stage1\[0\]$_DFF_PN0_ clknet_4_0_0_clk _0110_
+ net1 VSS VSS VDD VDD larger_exp_stage1\[0\] sky130_fd_sc_hd__dfrtp_1
Xlarger_exp_stage1\[1\]$_DFF_PN0_ clknet_4_0_0_clk _0111_
+ net1 VSS VSS VDD VDD larger_exp_stage1\[1\] sky130_fd_sc_hd__dfrtp_1
Xlarger_exp_stage1\[2\]$_DFF_PN0_ clknet_4_0_0_clk _0112_
+ net1 VSS VSS VDD VDD larger_exp_stage1\[2\] sky130_fd_sc_hd__dfrtp_1
Xlarger_exp_stage1\[3\]$_DFF_PN0_ clknet_4_1_0_clk _0113_
+ net1 VSS VSS VDD VDD larger_exp_stage1\[3\] sky130_fd_sc_hd__dfrtp_1
Xlarger_exp_stage1\[4\]$_DFF_PN0_ clknet_4_0_0_clk _0114_
+ net1 VSS VSS VDD VDD larger_exp_stage1\[4\] sky130_fd_sc_hd__dfrtp_1
Xlarger_exp_stage1\[5\]$_DFF_PN0_ clknet_4_0_0_clk _0115_
+ net1 VSS VSS VDD VDD larger_exp_stage1\[5\] sky130_fd_sc_hd__dfrtp_1
Xlarger_exp_stage1\[6\]$_DFF_PN0_ clknet_4_0_0_clk _0116_
+ net1 VSS VSS VDD VDD larger_exp_stage1\[6\] sky130_fd_sc_hd__dfrtp_1
Xlarger_exp_stage1\[7\]$_DFF_PN0_ clknet_4_0_0_clk _0117_
+ net1 VSS VSS VDD VDD larger_exp_stage1\[7\] sky130_fd_sc_hd__dfrtp_1
Xoverflow$_DFF_PN0_ clknet_4_1_0_clk _0118_ net1 VSS VSS VDD
+ VDD net70 sky130_fd_sc_hd__dfrtp_1
Xresult\[0\]$_DFF_PN0_ clknet_4_5_0_clk final_mant\[0\] net1
+ VSS VSS VDD VDD net71 sky130_fd_sc_hd__dfrtp_1
Xresult\[10\]$_DFF_PN0_ clknet_4_13_0_clk final_mant\[10\]
+ net1 VSS VSS VDD VDD net72 sky130_fd_sc_hd__dfrtp_1
Xresult\[11\]$_DFF_PN0_ clknet_4_14_0_clk final_mant\[11\]
+ net1 VSS VSS VDD VDD net73 sky130_fd_sc_hd__dfrtp_1
Xresult\[12\]$_DFF_PN0_ clknet_4_14_0_clk final_mant\[12\]
+ net1 VSS VSS VDD VDD net74 sky130_fd_sc_hd__dfrtp_1
Xresult\[13\]$_DFF_PN0_ clknet_4_13_0_clk final_mant\[13\]
+ net1 VSS VSS VDD VDD net75 sky130_fd_sc_hd__dfrtp_1
Xresult\[14\]$_DFF_PN0_ clknet_4_14_0_clk final_mant\[14\]
+ net1 VSS VSS VDD VDD net76 sky130_fd_sc_hd__dfrtp_1
Xresult\[15\]$_DFF_PN0_ clknet_4_15_0_clk final_mant\[15\]
+ net1 VSS VSS VDD VDD net77 sky130_fd_sc_hd__dfrtp_1
Xresult\[16\]$_DFF_PN0_ clknet_4_15_0_clk final_mant\[16\]
+ net1 VSS VSS VDD VDD net78 sky130_fd_sc_hd__dfrtp_1
Xresult\[17\]$_DFF_PN0_ clknet_4_13_0_clk final_mant\[17\]
+ net1 VSS VSS VDD VDD net79 sky130_fd_sc_hd__dfrtp_1
Xresult\[18\]$_DFF_PN0_ clknet_4_15_0_clk final_mant\[18\]
+ net1 VSS VSS VDD VDD net80 sky130_fd_sc_hd__dfrtp_1
Xresult\[19\]$_DFF_PN0_ clknet_4_5_0_clk final_mant\[19\]
+ net1 VSS VSS VDD VDD net81 sky130_fd_sc_hd__dfrtp_1
Xresult\[1\]$_DFF_PN0_ clknet_4_5_0_clk final_mant\[1\] net1
+ VSS VSS VDD VDD net82 sky130_fd_sc_hd__dfrtp_1
Xresult\[20\]$_DFF_PN0_ clknet_4_14_0_clk final_mant\[20\]
+ net1 VSS VSS VDD VDD net83 sky130_fd_sc_hd__dfrtp_1
Xresult\[21\]$_DFF_PN0_ clknet_4_13_0_clk final_mant\[21\]
+ net1 VSS VSS VDD VDD net84 sky130_fd_sc_hd__dfrtp_1
Xresult\[22\]$_DFF_PN0_ clknet_4_5_0_clk final_mant\[22\]
+ net1 VSS VSS VDD VDD net85 sky130_fd_sc_hd__dfrtp_1
Xresult\[23\]$_DFF_PN0_ clknet_4_7_0_clk final_exp\[0\] net1
+ VSS VSS VDD VDD net86 sky130_fd_sc_hd__dfrtp_1
Xresult\[24\]$_DFF_PN0_ clknet_4_7_0_clk final_exp\[1\] net1
+ VSS VSS VDD VDD net87 sky130_fd_sc_hd__dfrtp_1
Xresult\[25\]$_DFF_PN0_ clknet_4_7_0_clk final_exp\[2\] net1
+ VSS VSS VDD VDD net88 sky130_fd_sc_hd__dfrtp_1
Xresult\[26\]$_DFF_PN0_ clknet_4_1_0_clk final_exp\[3\] net1
+ VSS VSS VDD VDD net89 sky130_fd_sc_hd__dfrtp_1
Xresult\[27\]$_DFF_PN0_ clknet_4_1_0_clk final_exp\[4\] net1
+ VSS VSS VDD VDD net90 sky130_fd_sc_hd__dfrtp_1
Xresult\[28\]$_DFF_PN0_ clknet_4_7_0_clk final_exp\[5\] net1
+ VSS VSS VDD VDD net91 sky130_fd_sc_hd__dfrtp_1
Xresult\[29\]$_DFF_PN0_ clknet_4_1_0_clk final_exp\[6\] net1
+ VSS VSS VDD VDD net92 sky130_fd_sc_hd__dfrtp_1
Xresult\[2\]$_DFF_PN0_ clknet_4_4_0_clk final_mant\[2\] net1
+ VSS VSS VDD VDD net93 sky130_fd_sc_hd__dfrtp_1
Xresult\[30\]$_DFF_PN0_ clknet_4_1_0_clk final_exp\[7\] net1
+ VSS VSS VDD VDD net94 sky130_fd_sc_hd__dfrtp_1
Xresult\[31\]$_DFF_PN0_ clknet_4_1_0_clk result_sign_stage2
+ net1 VSS VSS VDD VDD net95 sky130_fd_sc_hd__dfrtp_1
Xresult\[3\]$_DFF_PN0_ clknet_4_5_0_clk final_mant\[3\] net1
+ VSS VSS VDD VDD net96 sky130_fd_sc_hd__dfrtp_1
Xresult\[4\]$_DFF_PN0_ clknet_4_4_0_clk final_mant\[4\] net1
+ VSS VSS VDD VDD net97 sky130_fd_sc_hd__dfrtp_1
Xresult\[5\]$_DFF_PN0_ clknet_4_4_0_clk final_mant\[5\] net1
+ VSS VSS VDD VDD net98 sky130_fd_sc_hd__dfrtp_1
Xresult\[6\]$_DFF_PN0_ clknet_4_5_0_clk final_mant\[6\] net1
+ VSS VSS VDD VDD net99 sky130_fd_sc_hd__dfrtp_1
Xresult\[7\]$_DFF_PN0_ clknet_4_5_0_clk final_mant\[7\] net1
+ VSS VSS VDD VDD net100 sky130_fd_sc_hd__dfrtp_1
Xresult\[8\]$_DFF_PN0_ clknet_4_13_0_clk final_mant\[8\] net1
+ VSS VSS VDD VDD net101 sky130_fd_sc_hd__dfrtp_1
Xresult\[9\]$_DFF_PN0_ clknet_4_13_0_clk final_mant\[9\] net1
+ VSS VSS VDD VDD net102 sky130_fd_sc_hd__dfrtp_1
Xresult_exp_stage2\[0\]$_DFF_PN0_ clknet_4_3_0_clk larger_exp_stage1\[0\]
+ net1 VSS VSS VDD VDD result_exp_stage2\[0\] sky130_fd_sc_hd__dfrtp_4
Xresult_exp_stage2\[1\]$_DFF_PN0_ clknet_4_3_0_clk larger_exp_stage1\[1\]
+ net1 VSS VSS VDD VDD result_exp_stage2\[1\] sky130_fd_sc_hd__dfrtp_4
Xresult_exp_stage2\[2\]$_DFF_PN0_ clknet_4_3_0_clk larger_exp_stage1\[2\]
+ net1 VSS VSS VDD VDD result_exp_stage2\[2\] sky130_fd_sc_hd__dfrtp_1
Xresult_exp_stage2\[3\]$_DFF_PN0_ clknet_4_1_0_clk larger_exp_stage1\[3\]
+ net1 VSS VSS VDD VDD result_exp_stage2\[3\] sky130_fd_sc_hd__dfrtp_1
Xresult_exp_stage2\[4\]$_DFF_PN0_ clknet_4_0_0_clk larger_exp_stage1\[4\]
+ net1 VSS VSS VDD VDD result_exp_stage2\[4\] sky130_fd_sc_hd__dfrtp_1
Xresult_exp_stage2\[5\]$_DFF_PN0_ clknet_4_0_0_clk larger_exp_stage1\[5\]
+ net1 VSS VSS VDD VDD result_exp_stage2\[5\] sky130_fd_sc_hd__dfrtp_1
Xresult_exp_stage2\[6\]$_DFF_PN0_ clknet_4_1_0_clk larger_exp_stage1\[6\]
+ net1 VSS VSS VDD VDD result_exp_stage2\[6\] sky130_fd_sc_hd__dfrtp_2
Xresult_exp_stage2\[7\]$_DFF_PN0_ clknet_4_0_0_clk larger_exp_stage1\[7\]
+ net1 VSS VSS VDD VDD result_exp_stage2\[7\] sky130_fd_sc_hd__dfrtp_1
Xresult_sign_stage2$_DFF_PN0_ clknet_4_1_0_clk _0119_ net1
+ VSS VSS VDD VDD result_sign_stage2 sky130_fd_sc_hd__dfrtp_1
Xunderflow$_DFF_PN0_ clknet_4_4_0_clk _0120_ net1 VSS VSS
+ VDD VDD net103 sky130_fd_sc_hd__dfrtp_1
Xvalid_out$_DFF_PN0_ clknet_4_15_0_clk valid_stage2 net1 VSS
+ VSS VDD VDD net104 sky130_fd_sc_hd__dfrtp_1
Xvalid_stage1$_DFF_PN0_ clknet_4_15_0_clk net67 net1 VSS VSS
+ VDD VDD valid_stage1 sky130_fd_sc_hd__dfrtp_1
Xvalid_stage2$_DFF_PN0_ clknet_4_14_0_clk valid_stage1 net1
+ VSS VSS VDD VDD valid_stage2 sky130_fd_sc_hd__dfrtp_1
Xhold1 net66 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_16
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 a[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xinput2 a[10] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_2
Xinput3 a[11] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_2
Xinput4 a[12] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_2
Xinput5 a[13] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_2
Xinput6 a[14] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_2
Xinput7 a[15] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_2
Xinput8 a[16] VSS VSS VDD VDD net9 sky130_fd_sc_hd__buf_2
Xinput9 a[17] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_2
Xinput10 a[18] VSS VSS VDD VDD net11 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput11 a[19] VSS VSS VDD VDD net12 sky130_fd_sc_hd__buf_2
Xinput12 a[1] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_2
Xinput13 a[20] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_2
Xinput14 a[21] VSS VSS VDD VDD net15 sky130_fd_sc_hd__buf_2
Xinput15 a[22] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_4
Xinput16 a[23] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_2
Xinput17 a[24] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_2
Xinput18 a[25] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_2
Xinput19 a[26] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_2
Xinput20 a[27] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_2
Xinput21 a[28] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_2
Xinput22 a[29] VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_2
Xinput23 a[2] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_2
Xinput24 a[30] VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_2
Xinput25 net107 VSS VSS VDD VDD net26 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput26 a[3] VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_2
Xinput27 a[4] VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_2
Xinput28 a[5] VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_2
Xinput29 a[6] VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_2
Xinput30 a[7] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_2
Xinput31 a[8] VSS VSS VDD VDD net32 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput32 a[9] VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_2
Xinput33 b[0] VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_2
Xinput34 b[10] VSS VSS VDD VDD net35 sky130_fd_sc_hd__buf_2
Xinput35 b[11] VSS VSS VDD VDD net36 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput36 b[12] VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_2
Xinput37 b[13] VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkbuf_2
Xinput38 b[14] VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_2
Xinput39 b[15] VSS VSS VDD VDD net40 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput40 b[16] VSS VSS VDD VDD net41 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput41 b[17] VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_2
Xinput42 b[18] VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_1
Xinput43 b[19] VSS VSS VDD VDD net44 sky130_fd_sc_hd__buf_2
Xinput44 b[1] VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_2
Xinput45 b[20] VSS VSS VDD VDD net46 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput46 b[21] VSS VSS VDD VDD net47 sky130_fd_sc_hd__clkbuf_2
Xinput47 b[22] VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkbuf_4
Xinput48 b[23] VSS VSS VDD VDD net49 sky130_fd_sc_hd__clkbuf_1
Xinput49 b[24] VSS VSS VDD VDD net50 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput50 b[25] VSS VSS VDD VDD net51 sky130_fd_sc_hd__clkbuf_1
Xinput51 b[26] VSS VSS VDD VDD net52 sky130_fd_sc_hd__clkbuf_1
Xinput52 b[27] VSS VSS VDD VDD net53 sky130_fd_sc_hd__clkbuf_1
Xinput53 b[28] VSS VSS VDD VDD net54 sky130_fd_sc_hd__clkbuf_1
Xinput54 b[29] VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkbuf_1
Xinput55 b[2] VSS VSS VDD VDD net56 sky130_fd_sc_hd__clkbuf_2
Xinput56 b[30] VSS VSS VDD VDD net57 sky130_fd_sc_hd__clkbuf_1
Xinput57 net106 VSS VSS VDD VDD net58 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput58 b[3] VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_2
Xinput59 b[4] VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkbuf_2
Xinput60 b[5] VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkbuf_2
Xinput61 b[6] VSS VSS VDD VDD net62 sky130_fd_sc_hd__buf_2
Xinput62 b[7] VSS VSS VDD VDD net63 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput63 b[8] VSS VSS VDD VDD net64 sky130_fd_sc_hd__clkbuf_2
Xinput64 b[9] VSS VSS VDD VDD net65 sky130_fd_sc_hd__buf_2
Xinput65 rst_n VSS VSS VDD VDD net66 sky130_fd_sc_hd__buf_12
Xinput66 net105 VSS VSS VDD VDD net67 sky130_fd_sc_hd__clkbuf_1
Xoutput67 net68 VSS VSS VDD VDD inexact sky130_fd_sc_hd__clkbuf_1
Xoutput68 net69 VSS VSS VDD VDD invalid_op sky130_fd_sc_hd__clkbuf_1
Xoutput69 net70 VSS VSS VDD VDD overflow sky130_fd_sc_hd__clkbuf_1
Xoutput70 net71 VSS VSS VDD VDD result[0] sky130_fd_sc_hd__clkbuf_1
Xoutput71 net72 VSS VSS VDD VDD result[10] sky130_fd_sc_hd__clkbuf_1
Xoutput72 net73 VSS VSS VDD VDD result[11] sky130_fd_sc_hd__clkbuf_1
Xoutput73 net74 VSS VSS VDD VDD result[12] sky130_fd_sc_hd__clkbuf_1
Xoutput74 net75 VSS VSS VDD VDD result[13] sky130_fd_sc_hd__clkbuf_1
Xoutput75 net76 VSS VSS VDD VDD result[14] sky130_fd_sc_hd__clkbuf_1
Xoutput76 net77 VSS VSS VDD VDD result[15] sky130_fd_sc_hd__clkbuf_1
Xoutput77 net78 VSS VSS VDD VDD result[16] sky130_fd_sc_hd__clkbuf_1
Xoutput78 net79 VSS VSS VDD VDD result[17] sky130_fd_sc_hd__clkbuf_1
Xoutput79 net80 VSS VSS VDD VDD result[18] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net81 VSS VSS VDD VDD result[19] sky130_fd_sc_hd__clkbuf_1
Xoutput81 net82 VSS VSS VDD VDD result[1] sky130_fd_sc_hd__clkbuf_1
Xoutput82 net83 VSS VSS VDD VDD result[20] sky130_fd_sc_hd__clkbuf_1
Xoutput83 net84 VSS VSS VDD VDD result[21] sky130_fd_sc_hd__clkbuf_1
Xoutput84 net85 VSS VSS VDD VDD result[22] sky130_fd_sc_hd__clkbuf_1
Xoutput85 net86 VSS VSS VDD VDD result[23] sky130_fd_sc_hd__clkbuf_1
Xoutput86 net87 VSS VSS VDD VDD result[24] sky130_fd_sc_hd__clkbuf_1
Xoutput87 net88 VSS VSS VDD VDD result[25] sky130_fd_sc_hd__clkbuf_1
Xoutput88 net89 VSS VSS VDD VDD result[26] sky130_fd_sc_hd__clkbuf_1
Xoutput89 net90 VSS VSS VDD VDD result[27] sky130_fd_sc_hd__clkbuf_1
Xoutput90 net91 VSS VSS VDD VDD result[28] sky130_fd_sc_hd__clkbuf_1
Xoutput91 net92 VSS VSS VDD VDD result[29] sky130_fd_sc_hd__clkbuf_1
Xoutput92 net93 VSS VSS VDD VDD result[2] sky130_fd_sc_hd__clkbuf_1
Xoutput93 net94 VSS VSS VDD VDD result[30] sky130_fd_sc_hd__clkbuf_1
Xoutput94 net95 VSS VSS VDD VDD result[31] sky130_fd_sc_hd__clkbuf_1
Xoutput95 net96 VSS VSS VDD VDD result[3] sky130_fd_sc_hd__clkbuf_1
Xoutput96 net97 VSS VSS VDD VDD result[4] sky130_fd_sc_hd__clkbuf_1
Xoutput97 net98 VSS VSS VDD VDD result[5] sky130_fd_sc_hd__clkbuf_1
Xoutput98 net99 VSS VSS VDD VDD result[6] sky130_fd_sc_hd__clkbuf_1
Xoutput99 net100 VSS VSS VDD VDD result[7] sky130_fd_sc_hd__clkbuf_1
Xoutput100 net101 VSS VSS VDD VDD result[8] sky130_fd_sc_hd__clkbuf_1
Xoutput101 net102 VSS VSS VDD VDD result[9] sky130_fd_sc_hd__clkbuf_1
Xoutput102 net103 VSS VSS VDD VDD underflow sky130_fd_sc_hd__clkbuf_1
Xoutput103 net104 VSS VSS VDD VDD valid_out sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_0_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_0_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_1_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_1_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_2_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_2_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_3_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_3_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_4_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_4_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_5_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_5_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_6_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_6_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_7_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_7_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_8_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_8_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_9_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_9_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_10_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_10_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_11_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_11_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_12_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_12_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_13_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_13_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_14_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_14_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_15_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_15_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_4_0_0_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__bufinv_16
Xclkload1 clknet_4_1_0_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkbuf_1
Xclkload2 clknet_4_2_0_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__inv_6
Xclkload3 clknet_4_3_0_clk VSS VSS VDD VDD _unconnected_3
+ sky130_fd_sc_hd__inv_6
Xclkload4 clknet_4_4_0_clk VSS VSS VDD VDD _unconnected_4
+ sky130_fd_sc_hd__inv_6
Xclkload5 clknet_4_5_0_clk VSS VSS VDD VDD _unconnected_5
+ sky130_fd_sc_hd__inv_4
Xclkload6 clknet_4_6_0_clk VSS VSS VDD VDD _unconnected_6
+ sky130_fd_sc_hd__clkinv_8
Xclkload7 clknet_4_7_0_clk VSS VSS VDD VDD _unconnected_7
+ sky130_fd_sc_hd__inv_8
Xclkload8 clknet_4_8_0_clk VSS VSS VDD VDD _unconnected_8
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload9 clknet_4_9_0_clk VSS VSS VDD VDD _unconnected_9
+ sky130_fd_sc_hd__inv_8
Xclkload10 clknet_4_10_0_clk VSS VSS VDD VDD _unconnected_10
+ sky130_fd_sc_hd__clkbuf_1
Xclkload11 clknet_4_11_0_clk VSS VSS VDD VDD _unconnected_11
+ sky130_fd_sc_hd__clkinv_4
Xclkload12 clknet_4_12_0_clk VSS VSS VDD VDD _unconnected_12
+ sky130_fd_sc_hd__clkinv_4
Xclkload13 clknet_4_13_0_clk VSS VSS VDD VDD _unconnected_13
+ sky130_fd_sc_hd__clkbuf_8
Xclkload14 clknet_4_14_0_clk VSS VSS VDD VDD _unconnected_14
+ sky130_fd_sc_hd__inv_4
Xhold2 valid_in VSS VSS VDD VDD net105 sky130_fd_sc_hd__dlygate4sd3_1
Xhold3 b[31] VSS VSS VDD VDD net106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold4 a[31] VSS VSS VDD VDD net107 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_1 _0074_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS floating_point_adder
