* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT spi_master clk rst_n rx_data[0] rx_data[1] rx_data[2]
+ rx_data[3] rx_data[4] rx_data[5] rx_data[6] rx_data[7] rx_valid
+ spi_clk spi_cs_n spi_miso spi_mosi tx_data[0] tx_data[1] tx_data[2]
+ tx_data[3] tx_data[4] tx_data[5] tx_data[6] tx_data[7] tx_ready
+ tx_valid
X_147_ bit_count\[2\] VSS VSS VDD VDD _126_ sky130_fd_sc_hd__buf_2
X_148_ bit_count\[3\] VSS VSS VDD VDD _127_ sky130_fd_sc_hd__clkinvlp_4
X_149_ _126_ _127_ _142_ VSS VSS VDD VDD _128_ sky130_fd_sc_hd__nand3_1
X_150_ _128_ VSS VSS VDD VDD _133_ sky130_fd_sc_hd__inv_1
X_151_ _126_ bit_count\[1\] bit_count\[0\] VSS VSS VDD VDD
+ _144_ sky130_fd_sc_hd__nand3_1
X_152_ _144_ _127_ VSS VSS VDD VDD _136_ sky130_fd_sc_hd__nand2b_1
X_153_ _126_ _127_ _142_ VSS VSS VDD VDD _139_ sky130_fd_sc_hd__nand3_1
X_154_ state\[0\] VSS VSS VDD VDD _034_ sky130_fd_sc_hd__buf_2
X_155_ _034_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__buf_2
X_156_ net22 VSS VSS VDD VDD _036_ sky130_fd_sc_hd__buf_2
X_157_ state\[1\] _036_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__or2_0
X_158_ _036_ bit_count\[0\] VSS VSS VDD VDD _038_ sky130_fd_sc_hd__nand2_1
X_159_ bit_count\[0\] _037_ _038_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__o21ai_0
X_160_ state\[1\] VSS VSS VDD VDD _040_ sky130_fd_sc_hd__buf_2
X_161_ _034_ net12 _040_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__o21bai_2
X_162_ _035_ _039_ _041_ bit_count\[0\] VSS VSS VDD VDD _000_
+ sky130_fd_sc_hd__a22o_1
X_163_ state\[1\] _036_ VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nor2_1
X_164_ _036_ bit_count\[1\] _143_ _042_ VSS VSS VDD VDD _043_
+ sky130_fd_sc_hd__a22o_1
X_165_ bit_count\[1\] _041_ _043_ _035_ VSS VSS VDD VDD _001_
+ sky130_fd_sc_hd__a22o_1
X_166_ _142_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__inv_1
X_167_ _036_ _044_ _126_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__o21ai_0
X_168_ _126_ _044_ _037_ _045_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__o31ai_1
X_169_ _126_ _041_ _046_ _035_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__a22o_1
X_170_ _036_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__inv_1
X_171_ _146_ _042_ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__nand2_1
X_172_ _047_ _127_ _048_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__o21ai_0
X_173_ bit_count\[3\] _041_ _049_ _035_ VSS VSS VDD VDD _003_
+ sky130_fd_sc_hd__a22o_1
X_174_ _130_ _138_ _141_ _137_ VSS VSS VDD VDD _050_ sky130_fd_sc_hd__nor4b_4
X_175_ _140_ _145_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__and2_0
X_176_ _137_ _141_ _138_ _130_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__and4b_2
X_177_ _140_ _145_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__nor2_1
X_178_ _050_ _051_ _052_ _053_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__a22oi_1
X_179_ _126_ _142_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__xnor2_1
X_180_ _134_ _131_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__nor2_1
X_181_ bit_count\[0\] _055_ _056_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__nand3_1
X_182_ _143_ _146_ _130_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__nand3b_1
X_183_ state\[1\] net22 state\[0\] VSS VSS VDD VDD _059_ sky130_fd_sc_hd__nor3b_4
X_184_ _054_ _057_ _058_ _059_ debug_miso_samples\[0\] VSS
+ VSS VDD VDD _060_ sky130_fd_sc_hd__o311ai_0
X_185_ net3 _059_ VSS VSS VDD VDD _061_ sky130_fd_sc_hd__nand2_1
X_186_ _054_ _057_ _058_ _061_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__or4_1
X_187_ _034_ _036_ _040_ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__a21o_1
X_188_ debug_miso_samples\[0\] _063_ VSS VSS VDD VDD _064_
+ sky130_fd_sc_hd__nand2_1
X_189_ _060_ _062_ _064_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__nand3_1
X_190_ debug_miso_samples\[1\] _063_ VSS VSS VDD VDD _065_
+ sky130_fd_sc_hd__nand2_1
X_191_ _146_ _143_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nor2b_1
X_192_ _146_ _140_ _145_ _143_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__and4b_1
X_193_ _052_ _053_ _066_ _067_ _050_ VSS VSS VDD VDD _068_
+ sky130_fd_sc_hd__a32oi_4
X_194_ _126_ _142_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__xor2_1
X_195_ bit_count\[0\] _130_ _134_ _131_ VSS VSS VDD VDD _070_
+ sky130_fd_sc_hd__nor4_1
X_196_ _069_ _070_ VSS VSS VDD VDD _071_ sky130_fd_sc_hd__nand2_1
X_197_ _068_ _071_ debug_miso_samples\[1\] _059_ VSS VSS VDD
+ VDD _072_ sky130_fd_sc_hd__o211ai_1
X_198_ _061_ _068_ _071_ VSS VSS VDD VDD _073_ sky130_fd_sc_hd__or3_1
X_199_ _065_ _072_ _073_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__nand3_1
X_200_ debug_miso_samples\[2\] _063_ VSS VSS VDD VDD _074_
+ sky130_fd_sc_hd__nand2_1
X_201_ _130_ _069_ _056_ bit_count\[0\] VSS VSS VDD VDD _075_
+ sky130_fd_sc_hd__nand4b_2
X_202_ _068_ _075_ debug_miso_samples\[2\] _059_ VSS VSS VDD
+ VDD _076_ sky130_fd_sc_hd__o211ai_1
X_203_ _061_ _068_ _075_ VSS VSS VDD VDD _077_ sky130_fd_sc_hd__or3_1
X_204_ _074_ _076_ _077_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__nand3_1
X_205_ _040_ _034_ debug_miso_samples\[3\] VSS VSS VDD VDD
+ _078_ sky130_fd_sc_hd__o21ai_0
X_206_ _146_ _140_ VSS VSS VDD VDD _079_ sky130_fd_sc_hd__nor2b_1
X_207_ _146_ _140_ _145_ VSS VSS VDD VDD _080_ sky130_fd_sc_hd__nor3_1
X_208_ _145_ _050_ _079_ _080_ _052_ VSS VSS VDD VDD _081_
+ sky130_fd_sc_hd__a32oi_4
X_209_ _036_ _143_ _034_ VSS VSS VDD VDD _082_ sky130_fd_sc_hd__o21ai_0
X_210_ _040_ _082_ VSS VSS VDD VDD _083_ sky130_fd_sc_hd__nand2b_1
X_211_ _081_ _071_ _083_ VSS VSS VDD VDD _084_ sky130_fd_sc_hd__nor3_1
X_212_ _143_ _061_ _081_ VSS VSS VDD VDD _085_ sky130_fd_sc_hd__or3_1
X_213_ _078_ _084_ _085_ _071_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__o22ai_1
X_214_ _040_ _035_ debug_miso_samples\[4\] VSS VSS VDD VDD
+ _086_ sky130_fd_sc_hd__o21ai_0
X_215_ _143_ _063_ _081_ _075_ VSS VSS VDD VDD _087_ sky130_fd_sc_hd__nor4_1
X_216_ _075_ _085_ _086_ _087_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__o22ai_1
X_217_ debug_miso_samples\[5\] _063_ VSS VSS VDD VDD _088_
+ sky130_fd_sc_hd__nand2_1
X_218_ _055_ _070_ VSS VSS VDD VDD _089_ sky130_fd_sc_hd__nand2_1
X_219_ _068_ _089_ debug_miso_samples\[5\] _059_ VSS VSS VDD
+ VDD _090_ sky130_fd_sc_hd__o211ai_1
X_220_ _061_ _068_ _089_ VSS VSS VDD VDD _091_ sky130_fd_sc_hd__or3_1
X_221_ _088_ _090_ _091_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__nand3_1
X_222_ debug_miso_samples\[6\] _063_ VSS VSS VDD VDD _092_
+ sky130_fd_sc_hd__nand2_1
X_223_ _130_ _057_ _068_ _059_ debug_miso_samples\[6\] VSS
+ VSS VDD VDD _093_ sky130_fd_sc_hd__o311ai_0
X_224_ _130_ _057_ _061_ _068_ VSS VSS VDD VDD _094_ sky130_fd_sc_hd__or4_1
X_225_ _092_ _093_ _094_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__nand3_1
X_226_ _040_ _034_ debug_miso_samples\[7\] VSS VSS VDD VDD
+ _095_ sky130_fd_sc_hd__o21ai_0
X_227_ _081_ _083_ _089_ VSS VSS VDD VDD _096_ sky130_fd_sc_hd__nor3_1
X_228_ _085_ _089_ _095_ _096_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__o22ai_1
X_229_ state\[0\] state\[1\] VSS VSS VDD VDD _097_ sky130_fd_sc_hd__nand2b_1
X_230_ _097_ VSS VSS VDD VDD _098_ sky130_fd_sc_hd__clkbuf_4
X_231_ debug_miso_samples\[0\] net13 _098_ VSS VSS VDD VDD
+ _012_ sky130_fd_sc_hd__mux2_1
X_232_ debug_miso_samples\[1\] net14 _098_ VSS VSS VDD VDD
+ _013_ sky130_fd_sc_hd__mux2_1
X_233_ debug_miso_samples\[2\] net15 _098_ VSS VSS VDD VDD
+ _014_ sky130_fd_sc_hd__mux2_1
X_234_ debug_miso_samples\[3\] net16 _098_ VSS VSS VDD VDD
+ _015_ sky130_fd_sc_hd__mux2_1
X_235_ debug_miso_samples\[4\] net17 _098_ VSS VSS VDD VDD
+ _016_ sky130_fd_sc_hd__mux2_1
X_236_ debug_miso_samples\[5\] net18 _098_ VSS VSS VDD VDD
+ _017_ sky130_fd_sc_hd__mux2_1
X_237_ debug_miso_samples\[6\] net19 _098_ VSS VSS VDD VDD
+ _018_ sky130_fd_sc_hd__mux2_1
X_238_ debug_miso_samples\[7\] net20 _098_ VSS VSS VDD VDD
+ _019_ sky130_fd_sc_hd__mux2_1
X_239_ _035_ net21 VSS VSS VDD VDD _099_ sky130_fd_sc_hd__nand2_1
X_240_ _098_ _099_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__nand2_1
X_241_ _040_ _036_ VSS VSS VDD VDD _100_ sky130_fd_sc_hd__nand2_1
X_242_ _037_ _100_ _035_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__a21boi_0
X_243_ _040_ _034_ VSS VSS VDD VDD _101_ sky130_fd_sc_hd__nor2_1
X_244_ net23 _034_ VSS VSS VDD VDD _102_ sky130_fd_sc_hd__nor2b_1
X_245_ net12 _101_ _102_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__a21oi_1
X_246_ state\[0\] net12 VSS VSS VDD VDD _103_ sky130_fd_sc_hd__nand2b_1
X_247_ _034_ _036_ _129_ VSS VSS VDD VDD _104_ sky130_fd_sc_hd__nand3_1
X_248_ _103_ _104_ state\[1\] VSS VSS VDD VDD _105_ sky130_fd_sc_hd__a21oi_2
X_249_ _105_ VSS VSS VDD VDD _106_ sky130_fd_sc_hd__buf_2
X_250_ state\[1\] _034_ VSS VSS VDD VDD _107_ sky130_fd_sc_hd__nor2b_1
X_251_ _107_ VSS VSS VDD VDD _108_ sky130_fd_sc_hd__clkbuf_4
X_252_ net11 tx_shift\[6\] _108_ VSS VSS VDD VDD _109_ sky130_fd_sc_hd__mux2i_1
X_253_ net24 _106_ VSS VSS VDD VDD _110_ sky130_fd_sc_hd__nor2_1
X_254_ _106_ _109_ _110_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__a21oi_1
X_255_ _035_ _047_ _133_ _041_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__a31oi_1
X_256_ _128_ _059_ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__nor2b_1
X_257_ _040_ _035_ net25 VSS VSS VDD VDD _111_ sky130_fd_sc_hd__o21ai_0
X_258_ _040_ _035_ net12 _111_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__o31ai_1
X_259_ tx_shift\[0\] VSS VSS VDD VDD _112_ sky130_fd_sc_hd__inv_1
X_260_ net12 net4 _101_ VSS VSS VDD VDD _113_ sky130_fd_sc_hd__nand3_1
X_261_ _112_ _106_ _113_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__o21ai_0
X_262_ net5 tx_shift\[0\] _108_ VSS VSS VDD VDD _114_ sky130_fd_sc_hd__mux2i_1
X_263_ tx_shift\[1\] _106_ VSS VSS VDD VDD _115_ sky130_fd_sc_hd__nor2_1
X_264_ _106_ _114_ _115_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__a21oi_1
X_265_ net6 tx_shift\[1\] _108_ VSS VSS VDD VDD _116_ sky130_fd_sc_hd__mux2i_1
X_266_ tx_shift\[2\] _105_ VSS VSS VDD VDD _117_ sky130_fd_sc_hd__nor2_1
X_267_ _106_ _116_ _117_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__a21oi_1
X_268_ net7 tx_shift\[2\] _108_ VSS VSS VDD VDD _118_ sky130_fd_sc_hd__mux2i_1
X_269_ tx_shift\[3\] _105_ VSS VSS VDD VDD _119_ sky130_fd_sc_hd__nor2_1
X_270_ _106_ _118_ _119_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__a21oi_1
X_271_ net8 tx_shift\[3\] _108_ VSS VSS VDD VDD _120_ sky130_fd_sc_hd__mux2i_1
X_272_ tx_shift\[4\] _105_ VSS VSS VDD VDD _121_ sky130_fd_sc_hd__nor2_1
X_273_ _106_ _120_ _121_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__a21oi_1
X_274_ net9 tx_shift\[4\] _108_ VSS VSS VDD VDD _122_ sky130_fd_sc_hd__mux2i_1
X_275_ tx_shift\[5\] _105_ VSS VSS VDD VDD _123_ sky130_fd_sc_hd__nor2_1
X_276_ _106_ _122_ _123_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__a21oi_1
X_277_ net10 tx_shift\[5\] _108_ VSS VSS VDD VDD _124_ sky130_fd_sc_hd__mux2i_1
X_278_ tx_shift\[6\] _105_ VSS VSS VDD VDD _125_ sky130_fd_sc_hd__nor2_1
X_279_ _106_ _124_ _125_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__a21oi_1
X_280_ _127_ _128_ VSS VSS VDD VDD _129_ _130_ sky130_fd_sc_hd__ha_2
X_281_ bit_count\[3\] _128_ VSS VSS VDD VDD _131_ _132_ sky130_fd_sc_hd__ha_1
X_282_ bit_count\[3\] _133_ VSS VSS VDD VDD _134_ _135_ sky130_fd_sc_hd__ha_1
X_283_ _127_ _136_ VSS VSS VDD VDD _137_ _138_ sky130_fd_sc_hd__ha_1
X_284_ _127_ _139_ VSS VSS VDD VDD _140_ _141_ sky130_fd_sc_hd__ha_1
X_285_ bit_count\[0\] bit_count\[1\] VSS VSS VDD VDD _142_
+ _143_ sky130_fd_sc_hd__ha_1
X_286_ _127_ _144_ VSS VSS VDD VDD _145_ _146_ sky130_fd_sc_hd__ha_1
Xbit_count\[0\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _000_ net1
+ VSS VSS VDD VDD bit_count\[0\] sky130_fd_sc_hd__dfrtp_2
Xbit_count\[1\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _001_ net1
+ VSS VSS VDD VDD bit_count\[1\] sky130_fd_sc_hd__dfrtp_1
Xbit_count\[2\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _002_ net1
+ VSS VSS VDD VDD bit_count\[2\] sky130_fd_sc_hd__dfrtp_1
Xbit_count\[3\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _003_ net1
+ VSS VSS VDD VDD bit_count\[3\] sky130_fd_sc_hd__dfrtp_1
Xdebug_miso_samples\[0\]$_DFFE_PN0P_ clknet_2_2__leaf_clk
+ _004_ net1 VSS VSS VDD VDD debug_miso_samples\[0\] sky130_fd_sc_hd__dfrtp_1
Xdebug_miso_samples\[1\]$_DFFE_PN0P_ clknet_2_3__leaf_clk
+ _005_ net1 VSS VSS VDD VDD debug_miso_samples\[1\] sky130_fd_sc_hd__dfrtp_1
Xdebug_miso_samples\[2\]$_DFFE_PN0P_ clknet_2_2__leaf_clk
+ _006_ net1 VSS VSS VDD VDD debug_miso_samples\[2\] sky130_fd_sc_hd__dfrtp_1
Xdebug_miso_samples\[3\]$_DFFE_PN0P_ clknet_2_2__leaf_clk
+ _007_ net1 VSS VSS VDD VDD debug_miso_samples\[3\] sky130_fd_sc_hd__dfrtp_1
Xdebug_miso_samples\[4\]$_DFFE_PN0P_ clknet_2_2__leaf_clk
+ _008_ net1 VSS VSS VDD VDD debug_miso_samples\[4\] sky130_fd_sc_hd__dfrtp_1
Xdebug_miso_samples\[5\]$_DFFE_PN0P_ clknet_2_3__leaf_clk
+ _009_ net1 VSS VSS VDD VDD debug_miso_samples\[5\] sky130_fd_sc_hd__dfrtp_1
Xdebug_miso_samples\[6\]$_DFFE_PN0P_ clknet_2_2__leaf_clk
+ _010_ net1 VSS VSS VDD VDD debug_miso_samples\[6\] sky130_fd_sc_hd__dfrtp_1
Xdebug_miso_samples\[7\]$_DFFE_PN0P_ clknet_2_2__leaf_clk
+ _011_ net1 VSS VSS VDD VDD debug_miso_samples\[7\] sky130_fd_sc_hd__dfrtp_1
Xrx_data\[0\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _012_ net1
+ VSS VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[1\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _013_ net1
+ VSS VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[2\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _014_ net1
+ VSS VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[3\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _015_ net1
+ VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[4\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _016_ net1
+ VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[5\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _017_ net1
+ VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[6\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _018_ net1
+ VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[7\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _019_ net1
+ VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xrx_valid$_DFFE_PN0P_ clknet_2_3__leaf_clk _020_ net1 VSS
+ VSS VDD VDD net21 sky130_fd_sc_hd__dfrtp_1
Xspi_clk$_DFFE_PN0P_ clknet_2_0__leaf_clk _021_ net1 VSS VSS
+ VDD VDD net22 sky130_fd_sc_hd__dfrtp_1
Xspi_cs_n$_DFFE_PN1P_ clknet_2_0__leaf_clk _022_ net2 VSS
+ VSS VDD VDD net23 sky130_fd_sc_hd__dfstp_1
Xspi_mosi$_DFFE_PN0P_ clknet_2_3__leaf_clk _023_ net1 VSS
+ VSS VDD VDD net24 sky130_fd_sc_hd__dfrtp_1
Xstate\[0\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _024_ net1 VSS
+ VSS VDD VDD state\[0\] sky130_fd_sc_hd__dfrtp_1
Xstate\[1\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _025_ net1 VSS
+ VSS VDD VDD state\[1\] sky130_fd_sc_hd__dfrtp_4
Xtx_ready$_DFFE_PN1P_ clknet_2_0__leaf_clk _026_ net2 VSS
+ VSS VDD VDD net25 sky130_fd_sc_hd__dfstp_1
Xtx_shift\[0\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _027_ net1
+ VSS VSS VDD VDD tx_shift\[0\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[1\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _028_ net1
+ VSS VSS VDD VDD tx_shift\[1\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[2\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _029_ net1
+ VSS VSS VDD VDD tx_shift\[2\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[3\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _030_ net1
+ VSS VSS VDD VDD tx_shift\[3\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[4\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _031_ net1
+ VSS VSS VDD VDD tx_shift\[4\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[5\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _032_ net1
+ VSS VSS VDD VDD tx_shift\[5\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[6\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _033_ net1
+ VSS VSS VDD VDD tx_shift\[6\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net2 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_12
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 net26 VSS VSS VDD VDD net2 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput2 spi_miso VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 tx_data[0] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 tx_data[1] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 tx_data[2] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 tx_data[3] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 tx_data[4] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 tx_data[5] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 tx_data[6] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 tx_data[7] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 tx_valid VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_2
Xoutput12 net13 VSS VSS VDD VDD rx_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD rx_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD rx_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD rx_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD rx_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD rx_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD rx_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD rx_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net21 VSS VSS VDD VDD rx_valid sky130_fd_sc_hd__clkbuf_1
Xoutput21 net22 VSS VSS VDD VDD spi_clk sky130_fd_sc_hd__clkbuf_1
Xoutput22 net23 VSS VSS VDD VDD spi_cs_n sky130_fd_sc_hd__clkbuf_1
Xoutput23 net24 VSS VSS VDD VDD spi_mosi sky130_fd_sc_hd__clkbuf_1
Xoutput24 net25 VSS VSS VDD VDD tx_ready sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_2_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xclkload1 clknet_2_1__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkinv_2
Xclkload2 clknet_2_2__leaf_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__clkbuf_8
Xhold2 rst_n VSS VSS VDD VDD net26 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS spi_master
