* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_updown_counter clk count[0] count[1]
+ count[2] count[3] enable overflow rst_n up_down
X_30_ net3 VSS VSS VDD VDD _24_ sky130_fd_sc_hd__inv_1
X_31_ net4 VSS VSS VDD VDD _25_ sky130_fd_sc_hd__inv_1
X_32_ net2 _26_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__nand2b_1
X_33_ enable VSS VSS VDD VDD _06_ sky130_fd_sc_hd__buf_2
X_34_ net5 net6 _05_ _06_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__o31a_1
X_35_ net5 net6 _28_ net2 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__nand4_1
X_36_ net3 _08_ _06_ VSS VSS VDD VDD _09_ sky130_fd_sc_hd__mux2i_1
X_37_ net3 _07_ _09_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__a21oi_1
X_38_ net2 _27_ VSS VSS VDD VDD _10_ sky130_fd_sc_hd__xnor2_1
X_39_ _06_ _10_ VSS VSS VDD VDD _11_ sky130_fd_sc_hd__nand2_1
X_40_ _25_ _06_ _11_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__o21ai_0
X_41_ _28_ net2 VSS VSS VDD VDD _12_ sky130_fd_sc_hd__nand2_1
X_42_ _05_ _12_ _06_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__a21bo_1
X_43_ net5 _13_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__xnor2_1
X_44_ net5 net4 net3 VSS VSS VDD VDD _14_ sky130_fd_sc_hd__nor3_1
X_45_ net6 net2 _14_ VSS VSS VDD VDD _15_ sky130_fd_sc_hd__nor3_1
X_46_ net5 VSS VSS VDD VDD _16_ sky130_fd_sc_hd__clkinv_2
X_47_ net4 net3 VSS VSS VDD VDD _17_ sky130_fd_sc_hd__nand2_1
X_48_ _16_ net6 _17_ _06_ net2 VSS VSS VDD VDD _18_ sky130_fd_sc_hd__o311a_1
X_49_ net4 net3 _28_ VSS VSS VDD VDD _19_ sky130_fd_sc_hd__a21oi_1
X_50_ _16_ _19_ net6 VSS VSS VDD VDD _20_ sky130_fd_sc_hd__o21ai_0
X_51_ net2 _06_ net6 VSS VSS VDD VDD _21_ sky130_fd_sc_hd__and3b_1
X_52_ _14_ _21_ net6 _06_ VSS VSS VDD VDD _22_ sky130_fd_sc_hd__o2bb2ai_1
X_53_ _07_ _15_ _18_ _20_ _22_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__a221oi_1
X_54_ _06_ net7 VSS VSS VDD VDD _23_ sky130_fd_sc_hd__nor2_1
X_55_ _07_ _08_ _23_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__a21oi_1
X_56_ _24_ _25_ VSS VSS VDD VDD _26_ _27_ sky130_fd_sc_hd__ha_1
X_57_ net3 net4 VSS VSS VDD VDD _28_ _29_ sky130_fd_sc_hd__ha_1
Xcounter_reg\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _00_ net1
+ VSS VSS VDD VDD net3 sky130_fd_sc_hd__dfrtp_2
Xcounter_reg\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _01_ net1
+ VSS VSS VDD VDD net4 sky130_fd_sc_hd__dfrtp_2
Xcounter_reg\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _02_ net1
+ VSS VSS VDD VDD net5 sky130_fd_sc_hd__dfrtp_2
Xcounter_reg\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _03_ net1
+ VSS VSS VDD VDD net6 sky130_fd_sc_hd__dfrtp_2
Xoverflow_reg$_DFFE_PN0P_ clknet_1_0__leaf_clk _04_ net1 VSS
+ VSS VDD VDD net7 sky130_fd_sc_hd__dfrtp_1
Xhold1 net8 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 up_down VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xoutput2 net3 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput3 net4 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput4 net5 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net6 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput6 net7 VSS VSS VDD VDD overflow sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net8 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_updown_counter
