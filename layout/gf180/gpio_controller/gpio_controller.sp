* cell gpio_controller
* pin gpio_in[15]
* pin gpio_pins[15]
* pin int_type[13]
* pin int_enable[13]
* pin int_polarity[13]
* pin int_type[15]
* pin int_clear[13]
* pin int_enable[15]
* pin int_polarity[15]
* pin int_clear[15]
* pin gpio_out[12]
* pin gpio_pins[12]
* pin gpio_in[12]
* pin int_status[13]
* pin int_status[15]
* pin int_polarity[6]
* pin int_clear[6]
* pin int_status[12]
* pin int_status[6]
* pin int_enable[6]
* pin gpio_out[17]
* pin int_clear[12]
* pin int_type[6]
* pin gpio_in[17]
* pin gpio_pins[17]
* pin int_enable[12]
* pin int_type[12]
* pin int_polarity[12]
* pin gpio_out[23]
* pin gpio_out[31]
* pin gpio_pins[23]
* pin gpio_in[23]
* pin gpio_in[31]
* pin gpio_pins[31]
* pin gpio_out[25]
* pin gpio_pins[25]
* pin rst_n
* pin gpio_in[25]
* pin gpio_out[28]
* pin gpio_in[28]
* pin gpio_pins[28]
* pin int_polarity[31]
* pin int_enable[31]
* pin int_type[31]
* pin int_clear[31]
* pin int_status[31]
* pin int_enable[28]
* pin int_status[28]
* pin int_enable[30]
* pin int_type[30]
* pin int_clear[28]
* pin int_type[28]
* pin int_polarity[30]
* pin int_clear[30]
* pin int_polarity[28]
* pin int_status[30]
* pin gpio_pins[30]
* pin gpio_out[30]
* pin gpio_in[30]
* pin gpio_out[13]
* pin gpio_in[13]
* pin gpio_pins[13]
* pin gpio_in[14]
* pin int_type[14]
* pin int_clear[14]
* pin gpio_out[14]
* pin gpio_out[15]
* pin int_enable[14]
* pin int_polarity[14]
* pin gpio_pins[14]
* pin int_clear[25]
* pin gpio_pins[4]
* pin int_enable[25]
* pin int_type[25]
* pin int_enable[22]
* pin int_status[25]
* pin int_polarity[4]
* pin gpio_out[4]
* pin int_enable[4]
* pin int_polarity[25]
* pin gpio_in[4]
* pin int_status[14]
* pin int_clear[4]
* pin int_polarity[22]
* pin int_clear[22]
* pin gpio_in[22]
* pin int_type[4]
* pin int_polarity[23]
* pin int_clear[5]
* pin gpio_in[6]
* pin gpio_out[6]
* pin int_type[5]
* pin int_type[23]
* pin int_enable[23]
* pin int_type[22]
* pin gpio_out[22]
* pin int_status[4]
* pin gpio_pins[6]
* pin gpio_out[5]
* pin int_polarity[5]
* pin gpio_out[18]
* pin gpio_pins[22]
* pin int_enable[5]
* pin gpio_in[18]
* pin int_status[22]
* pin int_status[5]
* pin int_clear[23]
* pin gpio_in[5]
* pin gpio_pins[5]
* pin int_status[7]
* pin int_type[17]
* pin int_status[23]
* pin gpio_in[3]
* pin gpio_pins[3]
* pin int_clear[7]
* pin int_polarity[18]
* pin gpio_pins[18]
* pin int_enable[17]
* pin int_clear[18]
* pin gpio_out[3]
* pin int_enable[7]
* pin int_enable[18]
* pin int_status[17]
* pin int_polarity[17]
* pin int_clear[17]
* pin int_type[18]
* pin int_polarity[7]
* pin int_polarity[3]
* pin int_status[20]
* pin int_status[18]
* pin int_type[3]
* pin int_type[7]
* pin clk
* pin int_clear[20]
* pin int_enable[3]
* pin gpio_out[7]
* pin gpio_in[7]
* pin gpio_pins[7]
* pin int_enable[20]
* pin int_type[20]
* pin int_out
* pin int_clear[3]
* pin int_status[3]
* pin int_polarity[20]
* pin int_status[1]
* pin int_clear[1]
* pin int_type[1]
* pin int_enable[1]
* pin int_polarity[1]
* pin int_status[2]
* pin int_polarity[21]
* pin int_enable[21]
* pin int_status[21]
* pin int_clear[21]
* pin int_type[21]
* pin gpio_out[21]
* pin gpio_pins[21]
* pin int_status[0]
* pin gpio_out[1]
* pin int_status[19]
* pin gpio_in[21]
* pin int_status[16]
* pin int_clear[0]
* pin gpio_pins[1]
* pin int_type[0]
* pin gpio_in[1]
* pin int_polarity[0]
* pin int_enable[0]
* pin gpio_out[0]
* pin int_enable[27]
* pin int_type[27]
* pin int_polarity[27]
* pin gpio_in[0]
* pin gpio_pins[0]
* pin int_enable[19]
* pin int_clear[27]
* pin int_type[19]
* pin gpio_pins[19]
* pin int_polarity[19]
* pin int_clear[19]
* pin int_type[10]
* pin gpio_out[10]
* pin gpio_in[19]
* pin gpio_out[19]
* pin int_status[27]
* pin int_enable[10]
* pin gpio_pins[10]
* pin gpio_in[10]
* pin int_polarity[10]
* pin int_clear[10]
* pin int_type[9]
* pin int_enable[16]
* pin gpio_out[16]
* pin int_clear[16]
* pin gpio_pins[27]
* pin gpio_in[16]
* pin gpio_pins[9]
* pin int_polarity[2]
* pin gpio_out[11]
* pin int_enable[24]
* pin int_enable[9]
* pin int_type[24]
* pin int_type[16]
* pin gpio_pins[11]
* pin gpio_in[11]
* pin int_enable[11]
* pin gpio_pins[16]
* pin int_polarity[16]
* pin int_type[8]
* pin gpio_in[8]
* pin int_clear[26]
* pin int_enable[29]
* pin int_polarity[24]
* pin gpio_out[27]
* pin gpio_pins[20]
* pin gpio_in[9]
* pin gpio_out[9]
* pin gpio_pins[8]
* pin int_polarity[8]
* pin int_clear[8]
* pin gpio_out[8]
* pin int_clear[29]
* pin int_status[29]
* pin int_status[10]
* pin int_type[26]
* pin gpio_pins[2]
* pin int_clear[9]
* pin int_status[9]
* pin gpio_out[24]
* pin int_enable[26]
* pin int_polarity[29]
* pin int_clear[24]
* pin int_polarity[9]
* pin gpio_in[26]
* pin gpio_in[20]
* pin gpio_pins[29]
* pin gpio_pins[26]
* pin int_enable[2]
* pin int_type[29]
* pin int_enable[8]
* pin int_status[24]
* pin int_status[26]
* pin int_polarity[26]
* pin int_clear[11]
* pin int_polarity[11]
* pin int_type[11]
* pin int_status[8]
* pin int_status[11]
* pin gpio_in[29]
* pin gpio_out[2]
* pin gpio_out[29]
* pin gpio_out[26]
* pin gpio_out[20]
* pin int_clear[2]
* pin int_type[2]
* pin gpio_in[24]
* pin gpio_in[2]
* pin gpio_pins[24]
* pin gpio_in[27]
* pin PWELL,gf180mcu_gnd
* pin NWELL
.SUBCKT gpio_controller 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47
+ 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 217 230
+ 232 233 234 238 241 249 251 253 258 259 260 262 263 264 269 276 279 280 281
+ 282 286 288 298 299 303 306 307 309 311 312 317 319 320 324 329 337 338 339
+ 344 345 350 352 353 356 360 361 370 373 374 380 381 382 383 392 398 399 407
+ 408 411 412 414 416 422 423 430 431 433 434 440 441 442 449 455 456 464 465
+ 466 469 472 474 475 476 477 485 486 492 493 499 500 501 506 507 508 509 518
+ 519 520 521 523 524 525 526 536 537 539 550 551 552 557 558 565 566 567 572
+ 573 574 575 583 645 653 674 676 679 690 702 704 712 718 725 726 732 734 735
+ 737 748 749 750 751 753 756 757 758 759 760 764 769 770 772 773 774 775 776
+ 777 778 779 780 781 782 783 784 785 786 787 788 789 790 791 792 793 794 795
+ 796 797 798 799 800 801 802 803 804 805 806 807 808 809 810 811 812 813
* net 1 gpio_in[15]
* net 2 gpio_pins[15]
* net 3 int_type[13]
* net 4 int_enable[13]
* net 5 int_polarity[13]
* net 6 int_type[15]
* net 7 int_clear[13]
* net 8 int_enable[15]
* net 9 int_polarity[15]
* net 10 int_clear[15]
* net 11 gpio_out[12]
* net 12 gpio_pins[12]
* net 13 gpio_in[12]
* net 14 int_status[13]
* net 15 int_status[15]
* net 16 int_polarity[6]
* net 17 int_clear[6]
* net 18 int_status[12]
* net 19 int_status[6]
* net 20 int_enable[6]
* net 21 gpio_out[17]
* net 22 int_clear[12]
* net 23 int_type[6]
* net 24 gpio_in[17]
* net 25 gpio_pins[17]
* net 26 int_enable[12]
* net 27 int_type[12]
* net 28 int_polarity[12]
* net 29 gpio_out[23]
* net 30 gpio_out[31]
* net 31 gpio_pins[23]
* net 32 gpio_in[23]
* net 33 gpio_in[31]
* net 34 gpio_pins[31]
* net 35 gpio_out[25]
* net 36 gpio_pins[25]
* net 37 rst_n
* net 38 gpio_in[25]
* net 39 gpio_out[28]
* net 40 gpio_in[28]
* net 41 gpio_pins[28]
* net 42 int_polarity[31]
* net 43 int_enable[31]
* net 44 int_type[31]
* net 45 int_clear[31]
* net 46 int_status[31]
* net 47 int_enable[28]
* net 48 int_status[28]
* net 49 int_enable[30]
* net 50 int_type[30]
* net 51 int_clear[28]
* net 52 int_type[28]
* net 53 int_polarity[30]
* net 54 int_clear[30]
* net 55 int_polarity[28]
* net 56 int_status[30]
* net 57 gpio_pins[30]
* net 58 gpio_out[30]
* net 59 gpio_in[30]
* net 60 gpio_out[13]
* net 61 gpio_in[13]
* net 62 gpio_pins[13]
* net 63 gpio_in[14]
* net 64 int_type[14]
* net 65 int_clear[14]
* net 66 gpio_out[14]
* net 67 gpio_out[15]
* net 68 int_enable[14]
* net 69 int_polarity[14]
* net 70 gpio_pins[14]
* net 217 int_clear[25]
* net 230 gpio_pins[4]
* net 232 int_enable[25]
* net 233 int_type[25]
* net 234 int_enable[22]
* net 238 int_status[25]
* net 241 int_polarity[4]
* net 249 gpio_out[4]
* net 251 int_enable[4]
* net 253 int_polarity[25]
* net 258 gpio_in[4]
* net 259 int_status[14]
* net 260 int_clear[4]
* net 262 int_polarity[22]
* net 263 int_clear[22]
* net 264 gpio_in[22]
* net 269 int_type[4]
* net 276 int_polarity[23]
* net 279 int_clear[5]
* net 280 gpio_in[6]
* net 281 gpio_out[6]
* net 282 int_type[5]
* net 286 int_type[23]
* net 288 int_enable[23]
* net 298 int_type[22]
* net 299 gpio_out[22]
* net 303 int_status[4]
* net 306 gpio_pins[6]
* net 307 gpio_out[5]
* net 309 int_polarity[5]
* net 311 gpio_out[18]
* net 312 gpio_pins[22]
* net 317 int_enable[5]
* net 319 gpio_in[18]
* net 320 int_status[22]
* net 324 int_status[5]
* net 329 int_clear[23]
* net 337 gpio_in[5]
* net 338 gpio_pins[5]
* net 339 int_status[7]
* net 344 int_type[17]
* net 345 int_status[23]
* net 350 gpio_in[3]
* net 352 gpio_pins[3]
* net 353 int_clear[7]
* net 356 int_polarity[18]
* net 360 gpio_pins[18]
* net 361 int_enable[17]
* net 370 int_clear[18]
* net 373 gpio_out[3]
* net 374 int_enable[7]
* net 380 int_enable[18]
* net 381 int_status[17]
* net 382 int_polarity[17]
* net 383 int_clear[17]
* net 392 int_type[18]
* net 398 int_polarity[7]
* net 399 int_polarity[3]
* net 407 int_status[20]
* net 408 int_status[18]
* net 411 int_type[3]
* net 412 int_type[7]
* net 414 clk
* net 416 int_clear[20]
* net 422 int_enable[3]
* net 423 gpio_out[7]
* net 430 gpio_in[7]
* net 431 gpio_pins[7]
* net 433 int_enable[20]
* net 434 int_type[20]
* net 440 int_out
* net 441 int_clear[3]
* net 442 int_status[3]
* net 449 int_polarity[20]
* net 455 int_status[1]
* net 456 int_clear[1]
* net 464 int_type[1]
* net 465 int_enable[1]
* net 466 int_polarity[1]
* net 469 int_status[2]
* net 472 int_polarity[21]
* net 474 int_enable[21]
* net 475 int_status[21]
* net 476 int_clear[21]
* net 477 int_type[21]
* net 485 gpio_out[21]
* net 486 gpio_pins[21]
* net 492 int_status[0]
* net 493 gpio_out[1]
* net 499 int_status[19]
* net 500 gpio_in[21]
* net 501 int_status[16]
* net 506 int_clear[0]
* net 507 gpio_pins[1]
* net 508 int_type[0]
* net 509 gpio_in[1]
* net 518 int_polarity[0]
* net 519 int_enable[0]
* net 520 gpio_out[0]
* net 521 int_enable[27]
* net 523 int_type[27]
* net 524 int_polarity[27]
* net 525 gpio_in[0]
* net 526 gpio_pins[0]
* net 536 int_enable[19]
* net 537 int_clear[27]
* net 539 int_type[19]
* net 550 gpio_pins[19]
* net 551 int_polarity[19]
* net 552 int_clear[19]
* net 557 int_type[10]
* net 558 gpio_out[10]
* net 565 gpio_in[19]
* net 566 gpio_out[19]
* net 567 int_status[27]
* net 572 int_enable[10]
* net 573 gpio_pins[10]
* net 574 gpio_in[10]
* net 575 int_polarity[10]
* net 583 int_clear[10]
* net 645 int_type[9]
* net 653 int_enable[16]
* net 674 gpio_out[16]
* net 676 int_clear[16]
* net 679 gpio_pins[27]
* net 690 gpio_in[16]
* net 702 gpio_pins[9]
* net 704 int_polarity[2]
* net 712 gpio_out[11]
* net 718 int_enable[24]
* net 725 int_enable[9]
* net 726 int_type[24]
* net 732 int_type[16]
* net 734 gpio_pins[11]
* net 735 gpio_in[11]
* net 737 int_enable[11]
* net 748 gpio_pins[16]
* net 749 int_polarity[16]
* net 750 int_type[8]
* net 751 gpio_in[8]
* net 753 int_clear[26]
* net 756 int_enable[29]
* net 757 int_polarity[24]
* net 758 gpio_out[27]
* net 759 gpio_pins[20]
* net 760 gpio_in[9]
* net 764 gpio_out[9]
* net 769 gpio_pins[8]
* net 770 int_polarity[8]
* net 772 int_clear[8]
* net 773 gpio_out[8]
* net 774 int_clear[29]
* net 775 int_status[29]
* net 776 int_status[10]
* net 777 int_type[26]
* net 778 gpio_pins[2]
* net 779 int_clear[9]
* net 780 int_status[9]
* net 781 gpio_out[24]
* net 782 int_enable[26]
* net 783 int_polarity[29]
* net 784 int_clear[24]
* net 785 int_polarity[9]
* net 786 gpio_in[26]
* net 787 gpio_in[20]
* net 788 gpio_pins[29]
* net 789 gpio_pins[26]
* net 790 int_enable[2]
* net 791 int_type[29]
* net 792 int_enable[8]
* net 793 int_status[24]
* net 794 int_status[26]
* net 795 int_polarity[26]
* net 796 int_clear[11]
* net 797 int_polarity[11]
* net 798 int_type[11]
* net 799 int_status[8]
* net 800 int_status[11]
* net 801 gpio_in[29]
* net 802 gpio_out[2]
* net 803 gpio_out[29]
* net 804 gpio_out[26]
* net 805 gpio_out[20]
* net 806 int_clear[2]
* net 807 int_type[2]
* net 808 gpio_in[24]
* net 809 gpio_in[2]
* net 810 gpio_pins[24]
* net 811 gpio_in[27]
* net 812 PWELL,gf180mcu_gnd
* net 813 NWELL
* cell instance $3 r0 *1 49.84,15.12
X$3 132 813 812 1 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7 r0 *1 44.8,25.2
X$7 120 813 812 2 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10 r0 *1 75.6,25.2
X$10 3 813 812 144 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14 r0 *1 58.8,5.04
X$14 4 813 812 78 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $18 m0 *1 77.84,25.2
X$18 5 813 812 121 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $22 m0 *1 72.24,35.28
X$22 6 813 812 184 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27 m0 *1 80.64,35.28
X$27 7 813 812 80 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $31 r0 *1 67.2,5.04
X$31 8 813 812 106 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $35 r0 *1 84,25.2
X$35 9 813 812 174 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $38 m0 *1 89.04,35.28
X$38 10 813 812 204 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $42 m0 *1 59.36,15.12
X$42 11 813 812 79 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $47 m0 *1 86.24,25.2
X$47 79 813 812 12 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $50 r0 *1 75.6,5.04
X$50 81 813 812 13 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $54 r0 *1 92.4,25.2
X$54 124 813 812 14 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $58 m0 *1 77.28,15.12
X$58 82 813 812 15 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $62 m0 *1 102.48,35.28
X$62 16 813 812 151 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67 m0 *1 94.08,15.12
X$67 17 813 812 84 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $71 r0 *1 92.4,15.12
X$71 125 813 812 18 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $74 r0 *1 84,5.04
X$74 83 813 812 19 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $79 r0 *1 106.96,25.2
X$79 20 813 812 156 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $82 r0 *1 92.4,5.04
X$82 21 813 812 85 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $87 r0 *1 102.48,5.04
X$87 22 813 812 87 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90 m0 *1 85.68,15.12
X$90 23 813 812 168 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $94 r0 *1 115.92,15.12
X$94 126 813 812 24 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99 m0 *1 109.76,15.12
X$99 85 813 812 25 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $103 r0 *1 110.88,5.04
X$103 26 813 812 110 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $106 r0 *1 119.28,5.04
X$106 27 813 812 89 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $111 m0 *1 118.16,15.12
X$111 28 813 812 88 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $115 r0 *1 136.08,5.04
X$115 29 813 812 91 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $119 r0 *1 127.68,5.04
X$119 30 813 812 90 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $123 r0 *1 124.32,15.12
X$123 91 813 812 31 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $127 m0 *1 160.16,15.12
X$127 94 813 812 32 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $131 r0 *1 132.72,15.12
X$131 127 813 812 33 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $134 m0 *1 126.56,15.12
X$134 90 813 812 34 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $138 m0 *1 134.96,15.12
X$138 35 813 812 93 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $142 r0 *1 161.28,5.04
X$142 93 813 812 36 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $147 r0 *1 138.88,25.2
X$147 812 186 37 813 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $151 r0 *1 152.88,5.04
X$151 113 813 812 38 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $154 m0 *1 143.36,15.12
X$154 39 813 812 92 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $158 m0 *1 168.56,15.12
X$158 115 813 812 40 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $163 r0 *1 145.04,15.12
X$163 92 813 812 41 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $167 r0 *1 169.68,5.04
X$167 42 813 812 141 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $170 r0 *1 178.08,5.04
X$170 43 813 812 95 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $174 m0 *1 176.96,15.12
X$174 44 813 812 116 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $178 r0 *1 186.48,5.04
X$178 45 813 812 96 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $182 r0 *1 218.4,5.04
X$182 100 813 812 46 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $186 r0 *1 210,5.04
X$186 47 813 812 162 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $191 r0 *1 220.08,15.12
X$191 101 813 812 48 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $194 m0 *1 218.4,25.2
X$194 49 813 812 109 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $199 r0 *1 228.48,15.12
X$199 50 813 812 131 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $202 m0 *1 220.08,35.28
X$202 51 813 812 102 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $207 r0 *1 226.8,5.04
X$207 52 813 812 104 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $211 m0 *1 185.36,15.12
X$211 53 813 812 112 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $215 r0 *1 216.16,35.28
X$215 54 813 812 147 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $219 m0 *1 228.48,35.28
X$219 55 813 812 148 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $223 r0 *1 201.6,5.04
X$223 98 813 812 56 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $227 m0 *1 229.6,15.12
X$227 103 813 812 57 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $230 r0 *1 226.24,35.28
X$230 58 813 812 103 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $234 m0 *1 226.8,25.2
X$234 133 813 812 59 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $238 m0 *1 2.24,25.2
X$238 60 813 812 118 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $241 r0 *1 11.76,25.2
X$241 142 813 812 61 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $246 r0 *1 15.12,15.12
X$246 118 813 812 62 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $249 r0 *1 24.08,5.04
X$249 75 813 812 63 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $252 r0 *1 10.64,5.04
X$252 64 813 812 73 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $255 r0 *1 2.24,5.04
X$255 65 813 812 71 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $258 m0 *1 10.64,15.12
X$258 66 813 812 74 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $261 m0 *1 29.12,15.12
X$261 67 813 812 120 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $264 m0 *1 2.24,15.12
X$264 68 813 812 72 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $267 r0 *1 2.24,15.12
X$267 69 813 812 117 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $270 m0 *1 19.04,15.12
X$270 74 813 812 70 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $274 m0 *1 7.84,45.36
X$274 812 71 813 201 202 208 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $277 r0 *1 7.84,35.28
X$277 813 72 812 197 202 172 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $279 r0 *1 2.24,25.2
X$279 152 73 153 197 117 813 812 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $281 m0 *1 10.64,25.2
X$281 812 813 73 180 143 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $287 m0 *1 16.24,35.28
X$287 812 111 181 119 74 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $289 r0 *1 19.04,5.04
X$289 74 813 812 75 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $295 r0 *1 24.08,15.12
X$295 812 111 76 119 118 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $297 m0 *1 39.2,15.12
X$297 812 111 77 119 76 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $299 m0 *1 45.92,25.2
X$299 812 111 145 119 77 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $301 r0 *1 61.6,25.2
X$301 77 813 121 154 812 166 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $303 r0 *1 60.48,15.12
X$303 144 135 121 122 77 813 812 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $311 r0 *1 67.76,25.2
X$311 813 78 812 122 123 166 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $315 r0 *1 81.76,55.44
X$315 812 111 239 136 79 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $318 m0 *1 69.44,25.2
X$318 79 813 812 81 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $324 m0 *1 67.76,15.12
X$324 812 80 813 105 123 137 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $331 m0 *1 86.24,45.36
X$331 83 124 125 82 813 812 218 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $334 m0 *1 97.44,35.28
X$334 812 813 82 175 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $338 r0 *1 79.52,35.28
X$338 812 111 82 136 199 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $342 m0 *1 102.48,15.12
X$342 812 83 813 140 86 155 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $347 m0 *1 94.64,25.2
X$347 812 111 83 136 139 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $356 r0 *1 101.92,15.12
X$356 812 813 139 84 140 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $358 m0 *1 125.44,85.68
X$358 812 111 296 244 85 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $362 r0 *1 107.52,15.12
X$362 85 813 812 126 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $370 r0 *1 115.36,25.2
X$370 813 156 170 812 86 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $375 m0 *1 108.64,45.36
X$375 812 87 813 210 211 177 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $378 r0 *1 120.96,35.28
X$378 223 813 88 191 812 200 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $380 r0 *1 114.8,45.36
X$380 89 220 88 205 223 813 812 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $384 m0 *1 123.76,45.36
X$384 812 813 206 191 89 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $388 m0 *1 129.92,35.28
X$388 812 111 187 128 90 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $390 m0 *1 127.68,25.2
X$390 90 813 812 127 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $396 m0 *1 132.72,65.52
X$396 812 111 257 244 91 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $401 r0 *1 144.48,5.04
X$401 91 813 812 94 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $407 m0 *1 148.96,25.2
X$407 812 111 149 128 92 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $411 m0 *1 151.76,15.12
X$411 92 813 812 115 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $415 m0 *1 151.2,45.36
X$415 812 111 207 128 93 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $419 m0 *1 138.88,25.2
X$419 93 813 812 113 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $433 m0 *1 177.52,35.28
X$433 813 95 171 812 185 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $437 m0 *1 193.76,15.12
X$437 812 813 138 96 114 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $439 r0 *1 197.12,35.28
X$439 812 111 194 97 192 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $442 r0 *1 194.88,45.36
X$442 812 111 179 97 228 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $444 r0 *1 213.92,25.2
X$444 812 111 98 97 161 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $446 r0 *1 188.16,55.44
X$446 812 111 236 97 229 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $448 r0 *1 190.96,15.12
X$448 812 111 130 97 129 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $450 m0 *1 190.96,65.52
X$450 812 813 97 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $452 r0 *1 178.08,35.28
X$452 812 111 192 97 103 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $455 m0 *1 203.84,15.12
X$455 812 111 101 97 107 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $457 m0 *1 201.6,45.36
X$457 812 111 195 97 194 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $459 r0 *1 193.2,65.52
X$459 812 111 267 97 275 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $461 m0 *1 201.6,65.52
X$461 812 224 97 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $472 r0 *1 221.2,45.36
X$472 812 98 813 165 108 183 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $474 m0 *1 202.16,35.28
X$474 179 101 100 98 813 812 193 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $483 r0 *1 194.88,5.04
X$483 813 109 99 812 108 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $485 m0 *1 210.56,35.28
X$485 813 194 112 812 99 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $489 r0 *1 181.44,25.2
X$489 812 100 813 114 185 159 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $493 r0 *1 171.92,15.12
X$493 812 111 100 128 138 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $502 r0 *1 203.84,25.2
X$502 812 101 813 134 169 160 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $508 m0 *1 222.88,15.12
X$508 812 813 107 102 134 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $514 r0 *1 211.68,15.12
X$514 103 813 812 133 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $523 r0 *1 193.76,25.2
X$523 812 813 104 160 167 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $530 r0 *1 71.12,15.12
X$530 812 111 124 136 105 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $535 m0 *1 78.4,45.36
X$535 813 106 812 189 190 203 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $551 m0 *1 115.92,45.36
X$551 813 110 812 205 211 200 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $557 r0 *1 134.4,55.44
X$557 812 186 111 813 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $560 r0 *1 26.88,85.68
X$560 812 111 314 261 294 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $562 r0 *1 210.56,226.8
X$562 812 111 710 588 688 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $564 r0 *1 199.36,216.72
X$564 812 111 687 588 675 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $567 m0 *1 207.2,216.72
X$567 812 111 688 588 687 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $569 r0 *1 178.08,216.72
X$569 812 111 686 588 715 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $571 m0 *1 7.84,95.76
X$571 812 111 318 261 331 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $573 m0 *1 15.12,75.6
X$573 812 111 283 261 273 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $578 r0 *1 26.32,105.84
X$578 812 111 340 261 385 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $580 m0 *1 36.96,95.76
X$580 812 111 334 261 310 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $583 r0 *1 185.36,105.84
X$583 812 111 359 284 369 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $586 r0 *1 47.6,216.72
X$586 812 111 700 594 713 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $588 m0 *1 49.28,226.8
X$588 812 111 723 594 722 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $591 r0 *1 10.64,146.16
X$591 812 111 511 426 510 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $594 r0 *1 2.24,136.08
X$594 812 111 494 426 487 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $596 r0 *1 204.96,95.76
X$596 812 111 327 284 347 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $598 r0 *1 71.68,206.64
X$598 812 111 666 586 644 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $600 m0 *1 58.24,206.64
X$600 812 111 644 586 635 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $602 m0 *1 59.36,45.36
X$602 812 111 214 136 188 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $605 m0 *1 84,226.8
X$605 812 111 701 586 740 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $607 m0 *1 89.6,216.72
X$607 812 111 682 586 666 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $610 m0 *1 218.96,126
X$610 812 111 405 435 387 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $612 r0 *1 47.6,35.28
X$612 812 111 188 119 173 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $614 m0 *1 90.16,176.4
X$614 812 111 495 443 603 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $616 r0 *1 36.96,146.16
X$616 812 111 516 426 527 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $620 m0 *1 41.44,136.08
X$620 812 111 463 426 425 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $624 m0 *1 19.04,126
X$624 812 111 428 426 427 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $626 r0 *1 173.6,115.92
X$626 812 111 378 284 421 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $628 m0 *1 180.32,115.92
X$628 812 111 420 284 377 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $632 r0 *1 12.88,196.56
X$632 812 111 627 594 654 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $634 m0 *1 2.8,186.48
X$634 812 111 600 594 592 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $636 m0 *1 12.88,216.72
X$636 812 111 680 594 627 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $638 r0 *1 2.24,206.64
X$638 812 111 654 594 661 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $640 m0 *1 8.96,206.64
X$640 812 111 641 594 634 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $644 m0 *1 2.8,176.4
X$644 812 111 545 594 559 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $646 r0 *1 62.72,186.48
X$646 812 111 618 586 607 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $648 m0 *1 54.88,196.56
X$648 812 111 620 586 606 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $653 r0 *1 170.24,45.36
X$653 812 111 229 128 207 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $655 m0 *1 99.12,186.48
X$655 812 111 604 586 596 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $657 m0 *1 28,206.64
X$657 812 111 656 594 641 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $659 r0 *1 36.4,206.64
X$659 812 111 665 594 656 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $662 m0 *1 28,186.48
X$662 812 111 562 426 600 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $664 r0 *1 154.56,25.2
X$664 812 111 157 128 178 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $666 m0 *1 35.28,166.32
X$666 812 111 531 426 545 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $668 r0 *1 33.04,156.24
X$668 812 111 544 426 531 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $671 r0 *1 81.76,186.48
X$671 812 111 596 586 618 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $673 r0 *1 42,176.4
X$673 812 111 553 443 562 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $675 m0 *1 129.36,196.56
X$675 812 111 625 610 623 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $678 m0 *1 134.96,206.64
X$678 812 111 659 610 637 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $680 m0 *1 106.4,206.64
X$680 812 111 643 586 636 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $682 r0 *1 120.96,196.56
X$682 812 111 637 610 643 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $684 r0 *1 47.04,85.68
X$684 812 111 310 261 314 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $686 m0 *1 151.76,75.6
X$686 812 111 278 244 257 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $688 r0 *1 64.4,105.84
X$688 812 111 368 252 388 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $690 m0 *1 67.76,115.92
X$690 812 111 397 252 368 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $692 r0 *1 146.16,176.4
X$692 812 111 547 470 587 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $697 r0 *1 142.24,196.56
X$697 812 111 611 610 629 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $700 m0 *1 161.28,105.84
X$700 812 111 366 284 302 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $702 r0 *1 157.36,95.76
X$702 812 111 349 244 323 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $705 m0 *1 148.4,196.56
X$705 812 111 624 470 625 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $708 r0 *1 45.36,105.84
X$708 812 111 388 261 351 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $710 r0 *1 157.36,186.48
X$710 812 111 630 610 611 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $713 m0 *1 141.12,95.76
X$713 812 111 323 244 296 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $715 r0 *1 199.92,196.56
X$715 812 111 497 588 655 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $717 r0 *1 213.36,186.48
X$717 812 111 613 588 589 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $719 m0 *1 205.52,186.48
X$719 812 111 597 588 570 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $722 r0 *1 169.12,196.56
X$722 812 111 642 610 630 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $724 m0 *1 175.84,196.56
X$724 812 111 631 588 624 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $726 m0 *1 181.44,186.48
X$726 812 111 612 588 564 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $728 r0 *1 194.32,186.48
X$728 812 111 589 588 612 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $730 m0 *1 26.32,55.44
X$730 812 111 221 119 225 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $733 m0 *1 35.28,35.28
X$733 812 111 173 119 120 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $736 r0 *1 30.8,55.44
X$736 812 111 237 119 221 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $740 r0 *1 9.52,45.36
X$740 812 111 212 119 201 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $742 r0 *1 47.6,65.52
X$742 812 111 243 252 271 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $744 m0 *1 166.88,216.72
X$744 812 111 649 610 658 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $747 m0 *1 170.24,25.2
X$747 812 111 129 128 149 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $749 m0 *1 150.08,226.8
X$749 812 111 672 610 743 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $751 m0 *1 7.28,55.44
X$751 812 111 225 119 240 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $754 m0 *1 65.52,65.52
X$754 812 111 150 252 243 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $757 m0 *1 84.56,65.52
X$757 812 111 222 252 150 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $760 r0 *1 101.92,35.28
X$760 812 111 125 128 210 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $762 m0 *1 181.44,75.6
X$762 812 111 275 284 274 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $764 m0 *1 173.04,85.68
X$764 812 111 297 284 278 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $766 r0 *1 170.24,75.6
X$766 812 111 274 284 245 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $768 r0 *1 51.52,136.08
X$768 812 111 490 443 482 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $770 m0 *1 57.68,126
X$770 812 111 415 443 403 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $776 r0 *1 171.92,156.24
X$776 812 111 543 435 548 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $778 r0 *1 48.16,126
X$778 812 111 403 443 463 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $780 m0 *1 114.24,55.44
X$780 812 111 206 136 223 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $783 r0 *1 189.28,146.16
X$783 812 111 515 435 512 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $786 r0 *1 56,146.16
X$786 812 111 482 443 516 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $789 r0 *1 189.28,136.08
X$789 812 111 471 435 491 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $791 r0 *1 169.12,146.16
X$791 812 111 517 435 498 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $793 m0 *1 179.2,146.16
X$793 812 111 512 435 517 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $796 m0 *1 144.48,146.16
X$796 812 111 458 470 496 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $798 r0 *1 166.32,105.84
X$798 812 111 377 244 366 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $801 m0 *1 148.96,35.28
X$801 812 111 178 128 187 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $803 m0 *1 208.88,85.68
X$803 812 111 301 284 285 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $805 r0 *1 21.84,25.2
X$805 812 111 153 119 181 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $808 m0 *1 160.72,166.32
X$808 812 111 548 470 547 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $810 m0 *1 128.8,156.24
X$810 812 111 496 470 532 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $812 m0 *1 17.36,25.2
X$812 812 111 143 119 153 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $815 m0 *1 216.16,166.32
X$815 812 111 483 435 569 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $817 r0 *1 101.92,55.44
X$817 812 111 223 136 239 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $819 m0 *1 159.6,136.08
X$819 812 111 481 470 458 813 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $976 r0 *1 173.6,25.2
X$976 812 813 116 159 158 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $981 m0 *1 7.84,35.28
X$981 153 813 117 180 812 172 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $990 r0 *1 10.64,15.12
X$990 118 813 812 142 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $1012 m0 *1 36.96,65.52
X$1012 812 224 119 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1028 r0 *1 44.24,15.12
X$1028 120 813 812 132 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $1045 r0 *1 83.44,45.36
X$1045 812 813 124 137 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1054 m0 *1 110.88,35.28
X$1054 812 813 125 177 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1072 m0 *1 150.64,55.44
X$1072 812 813 128 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $1078 m0 *1 155.12,55.44
X$1078 812 224 128 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1090 m0 *1 190.96,25.2
X$1090 813 129 148 812 146 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1094 m0 *1 202.16,25.2
X$1094 813 129 130 812 167 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1101 m0 *1 195.44,35.28
X$1101 812 813 131 183 182 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1120 m0 *1 65.52,25.2
X$1120 812 813 145 135 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1128 r0 *1 79.52,65.52
X$1128 812 224 136 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1139 m0 *1 82.32,75.6
X$1139 812 813 136 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $1164 r0 *1 161.28,15.12
X$1164 813 178 141 812 171 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1170 m0 *1 4.48,35.28
X$1170 812 813 143 152 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1178 r0 *1 56.56,25.2
X$1178 812 813 145 154 144 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1189 r0 *1 198.8,25.2
X$1189 813 162 146 812 169 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1192 m0 *1 212.24,25.2
X$1192 812 813 161 147 165 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1206 m0 *1 115.36,25.2
X$1206 813 150 151 812 170 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1208 m0 *1 98,55.44
X$1208 813 150 222 812 176 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1236 r0 *1 101.92,25.2
X$1236 812 813 168 155 176 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1241 m0 *1 168,35.28
X$1241 813 178 157 812 158 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1259 r0 *1 232.96,25.2
X$1259 813 163 196 812 164 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1261 m0 *1 221.2,55.44
X$1261 232 813 812 163 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1263 r0 *1 213.92,45.36
X$1263 812 179 813 227 164 198 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1300 r0 *1 77.28,45.36
X$1300 188 813 174 215 812 203 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1302 r0 *1 70,35.28
X$1302 213 184 188 189 174 813 812 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1308 m0 *1 94.64,45.36
X$1308 812 204 813 199 190 175 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1325 m0 *1 192.08,55.44
X$1325 179 813 812 238 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1342 m0 *1 224.56,45.36
X$1342 813 194 195 812 182 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1349 r0 *1 72.24,45.36
X$1349 812 813 184 215 214 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1389 r0 *1 204.4,126
X$1389 389 451 193 446 813 812 445 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1406 r0 *1 218.4,55.44
X$1406 813 229 248 812 196 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1414 m0 *1 195.44,45.36
X$1414 812 813 209 198 219 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1437 r0 *1 124.32,45.36
X$1437 812 813 206 220 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1447 m0 *1 15.12,45.36
X$1447 812 813 212 208 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1452 m0 *1 229.6,55.44
X$1452 233 813 812 209 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1463 r0 *1 27.44,95.76
X$1463 318 283 340 212 813 812 333 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1466 r0 *1 15.12,65.52
X$1466 212 813 812 259 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1474 r0 *1 68.32,45.36
X$1474 812 813 214 213 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1483 r0 *1 229.6,45.36
X$1483 217 813 812 216 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1486 m0 *1 203.84,55.44
X$1486 812 813 228 216 227 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1491 r0 *1 70,126
X$1491 333 444 218 453 813 812 432 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1499 r0 *1 207.76,55.44
X$1499 813 229 236 812 219 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1507 m0 *1 20.72,65.52
X$1507 813 221 242 812 247 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1510 r0 *1 38.08,65.52
X$1510 813 221 237 812 256 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1526 m0 *1 31.92,176.4
X$1526 812 224 594 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1529 r0 *1 31.36,166.32
X$1529 812 224 426 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1531 m0 *1 152.32,186.48
X$1531 812 224 610 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1533 m0 *1 70,166.32
X$1533 812 224 443 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1536 m0 *1 70,85.68
X$1536 812 224 252 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1539 m0 *1 148.4,176.4
X$1539 812 224 470 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1542 r0 *1 189.28,75.6
X$1542 812 224 284 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1545 r0 *1 151.76,65.52
X$1545 812 224 244 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1548 m0 *1 36.4,75.6
X$1548 812 224 261 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1553 r0 *1 194.32,166.32
X$1553 812 224 435 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1555 r0 *1 75.6,176.4
X$1555 812 224 586 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1560 r0 *1 196,176.4
X$1560 812 224 588 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1562 m0 *1 115.92,126
X$1562 812 414 224 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1585 m0 *1 231.28,65.52
X$1585 813 226 277 812 254 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1587 m0 *1 209.44,55.44
X$1587 234 813 812 226 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1608 r0 *1 2.24,55.44
X$1608 240 813 812 230 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1611 m0 *1 11.76,65.52
X$1611 251 813 812 231 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1613 r0 *1 21.28,55.44
X$1613 813 231 247 812 235 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1623 r0 *1 35.84,75.6
X$1623 812 283 813 304 235 272 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1641 r0 *1 2.24,65.52
X$1641 240 813 812 250 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $1643 m0 *1 2.8,65.52
X$1643 249 813 812 240 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1649 r0 *1 10.64,55.44
X$1649 241 813 812 242 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1666 m0 *1 151.76,65.52
X$1666 812 244 814 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1678 r0 *1 227.92,55.44
X$1678 245 813 812 246 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1680 m0 *1 192.08,85.68
X$1680 299 813 812 245 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1682 m0 *1 227.36,75.6
X$1682 245 813 812 312 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1688 r0 *1 229.6,65.52
X$1688 246 813 812 264 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1695 m0 *1 222.88,65.52
X$1695 253 813 812 248 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1701 r0 *1 6.72,65.52
X$1701 250 813 812 258 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1707 r0 *1 70,75.6
X$1707 812 252 816 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1725 m0 *1 201.6,85.68
X$1725 812 301 813 291 254 268 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1730 m0 *1 195.44,65.52
X$1730 812 813 315 268 255 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1732 m0 *1 202.72,75.6
X$1732 813 275 267 812 255 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1736 r0 *1 33.04,65.52
X$1736 812 813 265 272 256 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1749 r0 *1 24.64,65.52
X$1749 260 813 812 293 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1762 r0 *1 43.12,75.6
X$1762 812 813 261 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $1772 r0 *1 212.24,65.52
X$1772 262 813 812 290 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1775 r0 *1 220.64,65.52
X$1775 263 813 812 266 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1782 m0 *1 2.24,75.6
X$1782 269 813 812 265 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1785 m0 *1 212.24,75.6
X$1785 812 813 285 266 291 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1800 m0 *1 10.64,75.6
X$1800 271 813 812 270 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $1802 r0 *1 10.64,75.6
X$1802 270 813 812 280 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1805 r0 *1 19.04,75.6
X$1805 281 813 812 271 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1808 m0 *1 10.64,85.68
X$1808 271 813 812 306 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1817 m0 *1 35.84,85.68
X$1817 812 813 273 293 304 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1823 r0 *1 210.56,75.6
X$1823 813 275 290 812 277 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1832 m0 *1 218.96,75.6
X$1832 276 813 812 300 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1839 m0 *1 190.96,95.76
X$1839 813 278 300 812 336 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1843 r0 *1 190.4,85.68
X$1843 813 278 297 812 316 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1849 r0 *1 2.24,75.6
X$1849 279 813 812 289 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1856 r0 *1 27.44,75.6
X$1856 282 813 812 292 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1861 m0 *1 27.44,85.68
X$1861 283 813 812 303 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1868 m0 *1 186.48,95.76
X$1868 812 813 284 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $1896 r0 *1 220.08,75.6
X$1896 286 813 812 287 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1899 r0 *1 185.36,85.68
X$1899 812 813 287 322 316 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1904 r0 *1 228.48,75.6
X$1904 288 813 812 321 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1907 m0 *1 2.24,95.76
X$1907 812 813 331 289 330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1920 m0 *1 41.44,85.68
X$1920 812 813 292 371 305 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1930 r0 *1 7.84,85.68
X$1930 294 813 812 338 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1933 m0 *1 2.24,85.68
X$1933 307 813 812 294 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1935 r0 *1 2.8,85.68
X$1935 294 813 812 308 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $1939 m0 *1 19.04,85.68
X$1939 309 813 812 295 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1941 m0 *1 26.88,95.76
X$1941 813 310 295 812 363 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1947 r0 *1 199.92,85.68
X$1947 298 813 812 315 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1959 r0 *1 204.4,105.84
X$1959 359 378 327 301 813 812 389 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1961 r0 *1 229.6,85.68
X$1961 301 813 812 320 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1971 m0 *1 229.6,105.84
X$1971 302 813 812 360 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1973 r0 *1 208.88,85.68
X$1973 302 813 812 313 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1976 m0 *1 227.92,85.68
X$1976 311 813 812 302 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1988 m0 *1 56,95.76
X$1988 813 310 334 812 305 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1995 r0 *1 2.24,95.76
X$1995 308 813 812 337 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2012 r0 *1 219.52,85.68
X$2012 313 813 812 319 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2029 r0 *1 17.36,85.68
X$2029 317 813 812 325 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2032 r0 *1 19.04,105.84
X$2032 812 318 813 330 362 371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2036 r0 *1 10.64,95.76
X$2036 318 813 812 324 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2046 m0 *1 201.6,95.76
X$2046 813 321 336 812 335 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2051 m0 *1 206.64,95.76
X$2051 812 327 813 328 335 322 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2056 r0 *1 176.4,95.76
X$2056 813 323 349 812 348 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2058 m0 *1 180.32,105.84
X$2058 813 323 372 812 365 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2069 m0 *1 27.44,105.84
X$2069 813 325 363 812 362 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2074 r0 *1 194.88,95.76
X$2074 812 359 813 326 341 342 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2076 m0 *1 189.84,105.84
X$2076 812 813 369 355 326 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2081 m0 *1 220.64,95.76
X$2081 327 813 812 345 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2086 m0 *1 213.92,95.76
X$2086 812 813 347 332 328 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2088 m0 *1 229.6,95.76
X$2088 329 813 812 332 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2121 r0 *1 19.04,95.76
X$2121 340 813 812 339 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2126 m0 *1 36.4,105.84
X$2126 812 813 340 354 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2135 m0 *1 195.44,105.84
X$2135 813 364 365 812 341 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2139 r0 *1 189.84,95.76
X$2139 812 813 346 342 348 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2142 r0 *1 224,95.76
X$2142 812 813 387 343 358 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2144 m0 *1 219.52,105.84
X$2144 370 813 812 343 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2146 r0 *1 229.6,95.76
X$2146 344 813 812 346 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2167 m0 *1 2.24,105.84
X$2167 367 813 812 350 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2172 r0 *1 2.24,105.84
X$2172 373 813 812 351 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2175 m0 *1 10.64,105.84
X$2175 351 813 812 352 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2177 r0 *1 3.92,115.92
X$2177 351 813 812 367 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $2183 m0 *1 19.04,105.84
X$2183 353 813 812 393 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2187 m0 *1 32.48,115.92
X$2187 812 393 813 385 394 354 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2190 r0 *1 229.6,105.84
X$2190 383 813 812 355 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2194 m0 *1 210,105.84
X$2194 356 813 812 357 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2198 m0 *1 202.72,115.92
X$2198 813 377 357 812 379 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2202 r0 *1 212.24,115.92
X$2202 812 405 813 358 391 406 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2212 m0 *1 227.36,115.92
X$2212 359 813 812 381 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2219 m0 *1 201.6,105.84
X$2219 361 813 812 364 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2244 m0 *1 58.24,115.92
X$2244 813 368 397 812 375 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2247 m0 *1 20.16,115.92
X$2247 813 368 390 812 400 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2263 r0 *1 212.24,105.84
X$2263 382 813 812 372 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2270 r0 *1 10.64,105.84
X$2270 374 813 812 384 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2273 r0 *1 37.52,115.92
X$2273 812 813 409 438 375 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2278 r0 *1 45.92,115.92
X$2278 419 401 403 395 376 813 812 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2280 m0 *1 48.16,115.92
X$2280 403 813 376 402 812 396 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2282 m0 *1 2.24,115.92
X$2282 398 813 812 376 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2287 r0 *1 192.64,115.92
X$2287 813 377 420 812 410 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2295 r0 *1 189.28,126
X$2295 812 378 813 437 452 459 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2298 m0 *1 218.96,115.92
X$2298 378 813 812 407 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2304 m0 *1 213.92,115.92
X$2304 813 386 379 812 391 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2307 r0 *1 220.64,105.84
X$2307 380 813 812 386 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2318 m0 *1 40.32,115.92
X$2318 813 384 812 395 394 396 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2341 m0 *1 10.64,115.92
X$2341 399 813 812 390 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2346 m0 *1 202.16,126
X$2346 392 813 812 404 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2375 r0 *1 25.2,115.92
X$2375 813 417 400 812 413 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2378 m0 *1 45.92,126
X$2378 812 813 401 402 415 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2380 r0 *1 8.4,115.92
X$2380 412 813 812 401 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2394 r0 *1 206.64,115.92
X$2394 812 813 404 406 410 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2399 r0 *1 213.36,136.08
X$2399 497 483 405 471 813 812 451 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2403 r0 *1 228.48,115.92
X$2403 405 813 812 408 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2419 r0 *1 16.8,115.92
X$2419 411 813 812 409 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2430 r0 *1 26.32,126
X$2430 812 428 813 436 413 438 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2438 m0 *1 50.96,126
X$2438 812 813 415 419 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2444 r0 *1 219.52,115.92
X$2444 416 813 812 418 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2448 m0 *1 6.72,126
X$2448 422 813 812 417 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2453 m0 *1 189.28,126
X$2453 812 813 421 418 437 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2469 m0 *1 2.24,136.08
X$2469 423 813 812 425 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2472 r0 *1 2.24,126
X$2472 424 813 812 430 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2474 m0 *1 2.24,126
X$2474 425 813 812 424 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $2480 r0 *1 10.64,126
X$2480 425 813 812 431 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2488 m0 *1 35.84,156.24
X$2488 812 813 426 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $2507 r0 *1 19.04,126
X$2507 812 813 427 457 436 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2509 m0 *1 28,146.16
X$2509 494 511 428 495 813 812 444 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2512 m0 *1 10.64,146.16
X$2512 428 813 812 442 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2520 r0 *1 197.68,126
X$2520 813 429 454 812 452 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2522 m0 *1 210.56,126
X$2522 433 813 812 429 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2531 r0 *1 79.52,126
X$2531 812 445 432 813 439 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2535 r0 *1 226.24,126
X$2535 434 813 812 460 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2550 r0 *1 188.72,166.32
X$2550 812 813 435 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $2570 r0 *1 33.6,126
X$2570 439 813 812 440 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2577 m0 *1 2.24,146.16
X$2577 441 813 812 457 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2586 r0 *1 70,156.24
X$2586 812 443 817 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $2608 r0 *1 201.04,206.64
X$2608 672 597 686 649 813 812 446 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2611 r0 *1 212.8,126
X$2611 812 813 447 448 489 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2613 m0 *1 205.52,146.16
X$2613 477 813 812 447 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2615 m0 *1 213.36,136.08
X$2615 812 471 813 478 473 448 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2618 r0 *1 217.84,126
X$2618 449 813 812 450 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2622 r0 *1 179.76,126
X$2622 813 458 450 812 454 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2635 m0 *1 63.84,216.72
X$2635 701 700 723 620 813 812 453 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2643 r0 *1 2.24,146.16
X$2643 494 813 812 455 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2646 m0 *1 10.64,136.08
X$2646 456 813 812 462 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2654 m0 *1 178.64,136.08
X$2654 813 458 481 812 480 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2660 m0 *1 193.2,136.08
X$2660 812 813 460 459 480 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2667 m0 *1 229.04,136.08
X$2667 476 813 812 461 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2670 m0 *1 207.76,136.08
X$2670 812 813 491 461 478 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2675 m0 *1 19.04,136.08
X$2675 812 813 487 462 503 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2682 m0 *1 27.44,156.24
X$2682 464 813 812 514 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2689 m0 *1 19.04,146.16
X$2689 465 813 812 467 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2692 m0 *1 19.04,156.24
X$2692 466 813 812 502 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2695 m0 *1 29.68,136.08
X$2695 813 467 468 812 479 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2701 r0 *1 21.28,136.08
X$2701 813 482 502 812 468 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2703 r0 *1 30.8,136.08
X$2703 495 813 812 469 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2713 r0 *1 148.4,166.32
X$2713 812 470 815 813 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $2727 r0 *1 226.24,146.16
X$2727 471 813 812 475 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2734 m0 *1 220.64,136.08
X$2734 472 813 812 488 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2739 m0 *1 224.56,146.16
X$2739 813 484 504 812 473 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2742 r0 *1 221.2,136.08
X$2742 474 813 812 484 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2755 r0 *1 29.68,146.16
X$2755 812 494 813 503 479 513 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2768 r0 *1 42,136.08
X$2768 813 482 490 812 505 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2777 m0 *1 230.72,176.4
X$2777 812 483 813 579 578 591 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2780 m0 *1 229.6,156.24
X$2780 483 813 812 499 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2788 m0 *1 220.08,156.24
X$2788 485 813 812 498 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2791 r0 *1 229.6,136.08
X$2791 498 813 812 486 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2799 m0 *1 215.04,146.16
X$2799 813 512 488 812 504 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2804 r0 *1 208.32,146.16
X$2804 813 512 515 812 489 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2818 m0 *1 23.52,166.32
X$2818 511 813 812 492 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2823 m0 *1 2.24,156.24
X$2823 493 813 812 527 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2836 r0 *1 108.64,186.48
X$2836 812 495 813 602 622 619 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2845 r0 *1 218.96,196.56
X$2845 812 813 497 633 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2850 m0 *1 229.6,146.16
X$2850 497 813 812 501 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2856 m0 *1 210.56,156.24
X$2856 498 813 812 522 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2866 r0 *1 217.84,146.16
X$2866 522 813 812 500 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2883 m0 *1 35.84,146.16
X$2883 812 813 514 513 505 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2888 m0 *1 6.72,166.32
X$2888 506 813 812 605 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2891 m0 *1 15.12,166.32
X$2891 527 813 812 507 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2894 r0 *1 2.24,156.24
X$2894 508 813 812 541 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2897 r0 *1 22.96,166.32
X$2897 530 813 812 509 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2900 m0 *1 10.64,196.56
X$2900 812 813 510 605 581 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2903 r0 *1 15.68,166.32
X$2903 812 511 813 581 561 560 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2937 m0 *1 10.64,156.24
X$2937 518 813 812 528 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2940 r0 *1 19.04,176.4
X$2940 519 813 812 593 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2943 r0 *1 2.24,176.4
X$2943 520 813 812 559 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2946 r0 *1 201.6,156.24
X$2946 521 813 812 549 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2951 m0 *1 202.16,156.24
X$2951 523 813 812 542 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2954 r0 *1 221.2,166.32
X$2954 524 813 812 554 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2957 r0 *1 2.24,186.48
X$2957 615 813 812 525 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2960 r0 *1 2.24,166.32
X$2960 559 813 812 526 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2965 r0 *1 24.64,156.24
X$2965 527 813 812 530 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2973 r0 *1 14,156.24
X$2973 813 531 528 812 529 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2976 m0 *1 22.4,186.48
X$2976 813 593 529 812 561 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2984 r0 *1 52.08,156.24
X$2984 813 531 544 812 568 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2992 m0 *1 124.32,236.88
X$2992 805 813 812 532 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2994 r0 *1 120.96,216.72
X$2994 532 813 812 761 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2996 m0 *1 122.64,226.8
X$2996 532 813 812 759 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3002 m0 *1 193.2,176.4
X$3002 812 597 813 533 555 563 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3004 r0 *1 210,156.24
X$3004 812 813 570 535 533 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3008 r0 *1 196.56,156.24
X$3008 812 813 542 563 534 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3010 m0 *1 190.96,166.32
X$3010 813 548 543 812 534 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3013 m0 *1 204.4,176.4
X$3013 537 813 812 535 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3015 r0 *1 221.2,156.24
X$3015 536 813 812 538 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3021 r0 *1 232.4,186.48
X$3021 813 538 599 812 578 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3023 r0 *1 229.6,156.24
X$3023 539 813 812 540 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3026 m0 *1 232.96,186.48
X$3026 812 813 540 591 590 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3029 r0 *1 10.64,166.32
X$3029 812 813 541 560 568 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3048 m0 *1 54.32,166.32
X$3048 812 813 553 546 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3050 m0 *1 53.2,176.4
X$3050 584 546 571 577 562 813 812 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3055 m0 *1 201.6,166.32
X$3055 813 548 554 812 556 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3064 m0 *1 211.12,166.32
X$3064 813 549 556 812 555 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3068 r0 *1 229.6,166.32
X$3068 564 813 812 550 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3071 r0 *1 229.6,196.56
X$3071 551 813 812 614 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3076 m0 *1 224.56,196.56
X$3076 552 813 812 580 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3083 r0 *1 36.96,176.4
X$3083 812 813 553 582 584 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3102 r0 *1 10.64,186.48
X$3102 557 813 812 584 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3105 m0 *1 2.24,196.56
X$3105 558 813 812 592 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3109 m0 *1 2.24,166.32
X$3109 559 813 812 615 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $3127 r0 *1 53.2,166.32
X$3127 562 813 571 582 812 585 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3135 m0 *1 212.8,176.4
X$3135 566 813 812 564 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3138 r0 *1 217.28,176.4
X$3138 564 813 812 598 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3145 m0 *1 224.56,186.48
X$3145 598 813 812 565 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3150 m0 *1 216.16,196.56
X$3150 597 813 812 567 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3158 r0 *1 215.6,166.32
X$3158 812 813 569 580 579 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3167 r0 *1 23.52,186.48
X$3167 575 813 812 571 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3172 r0 *1 27.44,176.4
X$3172 572 813 812 601 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3175 r0 *1 10.64,176.4
X$3175 592 813 812 573 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3178 m0 *1 21.84,176.4
X$3178 576 813 812 574 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3185 m0 *1 16.24,196.56
X$3185 592 813 812 576 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $3188 m0 *1 47.6,186.48
X$3188 813 601 812 577 595 585 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3209 r0 *1 37.52,186.48
X$3209 583 813 812 616 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3223 r0 *1 71.12,176.4
X$3223 812 813 586 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $3249 r0 *1 136.64,206.64
X$3249 587 813 812 679 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3251 m0 *1 131.04,226.8
X$3251 758 813 812 587 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3253 r0 *1 156.8,216.72
X$3253 587 813 812 727 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3271 r0 *1 188.16,176.4
X$3271 812 813 588 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3283 r0 *1 227.36,176.4
X$3283 813 589 613 812 590 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3286 m0 *1 221.2,176.4
X$3286 813 589 614 812 599 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3315 m0 *1 31.92,196.56
X$3315 812 813 594 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3333 r0 *1 50.4,186.48
X$3333 812 616 813 606 595 617 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3338 m0 *1 118.16,186.48
X$3338 813 596 604 812 609 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3341 m0 *1 117.6,196.56
X$3341 813 596 628 812 626 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3368 m0 *1 90.72,186.48
X$3368 812 813 603 608 602 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3384 r0 *1 67.2,226.8
X$3384 607 813 812 765 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3386 m0 *1 80.08,216.72
X$3386 607 813 812 778 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3389 m0 *1 67.2,236.88
X$3389 802 813 812 607 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3393 m0 *1 84,236.88
X$3393 806 813 812 608 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3396 r0 *1 120.96,186.48
X$3396 812 813 705 619 609 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3409 m0 *1 147.84,186.48
X$3409 812 813 610 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $3437 r0 *1 59.36,186.48
X$3437 812 813 620 617 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3451 m0 *1 71.68,216.72
X$3451 620 813 812 776 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3458 m0 *1 107.52,236.88
X$3458 790 813 812 621 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3460 m0 *1 112.56,196.56
X$3460 813 621 626 812 622 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3465 r0 *1 140,226.8
X$3465 623 813 812 766 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3467 m0 *1 132.72,236.88
X$3467 804 813 812 623 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3469 r0 *1 129.36,216.72
X$3469 623 813 812 789 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3473 r0 *1 190.4,196.56
X$3473 813 624 631 812 632 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3475 m0 *1 178.08,226.8
X$3475 813 624 768 812 692 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3491 r0 *1 23.52,216.72
X$3491 627 813 697 698 812 664 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3494 m0 *1 24.64,226.8
X$3494 745 736 627 663 697 813 812 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3502 m0 *1 115.36,216.72
X$3502 704 813 812 628 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3505 m0 *1 141.12,236.88
X$3505 803 813 812 629 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3508 r0 *1 131.6,226.8
X$3508 629 813 812 788 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3511 m0 *1 149.52,236.88
X$3511 629 813 812 767 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3518 m0 *1 181.44,206.64
X$3518 813 630 642 812 650 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3520 r0 *1 167.44,216.72
X$3520 813 630 708 812 648 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3526 m0 *1 201.6,226.8
X$3526 812 813 728 739 632 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3531 m0 *1 214.48,206.64
X$3531 812 638 813 655 639 633 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3535 m0 *1 4.48,216.72
X$3535 712 813 812 634 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3538 r0 *1 2.24,216.72
X$3538 634 813 812 734 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3541 r0 *1 10.64,216.72
X$3541 634 813 812 696 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $3544 r0 *1 68.88,216.72
X$3544 635 813 812 724 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3547 r0 *1 78.4,216.72
X$3547 635 813 812 702 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3549 r0 *1 58.8,226.8
X$3549 764 813 812 635 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3555 m0 *1 92.4,236.88
X$3555 636 813 812 810 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3557 r0 *1 92.4,226.8
X$3557 781 813 812 636 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3560 m0 *1 111.44,226.8
X$3560 636 813 812 762 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3569 r0 *1 145.04,206.64
X$3569 813 637 659 812 660 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3572 r0 *1 137.76,216.72
X$3572 813 637 717 812 706 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3578 r0 *1 208.88,206.64
X$3578 676 813 812 638 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3581 m0 *1 221.76,206.64
X$3581 813 640 812 651 639 652 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3583 m0 *1 229.6,206.64
X$3583 653 813 812 640 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3598 m0 *1 98,206.64
X$3598 645 813 812 703 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3602 r0 *1 103.04,206.64
X$3602 813 667 812 668 646 669 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3605 r0 *1 90.72,206.64
X$3605 812 747 813 740 646 741 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3608 r0 *1 172.48,206.64
X$3608 813 647 648 812 678 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3610 m0 *1 169.12,226.8
X$3610 756 813 812 647 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3614 r0 *1 192.08,206.64
X$3614 812 649 813 657 678 673 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3619 r0 *1 190.4,226.8
X$3619 649 813 812 775 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3624 m0 *1 206.64,226.8
X$3624 812 813 729 673 650 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3629 r0 *1 224,216.72
X$3629 689 730 688 651 731 813 812 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3632 m0 *1 227.36,226.8
X$3632 688 813 731 733 812 652 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3648 m0 *1 34.72,226.8
X$3648 681 738 719 720 656 813 812 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3650 r0 *1 39.2,226.8
X$3650 656 813 719 746 812 721 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3657 r0 *1 184.8,206.64
X$3657 812 813 658 671 657 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3668 r0 *1 154.56,206.64
X$3668 812 813 685 670 660 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3671 r0 *1 30.8,226.8
X$3671 773 813 812 661 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3675 m0 *1 2.24,226.8
X$3675 661 813 812 744 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $3677 r0 *1 2.24,226.8
X$3677 661 813 812 769 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3680 m0 *1 2.24,236.88
X$3680 792 813 812 662 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3682 r0 *1 21.28,206.64
X$3682 813 662 812 663 691 664 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3690 m0 *1 41.44,216.72
X$3690 812 813 665 746 681 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3692 m0 *1 44.8,226.8
X$3692 812 813 665 738 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3698 m0 *1 109.2,216.72
X$3698 666 813 683 684 812 669 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3700 r0 *1 101.92,216.72
X$3700 742 703 666 668 683 813 812 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3708 r0 *1 92.4,216.72
X$3708 725 813 812 667 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3720 m0 *1 151.76,216.72
X$3720 812 672 813 716 694 670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3722 r0 *1 182,226.8
X$3722 774 813 812 671 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3727 m0 *1 183.12,236.88
X$3727 672 813 812 793 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3739 r0 *1 229.6,206.64
X$3739 674 813 812 675 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3744 m0 *1 215.6,236.88
X$3744 675 813 812 711 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3746 m0 *1 229.04,236.88
X$3746 675 813 812 748 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3758 m0 *1 191.52,216.72
X$3758 812 686 813 714 677 739 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3760 r0 *1 179.76,206.64
X$3760 813 754 692 812 677 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3771 r0 *1 27.44,226.8
X$3771 812 813 680 745 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3774 m0 *1 27.44,236.88
X$3774 812 813 736 698 680 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3777 m0 *1 32.48,236.88
X$3777 798 813 812 681 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3782 r0 *1 111.44,216.72
X$3782 812 813 682 742 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3785 m0 *1 105.28,226.8
X$3785 812 813 703 684 682 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3791 r0 *1 105.84,226.8
X$3791 785 813 812 683 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3796 r0 *1 147.28,216.72
X$3796 726 813 812 685 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3801 m0 *1 192.08,236.88
X$3801 686 813 812 794 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3816 m0 *1 226.24,216.72
X$3816 812 813 710 689 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3818 m0 *1 229.6,216.72
X$3818 711 813 812 690 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3822 m0 *1 31.92,216.72
X$3822 812 752 813 713 691 693 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3830 m0 *1 48.72,216.72
X$3830 812 813 700 693 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3837 m0 *1 145.04,216.72
X$3837 813 695 706 812 694 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3840 m0 *1 135.52,216.72
X$3840 718 813 812 695 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3845 r0 *1 15.12,216.72
X$3845 696 813 812 735 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3851 r0 *1 10.64,226.8
X$3851 770 813 812 697 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3859 r0 *1 38.64,216.72
X$3859 813 699 812 720 755 721 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3861 r0 *1 30.24,216.72
X$3861 737 813 812 699 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3867 m0 *1 50.4,236.88
X$3867 700 813 812 799 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3870 r0 *1 89.04,216.72
X$3870 812 813 701 741 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3875 r0 *1 75.6,226.8
X$3875 701 813 812 780 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3890 m0 *1 115.92,236.88
X$3890 807 813 812 705 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3894 m0 *1 159.6,216.72
X$3894 812 813 743 707 716 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3896 r0 *1 156.8,226.8
X$3896 784 813 812 707 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3899 r0 *1 165.2,226.8
X$3899 783 813 812 708 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3901 m0 *1 185.92,216.72
X$3901 812 813 715 709 714 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3903 m0 *1 188.72,226.8
X$3903 753 813 812 709 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3908 r0 *1 218.96,216.72
X$3908 812 813 730 733 710 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3938 m0 *1 140.56,226.8
X$3938 757 813 812 717 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3949 m0 *1 19.04,236.88
X$3949 797 813 812 719 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3957 r0 *1 46.48,226.8
X$3957 812 771 813 722 755 763 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3960 r0 *1 53.76,226.8
X$3960 812 813 723 763 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3965 m0 *1 58.8,236.88
X$3965 723 813 812 800 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3969 m0 *1 74.48,226.8
X$3969 724 813 812 760 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3980 m0 *1 166.32,236.88
X$3980 727 813 812 811 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3984 r0 *1 198.8,226.8
X$3984 777 813 812 728 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3987 m0 *1 202.72,236.88
X$3987 791 813 812 729 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3991 m0 *1 216.16,226.8
X$3991 732 813 812 730 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3995 r0 *1 229.6,226.8
X$3995 749 813 812 731 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4015 m0 *1 15.68,226.8
X$4015 750 813 812 736 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4047 m0 *1 6.72,226.8
X$4047 744 813 812 751 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4054 r0 *1 84,226.8
X$4054 779 813 812 747 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4067 r0 *1 19.04,226.8
X$4067 772 813 812 752 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4075 r0 *1 173.6,226.8
X$4075 782 813 812 754 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4096 r0 *1 123.2,226.8
X$4096 761 813 812 787 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4102 r0 *1 114.8,226.8
X$4102 762 813 812 808 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4112 m0 *1 75.6,236.88
X$4112 765 813 812 809 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4115 r0 *1 148.4,226.8
X$4115 766 813 812 786 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4118 m0 *1 157.92,236.88
X$4118 767 813 812 801 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4120 m0 *1 174.72,236.88
X$4120 795 813 812 768 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4130 m0 *1 10.64,236.88
X$4130 796 813 812 771 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS gpio_controller

* cell gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyc_2 1 7 11 13
* net 1 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* net 11 I
* net 13 NWELL,VDD
* device instance $1 r0 *1 8.34,3.365 pmos_5p0
M$1 6 5 17 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 8.34,4.085 pmos_5p0
M$2 17 5 13 13 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 10.14,3.785 pmos_5p0
M$3 7 6 13 13 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 4.34,3.365 pmos_5p0
M$5 4 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $6 r0 *1 6.18,3.365 pmos_5p0
M$6 16 4 5 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $7 r0 *1 4.34,4.085 pmos_5p0
M$7 13 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $8 r0 *1 6.18,4.085 pmos_5p0
M$8 13 4 16 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $9 r0 *1 2.18,3.365 pmos_5p0
M$9 15 2 3 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $10 r0 *1 0.87,4.085 pmos_5p0
M$10 13 11 2 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $11 r0 *1 2.18,4.085 pmos_5p0
M$11 13 2 15 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $12 r0 *1 0.92,0.795 nmos_5p0
M$12 1 11 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $13 r0 *1 2.23,0.795 nmos_5p0
M$13 12 2 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $14 r0 *1 2.23,1.515 nmos_5p0
M$14 3 2 12 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $15 r0 *1 4.39,0.52 nmos_5p0
M$15 1 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.2232P PS=1.98U PD=1.6U
* device instance $16 r0 *1 6.23,0.52 nmos_5p0
M$16 10 4 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.2232P AD=0.27P PS=1.6U PD=1.98U
* device instance $17 r0 *1 4.39,1.24 nmos_5p0
M$17 4 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $18 r0 *1 6.23,1.24 nmos_5p0
M$18 5 4 10 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $19 r0 *1 8.39,0.525 nmos_5p0
M$19 1 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $20 r0 *1 8.39,1.245 nmos_5p0
M$20 6 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $21 r0 *1 10.19,1.005 nmos_5p0
M$21 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyc_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.673P PS=26.59U PD=24.5U
* device instance $11 r0 *1 12.07,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.346P AD=11.5839P PS=49U PD=51.09U
* device instance $31 r0 *1 0.92,1.005 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=13.2U AS=3.6696P AD=3.432P PS=20.08U PD=18.4U
* device instance $41 r0 *1 12.12,1.005 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=26.4U AS=6.864P AD=7.1016P PS=36.8U PD=38.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_20

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_3 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,0.995 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=2.19U AS=0.7008P AD=0.7008P PS=4.84U PD=4.84U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_3

* cell gf180mcu_fd_sc_mcu9t5v0__inv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_4 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_4

* cell gf180mcu_fd_sc_mcu9t5v0__inv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_3 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=3.96U AS=1.2672P AD=1.2672P PS=7.2U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_3

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_4 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.2993P PS=6.99U PD=5.08U
* device instance $3 r0 *1 3.29,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.5071P PS=9.98U PD=11.89U
* device instance $7 r0 *1 0.92,1.23 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.4593P PS=3.59U PD=2.75U
* device instance $9 r0 *1 3.34,1.265 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=3.2U AS=0.8935P AD=0.976P PS=5.46U PD=6.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 10 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 10 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 11 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 11 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 8 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 8 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_2 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.732P PS=4.54U PD=2.63U
* device instance $2 r0 *1 2.17,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.2993P AD=1.3725P PS=5.08U PD=6.99U
* device instance $4 r0 *1 0.92,1.23 nmos_5p0
M$4 3 1 4 3 nmos_5p0 L=0.6U W=0.73U AS=0.3212P AD=0.2695P PS=2.34U PD=1.5U
* device instance $5 r0 *1 2.22,1.265 nmos_5p0
M$5 5 4 3 3 nmos_5p0 L=0.6U W=1.6U AS=0.4775P AD=0.56P PS=2.82U PD=3.8U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* pin A2
* pin A1
* pin B
* pin ZN
* pin C
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_2 1 2 4 5 6 7 8
* net 1 A2
* net 2 A1
* net 4 B
* net 5 ZN
* net 6 C
* net 7 NWELL,VDD
* net 8 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 5 1 3 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.3359P PS=6.89U PD=5.12U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 3 2 5 7 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.37,3.78 pmos_5p0
M$5 12 4 3 7 pmos_5p0 L=0.5U W=1.83U AS=0.8601P AD=0.2196P PS=2.77U PD=2.07U
* device instance $6 r0 *1 6.11,3.78 pmos_5p0
M$6 7 6 12 7 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.549P PS=2.07U PD=2.43U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 11 6 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.549P AD=0.4392P PS=2.43U PD=2.31U
* device instance $8 r0 *1 8.19,3.78 pmos_5p0
M$8 3 4 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.4392P AD=0.8052P PS=2.31U PD=4.54U
* device instance $9 r0 *1 5.02,0.745 nmos_5p0
M$9 5 4 8 8 nmos_5p0 L=0.6U W=1.58U AS=0.5609P AD=0.553P PS=3.195U PD=3.77U
* device instance $10 r0 *1 6.14,0.745 nmos_5p0
M$10 8 6 5 8 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $13 r0 *1 0.92,0.942 nmos_5p0
M$13 10 1 8 8 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.1422P PS=3.25U PD=1.425U
* device instance $14 r0 *1 1.76,0.942 nmos_5p0
M$14 5 2 10 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 2.88,0.942 nmos_5p0
M$15 9 2 5 8 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 3.72,0.942 nmos_5p0
M$16 8 1 9 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor2_2 1 5 6 7 8
* net 1 NWELL,VDD
* net 5 A1
* net 6 A2
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 ZN
* device instance $1 r0 *1 0.97,3.327 pmos_5p0
M$1 10 6 2 1 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.260775P PS=2.71U PD=1.485U
* device instance $2 r0 *1 2.04,3.327 pmos_5p0
M$2 1 5 10 1 pmos_5p0 L=0.5U W=0.915U AS=0.260775P AD=0.571875P PS=1.485U
+ PD=2.68U
* device instance $3 r0 *1 3.39,3.785 pmos_5p0
M$3 4 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.571875P AD=0.4758P PS=2.68U PD=2.35U
* device instance $4 r0 *1 4.41,3.785 pmos_5p0
M$4 3 5 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.4758P PS=2.35U PD=2.35U
* device instance $5 r0 *1 5.43,3.785 pmos_5p0
M$5 4 6 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.17,3.78 pmos_5p0
M$6 8 3 1 1 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 3 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,0.675 nmos_5p0
M$10 2 6 7 7 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $11 r0 *1 2.04,0.675 nmos_5p0
M$11 7 5 2 7 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.363P PS=1.18U PD=2.02U
* device instance $12 r0 *1 3.34,1.005 nmos_5p0
M$12 3 2 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.46,1.005 nmos_5p0
M$13 9 5 3 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 7 6 9 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
