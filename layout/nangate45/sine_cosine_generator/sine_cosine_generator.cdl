* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT sine_cosine_generator clk cosine_out[0] cosine_out[10]
+ cosine_out[11] cosine_out[12] cosine_out[13] cosine_out[14]
+ cosine_out[15] cosine_out[1] cosine_out[2] cosine_out[3] cosine_out[4]
+ cosine_out[5] cosine_out[6] cosine_out[7] cosine_out[8] cosine_out[9]
+ enable phase_in[0] phase_in[10] phase_in[11] phase_in[12]
+ phase_in[13] phase_in[14] phase_in[15] phase_in[1] phase_in[2]
+ phase_in[3] phase_in[4] phase_in[5] phase_in[6] phase_in[7]
+ phase_in[8] phase_in[9] rst_n sine_out[0] sine_out[10] sine_out[11]
+ sine_out[12] sine_out[13] sine_out[14] sine_out[15] sine_out[1]
+ sine_out[2] sine_out[3] sine_out[4] sine_out[5] sine_out[6]
+ sine_out[7] sine_out[8] sine_out[9] valid_out
X_323_ net4 _261_ VDD VSS BUF_X2
X_324_ _261_ _309_ VDD VSS INV_X2
X_325_ net5 _262_ VDD VSS BUF_X2
X_326_ _262_ _310_ VDD VSS INV_X2
X_327_ rst_n _263_ VDD VSS BUF_X2
X_328_ _263_ _264_ VDD VSS CLKBUF_X3
X_329_ enable _265_ VDD VSS BUF_X2
X_330_ _265_ _266_ VDD VSS CLKBUF_X3
X_331_ _264_ _266_ net15 _267_ VDD VSS OAI21_X1
X_332_ net6 net1 net8 net9 _268_ VDD VSS NOR4_X4
X_333_ net7 net10 net12 net2 _269_ VDD VSS NOR4_X4
X_334_ net11 net14 net13 net3 _270_ VDD VSS NOR4_X4
X_335_ _268_ _269_ _270_ _271_ VDD VSS AND3_X1
X_336_ _271_ _272_ VDD VSS CLKBUF_X3
X_337_ phase_in[15] _273_ VDD VSS CLKBUF_X3
X_338_ _273_ _274_ VDD VSS INV_X2
X_339_ phase_in[14] _275_ VDD VSS BUF_X4
X_340_ _275_ _276_ VDD VSS BUF_X4
X_341_ _311_ _277_ VDD VSS CLKBUF_X3
X_342_ _277_ _278_ VDD VSS INV_X1
X_343_ _274_ _276_ _278_ _279_ VDD VSS NOR3_X2
X_344_ _273_ _280_ VDD VSS CLKBUF_X3
X_345_ _321_ _281_ VDD VSS CLKBUF_X3
X_346_ _275_ _281_ _282_ VDD VSS NAND2_X2
X_347_ _280_ _282_ _283_ VDD VSS NOR2_X1
X_348_ _272_ _279_ _283_ _284_ VDD VSS OAI21_X1
X_349_ net1 net8 net7 net12 _285_ VDD VSS NAND4_X1
X_350_ net14 net13 net3 net2 _023_ VDD VSS NAND4_X1
X_351_ _285_ _023_ _024_ VDD VSS NOR2_X1
X_352_ net6 net10 net9 net11 _025_ VDD VSS AND4_X1
X_353_ _279_ _024_ _025_ _026_ VDD VSS NAND3_X2
X_354_ _265_ _284_ _026_ _027_ VDD VSS NAND3_X1
X_355_ _275_ _028_ VDD VSS CLKBUF_X3
X_356_ _317_ _028_ _029_ VDD VSS OR2_X1
X_357_ _028_ _261_ _030_ VDD VSS NAND2_X1
X_358_ _029_ _030_ _031_ VDD VSS NAND2_X1
X_359_ _280_ _032_ VDD VSS CLKBUF_X3
X_360_ _319_ _033_ VDD VSS CLKBUF_X3
X_361_ _275_ _033_ _034_ VDD VSS NAND2_X2
X_362_ _032_ _278_ _034_ _035_ VDD VSS AOI21_X1
X_363_ _315_ _036_ VDD VSS BUF_X1
X_364_ _036_ _037_ VDD VSS CLKBUF_X3
X_365_ _275_ _277_ _038_ VDD VSS AND2_X1
X_366_ _037_ _038_ _039_ VDD VSS NOR2_X1
X_367_ _275_ _040_ VDD VSS INV_X1
X_368_ _040_ _041_ VDD VSS CLKBUF_X3
X_369_ _041_ _042_ VDD VSS CLKBUF_X3
X_370_ _281_ _043_ VDD VSS CLKBUF_X3
X_371_ _280_ _042_ _043_ _044_ VDD VSS NAND3_X1
X_372_ _039_ _044_ _045_ VDD VSS NAND2_X1
X_373_ _272_ _035_ _045_ _046_ VDD VSS OAI21_X1
X_374_ _027_ _031_ _046_ _047_ VDD VSS AOI21_X1
X_375_ _274_ _276_ _048_ VDD VSS NAND2_X1
X_376_ _033_ _049_ VDD VSS CLKBUF_X3
X_377_ _049_ _277_ _050_ VDD VSS NOR2_X1
X_378_ _280_ _034_ _051_ VDD VSS AND2_X1
X_379_ _050_ _051_ _052_ VDD VSS NOR2_X1
X_380_ _272_ _048_ _049_ _052_ _043_ _053_ VDD VSS OAI221_X1
X_381_ _267_ _047_ _053_ _000_ VDD VSS AOI21_X1
X_382_ _264_ net16 _266_ _054_ VDD VSS OAI21_X1
X_383_ _282_ _310_ _276_ _055_ VDD VSS OAI21_X1
X_384_ _312_ _056_ VDD VSS BUF_X1
X_385_ _275_ _056_ _057_ VDD VSS NAND2_X1
X_386_ _057_ _262_ _276_ _058_ VDD VSS OAI21_X1
X_387_ _274_ _059_ VDD VSS CLKBUF_X3
X_388_ _055_ _058_ _059_ _060_ VDD VSS MUX2_X1
X_389_ _026_ _060_ _061_ VDD VSS NAND2_X1
X_390_ _273_ _062_ VDD VSS CLKBUF_X3
X_391_ _277_ _037_ _275_ _063_ VDD VSS MUX2_X1
X_392_ _062_ _049_ _063_ _064_ VDD VSS NOR3_X1
X_393_ _059_ _043_ _065_ VDD VSS NOR2_X1
X_394_ _041_ _037_ _066_ VDD VSS NAND2_X1
X_395_ _064_ _065_ _066_ _067_ VDD VSS AOI21_X1
X_396_ _067_ _068_ VDD VSS INV_X1
X_397_ _268_ _269_ _270_ _069_ VDD VSS NAND3_X4
X_398_ _033_ _275_ _274_ _070_ VDD VSS OAI21_X2
X_399_ _036_ _321_ _311_ _071_ VDD VSS NOR3_X2
X_400_ _069_ _070_ _071_ _072_ VDD VSS AOI21_X4
X_401_ _061_ _068_ _072_ _073_ VDD VSS MUX2_X1
X_402_ _054_ _073_ _266_ _001_ VDD VSS AOI21_X1
X_403_ _263_ _074_ VDD VSS INV_X2
X_404_ _265_ _075_ VDD VSS INV_X2
X_405_ _075_ net17 _076_ VDD VSS NAND2_X1
X_406_ _028_ _261_ _077_ VDD VSS XNOR2_X1
X_407_ _276_ _037_ _078_ VDD VSS NAND2_X2
X_408_ _041_ _261_ _079_ VDD VSS NAND2_X1
X_409_ _078_ _079_ _080_ VDD VSS NAND2_X1
X_410_ _077_ _080_ _280_ _081_ VDD VSS MUX2_X1
X_411_ net6 net11 net14 net13 _082_ VDD VSS NAND4_X2
X_412_ net3 net2 _311_ _083_ VDD VSS NAND3_X2
X_413_ net8 net7 net10 net9 _084_ VDD VSS NAND4_X2
X_414_ _273_ _040_ net1 net12 _085_ VDD VSS NAND4_X2
X_415_ _082_ _083_ _084_ _085_ _086_ VDD VSS NOR4_X4
X_416_ _086_ _072_ _087_ VDD VSS OR2_X1
X_417_ _087_ _088_ VDD VSS BUF_X8
X_418_ _036_ _277_ _089_ VDD VSS OR2_X1
X_419_ _274_ _276_ _281_ _089_ _090_ VDD VSS NOR4_X1
X_420_ _043_ _041_ _062_ _091_ VDD VSS OAI21_X1
X_421_ _049_ _089_ _092_ VDD VSS NOR2_X1
X_422_ _090_ _091_ _092_ _093_ VDD VSS AOI21_X1
X_423_ _062_ _078_ _094_ VDD VSS NAND2_X1
X_424_ _094_ _048_ _043_ _028_ _089_ _095_ VDD VSS OAI221_X1
X_425_ _272_ _093_ _095_ _096_ VDD VSS NAND3_X1
X_426_ _280_ _097_ VDD VSS CLKBUF_X3
X_427_ _044_ _034_ _097_ _098_ VDD VSS OAI21_X1
X_428_ _266_ _081_ _088_ _096_ _098_ _099_ VDD VSS OAI221_X1
X_429_ _074_ _076_ _099_ _002_ VDD VSS AOI21_X1
X_430_ _086_ _072_ _100_ VDD VSS NOR2_X4
X_431_ _265_ _263_ _101_ VDD VSS NAND2_X1
X_432_ _101_ _102_ VDD VSS INV_X1
X_433_ _102_ _022_ VDD VSS BUF_X4
X_434_ _042_ _313_ _103_ VDD VSS OR2_X1
X_435_ _097_ _103_ _104_ VDD VSS NAND2_X1
X_436_ _048_ _100_ _022_ _104_ _105_ VDD VSS NAND4_X1
X_437_ _028_ _106_ VDD VSS CLKBUF_X3
X_438_ _097_ _106_ _107_ VDD VSS NAND2_X1
X_439_ _049_ _037_ _043_ _108_ VDD VSS NOR3_X1
X_440_ _037_ _281_ _109_ VDD VSS NOR2_X1
X_441_ _050_ _109_ _110_ VDD VSS AND2_X1
X_442_ _059_ _042_ _111_ VDD VSS NAND2_X1
X_443_ _107_ _108_ _110_ _111_ _112_ VDD VSS OAI22_X1
X_444_ _272_ _022_ _112_ _113_ VDD VSS NAND3_X1
X_445_ _265_ _074_ _114_ VDD VSS NOR2_X4
X_446_ net18 _114_ _115_ VDD VSS NAND2_X1
X_447_ _105_ _113_ _115_ _003_ VDD VSS NAND3_X1
X_448_ _265_ _116_ VDD VSS CLKBUF_X3
X_449_ _264_ net21 _116_ _117_ VDD VSS OAI21_X1
X_450_ _280_ _041_ _118_ VDD VSS NAND2_X1
X_451_ _118_ _103_ _097_ _119_ VDD VSS OAI21_X1
X_452_ _100_ _119_ _120_ VDD VSS NAND2_X1
X_453_ _049_ _037_ _121_ VDD VSS NOR2_X1
X_454_ _118_ _109_ _121_ _048_ _122_ VDD VSS OAI22_X1
X_455_ _272_ _122_ _123_ VDD VSS AND2_X1
X_456_ _027_ _123_ _124_ VDD VSS NOR2_X1
X_457_ _117_ _120_ _124_ _004_ VDD VSS AOI21_X1
X_458_ _036_ _125_ VDD VSS INV_X1
X_459_ _034_ _125_ _028_ _126_ VDD VSS OAI21_X1
X_460_ _032_ _126_ _127_ VDD VSS NAND2_X1
X_461_ _281_ _128_ VDD VSS INV_X1
X_462_ _078_ _128_ _028_ _129_ VDD VSS OAI21_X1
X_463_ _059_ _129_ _130_ VDD VSS NAND2_X1
X_464_ _069_ _127_ _130_ _131_ VDD VSS AOI21_X2
X_465_ _041_ _033_ _132_ VDD VSS AND2_X1
X_466_ _132_ _310_ _106_ _133_ VDD VSS AOI21_X1
X_467_ _056_ _133_ _059_ _134_ VDD VSS MUX2_X1
X_468_ _022_ _131_ _096_ _134_ _088_ _135_ VDD VSS OAI221_X1
X_469_ _075_ net22 _264_ _136_ VDD VSS NAND3_X1
X_470_ _135_ _136_ _005_ VDD VSS NAND2_X1
X_471_ _264_ net29 _116_ _137_ VDD VSS OAI21_X1
X_472_ _282_ _278_ _028_ _138_ VDD VSS OAI21_X1
X_473_ _059_ _272_ _138_ _139_ VDD VSS NAND3_X1
X_474_ _116_ _026_ _139_ _140_ VDD VSS NAND3_X1
X_475_ _123_ _140_ _141_ VDD VSS NOR2_X1
X_476_ _059_ _142_ VDD VSS CLKBUF_X3
X_477_ _142_ _106_ _313_ _143_ VDD VSS NOR3_X1
X_478_ _042_ _277_ _144_ VDD VSS NAND2_X1
X_479_ _097_ _144_ _103_ _145_ VDD VSS AOI21_X1
X_480_ _100_ _143_ _145_ _146_ VDD VSS OAI21_X1
X_481_ _137_ _141_ _146_ _006_ VDD VSS AOI21_X1
X_482_ _264_ net26 _116_ _147_ VDD VSS OAI21_X1
X_483_ _131_ _140_ _148_ VDD VSS NOR2_X1
X_484_ _056_ _149_ VDD VSS INV_X1
X_485_ _041_ _149_ _150_ VDD VSS NAND2_X1
X_486_ _028_ _262_ _151_ VDD VSS NAND2_X1
X_487_ _280_ _150_ _151_ _152_ VDD VSS AOI21_X1
X_488_ _034_ _149_ _106_ _153_ VDD VSS OAI21_X1
X_489_ _152_ _153_ _032_ _154_ VDD VSS AOI21_X1
X_490_ _088_ _154_ _155_ VDD VSS OR2_X1
X_491_ _147_ _148_ _155_ _007_ VDD VSS AOI21_X1
X_492_ _263_ net19 _116_ _156_ VDD VSS OAI21_X1
X_493_ _280_ _030_ _066_ _157_ VDD VSS NAND3_X1
X_494_ _059_ _029_ _078_ _158_ VDD VSS NAND3_X1
X_495_ _026_ _157_ _158_ _159_ VDD VSS NAND3_X1
X_496_ _276_ _277_ _160_ VDD VSS NOR2_X1
X_497_ _033_ _281_ _161_ VDD VSS NOR2_X1
X_498_ _273_ _276_ _125_ _160_ _161_ _162_ VDD VSS AOI221_X1
X_499_ _066_ _161_ _042_ _163_ VDD VSS OAI21_X1
X_500_ _162_ _163_ _032_ _164_ VDD VSS AOI21_X1
X_501_ _159_ _164_ _072_ _165_ VDD VSS MUX2_X1
X_502_ _156_ _165_ _266_ _008_ VDD VSS AOI21_X1
X_503_ _042_ _043_ _166_ VDD VSS NAND2_X1
X_504_ _051_ _166_ _142_ _167_ VDD VSS AOI21_X1
X_505_ _041_ _262_ _261_ _168_ VDD VSS MUX2_X1
X_506_ _032_ _168_ _169_ VDD VSS NOR2_X1
X_507_ _132_ _056_ _106_ _170_ VDD VSS AOI21_X1
X_508_ _169_ _170_ _097_ _171_ VDD VSS AOI21_X1
X_509_ _266_ _096_ _167_ _171_ _088_ _172_ VDD VSS OAI221_X1
X_510_ _075_ net28 _173_ VDD VSS NAND2_X1
X_511_ _074_ _172_ _173_ _009_ VDD VSS AOI21_X1
X_512_ _097_ _166_ _151_ _174_ VDD VSS NAND3_X1
X_513_ _106_ _262_ _261_ _175_ VDD VSS MUX2_X1
X_514_ _142_ _175_ _176_ VDD VSS NAND2_X1
X_515_ _100_ _022_ _174_ _176_ _177_ VDD VSS NAND4_X1
X_516_ _049_ _089_ _042_ _178_ VDD VSS AOI21_X1
X_517_ _065_ _078_ _178_ _142_ _179_ VDD VSS AOI22_X1
X_518_ _272_ _022_ _179_ _180_ VDD VSS NAND3_X1
X_519_ net20 _114_ _181_ VDD VSS NAND2_X1
X_520_ _177_ _180_ _181_ _010_ VDD VSS NAND3_X1
X_521_ net31 _114_ _182_ VDD VSS NAND2_X1
X_522_ _079_ _042_ _317_ _183_ VDD VSS OAI21_X2
X_523_ _106_ _049_ _277_ _184_ VDD VSS OAI21_X1
X_524_ _043_ _049_ _142_ _185_ VDD VSS AOI21_X1
X_525_ _089_ _184_ _185_ _186_ VDD VSS NAND3_X1
X_526_ _022_ _183_ _088_ _186_ _069_ _187_ VDD VSS OAI221_X2
X_527_ _182_ _187_ _011_ VDD VSS NAND2_X1
X_528_ _075_ net32 _264_ _188_ VDD VSS NAND3_X1
X_529_ _277_ _281_ _273_ _189_ VDD VSS MUX2_X1
X_530_ _276_ _189_ _190_ VDD VSS NAND2_X1
X_531_ _062_ _125_ _191_ VDD VSS NAND2_X1
X_532_ _281_ _033_ _275_ _192_ VDD VSS MUX2_X2
X_533_ _191_ _192_ _032_ _193_ VDD VSS OAI21_X1
X_534_ _072_ _190_ _193_ _194_ VDD VSS NAND3_X1
X_535_ _022_ _194_ _195_ VDD VSS NAND2_X1
X_536_ _106_ _310_ _196_ VDD VSS NAND2_X1
X_537_ _032_ _196_ _150_ _197_ VDD VSS NAND3_X1
X_538_ _151_ _043_ _106_ _198_ VDD VSS OAI21_X1
X_539_ _197_ _198_ _097_ _199_ VDD VSS OAI21_X1
X_540_ _088_ _199_ _200_ VDD VSS NOR2_X1
X_541_ _188_ _195_ _200_ _012_ VDD VSS OAI21_X1
X_542_ net33 _114_ _201_ VDD VSS NAND2_X1
X_543_ _062_ _192_ _202_ VDD VSS NAND2_X1
X_544_ _072_ _202_ _203_ VDD VSS NAND2_X1
X_545_ _059_ _037_ _204_ VDD VSS NAND2_X1
X_546_ _069_ _190_ _204_ _205_ VDD VSS AOI21_X1
X_547_ _142_ _261_ _206_ VDD VSS NOR2_X1
X_548_ _206_ _039_ _142_ _207_ VDD VSS AOI21_X1
X_549_ _022_ _203_ _205_ _207_ _088_ _208_ VDD VSS OAI221_X2
X_550_ _201_ _208_ _013_ VDD VSS NAND2_X1
X_551_ _062_ _039_ _161_ _209_ VDD VSS AOI21_X1
X_552_ _042_ _313_ _210_ VDD VSS NAND2_X1
X_553_ _075_ _271_ _209_ _210_ _100_ _211_ VDD VSS AOI221_X2
X_554_ _142_ _075_ _212_ VDD VSS NOR2_X1
X_555_ _263_ net34 _116_ _213_ VDD VSS OAI21_X1
X_556_ _211_ _212_ _213_ _014_ VDD VSS NOR3_X1
X_557_ _075_ net36 _264_ _214_ VDD VSS NAND3_X1
X_558_ _142_ _037_ _192_ _215_ VDD VSS OAI21_X1
X_559_ _072_ _190_ _215_ _216_ VDD VSS NAND3_X1
X_560_ _022_ _216_ _217_ VDD VSS NAND2_X1
X_561_ _049_ _043_ _028_ _218_ VDD VSS MUX2_X1
X_562_ _032_ _218_ _219_ VDD VSS NAND2_X1
X_563_ _282_ _262_ _106_ _220_ VDD VSS OAI21_X1
X_564_ _219_ _220_ _097_ _221_ VDD VSS OAI21_X1
X_565_ _088_ _221_ _222_ VDD VSS NOR2_X1
X_566_ _214_ _217_ _222_ _015_ VDD VSS OAI21_X1
X_567_ _263_ net37 _116_ _223_ VDD VSS OAI21_X1
X_568_ _097_ _100_ _210_ _224_ VDD VSS NAND3_X1
X_569_ _116_ _026_ _225_ VDD VSS NAND2_X1
X_570_ _142_ _109_ _184_ _226_ VDD VSS AOI21_X1
X_571_ _225_ _226_ _272_ _227_ VDD VSS AOI21_X1
X_572_ _223_ _224_ _227_ _016_ VDD VSS AOI21_X1
X_573_ _263_ net38 _116_ _228_ VDD VSS OAI21_X1
X_574_ _062_ _034_ _150_ _229_ VDD VSS AOI21_X1
X_575_ _041_ _262_ _230_ VDD VSS NAND2_X1
X_576_ _062_ _230_ _057_ _231_ VDD VSS AND3_X1
X_577_ _086_ _229_ _231_ _232_ VDD VSS OR3_X1
X_578_ _273_ _276_ _033_ _233_ VDD VSS NOR3_X2
X_579_ _274_ _192_ _234_ VDD VSS NOR2_X1
X_580_ _273_ _041_ _281_ _277_ _235_ VDD VSS NOR4_X2
X_581_ _233_ _234_ _235_ _236_ VDD VSS NOR3_X1
X_582_ _037_ _236_ _237_ VDD VSS NOR2_X1
X_583_ _232_ _237_ _072_ _238_ VDD VSS MUX2_X1
X_584_ _228_ _238_ _266_ _017_ VDD VSS AOI21_X1
X_585_ _264_ net45 _266_ _239_ VDD VSS OAI21_X1
X_586_ _190_ _125_ _059_ _240_ VDD VSS OAI21_X1
X_587_ _203_ _240_ _271_ _114_ net45 _241_ VDD VSS AOI221_X2
X_588_ _280_ _313_ _242_ VDD VSS NAND2_X1
X_589_ _062_ _038_ _243_ VDD VSS OR2_X1
X_590_ _088_ _242_ _243_ _114_ net45 _244_ VDD VSS AOI221_X1
X_591_ _239_ _241_ _244_ _018_ VDD VSS NOR3_X1
X_592_ _191_ _192_ _245_ VDD VSS NOR2_X1
X_593_ _069_ _233_ _235_ _245_ _246_ VDD VSS NOR4_X1
X_594_ net42 _114_ _246_ _102_ _247_ VDD VSS AOI22_X1
X_595_ _042_ _056_ _248_ VDD VSS NOR2_X1
X_596_ _032_ _132_ _248_ _249_ VDD VSS NOR3_X1
X_597_ _101_ _231_ _249_ _250_ VDD VSS OR3_X1
X_598_ _247_ _250_ _088_ _019_ VDD VSS OAI21_X1
X_599_ _263_ net35 _116_ _251_ VDD VSS OAI21_X1
X_600_ _062_ _033_ _281_ _038_ _252_ VDD VSS OR4_X1
X_601_ _272_ _191_ _252_ _253_ VDD VSS NAND3_X1
X_602_ _191_ _183_ _032_ _254_ VDD VSS OAI21_X1
X_603_ _253_ _254_ _100_ _255_ VDD VSS MUX2_X1
X_604_ _251_ _255_ _266_ _020_ VDD VSS AOI21_X1
X_605_ _125_ _233_ _235_ _256_ VDD VSS OAI21_X1
X_606_ _069_ _234_ _257_ VDD VSS NOR2_X1
X_607_ _229_ _234_ _258_ VDD VSS NOR2_X1
X_608_ _075_ _256_ _257_ _258_ _100_ _259_ VDD VSS AOI221_X2
X_609_ _264_ net44 _266_ _260_ VDD VSS OAI21_X1
X_610_ _259_ _260_ _021_ VDD VSS NOR2_X1
X_611_ _309_ _310_ _311_ _312_ VDD VSS HA_X1
X_612_ _309_ _310_ _313_ _314_ VDD VSS HA_X1
X_613_ _309_ net5 _315_ _316_ VDD VSS HA_X1
X_614_ _309_ net5 _317_ _318_ VDD VSS HA_X1
X_615_ net4 _310_ _319_ _320_ VDD VSS HA_X1
X_616_ net4 net5 _321_ _322_ VDD VSS HA_X1
X_617_ net29 net23 VDD VSS BUF_X1
X_618_ net26 net24 VDD VSS BUF_X1
X_619_ net26 net25 VDD VSS BUF_X1
X_620_ net19 net27 VDD VSS BUF_X1
X_621_ net20 net30 VDD VSS BUF_X1
X_622_ net45 net39 VDD VSS BUF_X1
X_623_ net42 net40 VDD VSS BUF_X1
X_624_ net42 net41 VDD VSS BUF_X1
X_625_ net35 net43 VDD VSS BUF_X1
X_626_ net36 net46 VDD VSS BUF_X1
Xcosine_out\[0\]$_SDFFE_PN0P_ _000_ clknet_1_1__leaf_clk net15
+ _308_ VDD VSS DFF_X1
Xcosine_out\[10\]$_SDFFE_PN0P_ _001_ clknet_1_0__leaf_clk
+ net16 _307_ VDD VSS DFF_X1
Xcosine_out\[11\]$_SDFFE_PN0P_ _002_ clknet_1_1__leaf_clk
+ net17 _306_ VDD VSS DFF_X1
Xcosine_out\[12\]$_SDFFE_PN0P_ _003_ clknet_1_1__leaf_clk
+ net18 _305_ VDD VSS DFF_X1
Xcosine_out\[15\]$_SDFFE_PN0P_ _004_ clknet_1_0__leaf_clk
+ net21 _304_ VDD VSS DFF_X1
Xcosine_out\[1\]$_SDFFE_PN0P_ _005_ clknet_1_1__leaf_clk net22
+ _303_ VDD VSS DFF_X1
Xcosine_out\[2\]$_SDFFE_PN0P_ _006_ clknet_1_0__leaf_clk net29
+ _302_ VDD VSS DFF_X1
Xcosine_out\[5\]$_SDFFE_PN0P_ _007_ clknet_1_1__leaf_clk net26
+ _301_ VDD VSS DFF_X1
Xcosine_out\[6\]$_SDFFE_PN0P_ _008_ clknet_1_0__leaf_clk net19
+ _300_ VDD VSS DFF_X1
Xcosine_out\[7\]$_SDFFE_PN0P_ _009_ clknet_1_1__leaf_clk net28
+ _299_ VDD VSS DFF_X1
Xcosine_out\[9\]$_SDFFE_PN0P_ _010_ clknet_1_1__leaf_clk net20
+ _298_ VDD VSS DFF_X1
Xsine_out\[0\]$_SDFFE_PN0P_ _011_ clknet_1_1__leaf_clk net31
+ _297_ VDD VSS DFF_X1
Xsine_out\[10\]$_SDFFE_PN0P_ _012_ clknet_1_1__leaf_clk net32
+ _296_ VDD VSS DFF_X1
Xsine_out\[11\]$_SDFFE_PN0P_ _013_ clknet_1_1__leaf_clk net33
+ _295_ VDD VSS DFF_X1
Xsine_out\[12\]$_SDFFE_PN0P_ _014_ clknet_1_0__leaf_clk net34
+ _294_ VDD VSS DFF_X1
Xsine_out\[14\]$_SDFFE_PN0P_ _015_ clknet_1_1__leaf_clk net36
+ _293_ VDD VSS DFF_X1
Xsine_out\[15\]$_SDFFE_PN0P_ _016_ clknet_1_0__leaf_clk net37
+ _292_ VDD VSS DFF_X1
Xsine_out\[1\]$_SDFFE_PN0P_ _017_ clknet_1_0__leaf_clk net38
+ _291_ VDD VSS DFF_X1
Xsine_out\[2\]$_SDFFE_PN0P_ _018_ clknet_1_0__leaf_clk net45
+ _290_ VDD VSS DFF_X2
Xsine_out\[5\]$_SDFFE_PN0P_ _019_ clknet_1_0__leaf_clk net42
+ _289_ VDD VSS DFF_X1
Xsine_out\[6\]$_SDFFE_PN0P_ _020_ clknet_1_0__leaf_clk net35
+ _288_ VDD VSS DFF_X1
Xsine_out\[7\]$_SDFFE_PN0P_ _021_ clknet_1_0__leaf_clk net44
+ _287_ VDD VSS DFF_X1
Xvalid_out$_SDFF_PN0_ _022_ clknet_1_1__leaf_clk net47 _286_
+ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_65 VDD VSS TAPCELL_X1
Xinput1 phase_in[0] net1 VDD VSS BUF_X2
Xinput2 phase_in[10] net2 VDD VSS BUF_X2
Xinput3 phase_in[11] net3 VDD VSS CLKBUF_X2
Xinput4 phase_in[12] net4 VDD VSS BUF_X1
Xinput5 phase_in[13] net5 VDD VSS BUF_X2
Xinput6 phase_in[1] net6 VDD VSS CLKBUF_X2
Xinput7 phase_in[2] net7 VDD VSS BUF_X2
Xinput8 phase_in[3] net8 VDD VSS CLKBUF_X2
Xinput9 phase_in[4] net9 VDD VSS CLKBUF_X2
Xinput10 phase_in[5] net10 VDD VSS CLKBUF_X2
Xinput11 phase_in[6] net11 VDD VSS CLKBUF_X2
Xinput12 phase_in[7] net12 VDD VSS BUF_X2
Xinput13 phase_in[8] net13 VDD VSS CLKBUF_X2
Xinput14 phase_in[9] net14 VDD VSS CLKBUF_X2
Xoutput15 net15 cosine_out[0] VDD VSS BUF_X1
Xoutput16 net16 cosine_out[10] VDD VSS BUF_X1
Xoutput17 net17 cosine_out[11] VDD VSS BUF_X1
Xoutput18 net18 cosine_out[12] VDD VSS BUF_X1
Xoutput19 net19 cosine_out[13] VDD VSS BUF_X1
Xoutput20 net20 cosine_out[14] VDD VSS BUF_X1
Xoutput21 net21 cosine_out[15] VDD VSS BUF_X1
Xoutput22 net22 cosine_out[1] VDD VSS BUF_X1
Xoutput23 net23 cosine_out[2] VDD VSS BUF_X1
Xoutput24 net24 cosine_out[3] VDD VSS BUF_X1
Xoutput25 net25 cosine_out[4] VDD VSS BUF_X1
Xoutput26 net26 cosine_out[5] VDD VSS BUF_X1
Xoutput27 net27 cosine_out[6] VDD VSS BUF_X1
Xoutput28 net28 cosine_out[7] VDD VSS BUF_X1
Xoutput29 net29 cosine_out[8] VDD VSS BUF_X1
Xoutput30 net30 cosine_out[9] VDD VSS BUF_X1
Xoutput31 net31 sine_out[0] VDD VSS BUF_X1
Xoutput32 net32 sine_out[10] VDD VSS BUF_X1
Xoutput33 net33 sine_out[11] VDD VSS BUF_X1
Xoutput34 net34 sine_out[12] VDD VSS BUF_X1
Xoutput35 net35 sine_out[13] VDD VSS BUF_X1
Xoutput36 net36 sine_out[14] VDD VSS BUF_X1
Xoutput37 net37 sine_out[15] VDD VSS BUF_X1
Xoutput38 net38 sine_out[1] VDD VSS BUF_X1
Xoutput39 net39 sine_out[2] VDD VSS BUF_X1
Xoutput40 net40 sine_out[3] VDD VSS BUF_X1
Xoutput41 net41 sine_out[4] VDD VSS BUF_X1
Xoutput42 net42 sine_out[5] VDD VSS BUF_X1
Xoutput43 net43 sine_out[6] VDD VSS BUF_X1
Xoutput44 net44 sine_out[7] VDD VSS BUF_X1
Xoutput45 net45 sine_out[8] VDD VSS BUF_X1
Xoutput46 net46 sine_out[9] VDD VSS BUF_X1
Xoutput47 net47 valid_out VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_1_0__leaf_clk _unconnected_0 VDD VSS CLKBUF_X1
.ENDS sine_cosine_generator
