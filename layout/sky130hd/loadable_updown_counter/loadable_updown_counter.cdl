* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT loadable_updown_counter clk count[0] count[1] count[2]
+ count[3] count[4] count[5] count[6] count[7] enable load_en
+ load_val[0] load_val[1] load_val[2] load_val[3] load_val[4]
+ load_val[5] load_val[6] load_val[7] overflow rst_n underflow
+ up_down
X_089_ net11 VSS VSS VDD VDD _072_ sky130_fd_sc_hd__inv_1
X_090_ net12 VSS VSS VDD VDD _073_ sky130_fd_sc_hd__inv_1
X_091_ net10 VSS VSS VDD VDD _076_ sky130_fd_sc_hd__clkinv_2
X_092_ enable VSS VSS VDD VDD _028_ sky130_fd_sc_hd__buf_2
X_093_ _028_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__buf_2
X_094_ load_en VSS VSS VDD VDD _030_ sky130_fd_sc_hd__buf_2
X_095_ _030_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__buf_2
X_096_ _031_ net11 VSS VSS VDD VDD _032_ sky130_fd_sc_hd__nor2_1
X_097_ _031_ net2 _032_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__a21oi_1
X_098_ _029_ net11 VSS VSS VDD VDD _034_ sky130_fd_sc_hd__nor2_1
X_099_ _029_ _033_ _034_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__a21oi_1
X_100_ _031_ net3 VSS VSS VDD VDD _035_ sky130_fd_sc_hd__nand2_1
X_101_ _031_ _075_ _035_ VSS VSS VDD VDD _036_ sky130_fd_sc_hd__o21ai_0
X_102_ _029_ _036_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__nand2_1
X_103_ _029_ _073_ _037_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__o21ai_0
X_104_ _080_ _074_ VSS VSS VDD VDD _038_ sky130_fd_sc_hd__nor2b_1
X_105_ _074_ _080_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__nor2b_1
X_106_ _030_ _038_ _039_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nor3_1
X_107_ _031_ net4 _040_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__a21oi_1
X_108_ _029_ net13 VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nor2_1
X_109_ _029_ _041_ _042_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__a21oi_1
X_110_ net11 _080_ _078_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nand3_1
X_111_ _080_ _077_ _079_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__a21oi_2
X_112_ _084_ _043_ _044_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__nand3_1
X_113_ _043_ _044_ _084_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__a21o_1
X_114_ _045_ _046_ _030_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__a21oi_1
X_115_ _031_ net5 _047_ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__a21oi_1
X_116_ _029_ net14 VSS VSS VDD VDD _049_ sky130_fd_sc_hd__nor2_1
X_117_ _029_ _048_ _049_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__a21oi_1
X_118_ _079_ _039_ _084_ VSS VSS VDD VDD _050_ sky130_fd_sc_hd__o21ai_0
X_119_ _082_ _083_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nor2_1
X_120_ _084_ _083_ _082_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__o21a_1
X_121_ _079_ _083_ _039_ _052_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__o31a_1
X_122_ _050_ _051_ _053_ _030_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__a211oi_1
X_123_ _031_ net6 _054_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__a21oi_1
X_124_ _029_ net15 VSS VSS VDD VDD _056_ sky130_fd_sc_hd__nor2_1
X_125_ _029_ _055_ _056_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__a21oi_1
X_126_ _082_ _083_ _081_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__a21oi_1
X_127_ _084_ _082_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__nand2_1
X_128_ _043_ _044_ _058_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__a21o_1
X_129_ _057_ _059_ VSS VSS VDD VDD _060_ sky130_fd_sc_hd__nand2_1
X_130_ _086_ _060_ VSS VSS VDD VDD _061_ sky130_fd_sc_hd__xnor2_1
X_131_ _030_ _028_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__nand2b_1
X_132_ _028_ net16 VSS VSS VDD VDD _063_ sky130_fd_sc_hd__nor2b_1
X_133_ _031_ _028_ net7 _063_ VSS VSS VDD VDD _064_ sky130_fd_sc_hd__a31oi_1
X_134_ _061_ _062_ _064_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__o21ai_0
X_135_ _081_ _053_ _086_ VSS VSS VDD VDD _065_ sky130_fd_sc_hd__o21a_1
X_136_ _088_ _062_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nor2_1
X_137_ _085_ _065_ _066_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__o21ai_0
X_138_ _030_ _028_ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__nor2b_1
X_139_ _088_ _068_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__nand2_1
X_140_ _085_ _065_ _069_ VSS VSS VDD VDD _070_ sky130_fd_sc_hd__or3_1
X_141_ _028_ net17 VSS VSS VDD VDD _071_ sky130_fd_sc_hd__nor2b_1
X_142_ _031_ _028_ net8 _071_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__a31oi_1
X_143_ _067_ _070_ _008_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__nand3_1
X_144_ _086_ _088_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__nand2_1
X_145_ _043_ _044_ _058_ _009_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__a211o_1
X_146_ _088_ _085_ _087_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__a21oi_1
X_147_ _057_ _009_ _011_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__o21a_1
X_148_ _028_ net18 VSS VSS VDD VDD _013_ sky130_fd_sc_hd__nand2_1
X_149_ _010_ _012_ _013_ _076_ _030_ VSS VSS VDD VDD _014_
+ sky130_fd_sc_hd__a2111o_1
X_150_ _030_ net10 _013_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__nor3_1
X_151_ _010_ _012_ _015_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__nand3_1
X_152_ _010_ _012_ _030_ net18 net10 VSS VSS VDD VDD _017_
+ sky130_fd_sc_hd__a2111o_1
X_153_ _030_ net18 VSS VSS VDD VDD _018_ sky130_fd_sc_hd__nor2_1
X_154_ net10 _010_ _012_ _018_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__nand4_1
X_155_ _014_ _016_ _017_ _019_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__nand4_1
X_156_ _031_ _028_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__nand2_1
X_157_ _028_ net18 net9 _021_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__o22ai_1
X_158_ _020_ _022_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__nor2_1
X_159_ net16 net15 net17 net18 VSS VSS VDD VDD _023_ sky130_fd_sc_hd__nand4_1
X_160_ net12 net10 _068_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__nand3_1
X_161_ net11 net14 net13 VSS VSS VDD VDD _025_ sky130_fd_sc_hd__nand3_1
X_162_ _023_ _024_ _025_ VSS VSS VDD VDD net19 sky130_fd_sc_hd__nor3_1
X_163_ net16 net15 net17 net18 VSS VSS VDD VDD _026_ sky130_fd_sc_hd__nor4_1
X_164_ _073_ _076_ _068_ _026_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nand4_1
X_165_ net11 net14 net13 _027_ VSS VSS VDD VDD net20 sky130_fd_sc_hd__nor4_1
X_166_ _072_ _073_ net10 VSS VSS VDD VDD _074_ _075_ sky130_fd_sc_hd__fa_1
X_167_ net12 _076_ VSS VSS VDD VDD _077_ _078_ sky130_fd_sc_hd__ha_1
X_168_ net13 _076_ VSS VSS VDD VDD _079_ _080_ sky130_fd_sc_hd__ha_1
X_169_ net15 _076_ VSS VSS VDD VDD _081_ _082_ sky130_fd_sc_hd__ha_1
X_170_ net14 _076_ VSS VSS VDD VDD _083_ _084_ sky130_fd_sc_hd__ha_1
X_171_ net16 _076_ VSS VSS VDD VDD _085_ _086_ sky130_fd_sc_hd__ha_1
X_172_ net17 _076_ VSS VSS VDD VDD _087_ _088_ sky130_fd_sc_hd__ha_1
Xcount\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _000_ net1 VSS
+ VSS VDD VDD net11 sky130_fd_sc_hd__dfrtp_2
Xcount\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _001_ net1 VSS
+ VSS VDD VDD net12 sky130_fd_sc_hd__dfrtp_1
Xcount\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _002_ net1 VSS
+ VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xcount\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _003_ net1 VSS
+ VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_2
Xcount\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _004_ net1 VSS
+ VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_2
Xcount\[5\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _005_ net1 VSS
+ VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_2
Xcount\[6\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _006_ net1 VSS
+ VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_2
Xcount\[7\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _007_ net1 VSS
+ VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_2
Xhold1 net21 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 load_val[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 load_val[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 load_val[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 load_val[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 load_val[4] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 load_val[5] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 load_val[6] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 load_val[7] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 up_down VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_2
Xoutput10 net11 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput11 net12 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD count[5] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD count[6] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD count[7] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD overflow sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD underflow sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net21 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS loadable_updown_counter
