* cell wishbone_master
* pin wb_dat_o[13]
* pin wb_dat_o[27]
* pin wb_dat_o[18]
* pin wb_dat_o[19]
* pin wb_dat_o[23]
* pin wb_dat_o[24]
* pin write_data[25]
* pin wb_dat_o[25]
* pin write_data[24]
* pin write_data[26]
* pin wb_dat_o[26]
* pin wb_dat_o[20]
* pin wb_dat_o[21]
* pin write_data[18]
* pin write_data[19]
* pin write_data[20]
* pin write_data[21]
* pin write_data[1]
* pin wb_dat_o[1]
* pin wb_dat_o[8]
* pin write_data[8]
* pin write_data[16]
* pin write_data[13]
* pin write_data[14]
* pin write_data[15]
* pin write_data[17]
* pin wb_dat_o[15]
* pin wb_dat_o[14]
* pin wb_dat_o[16]
* pin wb_dat_o[17]
* pin read_sel[0]
* pin read_sel[1]
* pin wb_sel_o[1]
* pin write_sel[0]
* pin write_data[11]
* pin write_sel[1]
* pin write_addr[8]
* pin wb_sel_o[0]
* pin wb_adr_o[8]
* pin wb_dat_o[12]
* pin wb_dat_o[11]
* pin read_addr[8]
* pin wb_dat_o[10]
* pin wb_adr_o[9]
* pin write_data[12]
* pin read_addr[7]
* pin write_addr[5]
* pin write_addr[6]
* pin wb_adr_o[7]
* pin wb_adr_o[5]
* pin read_addr[6]
* pin read_addr[5]
* pin write_data[0]
* pin write_addr[4]
* pin write_addr[7]
* pin wb_dat_o[0]
* pin write_data[10]
* pin write_addr[9]
* pin write_addr[3]
* pin read_addr[4]
* pin read_addr[9]
* pin wb_adr_o[4]
* pin read_addr[3]
* pin read_addr[19]
* pin PWELL
* pin read_addr[24]
* pin read_addr[25]
* pin NWELL
* pin read_sel[3]
* pin read_sel[2]
* pin read_addr[28]
* pin wb_dat_o[29]
* pin read_addr[29]
* pin wb_adr_o[28]
* pin wb_adr_o[31]
* pin write_data[27]
* pin write_data[29]
* pin write_addr[28]
* pin wb_adr_o[3]
* pin write_data[2]
* pin wb_dat_o[2]
* pin wb_adr_o[30]
* pin wb_adr_o[2]
* pin read_addr[30]
* pin write_addr[30]
* pin write_data[30]
* pin wb_dat_o[28]
* pin wb_adr_o[29]
* pin write_data[28]
* pin read_addr[31]
* pin write_addr[29]
* pin write_data[23]
* pin write_addr[31]
* pin wb_dat_o[30]
* pin write_data[22]
* pin write_addr[2]
* pin read_addr[2]
* pin write_data[31]
* pin wb_adr_o[6]
* pin read_addr[27]
* pin wb_dat_o[31]
* pin wb_dat_o[22]
* pin wb_adr_o[25]
* pin wb_dat_o[5]
* pin wb_adr_o[27]
* pin wb_adr_o[26]
* pin write_data[5]
* pin rst_n
* pin write_addr[27]
* pin read_addr[26]
* pin write_data[9]
* pin wb_dat_o[9]
* pin write_addr[26]
* pin write_data[3]
* pin write_addr[25]
* pin wb_dat_o[7]
* pin write_sel[2]
* pin write_addr[24]
* pin write_data[7]
* pin wb_dat_o[3]
* pin write_data[4]
* pin wb_sel_o[2]
* pin wb_sel_o[3]
* pin wb_adr_o[24]
* pin write_data[6]
* pin write_sel[3]
* pin wb_dat_o[6]
* pin wb_dat_o[4]
* pin read_req
* pin write_err
* pin write_addr[19]
* pin write_addr[21]
* pin write_req
* pin read_addr[21]
* pin wb_adr_o[19]
* pin wb_adr_o[1]
* pin write_addr[1]
* pin wb_adr_o[21]
* pin clk
* pin wb_we_o
* pin wb_adr_o[14]
* pin read_addr[14]
* pin wb_rty_i
* pin write_addr[22]
* pin read_addr[1]
* pin wb_err_i
* pin wb_stb_o
* pin wb_adr_o[23]
* pin read_addr[22]
* pin write_addr[10]
* pin read_data[15]
* pin write_addr[23]
* pin wb_adr_o[20]
* pin wb_dat_i[15]
* pin read_addr[23]
* pin wb_dat_i[11]
* pin read_data[11]
* pin read_addr[17]
* pin wb_adr_o[22]
* pin wb_dat_i[14]
* pin wb_dat_i[12]
* pin wb_cyc_o
* pin write_addr[20]
* pin read_data[14]
* pin read_data[12]
* pin wb_adr_o[16]
* pin wb_adr_o[17]
* pin wb_dat_i[16]
* pin wb_dat_i[0]
* pin wb_adr_o[10]
* pin write_addr[17]
* pin wb_adr_o[18]
* pin wb_dat_i[13]
* pin read_data[0]
* pin write_addr[11]
* pin write_addr[16]
* pin wb_ack_i
* pin read_data[10]
* pin wb_dat_i[10]
* pin read_data[13]
* pin wb_adr_o[15]
* pin write_addr[18]
* pin read_addr[20]
* pin read_data[31]
* pin read_addr[10]
* pin read_addr[16]
* pin read_addr[15]
* pin read_data[3]
* pin write_addr[15]
* pin read_addr[18]
* pin write_addr[14]
* pin write_addr[0]
* pin read_addr[12]
* pin wb_adr_o[0]
* pin read_addr[0]
* pin read_data[20]
* pin read_data[29]
* pin read_data[16]
* pin wb_dat_i[25]
* pin read_data[17]
* pin read_data[24]
* pin wb_dat_i[9]
* pin read_data[21]
* pin read_data[8]
* pin read_data[2]
* pin read_addr[11]
* pin wb_tgd_o
* pin read_data[6]
* pin wb_dat_i[19]
* pin read_data[19]
* pin wb_adr_o[11]
* pin read_data[25]
* pin wb_dat_i[18]
* pin wb_dat_i[28]
* pin wb_dat_i[1]
* pin read_data[18]
* pin wb_dat_i[17]
* pin read_data[1]
* pin wb_dat_i[24]
* pin read_data[23]
* pin read_data[28]
* pin read_data[4]
* pin wb_dat_i[31]
* pin read_done
* pin wb_dat_i[22]
* pin wb_dat_i[20]
* pin write_done
* pin wb_dat_i[21]
* pin read_data[22]
* pin wb_dat_i[29]
* pin read_err
* pin wb_dat_i[5]
* pin wb_dat_i[8]
* pin wb_dat_i[7]
* pin wb_dat_i[26]
* pin read_data[5]
* pin read_data[26]
* pin read_addr[13]
* pin read_data[9]
* pin write_addr[13]
* pin wb_adr_o[13]
* pin write_addr[12]
* pin wb_dat_i[2]
* pin read_data[30]
* pin wb_dat_i[6]
* pin read_data[7]
* pin wb_adr_o[12]
* pin wb_dat_i[4]
* pin wb_dat_i[30]
* pin wb_dat_i[23]
* pin wb_dat_i[27]
* pin read_data[27]
* pin wb_dat_i[3]
.SUBCKT wishbone_master 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47
+ 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 81 85 113 114 116 142 143 164
+ 171 180 181 182 183 198 207 208 214 215 224 225 228 245 246 248 254 255 256
+ 257 261 272 282 283 290 291 292 302 305 307 308 313 314 319 322 325 326 333
+ 341 342 343 346 350 355 361 367 368 372 373 374 385 386 387 397 399 403 416
+ 417 418 428 429 430 445 446 458 459 460 467 478 485 486 497 501 502 513 519
+ 530 531 544 555 562 563 568 577 583 584 588 589 597 598 607 608 613 614 624
+ 625 631 632 640 641 642 654 655 668 669 678 680 681 682 700 701 702 703 725
+ 727 728 729 730 732 733 735 746 747 750 777 779 799 801 803 807 811 812 813
+ 816 824 825 828 829 830 831 832 833 834 835 836 837 838 839 840 841 842 844
+ 845 846 847 848 849 851 852 853 854 855 856 857 858 859 860 861 862 863 864
+ 865 866 867 868 869 870 871 872 873 874 875
* net 1 wb_dat_o[13]
* net 2 wb_dat_o[27]
* net 3 wb_dat_o[18]
* net 4 wb_dat_o[19]
* net 5 wb_dat_o[23]
* net 6 wb_dat_o[24]
* net 7 write_data[25]
* net 8 wb_dat_o[25]
* net 9 write_data[24]
* net 10 write_data[26]
* net 11 wb_dat_o[26]
* net 12 wb_dat_o[20]
* net 13 wb_dat_o[21]
* net 14 write_data[18]
* net 15 write_data[19]
* net 16 write_data[20]
* net 17 write_data[21]
* net 18 write_data[1]
* net 19 wb_dat_o[1]
* net 20 wb_dat_o[8]
* net 21 write_data[8]
* net 22 write_data[16]
* net 23 write_data[13]
* net 24 write_data[14]
* net 25 write_data[15]
* net 26 write_data[17]
* net 27 wb_dat_o[15]
* net 28 wb_dat_o[14]
* net 29 wb_dat_o[16]
* net 30 wb_dat_o[17]
* net 31 read_sel[0]
* net 32 read_sel[1]
* net 33 wb_sel_o[1]
* net 34 write_sel[0]
* net 35 write_data[11]
* net 36 write_sel[1]
* net 37 write_addr[8]
* net 38 wb_sel_o[0]
* net 39 wb_adr_o[8]
* net 40 wb_dat_o[12]
* net 41 wb_dat_o[11]
* net 42 read_addr[8]
* net 43 wb_dat_o[10]
* net 44 wb_adr_o[9]
* net 45 write_data[12]
* net 46 read_addr[7]
* net 47 write_addr[5]
* net 48 write_addr[6]
* net 49 wb_adr_o[7]
* net 50 wb_adr_o[5]
* net 51 read_addr[6]
* net 52 read_addr[5]
* net 53 write_data[0]
* net 54 write_addr[4]
* net 55 write_addr[7]
* net 56 wb_dat_o[0]
* net 57 write_data[10]
* net 58 write_addr[9]
* net 59 write_addr[3]
* net 60 read_addr[4]
* net 61 read_addr[9]
* net 62 wb_adr_o[4]
* net 63 read_addr[3]
* net 81 read_addr[19]
* net 85 PWELL
* net 113 read_addr[24]
* net 114 read_addr[25]
* net 116 NWELL
* net 142 read_sel[3]
* net 143 read_sel[2]
* net 164 read_addr[28]
* net 171 wb_dat_o[29]
* net 180 read_addr[29]
* net 181 wb_adr_o[28]
* net 182 wb_adr_o[31]
* net 183 write_data[27]
* net 198 write_data[29]
* net 207 write_addr[28]
* net 208 wb_adr_o[3]
* net 214 write_data[2]
* net 215 wb_dat_o[2]
* net 224 wb_adr_o[30]
* net 225 wb_adr_o[2]
* net 228 read_addr[30]
* net 245 write_addr[30]
* net 246 write_data[30]
* net 248 wb_dat_o[28]
* net 254 wb_adr_o[29]
* net 255 write_data[28]
* net 256 read_addr[31]
* net 257 write_addr[29]
* net 261 write_data[23]
* net 272 write_addr[31]
* net 282 wb_dat_o[30]
* net 283 write_data[22]
* net 290 write_addr[2]
* net 291 read_addr[2]
* net 292 write_data[31]
* net 302 wb_adr_o[6]
* net 305 read_addr[27]
* net 307 wb_dat_o[31]
* net 308 wb_dat_o[22]
* net 313 wb_adr_o[25]
* net 314 wb_dat_o[5]
* net 319 wb_adr_o[27]
* net 322 wb_adr_o[26]
* net 325 write_data[5]
* net 326 rst_n
* net 333 write_addr[27]
* net 341 read_addr[26]
* net 342 write_data[9]
* net 343 wb_dat_o[9]
* net 346 write_addr[26]
* net 350 write_data[3]
* net 355 write_addr[25]
* net 361 wb_dat_o[7]
* net 367 write_sel[2]
* net 368 write_addr[24]
* net 372 write_data[7]
* net 373 wb_dat_o[3]
* net 374 write_data[4]
* net 385 wb_sel_o[2]
* net 386 wb_sel_o[3]
* net 387 wb_adr_o[24]
* net 397 write_data[6]
* net 399 write_sel[3]
* net 403 wb_dat_o[6]
* net 416 wb_dat_o[4]
* net 417 read_req
* net 418 write_err
* net 428 write_addr[19]
* net 429 write_addr[21]
* net 430 write_req
* net 445 read_addr[21]
* net 446 wb_adr_o[19]
* net 458 wb_adr_o[1]
* net 459 write_addr[1]
* net 460 wb_adr_o[21]
* net 467 clk
* net 478 wb_we_o
* net 485 wb_adr_o[14]
* net 486 read_addr[14]
* net 497 wb_rty_i
* net 501 write_addr[22]
* net 502 read_addr[1]
* net 513 wb_err_i
* net 519 wb_stb_o
* net 530 wb_adr_o[23]
* net 531 read_addr[22]
* net 544 write_addr[10]
* net 555 read_data[15]
* net 562 write_addr[23]
* net 563 wb_adr_o[20]
* net 568 wb_dat_i[15]
* net 577 read_addr[23]
* net 583 wb_dat_i[11]
* net 584 read_data[11]
* net 588 read_addr[17]
* net 589 wb_adr_o[22]
* net 597 wb_dat_i[14]
* net 598 wb_dat_i[12]
* net 607 wb_cyc_o
* net 608 write_addr[20]
* net 613 read_data[14]
* net 614 read_data[12]
* net 624 wb_adr_o[16]
* net 625 wb_adr_o[17]
* net 631 wb_dat_i[16]
* net 632 wb_dat_i[0]
* net 640 wb_adr_o[10]
* net 641 write_addr[17]
* net 642 wb_adr_o[18]
* net 654 wb_dat_i[13]
* net 655 read_data[0]
* net 668 write_addr[11]
* net 669 write_addr[16]
* net 678 wb_ack_i
* net 680 read_data[10]
* net 681 wb_dat_i[10]
* net 682 read_data[13]
* net 700 wb_adr_o[15]
* net 701 write_addr[18]
* net 702 read_addr[20]
* net 703 read_data[31]
* net 725 read_addr[10]
* net 727 read_addr[16]
* net 728 read_addr[15]
* net 729 read_data[3]
* net 730 write_addr[15]
* net 732 read_addr[18]
* net 733 write_addr[14]
* net 735 write_addr[0]
* net 746 read_addr[12]
* net 747 wb_adr_o[0]
* net 750 read_addr[0]
* net 777 read_data[20]
* net 779 read_data[29]
* net 799 read_data[16]
* net 801 wb_dat_i[25]
* net 803 read_data[17]
* net 807 read_data[24]
* net 811 wb_dat_i[9]
* net 812 read_data[21]
* net 813 read_data[8]
* net 816 read_data[2]
* net 824 read_addr[11]
* net 825 wb_tgd_o
* net 828 read_data[6]
* net 829 wb_dat_i[19]
* net 830 read_data[19]
* net 831 wb_adr_o[11]
* net 832 read_data[25]
* net 833 wb_dat_i[18]
* net 834 wb_dat_i[28]
* net 835 wb_dat_i[1]
* net 836 read_data[18]
* net 837 wb_dat_i[17]
* net 838 read_data[1]
* net 839 wb_dat_i[24]
* net 840 read_data[23]
* net 841 read_data[28]
* net 842 read_data[4]
* net 844 wb_dat_i[31]
* net 845 read_done
* net 846 wb_dat_i[22]
* net 847 wb_dat_i[20]
* net 848 write_done
* net 849 wb_dat_i[21]
* net 851 read_data[22]
* net 852 wb_dat_i[29]
* net 853 read_err
* net 854 wb_dat_i[5]
* net 855 wb_dat_i[8]
* net 856 wb_dat_i[7]
* net 857 wb_dat_i[26]
* net 858 read_data[5]
* net 859 read_data[26]
* net 860 read_addr[13]
* net 861 read_data[9]
* net 862 write_addr[13]
* net 863 wb_adr_o[13]
* net 864 write_addr[12]
* net 865 wb_dat_i[2]
* net 866 read_data[30]
* net 867 wb_dat_i[6]
* net 868 read_data[7]
* net 869 wb_adr_o[12]
* net 870 wb_dat_i[4]
* net 871 wb_dat_i[30]
* net 872 wb_dat_i[23]
* net 873 wb_dat_i[27]
* net 874 read_data[27]
* net 875 wb_dat_i[3]
* cell instance $2 r0 *1 4.56,1.4
X$2 68 85 116 1 BUF_X1
* cell instance $12 r0 *1 7.03,4.2
X$12 155 85 116 2 BUF_X1
* cell instance $14 r0 *1 7.22,1.4
X$14 64 85 116 3 BUF_X1
* cell instance $20 r0 *1 9.12,1.4
X$20 86 85 116 4 BUF_X1
* cell instance $26 r0 *1 8.55,1.4
X$26 65 85 116 5 BUF_X1
* cell instance $32 r0 *1 7.79,1.4
X$32 93 85 116 6 BUF_X1
* cell instance $38 r0 *1 9.69,1.4
X$38 7 85 116 118 BUF_X1
* cell instance $44 r0 *1 10.26,1.4
X$44 127 85 116 8 BUF_X1
* cell instance $50 r0 *1 10.83,1.4
X$50 9 85 116 83 BUF_X1
* cell instance $56 m0 *1 9.88,4.2
X$56 10 85 116 128 BUF_X1
* cell instance $62 m0 *1 12.35,7
X$62 189 85 116 11 BUF_X1
* cell instance $72 r0 *1 12.54,4.2
X$72 202 85 116 12 BUF_X1
* cell instance $74 r0 *1 13.3,7
X$74 227 85 116 13 BUF_X1
* cell instance $80 r0 *1 13.11,4.2
X$80 14 85 116 166 BUF_X1
* cell instance $86 r0 *1 11.97,4.2
X$86 15 85 116 95 BUF_X1
* cell instance $92 m0 *1 14.63,7
X$92 16 85 116 229 BUF_X1
* cell instance $98 m0 *1 15.2,7
X$98 17 85 116 231 BUF_X1
* cell instance $104 r0 *1 14.44,1.4
X$104 18 85 116 98 BUF_X1
* cell instance $110 r0 *1 17.1,4.2
X$110 157 85 116 19 BUF_X1
* cell instance $116 r0 *1 15.01,1.4
X$116 87 85 116 20 BUF_X1
* cell instance $122 r0 *1 13.49,1.4
X$122 21 85 116 201 BUF_X1
* cell instance $128 r0 *1 18.62,4.2
X$128 22 85 116 194 BUF_X1
* cell instance $134 r0 *1 15.58,1.4
X$134 23 85 116 67 BUF_X1
* cell instance $140 r0 *1 18.05,1.4
X$140 24 85 116 100 BUF_X1
* cell instance $146 r0 *1 17.48,1.4
X$146 25 85 116 99 BUF_X1
* cell instance $152 m0 *1 20.33,4.2
X$152 26 85 116 122 BUF_X1
* cell instance $158 r0 *1 19.95,1.4
X$158 70 85 116 27 BUF_X1
* cell instance $164 r0 *1 21.85,1.4
X$164 71 85 116 28 BUF_X1
* cell instance $170 r0 *1 19.57,4.2
X$170 175 85 116 29 BUF_X1
* cell instance $176 r0 *1 22.61,1.4
X$176 88 85 116 30 BUF_X1
* cell instance $186 r0 *1 23.56,1.4
X$186 31 85 116 72 BUF_X1
* cell instance $192 r0 *1 24.13,1.4
X$192 32 85 116 102 BUF_X1
* cell instance $194 r0 *1 24.7,1.4
X$194 252 85 116 33 BUF_X1
* cell instance $200 r0 *1 25.84,1.4
X$200 34 85 116 154 BUF_X1
* cell instance $206 r0 *1 26.41,1.4
X$206 35 85 116 73 BUF_X1
* cell instance $212 r0 *1 25.27,1.4
X$212 36 85 116 124 BUF_X1
* cell instance $218 r0 *1 28.31,1.4
X$218 37 85 116 89 BUF_X1
* cell instance $226 m0 *1 26.79,4.2
X$226 131 85 116 38 BUF_X1
* cell instance $230 m0 *1 27.55,4.2
X$230 133 85 116 39 BUF_X1
* cell instance $236 r0 *1 30.59,4.2
X$236 160 85 116 40 BUF_X1
* cell instance $242 m0 *1 28.31,7
X$242 74 85 116 41 BUF_X1
* cell instance $248 r0 *1 29.45,4.2
X$248 42 85 116 170 BUF_X1
* cell instance $254 r0 *1 30.02,4.2
X$254 78 85 116 43 BUF_X1
* cell instance $260 r0 *1 30.97,1.4
X$260 76 85 116 44 BUF_X1
* cell instance $266 r0 *1 31.54,1.4
X$266 45 85 116 134 BUF_X1
* cell instance $272 r0 *1 37.24,1.4
X$272 46 85 116 106 BUF_X1
* cell instance $278 r0 *1 33.25,4.2
X$278 47 85 116 147 BUF_X1
* cell instance $284 r0 *1 38.95,1.4
X$284 48 85 116 119 BUF_X1
* cell instance $290 r0 *1 32.68,7
X$290 219 85 116 49 BUF_X1
* cell instance $296 r0 *1 34.2,1.4
X$296 79 85 116 50 BUF_X1
* cell instance $302 r0 *1 39.14,4.2
X$302 51 85 116 108 BUF_X1
* cell instance $312 r0 *1 35.34,1.4
X$312 52 85 116 80 BUF_X1
* cell instance $314 r0 *1 34.77,1.4
X$314 53 85 116 121 BUF_X1
* cell instance $320 r0 *1 44.84,1.4
X$320 54 85 116 112 BUF_X1
* cell instance $326 r0 *1 37.81,1.4
X$326 55 85 116 107 BUF_X1
* cell instance $332 r0 *1 38.38,1.4
X$332 105 85 116 56 BUF_X1
* cell instance $338 r0 *1 33.82,4.2
X$338 57 85 116 91 BUF_X1
* cell instance $344 m0 *1 37.24,7
X$344 58 85 116 196 BUF_X1
* cell instance $350 r0 *1 40.85,1.4
X$350 59 85 116 110 BUF_X1
* cell instance $356 r0 *1 41.42,1.4
X$356 60 85 116 117 BUF_X1
* cell instance $362 r0 *1 40.09,4.2
X$362 61 85 116 165 BUF_X1
* cell instance $368 m0 *1 39.33,7
X$368 162 85 116 62 BUF_X1
* cell instance $374 r0 *1 40.66,4.2
X$374 63 85 116 138 BUF_X1
* cell instance $380 r0 *1 8.74,4.2
X$380 85 936 64 188 126 116 DFF_X1
* cell instance $382 m0 *1 10.45,4.2
X$382 166 94 64 85 116 156 MUX2_X1
* cell instance $389 r0 *1 6.08,9.8
X$389 274 94 65 85 116 264 MUX2_X1
* cell instance $392 m0 *1 5.51,9.8
X$392 85 884 65 258 126 116 DFF_X1
* cell instance $396 r0 *1 11.4,1.4
X$396 95 94 86 85 116 66 MUX2_X1
* cell instance $398 r0 *1 12.73,1.4
X$398 96 66 116 85 97 AND2_X1
* cell instance $400 r0 *1 16.15,1.4
X$400 67 69 68 85 116 150 MUX2_X1
* cell instance $404 m0 *1 16.34,4.2
X$404 85 886 68 151 129 116 DFF_X1
* cell instance $410 r0 *1 20.52,1.4
X$410 122 69 88 85 116 101 MUX2_X1
* cell instance $412 m0 *1 31.35,4.2
X$412 134 69 160 85 116 168 MUX2_X1
* cell instance $415 r0 *1 26.98,1.4
X$415 73 69 74 85 116 75 MUX2_X1
* cell instance $417 r0 *1 32.11,1.4
X$417 91 69 78 85 116 90 MUX2_X1
* cell instance $419 m0 *1 32.68,4.2
X$419 121 69 105 85 116 104 MUX2_X1
* cell instance $422 m0 *1 17.67,18.2
X$422 266 85 116 69 CLKBUF_X3
* cell instance $425 m0 *1 19.19,7
X$425 194 69 175 85 116 203 MUX2_X1
* cell instance $429 r0 *1 17.1,7
X$429 99 69 70 85 116 218 MUX2_X1
* cell instance $431 r0 *1 18.62,1.4
X$431 100 69 71 85 116 152 MUX2_X1
* cell instance $436 m0 *1 16.15,29.4
X$436 511 482 69 515 528 116 85 536 OAI221_X1
* cell instance $451 m0 *1 16.15,9.8
X$451 85 901 70 251 129 116 DFF_X1
* cell instance $456 m0 *1 20.9,4.2
X$456 85 905 71 153 158 116 DFF_X1
* cell instance $464 m0 *1 25.46,4.2
X$464 72 103 154 85 116 132 MUX2_X1
* cell instance $470 m0 *1 25.08,7
X$470 85 918 74 176 158 116 DFF_X1
* cell instance $474 r0 *1 25.46,4.2
X$474 77 75 116 85 176 AND2_X1
* cell instance $479 m0 *1 28.69,12.6
X$479 85 915 76 301 270 116 DFF_X1
* cell instance $481 r0 *1 32.11,9.8
X$481 76 249 204 85 116 267 MUX2_X1
* cell instance $488 m0 *1 21.47,12.6
X$488 265 85 116 77 BUF_X2
* cell instance $490 r0 *1 36.29,12.6
X$490 77 304 116 85 303 AND2_X1
* cell instance $492 m0 *1 32.11,12.6
X$492 77 267 116 85 301 AND2_X1
* cell instance $495 m0 *1 36.29,7
X$495 77 137 116 85 161 AND2_X1
* cell instance $499 r0 *1 29.45,9.8
X$499 77 242 116 85 260 AND2_X1
* cell instance $501 r0 *1 30.21,1.4
X$501 77 90 116 85 123 AND2_X1
* cell instance $503 r0 *1 31.73,4.2
X$503 77 168 116 85 169 AND2_X1
* cell instance $505 r0 *1 32.49,4.2
X$505 77 197 116 85 177 AND2_X1
* cell instance $507 r0 *1 33.44,1.4
X$507 77 104 116 85 148 AND2_X1
* cell instance $509 r0 *1 31.92,7
X$509 77 235 116 85 243 AND2_X1
* cell instance $526 m0 *1 28.12,4.2
X$526 85 908 78 123 149 116 DFF_X1
* cell instance $532 m0 *1 34.77,7
X$532 79 136 120 85 116 197 MUX2_X1
* cell instance $534 m0 *1 31.54,7
X$534 85 911 79 177 149 116 DFF_X1
* cell instance $537 r0 *1 35.91,1.4
X$537 80 103 147 85 116 120 MUX2_X1
* cell instance $540 m0 *1 44.84,9.8
X$540 81 85 116 332 BUF_X1
* cell instance $545 r0 *1 2.66,1.4
X$545 82 125 116 85 115 AND2_X1
* cell instance $548 r0 *1 8.36,12.6
X$548 82 310 116 85 338 AND2_X1
* cell instance $550 r0 *1 3.04,12.6
X$550 82 284 116 85 285 AND2_X1
* cell instance $552 m0 *1 8.36,12.6
X$552 265 85 116 82 CLKBUF_X2
* cell instance $555 m0 *1 3.04,9.8
X$555 82 239 116 85 240 AND2_X1
* cell instance $557 r0 *1 7.41,9.8
X$557 82 264 116 85 258 AND2_X1
* cell instance $559 r0 *1 8.93,7
X$559 82 212 116 85 226 AND2_X1
* cell instance $561 r0 *1 5.13,1.4
X$561 82 84 116 85 92 AND2_X1
* cell instance $564 r0 *1 7.79,4.2
X$564 82 167 116 85 187 AND2_X1
* cell instance $566 m0 *1 4.56,7
X$566 82 209 116 85 186 AND2_X1
* cell instance $568 m0 *1 3.8,7
X$568 82 185 116 85 174 AND2_X1
* cell instance $584 r0 *1 5.89,1.4
X$584 83 94 93 85 116 84 MUX2_X1
* cell instance $590 m0 *1 19.76,32.2
X$590 582 85 116 573 INV_X1
* cell instance $591 m0 *1 18.05,32.2
X$591 580 365 573 542 581 116 85 AOI211_X2
* cell instance $596 m0 *1 30.21,32.2
X$596 268 85 116 526 CLKBUF_X3
* cell instance $597 m0 *1 31.16,32.2
X$597 526 85 116 INV_X2
* cell instance $599 m0 *1 33.25,32.2
X$599 85 899 559 558 526 116 DFF_X1
* cell instance $600 m0 *1 36.48,32.2
X$600 85 893 543 596 526 116 DFF_X1
* cell instance $601 m0 *1 39.71,32.2
X$601 268 85 116 476 CLKBUF_X3
* cell instance $604 r0 *1 18.24,32.2
X$604 528 469 85 116 610 NAND2_X1
* cell instance $606 r0 *1 19,32.2
X$606 557 586 345 116 612 85 OAI21_X1
* cell instance $609 r0 *1 20.33,32.2
X$609 85 978 582 581 526 116 DFF_X1
* cell instance $614 r0 *1 26.41,32.2
X$614 345 85 116 551 BUF_X2
* cell instance $619 r0 *1 37.24,32.2
X$619 452 595 116 85 596 AND2_X1
* cell instance $620 r0 *1 38,32.2
X$620 543 328 593 85 116 595 MUX2_X1
* cell instance $622 r0 *1 39.52,32.2
X$622 594 384 609 85 116 593 MUX2_X1
* cell instance $624 r0 *1 41.04,32.2
X$624 85 961 560 574 476 116 DFF_X1
* cell instance $625 m0 *1 41.8,32.2
X$625 517 85 116 530 BUF_X1
* cell instance $626 m0 *1 41.04,32.2
X$626 452 561 116 85 574 AND2_X1
* cell instance $628 m0 *1 44.08,32.2
X$628 531 85 116 518 BUF_X1
* cell instance $629 m0 *1 42.75,32.2
X$629 575 469 591 85 116 566 MUX2_X1
* cell instance $630 m0 *1 44.65,32.2
X$630 576 384 587 85 116 545 MUX2_X1
* cell instance $633 r0 *1 44.46,32.2
X$633 544 85 116 591 BUF_X1
* cell instance $635 r0 *1 45.41,32.2
X$635 562 85 116 587 BUF_X1
* cell instance $640 m0 *1 5.13,26.6
X$640 473 85 116 418 BUF_X1
* cell instance $652 r0 *1 4.18,26.6
X$652 487 85 116 478 BUF_X1
* cell instance $655 r0 *1 8.17,26.6
X$655 85 959 473 520 532 116 DFF_X1
* cell instance $656 r0 *1 11.4,26.6
X$656 473 85 116 521 INV_X1
* cell instance $657 r0 *1 11.78,26.6
X$657 504 116 409 85 BUF_X4
* cell instance $658 r0 *1 13.11,26.6
X$658 488 498 408 85 116 422 OR3_X1
* cell instance $660 m0 *1 13.68,26.6
X$660 455 489 85 116 454 NOR2_X2
* cell instance $661 r0 *1 14.06,26.6
X$661 489 455 461 85 116 515 OR3_X1
* cell instance $663 m0 *1 15.77,26.6
X$663 443 479 462 85 116 480 NAND3_X1
* cell instance $664 m0 *1 15.01,26.6
X$664 489 455 409 116 464 85 OAI21_X1
* cell instance $666 m0 *1 16.72,26.6
X$666 468 85 116 481 INV_X1
* cell instance $670 r0 *1 15.58,26.6
X$670 490 456 85 116 508 NOR2_X1
* cell instance $672 r0 *1 16.34,26.6
X$672 481 443 85 116 490 NOR2_X1
* cell instance $673 r0 *1 16.91,26.6
X$673 481 409 515 85 116 512 MUX2_X1
* cell instance $675 m0 *1 18.43,26.6
X$675 409 469 462 85 116 491 NOR3_X1
* cell instance $677 r0 *1 18.24,26.6
X$677 468 491 365 482 512 495 116 85 AOI221_X2
* cell instance $678 m0 *1 19.76,26.6
X$678 411 85 116 483 INV_X1
* cell instance $683 r0 *1 20.33,26.6
X$683 456 483 85 116 482 NAND2_X1
* cell instance $685 r0 *1 21.09,26.6
X$685 487 85 116 511 INV_X1
* cell instance $687 r0 *1 21.85,26.6
X$687 462 85 116 492 INV_X1
* cell instance $688 r0 *1 22.23,26.6
X$688 103 492 85 116 572 NOR2_X1
* cell instance $690 m0 *1 22.8,26.6
X$690 412 85 116 479 INV_X1
* cell instance $691 m0 *1 26.22,26.6
X$691 412 116 469 85 BUF_X4
* cell instance $695 m0 *1 32.3,26.6
X$695 85 484 116 249 BUF_X8
* cell instance $697 r0 *1 22.8,26.6
X$697 492 408 487 116 496 85 OAI21_X1
* cell instance $698 r0 *1 23.56,26.6
X$698 479 408 496 116 509 85 OAI21_X1
* cell instance $699 r0 *1 24.32,26.6
X$699 345 509 116 85 510 AND2_X1
* cell instance $703 m0 *1 35.15,26.6
X$703 85 892 470 477 476 116 DFF_X1
* cell instance $706 m0 *1 38.95,26.6
X$706 452 475 116 85 477 AND2_X1
* cell instance $710 r0 *1 38.95,26.6
X$710 551 493 116 85 506 AND2_X1
* cell instance $711 r0 *1 39.71,26.6
X$711 85 966 500 506 476 116 DFF_X1
* cell instance $712 m0 *1 42.94,26.6
X$712 470 85 116 458 BUF_X1
* cell instance $713 m0 *1 41.61,26.6
X$713 470 328 474 85 116 475 MUX2_X1
* cell instance $714 m0 *1 43.51,26.6
X$714 471 384 472 85 116 474 MUX2_X1
* cell instance $715 m0 *1 44.84,26.6
X$715 459 85 116 472 BUF_X1
* cell instance $717 r0 *1 42.94,26.6
X$717 500 484 505 85 116 493 MUX2_X1
* cell instance $718 r0 *1 44.27,26.6
X$718 503 469 494 85 116 505 MUX2_X1
* cell instance $723 m0 *1 5.51,21
X$723 85 912 389 379 327 116 DFF_X1
* cell instance $724 m0 *1 2.28,21
X$724 85 925 388 376 327 116 DFF_X1
* cell instance $726 m0 *1 9.5,21
X$726 85 888 380 391 394 116 DFF_X1
* cell instance $727 m0 *1 12.73,21
X$727 422 380 85 116 415 NAND2_X1
* cell instance $729 m0 *1 13.49,21
X$729 365 401 407 85 381 116 AOI21_X1
* cell instance $730 m0 *1 14.25,21
X$730 382 435 410 85 116 401 OR3_X1
* cell instance $732 m0 *1 1.33,21
X$732 397 85 116 431 BUF_X1
* cell instance $736 r0 *1 1.33,21
X$736 404 85 116 416 BUF_X1
* cell instance $737 r0 *1 1.9,21
X$737 405 85 116 403 BUF_X1
* cell instance $738 r0 *1 2.47,21
X$738 286 419 116 85 420 AND2_X1
* cell instance $742 r0 *1 3.23,21
X$742 431 172 405 85 116 433 MUX2_X1
* cell instance $743 r0 *1 4.56,21
X$743 266 85 116 172 CLKBUF_X3
* cell instance $746 r0 *1 6.08,21
X$746 286 433 116 85 432 AND2_X1
* cell instance $747 r0 *1 6.84,21
X$747 85 987 405 432 327 116 DFF_X1
* cell instance $748 r0 *1 10.07,21
X$748 380 410 415 85 116 364 MUX2_X1
* cell instance $749 r0 *1 11.4,21
X$749 380 406 421 116 85 423 HA_X1
* cell instance $750 r0 *1 13.3,21
X$750 406 382 380 85 116 424 NAND3_X1
* cell instance $751 r0 *1 14.06,21
X$751 423 85 116 435 INV_X1
* cell instance $753 r0 *1 14.82,21
X$753 410 435 382 408 409 116 85 407 OAI221_X1
* cell instance $754 m0 *1 16.53,21
X$754 85 934 411 402 394 116 DFF_X1
* cell instance $755 m0 *1 15.58,21
X$755 268 85 116 394 CLKBUF_X3
* cell instance $760 r0 *1 15.96,21
X$760 409 408 411 424 410 116 85 437 OAI221_X1
* cell instance $761 r0 *1 17.1,21
X$761 411 410 424 85 116 438 OR3_X1
* cell instance $762 r0 *1 18.05,21
X$762 365 438 437 85 402 116 AOI21_X1
* cell instance $764 r0 *1 19.19,21
X$764 85 436 425 441 394 116 DFF_X1
* cell instance $766 r0 *1 22.8,21
X$766 436 85 116 408 BUF_X2
* cell instance $769 m0 *1 35.53,21
X$769 345 400 116 85 366 AND2_X1
* cell instance $773 r0 *1 36.1,21
X$773 85 328 116 249 BUF_X8
* cell instance $774 m0 *1 36.86,21
X$774 383 249 396 85 116 400 MUX2_X1
* cell instance $777 m0 *1 41.8,21
X$777 383 85 116 386 BUF_X1
* cell instance $778 m0 *1 38.57,21
X$778 85 885 398 395 318 116 DFF_X1
* cell instance $780 m0 *1 42.56,21
X$780 398 328 393 85 116 392 MUX2_X1
* cell instance $781 m0 *1 43.89,21
X$781 398 85 116 387 BUF_X1
* cell instance $783 m0 *1 44.65,21
X$783 332 384 413 85 116 414 MUX2_X1
* cell instance $788 r0 *1 40.66,21
X$788 412 85 116 111 CLKBUF_X3
* cell instance $791 r0 *1 42.18,21
X$791 430 116 412 85 BUF_X4
* cell instance $792 r0 *1 43.51,21
X$792 451 328 414 85 116 434 MUX2_X1
* cell instance $793 r0 *1 44.84,21
X$793 429 85 116 450 BUF_X1
* cell instance $794 r0 *1 45.41,21
X$794 428 85 116 413 BUF_X1
* cell instance $796 m0 *1 1.9,29.4
X$796 85 929 565 514 532 116 DFF_X1
* cell instance $801 r0 *1 1.9,29.4
X$801 539 556 116 85 514 AND2_X1
* cell instance $802 r0 *1 2.66,29.4
X$802 85 955 564 538 532 116 DFF_X1
* cell instance $808 m0 *1 7.03,29.4
X$808 497 85 116 461 BUF_X1
* cell instance $809 m0 *1 7.79,29.4
X$809 513 85 116 455 BUF_X1
* cell instance $811 m0 *1 11.4,29.4
X$811 533 521 365 508 522 85 116 520 AOI221_X1
* cell instance $812 m0 *1 12.54,29.4
X$812 488 498 85 116 504 OR2_X1
* cell instance $813 m0 *1 13.3,29.4
X$813 454 498 85 116 549 NAND2_X1
* cell instance $814 m0 *1 13.87,29.4
X$814 498 479 443 85 522 116 AOI21_X1
* cell instance $819 r0 *1 8.74,29.4
X$819 85 952 540 546 532 116 DFF_X1
* cell instance $820 r0 *1 11.97,29.4
X$820 539 523 116 85 567 AND2_X1
* cell instance $821 r0 *1 12.73,29.4
X$821 539 536 116 85 546 AND2_X1
* cell instance $822 r0 *1 13.49,29.4
X$822 547 549 516 541 85 116 533 NAND4_X1
* cell instance $823 r0 *1 14.44,29.4
X$823 557 479 443 85 541 116 AOI21_X1
* cell instance $824 m0 *1 15.01,29.4
X$824 487 482 480 525 515 116 85 523 OAI221_X1
* cell instance $825 m0 *1 17.29,29.4
X$825 527 488 456 490 116 580 85 NOR4_X2
* cell instance $826 m0 *1 19,29.4
X$826 499 462 479 85 527 116 AOI21_X1
* cell instance $827 m0 *1 19.76,29.4
X$827 443 85 116 499 INV_X1
* cell instance $828 m0 *1 20.14,29.4
X$828 483 511 456 116 516 85 OAI21_X1
* cell instance $829 m0 *1 20.9,29.4
X$829 483 487 456 116 537 85 OAI21_X1
* cell instance $832 m0 *1 22.61,29.4
X$832 85 510 526 876 487 116 DFF_X2
* cell instance $833 m0 *1 26.22,29.4
X$833 85 928 507 495 526 116 DFF_X1
* cell instance $836 m0 *1 38.57,29.4
X$836 85 879 517 535 476 116 DFF_X1
* cell instance $837 m0 *1 41.8,29.4
X$837 507 85 116 524 BUF_X1
* cell instance $838 m0 *1 42.37,29.4
X$838 524 85 116 519 BUF_X1
* cell instance $839 m0 *1 42.94,29.4
X$839 500 85 116 485 BUF_X1
* cell instance $840 m0 *1 43.51,29.4
X$840 502 85 116 471 BUF_X1
* cell instance $841 m0 *1 44.08,29.4
X$841 518 384 529 85 116 534 MUX2_X1
* cell instance $842 m0 *1 45.41,29.4
X$842 486 85 116 503 BUF_X1
* cell instance $845 r0 *1 15.39,29.4
X$845 455 85 116 550 INV_X1
* cell instance $847 r0 *1 15.96,29.4
X$847 550 525 489 85 116 553 NOR3_X1
* cell instance $848 r0 *1 16.72,29.4
X$848 468 528 499 85 116 547 NAND3_X1
* cell instance $850 r0 *1 17.67,29.4
X$850 488 499 468 85 554 116 AOI21_X1
* cell instance $851 r0 *1 18.43,29.4
X$851 499 572 554 553 537 542 85 116 OAI221_X2
* cell instance $855 r0 *1 34.2,29.4
X$855 551 552 116 85 558 AND2_X1
* cell instance $858 r0 *1 37.24,29.4
X$858 559 484 566 85 116 552 MUX2_X1
* cell instance $859 r0 *1 38.57,29.4
X$859 476 85 116 INV_X2
* cell instance $862 r0 *1 39.71,29.4
X$862 543 85 116 563 BUF_X1
* cell instance $863 r0 *1 40.28,29.4
X$863 452 548 116 85 535 AND2_X1
* cell instance $864 r0 *1 41.04,29.4
X$864 517 328 545 85 116 548 MUX2_X1
* cell instance $867 r0 *1 43.51,29.4
X$867 560 328 534 85 116 561 MUX2_X1
* cell instance $868 r0 *1 44.84,29.4
X$868 501 85 116 529 BUF_X1
* cell instance $872 m0 *1 6.65,7
X$872 85 930 127 187 126 116 DFF_X1
* cell instance $875 m0 *1 10.07,7
X$875 128 94 189 85 116 212 MUX2_X1
* cell instance $877 m0 *1 11.59,7
X$877 96 156 116 85 188 AND2_X1
* cell instance $880 m0 *1 15.77,7
X$880 96 130 116 85 191 AND2_X1
* cell instance $884 m0 *1 1.33,7
X$884 200 85 116 171 BUF_X1
* cell instance $886 m0 *1 1.9,7
X$886 198 85 116 173 BUF_X1
* cell instance $887 m0 *1 2.47,7
X$887 173 172 200 85 116 209 MUX2_X1
* cell instance $891 r0 *1 1.33,7
X$891 214 85 116 199 BUF_X1
* cell instance $892 r0 *1 1.9,7
X$892 199 172 216 85 116 185 MUX2_X1
* cell instance $896 r0 *1 3.23,7
X$896 85 973 216 174 126 116 DFF_X1
* cell instance $901 r0 *1 9.88,7
X$901 85 976 189 226 129 116 DFF_X1
* cell instance $904 r0 *1 14.06,7
X$904 229 94 202 85 116 217 MUX2_X1
* cell instance $905 r0 *1 15.39,7
X$905 231 94 227 85 116 232 MUX2_X1
* cell instance $908 r0 *1 19.19,7
X$908 85 947 175 234 129 116 DFF_X1
* cell instance $909 m0 *1 20.52,7
X$909 96 203 116 85 234 AND2_X1
* cell instance $920 m0 *1 38,7
X$920 205 136 139 85 116 206 MUX2_X1
* cell instance $921 m0 *1 39.9,7
X$921 178 136 211 85 116 192 MUX2_X1
* cell instance $922 m0 *1 41.23,7
X$922 144 192 116 85 163 AND2_X1
* cell instance $923 m0 *1 41.99,7
X$923 164 85 116 193 BUF_X1
* cell instance $924 m0 *1 42.56,7
X$924 207 85 116 190 BUF_X1
* cell instance $925 m0 *1 43.13,7
X$925 114 85 116 244 BUF_X1
* cell instance $926 m0 *1 43.7,7
X$926 178 85 116 181 BUF_X1
* cell instance $930 r0 *1 33.63,7
X$930 219 136 135 85 116 235 MUX2_X1
* cell instance $931 r0 *1 34.96,7
X$931 85 938 205 236 149 116 DFF_X1
* cell instance $933 r0 *1 38.38,7
X$933 144 206 116 85 236 AND2_X1
* cell instance $934 r0 *1 39.14,7
X$934 205 85 116 208 BUF_X1
* cell instance $935 r0 *1 39.71,7
X$935 142 85 116 237 BUF_X1
* cell instance $937 r0 *1 40.47,7
X$937 144 213 116 85 220 AND2_X1
* cell instance $938 r0 *1 41.23,7
X$938 221 136 233 85 116 213 MUX2_X1
* cell instance $939 r0 *1 42.56,7
X$939 221 85 116 224 BUF_X1
* cell instance $940 r0 *1 43.13,7
X$940 210 111 230 85 116 233 MUX2_X1
* cell instance $941 r0 *1 44.46,7
X$941 228 85 116 210 BUF_X1
* cell instance $943 m0 *1 44.65,7
X$943 140 136 223 85 116 141 MUX2_X1
* cell instance $945 r0 *1 45.22,7
X$945 113 85 116 222 BUF_X1
* cell instance $948 m0 *1 1.33,23.8
X$948 375 172 404 85 116 419 MUX2_X1
* cell instance $950 m0 *1 2.66,23.8
X$950 85 904 404 420 327 116 DFF_X1
* cell instance $953 m0 *1 8.17,23.8
X$953 85 920 406 448 394 116 DFF_X1
* cell instance $954 m0 *1 11.4,23.8
X$954 365 439 447 85 448 116 AOI21_X1
* cell instance $955 m0 *1 12.16,23.8
X$955 422 410 406 85 116 439 NAND3_X1
* cell instance $957 m0 *1 13.68,23.8
X$957 417 85 116 462 BUF_X2
* cell instance $958 m0 *1 14.44,23.8
X$958 410 365 85 116 440 NOR2_X1
* cell instance $971 r0 *1 11.02,23.8
X$971 454 409 421 461 85 116 447 NAND4_X1
* cell instance $972 r0 *1 11.97,23.8
X$972 454 409 461 85 116 410 NAND3_X2
* cell instance $975 r0 *1 13.87,23.8
X$975 85 440 394 468 463 116 DFF_X2
* cell instance $976 r0 *1 17.48,23.8
X$976 463 85 116 456 BUF_X2
* cell instance $979 r0 *1 18.81,23.8
X$979 365 411 456 85 442 116 AOI21_X1
* cell instance $981 r0 *1 19.76,23.8
X$981 465 442 464 85 116 441 NAND3_X1
* cell instance $983 m0 *1 21.66,23.8
X$983 425 85 116 443 CLKBUF_X3
* cell instance $984 m0 *1 20.71,23.8
X$984 443 412 85 116 266 NAND2_X2
* cell instance $988 m0 *1 31.92,23.8
X$988 412 116 103 85 BUF_X4
* cell instance $992 m0 *1 38,23.8
X$992 444 328 449 85 116 426 MUX2_X1
* cell instance $994 m0 *1 39.52,23.8
X$994 452 426 116 85 466 AND2_X1
* cell instance $996 m0 *1 40.47,23.8
X$996 452 434 116 85 453 AND2_X1
* cell instance $997 m0 *1 41.23,23.8
X$997 85 903 451 453 318 116 DFF_X1
* cell instance $998 m0 *1 44.46,23.8
X$998 427 384 450 85 116 449 MUX2_X1
* cell instance $1001 r0 *1 20.71,23.8
X$1001 457 443 85 116 465 NAND2_X1
* cell instance $1003 r0 *1 21.47,23.8
X$1003 412 462 85 116 457 NOR2_X2
* cell instance $1005 r0 *1 22.8,23.8
X$1005 457 408 249 85 116 NOR2_X4
* cell instance $1006 r0 *1 24.51,23.8
X$1006 467 85 116 268 CLKBUF_X3
* cell instance $1011 r0 *1 36.48,23.8
X$1011 345 85 116 452 BUF_X2
* cell instance $1014 r0 *1 38.38,23.8
X$1014 85 954 444 466 476 116 DFF_X1
* cell instance $1017 r0 *1 42.18,23.8
X$1017 412 85 116 384 CLKBUF_X3
* cell instance $1020 r0 *1 43.7,23.8
X$1020 444 85 116 460 BUF_X1
* cell instance $1021 r0 *1 44.27,23.8
X$1021 451 85 116 446 BUF_X1
* cell instance $1024 r0 *1 45.41,23.8
X$1024 445 85 116 427 BUF_X1
* cell instance $1026 m0 *1 1.33,12.6
X$1026 262 172 263 85 116 284 MUX2_X1
* cell instance $1028 m0 *1 2.66,12.6
X$1028 85 887 263 285 126 116 DFF_X1
* cell instance $1035 r0 *1 1.33,12.6
X$1035 292 85 116 335 BUF_X1
* cell instance $1036 r0 *1 1.9,12.6
X$1036 263 85 116 282 BUF_X1
* cell instance $1037 r0 *1 2.47,12.6
X$1037 336 85 116 314 BUF_X1
* cell instance $1041 r0 *1 3.8,12.6
X$1041 286 316 116 85 309 AND2_X1
* cell instance $1042 r0 *1 4.56,12.6
X$1042 317 85 116 307 BUF_X1
* cell instance $1044 r0 *1 5.32,12.6
X$1044 283 85 116 294 BUF_X1
* cell instance $1045 r0 *1 5.89,12.6
X$1045 287 85 116 308 BUF_X1
* cell instance $1048 r0 *1 7.03,12.6
X$1048 294 94 287 85 116 310 MUX2_X1
* cell instance $1051 m0 *1 10.45,12.6
X$1051 126 85 116 CLKBUF_X1
* cell instance $1052 m0 *1 11.02,12.6
X$1052 268 85 116 126 CLKBUF_X3
* cell instance $1055 m0 *1 12.35,12.6
X$1055 266 85 116 94 CLKBUF_X3
* cell instance $1057 m0 *1 14.25,12.6
X$1057 201 266 87 85 116 296 MUX2_X1
* cell instance $1059 m0 *1 15.77,12.6
X$1059 129 85 116 CLKBUF_X1
* cell instance $1060 m0 *1 16.34,12.6
X$1060 85 890 87 295 129 116 DFF_X1
* cell instance $1066 r0 *1 16.53,12.6
X$1066 286 296 116 85 295 AND2_X1
* cell instance $1070 m0 *1 22.61,12.6
X$1070 286 300 116 85 279 AND2_X1
* cell instance $1072 m0 *1 24.51,12.6
X$1072 252 249 299 85 116 300 MUX2_X1
* cell instance $1073 m0 *1 23.75,12.6
X$1073 286 241 116 85 288 AND2_X1
* cell instance $1075 r0 *1 24.13,12.6
X$1075 85 948 131 288 158 116 DFF_X1
* cell instance $1076 m0 *1 26.22,12.6
X$1076 268 85 116 158 CLKBUF_X3
* cell instance $1077 m0 *1 27.17,12.6
X$1077 158 85 116 INV_X2
* cell instance $1082 m0 *1 33.06,12.6
X$1082 268 85 116 149 CLKBUF_X3
* cell instance $1089 r0 *1 33.06,12.6
X$1089 85 937 289 303 270 116 DFF_X1
* cell instance $1090 m0 *1 35.34,12.6
X$1090 289 136 109 85 116 304 MUX2_X1
* cell instance $1094 r0 *1 37.05,12.6
X$1094 289 85 116 302 BUF_X1
* cell instance $1097 m0 *1 37.81,12.6
X$1097 144 306 116 85 281 AND2_X1
* cell instance $1098 m0 *1 38.76,12.6
X$1098 247 136 298 85 116 306 MUX2_X1
* cell instance $1099 m0 *1 40.09,12.6
X$1099 85 923 253 269 270 116 DFF_X1
* cell instance $1100 m0 *1 43.32,12.6
X$1100 293 111 297 85 116 298 MUX2_X1
* cell instance $1101 m0 *1 44.65,12.6
X$1101 275 111 271 85 116 223 MUX2_X1
* cell instance $1106 r0 *1 42.75,12.6
X$1106 305 85 116 311 BUF_X1
* cell instance $1108 r0 *1 43.51,12.6
X$1108 244 111 315 85 116 312 MUX2_X1
* cell instance $1109 r0 *1 44.84,12.6
X$1109 290 85 116 297 BUF_X1
* cell instance $1110 r0 *1 45.41,12.6
X$1110 291 85 116 293 BUF_X1
* cell instance $1112 m0 *1 7.03,46.2
X$1112 827 758 800 85 116 826 MUX2_X1
* cell instance $1114 m0 *1 8.36,46.2
X$1114 829 85 116 827 BUF_X1
* cell instance $1115 m0 *1 8.93,46.2
X$1115 800 85 116 830 BUF_X1
* cell instance $1116 m0 *1 9.5,46.2
X$1116 766 85 116 832 BUF_X1
* cell instance $1119 m0 *1 11.02,46.2
X$1119 833 85 116 784 BUF_X1
* cell instance $1120 m0 *1 11.59,46.2
X$1120 749 85 116 836 BUF_X1
* cell instance $1121 m0 *1 12.16,46.2
X$1121 835 85 116 785 BUF_X1
* cell instance $1122 m0 *1 12.73,46.2
X$1122 837 85 116 804 BUF_X1
* cell instance $1123 m0 *1 13.3,46.2
X$1123 759 85 116 838 BUF_X1
* cell instance $1124 m0 *1 13.87,46.2
X$1124 872 85 116 805 BUF_X1
* cell instance $1125 m0 *1 14.44,46.2
X$1125 752 85 116 840 BUF_X1
* cell instance $1126 m0 *1 15.01,46.2
X$1126 839 85 116 806 BUF_X1
* cell instance $1127 m0 *1 15.58,46.2
X$1127 843 758 788 85 116 787 MUX2_X1
* cell instance $1128 m0 *1 16.91,46.2
X$1128 658 787 116 85 808 AND2_X1
* cell instance $1129 m0 *1 17.67,46.2
X$1129 603 85 116 845 BUF_X1
* cell instance $1130 m0 *1 18.24,46.2
X$1130 846 85 116 843 BUF_X1
* cell instance $1131 m0 *1 18.81,46.2
X$1131 586 85 116 848 BUF_X1
* cell instance $1132 m0 *1 19.38,46.2
X$1132 847 85 116 755 BUF_X1
* cell instance $1133 m0 *1 19.95,46.2
X$1133 849 85 116 850 BUF_X1
* cell instance $1134 m0 *1 20.52,46.2
X$1134 788 85 116 851 BUF_X1
* cell instance $1135 m0 *1 21.09,46.2
X$1135 850 758 790 85 116 789 MUX2_X1
* cell instance $1136 m0 *1 22.42,46.2
X$1136 582 85 116 853 BUF_X1
* cell instance $1138 m0 *1 1.33,32.2
X$1138 570 569 565 85 116 556 MUX2_X1
* cell instance $1140 m0 *1 2.66,32.2
X$1140 578 569 564 85 116 571 MUX2_X1
* cell instance $1141 m0 *1 3.99,32.2
X$1141 565 85 116 555 BUF_X1
* cell instance $1145 m0 *1 11.59,32.2
X$1145 540 116 498 85 BUF_X4
* cell instance $1148 m0 *1 14.63,32.2
X$1148 489 498 116 85 557 AND2_X1
* cell instance $1150 m0 *1 15.58,32.2
X$1150 488 85 116 525 INV_X1
* cell instance $1151 m0 *1 15.96,32.2
X$1151 585 572 525 85 116 579 MUX2_X1
* cell instance $1152 m0 *1 17.29,32.2
X$1152 498 85 116 528 INV_X1
* cell instance $1155 r0 *1 1.33,32.2
X$1155 568 85 116 570 BUF_X1
* cell instance $1156 r0 *1 1.9,32.2
X$1156 583 85 116 578 BUF_X1
* cell instance $1158 r0 *1 2.66,32.2
X$1158 564 85 116 584 BUF_X1
* cell instance $1162 r0 *1 3.23,32.2
X$1162 539 571 116 85 538 AND2_X1
* cell instance $1163 r0 *1 3.99,32.2
X$1163 85 956 600 601 532 116 DFF_X1
* cell instance $1167 r0 *1 9.31,32.2
X$1167 85 964 590 567 602 116 DFF_X1
* cell instance $1168 r0 *1 12.54,32.2
X$1168 590 116 488 85 BUF_X4
* cell instance $1171 r0 *1 15.77,32.2
X$1171 569 585 365 443 579 85 116 592 AOI221_X1
* cell instance $1173 r0 *1 17.29,32.2
X$1173 603 85 116 585 INV_X1
* cell instance $1175 m0 *1 37.81,46.2
X$1175 852 85 116 822 BUF_X1
* cell instance $1177 m0 *1 38.38,46.2
X$1177 822 721 780 85 116 796 MUX2_X1
* cell instance $1178 m0 *1 39.71,46.2
X$1178 691 796 116 85 810 AND2_X1
* cell instance $1179 m0 *1 40.47,46.2
X$1179 844 85 116 693 BUF_X1
* cell instance $1180 m0 *1 41.04,46.2
X$1180 762 85 116 842 BUF_X1
* cell instance $1181 m0 *1 41.61,46.2
X$1181 764 85 116 841 BUF_X1
* cell instance $1182 m0 *1 42.18,46.2
X$1182 834 85 116 771 BUF_X1
* cell instance $1183 m0 *1 42.75,46.2
X$1183 626 85 116 831 BUF_X1
* cell instance $1184 m0 *1 43.32,46.2
X$1184 690 85 116 828 BUF_X1
* cell instance $1185 m0 *1 43.89,46.2
X$1185 824 85 116 674 BUF_X1
* cell instance $1186 m0 *1 44.46,46.2
X$1186 875 85 116 736 BUF_X1
* cell instance $1190 m0 *1 1.33,40.6
X$1190 681 85 116 714 BUF_X1
* cell instance $1192 m0 *1 1.9,40.6
X$1192 714 569 683 85 116 716 MUX2_X1
* cell instance $1193 m0 *1 3.23,40.6
X$1193 539 716 116 85 715 AND2_X1
* cell instance $1196 m0 *1 5.7,40.6
X$1196 85 933 656 684 635 116 DFF_X1
* cell instance $1198 m0 *1 9.69,40.6
X$1198 85 881 731 707 635 116 DFF_X1
* cell instance $1199 m0 *1 12.92,40.6
X$1199 804 569 731 85 116 709 MUX2_X1
* cell instance $1203 r0 *1 1.33,40.6
X$1203 656 85 116 682 BUF_X1
* cell instance $1204 r0 *1 1.9,40.6
X$1204 85 983 683 715 635 116 DFF_X1
* cell instance $1211 r0 *1 9.88,40.6
X$1211 85 963 749 742 602 116 DFF_X1
* cell instance $1213 r0 *1 14.63,40.6
X$1213 85 944 752 717 660 116 DFF_X1
* cell instance $1214 m0 *1 16.34,40.6
X$1214 85 907 718 734 660 116 DFF_X1
* cell instance $1219 r0 *1 18.24,40.6
X$1219 755 758 718 85 116 719 MUX2_X1
* cell instance $1220 r0 *1 19.57,40.6
X$1220 658 719 116 85 734 AND2_X1
* cell instance $1223 m0 *1 20.71,40.6
X$1223 659 85 116 758 CLKBUF_X3
* cell instance $1225 m0 *1 22.61,40.6
X$1225 737 659 685 85 116 686 MUX2_X1
* cell instance $1226 m0 *1 23.94,40.6
X$1226 551 686 116 85 711 AND2_X1
* cell instance $1229 m0 *1 25.65,40.6
X$1229 687 659 720 85 116 688 MUX2_X1
* cell instance $1230 m0 *1 26.98,40.6
X$1230 551 688 116 85 738 AND2_X1
* cell instance $1233 m0 *1 29.45,40.6
X$1233 659 85 116 721 CLKBUF_X3
* cell instance $1234 m0 *1 30.4,40.6
X$1234 722 721 690 85 116 653 MUX2_X1
* cell instance $1239 r0 *1 25.46,40.6
X$1239 85 986 720 738 604 116 DFF_X1
* cell instance $1241 r0 *1 29.07,40.6
X$1241 85 981 762 739 604 116 DFF_X1
* cell instance $1242 m0 *1 33.44,40.6
X$1242 85 900 694 740 665 116 DFF_X1
* cell instance $1243 m0 *1 32.11,40.6
X$1243 723 721 638 85 116 692 MUX2_X1
* cell instance $1244 m0 *1 36.67,40.6
X$1244 693 721 694 85 116 713 MUX2_X1
* cell instance $1245 m0 *1 38,40.6
X$1245 694 85 116 703 BUF_X1
* cell instance $1246 m0 *1 38.57,40.6
X$1246 691 695 116 85 712 AND2_X1
* cell instance $1248 m0 *1 39.52,40.6
X$1248 702 85 116 594 BUF_X1
* cell instance $1249 m0 *1 40.09,40.6
X$1249 551 710 116 85 724 AND2_X1
* cell instance $1250 m0 *1 40.85,40.6
X$1250 696 85 116 729 BUF_X1
* cell instance $1251 m0 *1 41.42,40.6
X$1251 726 484 772 85 116 710 MUX2_X1
* cell instance $1252 m0 *1 42.75,40.6
X$1252 725 85 116 575 BUF_X1
* cell instance $1254 m0 *1 43.51,40.6
X$1254 641 85 116 621 BUF_X1
* cell instance $1256 m0 *1 44.27,40.6
X$1256 701 85 116 698 BUF_X1
* cell instance $1257 m0 *1 44.84,40.6
X$1257 699 85 116 700 BUF_X1
* cell instance $1258 m0 *1 45.41,40.6
X$1258 730 85 116 765 BUF_X1
* cell instance $1260 r0 *1 32.3,40.6
X$1260 691 753 116 85 743 AND2_X1
* cell instance $1261 r0 *1 33.06,40.6
X$1261 85 945 744 741 665 116 DFF_X1
* cell instance $1262 r0 *1 36.29,40.6
X$1262 691 745 116 85 741 AND2_X1
* cell instance $1265 r0 *1 38.19,40.6
X$1265 736 721 696 85 116 695 MUX2_X1
* cell instance $1266 r0 *1 39.52,40.6
X$1266 750 85 116 751 BUF_X1
* cell instance $1267 r0 *1 40.09,40.6
X$1267 85 950 726 724 665 116 DFF_X1
* cell instance $1268 r0 *1 43.32,40.6
X$1268 726 85 116 747 BUF_X1
* cell instance $1270 r0 *1 44.08,40.6
X$1270 735 85 116 748 BUF_X1
* cell instance $1272 r0 *1 44.84,40.6
X$1272 733 85 116 494 BUF_X1
* cell instance $1273 r0 *1 45.41,40.6
X$1273 732 85 116 697 BUF_X1
* cell instance $1275 m0 *1 1.33,35
X$1275 600 85 116 613 BUF_X1
* cell instance $1277 m0 *1 1.9,35
X$1277 597 85 116 599 BUF_X1
* cell instance $1278 m0 *1 2.47,35
X$1278 599 569 600 85 116 616 MUX2_X1
* cell instance $1279 m0 *1 3.8,35
X$1279 539 616 116 85 601 AND2_X1
* cell instance $1280 m0 *1 4.56,35
X$1280 85 898 615 618 532 116 DFF_X1
* cell instance $1282 m0 *1 9.31,35
X$1282 268 85 116 532 CLKBUF_X3
* cell instance $1283 m0 *1 10.26,35
X$1283 532 85 116 INV_X2
* cell instance $1286 m0 *1 14.06,35
X$1286 345 85 116 539 CLKBUF_X2
* cell instance $1287 m0 *1 14.82,35
X$1287 85 891 603 592 602 116 DFF_X1
* cell instance $1289 m0 *1 18.81,35
X$1289 469 586 610 116 611 85 OAI21_X1
* cell instance $1290 m0 *1 19.57,35
X$1290 612 443 611 85 648 116 AOI21_X1
* cell instance $1296 r0 *1 1.33,35
X$1296 598 85 116 643 BUF_X1
* cell instance $1297 r0 *1 1.9,35
X$1297 615 85 116 614 BUF_X1
* cell instance $1298 r0 *1 2.47,35
X$1298 643 569 615 85 116 617 MUX2_X1
* cell instance $1302 r0 *1 3.8,35
X$1302 539 617 116 85 618 AND2_X1
* cell instance $1307 r0 *1 12.73,35
X$1307 635 85 116 INV_X2
* cell instance $1311 r0 *1 15.96,35
X$1311 488 489 85 116 659 NAND2_X2
* cell instance $1314 r0 *1 19.19,35
X$1314 85 968 586 648 660 116 DFF_X1
* cell instance $1317 r0 *1 26.98,35
X$1317 551 650 116 85 649 AND2_X1
* cell instance $1319 r0 *1 27.93,35
X$1319 604 85 116 989 INV_X1
* cell instance $1321 m0 *1 29.26,35
X$1321 85 927 651 629 604 116 DFF_X1
* cell instance $1324 m0 *1 32.68,35
X$1324 85 897 626 628 526 116 DFF_X1
* cell instance $1325 m0 *1 35.91,35
X$1325 551 605 116 85 628 AND2_X1
* cell instance $1327 r0 *1 29.83,35
X$1327 551 652 116 85 629 AND2_X1
* cell instance $1328 r0 *1 30.59,35
X$1328 551 653 116 85 663 AND2_X1
* cell instance $1330 r0 *1 31.73,35
X$1330 651 484 630 85 116 652 MUX2_X1
* cell instance $1334 r0 *1 35.15,35
X$1334 626 484 627 85 116 605 MUX2_X1
* cell instance $1337 m0 *1 37.05,35
X$1337 85 895 620 619 476 116 DFF_X1
* cell instance $1338 m0 *1 40.47,35
X$1338 85 921 622 606 476 116 DFF_X1
* cell instance $1340 m0 *1 43.89,35
X$1340 507 85 116 607 BUF_X1
* cell instance $1341 m0 *1 44.46,35
X$1341 560 85 116 589 BUF_X1
* cell instance $1344 r0 *1 37.43,35
X$1344 620 484 647 85 116 639 MUX2_X1
* cell instance $1345 r0 *1 38.76,35
X$1345 452 639 116 85 619 AND2_X1
* cell instance $1347 r0 *1 39.9,35
X$1347 646 384 621 85 116 647 MUX2_X1
* cell instance $1348 r0 *1 41.23,35
X$1348 588 85 116 646 BUF_X1
* cell instance $1349 r0 *1 41.8,35
X$1349 608 85 116 609 BUF_X1
* cell instance $1351 r0 *1 42.75,35
X$1351 622 484 644 85 116 645 MUX2_X1
* cell instance $1352 r0 *1 44.08,35
X$1352 673 384 623 85 116 644 MUX2_X1
* cell instance $1354 m0 *1 45.41,35
X$1354 577 85 116 576 BUF_X1
* cell instance $1355 r0 *1 45.41,35
X$1355 622 85 116 624 BUF_X1
* cell instance $1357 m0 *1 1.9,37.8
X$1357 632 85 116 670 BUF_X1
* cell instance $1359 m0 *1 2.47,37.8
X$1359 670 569 633 85 116 671 MUX2_X1
* cell instance $1360 m0 *1 3.8,37.8
X$1360 85 932 633 634 635 116 DFF_X1
* cell instance $1361 m0 *1 7.03,37.8
X$1361 631 85 116 657 BUF_X1
* cell instance $1362 m0 *1 7.6,37.8
X$1362 657 569 675 85 116 676 MUX2_X1
* cell instance $1363 m0 *1 8.93,37.8
X$1363 539 676 116 85 706 AND2_X1
* cell instance $1369 r0 *1 1.33,37.8
X$1369 654 85 116 704 BUF_X1
* cell instance $1370 r0 *1 1.9,37.8
X$1370 633 85 116 655 BUF_X1
* cell instance $1371 r0 *1 2.47,37.8
X$1371 704 569 656 85 116 672 MUX2_X1
* cell instance $1375 r0 *1 3.8,37.8
X$1375 539 671 116 85 634 AND2_X1
* cell instance $1377 r0 *1 5.32,37.8
X$1377 539 672 116 85 684 AND2_X1
* cell instance $1380 r0 *1 7.03,37.8
X$1380 85 972 675 706 635 116 DFF_X1
* cell instance $1382 m0 *1 11.78,37.8
X$1382 602 85 116 991 INV_X4
* cell instance $1384 m0 *1 12.73,37.8
X$1384 268 85 116 635 CLKBUF_X3
* cell instance $1385 m0 *1 13.68,37.8
X$1385 268 85 116 602 CLKBUF_X3
* cell instance $1386 m0 *1 14.63,37.8
X$1386 678 85 116 489 BUF_X2
* cell instance $1387 m0 *1 15.39,37.8
X$1387 345 85 116 658 CLKBUF_X2
* cell instance $1390 r0 *1 11.78,37.8
X$1390 658 709 116 85 707 AND2_X1
* cell instance $1393 r0 *1 15.77,37.8
X$1393 659 85 116 569 CLKBUF_X3
* cell instance $1396 r0 *1 18.62,37.8
X$1396 660 85 116 INV_X2
* cell instance $1397 r0 *1 19.19,37.8
X$1397 268 85 116 660 CLKBUF_X3
* cell instance $1399 r0 *1 20.52,37.8
X$1399 85 982 685 711 660 116 DFF_X1
* cell instance $1400 m0 *1 22.8,37.8
X$1400 636 659 661 85 116 679 MUX2_X1
* cell instance $1403 r0 *1 23.75,37.8
X$1403 85 985 661 637 604 116 DFF_X1
* cell instance $1404 m0 *1 24.7,37.8
X$1404 551 679 116 85 637 AND2_X1
* cell instance $1407 m0 *1 26.22,37.8
X$1407 85 917 662 649 604 116 DFF_X1
* cell instance $1408 m0 *1 29.45,37.8
X$1408 268 85 116 604 CLKBUF_X3
* cell instance $1409 m0 *1 30.4,37.8
X$1409 345 85 116 691 BUF_X2
* cell instance $1411 m0 *1 31.35,37.8
X$1411 85 926 638 664 665 116 DFF_X1
* cell instance $1415 r0 *1 27.93,37.8
X$1415 662 484 689 85 116 650 MUX2_X1
* cell instance $1416 r0 *1 29.26,37.8
X$1416 85 980 690 663 604 116 DFF_X1
* cell instance $1418 r0 *1 32.68,37.8
X$1418 691 692 116 85 664 AND2_X1
* cell instance $1421 m0 *1 34.96,37.8
X$1421 268 85 116 665 CLKBUF_X3
* cell instance $1424 r0 *1 35.72,37.8
X$1424 691 713 116 85 740 AND2_X1
* cell instance $1425 r0 *1 36.48,37.8
X$1425 85 970 696 712 665 116 DFF_X1
* cell instance $1426 m0 *1 39.52,37.8
X$1426 674 469 666 85 116 627 MUX2_X1
* cell instance $1429 m0 *1 41.04,37.8
X$1429 452 645 116 85 606 AND2_X1
* cell instance $1431 r0 *1 39.71,37.8
X$1431 559 85 116 640 BUF_X1
* cell instance $1432 r0 *1 40.28,37.8
X$1432 668 85 116 666 BUF_X1
* cell instance $1434 r0 *1 41.23,37.8
X$1434 452 708 116 85 677 AND2_X1
* cell instance $1435 r0 *1 41.99,37.8
X$1435 667 484 705 85 116 708 MUX2_X1
* cell instance $1436 m0 *1 45.41,37.8
X$1436 620 85 116 625 BUF_X1
* cell instance $1437 m0 *1 42.18,37.8
X$1437 85 902 667 677 665 116 DFF_X1
* cell instance $1439 r0 *1 43.32,37.8
X$1439 697 384 698 85 116 705 MUX2_X1
* cell instance $1440 r0 *1 44.65,37.8
X$1440 669 85 116 623 BUF_X1
* cell instance $1441 r0 *1 45.22,37.8
X$1441 667 85 116 642 BUF_X1
* cell instance $1444 m0 *1 1.33,18.2
X$1444 350 85 116 351 BUF_X1
* cell instance $1446 m0 *1 1.9,18.2
X$1446 352 85 116 343 BUF_X1
* cell instance $1447 m0 *1 2.47,18.2
X$1447 286 357 116 85 344 AND2_X1
* cell instance $1450 r0 *1 1.33,18.2
X$1450 374 85 116 375 BUF_X1
* cell instance $1451 r0 *1 1.9,18.2
X$1451 351 172 388 85 116 377 MUX2_X1
* cell instance $1455 r0 *1 3.23,18.2
X$1455 286 377 116 85 376 AND2_X1
* cell instance $1456 m0 *1 3.8,18.2
X$1456 342 85 116 347 BUF_X1
* cell instance $1459 m0 *1 5.89,18.2
X$1459 389 85 116 361 BUF_X1
* cell instance $1460 m0 *1 6.46,18.2
X$1460 347 266 352 85 116 353 MUX2_X1
* cell instance $1461 m0 *1 7.79,18.2
X$1461 286 353 116 85 363 AND2_X1
* cell instance $1464 r0 *1 3.99,18.2
X$1464 388 85 116 373 BUF_X1
* cell instance $1465 r0 *1 4.56,18.2
X$1465 372 85 116 378 BUF_X1
* cell instance $1466 r0 *1 5.13,18.2
X$1466 378 266 389 85 116 362 MUX2_X1
* cell instance $1467 r0 *1 6.46,18.2
X$1467 286 362 116 85 379 AND2_X1
* cell instance $1468 r0 *1 7.22,18.2
X$1468 85 958 352 363 327 116 DFF_X1
* cell instance $1470 m0 *1 9.69,18.2
X$1470 327 85 116 988 INV_X1
* cell instance $1472 r0 *1 10.45,18.2
X$1472 268 85 116 327 CLKBUF_X3
* cell instance $1473 r0 *1 11.4,18.2
X$1473 364 365 85 116 391 NOR2_X1
* cell instance $1476 m0 *1 12.16,18.2
X$1476 265 85 116 365 INV_X4
* cell instance $1480 m0 *1 18.81,18.2
X$1480 265 85 116 345 CLKBUF_X3
* cell instance $1485 m0 *1 33.63,18.2
X$1485 345 360 116 85 371 AND2_X1
* cell instance $1487 m0 *1 35.15,18.2
X$1487 354 249 359 85 116 360 MUX2_X1
* cell instance $1488 m0 *1 36.48,18.2
X$1488 268 85 116 270 CLKBUF_X3
* cell instance $1489 m0 *1 37.43,18.2
X$1489 270 85 116 990 INV_X4
* cell instance $1490 m0 *1 38.38,18.2
X$1490 280 103 369 85 116 359 MUX2_X1
* cell instance $1491 m0 *1 39.71,18.2
X$1491 345 85 116 144 BUF_X2
* cell instance $1492 m0 *1 40.47,18.2
X$1492 144 348 116 85 349 AND2_X1
* cell instance $1493 m0 *1 41.23,18.2
X$1493 144 321 116 85 330 AND2_X1
* cell instance $1494 m0 *1 41.99,18.2
X$1494 358 111 356 85 116 320 MUX2_X1
* cell instance $1495 m0 *1 43.32,18.2
X$1495 144 323 116 85 339 AND2_X1
* cell instance $1497 m0 *1 44.84,18.2
X$1497 346 85 116 356 BUF_X1
* cell instance $1498 m0 *1 45.41,18.2
X$1498 355 85 116 315 BUF_X1
* cell instance $1502 r0 *1 13.3,18.2
X$1502 85 946 382 381 394 116 DFF_X1
* cell instance $1503 r0 *1 16.53,18.2
X$1503 394 85 116 INV_X2
* cell instance $1507 r0 *1 32.3,18.2
X$1507 85 940 354 371 318 116 DFF_X1
* cell instance $1508 r0 *1 35.53,18.2
X$1508 85 953 383 366 318 116 DFF_X1
* cell instance $1511 r0 *1 39.33,18.2
X$1511 237 103 370 85 116 396 MUX2_X1
* cell instance $1514 r0 *1 41.23,18.2
X$1514 144 392 116 85 395 AND2_X1
* cell instance $1515 r0 *1 41.99,18.2
X$1515 399 85 116 370 BUF_X1
* cell instance $1516 r0 *1 42.56,18.2
X$1516 367 85 116 369 BUF_X1
* cell instance $1518 r0 *1 43.51,18.2
X$1518 222 384 390 85 116 393 MUX2_X1
* cell instance $1519 r0 *1 44.84,18.2
X$1519 354 85 116 385 BUF_X1
* cell instance $1520 r0 *1 45.41,18.2
X$1520 368 85 116 390 BUF_X1
* cell instance $1522 m0 *1 1.33,15.4
X$1522 325 85 116 334 BUF_X1
* cell instance $1525 m0 *1 2.09,15.4
X$1525 335 172 317 85 116 316 MUX2_X1
* cell instance $1526 m0 *1 3.42,15.4
X$1526 85 913 317 309 327 116 DFF_X1
* cell instance $1528 m0 *1 8.17,15.4
X$1528 85 896 287 338 327 116 DFF_X1
* cell instance $1534 m0 *1 36.48,15.4
X$1534 318 85 116 INV_X2
* cell instance $1535 m0 *1 37.05,15.4
X$1535 329 328 324 85 116 348 MUX2_X1
* cell instance $1539 r0 *1 1.52,15.4
X$1539 334 172 336 85 116 357 MUX2_X1
* cell instance $1540 r0 *1 2.85,15.4
X$1540 85 969 336 344 327 116 DFF_X1
* cell instance $1544 r0 *1 6.08,15.4
X$1544 326 85 116 265 BUF_X2
* cell instance $1550 r0 *1 21.09,15.4
X$1550 265 85 116 286 BUF_X2
* cell instance $1555 r0 *1 34.58,15.4
X$1555 268 85 116 318 CLKBUF_X3
* cell instance $1556 r0 *1 35.53,15.4
X$1556 85 977 329 349 318 116 DFF_X1
* cell instance $1557 m0 *1 38.95,15.4
X$1557 329 85 116 319 BUF_X1
* cell instance $1559 m0 *1 39.52,15.4
X$1559 340 328 320 85 116 321 MUX2_X1
* cell instance $1561 r0 *1 38.76,15.4
X$1561 85 949 340 330 270 116 DFF_X1
* cell instance $1562 m0 *1 41.8,15.4
X$1562 341 85 116 358 BUF_X1
* cell instance $1563 m0 *1 41.23,15.4
X$1563 340 85 116 322 BUF_X1
* cell instance $1564 m0 *1 42.37,15.4
X$1564 311 111 337 85 116 324 MUX2_X1
* cell instance $1566 r0 *1 41.99,15.4
X$1566 85 984 331 339 318 116 DFF_X1
* cell instance $1567 m0 *1 45.41,15.4
X$1567 331 85 116 313 BUF_X1
* cell instance $1568 m0 *1 44.08,15.4
X$1568 331 328 312 85 116 323 MUX2_X1
* cell instance $1571 r0 *1 45.41,15.4
X$1571 333 85 116 337 BUF_X1
* cell instance $1573 m0 *1 23.56,46.2
X$1573 855 85 116 737 BUF_X1
* cell instance $1575 m0 *1 24.13,46.2
X$1575 857 85 116 791 BUF_X1
* cell instance $1577 m0 *1 25.27,46.2
X$1577 856 85 116 687 BUF_X1
* cell instance $1579 m0 *1 25.84,46.2
X$1579 756 85 116 859 BUF_X1
* cell instance $1580 m0 *1 26.41,46.2
X$1580 661 85 116 861 BUF_X1
* cell instance $1582 m0 *1 27.17,46.2
X$1582 860 85 116 792 BUF_X1
* cell instance $1583 m0 *1 27.74,46.2
X$1583 662 85 116 863 BUF_X1
* cell instance $1584 m0 *1 28.31,46.2
X$1584 862 85 116 815 BUF_X1
* cell instance $1585 m0 *1 28.88,46.2
X$1585 819 85 116 866 BUF_X1
* cell instance $1587 m0 *1 29.64,46.2
X$1587 720 85 116 868 BUF_X1
* cell instance $1588 m0 *1 30.21,46.2
X$1588 867 85 116 722 BUF_X1
* cell instance $1589 m0 *1 30.78,46.2
X$1589 871 85 116 793 BUF_X1
* cell instance $1590 m0 *1 31.35,46.2
X$1590 651 85 116 869 BUF_X1
* cell instance $1591 m0 *1 31.92,46.2
X$1591 870 85 116 794 BUF_X1
* cell instance $1592 m0 *1 32.49,46.2
X$1592 865 85 116 723 BUF_X1
* cell instance $1593 m0 *1 33.06,46.2
X$1593 864 85 116 818 BUF_X1
* cell instance $1594 m0 *1 33.63,46.2
X$1594 873 85 116 821 BUF_X1
* cell instance $1595 m0 *1 34.2,46.2
X$1595 821 721 763 85 116 753 MUX2_X1
* cell instance $1596 m0 *1 35.53,46.2
X$1596 763 85 116 874 BUF_X1
* cell instance $1597 m0 *1 36.1,46.2
X$1597 854 85 116 795 BUF_X1
* cell instance $1598 m0 *1 36.67,46.2
X$1598 744 85 116 858 BUF_X1
* cell instance $1600 m0 *1 1.33,9.8
X$1600 246 85 116 262 BUF_X1
* cell instance $1602 m0 *1 1.9,9.8
X$1602 255 85 116 273 BUF_X1
* cell instance $1603 m0 *1 2.47,9.8
X$1603 238 85 116 248 BUF_X1
* cell instance $1604 m0 *1 3.8,9.8
X$1604 216 85 116 215 BUF_X1
* cell instance $1607 r0 *1 1.33,9.8
X$1607 273 172 238 85 116 239 MUX2_X1
* cell instance $1608 r0 *1 2.66,9.8
X$1608 85 974 238 240 126 116 DFF_X1
* cell instance $1613 m0 *1 4.75,9.8
X$1613 261 85 116 274 BUF_X1
* cell instance $1616 m0 *1 11.97,9.8
X$1616 85 906 202 250 129 116 DFF_X1
* cell instance $1617 m0 *1 15.2,9.8
X$1617 96 217 116 85 250 AND2_X1
* cell instance $1626 r0 *1 13.3,9.8
X$1626 85 951 227 278 129 116 DFF_X1
* cell instance $1627 r0 *1 16.53,9.8
X$1627 268 85 116 129 CLKBUF_X3
* cell instance $1629 r0 *1 17.86,9.8
X$1629 96 218 116 85 251 AND2_X1
* cell instance $1630 r0 *1 18.62,9.8
X$1630 96 232 116 85 278 AND2_X1
* cell instance $1632 r0 *1 19.76,9.8
X$1632 265 85 116 96 CLKBUF_X2
* cell instance $1636 r0 *1 21.85,9.8
X$1636 85 967 252 279 158 116 DFF_X1
* cell instance $1639 m0 *1 25.84,9.8
X$1639 131 249 132 85 116 241 MUX2_X1
* cell instance $1640 m0 *1 28.69,9.8
X$1640 133 249 159 85 116 242 MUX2_X1
* cell instance $1644 r0 *1 26.22,9.8
X$1644 85 941 133 260 158 116 DFF_X1
* cell instance $1646 m0 *1 31.35,9.8
X$1646 85 894 219 243 149 116 DFF_X1
* cell instance $1651 m0 *1 39.9,9.8
X$1651 85 877 221 220 149 116 DFF_X1
* cell instance $1654 r0 *1 33.44,9.8
X$1654 85 136 116 249 BUF_X8
* cell instance $1656 r0 *1 36.1,9.8
X$1656 85 965 247 281 149 116 DFF_X1
* cell instance $1659 r0 *1 39.9,9.8
X$1659 143 85 116 280 BUF_X1
* cell instance $1661 r0 *1 40.66,9.8
X$1661 144 277 116 85 269 AND2_X1
* cell instance $1662 r0 *1 41.42,9.8
X$1662 253 136 259 85 116 277 MUX2_X1
* cell instance $1663 r0 *1 42.75,9.8
X$1663 179 111 276 85 116 259 MUX2_X1
* cell instance $1664 m0 *1 43.7,9.8
X$1664 247 85 116 225 BUF_X1
* cell instance $1666 m0 *1 44.27,9.8
X$1666 245 85 116 230 BUF_X1
* cell instance $1667 m0 *1 45.41,9.8
X$1667 253 85 116 254 BUF_X1
* cell instance $1669 r0 *1 44.08,9.8
X$1669 257 85 116 276 BUF_X1
* cell instance $1671 r0 *1 44.84,9.8
X$1671 256 85 116 275 BUF_X1
* cell instance $1672 r0 *1 45.41,9.8
X$1672 272 85 116 271 BUF_X1
* cell instance $1674 r0 *1 28.88,1.4
X$1674 170 103 89 85 116 159 MUX2_X1
* cell instance $1675 r0 *1 39.52,1.4
X$1675 108 103 119 85 116 109 MUX2_X1
* cell instance $1677 r0 *1 42.18,1.4
X$1677 193 111 190 85 116 211 MUX2_X1
* cell instance $1678 r0 *1 43.51,1.4
X$1678 117 111 112 85 116 146 MUX2_X1
* cell instance $1689 m0 *1 5.13,4.2
X$1689 85 883 93 92 126 116 DFF_X1
* cell instance $1690 m0 *1 8.55,4.2
X$1690 118 94 127 85 116 167 MUX2_X1
* cell instance $1691 m0 *1 11.78,4.2
X$1691 85 889 86 97 129 116 DFF_X1
* cell instance $1692 m0 *1 15.01,4.2
X$1692 98 94 157 85 116 130 MUX2_X1
* cell instance $1693 m0 *1 19.57,4.2
X$1693 96 152 116 85 153 AND2_X1
* cell instance $1694 m0 *1 24.13,4.2
X$1694 102 103 124 85 116 299 MUX2_X1
* cell instance $1696 m0 *1 34.01,4.2
X$1696 85 916 105 148 149 116 DFF_X1
* cell instance $1697 m0 *1 37.24,4.2
X$1697 106 103 107 85 116 135 MUX2_X1
* cell instance $1701 m0 *1 1.52,4.2
X$1701 85 914 155 115 126 116 DFF_X1
* cell instance $1705 r0 *1 1.52,4.2
X$1705 183 85 116 184 BUF_X1
* cell instance $1707 r0 *1 2.28,4.2
X$1707 184 172 155 85 116 125 MUX2_X1
* cell instance $1711 r0 *1 3.61,4.2
X$1711 85 975 200 186 126 116 DFF_X1
* cell instance $1716 r0 *1 13.87,4.2
X$1716 85 957 157 191 129 116 DFF_X1
* cell instance $1717 r0 *1 17.67,4.2
X$1717 96 150 116 85 151 AND2_X1
* cell instance $1720 r0 *1 20.14,4.2
X$1720 96 101 116 85 195 AND2_X1
* cell instance $1721 r0 *1 20.9,4.2
X$1721 85 960 88 195 158 116 DFF_X1
* cell instance $1725 r0 *1 26.22,4.2
X$1725 85 942 160 169 158 116 DFF_X1
* cell instance $1729 r0 *1 34.58,4.2
X$1729 165 103 196 85 116 204 MUX2_X1
* cell instance $1730 r0 *1 35.91,4.2
X$1730 85 939 162 161 149 116 DFF_X1
* cell instance $1732 m0 *1 38.95,4.2
X$1732 162 136 146 85 116 137 MUX2_X1
* cell instance $1734 m0 *1 41.99,4.2
X$1734 85 924 140 145 149 116 DFF_X1
* cell instance $1735 m0 *1 40.66,4.2
X$1735 138 111 110 85 116 139 MUX2_X1
* cell instance $1736 m0 *1 45.22,4.2
X$1736 144 141 116 85 145 AND2_X1
* cell instance $1738 r0 *1 41.23,4.2
X$1738 85 962 178 163 149 116 DFF_X1
* cell instance $1739 r0 *1 44.46,4.2
X$1739 180 85 116 179 BUF_X1
* cell instance $1741 r0 *1 45.41,4.2
X$1741 140 85 116 182 BUF_X1
* cell instance $1745 m0 *1 1.52,43.4
X$1745 683 85 116 680 BUF_X1
* cell instance $1748 m0 *1 5.89,43.4
X$1748 85 931 766 757 635 116 DFF_X1
* cell instance $1753 r0 *1 2.28,43.4
X$1753 85 943 800 797 635 116 DFF_X1
* cell instance $1758 r0 *1 6.27,43.4
X$1758 658 798 116 85 757 AND2_X1
* cell instance $1760 r0 *1 7.22,43.4
X$1760 767 758 766 85 116 798 MUX2_X1
* cell instance $1761 r0 *1 8.55,43.4
X$1761 675 85 116 799 BUF_X1
* cell instance $1763 r0 *1 9.31,43.4
X$1763 801 85 116 767 BUF_X1
* cell instance $1764 m0 *1 9.69,43.4
X$1764 658 768 116 85 742 AND2_X1
* cell instance $1766 m0 *1 10.45,43.4
X$1766 85 878 759 773 602 116 DFF_X1
* cell instance $1767 m0 *1 13.68,43.4
X$1767 658 774 116 85 773 AND2_X1
* cell instance $1769 m0 *1 14.63,43.4
X$1769 85 910 754 776 660 116 DFF_X1
* cell instance $1770 m0 *1 17.86,43.4
X$1770 658 760 116 85 776 AND2_X1
* cell instance $1772 m0 *1 18.81,43.4
X$1772 718 85 116 777 BUF_X1
* cell instance $1774 m0 *1 19.57,43.4
X$1774 85 919 790 781 660 116 DFF_X1
* cell instance $1778 r0 *1 10.26,43.4
X$1778 784 758 749 85 116 768 MUX2_X1
* cell instance $1780 r0 *1 11.97,43.4
X$1780 731 85 116 803 BUF_X1
* cell instance $1782 r0 *1 12.73,43.4
X$1782 785 758 759 85 116 774 MUX2_X1
* cell instance $1783 r0 *1 14.06,43.4
X$1783 805 758 752 85 116 786 MUX2_X1
* cell instance $1784 r0 *1 15.39,43.4
X$1784 658 786 116 85 717 AND2_X1
* cell instance $1785 r0 *1 16.15,43.4
X$1785 754 85 116 807 BUF_X1
* cell instance $1786 r0 *1 16.72,43.4
X$1786 806 758 754 85 116 760 MUX2_X1
* cell instance $1787 r0 *1 18.05,43.4
X$1787 85 935 788 808 660 116 DFF_X1
* cell instance $1788 r0 *1 21.28,43.4
X$1788 658 789 116 85 781 AND2_X1
* cell instance $1789 r0 *1 22.04,43.4
X$1789 811 85 116 636 BUF_X1
* cell instance $1790 r0 *1 22.61,43.4
X$1790 790 85 116 812 BUF_X1
* cell instance $1792 r0 *1 23.37,43.4
X$1792 685 85 116 813 BUF_X1
* cell instance $1793 r0 *1 23.94,43.4
X$1793 791 758 756 85 116 814 MUX2_X1
* cell instance $1794 m0 *1 27.93,43.4
X$1794 792 469 815 85 116 689 MUX2_X1
* cell instance $1795 m0 *1 24.7,43.4
X$1795 85 882 756 782 604 116 DFF_X1
* cell instance $1798 m0 *1 30.97,43.4
X$1798 691 783 116 85 739 AND2_X1
* cell instance $1799 m0 *1 31.73,43.4
X$1799 85 922 763 743 665 116 DFF_X1
* cell instance $1800 m0 *1 34.96,43.4
X$1800 746 85 116 817 BUF_X1
* cell instance $1802 m0 *1 35.72,43.4
X$1802 795 721 744 85 116 745 MUX2_X1
* cell instance $1803 m0 *1 37.05,43.4
X$1803 780 85 116 779 BUF_X1
* cell instance $1804 m0 *1 37.62,43.4
X$1804 85 909 764 778 665 116 DFF_X1
* cell instance $1805 m0 *1 40.85,43.4
X$1805 452 770 116 85 775 AND2_X1
* cell instance $1806 m0 *1 41.61,43.4
X$1806 85 880 699 775 665 116 DFF_X1
* cell instance $1807 m0 *1 44.84,43.4
X$1807 728 85 116 769 BUF_X1
* cell instance $1808 m0 *1 45.41,43.4
X$1808 727 85 116 673 BUF_X1
* cell instance $1811 r0 *1 25.65,43.4
X$1811 691 814 116 85 782 AND2_X1
* cell instance $1812 r0 *1 26.41,43.4
X$1812 85 979 819 761 604 116 DFF_X1
* cell instance $1813 r0 *1 29.64,43.4
X$1813 691 820 116 85 761 AND2_X1
* cell instance $1814 r0 *1 30.4,43.4
X$1814 793 721 819 85 116 820 MUX2_X1
* cell instance $1815 r0 *1 31.73,43.4
X$1815 794 721 762 85 116 783 MUX2_X1
* cell instance $1817 r0 *1 33.44,43.4
X$1817 817 469 818 85 116 630 MUX2_X1
* cell instance $1819 r0 *1 35.15,43.4
X$1819 638 85 116 816 BUF_X1
* cell instance $1820 r0 *1 35.72,43.4
X$1820 85 971 780 810 665 116 DFF_X1
* cell instance $1821 r0 *1 38.95,43.4
X$1821 691 809 116 85 778 AND2_X1
* cell instance $1822 r0 *1 39.71,43.4
X$1822 771 721 764 85 116 809 MUX2_X1
* cell instance $1823 r0 *1 41.04,43.4
X$1823 751 469 748 85 116 772 MUX2_X1
* cell instance $1825 r0 *1 42.75,43.4
X$1825 699 484 802 85 116 770 MUX2_X1
* cell instance $1826 r0 *1 44.08,43.4
X$1826 769 469 765 85 116 802 MUX2_X1
* cell instance $1844 m0 *1 2.28,46.2
X$1844 823 85 116 LOGIC0_X1
* cell instance $1845 m0 *1 2.66,46.2
X$1845 823 85 116 825 BUF_X1
* cell instance $1849 m0 *1 5.7,46.2
X$1849 658 826 116 85 797 AND2_X1
.ENDS wishbone_master

* cell CLKBUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT CLKBUF_X1 1 3 4
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.19,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.38,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.19,0.2075 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.095U AS=0.009975P AD=0.01015P PS=0.4U PD=0.335U
* device instance $4 r0 *1 0.38,0.2575 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.195U AS=0.01015P AD=0.020475P PS=0.335U PD=0.6U
.ENDS CLKBUF_X1

* cell HA_X1
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin CO
.SUBCKT HA_X1 1 2 4 5 6 9
* net 1 A
* net 2 B
* net 4 S
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 9 CO
* device instance $1 r0 *1 0.785,1.0275 PMOS_VTL
M$1 10 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $2 r0 *1 0.975,1.0275 PMOS_VTL
M$2 7 1 10 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $3 r0 *1 0.21,0.995 PMOS_VTL
M$3 4 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $4 r0 *1 0.4,0.995 PMOS_VTL
M$4 3 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.59,0.995 PMOS_VTL
M$5 5 7 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0338625P PS=0.77U PD=0.775U
* device instance $6 r0 *1 1.345,1.0275 PMOS_VTL
M$6 8 1 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $7 r0 *1 1.535,1.0275 PMOS_VTL
M$7 8 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $8 r0 *1 1.725,0.995 PMOS_VTL
M$8 9 8 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.345,0.195 NMOS_VTL
M$9 12 1 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $10 r0 *1 1.535,0.195 NMOS_VTL
M$10 6 2 12 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $11 r0 *1 1.725,0.2975 NMOS_VTL
M$11 9 8 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $12 r0 *1 0.785,0.195 NMOS_VTL
M$12 7 2 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.0224P AD=0.0147P PS=0.56U PD=0.35U
* device instance $13 r0 *1 0.975,0.195 NMOS_VTL
M$13 6 1 7 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $14 r0 *1 0.21,0.2975 NMOS_VTL
M$14 11 2 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $15 r0 *1 0.4,0.2975 NMOS_VTL
M$15 4 1 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.59,0.2975 NMOS_VTL
M$16 6 7 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0224P PS=0.555U PD=0.56U
.ENDS HA_X1

* cell OAI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI221_X1 1 2 3 4 5 7 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 12 1 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 12 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 5 11 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 8 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 6 2 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 10 3 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 9 4 10 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 10 5 9 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI221_X1

* cell OR3_X1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 8 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 5 1 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 4 2 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 5 3 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR3_X1

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell AOI221_X2
* pin B1
* pin B2
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI221_X2 1 2 3 4 5 6 8 9
* net 1 B1
* net 2 B2
* net 3 A
* net 4 C2
* net 5 C1
* net 6 ZN
* net 8 NWELL,VDD
* net 9 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 3 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.09135P PS=2.24U PD=1.55U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 1 7 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.32,0.995 PMOS_VTL
M$7 6 4 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.09135P AD=0.11025P PS=1.55U PD=2.24U
* device instance $8 r0 *1 1.51,0.995 PMOS_VTL
M$8 10 5 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 6 3 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.060175P PS=1.595U
+ PD=1.12U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 14 1 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 9 2 14 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 13 2 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 6 1 13 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.32,0.2975 NMOS_VTL
M$17 12 4 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.031125P AD=0.02905P PS=0.565U
+ PD=0.555U
* device instance $18 r0 *1 1.51,0.2975 NMOS_VTL
M$18 6 5 12 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.7,0.2975 NMOS_VTL
M$19 11 5 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.89,0.2975 NMOS_VTL
M$20 9 4 11 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X2

* cell AOI211_X2
* pin B
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI211_X2 1 2 3 4 6 7 8
* net 1 B
* net 2 A
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 10 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 7 2 10 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 9 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 5 1 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.055125P PS=0.77U PD=0.805U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 6 3 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.099225P AD=0.11025P PS=1.575U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 5 4 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 6 1 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0653625P PS=1.595U
+ PD=1.145U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 6 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 11 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.0363125P AD=0.02905P PS=0.59U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 6 4 11 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 12 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 8 3 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI211_X2

* cell OAI221_X2
* pin C2
* pin C1
* pin B1
* pin B2
* pin A
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI221_X2 1 2 3 4 5 7 9 10
* net 1 C2
* net 2 C1
* net 3 B1
* net 4 B2
* net 5 A
* net 7 ZN
* net 9 PWELL,VSS
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 1 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 2 12 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 11 2 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 10 1 11 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 5 10 10 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 14 3 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 10 4 14 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 13 4 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.73,0.995 PMOS_VTL
M$9 7 3 13 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 0.21,0.2975 NMOS_VTL
M$11 7 1 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.4,0.2975 NMOS_VTL
M$12 6 2 7 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.97,0.2975 NMOS_VTL
M$15 8 5 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $16 r0 *1 1.16,0.2975 NMOS_VTL
M$16 9 3 8 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.35,0.2975 NMOS_VTL
M$17 8 4 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI221_X2

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell NOR4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 11 1 12 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 10 2 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 6 3 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 9 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 13 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 8 1 13 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 4 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 6 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 7 1 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 6 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 7 3 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR4_X2

* cell LOGIC0_X1
* pin Z
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT LOGIC0_X1 1 3 4
* net 1 Z
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.185,1.19 PMOS_VTL
M$1 4 2 2 4 PMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
* device instance $2 r0 *1 0.185,0.21 NMOS_VTL
M$2 3 2 1 3 NMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
.ENDS LOGIC0_X1

* cell CLKBUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.17,0.1875 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $5 r0 *1 0.36,0.1875 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.39U AS=0.0273P AD=0.034125P PS=0.67U PD=0.935U
.ENDS CLKBUF_X2

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X4 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT INV_X2 1 2 3
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell BUF_X8
* pin PWELL,VSS
* pin Z
* pin NWELL,VDD
* pin A
.SUBCKT BUF_X8 1 3 4 5
* net 1 PWELL,VSS
* net 3 Z
* net 4 NWELL,VDD
* net 5 A
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 5 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 3 2 4 4 PMOS_VTL L=0.05U W=5.04U AS=0.3528P AD=0.37485P PS=6.16U PD=6.86U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.2324P AD=0.246925P PS=4.44U PD=4.925U
.ENDS BUF_X8

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell DFF_X2
* pin PWELL,VSS
* pin D
* pin CK
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFF_X2 1 6 8 10 11 16
* net 1 PWELL,VSS
* net 6 D
* net 8 CK
* net 10 QN
* net 11 Q
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.855,0.995 PMOS_VTL
M$1 10 9 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.235,0.995 PMOS_VTL
M$3 11 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.2,0.9275 PMOS_VTL
M$5 16 7 3 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $6 r0 *1 0.39,1.04 PMOS_VTL
M$6 17 4 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $7 r0 *1 0.58,1.04 PMOS_VTL
M$7 17 7 5 16 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $8 r0 *1 0.77,0.975 PMOS_VTL
M$8 18 3 5 16 PMOS_VTL L=0.05U W=0.42U AS=0.01785P AD=0.0294P PS=0.56U PD=0.56U
* device instance $9 r0 *1 0.96,0.975 PMOS_VTL
M$9 16 6 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 1.15,1.0275 PMOS_VTL
M$10 4 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $11 r0 *1 2.135,0.915 PMOS_VTL
M$11 20 3 9 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $12 r0 *1 2.325,0.915 PMOS_VTL
M$12 20 2 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $13 r0 *1 1.565,1.0275 PMOS_VTL
M$13 16 8 7 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $14 r0 *1 1.755,1.0275 PMOS_VTL
M$14 19 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $15 r0 *1 1.945,1.0275 PMOS_VTL
M$15 9 7 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.515,0.995 PMOS_VTL
M$16 2 9 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 2.855,0.2975 NMOS_VTL
M$17 10 9 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $19 r0 *1 3.235,0.2975 NMOS_VTL
M$19 11 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $21 r0 *1 0.39,0.31 NMOS_VTL
M$21 12 4 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $22 r0 *1 0.58,0.31 NMOS_VTL
M$22 12 3 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $23 r0 *1 1.15,0.25 NMOS_VTL
M$23 4 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $24 r0 *1 0.77,0.2825 NMOS_VTL
M$24 13 7 5 1 NMOS_VTL L=0.05U W=0.275U AS=0.012775P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $25 r0 *1 0.96,0.2825 NMOS_VTL
M$25 1 6 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $26 r0 *1 0.2,0.37 NMOS_VTL
M$26 1 7 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $27 r0 *1 1.565,0.35 NMOS_VTL
M$27 1 8 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $28 r0 *1 1.755,0.35 NMOS_VTL
M$28 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $29 r0 *1 1.945,0.35 NMOS_VTL
M$29 9 3 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $30 r0 *1 2.135,0.41 NMOS_VTL
M$30 15 7 9 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $31 r0 *1 2.325,0.41 NMOS_VTL
M$31 15 2 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $32 r0 *1 2.515,0.2975 NMOS_VTL
M$32 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFF_X2

* cell DFF_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 8 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 2.125,0.345 NMOS_VTL
M$17 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $18 r0 *1 2.32,0.345 NMOS_VTL
M$18 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $19 r0 *1 1.555,0.36 NMOS_VTL
M$19 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $20 r0 *1 1.745,0.36 NMOS_VTL
M$20 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $21 r0 *1 1.935,0.36 NMOS_VTL
M$21 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $22 r0 *1 2.51,0.36 NMOS_VTL
M$22 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
* device instance $23 r0 *1 0.185,0.285 NMOS_VTL
M$23 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $24 r0 *1 0.375,0.345 NMOS_VTL
M$24 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 0.565,0.345 NMOS_VTL
M$25 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $26 r0 *1 1.14,0.285 NMOS_VTL
M$26 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.76,0.3175 NMOS_VTL
M$27 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $28 r0 *1 0.95,0.3175 NMOS_VTL
M$28 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
.ENDS DFF_X1

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell NOR2_X4
* pin A2
* pin A1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT NOR2_X4 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 ZN
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 9 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 3 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 8 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 1 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 3 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 6 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 1 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 3 1 4 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 4 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS NOR2_X4

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell NAND3_X2
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 10 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 9 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 1 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X2

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell NOR2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 4 1 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.21,0.2975 NMOS_VTL
M$5 5 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $6 r0 *1 0.4,0.2975 NMOS_VTL
M$6 3 2 5 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR2_X2

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4
