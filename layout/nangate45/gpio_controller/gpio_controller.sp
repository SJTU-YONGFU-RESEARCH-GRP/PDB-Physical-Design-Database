* cell gpio_controller
* pin clk
* pin gpio_in[20]
* pin int_status[22]
* pin int_polarity[23]
* pin int_clear[22]
* pin int_clear[23]
* pin int_enable[23]
* pin gpio_out[20]
* pin gpio_pins[20]
* pin gpio_in[24]
* pin int_status[17]
* pin int_clear[20]
* pin int_status[20]
* pin int_polarity[20]
* pin gpio_out[24]
* pin gpio_pins[24]
* pin int_enable[20]
* pin gpio_out[26]
* pin gpio_in[26]
* pin gpio_pins[26]
* pin gpio_in[25]
* pin gpio_pins[25]
* pin gpio_out[25]
* pin int_clear[24]
* pin int_polarity[24]
* pin int_clear[26]
* pin int_polarity[26]
* pin int_enable[24]
* pin int_enable[26]
* pin gpio_out[3]
* pin gpio_out[27]
* pin gpio_in[3]
* pin gpio_pins[27]
* pin int_out
* pin gpio_pins[3]
* pin gpio_in[27]
* pin int_clear[27]
* pin int_polarity[25]
* pin int_polarity[27]
* pin int_enable[27]
* pin int_clear[29]
* pin int_clear[25]
* pin gpio_out[29]
* pin gpio_pins[29]
* pin gpio_in[29]
* pin gpio_out[31]
* pin gpio_pins[31]
* pin gpio_in[31]
* pin gpio_out[28]
* pin gpio_pins[28]
* pin gpio_in[28]
* pin gpio_in[19]
* pin gpio_pins[19]
* pin gpio_in[2]
* pin gpio_in[30]
* pin gpio_out[22]
* pin int_clear[30]
* pin PWELL
* pin int_clear[28]
* pin gpio_in[23]
* pin int_type[27]
* pin NWELL
* pin gpio_out[23]
* pin int_status[31]
* pin gpio_pins[23]
* pin int_type[23]
* pin int_enable[28]
* pin int_status[24]
* pin int_type[20]
* pin int_type[26]
* pin gpio_pins[22]
* pin gpio_in[22]
* pin int_type[24]
* pin int_enable[31]
* pin int_type[29]
* pin int_polarity[28]
* pin int_type[22]
* pin int_type[28]
* pin int_polarity[22]
* pin int_status[23]
* pin int_status[26]
* pin int_polarity[31]
* pin int_enable[22]
* pin int_type[31]
* pin gpio_out[19]
* pin gpio_out[1]
* pin int_enable[21]
* pin int_clear[19]
* pin int_status[29]
* pin int_status[27]
* pin int_polarity[29]
* pin int_polarity[19]
* pin int_enable[29]
* pin int_enable[19]
* pin int_status[28]
* pin int_clear[17]
* pin gpio_pins[1]
* pin int_status[25]
* pin int_clear[31]
* pin int_status[30]
* pin gpio_out[21]
* pin int_type[19]
* pin int_enable[25]
* pin gpio_pins[30]
* pin gpio_pins[21]
* pin int_status[19]
* pin int_polarity[21]
* pin int_type[25]
* pin int_polarity[30]
* pin gpio_out[30]
* pin int_type[21]
* pin gpio_in[21]
* pin int_type[30]
* pin int_enable[30]
* pin int_clear[21]
* pin int_status[21]
* pin gpio_in[1]
* pin gpio_out[4]
* pin gpio_out[2]
* pin gpio_pins[2]
* pin int_clear[18]
* pin int_status[18]
* pin gpio_pins[4]
* pin gpio_in[4]
* pin int_polarity[3]
* pin int_type[1]
* pin gpio_pins[18]
* pin int_polarity[1]
* pin gpio_out[18]
* pin int_type[3]
* pin int_enable[18]
* pin int_type[18]
* pin int_type[4]
* pin int_polarity[4]
* pin rst_n
* pin int_polarity[18]
* pin int_enable[4]
* pin int_enable[3]
* pin int_status[16]
* pin int_enable[1]
* pin int_polarity[2]
* pin int_enable[2]
* pin int_enable[16]
* pin int_status[2]
* pin int_type[16]
* pin gpio_in[16]
* pin gpio_pins[17]
* pin int_status[0]
* pin int_status[3]
* pin int_clear[4]
* pin int_enable[17]
* pin int_polarity[17]
* pin gpio_out[5]
* pin int_type[2]
* pin int_type[17]
* pin int_status[1]
* pin gpio_in[17]
* pin gpio_out[17]
* pin gpio_in[6]
* pin gpio_pins[5]
* pin gpio_pins[0]
* pin gpio_out[0]
* pin int_enable[5]
* pin int_clear[5]
* pin gpio_pins[16]
* pin int_clear[2]
* pin gpio_out[6]
* pin int_type[11]
* pin int_enable[11]
* pin int_polarity[6]
* pin gpio_out[11]
* pin gpio_pins[11]
* pin int_type[6]
* pin gpio_pins[6]
* pin gpio_out[16]
* pin gpio_in[11]
* pin int_polarity[11]
* pin int_clear[7]
* pin int_status[5]
* pin int_status[7]
* pin int_polarity[16]
* pin gpio_pins[10]
* pin int_enable[7]
* pin int_type[7]
* pin int_clear[16]
* pin gpio_in[10]
* pin gpio_out[10]
* pin int_polarity[7]
* pin int_status[4]
* pin int_enable[6]
* pin gpio_in[0]
* pin gpio_in[18]
* pin int_polarity[5]
* pin int_clear[3]
* pin gpio_in[15]
* pin gpio_out[15]
* pin gpio_pins[15]
* pin int_status[14]
* pin int_type[5]
* pin gpio_in[5]
* pin gpio_pins[7]
* pin gpio_pins[12]
* pin int_clear[1]
* pin int_enable[0]
* pin int_enable[14]
* pin gpio_pins[8]
* pin gpio_in[12]
* pin int_enable[12]
* pin int_polarity[12]
* pin gpio_out[12]
* pin int_clear[10]
* pin int_clear[11]
* pin int_type[10]
* pin int_polarity[15]
* pin int_type[15]
* pin int_polarity[10]
* pin int_enable[15]
* pin int_clear[15]
* pin int_status[11]
* pin int_enable[10]
* pin int_status[15]
* pin gpio_in[9]
* pin gpio_out[9]
* pin int_status[10]
* pin gpio_pins[9]
* pin int_type[12]
* pin gpio_in[13]
* pin int_clear[12]
* pin gpio_out[13]
* pin int_status[12]
* pin gpio_pins[13]
* pin int_polarity[9]
* pin int_type[9]
* pin int_enable[9]
* pin gpio_out[14]
* pin int_clear[13]
* pin gpio_pins[14]
* pin int_status[13]
* pin int_type[0]
* pin int_status[9]
* pin gpio_out[8]
* pin int_polarity[13]
* pin int_type[13]
* pin int_enable[13]
* pin int_status[8]
* pin int_clear[8]
* pin gpio_out[7]
* pin int_enable[8]
* pin int_type[8]
* pin int_polarity[8]
* pin int_polarity[14]
* pin int_type[14]
* pin gpio_in[8]
* pin int_clear[6]
* pin int_clear[14]
* pin int_status[6]
* pin int_clear[0]
* pin int_clear[9]
* pin int_polarity[0]
* pin gpio_in[7]
* pin gpio_in[14]
.SUBCKT gpio_controller 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47
+ 48 49 50 51 52 55 80 81 82 83 87 89 97 108 111 119 140 156 157 164 165 176
+ 188 189 196 197 218 219 220 221 233 238 239 254 263 276 285 286 288 289 290
+ 304 305 306 307 308 317 329 341 342 352 353 354 361 362 383 384 396 397 398
+ 411 412 413 417 418 426 427 434 435 436 443 444 445 449 450 463 464 468 470
+ 472 473 474 484 491 492 506 507 518 519 528 529 537 538 542 543 546 554 561
+ 562 563 574 575 576 588 589 600 601 610 615 620 621 631 632 633 634 645 646
+ 653 659 660 662 663 670 676 677 694 695 707 708 709 723 724 725 735 736 750
+ 751 764 765 766 780 781 782 786 787 801 802 812 813 814 825 826 827 837 870
+ 871 925 937 938 939 940 941 942 943 944 945 946 947 948 949 950 951 953 954
+ 955 956 957 958 959 960 961 962 963 964 965 966 967 968 969 970 971 972 973
+ 974 975 976 977 978 979 980 981 982 983 984 985 986 987 988 989 990 991 992
+ 993 994
* net 1 clk
* net 2 gpio_in[20]
* net 3 int_status[22]
* net 4 int_polarity[23]
* net 5 int_clear[22]
* net 6 int_clear[23]
* net 7 int_enable[23]
* net 8 gpio_out[20]
* net 9 gpio_pins[20]
* net 10 gpio_in[24]
* net 11 int_status[17]
* net 12 int_clear[20]
* net 13 int_status[20]
* net 14 int_polarity[20]
* net 15 gpio_out[24]
* net 16 gpio_pins[24]
* net 17 int_enable[20]
* net 18 gpio_out[26]
* net 19 gpio_in[26]
* net 20 gpio_pins[26]
* net 21 gpio_in[25]
* net 22 gpio_pins[25]
* net 23 gpio_out[25]
* net 24 int_clear[24]
* net 25 int_polarity[24]
* net 26 int_clear[26]
* net 27 int_polarity[26]
* net 28 int_enable[24]
* net 29 int_enable[26]
* net 30 gpio_out[3]
* net 31 gpio_out[27]
* net 32 gpio_in[3]
* net 33 gpio_pins[27]
* net 34 int_out
* net 35 gpio_pins[3]
* net 36 gpio_in[27]
* net 37 int_clear[27]
* net 38 int_polarity[25]
* net 39 int_polarity[27]
* net 40 int_enable[27]
* net 41 int_clear[29]
* net 42 int_clear[25]
* net 43 gpio_out[29]
* net 44 gpio_pins[29]
* net 45 gpio_in[29]
* net 46 gpio_out[31]
* net 47 gpio_pins[31]
* net 48 gpio_in[31]
* net 49 gpio_out[28]
* net 50 gpio_pins[28]
* net 51 gpio_in[28]
* net 52 gpio_in[19]
* net 55 gpio_pins[19]
* net 80 gpio_in[2]
* net 81 gpio_in[30]
* net 82 gpio_out[22]
* net 83 int_clear[30]
* net 87 PWELL
* net 89 int_clear[28]
* net 97 gpio_in[23]
* net 108 int_type[27]
* net 111 NWELL
* net 119 gpio_out[23]
* net 140 int_status[31]
* net 156 gpio_pins[23]
* net 157 int_type[23]
* net 164 int_enable[28]
* net 165 int_status[24]
* net 176 int_type[20]
* net 188 int_type[26]
* net 189 gpio_pins[22]
* net 196 gpio_in[22]
* net 197 int_type[24]
* net 218 int_enable[31]
* net 219 int_type[29]
* net 220 int_polarity[28]
* net 221 int_type[22]
* net 233 int_type[28]
* net 238 int_polarity[22]
* net 239 int_status[23]
* net 254 int_status[26]
* net 263 int_polarity[31]
* net 276 int_enable[22]
* net 285 int_type[31]
* net 286 gpio_out[19]
* net 288 gpio_out[1]
* net 289 int_enable[21]
* net 290 int_clear[19]
* net 304 int_status[29]
* net 305 int_status[27]
* net 306 int_polarity[29]
* net 307 int_polarity[19]
* net 308 int_enable[29]
* net 317 int_enable[19]
* net 329 int_status[28]
* net 341 int_clear[17]
* net 342 gpio_pins[1]
* net 352 int_status[25]
* net 353 int_clear[31]
* net 354 int_status[30]
* net 361 gpio_out[21]
* net 362 int_type[19]
* net 383 int_enable[25]
* net 384 gpio_pins[30]
* net 396 gpio_pins[21]
* net 397 int_status[19]
* net 398 int_polarity[21]
* net 411 int_type[25]
* net 412 int_polarity[30]
* net 413 gpio_out[30]
* net 417 int_type[21]
* net 418 gpio_in[21]
* net 426 int_type[30]
* net 427 int_enable[30]
* net 434 int_clear[21]
* net 435 int_status[21]
* net 436 gpio_in[1]
* net 443 gpio_out[4]
* net 444 gpio_out[2]
* net 445 gpio_pins[2]
* net 449 int_clear[18]
* net 450 int_status[18]
* net 463 gpio_pins[4]
* net 464 gpio_in[4]
* net 468 int_polarity[3]
* net 470 int_type[1]
* net 472 gpio_pins[18]
* net 473 int_polarity[1]
* net 474 gpio_out[18]
* net 484 int_type[3]
* net 491 int_enable[18]
* net 492 int_type[18]
* net 506 int_type[4]
* net 507 int_polarity[4]
* net 518 rst_n
* net 519 int_polarity[18]
* net 528 int_enable[4]
* net 529 int_enable[3]
* net 537 int_status[16]
* net 538 int_enable[1]
* net 542 int_polarity[2]
* net 543 int_enable[2]
* net 546 int_enable[16]
* net 554 int_status[2]
* net 561 int_type[16]
* net 562 gpio_in[16]
* net 563 gpio_pins[17]
* net 574 int_status[0]
* net 575 int_status[3]
* net 576 int_clear[4]
* net 588 int_enable[17]
* net 589 int_polarity[17]
* net 600 gpio_out[5]
* net 601 int_type[2]
* net 610 int_type[17]
* net 615 int_status[1]
* net 620 gpio_in[17]
* net 621 gpio_out[17]
* net 631 gpio_in[6]
* net 632 gpio_pins[5]
* net 633 gpio_pins[0]
* net 634 gpio_out[0]
* net 645 int_enable[5]
* net 646 int_clear[5]
* net 653 gpio_pins[16]
* net 659 int_clear[2]
* net 660 gpio_out[6]
* net 662 int_type[11]
* net 663 int_enable[11]
* net 670 int_polarity[6]
* net 676 gpio_out[11]
* net 677 gpio_pins[11]
* net 694 int_type[6]
* net 695 gpio_pins[6]
* net 707 gpio_out[16]
* net 708 gpio_in[11]
* net 709 int_polarity[11]
* net 723 int_clear[7]
* net 724 int_status[5]
* net 725 int_status[7]
* net 735 int_polarity[16]
* net 736 gpio_pins[10]
* net 750 int_enable[7]
* net 751 int_type[7]
* net 764 int_clear[16]
* net 765 gpio_in[10]
* net 766 gpio_out[10]
* net 780 int_polarity[7]
* net 781 int_status[4]
* net 782 int_enable[6]
* net 786 gpio_in[0]
* net 787 gpio_in[18]
* net 801 int_polarity[5]
* net 802 int_clear[3]
* net 812 gpio_in[15]
* net 813 gpio_out[15]
* net 814 gpio_pins[15]
* net 825 int_status[14]
* net 826 int_type[5]
* net 827 gpio_in[5]
* net 837 gpio_pins[7]
* net 870 gpio_pins[12]
* net 871 int_clear[1]
* net 925 int_enable[0]
* net 937 int_enable[14]
* net 938 gpio_pins[8]
* net 939 gpio_in[12]
* net 940 int_enable[12]
* net 941 int_polarity[12]
* net 942 gpio_out[12]
* net 943 int_clear[10]
* net 944 int_clear[11]
* net 945 int_type[10]
* net 946 int_polarity[15]
* net 947 int_type[15]
* net 948 int_polarity[10]
* net 949 int_enable[15]
* net 950 int_clear[15]
* net 951 int_status[11]
* net 953 int_enable[10]
* net 954 int_status[15]
* net 955 gpio_in[9]
* net 956 gpio_out[9]
* net 957 int_status[10]
* net 958 gpio_pins[9]
* net 959 int_type[12]
* net 960 gpio_in[13]
* net 961 int_clear[12]
* net 962 gpio_out[13]
* net 963 int_status[12]
* net 964 gpio_pins[13]
* net 965 int_polarity[9]
* net 966 int_type[9]
* net 967 int_enable[9]
* net 968 gpio_out[14]
* net 969 int_clear[13]
* net 970 gpio_pins[14]
* net 971 int_status[13]
* net 972 int_type[0]
* net 973 int_status[9]
* net 974 gpio_out[8]
* net 975 int_polarity[13]
* net 976 int_type[13]
* net 977 int_enable[13]
* net 978 int_status[8]
* net 979 int_clear[8]
* net 980 gpio_out[7]
* net 981 int_enable[8]
* net 982 int_type[8]
* net 983 int_polarity[8]
* net 984 int_polarity[14]
* net 985 int_type[14]
* net 986 gpio_in[8]
* net 987 int_clear[6]
* net 988 int_clear[14]
* net 989 int_status[6]
* net 990 int_clear[0]
* net 991 int_clear[9]
* net 992 int_polarity[0]
* net 993 gpio_in[7]
* net 994 gpio_in[14]
* cell instance $2 r0 *1 24.51,23.8
X$2 1 87 111 298 CLKBUF_X3
* cell instance $7 r0 *1 6.84,1.4
X$7 56 87 111 2 BUF_X1
* cell instance $14 r0 *1 9.88,1.4
X$14 88 87 111 3 BUF_X1
* cell instance $20 r0 *1 10.45,1.4
X$20 4 87 111 85 BUF_X1
* cell instance $26 r0 *1 11.02,1.4
X$26 5 87 111 59 BUF_X1
* cell instance $32 r0 *1 11.59,1.4
X$32 6 87 111 147 BUF_X1
* cell instance $38 r0 *1 12.16,1.4
X$38 7 87 111 113 BUF_X1
* cell instance $44 r0 *1 12.73,1.4
X$44 8 87 111 60 BUF_X1
* cell instance $50 m0 *1 12.73,4.2
X$50 60 87 111 9 BUF_X1
* cell instance $56 r0 *1 13.87,1.4
X$56 90 87 111 10 BUF_X1
* cell instance $62 r0 *1 14.44,1.4
X$62 99 87 111 11 BUF_X1
* cell instance $68 r0 *1 15.01,1.4
X$68 12 87 111 61 BUF_X1
* cell instance $74 r0 *1 16.91,1.4
X$74 62 87 111 13 BUF_X1
* cell instance $84 r0 *1 16.34,1.4
X$84 14 87 111 117 BUF_X1
* cell instance $86 r0 *1 17.48,1.4
X$86 15 87 111 64 BUF_X1
* cell instance $92 r0 *1 18.05,1.4
X$92 64 87 111 16 BUF_X1
* cell instance $98 m0 *1 17.67,4.2
X$98 17 87 111 130 BUF_X1
* cell instance $108 r0 *1 18.62,1.4
X$108 18 87 111 65 BUF_X1
* cell instance $110 m0 *1 19.19,4.2
X$110 153 87 111 19 BUF_X1
* cell instance $116 r0 *1 19.19,1.4
X$116 65 87 111 20 BUF_X1
* cell instance $122 r0 *1 19.76,1.4
X$122 118 87 111 21 BUF_X1
* cell instance $128 r0 *1 20.33,1.4
X$128 101 87 111 22 BUF_X1
* cell instance $134 r0 *1 20.9,1.4
X$134 23 87 111 101 BUF_X1
* cell instance $144 r0 *1 21.85,1.4
X$144 24 87 111 66 BUF_X1
* cell instance $150 r0 *1 22.42,1.4
X$150 25 87 111 102 BUF_X1
* cell instance $152 m0 *1 23.75,4.2
X$152 26 87 111 133 BUF_X1
* cell instance $162 r0 *1 23.56,1.4
X$162 27 87 111 202 BUF_X1
* cell instance $164 r0 *1 22.99,1.4
X$164 28 87 111 132 BUF_X1
* cell instance $170 m0 *1 25.08,4.2
X$170 29 87 111 192 BUF_X1
* cell instance $180 r0 *1 25.27,1.4
X$180 30 87 111 67 BUF_X1
* cell instance $186 r0 *1 25.84,1.4
X$186 31 87 111 69 BUF_X1
* cell instance $188 r0 *1 24.7,1.4
X$188 92 87 111 32 BUF_X1
* cell instance $194 r0 *1 28.12,1.4
X$194 69 87 111 33 BUF_X1
* cell instance $200 r0 *1 28.69,1.4
X$200 94 87 111 34 BUF_X1
* cell instance $206 r0 *1 27.55,1.4
X$206 67 87 111 35 BUF_X1
* cell instance $212 r0 *1 29.83,1.4
X$212 95 87 111 36 BUF_X1
* cell instance $218 r0 *1 30.4,1.4
X$218 37 87 111 70 BUF_X1
* cell instance $224 r0 *1 30.97,1.4
X$224 38 87 111 114 BUF_X1
* cell instance $230 r0 *1 31.54,1.4
X$230 39 87 111 71 BUF_X1
* cell instance $236 r0 *1 32.11,1.4
X$236 40 87 111 106 BUF_X1
* cell instance $242 m0 *1 34.01,4.2
X$242 41 87 111 209 BUF_X1
* cell instance $248 m0 *1 31.92,4.2
X$248 42 87 111 150 BUF_X1
* cell instance $254 r0 *1 32.68,1.4
X$254 43 87 111 72 BUF_X1
* cell instance $260 r0 *1 33.25,1.4
X$260 72 87 111 44 BUF_X1
* cell instance $266 r0 *1 33.82,1.4
X$266 107 87 111 45 BUF_X1
* cell instance $272 r0 *1 34.39,1.4
X$272 46 87 111 73 BUF_X1
* cell instance $278 m0 *1 34.58,4.2
X$278 73 87 111 47 BUF_X1
* cell instance $284 r0 *1 38.57,1.4
X$284 93 87 111 48 BUF_X1
* cell instance $290 r0 *1 34.96,1.4
X$290 49 87 111 74 BUF_X1
* cell instance $296 r0 *1 35.53,1.4
X$296 74 87 111 50 BUF_X1
* cell instance $302 r0 *1 37.43,1.4
X$302 96 87 111 51 BUF_X1
* cell instance $308 r0 *1 3.42,1.4
X$308 84 87 111 52 BUF_X1
* cell instance $313 r0 *1 1.33,1.4
X$313 82 87 111 53 BUF_X1
* cell instance $315 m0 *1 3.23,7
X$315 178 53 111 87 198 AND2_X1
* cell instance $318 m0 *1 1.33,7
X$318 53 87 111 189 BUF_X1
* cell instance $321 r0 *1 1.52,4.2
X$321 53 87 111 177 BUF_X1
* cell instance $323 r0 *1 1.9,1.4
X$323 54 87 111 55 BUF_X1
* cell instance $326 r0 *1 4.18,9.8
X$326 178 54 111 87 357 AND2_X1
* cell instance $328 r0 *1 2.85,1.4
X$328 54 87 111 84 BUF_X1
* cell instance $331 r0 *1 1.33,9.8
X$331 286 87 111 54 BUF_X1
* cell instance $342 r0 *1 7.41,1.4
X$342 60 87 111 56 BUF_X1
* cell instance $344 r0 *1 9.5,1.4
X$344 58 87 111 57 INV_X1
* cell instance $346 r0 *1 8.74,1.4
X$346 86 125 57 87 112 111 AOI21_X1
* cell instance $348 r0 *1 10.07,4.2
X$348 167 125 58 87 146 111 AOI21_X1
* cell instance $351 m0 *1 7.03,4.2
X$351 87 58 143 123 111 DFF_X1
* cell instance $356 r0 *1 9.31,4.2
X$356 128 59 87 111 180 OR2_X1
* cell instance $362 m0 *1 11.59,9.8
X$362 178 60 111 87 312 AND2_X1
* cell instance $372 r0 *1 15.58,1.4
X$372 128 61 87 111 63 OR2_X1
* cell instance $376 m0 *1 16.53,4.2
X$376 62 87 111 100 INV_X1
* cell instance $378 m0 *1 13.3,4.2
X$378 87 62 151 123 111 DFF_X1
* cell instance $381 m0 *1 14.06,7
X$381 88 245 62 99 87 111 193 NOR4_X1
* cell instance $384 m0 *1 16.91,4.2
X$384 63 100 129 87 151 111 AOI21_X1
* cell instance $391 r0 *1 14.82,7
X$391 178 64 111 87 246 AND2_X1
* cell instance $394 r0 *1 13.3,1.4
X$394 64 87 111 90 BUF_X1
* cell instance $399 m0 *1 18.62,4.2
X$399 65 87 111 153 BUF_X1
* cell instance $402 r0 *1 19.57,7
X$402 178 65 111 87 247 AND2_X1
* cell instance $407 m0 *1 21.85,4.2
X$407 128 66 87 111 154 OR2_X1
* cell instance $409 r0 *1 26.79,15.4
X$409 68 67 111 87 403 AND2_X1
* cell instance $415 r0 *1 24.13,1.4
X$415 67 87 111 92 BUF_X1
* cell instance $421 m0 *1 27.55,29.4
X$421 454 87 111 68 BUF_X2
* cell instance $425 r0 *1 34.77,18.2
X$425 68 380 111 87 448 AND2_X1
* cell instance $428 m0 *1 33.06,7
X$428 68 72 111 87 236 AND2_X1
* cell instance $431 r0 *1 36.1,1.4
X$431 68 74 111 87 75 AND2_X1
* cell instance $433 m0 *1 35.91,29.4
X$433 68 603 111 87 607 AND2_X1
* cell instance $437 r0 *1 33.25,29.4
X$437 68 612 111 87 619 AND2_X1
* cell instance $439 m0 *1 35.15,4.2
X$439 68 73 111 87 137 AND2_X1
* cell instance $442 m0 *1 35.91,15.4
X$442 68 387 111 87 377 AND2_X1
* cell instance $444 r0 *1 35.72,18.2
X$444 68 442 111 87 441 AND2_X1
* cell instance $447 r0 *1 26.79,1.4
X$447 68 69 111 87 115 AND2_X1
* cell instance $458 r0 *1 29.26,1.4
X$458 69 87 111 95 BUF_X1
* cell instance $468 m0 *1 30.02,7
X$468 109 70 87 111 207 OR2_X1
* cell instance $470 m0 *1 31.16,4.2
X$470 105 71 87 111 135 OR2_X1
* cell instance $474 m0 *1 30.59,4.2
X$474 71 105 87 111 152 NAND2_X1
* cell instance $480 m0 *1 33.25,4.2
X$480 72 87 111 107 BUF_X1
* cell instance $483 r0 *1 38,1.4
X$483 73 87 111 93 BUF_X1
* cell instance $495 r0 *1 36.86,1.4
X$495 74 87 111 96 BUF_X1
* cell instance $499 m0 *1 36.29,4.2
X$499 87 139 75 138 111 DFF_X1
* cell instance $501 r0 *1 41.23,4.2
X$501 87 76 190 138 111 DFF_X1
* cell instance $503 r0 *1 43.7,1.4
X$503 76 87 111 232 INV_X1
* cell instance $505 m0 *1 44.27,7
X$505 230 213 76 87 215 111 AOI21_X1
* cell instance $507 r0 *1 44.27,1.4
X$507 109 77 87 111 78 OR2_X1
* cell instance $509 r0 *1 45.22,1.4
X$509 89 87 111 77 BUF_X1
* cell instance $512 r0 *1 44.46,4.2
X$512 78 214 187 87 166 111 AOI21_X1
* cell instance $514 r0 *1 45.79,1.4
X$514 83 87 111 79 BUF_X1
* cell instance $516 r0 *1 45.41,4.2
X$516 109 79 87 111 386 OR2_X1
* cell instance $518 r0 *1 43.13,1.4
X$518 91 87 111 80 BUF_X1
* cell instance $523 m0 *1 41.99,4.2
X$523 145 87 111 81 BUF_X1
* cell instance $538 m0 *1 10.26,4.2
X$538 85 124 87 111 167 NAND2_X1
* cell instance $540 r0 *1 7.98,1.4
X$540 124 85 87 111 86 OR2_X1
* cell instance $549 m0 *1 20.52,37.8
X$549 715 87 111 1004 INV_X2
* cell instance $550 m0 *1 19.57,37.8
X$550 298 87 111 715 CLKBUF_X3
* cell instance $552 m0 *1 24.13,37.8
X$552 87 762 743 687 111 DFF_X1
* cell instance $554 m0 *1 27.55,37.8
X$554 568 744 111 87 763 AND2_X1
* cell instance $557 r0 *1 19.76,37.8
X$557 636 833 111 87 684 AND2_X1
* cell instance $560 r0 *1 21.09,37.8
X$560 636 686 111 87 772 AND2_X1
* cell instance $564 r0 *1 23.94,37.8
X$564 636 742 111 87 743 AND2_X1
* cell instance $567 r0 *1 25.84,37.8
X$567 87 810 763 687 111 DFF_X1
* cell instance $568 m0 *1 29.64,37.8
X$568 654 762 111 87 745 AND2_X1
* cell instance $569 m0 *1 28.69,37.8
X$569 298 87 111 687 CLKBUF_X3
* cell instance $570 m0 *1 30.4,37.8
X$570 687 87 111 1003 INV_X2
* cell instance $572 m0 *1 31.16,37.8
X$572 654 785 111 87 734 AND2_X1
* cell instance $576 r0 *1 29.26,37.8
X$576 87 773 745 687 111 DFF_X1
* cell instance $577 r0 *1 32.49,37.8
X$577 87 823 761 693 111 DFF_X1
* cell instance $578 m0 *1 33.25,37.8
X$578 211 688 111 87 761 AND2_X1
* cell instance $581 m0 *1 34.77,37.8
X$581 87 720 717 693 111 DFF_X1
* cell instance $583 r0 *1 35.72,37.8
X$583 693 87 111 CLKBUF_X1
* cell instance $586 m0 *1 39.14,37.8
X$586 211 720 111 87 747 AND2_X1
* cell instance $587 m0 *1 38.38,37.8
X$587 759 718 758 111 746 87 OAI21_X1
* cell instance $591 m0 *1 42.37,37.8
X$591 721 720 87 111 776 NAND2_X1
* cell instance $592 m0 *1 42.94,37.8
X$592 720 721 87 111 755 OR2_X1
* cell instance $593 m0 *1 43.7,37.8
X$593 109 753 87 111 749 OR2_X1
* cell instance $595 r0 *1 38.57,37.8
X$595 87 775 747 693 111 DFF_X1
* cell instance $596 r0 *1 41.8,37.8
X$596 775 87 111 748 INV_X1
* cell instance $598 r0 *1 42.37,37.8
X$598 755 748 777 87 756 111 AOI21_X1
* cell instance $599 r0 *1 43.13,37.8
X$599 87 774 778 693 111 DFF_X1
* cell instance $600 m0 *1 45.03,37.8
X$600 723 87 111 753 BUF_X1
* cell instance $603 m0 *1 45.79,37.8
X$603 774 87 111 725 BUF_X1
* cell instance $606 m0 *1 3.61,18.2
X$606 446 428 296 111 414 87 OAI21_X1
* cell instance $607 m0 *1 2.85,18.2
X$607 399 420 415 87 428 111 AOI21_X1
* cell instance $608 m0 *1 4.37,18.2
X$608 422 401 414 87 421 111 AOI21_X1
* cell instance $609 m0 *1 5.13,18.2
X$609 423 87 111 401 INV_X1
* cell instance $611 m0 *1 6.27,18.2
X$611 87 432 402 322 111 DFF_X1
* cell instance $612 m0 *1 9.5,18.2
X$612 87 365 424 322 111 DFF_X1
* cell instance $613 m0 *1 12.73,18.2
X$613 322 87 111 1005 INV_X2
* cell instance $618 m0 *1 1.33,18.2
X$618 369 87 111 418 BUF_X1
* cell instance $620 m0 *1 1.9,18.2
X$620 417 87 111 420 BUF_X1
* cell instance $623 r0 *1 1.33,18.2
X$623 343 87 111 419 BUF_X1
* cell instance $624 r0 *1 1.9,18.2
X$624 419 87 111 436 BUF_X1
* cell instance $625 r0 *1 2.47,18.2
X$625 423 87 111 435 BUF_X1
* cell instance $630 r0 *1 3.23,18.2
X$630 87 423 421 346 111 DFF_X1
* cell instance $631 r0 *1 6.46,18.2
X$631 437 367 476 423 111 324 87 NOR4_X2
* cell instance $632 r0 *1 8.17,18.2
X$632 131 365 111 87 447 AND2_X1
* cell instance $635 r0 *1 9.5,18.2
X$635 144 432 111 87 424 AND2_X1
* cell instance $636 r0 *1 10.26,18.2
X$636 298 87 111 322 CLKBUF_X3
* cell instance $637 r0 *1 11.21,18.2
X$637 178 343 111 87 438 AND2_X1
* cell instance $641 m0 *1 26.79,18.2
X$641 87 433 403 299 111 DFF_X1
* cell instance $648 r0 *1 30.02,18.2
X$648 237 433 111 87 439 AND2_X1
* cell instance $649 m0 *1 31.35,18.2
X$649 299 87 111 1000 INV_X2
* cell instance $650 m0 *1 30.4,18.2
X$650 298 87 111 299 CLKBUF_X3
* cell instance $655 r0 *1 31.54,18.2
X$655 87 440 448 299 111 DFF_X1
* cell instance $657 m0 *1 36.29,18.2
X$657 378 87 111 1010 INV_X1
* cell instance $659 m0 *1 36.67,18.2
X$659 298 87 111 378 CLKBUF_X3
* cell instance $660 m0 *1 37.62,18.2
X$660 87 406 405 378 111 DFF_X1
* cell instance $661 m0 *1 40.85,18.2
X$661 87 408 407 378 111 DFF_X1
* cell instance $662 m0 *1 44.08,18.2
X$662 409 431 408 87 430 111 AOI21_X1
* cell instance $663 m0 *1 44.84,18.2
X$663 410 431 425 87 416 111 AOI21_X1
* cell instance $664 m0 *1 45.6,18.2
X$664 416 430 429 111 382 87 OAI21_X1
* cell instance $667 r0 *1 42.56,18.2
X$667 413 87 111 387 BUF_X1
* cell instance $668 r0 *1 43.13,18.2
X$668 380 87 111 445 BUF_X1
* cell instance $669 r0 *1 43.7,18.2
X$669 426 87 111 431 BUF_X1
* cell instance $671 r0 *1 44.65,18.2
X$671 408 87 111 425 INV_X1
* cell instance $673 r0 *1 45.22,18.2
X$673 443 87 111 442 BUF_X1
* cell instance $674 r0 *1 45.79,18.2
X$674 427 87 111 429 BUF_X1
* cell instance $679 m0 *1 5.89,46.2
X$679 888 87 111 939 BUF_X1
* cell instance $680 m0 *1 6.46,46.2
X$680 942 87 111 852 BUF_X1
* cell instance $681 m0 *1 7.03,46.2
X$681 940 87 111 790 BUF_X1
* cell instance $682 m0 *1 7.6,46.2
X$682 944 87 111 889 BUF_X1
* cell instance $683 m0 *1 8.17,46.2
X$683 941 87 111 769 BUF_X1
* cell instance $684 m0 *1 8.74,46.2
X$684 946 87 111 844 BUF_X1
* cell instance $685 m0 *1 9.31,46.2
X$685 943 87 111 936 BUF_X1
* cell instance $686 m0 *1 9.88,46.2
X$686 947 87 111 890 BUF_X1
* cell instance $687 m0 *1 10.45,46.2
X$687 891 890 911 87 932 111 AOI21_X1
* cell instance $688 m0 *1 11.21,46.2
X$688 945 87 111 854 BUF_X1
* cell instance $689 m0 *1 11.78,46.2
X$689 949 87 111 893 BUF_X1
* cell instance $690 m0 *1 12.35,46.2
X$690 948 87 111 789 BUF_X1
* cell instance $691 m0 *1 12.92,46.2
X$691 950 87 111 895 BUF_X1
* cell instance $692 m0 *1 13.49,46.2
X$692 953 87 111 896 BUF_X1
* cell instance $693 m0 *1 14.06,46.2
X$693 850 87 111 951 BUF_X1
* cell instance $694 m0 *1 14.63,46.2
X$694 952 87 111 913 INV_X1
* cell instance $695 m0 *1 15.01,46.2
X$695 952 87 111 954 BUF_X1
* cell instance $696 m0 *1 15.58,46.2
X$696 740 87 111 997 BUF_X1
* cell instance $697 m0 *1 16.15,46.2
X$697 997 87 111 955 BUF_X1
* cell instance $698 m0 *1 16.72,46.2
X$698 956 87 111 740 BUF_X1
* cell instance $699 m0 *1 17.29,46.2
X$699 740 87 111 958 BUF_X1
* cell instance $700 m0 *1 17.86,46.2
X$700 857 87 111 957 BUF_X1
* cell instance $701 m0 *1 18.43,46.2
X$701 959 87 111 792 BUF_X1
* cell instance $702 m0 *1 19,46.2
X$702 897 87 111 960 BUF_X1
* cell instance $703 m0 *1 19.57,46.2
X$703 961 87 111 919 BUF_X1
* cell instance $704 m0 *1 20.14,46.2
X$704 920 87 111 963 BUF_X1
* cell instance $705 m0 *1 20.71,46.2
X$705 952 920 923 798 87 111 807 NOR4_X1
* cell instance $706 m0 *1 21.66,46.2
X$706 965 87 111 819 BUF_X1
* cell instance $707 m0 *1 22.23,46.2
X$707 966 87 111 836 BUF_X1
* cell instance $708 m0 *1 22.8,46.2
X$708 967 87 111 898 BUF_X1
* cell instance $709 m0 *1 23.37,46.2
X$709 968 87 111 742 BUF_X1
* cell instance $710 m0 *1 23.94,46.2
X$710 969 87 111 999 BUF_X1
* cell instance $711 m0 *1 24.51,46.2
X$711 923 87 111 971 BUF_X1
* cell instance $712 m0 *1 25.08,46.2
X$712 581 999 87 111 899 OR2_X1
* cell instance $714 m0 *1 26.03,46.2
X$714 742 87 111 970 BUF_X1
* cell instance $715 m0 *1 26.6,46.2
X$715 846 87 111 973 BUF_X1
* cell instance $716 m0 *1 27.17,46.2
X$716 972 87 111 933 BUF_X1
* cell instance $717 m0 *1 27.74,46.2
X$717 716 933 87 111 909 NAND2_X1
* cell instance $718 m0 *1 28.31,46.2
X$718 975 87 111 794 BUF_X1
* cell instance $719 m0 *1 28.88,46.2
X$719 976 87 111 842 BUF_X1
* cell instance $720 m0 *1 29.45,46.2
X$720 977 87 111 900 BUF_X1
* cell instance $721 m0 *1 30.02,46.2
X$721 859 87 111 978 BUF_X1
* cell instance $722 m0 *1 30.59,46.2
X$722 979 87 111 901 BUF_X1
* cell instance $723 m0 *1 31.16,46.2
X$723 533 996 87 111 884 OR2_X1
* cell instance $724 m0 *1 31.92,46.2
X$724 742 87 111 935 BUF_X1
* cell instance $725 m0 *1 32.49,46.2
X$725 982 87 111 902 BUF_X1
* cell instance $726 m0 *1 33.06,46.2
X$726 981 87 111 903 BUF_X1
* cell instance $727 m0 *1 33.63,46.2
X$727 983 87 111 847 BUF_X1
* cell instance $728 m0 *1 34.2,46.2
X$728 974 87 111 795 BUF_X1
* cell instance $729 m0 *1 34.77,46.2
X$729 998 87 111 986 BUF_X1
* cell instance $730 m0 *1 35.34,46.2
X$730 984 87 111 848 BUF_X1
* cell instance $731 m0 *1 35.91,46.2
X$731 985 87 111 904 BUF_X1
* cell instance $732 m0 *1 36.48,46.2
X$732 980 87 111 785 BUF_X1
* cell instance $733 m0 *1 37.05,46.2
X$733 987 87 111 811 BUF_X1
* cell instance $734 m0 *1 37.62,46.2
X$734 798 87 111 989 BUF_X1
* cell instance $735 m0 *1 38.19,46.2
X$735 991 87 111 996 BUF_X1
* cell instance $736 m0 *1 38.76,46.2
X$736 992 87 111 824 BUF_X1
* cell instance $737 m0 *1 39.33,46.2
X$737 988 87 111 906 BUF_X1
* cell instance $738 m0 *1 39.9,46.2
X$738 912 87 111 993 BUF_X1
* cell instance $739 m0 *1 40.47,46.2
X$739 935 87 111 994 BUF_X1
* cell instance $741 m0 *1 41.23,46.2
X$741 990 87 111 995 BUF_X1
* cell instance $742 m0 *1 41.8,46.2
X$742 907 581 995 87 111 934 NOR3_X1
* cell instance $750 m0 *1 20.71,40.6
X$750 87 793 772 715 111 DFF_X1
* cell instance $752 m0 *1 27.74,40.6
X$752 840 807 608 806 87 111 340 NAND4_X1
* cell instance $755 m0 *1 32.49,40.6
X$755 568 773 111 87 796 AND2_X1
* cell instance $759 m0 *1 18.05,40.6
X$759 771 792 770 87 817 111 AOI21_X1
* cell instance $760 m0 *1 17.29,40.6
X$760 784 792 741 87 791 111 AOI21_X1
* cell instance $764 r0 *1 17.48,40.6
X$764 817 791 790 111 818 87 OAI21_X1
* cell instance $768 r0 *1 21.85,40.6
X$768 686 819 87 111 820 OR2_X1
* cell instance $769 r0 *1 22.61,40.6
X$769 819 686 87 111 835 NAND2_X1
* cell instance $771 r0 *1 23.37,40.6
X$771 835 836 793 87 821 111 AOI21_X1
* cell instance $772 r0 *1 24.13,40.6
X$772 793 87 111 838 INV_X1
* cell instance $775 r0 *1 28.31,40.6
X$775 794 744 87 111 822 NAND2_X1
* cell instance $776 r0 *1 28.88,40.6
X$776 744 794 87 111 887 OR2_X1
* cell instance $780 r0 *1 32.11,40.6
X$780 87 834 796 693 111 DFF_X1
* cell instance $784 m0 *1 38.19,40.6
X$784 798 87 111 808 INV_X1
* cell instance $785 m0 *1 37.43,40.6
X$785 109 811 87 111 809 OR2_X1
* cell instance $786 m0 *1 38.57,40.6
X$786 809 808 746 87 797 111 AOI21_X1
* cell instance $789 m0 *1 40.28,40.6
X$789 782 87 111 758 BUF_X1
* cell instance $791 r0 *1 37.43,40.6
X$791 87 798 797 693 111 DFF_X1
* cell instance $793 m0 *1 42.18,40.6
X$793 776 775 777 87 799 111 AOI21_X1
* cell instance $794 m0 *1 41.23,40.6
X$794 849 774 644 722 87 111 806 NOR4_X1
* cell instance $795 m0 *1 42.94,40.6
X$795 780 87 111 721 BUF_X1
* cell instance $796 m0 *1 43.51,40.6
X$796 774 87 111 831 INV_X1
* cell instance $797 m0 *1 43.89,40.6
X$797 751 87 111 777 BUF_X1
* cell instance $798 m0 *1 44.46,40.6
X$798 644 87 111 781 BUF_X1
* cell instance $799 m0 *1 45.03,40.6
X$799 109 779 87 111 553 OR2_X1
* cell instance $800 m0 *1 45.79,40.6
X$800 722 87 111 724 BUF_X1
* cell instance $803 r0 *1 42.37,40.6
X$803 756 799 800 111 830 87 OAI21_X1
* cell instance $804 r0 *1 43.13,40.6
X$804 750 87 111 800 BUF_X1
* cell instance $805 r0 *1 43.7,40.6
X$805 749 831 830 87 778 111 AOI21_X1
* cell instance $806 r0 *1 44.46,40.6
X$806 801 87 111 657 BUF_X1
* cell instance $807 r0 *1 45.03,40.6
X$807 802 87 111 779 BUF_X1
* cell instance $812 m0 *1 1.52,9.8
X$812 276 87 111 265 BUF_X1
* cell instance $813 m0 *1 2.09,9.8
X$813 264 240 277 87 241 111 AOI21_X1
* cell instance $814 m0 *1 2.85,9.8
X$814 241 258 265 111 179 87 OAI21_X1
* cell instance $815 m0 *1 3.61,9.8
X$815 242 244 87 111 259 NAND2_X1
* cell instance $816 m0 *1 4.18,9.8
X$816 244 242 87 111 264 OR2_X1
* cell instance $817 m0 *1 4.94,9.8
X$817 245 87 111 239 BUF_X1
* cell instance $819 m0 *1 5.7,9.8
X$819 87 244 255 123 111 DFF_X1
* cell instance $820 m0 *1 8.93,9.8
X$820 131 244 111 87 267 AND2_X1
* cell instance $824 r0 *1 1.9,9.8
X$824 307 87 111 294 BUF_X1
* cell instance $825 r0 *1 2.47,9.8
X$825 278 87 111 277 INV_X1
* cell instance $826 r0 *1 2.85,9.8
X$826 259 240 278 87 258 111 AOI21_X1
* cell instance $830 r0 *1 3.61,9.8
X$830 289 87 111 296 BUF_X1
* cell instance $831 r0 *1 4.94,9.8
X$831 288 87 111 343 BUF_X1
* cell instance $834 r0 *1 7.79,9.8
X$834 87 278 267 123 111 DFF_X1
* cell instance $836 r0 *1 11.4,9.8
X$836 87 280 312 123 111 DFF_X1
* cell instance $838 m0 *1 13.87,9.8
X$838 87 158 279 182 111 DFF_X1
* cell instance $842 r0 *1 14.63,9.8
X$842 144 280 111 87 279 AND2_X1
* cell instance $846 r0 *1 19.57,9.8
X$846 87 360 247 182 111 DFF_X1
* cell instance $848 r0 *1 23.56,9.8
X$848 87 260 281 134 111 DFF_X1
* cell instance $850 m0 *1 24.32,9.8
X$850 131 203 111 87 281 AND2_X1
* cell instance $851 m0 *1 25.84,9.8
X$851 257 204 260 87 261 111 AOI21_X1
* cell instance $852 m0 *1 25.46,9.8
X$852 260 87 111 205 INV_X1
* cell instance $853 m0 *1 26.6,9.8
X$853 231 275 256 87 274 111 AOI21_X1
* cell instance $855 m0 *1 28.12,9.8
X$855 273 87 111 275 INV_X1
* cell instance $858 m0 *1 30.21,9.8
X$858 87 250 249 134 111 DFF_X1
* cell instance $861 r0 *1 26.79,9.8
X$861 87 273 274 134 111 DFF_X1
* cell instance $863 r0 *1 31.54,9.8
X$863 282 273 250 155 87 111 287 NOR4_X1
* cell instance $866 r0 *1 34.39,9.8
X$866 109 209 87 111 313 OR2_X1
* cell instance $867 r0 *1 35.15,9.8
X$867 282 87 111 314 INV_X1
* cell instance $869 m0 *1 35.34,9.8
X$869 237 251 111 87 283 AND2_X1
* cell instance $872 r0 *1 35.53,9.8
X$872 87 284 283 138 111 DFF_X1
* cell instance $873 m0 *1 38.95,9.8
X$873 273 87 111 254 BUF_X1
* cell instance $877 m0 *1 40.47,9.8
X$877 87 269 272 138 111 DFF_X1
* cell instance $878 m0 *1 43.7,9.8
X$878 269 87 111 266 INV_X1
* cell instance $879 m0 *1 44.08,9.8
X$879 270 252 269 87 262 111 AOI21_X1
* cell instance $880 m0 *1 44.84,9.8
X$880 253 252 266 87 268 111 AOI21_X1
* cell instance $882 m0 *1 45.79,9.8
X$882 263 87 111 217 BUF_X1
* cell instance $884 r0 *1 38.76,9.8
X$884 250 87 111 305 BUF_X1
* cell instance $887 r0 *1 40.28,9.8
X$887 302 284 87 111 301 NAND2_X1
* cell instance $888 r0 *1 40.85,9.8
X$888 284 302 87 111 336 OR2_X1
* cell instance $889 r0 *1 41.61,9.8
X$889 306 87 111 302 BUF_X1
* cell instance $890 r0 *1 42.18,9.8
X$890 282 87 111 304 BUF_X1
* cell instance $892 r0 *1 42.94,9.8
X$892 334 311 310 87 333 111 AOI21_X1
* cell instance $894 r0 *1 43.89,9.8
X$894 141 87 111 311 INV_X1
* cell instance $895 r0 *1 44.27,9.8
X$895 268 262 225 111 310 87 OAI21_X1
* cell instance $896 r0 *1 45.03,9.8
X$896 308 87 111 309 BUF_X1
* cell instance $898 r0 *1 45.79,9.8
X$898 285 87 111 252 BUF_X1
* cell instance $902 m0 *1 2.47,21
X$902 437 87 111 450 BUF_X1
* cell instance $904 m0 *1 3.04,21
X$904 437 87 111 452 INV_X1
* cell instance $905 m0 *1 3.42,21
X$905 400 420 466 87 446 111 AOI21_X1
* cell instance $906 m0 *1 4.18,21
X$906 128 467 87 111 422 OR2_X1
* cell instance $907 m0 *1 4.94,21
X$907 415 87 111 466 INV_X1
* cell instance $910 m0 *1 1.33,21
X$910 434 87 111 467 BUF_X1
* cell instance $914 r0 *1 1.33,21
X$914 474 87 111 475 BUF_X1
* cell instance $915 r0 *1 1.9,21
X$915 449 87 111 451 BUF_X1
* cell instance $916 r0 *1 2.47,21
X$916 128 451 87 111 486 OR2_X1
* cell instance $920 r0 *1 3.23,21
X$920 486 452 485 87 465 111 AOI21_X1
* cell instance $922 r0 *1 4.37,21
X$922 87 437 465 346 111 DFF_X1
* cell instance $923 m0 *1 7.41,21
X$923 87 415 447 322 111 DFF_X1
* cell instance $925 m0 *1 10.64,21
X$925 87 471 438 322 111 DFF_X1
* cell instance $927 m0 *1 14.63,21
X$927 144 471 111 87 453 AND2_X1
* cell instance $935 r0 *1 9.31,21
X$935 144 487 111 87 514 AND2_X1
* cell instance $938 r0 *1 14.63,21
X$938 87 478 453 346 111 DFF_X1
* cell instance $942 r0 *1 19.19,21
X$942 454 87 111 178 BUF_X2
* cell instance $946 r0 *1 24.13,21
X$946 479 87 111 131 BUF_X2
* cell instance $948 r0 *1 26.41,21
X$948 454 87 111 237 BUF_X2
* cell instance $950 r0 *1 27.36,21
X$950 131 478 111 87 477 AND2_X1
* cell instance $953 r0 *1 29.26,21
X$953 533 87 111 128 BUF_X2
* cell instance $955 m0 *1 30.4,21
X$955 87 455 439 299 111 DFF_X1
* cell instance $959 m0 *1 34.2,21
X$959 237 440 111 87 456 AND2_X1
* cell instance $961 m0 *1 34.96,21
X$961 87 458 441 378 111 DFF_X1
* cell instance $962 m0 *1 38.19,21
X$962 237 458 111 87 457 AND2_X1
* cell instance $964 m0 *1 40.47,21
X$964 211 459 111 87 460 AND2_X1
* cell instance $967 r0 *1 34.58,21
X$967 455 479 111 87 517 AND2_X1
* cell instance $971 r0 *1 37.43,21
X$971 87 459 457 378 111 DFF_X1
* cell instance $972 r0 *1 40.66,21
X$972 87 480 460 378 111 DFF_X1
* cell instance $973 m0 *1 42.56,21
X$973 470 87 111 461 BUF_X1
* cell instance $975 m0 *1 43.13,21
X$975 444 87 111 380 BUF_X1
* cell instance $976 m0 *1 43.7,21
X$976 442 87 111 469 BUF_X1
* cell instance $978 m0 *1 44.46,21
X$978 469 87 111 464 BUF_X1
* cell instance $979 m0 *1 45.03,21
X$979 468 87 111 462 BUF_X1
* cell instance $981 m0 *1 45.79,21
X$981 442 87 111 463 BUF_X1
* cell instance $984 r0 *1 44.08,21
X$984 455 462 87 111 515 OR2_X1
* cell instance $985 r0 *1 44.84,21
X$985 462 455 87 111 483 NAND2_X1
* cell instance $986 r0 *1 45.41,21
X$986 484 87 111 482 BUF_X1
* cell instance $989 m0 *1 1.33,4.2
X$989 119 87 111 98 BUF_X1
* cell instance $991 m0 *1 1.9,4.2
X$991 98 87 111 156 BUF_X1
* cell instance $992 m0 *1 2.47,4.2
X$992 178 98 111 87 120 AND2_X1
* cell instance $993 m0 *1 3.23,4.2
X$993 98 87 111 142 BUF_X1
* cell instance $994 m0 *1 3.8,4.2
X$994 142 87 111 97 BUF_X1
* cell instance $996 m0 *1 5.89,4.2
X$996 144 121 111 87 122 AND2_X1
* cell instance $1000 r0 *1 2.09,4.2
X$1000 87 121 120 123 111 DFF_X1
* cell instance $1004 r0 *1 5.32,4.2
X$1004 87 124 122 123 111 DFF_X1
* cell instance $1006 m0 *1 11.02,4.2
X$1006 112 146 113 111 126 87 OAI21_X1
* cell instance $1007 m0 *1 11.78,4.2
X$1007 128 147 87 111 127 OR2_X1
* cell instance $1010 r0 *1 8.55,4.2
X$1010 131 124 111 87 143 AND2_X1
* cell instance $1012 r0 *1 11.02,4.2
X$1012 127 168 126 87 199 111 AOI21_X1
* cell instance $1013 r0 *1 11.78,4.2
X$1013 245 87 111 168 INV_X1
* cell instance $1018 r0 *1 15.01,4.2
X$1018 117 158 87 111 172 NAND2_X1
* cell instance $1020 r0 *1 15.77,4.2
X$1020 131 158 111 87 181 AND2_X1
* cell instance $1021 r0 *1 16.53,4.2
X$1021 158 117 87 111 174 OR2_X1
* cell instance $1022 r0 *1 17.29,4.2
X$1022 195 171 130 111 129 87 OAI21_X1
* cell instance $1023 r0 *1 18.05,4.2
X$1023 172 159 173 87 171 111 AOI21_X1
* cell instance $1025 m0 *1 19.95,4.2
X$1025 101 87 111 118 BUF_X1
* cell instance $1028 r0 *1 18.81,4.2
X$1028 174 159 160 87 195 111 AOI21_X1
* cell instance $1029 r0 *1 19.57,4.2
X$1029 173 87 111 160 INV_X1
* cell instance $1032 r0 *1 20.52,4.2
X$1032 131 161 111 87 226 AND2_X1
* cell instance $1034 r0 *1 21.47,4.2
X$1034 161 102 87 111 183 OR2_X1
* cell instance $1036 m0 *1 22.61,4.2
X$1036 154 116 103 87 175 111 AOI21_X1
* cell instance $1038 r0 *1 22.23,4.2
X$1038 87 155 175 182 111 DFF_X1
* cell instance $1040 m0 *1 24.7,4.2
X$1040 155 87 111 116 INV_X1
* cell instance $1044 m0 *1 26.03,4.2
X$1044 87 104 115 134 111 DFF_X1
* cell instance $1045 m0 *1 29.45,4.2
X$1045 131 105 111 87 136 AND2_X1
* cell instance $1049 r0 *1 27.55,4.2
X$1049 87 105 162 134 111 DFF_X1
* cell instance $1050 m0 *1 32.49,4.2
X$1050 149 170 106 111 148 87 OAI21_X1
* cell instance $1053 r0 *1 30.78,4.2
X$1053 152 163 169 87 170 111 AOI21_X1
* cell instance $1054 r0 *1 31.54,4.2
X$1054 87 169 136 138 111 DFF_X1
* cell instance $1055 r0 *1 34.77,4.2
X$1055 87 184 137 138 111 DFF_X1
* cell instance $1056 m0 *1 39.52,4.2
X$1056 108 87 111 163 BUF_X1
* cell instance $1057 m0 *1 40.09,4.2
X$1057 155 87 111 165 BUF_X1
* cell instance $1060 r0 *1 38,4.2
X$1060 87 185 191 138 111 DFF_X1
* cell instance $1062 m0 *1 42.56,4.2
X$1062 87 110 166 138 111 DFF_X1
* cell instance $1063 m0 *1 45.79,4.2
X$1063 141 87 111 140 BUF_X1
* cell instance $1068 m0 *1 1.33,15.4
X$1068 343 87 111 342 BUF_X1
* cell instance $1070 m0 *1 1.9,15.4
X$1070 362 87 111 291 BUF_X1
* cell instance $1071 m0 *1 2.47,15.4
X$1071 128 319 87 111 364 OR2_X1
* cell instance $1073 m0 *1 3.42,15.4
X$1073 364 385 356 87 366 111 AOI21_X1
* cell instance $1074 m0 *1 4.18,15.4
X$1074 367 87 111 385 INV_X1
* cell instance $1075 m0 *1 4.56,15.4
X$1075 87 367 366 346 111 DFF_X1
* cell instance $1078 r0 *1 1.33,15.4
X$1078 361 87 111 368 BUF_X1
* cell instance $1079 r0 *1 1.9,15.4
X$1079 368 87 111 396 BUF_X1
* cell instance $1080 r0 *1 2.47,15.4
X$1080 398 87 111 363 BUF_X1
* cell instance $1084 r0 *1 3.04,15.4
X$1084 363 365 87 111 399 NAND2_X1
* cell instance $1085 r0 *1 3.61,15.4
X$1085 365 363 87 111 400 OR2_X1
* cell instance $1086 r0 *1 4.37,15.4
X$1086 367 87 111 397 BUF_X1
* cell instance $1088 r0 *1 5.13,15.4
X$1088 368 87 111 369 BUF_X1
* cell instance $1089 r0 *1 5.7,15.4
X$1089 178 368 111 87 402 AND2_X1
* cell instance $1091 m0 *1 8.36,15.4
X$1091 87 293 345 346 111 DFF_X1
* cell instance $1093 m0 *1 11.59,15.4
X$1093 358 389 521 87 321 111 AOI21_X1
* cell instance $1097 m0 *1 20.71,15.4
X$1097 87 370 390 182 111 DFF_X1
* cell instance $1100 r0 *1 10.26,15.4
X$1100 298 87 111 346 CLKBUF_X3
* cell instance $1101 r0 *1 11.21,15.4
X$1101 346 87 111 1009 INV_X2
* cell instance $1105 m0 *1 25.08,15.4
X$1105 87 347 393 134 111 DFF_X1
* cell instance $1106 m0 *1 24.32,15.4
X$1106 237 370 111 87 393 AND2_X1
* cell instance $1108 m0 *1 28.5,15.4
X$1108 131 347 111 87 371 AND2_X1
* cell instance $1111 m0 *1 30.21,15.4
X$1111 347 114 87 111 392 OR2_X1
* cell instance $1112 m0 *1 30.97,15.4
X$1112 114 347 87 111 395 NAND2_X1
* cell instance $1119 r0 *1 28.12,15.4
X$1119 87 372 371 299 111 DFF_X1
* cell instance $1120 r0 *1 31.35,15.4
X$1120 395 375 372 87 394 111 AOI21_X1
* cell instance $1121 m0 *1 32.68,15.4
X$1121 376 394 388 111 391 87 OAI21_X1
* cell instance $1122 m0 *1 31.92,15.4
X$1122 373 374 391 87 348 111 AOI21_X1
* cell instance $1128 m0 *1 40.47,15.4
X$1128 383 87 111 388 BUF_X1
* cell instance $1130 r0 *1 32.11,15.4
X$1130 392 375 404 87 376 111 AOI21_X1
* cell instance $1131 r0 *1 32.87,15.4
X$1131 372 87 111 404 INV_X1
* cell instance $1134 r0 *1 35.15,15.4
X$1134 87 379 377 378 111 DFF_X1
* cell instance $1135 r0 *1 38.38,15.4
X$1135 237 379 111 87 405 AND2_X1
* cell instance $1138 r0 *1 40.85,15.4
X$1138 211 406 111 87 407 AND2_X1
* cell instance $1139 m0 *1 41.61,15.4
X$1139 387 87 111 145 BUF_X1
* cell instance $1141 m0 *1 42.18,15.4
X$1141 87 349 351 378 111 DFF_X1
* cell instance $1142 m0 *1 45.41,15.4
X$1142 386 350 382 87 351 111 AOI21_X1
* cell instance $1146 r0 *1 42.37,15.4
X$1146 411 87 111 375 BUF_X1
* cell instance $1147 r0 *1 42.94,15.4
X$1147 380 87 111 91 BUF_X1
* cell instance $1148 r0 *1 43.51,15.4
X$1148 387 87 111 384 BUF_X1
* cell instance $1149 r0 *1 44.08,15.4
X$1149 381 406 87 111 409 NAND2_X1
* cell instance $1150 r0 *1 44.65,15.4
X$1150 406 381 87 111 410 OR2_X1
* cell instance $1151 r0 *1 45.41,15.4
X$1151 349 87 111 350 INV_X1
* cell instance $1152 r0 *1 45.79,15.4
X$1152 412 87 111 381 BUF_X1
* cell instance $1154 m0 *1 1.33,43.4
X$1154 813 87 111 843 BUF_X1
* cell instance $1156 m0 *1 1.9,43.4
X$1156 843 87 111 814 BUF_X1
* cell instance $1157 m0 *1 2.47,43.4
X$1157 851 87 111 812 BUF_X1
* cell instance $1165 m0 *1 3.42,43.4
X$1165 843 87 111 851 BUF_X1
* cell instance $1166 m0 *1 7.03,43.4
X$1166 869 868 728 87 853 111 AOI21_X1
* cell instance $1168 m0 *1 7.98,43.4
X$1168 581 889 87 111 869 OR2_X1
* cell instance $1169 m0 *1 8.74,43.4
X$1169 850 87 111 868 INV_X1
* cell instance $1170 m0 *1 9.12,43.4
X$1170 852 87 111 870 BUF_X1
* cell instance $1174 r0 *1 5.32,43.4
X$1174 852 87 111 888 BUF_X1
* cell instance $1175 r0 *1 5.89,43.4
X$1175 87 850 853 713 111 DFF_X1
* cell instance $1177 r0 *1 9.5,43.4
X$1177 581 936 87 111 892 OR2_X1
* cell instance $1178 m0 *1 10.64,43.4
X$1178 872 890 815 87 855 111 AOI21_X1
* cell instance $1179 m0 *1 10.07,43.4
X$1179 844 829 87 111 872 NAND2_X1
* cell instance $1181 m0 *1 11.59,43.4
X$1181 816 854 832 87 873 111 AOI21_X1
* cell instance $1182 m0 *1 12.35,43.4
X$1182 874 854 768 87 875 111 AOI21_X1
* cell instance $1183 m0 *1 13.11,43.4
X$1183 873 875 896 111 856 87 OAI21_X1
* cell instance $1184 m0 *1 13.87,43.4
X$1184 87 952 845 715 111 DFF_X1
* cell instance $1186 r0 *1 10.26,43.4
X$1186 829 844 87 111 891 OR2_X1
* cell instance $1187 r0 *1 11.02,43.4
X$1187 815 87 111 911 INV_X1
* cell instance $1189 r0 *1 11.78,43.4
X$1189 932 855 893 111 915 87 OAI21_X1
* cell instance $1190 r0 *1 12.54,43.4
X$1190 892 878 856 87 894 111 AOI21_X1
* cell instance $1191 r0 *1 13.3,43.4
X$1191 581 895 87 111 916 OR2_X1
* cell instance $1192 r0 *1 14.06,43.4
X$1192 916 913 915 87 845 111 AOI21_X1
* cell instance $1193 r0 *1 14.82,43.4
X$1193 87 857 894 715 111 DFF_X1
* cell instance $1194 m0 *1 17.67,43.4
X$1194 880 877 818 87 879 111 AOI21_X1
* cell instance $1196 m0 *1 18.43,43.4
X$1196 87 920 879 715 111 DFF_X1
* cell instance $1198 r0 *1 18.05,43.4
X$1198 857 87 111 878 INV_X1
* cell instance $1199 r0 *1 18.43,43.4
X$1199 581 919 87 111 880 OR2_X1
* cell instance $1200 r0 *1 19.19,43.4
X$1200 833 87 111 897 BUF_X1
* cell instance $1201 r0 *1 19.76,43.4
X$1201 920 87 111 877 INV_X1
* cell instance $1203 r0 *1 20.33,43.4
X$1203 962 87 111 833 BUF_X1
* cell instance $1204 r0 *1 20.9,43.4
X$1204 833 87 111 964 BUF_X1
* cell instance $1205 r0 *1 21.47,43.4
X$1205 87 923 921 715 111 DFF_X1
* cell instance $1206 m0 *1 22.23,43.4
X$1206 820 836 838 87 881 111 AOI21_X1
* cell instance $1208 m0 *1 22.99,43.4
X$1208 881 821 898 111 922 87 OAI21_X1
* cell instance $1209 m0 *1 23.75,43.4
X$1209 923 87 111 882 INV_X1
* cell instance $1210 m0 *1 24.13,43.4
X$1210 87 846 885 687 111 DFF_X1
* cell instance $1211 m0 *1 27.36,43.4
X$1211 846 87 111 839 INV_X1
* cell instance $1212 m0 *1 27.74,43.4
X$1212 822 842 810 87 858 111 AOI21_X1
* cell instance $1213 m0 *1 28.5,43.4
X$1213 810 87 111 841 INV_X1
* cell instance $1214 m0 *1 28.88,43.4
X$1214 887 842 841 87 886 111 AOI21_X1
* cell instance $1216 r0 *1 24.7,43.4
X$1216 899 882 924 87 921 111 AOI21_X1
* cell instance $1218 r0 *1 25.65,43.4
X$1218 884 839 922 87 885 111 AOI21_X1
* cell instance $1219 r0 *1 26.41,43.4
X$1219 857 850 859 846 87 111 840 NOR4_X1
* cell instance $1221 r0 *1 27.55,43.4
X$1221 886 858 900 111 924 87 OAI21_X1
* cell instance $1222 r0 *1 28.31,43.4
X$1222 87 859 927 687 111 DFF_X1
* cell instance $1223 m0 *1 30.59,43.4
X$1223 533 901 87 111 883 OR2_X1
* cell instance $1224 m0 *1 30.02,43.4
X$1224 795 87 111 938 BUF_X1
* cell instance $1225 m0 *1 31.35,43.4
X$1225 859 87 111 929 INV_X1
* cell instance $1227 r0 *1 31.54,43.4
X$1227 883 929 930 87 927 111 AOI21_X1
* cell instance $1228 m0 *1 32.49,43.4
X$1228 688 847 87 111 860 OR2_X1
* cell instance $1229 m0 *1 32.11,43.4
X$1229 823 87 111 931 INV_X1
* cell instance $1230 m0 *1 33.25,43.4
X$1230 785 87 111 837 BUF_X1
* cell instance $1231 m0 *1 33.82,43.4
X$1231 847 688 87 111 861 NAND2_X1
* cell instance $1232 m0 *1 34.39,43.4
X$1232 795 87 111 998 BUF_X1
* cell instance $1233 m0 *1 34.96,43.4
X$1233 848 773 87 111 862 NAND2_X1
* cell instance $1234 m0 *1 35.53,43.4
X$1234 773 848 87 111 864 OR2_X1
* cell instance $1235 m0 *1 36.29,43.4
X$1235 834 87 111 876 INV_X1
* cell instance $1238 r0 *1 32.3,43.4
X$1238 860 931 902 87 928 111 AOI21_X1
* cell instance $1239 r0 *1 33.06,43.4
X$1239 928 926 903 111 930 87 OAI21_X1
* cell instance $1240 r0 *1 33.82,43.4
X$1240 861 823 902 87 926 111 AOI21_X1
* cell instance $1241 r0 *1 34.58,43.4
X$1241 925 87 111 917 BUF_X1
* cell instance $1242 r0 *1 35.15,43.4
X$1242 862 904 834 87 865 111 AOI21_X1
* cell instance $1243 r0 *1 35.91,43.4
X$1243 864 904 876 87 863 111 AOI21_X1
* cell instance $1244 r0 *1 36.67,43.4
X$1244 937 87 111 914 BUF_X1
* cell instance $1245 r0 *1 37.24,43.4
X$1245 863 865 914 111 905 87 OAI21_X1
* cell instance $1247 m0 *1 37.81,43.4
X$1247 639 824 111 87 918 XNOR2_X1
* cell instance $1248 m0 *1 39.71,43.4
X$1248 871 87 111 609 BUF_X1
* cell instance $1250 r0 *1 38,43.4
X$1250 785 87 111 912 BUF_X1
* cell instance $1251 r0 *1 38.57,43.4
X$1251 917 918 111 87 908 AND2_X1
* cell instance $1252 r0 *1 39.33,43.4
X$1252 581 906 87 111 910 OR2_X1
* cell instance $1253 r0 *1 40.09,43.4
X$1253 910 866 905 87 867 111 AOI21_X1
* cell instance $1254 m0 *1 41.04,43.4
X$1254 87 849 867 693 111 DFF_X1
* cell instance $1255 m0 *1 40.66,43.4
X$1255 849 87 111 866 INV_X1
* cell instance $1256 m0 *1 44.27,43.4
X$1256 849 87 111 825 BUF_X1
* cell instance $1257 m0 *1 44.84,43.4
X$1257 826 87 111 668 BUF_X1
* cell instance $1260 r0 *1 41.23,43.4
X$1260 614 908 909 87 907 111 AOI21_X1
* cell instance $1261 r0 *1 41.99,43.4
X$1261 87 614 934 693 111 DFF_X1
* cell instance $1264 m0 *1 45.79,43.4
X$1264 669 87 111 827 BUF_X1
* cell instance $1267 m0 *1 1.33,40.6
X$1267 766 87 111 737 BUF_X1
* cell instance $1269 m0 *1 1.9,40.6
X$1269 735 87 111 594 BUF_X1
* cell instance $1270 m0 *1 2.47,40.6
X$1270 696 87 111 786 BUF_X1
* cell instance $1273 r0 *1 1.33,40.6
X$1273 555 87 111 787 BUF_X1
* cell instance $1274 r0 *1 1.9,40.6
X$1274 737 87 111 828 BUF_X1
* cell instance $1275 r0 *1 2.47,40.6
X$1275 828 87 111 765 BUF_X1
* cell instance $1279 r0 *1 3.04,40.6
X$1279 764 87 111 616 BUF_X1
* cell instance $1281 m0 *1 3.42,40.6
X$1281 87 804 803 713 111 DFF_X1
* cell instance $1282 r0 *1 3.61,40.6
X$1282 636 843 111 87 803 AND2_X1
* cell instance $1285 r0 *1 5.32,40.6
X$1285 87 829 805 713 111 DFF_X1
* cell instance $1286 m0 *1 7.22,40.6
X$1286 654 804 111 87 805 AND2_X1
* cell instance $1289 m0 *1 8.55,40.6
X$1289 568 829 111 87 788 AND2_X1
* cell instance $1294 r0 *1 8.55,40.6
X$1294 87 815 788 713 111 DFF_X1
* cell instance $1295 r0 *1 11.78,40.6
X$1295 757 789 87 111 816 OR2_X1
* cell instance $1297 r0 *1 12.73,40.6
X$1297 789 757 87 111 874 NAND2_X1
* cell instance $1299 r0 *1 13.49,40.6
X$1299 768 87 111 832 INV_X1
* cell instance $1302 m0 *1 1.33,37.8
X$1302 707 87 111 647 BUF_X1
* cell instance $1304 m0 *1 1.9,37.8
X$1304 676 87 111 679 BUF_X1
* cell instance $1305 m0 *1 2.47,37.8
X$1305 710 697 752 111 728 87 OAI21_X1
* cell instance $1306 m0 *1 3.23,37.8
X$1306 712 681 87 111 726 NAND2_X1
* cell instance $1307 m0 *1 3.8,37.8
X$1307 681 712 87 111 698 OR2_X1
* cell instance $1308 m0 *1 4.56,37.8
X$1308 679 87 111 754 BUF_X1
* cell instance $1310 m0 *1 5.32,37.8
X$1310 754 87 111 708 BUF_X1
* cell instance $1314 r0 *1 1.33,37.8
X$1314 663 87 111 752 BUF_X1
* cell instance $1316 r0 *1 2.09,37.8
X$1316 737 87 111 736 BUF_X1
* cell instance $1318 r0 *1 2.85,37.8
X$1318 709 87 111 712 BUF_X1
* cell instance $1323 r0 *1 3.61,37.8
X$1323 636 737 111 87 783 AND2_X1
* cell instance $1324 r0 *1 4.37,37.8
X$1324 87 767 783 713 111 DFF_X1
* cell instance $1325 m0 *1 7.22,37.8
X$1325 87 757 738 713 111 DFF_X1
* cell instance $1328 r0 *1 7.6,37.8
X$1328 654 767 111 87 738 AND2_X1
* cell instance $1332 m0 *1 11.02,37.8
X$1332 568 757 111 87 739 AND2_X1
* cell instance $1335 m0 *1 12.54,37.8
X$1335 298 87 111 713 CLKBUF_X3
* cell instance $1336 m0 *1 13.49,37.8
X$1336 713 87 111 CLKBUF_X1
* cell instance $1340 r0 *1 11.21,37.8
X$1340 87 768 739 713 111 DFF_X1
* cell instance $1343 m0 *1 15.2,37.8
X$1343 87 741 760 715 111 DFF_X1
* cell instance $1345 r0 *1 15.96,37.8
X$1345 568 714 111 87 760 AND2_X1
* cell instance $1346 r0 *1 16.72,37.8
X$1346 769 714 87 111 784 NAND2_X1
* cell instance $1347 r0 *1 17.29,37.8
X$1347 714 769 87 111 771 OR2_X1
* cell instance $1348 r0 *1 18.05,37.8
X$1348 741 87 111 770 INV_X1
* cell instance $1351 m0 *1 1.33,29.4
X$1351 561 87 111 590 BUF_X1
* cell instance $1353 m0 *1 1.9,29.4
X$1353 602 590 560 87 548 111 AOI21_X1
* cell instance $1354 m0 *1 2.66,29.4
X$1354 560 87 111 591 INV_X1
* cell instance $1357 r0 *1 1.33,29.4
X$1357 588 87 111 605 BUF_X1
* cell instance $1358 r0 *1 1.9,29.4
X$1358 622 87 111 562 BUF_X1
* cell instance $1359 r0 *1 2.47,29.4
X$1359 593 590 591 87 547 111 AOI21_X1
* cell instance $1363 r0 *1 3.23,29.4
X$1363 581 616 87 111 592 OR2_X1
* cell instance $1364 m0 *1 3.99,29.4
X$1364 564 594 87 111 593 OR2_X1
* cell instance $1365 m0 *1 3.42,29.4
X$1365 594 564 87 111 602 NAND2_X1
* cell instance $1367 r0 *1 3.99,29.4
X$1367 87 595 624 520 111 DFF_X1
* cell instance $1369 m0 *1 5.13,29.4
X$1369 568 564 111 87 580 AND2_X1
* cell instance $1371 m0 *1 7.22,29.4
X$1371 87 564 565 520 111 DFF_X1
* cell instance $1373 m0 *1 10.45,29.4
X$1373 596 566 87 111 567 OR2_X1
* cell instance $1375 m0 *1 11.4,29.4
X$1375 566 596 87 111 585 NAND2_X1
* cell instance $1377 m0 *1 12.16,29.4
X$1377 568 596 111 87 606 AND2_X1
* cell instance $1378 m0 *1 12.92,29.4
X$1378 87 583 606 626 111 DFF_X1
* cell instance $1386 m0 *1 30.78,29.4
X$1386 533 111 581 87 BUF_X4
* cell instance $1387 m0 *1 32.11,29.4
X$1387 87 597 607 628 111 DFF_X1
* cell instance $1389 r0 *1 7.22,29.4
X$1389 144 595 111 87 565 AND2_X1
* cell instance $1391 r0 *1 8.36,29.4
X$1391 87 596 617 520 111 DFF_X1
* cell instance $1392 r0 *1 11.59,29.4
X$1392 144 625 111 87 617 AND2_X1
* cell instance $1396 r0 *1 25.27,29.4
X$1396 454 87 111 654 BUF_X2
* cell instance $1401 r0 *1 28.88,29.4
X$1401 87 611 619 628 111 DFF_X1
* cell instance $1402 r0 *1 32.11,29.4
X$1402 479 611 111 87 652 AND2_X1
* cell instance $1405 r0 *1 34.77,29.4
X$1405 479 597 111 87 629 AND2_X1
* cell instance $1410 m0 *1 37.62,29.4
X$1410 570 587 569 87 599 111 AOI21_X1
* cell instance $1411 m0 *1 38.38,29.4
X$1411 599 609 581 87 111 598 NOR3_X1
* cell instance $1416 r0 *1 36.86,29.4
X$1416 535 87 111 1008 INV_X2
* cell instance $1417 r0 *1 37.43,29.4
X$1417 87 570 598 535 111 DFF_X1
* cell instance $1418 m0 *1 43.51,29.4
X$1418 572 87 111 554 BUF_X1
* cell instance $1419 m0 *1 40.28,29.4
X$1419 87 572 584 535 111 DFF_X1
* cell instance $1420 m0 *1 44.08,29.4
X$1420 542 87 111 525 BUF_X1
* cell instance $1421 m0 *1 44.65,29.4
X$1421 573 87 111 575 BUF_X1
* cell instance $1422 m0 *1 45.22,29.4
X$1422 573 87 111 579 INV_X1
* cell instance $1423 m0 *1 45.6,29.4
X$1423 600 87 111 603 BUF_X1
* cell instance $1426 r0 *1 40.66,29.4
X$1426 573 614 570 572 111 608 87 NOR4_X2
* cell instance $1428 r0 *1 43.13,29.4
X$1428 601 87 111 557 BUF_X1
* cell instance $1429 r0 *1 43.7,29.4
X$1429 604 630 526 87 618 111 AOI21_X1
* cell instance $1430 r0 *1 44.46,29.4
X$1430 109 613 87 111 604 OR2_X1
* cell instance $1431 r0 *1 45.22,29.4
X$1431 576 87 111 613 BUF_X1
* cell instance $1432 r0 *1 45.79,29.4
X$1432 614 87 111 574 BUF_X1
* cell instance $1434 m0 *1 1.33,26.6
X$1434 475 87 111 555 BUF_X1
* cell instance $1436 m0 *1 1.9,26.6
X$1436 546 87 111 539 BUF_X1
* cell instance $1437 m0 *1 2.47,26.6
X$1437 476 87 111 578 INV_X1
* cell instance $1438 m0 *1 2.85,26.6
X$1438 476 87 111 537 BUF_X1
* cell instance $1439 m0 *1 3.42,26.6
X$1439 87 476 558 520 111 DFF_X1
* cell instance $1447 r0 *1 1.33,26.6
X$1447 538 87 111 586 BUF_X1
* cell instance $1448 r0 *1 1.9,26.6
X$1448 547 548 539 111 577 87 OAI21_X1
* cell instance $1449 r0 *1 2.66,26.6
X$1449 592 578 577 87 558 111 AOI21_X1
* cell instance $1454 r0 *1 3.61,26.6
X$1454 87 560 580 520 111 DFF_X1
* cell instance $1459 r0 *1 11.21,26.6
X$1459 567 549 582 87 550 111 AOI21_X1
* cell instance $1460 r0 *1 11.97,26.6
X$1460 550 559 605 111 521 87 OAI21_X1
* cell instance $1461 r0 *1 12.73,26.6
X$1461 585 549 583 87 559 111 AOI21_X1
* cell instance $1462 r0 *1 13.49,26.6
X$1462 583 87 111 582 INV_X1
* cell instance $1466 r0 *1 16.34,26.6
X$1466 586 522 111 87 587 AND2_X1
* cell instance $1467 r0 *1 17.1,26.6
X$1467 454 87 111 144 BUF_X2
* cell instance $1471 m0 *1 24.51,26.6
X$1471 454 87 111 479 BUF_X2
* cell instance $1474 m0 *1 30.02,26.6
X$1474 533 87 111 109 BUF_X2
* cell instance $1482 m0 *1 36.48,26.6
X$1482 87 545 524 535 111 DFF_X1
* cell instance $1483 m0 *1 39.9,26.6
X$1483 523 545 111 87 540 XNOR2_X1
* cell instance $1484 m0 *1 41.04,26.6
X$1484 540 557 87 111 551 NAND2_X1
* cell instance $1487 m0 *1 42.56,26.6
X$1487 523 525 111 87 541 XNOR2_X1
* cell instance $1488 m0 *1 43.7,26.6
X$1488 544 541 111 87 536 AND2_X1
* cell instance $1489 m0 *1 44.46,26.6
X$1489 543 87 111 544 BUF_X1
* cell instance $1492 r0 *1 40.66,26.6
X$1492 572 536 551 87 552 111 AOI21_X1
* cell instance $1493 r0 *1 41.42,26.6
X$1493 552 571 581 87 111 584 NOR3_X1
* cell instance $1494 r0 *1 42.18,26.6
X$1494 87 573 556 535 111 DFF_X1
* cell instance $1496 m0 *1 45.41,26.6
X$1496 528 87 111 532 BUF_X1
* cell instance $1497 r0 *1 45.41,26.6
X$1497 553 579 527 87 556 111 AOI21_X1
* cell instance $1501 m0 *1 1.33,32.2
X$1501 589 87 111 566 BUF_X1
* cell instance $1503 m0 *1 1.9,32.2
X$1503 647 87 111 622 BUF_X1
* cell instance $1504 m0 *1 2.47,32.2
X$1504 621 87 111 623 BUF_X1
* cell instance $1506 m0 *1 3.23,32.2
X$1506 623 87 111 563 BUF_X1
* cell instance $1507 m0 *1 3.8,32.2
X$1507 636 647 111 87 624 AND2_X1
* cell instance $1509 m0 *1 4.75,32.2
X$1509 623 87 111 637 BUF_X1
* cell instance $1511 m0 *1 6.84,32.2
X$1511 636 623 111 87 648 AND2_X1
* cell instance $1513 m0 *1 7.79,32.2
X$1513 610 87 111 549 BUF_X1
* cell instance $1515 m0 *1 8.55,32.2
X$1515 520 87 111 1001 INV_X2
* cell instance $1516 m0 *1 9.12,32.2
X$1516 87 625 648 626 111 DFF_X1
* cell instance $1521 r0 *1 1.33,32.2
X$1521 634 87 111 635 BUF_X1
* cell instance $1522 r0 *1 1.9,32.2
X$1522 647 87 111 653 BUF_X1
* cell instance $1523 r0 *1 2.47,32.2
X$1523 635 87 111 633 BUF_X1
* cell instance $1529 r0 *1 4.75,32.2
X$1529 637 87 111 620 BUF_X1
* cell instance $1532 r0 *1 7.22,32.2
X$1532 654 675 111 87 702 AND2_X1
* cell instance $1535 r0 *1 10.26,32.2
X$1535 298 87 111 520 CLKBUF_X3
* cell instance $1538 r0 *1 11.78,32.2
X$1538 636 635 111 87 650 AND2_X1
* cell instance $1542 r0 *1 13.87,32.2
X$1542 87 627 650 626 111 DFF_X1
* cell instance $1543 m0 *1 17.29,32.2
X$1543 298 87 111 626 CLKBUF_X3
* cell instance $1544 m0 *1 16.53,32.2
X$1544 654 627 111 87 651 AND2_X1
* cell instance $1545 m0 *1 18.24,32.2
X$1545 626 87 111 INV_X4
* cell instance $1547 r0 *1 17.1,32.2
X$1547 87 638 655 626 111 DFF_X1
* cell instance $1548 m0 *1 19.76,32.2
X$1548 87 639 651 626 111 DFF_X1
* cell instance $1551 m0 *1 23.75,32.2
X$1551 568 639 111 87 640 AND2_X1
* cell instance $1556 r0 *1 20.33,32.2
X$1556 479 638 111 87 705 AND2_X1
* cell instance $1559 r0 *1 22.23,32.2
X$1559 479 87 111 636 BUF_X2
* cell instance $1561 r0 *1 23.75,32.2
X$1561 87 661 640 687 111 DFF_X1
* cell instance $1562 r0 *1 26.98,32.2
X$1562 639 661 111 87 716 XNOR2_X1
* cell instance $1566 r0 *1 29.45,32.2
X$1566 479 665 111 87 666 AND2_X1
* cell instance $1567 m0 *1 30.4,32.2
X$1567 628 87 111 1002 INV_X2
* cell instance $1569 m0 *1 30.97,32.2
X$1569 298 87 111 628 CLKBUF_X3
* cell instance $1570 m0 *1 31.92,32.2
X$1570 87 641 652 628 111 DFF_X1
* cell instance $1571 m0 *1 35.15,32.2
X$1571 87 643 629 628 111 DFF_X1
* cell instance $1572 m0 *1 38.38,32.2
X$1572 211 643 111 87 656 AND2_X1
* cell instance $1573 m0 *1 39.14,32.2
X$1573 87 644 618 535 111 DFF_X1
* cell instance $1576 m0 *1 43.32,32.2
X$1576 644 87 111 630 INV_X1
* cell instance $1579 m0 *1 44.65,32.2
X$1579 612 87 111 649 BUF_X1
* cell instance $1580 m0 *1 45.22,32.2
X$1580 649 87 111 631 BUF_X1
* cell instance $1581 m0 *1 45.79,32.2
X$1581 603 87 111 632 BUF_X1
* cell instance $1586 r0 *1 35.15,32.2
X$1586 211 641 111 87 642 AND2_X1
* cell instance $1589 r0 *1 36.86,32.2
X$1589 298 87 111 535 CLKBUF_X3
* cell instance $1590 r0 *1 37.81,32.2
X$1590 87 690 656 535 111 DFF_X1
* cell instance $1592 r0 *1 41.23,32.2
X$1592 570 87 111 615 BUF_X1
* cell instance $1594 r0 *1 42.18,32.2
X$1594 657 643 87 111 674 NAND2_X1
* cell instance $1596 r0 *1 42.94,32.2
X$1596 643 657 87 111 703 OR2_X1
* cell instance $1598 r0 *1 43.89,32.2
X$1598 660 87 111 612 BUF_X1
* cell instance $1599 r0 *1 44.46,32.2
X$1599 109 672 87 111 658 OR2_X1
* cell instance $1600 r0 *1 45.22,32.2
X$1600 603 87 111 669 BUF_X1
* cell instance $1601 r0 *1 45.79,32.2
X$1601 645 87 111 671 BUF_X1
* cell instance $1603 m0 *1 1.33,35
X$1603 662 87 111 678 BUF_X1
* cell instance $1605 m0 *1 1.9,35
X$1605 635 87 111 696 BUF_X1
* cell instance $1608 r0 *1 1.33,35
X$1608 679 87 111 677 BUF_X1
* cell instance $1609 r0 *1 1.9,35
X$1609 698 678 711 87 710 111 AOI21_X1
* cell instance $1610 r0 *1 2.66,35
X$1610 680 87 111 711 INV_X1
* cell instance $1611 m0 *1 3.61,35
X$1611 636 679 111 87 701 AND2_X1
* cell instance $1612 m0 *1 2.85,35
X$1612 726 678 680 87 697 111 AOI21_X1
* cell instance $1613 m0 *1 4.37,35
X$1613 87 675 701 520 111 DFF_X1
* cell instance $1614 m0 *1 7.6,35
X$1614 87 681 702 520 111 DFF_X1
* cell instance $1622 r0 *1 3.23,35
X$1622 87 680 727 713 111 DFF_X1
* cell instance $1623 r0 *1 6.46,35
X$1623 568 681 111 87 727 AND2_X1
* cell instance $1626 r0 *1 9.5,35
X$1626 636 852 111 87 730 AND2_X1
* cell instance $1627 r0 *1 10.26,35
X$1627 87 682 730 713 111 DFF_X1
* cell instance $1628 r0 *1 13.49,35
X$1628 87 714 683 713 111 DFF_X1
* cell instance $1630 m0 *1 13.49,35
X$1630 654 682 111 87 683 AND2_X1
* cell instance $1634 m0 *1 17.1,35
X$1634 654 740 111 87 655 AND2_X1
* cell instance $1638 m0 *1 20.14,35
X$1638 87 686 705 715 111 DFF_X1
* cell instance $1640 m0 *1 26.41,35
X$1640 87 665 664 687 111 DFF_X1
* cell instance $1641 m0 *1 29.64,35
X$1641 87 688 666 628 111 DFF_X1
* cell instance $1646 r0 *1 19.38,35
X$1646 87 685 684 715 111 DFF_X1
* cell instance $1647 r0 *1 22.61,35
X$1647 654 685 111 87 733 AND2_X1
* cell instance $1648 r0 *1 23.37,35
X$1648 87 744 733 687 111 DFF_X1
* cell instance $1652 r0 *1 29.26,35
X$1652 654 795 111 87 664 AND2_X1
* cell instance $1655 r0 *1 30.97,35
X$1655 87 689 734 628 111 DFF_X1
* cell instance $1656 r0 *1 34.2,35
X$1656 479 689 111 87 717 AND2_X1
* cell instance $1658 m0 *1 34.77,35
X$1658 87 731 642 693 111 DFF_X1
* cell instance $1661 r0 *1 35.72,35
X$1661 298 87 111 693 CLKBUF_X3
* cell instance $1664 r0 *1 37.81,35
X$1664 731 87 111 732 INV_X1
* cell instance $1665 r0 *1 38.19,35
X$1665 706 732 719 87 759 111 AOI21_X1
* cell instance $1666 r0 *1 38.95,35
X$1666 729 731 719 87 718 111 AOI21_X1
* cell instance $1667 m0 *1 39.71,35
X$1667 641 667 87 111 706 OR2_X1
* cell instance $1668 m0 *1 39.14,35
X$1668 667 641 87 111 729 NAND2_X1
* cell instance $1671 m0 *1 41.04,35
X$1671 670 87 111 667 BUF_X1
* cell instance $1673 m0 *1 41.61,35
X$1673 690 87 111 704 INV_X1
* cell instance $1675 m0 *1 42.18,35
X$1675 658 691 673 87 692 111 AOI21_X1
* cell instance $1676 m0 *1 42.94,35
X$1676 703 704 668 87 700 111 AOI21_X1
* cell instance $1677 m0 *1 43.7,35
X$1677 674 690 668 87 699 111 AOI21_X1
* cell instance $1678 m0 *1 44.46,35
X$1678 700 699 671 111 673 87 OAI21_X1
* cell instance $1679 m0 *1 45.22,35
X$1679 612 87 111 695 BUF_X1
* cell instance $1680 m0 *1 45.79,35
X$1680 646 87 111 672 BUF_X1
* cell instance $1683 r0 *1 41.61,35
X$1683 722 87 111 691 INV_X1
* cell instance $1684 r0 *1 41.99,35
X$1684 87 722 692 693 111 DFF_X1
* cell instance $1685 r0 *1 45.22,35
X$1685 694 87 111 719 BUF_X1
* cell instance $1686 r0 *1 45.79,35
X$1686 659 87 111 571 BUF_X1
* cell instance $1690 m0 *1 2.09,7
X$1690 177 87 111 196 BUF_X1
* cell instance $1693 r0 *1 1.33,7
X$1693 221 87 111 240 BUF_X1
* cell instance $1695 r0 *1 2.66,7
X$1695 238 87 111 242 BUF_X1
* cell instance $1703 r0 *1 3.23,7
X$1703 87 243 198 123 111 DFF_X1
* cell instance $1704 r0 *1 6.46,7
X$1704 144 243 111 87 255 AND2_X1
* cell instance $1706 m0 *1 6.65,7
X$1706 157 87 111 125 BUF_X1
* cell instance $1708 m0 *1 7.79,7
X$1708 176 87 111 159 BUF_X1
* cell instance $1712 r0 *1 8.17,7
X$1712 197 87 111 227 BUF_X1
* cell instance $1713 m0 *1 9.12,7
X$1713 180 222 179 87 224 111 AOI21_X1
* cell instance $1714 m0 *1 8.74,7
X$1714 88 87 111 222 INV_X1
* cell instance $1715 m0 *1 9.88,7
X$1715 87 88 224 123 111 DFF_X1
* cell instance $1719 m0 *1 15.77,7
X$1719 87 173 181 182 111 DFF_X1
* cell instance $1723 r0 *1 10.64,7
X$1723 87 245 199 123 111 DFF_X1
* cell instance $1729 m0 *1 22.61,7
X$1729 194 228 132 111 103 87 OAI21_X1
* cell instance $1730 m0 *1 19.38,7
X$1730 87 200 226 182 111 DFF_X1
* cell instance $1731 m0 *1 23.37,7
X$1731 102 161 87 111 201 NAND2_X1
* cell instance $1733 m0 *1 24.7,7
X$1733 128 133 87 111 231 OR2_X1
* cell instance $1737 m0 *1 27.93,7
X$1737 237 104 111 87 162 AND2_X1
* cell instance $1743 r0 *1 21.66,7
X$1743 183 227 248 87 194 111 AOI21_X1
* cell instance $1744 r0 *1 22.42,7
X$1744 200 87 111 248 INV_X1
* cell instance $1747 r0 *1 23.37,7
X$1747 201 227 200 87 228 111 AOI21_X1
* cell instance $1748 r0 *1 24.13,7
X$1748 202 203 87 111 257 NAND2_X1
* cell instance $1749 r0 *1 24.7,7
X$1749 203 202 87 111 229 OR2_X1
* cell instance $1750 r0 *1 25.46,7
X$1750 229 204 205 87 206 111 AOI21_X1
* cell instance $1752 r0 *1 26.41,7
X$1752 206 261 192 111 256 87 OAI21_X1
* cell instance $1758 r0 *1 30.78,7
X$1758 207 235 148 87 249 111 AOI21_X1
* cell instance $1759 m0 *1 31.35,7
X$1759 135 163 208 87 149 111 AOI21_X1
* cell instance $1761 m0 *1 32.11,7
X$1761 169 87 111 208 INV_X1
* cell instance $1764 r0 *1 31.92,7
X$1764 250 87 111 235 INV_X1
* cell instance $1765 r0 *1 32.3,7
X$1765 87 251 236 134 111 DFF_X1
* cell instance $1771 m0 *1 37.43,7
X$1771 237 184 111 87 210 AND2_X1
* cell instance $1773 m0 *1 38.19,7
X$1773 237 139 111 87 191 AND2_X1
* cell instance $1774 m0 *1 38.95,7
X$1774 188 87 111 204 BUF_X1
* cell instance $1777 r0 *1 37.43,7
X$1777 87 216 210 138 111 DFF_X1
* cell instance $1778 r0 *1 40.66,7
X$1778 211 216 111 87 272 AND2_X1
* cell instance $1779 m0 *1 42.18,7
X$1779 212 185 87 111 230 NAND2_X1
* cell instance $1780 m0 *1 41.42,7
X$1780 211 185 111 87 190 AND2_X1
* cell instance $1781 m0 *1 42.75,7
X$1781 185 212 87 111 234 OR2_X1
* cell instance $1782 m0 *1 43.51,7
X$1782 234 213 232 87 186 111 AOI21_X1
* cell instance $1783 m0 *1 45.03,7
X$1783 186 215 223 111 187 87 OAI21_X1
* cell instance $1784 m0 *1 45.79,7
X$1784 164 87 111 223 BUF_X1
* cell instance $1788 r0 *1 42.37,7
X$1788 219 87 111 271 BUF_X1
* cell instance $1789 r0 *1 42.94,7
X$1789 220 87 111 212 BUF_X1
* cell instance $1790 r0 *1 43.51,7
X$1790 233 87 111 213 BUF_X1
* cell instance $1791 r0 *1 44.08,7
X$1791 110 87 111 214 INV_X1
* cell instance $1792 r0 *1 44.46,7
X$1792 217 216 87 111 270 NAND2_X1
* cell instance $1793 r0 *1 45.03,7
X$1793 216 217 87 111 253 OR2_X1
* cell instance $1794 r0 *1 45.79,7
X$1794 218 87 111 225 BUF_X1
* cell instance $1796 m0 *1 1.33,12.6
X$1796 317 87 111 355 BUF_X1
* cell instance $1798 m0 *1 1.9,12.6
X$1798 290 87 111 319 BUF_X1
* cell instance $1799 m0 *1 2.47,12.6
X$1799 331 291 292 87 330 111 AOI21_X1
* cell instance $1800 m0 *1 3.23,12.6
X$1800 293 87 111 292 INV_X1
* cell instance $1801 m0 *1 3.61,12.6
X$1801 294 295 87 111 320 NAND2_X1
* cell instance $1803 m0 *1 4.37,12.6
X$1803 295 294 87 111 331 OR2_X1
* cell instance $1804 m0 *1 5.13,12.6
X$1804 341 87 111 337 BUF_X1
* cell instance $1809 r0 *1 2.09,12.6
X$1809 330 318 355 111 356 87 OAI21_X1
* cell instance $1811 r0 *1 3.04,12.6
X$1811 320 291 293 87 318 111 AOI21_X1
* cell instance $1813 r0 *1 3.99,12.6
X$1813 87 344 357 322 111 DFF_X1
* cell instance $1814 m0 *1 7.03,12.6
X$1814 87 295 332 123 111 DFF_X1
* cell instance $1818 m0 *1 12.54,12.6
X$1818 298 87 111 123 CLKBUF_X3
* cell instance $1821 r0 *1 7.22,12.6
X$1821 144 344 111 87 332 AND2_X1
* cell instance $1824 r0 *1 8.93,12.6
X$1824 131 295 111 87 345 AND2_X1
* cell instance $1826 r0 *1 9.88,12.6
X$1826 128 337 87 111 358 OR2_X1
* cell instance $1827 r0 *1 10.64,12.6
X$1827 87 99 321 322 111 DFF_X1
* cell instance $1828 r0 *1 13.87,12.6
X$1828 99 87 111 389 INV_X1
* cell instance $1830 m0 *1 17.86,12.6
X$1830 87 161 297 182 111 DFF_X1
* cell instance $1831 m0 *1 14.63,12.6
X$1831 87 323 246 182 111 DFF_X1
* cell instance $1832 m0 *1 21.09,12.6
X$1832 298 87 111 182 CLKBUF_X3
* cell instance $1835 r0 *1 17.67,12.6
X$1835 144 323 111 87 297 AND2_X1
* cell instance $1838 r0 *1 19.57,12.6
X$1838 182 87 111 1007 INV_X2
* cell instance $1839 r0 *1 20.14,12.6
X$1839 178 101 111 87 390 AND2_X1
* cell instance $1841 r0 *1 21.66,12.6
X$1841 237 360 111 87 339 AND2_X1
* cell instance $1843 m0 *1 22.42,12.6
X$1843 87 203 339 134 111 DFF_X1
* cell instance $1845 m0 *1 26.6,12.6
X$1845 287 326 324 193 87 111 316 NAND4_X1
* cell instance $1848 m0 *1 28.5,12.6
X$1848 298 87 111 134 CLKBUF_X3
* cell instance $1849 m0 *1 29.45,12.6
X$1849 316 340 87 111 94 OR2_X1
* cell instance $1850 m0 *1 30.21,12.6
X$1850 134 87 111 1006 INV_X2
* cell instance $1854 m0 *1 31.92,12.6
X$1854 87 282 315 299 111 DFF_X1
* cell instance $1855 m0 *1 31.16,12.6
X$1855 128 150 87 111 373 OR2_X1
* cell instance $1858 r0 *1 31.73,12.6
X$1858 87 325 348 299 111 DFF_X1
* cell instance $1859 r0 *1 34.96,12.6
X$1859 325 87 111 374 INV_X1
* cell instance $1861 r0 *1 35.53,12.6
X$1861 138 87 111 CLKBUF_X1
* cell instance $1862 m0 *1 36.48,12.6
X$1862 313 314 338 87 315 111 AOI21_X1
* cell instance $1863 m0 *1 35.53,12.6
X$1863 298 87 111 138 CLKBUF_X3
* cell instance $1865 m0 *1 37.43,12.6
X$1865 211 284 111 87 359 AND2_X1
* cell instance $1867 m0 *1 39.71,12.6
X$1867 300 87 111 303 INV_X1
* cell instance $1868 m0 *1 40.09,12.6
X$1868 301 271 300 87 335 111 AOI21_X1
* cell instance $1869 m0 *1 40.85,12.6
X$1869 336 271 303 87 327 111 AOI21_X1
* cell instance $1870 m0 *1 41.61,12.6
X$1870 327 335 309 111 338 87 OAI21_X1
* cell instance $1871 m0 *1 42.37,12.6
X$1871 87 141 333 138 111 DFF_X1
* cell instance $1873 m0 *1 45.79,12.6
X$1873 110 87 111 329 BUF_X1
* cell instance $1875 r0 *1 36.1,12.6
X$1875 87 300 359 378 111 DFF_X1
* cell instance $1880 r0 *1 42.18,12.6
X$1880 353 87 111 328 BUF_X1
* cell instance $1882 r0 *1 42.94,12.6
X$1882 109 328 87 111 334 OR2_X1
* cell instance $1884 r0 *1 44.08,12.6
X$1884 349 141 110 325 87 111 326 NOR4_X1
* cell instance $1886 r0 *1 45.22,12.6
X$1886 325 87 111 352 BUF_X1
* cell instance $1887 r0 *1 45.79,12.6
X$1887 349 87 111 354 BUF_X1
* cell instance $1892 m0 *1 1.33,23.8
X$1892 475 87 111 472 BUF_X1
* cell instance $1894 m0 *1 1.9,23.8
X$1894 492 87 111 494 BUF_X1
* cell instance $1896 m0 *1 2.66,23.8
X$1896 491 87 111 508 BUF_X1
* cell instance $1898 m0 *1 3.42,23.8
X$1898 496 509 508 111 485 87 OAI21_X1
* cell instance $1899 m0 *1 4.18,23.8
X$1899 178 475 111 87 512 AND2_X1
* cell instance $1900 m0 *1 4.94,23.8
X$1900 87 487 512 346 111 DFF_X1
* cell instance $1901 m0 *1 8.17,23.8
X$1901 473 87 111 488 BUF_X1
* cell instance $1904 r0 *1 1.33,23.8
X$1904 519 87 111 493 BUF_X1
* cell instance $1906 r0 *1 2.28,23.8
X$1906 493 495 87 111 511 NAND2_X1
* cell instance $1907 r0 *1 2.85,23.8
X$1907 495 493 87 111 530 OR2_X1
* cell instance $1911 r0 *1 3.61,23.8
X$1911 530 494 510 87 496 111 AOI21_X1
* cell instance $1912 r0 *1 4.37,23.8
X$1912 511 494 497 87 509 111 AOI21_X1
* cell instance $1913 r0 *1 5.13,23.8
X$1913 497 87 111 510 INV_X1
* cell instance $1915 r0 *1 5.89,23.8
X$1915 568 495 111 87 531 AND2_X1
* cell instance $1917 r0 *1 6.84,23.8
X$1917 87 497 531 520 111 DFF_X1
* cell instance $1919 m0 *1 9.12,23.8
X$1919 87 495 514 322 111 DFF_X1
* cell instance $1924 m0 *1 26.98,23.8
X$1924 87 490 477 299 111 DFF_X1
* cell instance $1925 m0 *1 30.21,23.8
X$1925 478 490 111 87 489 XNOR2_X1
* cell instance $1932 r0 *1 14.25,23.8
X$1932 518 111 454 87 BUF_X4
* cell instance $1934 r0 *1 15.96,23.8
X$1934 478 488 111 87 522 XNOR2_X1
* cell instance $1941 r0 *1 26.41,23.8
X$1941 479 87 111 568 BUF_X2
* cell instance $1944 r0 *1 28.12,23.8
X$1944 454 87 111 533 INV_X2
* cell instance $1948 r0 *1 33.63,23.8
X$1948 87 523 456 535 111 DFF_X1
* cell instance $1949 m0 *1 34.2,23.8
X$1949 479 87 111 211 BUF_X2
* cell instance $1951 m0 *1 34.96,23.8
X$1951 87 498 517 378 111 DFF_X1
* cell instance $1953 m0 *1 41.23,23.8
X$1953 498 87 111 513 INV_X1
* cell instance $1954 m0 *1 41.61,23.8
X$1954 499 459 87 111 516 NAND2_X1
* cell instance $1955 m0 *1 42.18,23.8
X$1955 459 499 87 111 500 OR2_X1
* cell instance $1956 m0 *1 42.94,23.8
X$1956 480 87 111 501 INV_X1
* cell instance $1957 m0 *1 43.32,23.8
X$1957 516 480 481 87 503 111 AOI21_X1
* cell instance $1958 m0 *1 44.08,23.8
X$1958 515 513 482 87 504 111 AOI21_X1
* cell instance $1959 m0 *1 44.84,23.8
X$1959 483 498 482 87 534 111 AOI21_X1
* cell instance $1960 m0 *1 45.6,23.8
X$1960 507 87 111 499 BUF_X1
* cell instance $1963 r0 *1 36.86,23.8
X$1963 211 523 111 87 524 AND2_X1
* cell instance $1964 r0 *1 37.62,23.8
X$1964 489 461 87 111 569 NAND2_X1
* cell instance $1967 r0 *1 42.75,23.8
X$1967 500 501 481 87 502 111 AOI21_X1
* cell instance $1968 r0 *1 43.51,23.8
X$1968 502 503 532 111 526 87 OAI21_X1
* cell instance $1969 r0 *1 44.27,23.8
X$1969 506 87 111 481 BUF_X1
* cell instance $1970 r0 *1 44.84,23.8
X$1970 504 534 505 111 527 87 OAI21_X1
* cell instance $1972 r0 *1 45.79,23.8
X$1972 529 87 111 505 BUF_X1
.ENDS gpio_controller

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT INV_X4 1 2 3
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell NOR4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 11 1 12 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 10 2 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 6 3 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 9 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 13 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 8 1 13 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 4 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 6 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 7 1 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 6 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 7 3 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR4_X2

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell CLKBUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT CLKBUF_X1 1 3 4
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.19,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.38,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.19,0.2075 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.095U AS=0.009975P AD=0.01015P PS=0.4U PD=0.335U
* device instance $4 r0 *1 0.38,0.2575 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.195U AS=0.01015P AD=0.020475P PS=0.335U PD=0.6U
.ENDS CLKBUF_X1

* cell NOR4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 3 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 7 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 5 4 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR4_X1

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell DFF_X1
* pin PWELL,VSS
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 2.125,0.345 NMOS_VTL
M$17 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $18 r0 *1 2.32,0.345 NMOS_VTL
M$18 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $19 r0 *1 1.555,0.36 NMOS_VTL
M$19 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $20 r0 *1 1.745,0.36 NMOS_VTL
M$20 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $21 r0 *1 1.935,0.36 NMOS_VTL
M$21 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $22 r0 *1 2.51,0.36 NMOS_VTL
M$22 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
* device instance $23 r0 *1 0.185,0.285 NMOS_VTL
M$23 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $24 r0 *1 0.375,0.345 NMOS_VTL
M$24 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 0.565,0.345 NMOS_VTL
M$25 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $26 r0 *1 1.14,0.285 NMOS_VTL
M$26 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.76,0.3175 NMOS_VTL
M$27 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $28 r0 *1 0.95,0.3175 NMOS_VTL
M$28 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
.ENDS DFF_X1

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell XNOR2_X1
* pin A
* pin B
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT XNOR2_X1 1 2 4 5 7
* net 1 A
* net 2 B
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.18,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.37,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 7 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 8 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 4 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.18,0.195 NMOS_VTL
M$6 9 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.37,0.195 NMOS_VTL
M$7 5 2 9 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.565,0.2975 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.755,0.2975 NMOS_VTL
M$9 7 1 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.945,0.2975 NMOS_VTL
M$10 6 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X1

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X2 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4
