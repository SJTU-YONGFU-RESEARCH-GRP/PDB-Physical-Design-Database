* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_decade_counter clk count[0] count[1]
+ count[2] count[3] enable rst_n tc
X_19_ net6 _15_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__nand2_1
X_20_ net5 _04_ VSS VSS VDD VDD net7 sky130_fd_sc_hd__nor2_1
X_21_ net4 VSS VSS VDD VDD _14_ sky130_fd_sc_hd__inv_1
X_22_ net3 net2 VSS VSS VDD VDD _05_ sky130_fd_sc_hd__nand2b_1
X_23_ net2 net3 VSS VSS VDD VDD _06_ sky130_fd_sc_hd__nand2b_1
X_24_ net7 _05_ _06_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__o21ai_0
X_25_ _16_ net2 VSS VSS VDD VDD _07_ sky130_fd_sc_hd__nand2b_1
X_26_ net2 _14_ net7 _07_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__o22ai_1
X_27_ net2 _17_ VSS VSS VDD VDD _08_ sky130_fd_sc_hd__nand2_1
X_28_ net5 _08_ _04_ VSS VSS VDD VDD _09_ sky130_fd_sc_hd__nor3b_1
X_29_ net5 _08_ _09_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__a21o_1
X_30_ net2 net4 net3 VSS VSS VDD VDD _10_ sky130_fd_sc_hd__nand3_1
X_31_ net4 net3 net6 VSS VSS VDD VDD _11_ sky130_fd_sc_hd__a21bo_1
X_32_ net6 _10_ _11_ VSS VSS VDD VDD _12_ sky130_fd_sc_hd__o21ai_0
X_33_ net5 _15_ net2 VSS VSS VDD VDD _13_ sky130_fd_sc_hd__o21ai_0
X_34_ net5 _12_ _13_ net6 VSS VSS VDD VDD _03_ sky130_fd_sc_hd__a22o_1
X_35_ net3 _14_ VSS VSS VDD VDD _15_ _16_ sky130_fd_sc_hd__ha_1
X_36_ net3 net4 VSS VSS VDD VDD _17_ _18_ sky130_fd_sc_hd__ha_1
Xcount\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _00_ net1 VSS
+ VSS VDD VDD net3 sky130_fd_sc_hd__dfrtp_2
Xcount\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _01_ net1 VSS
+ VSS VDD VDD net4 sky130_fd_sc_hd__dfrtp_1
Xcount\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1 VSS
+ VSS VDD VDD net5 sky130_fd_sc_hd__dfrtp_1
Xcount\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _03_ net1 VSS
+ VSS VDD VDD net6 sky130_fd_sc_hd__dfrtp_1
Xhold1 net8 VSS VSS VDD VDD net1 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 enable VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xoutput2 net3 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput3 net4 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput4 net5 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net6 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput6 net7 VSS VSS VDD VDD tc sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net8 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_decade_counter
