* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT hamming_code corrected_code[0] corrected_code[1] corrected_code[2]
+ corrected_code[3] corrected_code[4] corrected_code[5] corrected_code[6]
+ data_in[0] data_in[1] data_in[2] data_in[3] data_out[0] data_out[1]
+ data_out[2] data_out[3] encoded_out[0] encoded_out[1] encoded_out[2]
+ encoded_out[3] encoded_out[4] encoded_out[5] encoded_out[6]
+ received_in[0] received_in[1] received_in[2] received_in[3]
+ received_in[4] received_in[5] received_in[6] single_bit_error
X_080_ received_in[2] VSS VSS VDD VDD _009_ sky130_fd_sc_hd__buf_4
X_081_ _009_ net5 VSS VSS VDD VDD _010_ sky130_fd_sc_hd__xnor2_2
X_082_ _010_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__buf_6
X_083_ received_in[5] VSS VSS VDD VDD _012_ sky130_fd_sc_hd__clkbuf_2
X_084_ _012_ net7 VSS VSS VDD VDD _013_ sky130_fd_sc_hd__xor2_1
X_085_ net8 net9 VSS VSS VDD VDD _014_ sky130_fd_sc_hd__xor2_1
X_086_ _013_ _014_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__or2_0
X_087_ _013_ _014_ _011_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__nand3_1
X_088_ _011_ _015_ _016_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__o21ai_1
X_089_ _009_ net6 VSS VSS VDD VDD _018_ sky130_fd_sc_hd__xnor2_1
X_090_ _018_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__buf_2
X_091_ net9 _012_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__xnor2_2
X_092_ _019_ _020_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__xnor2_1
X_093_ _017_ _021_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__nand2_1
X_094_ net5 _022_ VSS VSS VDD VDD net10 sky130_fd_sc_hd__xnor2_1
X_095_ _009_ _020_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__xnor2_1
X_096_ _009_ net5 VSS VSS VDD VDD _024_ sky130_fd_sc_hd__xor2_1
X_097_ _024_ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__buf_4
X_098_ _013_ _014_ _024_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__nand3_1
X_099_ _025_ _015_ _026_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__o21ai_1
X_100_ net6 _023_ _027_ VSS VSS VDD VDD net11 sky130_fd_sc_hd__mux2_1
X_101_ net6 _020_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__xnor2_1
X_102_ _009_ _028_ _017_ VSS VSS VDD VDD net12 sky130_fd_sc_hd__mux2_1
X_103_ net7 VSS VSS VDD VDD _029_ sky130_fd_sc_hd__buf_2
X_104_ _029_ _010_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__nor2_1
X_105_ net7 VSS VSS VDD VDD _031_ sky130_fd_sc_hd__buf_2
X_106_ _009_ net6 VSS VSS VDD VDD _032_ sky130_fd_sc_hd__xor2_4
X_107_ _010_ _032_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__nand2_1
X_108_ _012_ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__buf_2
X_109_ _031_ _033_ _034_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__a21oi_1
X_110_ net9 VSS VSS VDD VDD _036_ sky130_fd_sc_hd__buf_2
X_111_ _030_ _035_ _036_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__o21a_1
X_112_ _012_ VSS VSS VDD VDD _038_ sky130_fd_sc_hd__inv_1
X_113_ _038_ _025_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__nand2_1
X_114_ _011_ _019_ _029_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__o21ai_0
X_115_ _039_ _040_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__nand2_1
X_116_ net8 VSS VSS VDD VDD _042_ sky130_fd_sc_hd__buf_2
X_117_ _031_ _019_ _041_ _036_ _042_ VSS VSS VDD VDD _043_
+ sky130_fd_sc_hd__o221ai_1
X_118_ _025_ _032_ _031_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__o21ai_0
X_119_ _038_ _044_ _030_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__a21oi_1
X_120_ _011_ _032_ _031_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__o21ai_0
X_121_ _042_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__inv_1
X_122_ _031_ _032_ _047_ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__o21ai_0
X_123_ _036_ _046_ _039_ _048_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__a31oi_1
X_124_ _036_ _045_ _049_ VSS VSS VDD VDD _050_ sky130_fd_sc_hd__o21ai_0
X_125_ _037_ _043_ _050_ VSS VSS VDD VDD net13 sky130_fd_sc_hd__o21ai_0
X_126_ _029_ _019_ _042_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__a21oi_1
X_127_ _029_ _024_ _032_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__nor3_1
X_128_ _051_ _052_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__nor2_1
X_129_ _042_ _025_ _053_ _034_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__o22ai_1
X_130_ _029_ _019_ _047_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__o21ai_0
X_131_ _031_ _011_ _032_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__nand3_1
X_132_ _055_ _056_ _038_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__a21oi_1
X_133_ _031_ _011_ _032_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__nor3_1
X_134_ _051_ _058_ _034_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__o21ai_0
X_135_ _029_ _025_ _032_ VSS VSS VDD VDD _060_ sky130_fd_sc_hd__nand3_1
X_136_ _055_ _060_ _034_ VSS VSS VDD VDD _061_ sky130_fd_sc_hd__a21o_1
X_137_ _042_ _011_ _059_ _061_ _036_ VSS VSS VDD VDD _062_
+ sky130_fd_sc_hd__o2111ai_1
X_138_ _036_ _054_ _057_ _062_ VSS VSS VDD VDD net14 sky130_fd_sc_hd__o31ai_2
X_139_ _029_ _011_ _012_ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__a21oi_1
X_140_ _052_ _063_ _047_ VSS VSS VDD VDD _064_ sky130_fd_sc_hd__o21ai_0
X_141_ _034_ _032_ _064_ VSS VSS VDD VDD _065_ sky130_fd_sc_hd__o21ai_0
X_142_ _042_ _031_ _025_ _019_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nand4_1
X_143_ _036_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__inv_1
X_144_ _047_ _034_ _030_ _066_ _067_ VSS VSS VDD VDD _068_
+ sky130_fd_sc_hd__o311ai_1
X_145_ _034_ _030_ _060_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__o21a_1
X_146_ _029_ _025_ _019_ VSS VSS VDD VDD _070_ sky130_fd_sc_hd__nor3_1
X_147_ _063_ _070_ _042_ VSS VSS VDD VDD _071_ sky130_fd_sc_hd__o21ai_0
X_148_ _034_ _019_ _069_ _042_ _071_ VSS VSS VDD VDD _072_
+ sky130_fd_sc_hd__o221ai_1
X_149_ _065_ _068_ _072_ _067_ VSS VSS VDD VDD net15 sky130_fd_sc_hd__o22ai_2
X_150_ _034_ _019_ VSS VSS VDD VDD _073_ sky130_fd_sc_hd__xnor2_1
X_151_ net9 _033_ VSS VSS VDD VDD _074_ sky130_fd_sc_hd__nand2_1
X_152_ _012_ net7 VSS VSS VDD VDD _075_ sky130_fd_sc_hd__nor2_1
X_153_ _011_ _075_ VSS VSS VDD VDD _076_ sky130_fd_sc_hd__nor2_1
X_154_ net9 _076_ VSS VSS VDD VDD _077_ sky130_fd_sc_hd__nor2_1
X_155_ _011_ _018_ _075_ VSS VSS VDD VDD _078_ sky130_fd_sc_hd__and3_1
X_156_ _034_ _031_ _074_ _077_ _078_ VSS VSS VDD VDD _079_
+ sky130_fd_sc_hd__a311oi_1
X_157_ _038_ _029_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__nand2_1
X_158_ _025_ _019_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__nand2_1
X_159_ _038_ _029_ _025_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__a21oi_1
X_160_ _000_ _001_ _002_ _036_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__o22ai_1
X_161_ _025_ _032_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__nand2_1
X_162_ _036_ _004_ _031_ _038_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__a211oi_1
X_163_ _003_ _005_ _042_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__o21ai_0
X_164_ _036_ _073_ _079_ _042_ _006_ VSS VSS VDD VDD net16
+ sky130_fd_sc_hd__o221a_1
X_165_ net4 net2 VSS VSS VDD VDD _007_ sky130_fd_sc_hd__xnor2_1
X_166_ net1 _007_ VSS VSS VDD VDD p1 sky130_fd_sc_hd__xnor2_1
X_167_ net1 net3 VSS VSS VDD VDD _008_ sky130_fd_sc_hd__xnor2_1
X_168_ net4 _008_ VSS VSS VDD VDD p2 sky130_fd_sc_hd__xnor2_1
X_169_ net3 _007_ VSS VSS VDD VDD p3 sky130_fd_sc_hd__xnor2_1
X_170_ _021_ _027_ VSS VSS VDD VDD net28 sky130_fd_sc_hd__nand2_1
X_171_ net12 VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
X_172_ net14 VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
X_173_ net15 VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
X_174_ net16 VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_1
X_175_ p1 VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_1
X_176_ p2 VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_1
X_177_ net1 VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_1
X_178_ p3 VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
X_179_ net2 VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_1
X_180_ net3 VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_1
X_181_ net4 VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 data_in[0] VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_1
Xinput2 data_in[1] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput3 data_in[2] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput4 data_in[3] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput5 received_in[0] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_2
Xinput6 received_in[1] VSS VSS VDD VDD net6 sky130_fd_sc_hd__buf_2
Xinput7 received_in[3] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput8 received_in[4] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput9 received_in[6] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_2
Xoutput10 net10 VSS VSS VDD VDD corrected_code[0] sky130_fd_sc_hd__clkbuf_1
Xoutput11 net11 VSS VSS VDD VDD corrected_code[1] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net12 VSS VSS VDD VDD corrected_code[2] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net13 VSS VSS VDD VDD corrected_code[3] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net14 VSS VSS VDD VDD corrected_code[4] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net15 VSS VSS VDD VDD corrected_code[5] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net16 VSS VSS VDD VDD corrected_code[6] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net17 VSS VSS VDD VDD data_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net18 VSS VSS VDD VDD data_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net19 VSS VSS VDD VDD data_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net20 VSS VSS VDD VDD data_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net21 VSS VSS VDD VDD encoded_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput22 net22 VSS VSS VDD VDD encoded_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput23 net23 VSS VSS VDD VDD encoded_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput24 net24 VSS VSS VDD VDD encoded_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput25 net25 VSS VSS VDD VDD encoded_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput26 net26 VSS VSS VDD VDD encoded_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput27 net27 VSS VSS VDD VDD encoded_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput28 net28 VSS VSS VDD VDD single_bit_error sky130_fd_sc_hd__clkbuf_1
.ENDS hamming_code
