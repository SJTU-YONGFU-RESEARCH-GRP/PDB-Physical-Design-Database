* cell ddr_controller
* pin phy_dm[7]
* pin wr_mask[0]
* pin phy_dm[0]
* pin wr_mask[4]
* pin phy_dm[4]
* pin phy_bank[0]
* pin phy_bank[1]
* pin phy_bank[2]
* pin cmd_addr[8]
* pin cmd_addr[22]
* pin cmd_addr[12]
* pin phy_addr[8]
* pin cmd_addr[9]
* pin phy_addr[11]
* pin cmd_addr[7]
* pin cmd_addr[4]
* pin cmd_addr[6]
* pin cmd_addr[18]
* pin cmd_addr[20]
* pin phy_addr[9]
* pin cmd_addr[23]
* pin phy_addr[6]
* pin phy_addr[4]
* pin cmd_addr[25]
* pin wr_mask[3]
* pin phy_dm[3]
* pin wr_mask[7]
* pin PWELL
* pin clk
* pin NWELL
* pin wr_mask[2]
* pin phy_dm[2]
* pin cmd_addr[11]
* pin phy_cs_n
* pin rst_n
* pin cmd_addr[13]
* pin init_done
* pin wr_ready
* pin phy_reset_n
* pin state[1]
* pin cmd_addr[21]
* pin cmd_addr[14]
* pin cmd_addr[15]
* pin cmd_addr[16]
* pin cmd_addr[24]
* pin state[0]
* pin cmd_ready
* pin cmd_addr[2]
* pin cmd_addr[0]
* pin phy_addr[7]
* pin phy_addr[2]
* pin cmd_addr[17]
* pin cmd_valid
* pin cmd_addr[1]
* pin phy_addr[10]
* pin cmd_addr[19]
* pin wr_data[35]
* pin phy_addr[0]
* pin cmd_write
* pin cmd_addr[26]
* pin phy_addr[1]
* pin cmd_addr[27]
* pin phy_addr[12]
* pin phy_addr[13]
* pin phy_dq[1]
* pin rd_data[1]
* pin wr_data[13]
* pin phy_dm[6]
* pin wr_data[53]
* pin wr_data[27]
* pin phy_dq[20]
* pin wr_data[54]
* pin wr_data[57]
* pin wr_data[60]
* pin wr_data[22]
* pin phy_dq[21]
* pin rd_data[22]
* pin wr_mask[6]
* pin wr_valid
* pin wr_data[46]
* pin rd_data[21]
* pin wr_data[21]
* pin rd_ready
* pin wr_data[8]
* pin wr_data[6]
* pin wr_data[40]
* pin phy_dq[24]
* pin wr_data[43]
* pin wr_data[49]
* pin rd_valid
* pin rd_data[54]
* pin phy_dq[25]
* pin wr_data[19]
* pin rd_data[24]
* pin rd_data[52]
* pin wr_data[7]
* pin phy_dq[26]
* pin rd_data[26]
* pin rd_data[51]
* pin rd_data[53]
* pin wr_data[25]
* pin rd_data[25]
* pin wr_data[51]
* pin rd_data[7]
* pin wr_data[5]
* pin wr_data[52]
* pin rd_data[58]
* pin rd_data[9]
* pin wr_data[45]
* pin wr_data[9]
* pin wr_data[38]
* pin rd_data[8]
* pin wr_data[48]
* pin wr_data[47]
* pin wr_data[44]
* pin wr_data[26]
* pin wr_data[24]
* pin phy_dq[22]
* pin phy_dq[9]
* pin phy_dq[52]
* pin wr_data[50]
* pin rd_data[50]
* pin wr_data[4]
* pin wr_data[42]
* pin wr_data[37]
* pin wr_data[20]
* pin wr_data[32]
* pin rd_data[4]
* pin rd_data[20]
* pin phy_dq[27]
* pin rd_data[57]
* pin rd_data[6]
* pin wr_data[23]
* pin wr_data[3]
* pin rd_data[5]
* pin wr_data[41]
* pin rd_data[55]
* pin wr_data[55]
* pin wr_data[1]
* pin wr_data[39]
* pin wr_data[28]
* pin phy_dq[23]
* pin phy_dq[4]
* pin wr_data[62]
* pin wr_data[16]
* pin wr_data[14]
* pin phy_dq[44]
* pin rd_data[60]
* pin wr_data[58]
* pin rd_data[59]
* pin phy_dq[5]
* pin phy_dq[42]
* pin phy_dq[14]
* pin rd_data[13]
* pin wr_data[33]
* pin wr_data[31]
* pin wr_data[36]
* pin phy_dq[16]
* pin phy_dq[6]
* pin wr_data[61]
* pin rd_data[62]
* pin phy_dq[3]
* pin wr_data[11]
* pin wr_data[10]
* pin wr_data[12]
* pin wr_data[18]
* pin wr_data[2]
* pin phy_dq[13]
* pin phy_dq[50]
* pin wr_data[56]
* pin wr_data[59]
* pin rd_data[61]
* pin phy_dq[62]
* pin wr_data[15]
* pin phy_dq[33]
* pin wr_data[0]
* pin phy_dq[10]
* pin phy_dq[2]
* pin phy_dq[55]
* pin wr_data[17]
* pin phy_dq[58]
* pin phy_dq[12]
* pin phy_dq[60]
* pin phy_dq[32]
* pin phy_dq[41]
* pin phy_dq[37]
* pin phy_dq[34]
* pin phy_dq[36]
* pin phy_dq[45]
* pin phy_dq[38]
* pin phy_dq[40]
* pin wr_data[29]
* pin wr_mask[1]
* pin phy_odt
* pin rd_data[15]
* pin wr_data[34]
* pin wr_data[63]
* pin phy_dqs_p[3]
* pin wr_data[30]
* pin phy_cke
* pin phy_dqs_n[2]
* pin phy_dq[57]
* pin phy_dqs_n[4]
* pin phy_dqs_n[0]
* pin phy_dq[47]
* pin rd_data[17]
* pin cmd_burst_len[0]
* pin phy_dq[17]
* pin cmd_burst_len[1]
* pin phy_dq[51]
* pin rd_data[44]
* pin phy_dq[39]
* pin phy_dq[63]
* pin wr_mask[5]
* pin phy_dq[15]
* pin phy_clk
* pin phy_dq[8]
* pin rd_data[10]
* pin rd_data[45]
* pin phy_dm[5]
* pin phy_dqs_p[2]
* pin rd_data[0]
* pin rd_data[33]
* pin phy_bank_group[0]
* pin phy_dqs_n[3]
* pin phy_dq[11]
* pin phy_dqs_p[7]
* pin phy_dq[0]
* pin phy_dqs_n[5]
* pin phy_dqs_p[5]
* pin rd_data[18]
* pin phy_dqs_n[7]
* pin phy_bank_group[1]
* pin phy_dqs_p[6]
* pin rd_data[16]
* pin phy_dqs_n[6]
* pin phy_dqs_n[1]
* pin phy_dq[18]
* pin phy_dqs_p[4]
* pin rd_data[14]
* pin phy_dqs_p[1]
* pin rd_data[27]
* pin rd_data[47]
* pin phy_dq[49]
* pin rd_data[46]
* pin phy_dq[46]
* pin phy_cas_n
* pin rd_data[12]
* pin rd_data[19]
* pin cmd_burst_len[2]
* pin phy_dq[7]
* pin rd_data[23]
* pin phy_ras_n
* pin rd_data[11]
* pin phy_we_n
* pin rd_data[41]
* pin phy_dq[56]
* pin rd_data[2]
* pin rd_data[42]
* pin rd_data[48]
* pin rd_data[39]
* pin phy_dq[54]
* pin rd_data[38]
* pin rd_data[40]
* pin rd_data[30]
* pin rd_data[32]
* pin rd_data[43]
* pin rd_data[35]
* pin phy_dq[29]
* pin rd_data[3]
* pin rd_data[29]
* pin phy_dq[30]
* pin phy_dq[31]
* pin phy_addr[3]
* pin phy_dq[35]
* pin rd_data[34]
* pin rd_data[37]
* pin rd_data[63]
* pin rd_data[56]
* pin rd_data[28]
* pin phy_dm[1]
* pin phy_dqs_p[0]
* pin rd_data[49]
* pin phy_dq[59]
* pin phy_dq[61]
* pin phy_dq[48]
* pin phy_dq[53]
* pin cmd_burst_len[3]
* pin phy_dq[28]
* pin cmd_addr[3]
* pin rd_data[31]
* pin cmd_addr[5]
* pin phy_dq[19]
* pin rd_data[36]
* pin phy_dq[43]
* pin phy_addr[5]
.SUBCKT ddr_controller 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22
+ 23 24 25 26 31 32 46 59 108 109 131 389 414 484 487 488 574 599 614 615 616
+ 652 653 676 677 690 691 692 726 752 759 786 787 788 789 837 846 875 876 877
+ 879 916 962 963 964 975 976 993 994 1009 1010 1011 1043 1044 1045 1046 1066
+ 1067 1083 1084 1103 1104 1105 1125 1126 1127 1142 1143 1144 1163 1164 1165
+ 1176 1177 1184 1185 1186 1187 1201 1202 1215 1226 1242 1243 1244 1253 1254
+ 1255 1278 1283 1284 1285 1298 1299 1300 1301 1307 1308 1309 1310 1311 1323
+ 1324 1325 1341 1342 1348 1354 1357 1358 1368 1369 1375 1379 1385 1386 1391
+ 1392 1396 1402 1405 1407 1415 1416 1417 1420 1421 1422 1424 1432 1435 1440
+ 1441 1442 1444 1451 1457 1458 1459 1469 1481 1482 1483 1484 1485 1487 1489
+ 1493 1494 1495 1496 1505 1506 1507 1508 1511 1513 1515 1516 1517 1520 1525
+ 1528 1529 1530 1531 1532 1533 1534 1536 1537 1539 1543 1544 1547 1549 1550
+ 1551 1557 1558 1561 1562 1565 1566 1569 1571 1572 1573 1574 1576 1577 1579
+ 1580 1581 1582 1583 1585 1586 1587 1588 1589 1590 1591 1592 1593 1594 1595
+ 1596 1599 1600 1601 1602 1603 1605 1606 1608 1609 1611 1614 1615 1616 1617
+ 1618 1619 1620 1621 1622 1623 1624 1625 1626 1627 1628 1629 1630 1631 1632
+ 1633 1634 1635 1636 1637 1638 1639 1640 1641 1642 1643 1644 1645 1646 1647
+ 1648 1649 1650 1651 1652 1653 1654 1655 1656 1657 1658 1659 1660 1661 1662
+ 1663 1664 1665 1666 1667 1668 1669
* net 1 phy_dm[7]
* net 2 wr_mask[0]
* net 3 phy_dm[0]
* net 4 wr_mask[4]
* net 5 phy_dm[4]
* net 6 phy_bank[0]
* net 7 phy_bank[1]
* net 8 phy_bank[2]
* net 9 cmd_addr[8]
* net 10 cmd_addr[22]
* net 11 cmd_addr[12]
* net 12 phy_addr[8]
* net 13 cmd_addr[9]
* net 14 phy_addr[11]
* net 15 cmd_addr[7]
* net 16 cmd_addr[4]
* net 17 cmd_addr[6]
* net 18 cmd_addr[18]
* net 19 cmd_addr[20]
* net 20 phy_addr[9]
* net 21 cmd_addr[23]
* net 22 phy_addr[6]
* net 23 phy_addr[4]
* net 24 cmd_addr[25]
* net 25 wr_mask[3]
* net 26 phy_dm[3]
* net 31 wr_mask[7]
* net 32 PWELL
* net 46 clk
* net 59 NWELL
* net 108 wr_mask[2]
* net 109 phy_dm[2]
* net 131 cmd_addr[11]
* net 389 phy_cs_n
* net 414 rst_n
* net 484 cmd_addr[13]
* net 487 init_done
* net 488 wr_ready
* net 574 phy_reset_n
* net 599 state[1]
* net 614 cmd_addr[21]
* net 615 cmd_addr[14]
* net 616 cmd_addr[15]
* net 652 cmd_addr[16]
* net 653 cmd_addr[24]
* net 676 state[0]
* net 677 cmd_ready
* net 690 cmd_addr[2]
* net 691 cmd_addr[0]
* net 692 phy_addr[7]
* net 726 phy_addr[2]
* net 752 cmd_addr[17]
* net 759 cmd_valid
* net 786 cmd_addr[1]
* net 787 phy_addr[10]
* net 788 cmd_addr[19]
* net 789 wr_data[35]
* net 837 phy_addr[0]
* net 846 cmd_write
* net 875 cmd_addr[26]
* net 876 phy_addr[1]
* net 877 cmd_addr[27]
* net 879 phy_addr[12]
* net 916 phy_addr[13]
* net 962 phy_dq[1]
* net 963 rd_data[1]
* net 964 wr_data[13]
* net 975 phy_dm[6]
* net 976 wr_data[53]
* net 993 wr_data[27]
* net 994 phy_dq[20]
* net 1009 wr_data[54]
* net 1010 wr_data[57]
* net 1011 wr_data[60]
* net 1043 wr_data[22]
* net 1044 phy_dq[21]
* net 1045 rd_data[22]
* net 1046 wr_mask[6]
* net 1066 wr_valid
* net 1067 wr_data[46]
* net 1083 rd_data[21]
* net 1084 wr_data[21]
* net 1103 rd_ready
* net 1104 wr_data[8]
* net 1105 wr_data[6]
* net 1125 wr_data[40]
* net 1126 phy_dq[24]
* net 1127 wr_data[43]
* net 1142 wr_data[49]
* net 1143 rd_valid
* net 1144 rd_data[54]
* net 1163 phy_dq[25]
* net 1164 wr_data[19]
* net 1165 rd_data[24]
* net 1176 rd_data[52]
* net 1177 wr_data[7]
* net 1184 phy_dq[26]
* net 1185 rd_data[26]
* net 1186 rd_data[51]
* net 1187 rd_data[53]
* net 1201 wr_data[25]
* net 1202 rd_data[25]
* net 1215 wr_data[51]
* net 1226 rd_data[7]
* net 1242 wr_data[5]
* net 1243 wr_data[52]
* net 1244 rd_data[58]
* net 1253 rd_data[9]
* net 1254 wr_data[45]
* net 1255 wr_data[9]
* net 1278 wr_data[38]
* net 1283 rd_data[8]
* net 1284 wr_data[48]
* net 1285 wr_data[47]
* net 1298 wr_data[44]
* net 1299 wr_data[26]
* net 1300 wr_data[24]
* net 1301 phy_dq[22]
* net 1307 phy_dq[9]
* net 1308 phy_dq[52]
* net 1309 wr_data[50]
* net 1310 rd_data[50]
* net 1311 wr_data[4]
* net 1323 wr_data[42]
* net 1324 wr_data[37]
* net 1325 wr_data[20]
* net 1341 wr_data[32]
* net 1342 rd_data[4]
* net 1348 rd_data[20]
* net 1354 phy_dq[27]
* net 1357 rd_data[57]
* net 1358 rd_data[6]
* net 1368 wr_data[23]
* net 1369 wr_data[3]
* net 1375 rd_data[5]
* net 1379 wr_data[41]
* net 1385 rd_data[55]
* net 1386 wr_data[55]
* net 1391 wr_data[1]
* net 1392 wr_data[39]
* net 1396 wr_data[28]
* net 1402 phy_dq[23]
* net 1405 phy_dq[4]
* net 1407 wr_data[62]
* net 1415 wr_data[16]
* net 1416 wr_data[14]
* net 1417 phy_dq[44]
* net 1420 rd_data[60]
* net 1421 wr_data[58]
* net 1422 rd_data[59]
* net 1424 phy_dq[5]
* net 1432 phy_dq[42]
* net 1435 phy_dq[14]
* net 1440 rd_data[13]
* net 1441 wr_data[33]
* net 1442 wr_data[31]
* net 1444 wr_data[36]
* net 1451 phy_dq[16]
* net 1457 phy_dq[6]
* net 1458 wr_data[61]
* net 1459 rd_data[62]
* net 1469 phy_dq[3]
* net 1481 wr_data[11]
* net 1482 wr_data[10]
* net 1483 wr_data[12]
* net 1484 wr_data[18]
* net 1485 wr_data[2]
* net 1487 phy_dq[13]
* net 1489 phy_dq[50]
* net 1493 wr_data[56]
* net 1494 wr_data[59]
* net 1495 rd_data[61]
* net 1496 phy_dq[62]
* net 1505 wr_data[15]
* net 1506 phy_dq[33]
* net 1507 wr_data[0]
* net 1508 phy_dq[10]
* net 1511 phy_dq[2]
* net 1513 phy_dq[55]
* net 1515 wr_data[17]
* net 1516 phy_dq[58]
* net 1517 phy_dq[12]
* net 1520 phy_dq[60]
* net 1525 phy_dq[32]
* net 1528 phy_dq[41]
* net 1529 phy_dq[37]
* net 1530 phy_dq[34]
* net 1531 phy_dq[36]
* net 1532 phy_dq[45]
* net 1533 phy_dq[38]
* net 1534 phy_dq[40]
* net 1536 wr_data[29]
* net 1537 wr_mask[1]
* net 1539 phy_odt
* net 1543 rd_data[15]
* net 1544 wr_data[34]
* net 1547 wr_data[63]
* net 1549 phy_dqs_p[3]
* net 1550 wr_data[30]
* net 1551 phy_cke
* net 1557 phy_dqs_n[2]
* net 1558 phy_dq[57]
* net 1561 phy_dqs_n[4]
* net 1562 phy_dqs_n[0]
* net 1565 phy_dq[47]
* net 1566 rd_data[17]
* net 1569 cmd_burst_len[0]
* net 1571 phy_dq[17]
* net 1572 cmd_burst_len[1]
* net 1573 phy_dq[51]
* net 1574 rd_data[44]
* net 1576 phy_dq[39]
* net 1577 phy_dq[63]
* net 1579 wr_mask[5]
* net 1580 phy_dq[15]
* net 1581 phy_clk
* net 1582 phy_dq[8]
* net 1583 rd_data[10]
* net 1585 rd_data[45]
* net 1586 phy_dm[5]
* net 1587 phy_dqs_p[2]
* net 1588 rd_data[0]
* net 1589 rd_data[33]
* net 1590 phy_bank_group[0]
* net 1591 phy_dqs_n[3]
* net 1592 phy_dq[11]
* net 1593 phy_dqs_p[7]
* net 1594 phy_dq[0]
* net 1595 phy_dqs_n[5]
* net 1596 phy_dqs_p[5]
* net 1599 rd_data[18]
* net 1600 phy_dqs_n[7]
* net 1601 phy_bank_group[1]
* net 1602 phy_dqs_p[6]
* net 1603 rd_data[16]
* net 1605 phy_dqs_n[6]
* net 1606 phy_dqs_n[1]
* net 1608 phy_dq[18]
* net 1609 phy_dqs_p[4]
* net 1611 rd_data[14]
* net 1614 phy_dqs_p[1]
* net 1615 rd_data[27]
* net 1616 rd_data[47]
* net 1617 phy_dq[49]
* net 1618 rd_data[46]
* net 1619 phy_dq[46]
* net 1620 phy_cas_n
* net 1621 rd_data[12]
* net 1622 rd_data[19]
* net 1623 cmd_burst_len[2]
* net 1624 phy_dq[7]
* net 1625 rd_data[23]
* net 1626 phy_ras_n
* net 1627 rd_data[11]
* net 1628 phy_we_n
* net 1629 rd_data[41]
* net 1630 phy_dq[56]
* net 1631 rd_data[2]
* net 1632 rd_data[42]
* net 1633 rd_data[48]
* net 1634 rd_data[39]
* net 1635 phy_dq[54]
* net 1636 rd_data[38]
* net 1637 rd_data[40]
* net 1638 rd_data[30]
* net 1639 rd_data[32]
* net 1640 rd_data[43]
* net 1641 rd_data[35]
* net 1642 phy_dq[29]
* net 1643 rd_data[3]
* net 1644 rd_data[29]
* net 1645 phy_dq[30]
* net 1646 phy_dq[31]
* net 1647 phy_addr[3]
* net 1648 phy_dq[35]
* net 1649 rd_data[34]
* net 1650 rd_data[37]
* net 1651 rd_data[63]
* net 1652 rd_data[56]
* net 1653 rd_data[28]
* net 1654 phy_dm[1]
* net 1655 phy_dqs_p[0]
* net 1656 rd_data[49]
* net 1657 phy_dq[59]
* net 1658 phy_dq[61]
* net 1659 phy_dq[48]
* net 1660 phy_dq[53]
* net 1661 cmd_burst_len[3]
* net 1662 phy_dq[28]
* net 1663 cmd_addr[3]
* net 1664 rd_data[31]
* net 1665 cmd_addr[5]
* net 1666 phy_dq[19]
* net 1667 rd_data[36]
* net 1668 phy_dq[43]
* net 1669 phy_addr[5]
* cell instance $2 r0 *1 2.09,1.4
X$2 27 32 59 1 BUF_X1
* cell instance $8 r0 *1 12.35,1.4
X$8 2 32 59 33 BUF_X1
* cell instance $14 r0 *1 12.92,1.4
X$14 33 32 59 3 BUF_X1
* cell instance $24 r0 *1 17.48,1.4
X$24 4 32 59 35 BUF_X1
* cell instance $26 r0 *1 18.05,1.4
X$26 35 32 59 5 BUF_X1
* cell instance $35 r0 *1 22.99,1.4
X$35 37 32 59 6 BUF_X1
* cell instance $38 m0 *1 22.23,4.2
X$38 57 32 59 7 BUF_X1
* cell instance $44 r0 *1 29.64,1.4
X$44 94 32 59 8 BUF_X1
* cell instance $50 r0 *1 31.54,1.4
X$50 9 32 59 438 BUF_X1
* cell instance $56 r0 *1 32.11,1.4
X$56 10 32 59 43 BUF_X1
* cell instance $62 r0 *1 32.68,1.4
X$62 11 59 64 32 BUF_X4
* cell instance $68 r0 *1 34.01,1.4
X$68 28 32 59 12 BUF_X1
* cell instance $74 r0 *1 34.58,1.4
X$74 13 32 59 44 BUF_X1
* cell instance $80 r0 *1 35.15,1.4
X$80 40 32 59 14 BUF_X1
* cell instance $90 r0 *1 35.91,1.4
X$90 15 32 59 51 BUF_X1
* cell instance $92 r0 *1 37.05,1.4
X$92 16 32 59 179 BUF_X1
* cell instance $98 r0 *1 36.48,1.4
X$98 17 32 59 177 BUF_X1
* cell instance $104 r0 *1 38.95,1.4
X$104 18 32 59 45 BUF_X1
* cell instance $110 r0 *1 40.09,1.4
X$110 19 32 59 182 BUF_X1
* cell instance $116 r0 *1 38.38,1.4
X$116 41 32 59 20 BUF_X1
* cell instance $122 r0 *1 39.52,1.4
X$122 21 32 59 47 BUF_X1
* cell instance $128 r0 *1 41.04,1.4
X$128 80 32 59 22 BUF_X1
* cell instance $134 r0 *1 41.61,1.4
X$134 39 32 59 23 BUF_X1
* cell instance $140 r0 *1 42.94,1.4
X$140 24 32 59 49 BUF_X1
* cell instance $146 r0 *1 59.47,1.4
X$146 25 32 59 34 BUF_X1
* cell instance $152 r0 *1 60.04,1.4
X$152 34 32 59 26 BUF_X1
* cell instance $159 r0 *1 1.52,1.4
X$159 31 32 59 27 BUF_X1
* cell instance $161 m0 *1 32.3,4.2
X$161 32 1712 28 74 60 59 DFF_X1
* cell instance $164 r0 *1 35.34,4.2
X$164 28 32 59 52 BUF_X2
* cell instance $166 r0 *1 45.6,15.4
X$166 307 32 59 29 CLKBUF_X3
* cell instance $168 r0 *1 34.58,7
X$168 32 1856 96 91 29 59 DFF_X1
* cell instance $170 m0 *1 38.76,4.2
X$170 32 1707 39 66 29 59 DFF_X1
* cell instance $173 r0 *1 44.65,1.4
X$173 32 1848 48 36 29 59 DFF_X1
* cell instance $176 m0 *1 35.53,4.2
X$176 32 1762 41 76 29 59 DFF_X1
* cell instance $178 r0 *1 40.09,7
X$178 32 1825 99 128 29 59 DFF_X1
* cell instance $180 m0 *1 38,7
X$180 32 1709 80 134 29 59 DFF_X1
* cell instance $183 m0 *1 41.99,4.2
X$183 32 1713 67 75 29 59 DFF_X1
* cell instance $186 m0 *1 48.83,4.2
X$186 32 1756 53 62 29 59 DFF_X1
* cell instance $188 m0 *1 41.61,12.6
X$188 32 1739 225 224 29 59 DFF_X1
* cell instance $190 m0 *1 43.32,9.8
X$190 32 1708 100 169 29 59 DFF_X1
* cell instance $193 r0 *1 48.64,4.2
X$193 32 1795 103 104 29 59 DFF_X1
* cell instance $195 r0 *1 46.55,15.4
X$195 29 32 59 1674 INV_X4
* cell instance $198 r0 *1 47.5,15.4
X$198 32 1873 316 315 29 59 DFF_X1
* cell instance $201 r0 *1 44.84,12.6
X$201 32 1889 256 259 29 59 DFF_X1
* cell instance $213 r0 *1 54.34,12.6
X$213 32 1794 188 227 30 59 DFF_X1
* cell instance $216 r0 *1 51.87,1.4
X$216 32 1824 56 54 30 59 DFF_X1
* cell instance $218 r0 *1 67.83,9.8
X$218 32 1823 160 190 30 59 DFF_X1
* cell instance $220 r0 *1 62.13,12.6
X$220 32 1890 228 249 30 59 DFF_X1
* cell instance $223 r0 *1 66.12,7
X$223 32 1843 86 114 30 59 DFF_X1
* cell instance $225 r0 *1 58.33,4.2
X$225 32 1837 71 73 30 59 DFF_X1
* cell instance $228 r0 *1 54.91,4.2
X$228 32 1869 83 70 30 59 DFF_X1
* cell instance $231 r0 *1 59.28,7
X$231 32 1829 117 118 30 59 DFF_X1
* cell instance $233 r0 *1 59.66,9.8
X$233 32 1858 196 198 30 59 DFF_X1
* cell instance $236 r0 *1 66.69,12.6
X$236 32 1893 229 230 30 59 DFF_X1
* cell instance $239 r0 *1 55.67,7
X$239 32 1799 82 119 30 59 DFF_X1
* cell instance $241 m0 *1 60.04,18.2
X$241 307 32 59 30 CLKBUF_X3
* cell instance $243 r0 *1 54.91,15.4
X$243 32 1853 280 298 30 59 DFF_X1
* cell instance $246 r0 *1 51.68,7
X$246 32 1822 120 105 30 59 DFF_X1
* cell instance $248 m0 *1 67.83,15.4
X$248 32 1735 283 285 30 59 DFF_X1
* cell instance $250 r0 *1 58.14,15.4
X$250 32 1800 295 281 30 59 DFF_X1
* cell instance $253 r0 *1 65.36,15.4
X$253 32 1895 290 250 30 59 DFF_X1
* cell instance $255 m0 *1 63.65,9.8
X$255 32 1730 116 87 30 59 DFF_X1
* cell instance $258 r0 *1 52.06,9.8
X$258 32 1812 186 203 30 59 DFF_X1
* cell instance $260 m0 *1 51.3,15.4
X$260 32 1781 254 255 30 59 DFF_X1
* cell instance $283 m0 *1 55.67,43.4
X$283 954 165 130 32 59 1000 NAND3_X1
* cell instance $286 m0 *1 57.95,43.4
X$286 102 32 59 372 CLKBUF_X3
* cell instance $288 m0 *1 59.09,43.4
X$288 32 1695 957 956 649 59 DFF_X1
* cell instance $291 m0 *1 63.27,43.4
X$291 32 1704 914 958 649 59 DFF_X1
* cell instance $294 m0 *1 67.45,43.4
X$294 960 1041 961 32 59 959 MUX2_X1
* cell instance $296 m0 *1 69.54,43.4
X$296 964 32 59 997 BUF_X1
* cell instance $299 r0 *1 55.67,43.4
X$299 1035 165 130 32 59 1052 NAND3_X1
* cell instance $301 r0 *1 56.62,43.4
X$301 1000 1051 1037 1092 32 955 59 NAND4_X2
* cell instance $303 r0 *1 58.52,43.4
X$303 307 32 59 1048 CLKBUF_X3
* cell instance $304 r0 *1 59.47,43.4
X$304 998 991 486 32 59 1051 NAND3_X1
* cell instance $305 r0 *1 60.23,43.4
X$305 1090 372 957 32 59 1039 MUX2_X1
* cell instance $306 r0 *1 61.56,43.4
X$306 1048 32 59 1679 INV_X4
* cell instance $309 r0 *1 63.65,43.4
X$309 1040 372 914 32 59 998 MUX2_X1
* cell instance $312 r0 *1 66.88,43.4
X$312 32 1874 1086 1042 992 59 DFF_X1
* cell instance $313 r0 *1 70.11,43.4
X$313 961 32 59 963 BUF_X1
* cell instance $315 m0 *1 70.49,43.4
X$315 960 32 59 962 BUF_X1
* cell instance $321 m0 *1 13.49,46.2
X$321 775 468 823 32 59 1050 NAND3_X1
* cell instance $322 m0 *1 11.4,46.2
X$322 977 942 939 1015 979 980 32 59 OAI221_X2
* cell instance $323 m0 *1 14.25,46.2
X$323 775 32 59 703 INV_X2
* cell instance $324 m0 *1 14.82,46.2
X$324 32 852 1018 1017 666 59 DFF_X1
* cell instance $325 m0 *1 18.05,46.2
X$325 1139 1018 32 59 1054 NOR2_X1
* cell instance $328 m0 *1 19.57,46.2
X$328 977 1018 1019 32 59 1056 NOR3_X1
* cell instance $331 m0 *1 22.04,46.2
X$331 1020 1058 32 59 1074 XOR2_X1
* cell instance $332 m0 *1 23.18,46.2
X$332 1072 1007 32 59 1061 NOR2_X1
* cell instance $335 m0 *1 25.46,46.2
X$335 1021 1007 1096 32 59 1095 OR3_X1
* cell instance $340 r0 *1 11.59,46.2
X$340 883 980 1135 32 1091 59 AOI21_X1
* cell instance $341 r0 *1 12.35,46.2
X$341 580 1050 59 32 1135 AND2_X1
* cell instance $342 r0 *1 13.11,46.2
X$342 681 1147 1148 703 32 59 900 OR4_X1
* cell instance $345 r0 *1 14.82,46.2
X$345 666 32 59 INV_X8
* cell instance $346 r0 *1 16.53,46.2
X$346 307 32 59 666 CLKBUF_X3
* cell instance $350 r0 *1 19.57,46.2
X$350 1019 1018 1139 32 59 1072 OR3_X1
* cell instance $352 r0 *1 20.9,46.2
X$352 1072 1095 32 59 1112 NOR2_X1
* cell instance $353 r0 *1 21.47,46.2
X$353 1112 847 32 59 1113 NAND2_X1
* cell instance $355 r0 *1 22.42,46.2
X$355 848 1073 1020 1057 59 32 1141 OAI22_X1
* cell instance $356 r0 *1 23.37,46.2
X$356 223 1141 59 32 1094 AND2_X1
* cell instance $359 r0 *1 24.7,46.2
X$359 32 1020 1096 1094 1022 59 DFF_X1
* cell instance $361 r0 *1 28.69,46.2
X$361 32 985 1114 1076 1022 59 DFF_X1
* cell instance $362 m0 *1 29.64,46.2
X$362 1022 32 59 INV_X8
* cell instance $363 m0 *1 29.07,46.2
X$363 1075 415 32 59 1076 NOR2_X1
* cell instance $364 m0 *1 31.35,46.2
X$364 307 32 59 1022 CLKBUF_X3
* cell instance $366 m0 *1 32.49,46.2
X$366 1065 32 59 1077 INV_X1
* cell instance $367 m0 *1 32.87,46.2
X$367 1077 828 634 32 1063 59 AOI21_X1
* cell instance $368 m0 *1 33.63,46.2
X$368 1100 861 730 32 59 1102 NOR3_X1
* cell instance $369 m0 *1 34.39,46.2
X$369 1024 415 32 59 1099 NOR2_X1
* cell instance $370 m0 *1 34.96,46.2
X$370 1025 1098 861 32 1024 59 AOI21_X1
* cell instance $371 m0 *1 35.72,46.2
X$371 32 1026 1098 1099 1029 59 DFF_X1
* cell instance $374 r0 *1 31.92,46.2
X$374 1023 685 634 32 1100 59 AOI21_X1
* cell instance $375 r0 *1 32.68,46.2
X$375 1102 1114 861 32 1075 59 AOI21_X1
* cell instance $376 r0 *1 33.44,46.2
X$376 1101 415 32 59 1115 NOR2_X1
* cell instance $377 r0 *1 34.01,46.2
X$377 1063 861 730 32 59 1116 NOR3_X1
* cell instance $378 r0 *1 34.77,46.2
X$378 1116 1140 861 32 1101 59 AOI21_X1
* cell instance $380 m0 *1 43.32,46.2
X$380 1027 69 908 32 59 1097 MUX2_X1
* cell instance $381 m0 *1 40.09,46.2
X$381 32 1733 1027 1097 1029 59 DFF_X1
* cell instance $382 m0 *1 44.65,46.2
X$382 32 1734 1093 1062 1029 59 DFF_X1
* cell instance $383 m0 *1 47.88,46.2
X$383 866 184 1093 32 59 1062 MUX2_X1
* cell instance $384 m0 *1 49.21,46.2
X$384 1030 1033 32 59 1060 NAND2_X1
* cell instance $386 m0 *1 49.97,46.2
X$386 1031 1032 1136 1060 32 812 59 NAND4_X2
* cell instance $387 m0 *1 51.68,46.2
X$387 32 1776 1034 1055 1048 59 DFF_X1
* cell instance $388 m0 *1 54.91,46.2
X$388 1034 308 1036 32 59 1035 MUX2_X1
* cell instance $389 m0 *1 56.24,46.2
X$389 1078 1033 32 59 1053 NAND2_X1
* cell instance $391 m0 *1 57,46.2
X$391 1087 673 486 32 59 1037 NAND3_X1
* cell instance $392 m0 *1 57.76,46.2
X$392 1052 1080 1049 1053 32 1038 59 NAND4_X2
* cell instance $393 m0 *1 59.47,46.2
X$393 871 85 1090 32 59 1132 MUX2_X1
* cell instance $394 m0 *1 60.8,46.2
X$394 1039 991 486 32 59 1049 NAND3_X1
* cell instance $400 r0 *1 45.22,46.2
X$400 32 1844 1117 1137 1029 59 DFF_X1
* cell instance $401 r0 *1 48.45,46.2
X$401 1093 308 1117 32 59 1002 MUX2_X1
* cell instance $405 r0 *1 51.87,46.2
X$405 1118 673 486 32 59 1136 NAND3_X1
* cell instance $408 r0 *1 53.58,46.2
X$408 871 185 1036 32 59 1175 MUX2_X1
* cell instance $411 r0 *1 55.86,46.2
X$411 1119 1033 32 59 1092 NAND2_X1
* cell instance $413 r0 *1 56.81,46.2
X$413 1120 673 1079 32 59 1078 MUX2_X1
* cell instance $414 r0 *1 58.14,46.2
X$414 1133 673 486 32 59 1080 NAND3_X1
* cell instance $420 r0 *1 59.85,46.2
X$420 32 1839 1090 1132 1048 59 DFF_X1
* cell instance $421 r0 *1 63.08,46.2
X$421 32 1849 1040 1081 1048 59 DFF_X1
* cell instance $423 m0 *1 63.46,46.2
X$423 869 85 1040 32 59 1081 MUX2_X1
* cell instance $424 m0 *1 66.31,46.2
X$424 993 32 59 1122 BUF_X1
* cell instance $425 m0 *1 66.88,46.2
X$425 1123 1041 1086 32 59 1042 MUX2_X1
* cell instance $428 m0 *1 69.92,46.2
X$428 1086 32 59 1045 BUF_X1
* cell instance $430 r0 *1 66.31,46.2
X$430 1043 32 59 1123 BUF_X1
* cell instance $431 r0 *1 66.88,46.2
X$431 32 1807 1124 1129 992 59 DFF_X1
* cell instance $433 r0 *1 70.49,46.2
X$433 1084 32 59 1082 BUF_X1
* cell instance $437 m0 *1 32.49,37.8
X$437 686 532 778 32 748 59 AOI21_X1
* cell instance $438 m0 *1 29.26,37.8
X$438 32 778 814 810 777 59 DFF_X1
* cell instance $441 m0 *1 37.05,37.8
X$441 833 243 908 32 59 820 MUX2_X1
* cell instance $444 r0 *1 29.45,37.8
X$444 893 415 32 59 928 NOR2_X1
* cell instance $445 r0 *1 30.02,37.8
X$445 718 673 892 32 59 891 MUX2_X1
* cell instance $446 r0 *1 31.35,37.8
X$446 858 685 534 32 932 59 AOI21_X1
* cell instance $447 r0 *1 32.11,37.8
X$447 892 32 59 858 INV_X1
* cell instance $451 r0 *1 33.82,37.8
X$451 844 415 32 59 859 NOR2_X1
* cell instance $452 r0 *1 34.39,37.8
X$452 829 828 534 32 830 59 AOI21_X1
* cell instance $453 r0 *1 35.15,37.8
X$453 831 32 59 829 INV_X1
* cell instance $455 r0 *1 35.72,37.8
X$455 862 860 861 32 844 59 AOI21_X1
* cell instance $456 r0 *1 36.48,37.8
X$456 686 817 274 32 832 59 AOI21_X1
* cell instance $457 r0 *1 37.24,37.8
X$457 832 624 32 59 833 NOR2_X1
* cell instance $460 r0 *1 38.38,37.8
X$460 887 834 32 59 863 NAND2_X1
* cell instance $462 m0 *1 38.76,37.8
X$462 820 223 32 59 834 NAND2_X1
* cell instance $465 m0 *1 44.08,37.8
X$465 908 184 779 32 59 821 MUX2_X1
* cell instance $467 m0 *1 45.6,37.8
X$467 130 835 865 336 818 816 32 59 OAI221_X2
* cell instance $469 m0 *1 48.45,37.8
X$469 843 445 781 32 59 780 MUX2_X1
* cell instance $471 m0 *1 49.97,37.8
X$471 812 781 59 813 32 XOR2_X2
* cell instance $477 r0 *1 44.46,37.8
X$477 32 1892 750 885 607 59 DFF_X1
* cell instance $480 r0 *1 49.59,37.8
X$480 605 780 630 843 274 32 59 836 AOI221_X1
* cell instance $482 m0 *1 55.29,37.8
X$482 782 274 630 783 424 802 59 32 AOI221_X2
* cell instance $483 m0 *1 52.06,37.8
X$483 32 1773 808 809 649 59 DFF_X1
* cell instance $484 m0 *1 57.38,37.8
X$484 32 1701 784 804 649 59 DFF_X1
* cell instance $485 m0 *1 60.61,37.8
X$485 802 702 800 32 840 59 AOI21_X1
* cell instance $486 m0 *1 61.37,37.8
X$486 669 483 32 59 800 NAND2_X1
* cell instance $488 m0 *1 62.13,37.8
X$488 32 1744 785 840 649 59 DFF_X1
* cell instance $491 m0 *1 66.31,37.8
X$491 785 32 59 483 BUF_X2
* cell instance $496 r0 *1 52.63,37.8
X$496 869 184 867 32 59 921 MUX2_X1
* cell instance $498 r0 *1 54.72,37.8
X$498 869 185 911 32 59 868 MUX2_X1
* cell instance $501 r0 *1 57.76,37.8
X$501 1038 872 59 592 32 XOR2_X2
* cell instance $507 r0 *1 61.37,37.8
X$507 669 871 32 59 841 NAND2_X1
* cell instance $508 r0 *1 61.94,37.8
X$508 730 517 872 32 842 59 AOI21_X1
* cell instance $509 r0 *1 62.7,37.8
X$509 724 842 841 59 873 32 OAI21_X1
* cell instance $511 r0 *1 64.98,37.8
X$511 32 1872 874 881 649 59 DFF_X1
* cell instance $513 r0 *1 68.59,37.8
X$513 789 32 59 880 BUF_X1
* cell instance $514 r0 *1 69.16,37.8
X$514 784 32 59 837 BUF_X1
* cell instance $515 m0 *1 69.92,37.8
X$515 786 32 59 782 BUF_X1
* cell instance $517 m0 *1 70.49,37.8
X$517 788 32 59 781 BUF_X1
* cell instance $520 r0 *1 69.92,37.8
X$520 785 32 59 876 BUF_X1
* cell instance $527 m0 *1 3.61,35
X$527 712 727 708 59 694 32 OAI21_X1
* cell instance $530 m0 *1 5.32,35
X$530 709 710 711 59 727 32 OAI21_X1
* cell instance $540 r0 *1 3.42,35
X$540 838 32 59 677 BUF_X1
* cell instance $542 r0 *1 4.37,35
X$542 760 712 32 59 708 NAND2_X1
* cell instance $544 r0 *1 5.13,35
X$544 790 713 760 32 753 59 AOI21_X1
* cell instance $545 r0 *1 5.89,35
X$545 709 754 711 59 761 32 OAI21_X1
* cell instance $546 r0 *1 6.65,35
X$546 761 713 32 59 790 NOR2_X1
* cell instance $547 m0 *1 7.41,35
X$547 712 32 59 713 INV_X1
* cell instance $549 m0 *1 7.79,35
X$549 694 303 32 59 714 NAND2_X1
* cell instance $551 m0 *1 9.12,35
X$551 715 709 713 32 59 764 NOR3_X1
* cell instance $554 r0 *1 7.41,35
X$554 755 424 714 32 791 59 AOI21_X1
* cell instance $555 r0 *1 8.17,35
X$555 753 792 762 32 755 59 AOI21_X1
* cell instance $558 r0 *1 9.5,35
X$558 764 468 715 32 741 59 AOI21_X1
* cell instance $559 r0 *1 10.26,35
X$559 741 577 624 59 792 32 OAI21_X1
* cell instance $561 m0 *1 10.26,35
X$561 637 577 715 681 528 703 32 59 732 OAI33_X1
* cell instance $562 m0 *1 11.78,35
X$562 642 680 679 734 681 59 32 696 OAI221_X1
* cell instance $563 m0 *1 12.92,35
X$563 528 710 32 59 700 NOR2_X1
* cell instance $567 r0 *1 11.78,35
X$567 642 796 32 59 756 OR2_X1
* cell instance $568 r0 *1 12.54,35
X$568 602 767 600 59 796 32 OAI21_X1
* cell instance $570 r0 *1 13.68,35
X$570 265 528 742 59 32 698 OAI21_X2
* cell instance $571 m0 *1 15.96,35
X$571 468 710 32 59 739 NAND2_X1
* cell instance $572 m0 *1 14.63,35
X$572 445 739 742 59 642 32 NOR3_X2
* cell instance $576 m0 *1 19,35
X$576 682 602 32 59 772 NAND2_X1
* cell instance $579 m0 *1 20.52,35
X$579 32 644 717 703 603 59 AOI21_X4
* cell instance $580 m0 *1 22.99,35
X$580 644 744 624 596 32 59 684 AOI22_X1
* cell instance $581 m0 *1 23.94,35
X$581 684 683 32 59 716 NOR2_X1
* cell instance $584 m0 *1 25.46,35
X$584 717 32 59 681 CLKBUF_X3
* cell instance $586 r0 *1 15.01,35
X$586 770 742 424 32 59 793 NAND3_X1
* cell instance $587 r0 *1 15.77,35
X$587 176 739 32 59 770 NOR2_X1
* cell instance $588 r0 *1 16.34,35
X$588 770 392 758 59 799 32 OAI21_X1
* cell instance $589 r0 *1 17.1,35
X$589 628 701 730 32 59 758 NOR3_X1
* cell instance $591 r0 *1 18.24,35
X$591 743 59 528 32 BUF_X4
* cell instance $594 r0 *1 20.14,35
X$594 603 32 59 743 INV_X1
* cell instance $595 r0 *1 20.52,35
X$595 494 527 717 32 59 754 NAND3_X2
* cell instance $596 r0 *1 21.85,35
X$596 754 440 32 59 683 NAND2_X1
* cell instance $598 r0 *1 22.8,35
X$598 743 265 32 59 745 NAND2_X1
* cell instance $599 r0 *1 23.37,35
X$599 774 745 494 32 59 747 NAND3_X2
* cell instance $601 r0 *1 24.89,35
X$601 468 775 717 745 32 59 776 AOI22_X1
* cell instance $604 r0 *1 26.41,35
X$604 32 718 757 746 777 59 DFF_X1
* cell instance $606 m0 *1 26.79,35
X$606 331 807 59 32 746 AND2_X1
* cell instance $608 m0 *1 29.64,35
X$608 686 598 718 32 811 59 AOI21_X1
* cell instance $612 m0 *1 34.2,35
X$612 681 536 32 59 688 NAND2_X1
* cell instance $613 m0 *1 34.77,35
X$613 740 719 32 59 702 NAND2_X1
* cell instance $614 m0 *1 35.34,35
X$614 536 363 719 59 706 32 OAI21_X1
* cell instance $616 r0 *1 29.64,35
X$616 811 747 757 32 59 807 MUX2_X1
* cell instance $619 r0 *1 31.54,35
X$619 331 815 59 32 810 AND2_X1
* cell instance $620 r0 *1 32.3,35
X$620 748 747 814 32 59 815 MUX2_X1
* cell instance $623 r0 *1 34.77,35
X$623 243 526 32 59 719 NOR2_X1
* cell instance $624 r0 *1 35.34,35
X$624 719 536 32 59 724 NAND2_X1
* cell instance $625 r0 *1 35.91,35
X$625 817 176 729 32 59 819 MUX2_X1
* cell instance $626 m0 *1 37.24,35
X$626 720 624 32 59 705 NOR2_X1
* cell instance $627 m0 *1 36.48,35
X$627 686 51 274 32 720 59 AOI21_X1
* cell instance $630 r0 *1 37.43,35
X$630 243 624 526 32 59 749 NOR3_X1
* cell instance $631 r0 *1 38.19,35
X$631 819 749 424 32 59 887 NAND3_X1
* cell instance $632 m0 *1 38.38,35
X$632 721 749 424 32 59 738 NAND3_X1
* cell instance $636 m0 *1 39.71,35
X$636 738 687 32 59 737 NAND2_X1
* cell instance $643 m0 *1 41.42,35
X$643 32 1727 722 737 607 59 DFF_X1
* cell instance $645 r0 *1 41.42,35
X$645 32 1876 779 821 607 59 DFF_X1
* cell instance $646 r0 *1 44.65,35
X$646 779 183 750 32 59 751 MUX2_X1
* cell instance $648 m0 *1 45.79,35
X$648 722 32 59 339 BUF_X2
* cell instance $652 m0 *1 56.62,35
X$652 736 605 688 689 274 806 59 32 AOI221_X2
* cell instance $653 m0 *1 58.71,35
X$653 735 706 733 59 731 32 OAI21_X1
* cell instance $655 m0 *1 59.66,35
X$655 669 72 32 59 733 NAND2_X1
* cell instance $658 r0 *1 45.98,35
X$658 162 127 751 32 59 818 OR3_X1
* cell instance $661 r0 *1 48.83,35
X$661 729 816 32 59 210 XNOR2_X2
* cell instance $664 r0 *1 52.63,35
X$664 451 226 808 32 59 809 MUX2_X1
* cell instance $667 r0 *1 54.91,35
X$667 605 59 424 32 BUF_X4
* cell instance $668 r0 *1 56.24,35
X$668 782 445 620 32 59 783 MUX2_X1
* cell instance $670 r0 *1 57.76,35
X$670 806 702 803 59 804 32 OAI21_X1
* cell instance $671 r0 *1 58.52,35
X$671 669 451 32 59 803 NAND2_X1
* cell instance $677 r0 *1 60.23,35
X$677 784 32 59 451 BUF_X2
* cell instance $679 r0 *1 61.18,35
X$679 669 282 32 59 725 NAND2_X1
* cell instance $680 m0 *1 62.13,35
X$680 723 724 725 59 699 32 OAI21_X1
* cell instance $681 m0 *1 61.37,35
X$681 730 517 589 32 723 59 AOI21_X1
* cell instance $682 m0 *1 62.89,35
X$682 32 1767 728 731 649 59 DFF_X1
* cell instance $683 m0 *1 66.12,35
X$683 728 32 59 72 BUF_X2
* cell instance $686 r0 *1 61.75,35
X$686 660 279 483 32 59 797 MUX2_X1
* cell instance $687 r0 *1 63.08,35
X$687 32 1888 660 797 649 59 DFF_X1
* cell instance $688 r0 *1 66.31,35
X$688 32 1857 794 699 649 59 DFF_X1
* cell instance $689 m0 *1 68.21,35
X$689 752 32 59 729 BUF_X1
* cell instance $692 m0 *1 69.35,35
X$692 722 32 59 692 BUF_X1
* cell instance $695 r0 *1 69.54,35
X$695 794 32 59 282 BUF_X2
* cell instance $696 r0 *1 70.3,35
X$696 794 32 59 787 BUF_X1
* cell instance $697 m0 *1 70.49,35
X$697 728 32 59 726 BUF_X1
* cell instance $709 r0 *1 1.9,29.4
X$709 32 617 390 519 490 59 DFF_X2
* cell instance $714 m0 *1 3.99,29.4
X$714 548 32 59 574 BUF_X1
* cell instance $715 m0 *1 4.75,29.4
X$715 518 575 490 32 59 618 MUX2_X1
* cell instance $716 m0 *1 6.08,29.4
X$716 491 519 518 59 32 551 HA_X1
* cell instance $718 m0 *1 8.17,29.4
X$718 551 32 59 521 CLKBUF_X2
* cell instance $721 r0 *1 5.7,29.4
X$721 223 618 59 32 617 AND2_X1
* cell instance $722 r0 *1 6.46,29.4
X$722 223 619 59 32 654 AND2_X1
* cell instance $723 r0 *1 7.22,29.4
X$723 555 575 550 32 59 619 MUX2_X1
* cell instance $724 r0 *1 8.55,29.4
X$724 32 521 324 580 265 640 59 NOR4_X4
* cell instance $726 m0 *1 9.31,29.4
X$726 521 59 576 32 BUF_X4
* cell instance $727 m0 *1 11.4,29.4
X$727 527 518 59 32 556 AND2_X1
* cell instance $729 m0 *1 12.35,29.4
X$729 525 553 444 32 548 59 AOI21_X1
* cell instance $731 r0 *1 11.97,29.4
X$731 622 624 415 32 59 489 NOR3_X1
* cell instance $732 r0 *1 12.73,29.4
X$732 324 303 59 32 600 AND2_X1
* cell instance $734 m0 *1 13.68,29.4
X$734 578 176 556 59 555 32 OAI21_X1
* cell instance $736 m0 *1 14.44,29.4
X$736 601 576 522 32 626 59 AOI21_X1
* cell instance $739 r0 *1 13.68,29.4
X$739 265 32 59 527 INV_X4
* cell instance $741 r0 *1 14.82,29.4
X$741 626 606 32 59 575 NAND2_X1
* cell instance $743 r0 *1 15.77,29.4
X$743 644 643 663 628 32 59 665 OR4_X1
* cell instance $745 m0 *1 18.81,29.4
X$745 525 32 59 415 CLKBUF_X3
* cell instance $746 m0 *1 17.1,29.4
X$746 602 536 362 32 59 NOR2_X4
* cell instance $749 m0 *1 22.99,29.4
X$749 32 526 527 496 528 365 59 NOR4_X4
* cell instance $750 m0 *1 26.41,29.4
X$750 525 595 562 32 477 59 AOI21_X1
* cell instance $751 m0 *1 27.17,29.4
X$751 529 496 32 59 633 NAND2_X1
* cell instance $752 m0 *1 27.74,29.4
X$752 529 398 32 59 562 NAND2_X1
* cell instance $753 m0 *1 28.31,29.4
X$753 530 398 531 32 597 59 AOI21_X1
* cell instance $755 r0 *1 17.1,29.4
X$755 444 523 32 59 715 NAND2_X2
* cell instance $757 r0 *1 18.24,29.4
X$757 523 524 32 59 596 NAND2_X1
* cell instance $759 r0 *1 19,29.4
X$759 324 32 59 578 INV_X2
* cell instance $761 r0 *1 19.76,29.4
X$761 577 32 59 524 INV_X1
* cell instance $764 r0 *1 21.09,29.4
X$764 324 576 32 59 494 NOR2_X2
* cell instance $766 r0 *1 22.8,29.4
X$766 528 59 602 32 BUF_X4
* cell instance $767 r0 *1 24.13,29.4
X$767 324 59 605 32 BUF_X4
* cell instance $769 r0 *1 25.84,29.4
X$769 635 529 37 32 59 579 MUX2_X1
* cell instance $770 r0 *1 27.17,29.4
X$770 525 646 633 32 672 59 AOI21_X1
* cell instance $772 m0 *1 29.64,29.4
X$772 364 497 597 32 59 598 OR3_X1
* cell instance $774 m0 *1 30.59,29.4
X$774 533 32 59 531 BUF_X2
* cell instance $776 m0 *1 32.11,29.4
X$776 396 32 59 566 INV_X1
* cell instance $777 m0 *1 32.49,29.4
X$777 536 363 566 32 535 59 AOI21_X1
* cell instance $778 m0 *1 33.25,29.4
X$778 535 581 580 32 59 479 NOR3_X1
* cell instance $779 m0 *1 34.01,29.4
X$779 32 526 578 581 278 221 59 NOR4_X4
* cell instance $781 m0 *1 37.62,29.4
X$781 32 1726 537 572 337 59 DFF_X1
* cell instance $785 r0 *1 29.64,29.4
X$785 37 564 1693 59 32 634 HA_X1
* cell instance $786 r0 *1 31.54,29.4
X$786 363 605 165 32 59 635 MUX2_X1
* cell instance $787 r0 *1 32.87,29.4
X$787 580 576 32 59 311 NOR2_X2
* cell instance $789 r0 *1 34.58,29.4
X$789 606 582 32 59 581 NAND2_X2
* cell instance $791 r0 *1 36.29,29.4
X$791 46 32 59 307 CLKBUF_X3
* cell instance $792 r0 *1 37.24,29.4
X$792 581 32 59 243 CLKBUF_X3
* cell instance $793 r0 *1 38.19,29.4
X$793 582 486 424 32 59 595 NAND3_X1
* cell instance $796 r0 *1 41.23,29.4
X$796 32 1860 583 594 607 59 DFF_X1
* cell instance $798 m0 *1 41.99,29.4
X$798 573 205 32 59 569 NOR2_X1
* cell instance $799 m0 *1 42.75,29.4
X$799 499 226 583 32 59 594 MUX2_X1
* cell instance $800 m0 *1 44.08,29.4
X$800 32 1749 539 538 607 59 DFF_X1
* cell instance $801 m0 *1 47.31,29.4
X$801 569 571 584 568 59 593 32 NOR4_X2
* cell instance $802 m0 *1 49.02,29.4
X$802 593 49 59 610 32 XOR2_X2
* cell instance $804 m0 *1 51.49,29.4
X$804 32 1783 540 565 318 59 DFF_X1
* cell instance $807 r0 *1 44.65,29.4
X$807 583 152 539 32 59 632 MUX2_X1
* cell instance $808 r0 *1 45.98,29.4
X$808 632 336 32 59 571 NOR2_X1
* cell instance $811 r0 *1 47.69,29.4
X$811 631 127 486 32 59 584 NOR3_X1
* cell instance $814 r0 *1 49.4,29.4
X$814 32 559 234 609 629 445 59 NAND4_X4
* cell instance $815 r0 *1 52.82,29.4
X$815 353 625 592 59 629 32 NOR3_X2
* cell instance $818 m0 *1 55.29,29.4
X$818 560 541 502 543 59 542 32 NOR4_X2
* cell instance $820 m0 *1 57,29.4
X$820 32 1786 503 544 318 59 DFF_X1
* cell instance $821 m0 *1 60.23,29.4
X$821 32 554 557 545 587 559 59 NOR4_X4
* cell instance $822 m0 *1 63.65,29.4
X$822 552 127 162 32 59 547 NOR3_X1
* cell instance $825 r0 *1 55.48,29.4
X$825 585 336 32 59 541 NOR2_X1
* cell instance $830 r0 *1 62.13,29.4
X$830 546 620 59 587 32 XOR2_X2
* cell instance $831 r0 *1 63.84,29.4
X$831 590 205 32 59 591 NOR2_X1
* cell instance $832 r0 *1 64.41,29.4
X$832 483 132 588 32 59 613 MUX2_X1
* cell instance $833 m0 *1 66.5,29.4
X$833 507 183 508 32 59 552 MUX2_X1
* cell instance $834 m0 *1 64.79,29.4
X$834 193 621 59 554 32 XOR2_X2
* cell instance $838 r0 *1 65.74,29.4
X$838 588 183 651 32 59 590 MUX2_X1
* cell instance $840 r0 *1 67.26,29.4
X$840 615 32 59 623 BUF_X1
* cell instance $844 r0 *1 69.16,29.4
X$844 653 32 59 589 BUF_X1
* cell instance $852 m0 *1 3.61,37.8
X$852 759 32 59 710 CLKBUF_X2
* cell instance $855 m0 *1 5.32,37.8
X$855 709 711 32 59 760 NAND2_X1
* cell instance $858 m0 *1 7.6,37.8
X$858 525 791 793 32 839 59 AOI21_X1
* cell instance $861 m0 *1 10.07,37.8
X$861 698 754 32 59 763 NAND2_X1
* cell instance $863 m0 *1 10.83,37.8
X$863 715 577 32 59 765 NOR2_X1
* cell instance $864 m0 *1 11.4,37.8
X$864 715 528 32 59 795 NOR2_X1
* cell instance $866 m0 *1 12.16,37.8
X$866 576 640 528 32 766 59 AOI21_X1
* cell instance $869 m0 *1 15.2,37.8
X$869 798 739 600 32 801 59 AOI21_X1
* cell instance $871 m0 *1 16.15,37.8
X$871 769 494 32 59 768 NAND2_X1
* cell instance $873 m0 *1 17.48,37.8
X$873 825 528 32 59 773 NAND2_X1
* cell instance $874 m0 *1 18.05,37.8
X$874 743 826 576 600 59 32 771 OAI22_X1
* cell instance $875 m0 *1 19,37.8
X$875 801 772 769 32 59 855 NAND3_X1
* cell instance $884 r0 *1 4.94,37.8
X$884 32 839 666 712 878 59 DFF_X2
* cell instance $885 r0 *1 8.55,37.8
X$885 392 847 32 59 838 NOR2_X1
* cell instance $886 r0 *1 9.12,37.8
X$886 763 822 882 32 762 59 AOI21_X1
* cell instance $887 r0 *1 9.88,37.8
X$887 848 712 32 59 882 NAND2_X1
* cell instance $888 r0 *1 10.45,37.8
X$888 640 576 765 32 769 59 AOI21_X2
* cell instance $889 r0 *1 11.78,37.8
X$889 795 766 698 823 769 59 32 883 OAI221_X1
* cell instance $890 r0 *1 12.92,37.8
X$890 710 32 59 849 INV_X1
* cell instance $891 r0 *1 13.3,37.8
X$891 849 640 823 59 767 32 OAI21_X1
* cell instance $892 r0 *1 14.06,37.8
X$892 850 32 59 742 INV_X1
* cell instance $895 r0 *1 15.01,37.8
X$895 392 710 32 59 826 NOR2_X1
* cell instance $896 r0 *1 15.58,37.8
X$896 710 824 303 59 851 32 OAI21_X1
* cell instance $897 r0 *1 16.34,37.8
X$897 824 774 769 32 922 59 AOI21_X1
* cell instance $898 r0 *1 17.1,37.8
X$898 852 602 32 59 824 OR2_X1
* cell instance $899 r0 *1 17.86,37.8
X$899 715 827 524 59 886 32 OAI21_X1
* cell instance $900 r0 *1 18.62,37.8
X$900 771 769 32 59 853 NAND2_X1
* cell instance $902 r0 *1 19.38,37.8
X$902 602 59 847 32 BUF_X4
* cell instance $904 m0 *1 20.33,37.8
X$904 440 854 701 59 32 805 OAI21_X4
* cell instance $906 r0 *1 20.71,37.8
X$906 848 524 536 32 59 890 NOR3_X1
* cell instance $909 r0 *1 22.04,37.8
X$909 644 889 624 561 32 59 856 AOI22_X1
* cell instance $910 r0 *1 22.99,37.8
X$910 857 602 773 59 889 32 OAI21_X1
* cell instance $911 m0 *1 23.37,37.8
X$911 580 775 528 59 32 774 OAI21_X2
* cell instance $913 m0 *1 24.7,37.8
X$913 576 601 776 32 59 845 OR3_X2
* cell instance $917 r0 *1 24.13,37.8
X$917 905 602 773 59 744 32 OAI21_X1
* cell instance $919 r0 *1 25.65,37.8
X$919 576 32 59 624 CLKBUF_X3
* cell instance $926 m0 *1 3.04,32.2
X$926 490 32 59 599 BUF_X1
* cell instance $927 m0 *1 3.61,32.2
X$927 32 654 390 491 550 59 DFF_X2
* cell instance $931 m0 *1 9.69,32.2
X$931 521 32 59 637 INV_X1
* cell instance $934 m0 *1 11.02,32.2
X$934 656 602 576 59 655 32 OAI21_X1
* cell instance $935 m0 *1 11.78,32.2
X$935 639 596 444 59 656 32 OAI21_X1
* cell instance $937 m0 *1 12.73,32.2
X$937 662 642 600 32 622 59 AOI21_X1
* cell instance $938 m0 *1 13.49,32.2
X$938 32 601 578 641 303 59 AOI21_X4
* cell instance $939 m0 *1 15.96,32.2
X$939 32 1746 667 665 666 59 DFF_X1
* cell instance $940 m0 *1 19.19,32.2
X$940 536 444 527 59 682 32 OAI21_X1
* cell instance $941 m0 *1 19.95,32.2
X$941 637 59 536 32 BUF_X4
* cell instance $942 m0 *1 21.28,32.2
X$942 637 604 603 32 645 59 AOI21_X2
* cell instance $944 m0 *1 23.37,32.2
X$944 601 645 582 32 59 NOR2_X4
* cell instance $945 m0 *1 25.08,32.2
X$945 582 624 605 59 32 529 OAI21_X2
* cell instance $946 m0 *1 26.41,32.2
X$946 32 672 777 564 57 59 DFF_X2
* cell instance $947 m0 *1 30.02,32.2
X$947 37 57 1686 59 32 675 HA_X1
* cell instance $954 r0 *1 2.28,32.2
X$954 550 32 59 676 BUF_X1
* cell instance $955 r0 *1 2.85,32.2
X$955 550 490 1691 59 32 693 HA_X1
* cell instance $959 r0 *1 4.75,32.2
X$959 693 59 580 32 BUF_X4
* cell instance $963 r0 *1 7.41,32.2
X$963 639 602 638 32 59 695 MUX2_X1
* cell instance $964 r0 *1 8.74,32.2
X$964 525 695 640 32 636 59 AOI21_X1
* cell instance $965 r0 *1 9.5,32.2
X$965 636 696 59 32 697 AND2_X1
* cell instance $967 r0 *1 10.45,32.2
X$967 655 698 638 602 32 59 678 AOI22_X1
* cell instance $968 r0 *1 11.4,32.2
X$968 678 640 32 59 679 NOR2_X1
* cell instance $970 r0 *1 12.16,32.2
X$970 659 32 59 680 INV_X1
* cell instance $971 r0 *1 12.54,32.2
X$971 639 700 392 528 638 32 59 659 AOI221_X1
* cell instance $973 r0 *1 14.44,32.2
X$973 698 32 59 663 INV_X1
* cell instance $975 r0 *1 15.01,32.2
X$975 578 642 303 32 643 59 AOI21_X1
* cell instance $977 r0 *1 16.15,32.2
X$977 32 640 701 644 606 59 NOR3_X4
* cell instance $980 r0 *1 19.38,32.2
X$980 603 527 701 32 59 NOR2_X4
* cell instance $983 r0 *1 21.66,32.2
X$983 603 59 468 32 BUF_X4
* cell instance $984 r0 *1 22.99,32.2
X$984 645 683 32 59 628 OR2_X1
* cell instance $986 r0 *1 24.51,32.2
X$986 580 32 59 717 INV_X2
* cell instance $989 r0 *1 26.79,32.2
X$989 529 707 32 59 646 OR2_X1
* cell instance $991 r0 *1 29.07,32.2
X$991 531 398 59 685 32 XOR2_X2
* cell instance $992 r0 *1 30.78,32.2
X$992 647 424 673 32 707 59 AOI21_X1
* cell instance $993 r0 *1 31.54,32.2
X$993 363 605 396 32 59 647 NOR3_X1
* cell instance $994 r0 *1 32.3,32.2
X$994 398 531 32 59 828 XNOR2_X2
* cell instance $996 r0 *1 34.39,32.2
X$996 363 396 624 59 740 32 OAI21_X1
* cell instance $997 m0 *1 34.77,32.2
X$997 440 32 59 526 INV_X4
* cell instance $999 m0 *1 35.72,32.2
X$999 311 606 582 32 59 630 NAND3_X2
* cell instance $1000 m0 *1 37.05,32.2
X$1000 51 176 586 32 59 721 MUX2_X1
* cell instance $1005 r0 *1 35.34,32.2
X$1005 32 669 526 606 582 59 AOI21_X4
* cell instance $1008 r0 *1 38.38,32.2
X$1008 705 243 339 32 59 704 MUX2_X1
* cell instance $1009 r0 *1 39.71,32.2
X$1009 704 223 32 59 687 NAND2_X1
* cell instance $1011 m0 *1 44.27,32.2
X$1011 499 184 648 32 59 674 MUX2_X1
* cell instance $1012 m0 *1 43.32,32.2
X$1012 605 445 59 32 517 AND2_X2
* cell instance $1015 m0 *1 46.55,32.2
X$1015 648 152 608 32 59 631 MUX2_X1
* cell instance $1016 m0 *1 47.88,32.2
X$1016 499 185 608 32 59 671 MUX2_X1
* cell instance $1018 m0 *1 49.97,32.2
X$1018 813 610 670 627 59 609 32 NOR4_X2
* cell instance $1021 m0 *1 52.63,32.2
X$1021 611 279 451 32 59 668 MUX2_X1
* cell instance $1023 m0 *1 54.15,32.2
X$1023 808 152 611 32 59 585 MUX2_X1
* cell instance $1024 m0 *1 55.48,32.2
X$1024 542 623 59 627 32 XOR2_X2
* cell instance $1025 m0 *1 57.19,32.2
X$1025 612 445 621 32 59 664 MUX2_X1
* cell instance $1027 m0 *1 59.28,32.2
X$1027 483 226 661 32 59 650 MUX2_X1
* cell instance $1029 r0 *1 43.32,32.2
X$1029 32 1811 648 674 607 59 DFF_X1
* cell instance $1030 r0 *1 46.55,32.2
X$1030 32 1896 608 671 607 59 DFF_X1
* cell instance $1031 r0 *1 49.78,32.2
X$1031 152 59 673 32 BUF_X4
* cell instance $1034 r0 *1 51.68,32.2
X$1034 32 1810 611 668 649 59 DFF_X1
* cell instance $1036 r0 *1 55.29,32.2
X$1036 689 445 623 32 59 736 MUX2_X1
* cell instance $1038 r0 *1 57,32.2
X$1038 605 664 688 612 274 32 59 735 AOI221_X1
* cell instance $1044 r0 *1 59.28,32.2
X$1044 32 1850 661 650 649 59 DFF_X1
* cell instance $1045 m0 *1 61.18,32.2
X$1045 661 152 660 32 59 658 MUX2_X1
* cell instance $1047 m0 *1 62.51,32.2
X$1047 658 336 32 59 505 NOR2_X1
* cell instance $1048 m0 *1 63.08,32.2
X$1048 614 32 59 586 BUF_X1
* cell instance $1050 m0 *1 64.41,32.2
X$1050 32 1764 588 613 649 59 DFF_X1
* cell instance $1051 m0 *1 67.64,32.2
X$1051 651 58 483 32 59 657 MUX2_X1
* cell instance $1052 m0 *1 68.97,32.2
X$1052 652 32 59 621 BUF_X1
* cell instance $1053 m0 *1 69.54,32.2
X$1053 616 32 59 620 BUF_X1
* cell instance $1057 r0 *1 62.51,32.2
X$1057 691 32 59 689 BUF_X1
* cell instance $1060 r0 *1 63.65,32.2
X$1060 690 32 59 612 BUF_X1
* cell instance $1063 r0 *1 66.12,32.2
X$1063 32 1845 651 657 649 59 DFF_X1
* cell instance $1079 m0 *1 28.12,43.4
X$1079 32 950 1006 1008 1022 59 DFF_X1
* cell instance $1081 m0 *1 31.35,43.4
X$1081 1005 685 675 32 984 59 AOI21_X1
* cell instance $1083 m0 *1 32.3,43.4
X$1083 985 673 950 32 59 974 MUX2_X1
* cell instance $1087 m0 *1 38.95,43.4
X$1087 32 1718 951 972 607 59 DFF_X1
* cell instance $1090 m0 *1 23.18,43.4
X$1090 857 1061 32 59 946 XOR2_X1
* cell instance $1091 m0 *1 22.61,43.4
X$1091 1056 847 32 59 906 NAND2_X1
* cell instance $1092 m0 *1 24.32,43.4
X$1092 32 905 1007 948 777 59 DFF_X1
* cell instance $1094 r0 *1 22.61,43.4
X$1094 1056 1059 32 59 1058 NAND2_X1
* cell instance $1095 r0 *1 23.18,43.4
X$1095 32 857 1021 945 1022 59 DFF_X1
* cell instance $1096 r0 *1 26.41,43.4
X$1096 1007 1021 32 59 1059 NOR2_X1
* cell instance $1100 r0 *1 29.07,43.4
X$1100 307 32 59 777 CLKBUF_X3
* cell instance $1103 r0 *1 30.59,43.4
X$1103 983 1006 861 32 949 59 AOI21_X1
* cell instance $1104 r0 *1 31.35,43.4
X$1104 984 747 686 32 59 983 NOR3_X1
* cell instance $1106 r0 *1 32.3,43.4
X$1106 985 32 59 1023 INV_X1
* cell instance $1109 r0 *1 34.39,43.4
X$1109 1064 828 675 32 986 59 AOI21_X1
* cell instance $1110 r0 *1 35.15,43.4
X$1110 986 861 730 32 59 1025 NOR3_X1
* cell instance $1111 r0 *1 35.91,43.4
X$1111 1065 673 1026 32 59 987 MUX2_X1
* cell instance $1112 r0 *1 37.24,43.4
X$1112 1026 32 59 1064 INV_X1
* cell instance $1115 r0 *1 38.57,43.4
X$1115 32 1855 988 1004 1029 59 DFF_X1
* cell instance $1116 r0 *1 41.8,43.4
X$1116 988 58 908 32 59 1004 MUX2_X1
* cell instance $1118 m0 *1 44.65,43.4
X$1118 989 308 1028 32 59 835 MUX2_X1
* cell instance $1119 m0 *1 43.32,43.4
X$1119 952 102 951 32 59 989 MUX2_X1
* cell instance $1121 r0 *1 43.32,43.4
X$1121 1027 102 988 32 59 1028 MUX2_X1
* cell instance $1124 r0 *1 45.22,43.4
X$1124 607 32 59 1677 INV_X4
* cell instance $1125 r0 *1 46.17,43.4
X$1125 307 32 59 1029 CLKBUF_X3
* cell instance $1126 m0 *1 46.55,43.4
X$1126 102 59 165 32 BUF_X4
* cell instance $1130 r0 *1 47.12,43.4
X$1130 1029 32 59 1675 INV_X4
* cell instance $1132 m0 *1 49.21,43.4
X$1132 864 102 953 32 59 990 MUX2_X1
* cell instance $1139 r0 *1 50.16,43.4
X$1139 990 991 486 32 59 1032 NAND3_X1
* cell instance $1140 r0 *1 50.92,43.4
X$1140 1002 165 130 32 59 1031 NAND3_X1
* cell instance $1142 r0 *1 52.06,43.4
X$1142 673 32 59 991 INV_X1
* cell instance $1144 r0 *1 53.2,43.4
X$1144 372 162 32 59 1033 NOR2_X1
* cell instance $1145 r0 *1 53.77,43.4
X$1145 871 184 1034 32 59 1055 MUX2_X1
* cell instance $1147 m0 *1 1.9,57.4
X$1147 32 1722 1312 1286 992 59 DFF_X1
* cell instance $1149 m0 *1 5.13,57.4
X$1149 32 1757 1268 1288 992 59 DFF_X1
* cell instance $1155 r0 *1 1.33,57.4
X$1155 1349 1326 1312 32 59 1286 MUX2_X1
* cell instance $1156 r0 *1 2.66,57.4
X$1156 1128 1326 1353 32 59 1327 MUX2_X1
* cell instance $1160 r0 *1 3.99,57.4
X$1160 32 1798 1353 1327 992 59 DFF_X1
* cell instance $1163 r0 *1 7.79,57.4
X$1163 1313 32 59 1310 BUF_X1
* cell instance $1164 r0 *1 8.36,57.4
X$1164 1309 32 59 1345 BUF_X1
* cell instance $1165 r0 *1 8.93,57.4
X$1165 1345 1166 1313 32 59 1328 MUX2_X1
* cell instance $1166 m0 *1 10.45,57.4
X$1166 1285 32 59 1330 BUF_X1
* cell instance $1170 m0 *1 12.73,57.4
X$1170 32 1289 1271 1291 1179 59 DFF_X1
* cell instance $1171 m0 *1 15.96,57.4
X$1171 1290 805 32 59 1291 NOR2_X1
* cell instance $1172 m0 *1 16.53,57.4
X$1172 1314 805 32 59 1329 NOR2_X1
* cell instance $1174 m0 *1 17.86,57.4
X$1174 1333 1306 32 59 1362 XOR2_X1
* cell instance $1177 r0 *1 10.26,57.4
X$1177 32 1818 1313 1328 992 59 DFF_X1
* cell instance $1179 r0 *1 13.87,57.4
X$1179 32 1332 1315 1329 1179 59 DFF_X1
* cell instance $1181 r0 *1 17.48,57.4
X$1181 32 1333 1334 1356 1179 59 DFF_X1
* cell instance $1182 m0 *1 20.33,57.4
X$1182 1246 1334 1292 32 59 1335 NOR3_X1
* cell instance $1184 m0 *1 21.09,57.4
X$1184 1292 1334 1337 32 59 1247 OR3_X1
* cell instance $1185 m0 *1 22.04,57.4
X$1185 1336 1335 32 59 1373 XOR2_X1
* cell instance $1188 r0 *1 20.71,57.4
X$1188 32 1336 1337 1316 1179 59 DFF_X1
* cell instance $1190 m0 *1 27.17,57.4
X$1190 1338 686 1293 32 1317 59 AOI21_X1
* cell instance $1191 m0 *1 26.6,57.4
X$1191 1411 686 32 59 1338 NOR2_X1
* cell instance $1193 m0 *1 28.12,57.4
X$1193 1272 1173 1317 32 59 1280 MUX2_X1
* cell instance $1195 m0 *1 30.21,57.4
X$1195 1355 580 1273 32 59 1294 MUX2_X1
* cell instance $1199 m0 *1 31.92,57.4
X$1199 32 1273 1249 1339 1022 59 DFF_X1
* cell instance $1202 m0 *1 39.9,57.4
X$1202 1252 32 59 1307 BUF_X1
* cell instance $1206 m0 *1 53.39,57.4
X$1206 1224 32 59 1666 BUF_X1
* cell instance $1207 m0 *1 53.96,57.4
X$1207 32 1779 1318 1305 992 59 DFF_X1
* cell instance $1208 m0 *1 57.19,57.4
X$1208 1224 1041 1318 32 59 1305 MUX2_X1
* cell instance $1210 m0 *1 58.71,57.4
X$1210 1122 1041 1340 32 59 1319 MUX2_X1
* cell instance $1214 m0 *1 64.03,57.4
X$1214 1298 32 59 1297 BUF_X1
* cell instance $1215 m0 *1 64.6,57.4
X$1215 1252 1287 1331 32 59 1320 MUX2_X1
* cell instance $1223 r0 *1 56.62,57.4
X$1223 1287 32 59 1041 CLKBUF_X3
* cell instance $1225 r0 *1 57.95,57.4
X$1225 1122 32 59 1354 BUF_X1
* cell instance $1226 r0 *1 58.52,57.4
X$1226 32 1862 1340 1319 992 59 DFF_X1
* cell instance $1232 r0 *1 63.65,57.4
X$1232 1278 32 59 1352 BUF_X1
* cell instance $1234 r0 *1 64.6,57.4
X$1234 1254 32 59 1347 BUF_X1
* cell instance $1235 r0 *1 65.17,57.4
X$1235 32 1894 1331 1320 992 59 DFF_X1
* cell instance $1237 m0 *1 67.07,57.4
X$1237 1123 32 59 1301 BUF_X1
* cell instance $1238 m0 *1 68.21,57.4
X$1238 1331 32 59 1253 BUF_X1
* cell instance $1240 m0 *1 68.78,57.4
X$1240 1277 1041 1276 32 59 1275 MUX2_X1
* cell instance $1244 r0 *1 68.4,57.4
X$1244 1321 1041 1322 32 59 1350 MUX2_X1
* cell instance $1246 r0 *1 69.92,57.4
X$1246 1321 32 59 994 BUF_X1
* cell instance $1247 r0 *1 70.49,57.4
X$1247 1322 32 59 1348 BUF_X1
* cell instance $1249 m0 *1 3.42,15.4
X$1249 32 213 267 237 139 59 DFF_X1
* cell instance $1251 m0 *1 6.65,15.4
X$1251 288 93 32 59 266 NOR2_X1
* cell instance $1253 m0 *1 7.41,15.4
X$1253 287 253 59 32 288 XNOR2_X1
* cell instance $1254 m0 *1 8.55,15.4
X$1254 239 267 238 172 59 32 289 AND4_X1
* cell instance $1255 m0 *1 9.69,15.4
X$1255 238 267 239 172 32 326 59 NAND4_X2
* cell instance $1256 m0 *1 11.4,15.4
X$1256 233 93 32 59 216 NOR2_X1
* cell instance $1263 r0 *1 1.52,15.4
X$1263 32 286 345 284 139 59 DFF_X1
* cell instance $1268 r0 *1 4.94,15.4
X$1268 138 286 32 59 284 NOR2_X1
* cell instance $1270 r0 *1 5.7,15.4
X$1270 32 287 238 266 139 59 DFF_X1
* cell instance $1272 r0 *1 9.12,15.4
X$1272 32 303 319 289 268 59 AOI21_X4
* cell instance $1275 m0 *1 13.68,15.4
X$1275 219 174 32 59 273 NOR2_X1
* cell instance $1276 m0 *1 12.35,15.4
X$1276 292 270 147 32 269 59 AOI21_X2
* cell instance $1278 m0 *1 15.01,15.4
X$1278 174 219 32 59 292 OR2_X1
* cell instance $1280 m0 *1 15.96,15.4
X$1280 257 93 32 59 293 NOR2_X1
* cell instance $1281 m0 *1 16.53,15.4
X$1281 32 240 174 293 60 59 DFF_X1
* cell instance $1284 r0 *1 12.54,15.4
X$1284 272 271 32 59 270 OR2_X1
* cell instance $1285 r0 *1 13.3,15.4
X$1285 271 272 32 59 291 NOR2_X1
* cell instance $1287 r0 *1 14.06,15.4
X$1287 273 291 218 59 32 268 OAI21_X2
* cell instance $1288 r0 *1 15.39,15.4
X$1288 272 303 59 32 142 AND2_X1
* cell instance $1291 r0 *1 22.99,15.4
X$1291 265 59 274 32 BUF_X4
* cell instance $1293 r0 *1 25.08,15.4
X$1293 32 1828 275 294 306 59 DFF_X1
* cell instance $1294 m0 *1 26.41,15.4
X$1294 307 32 59 60 CLKBUF_X3
* cell instance $1296 m0 *1 27.36,15.4
X$1296 60 32 59 1671 INV_X4
* cell instance $1297 m0 *1 28.31,15.4
X$1297 275 98 241 32 59 262 MUX2_X1
* cell instance $1299 m0 *1 29.83,15.4
X$1299 32 1747 276 296 60 59 DFF_X1
* cell instance $1301 r0 *1 28.31,15.4
X$1301 97 77 275 32 59 294 MUX2_X1
* cell instance $1304 r0 *1 30.59,15.4
X$1304 97 245 309 32 59 322 MUX2_X1
* cell instance $1306 r0 *1 32.3,15.4
X$1306 264 308 276 32 59 302 MUX2_X1
* cell instance $1307 m0 *1 33.63,15.4
X$1307 276 246 42 32 59 296 MUX2_X1
* cell instance $1309 m0 *1 34.96,15.4
X$1309 297 243 42 32 59 244 MUX2_X1
* cell instance $1310 m0 *1 36.29,15.4
X$1310 177 265 32 59 277 NAND2_X1
* cell instance $1312 m0 *1 37.05,15.4
X$1312 299 243 97 32 59 261 MUX2_X1
* cell instance $1316 r0 *1 34.77,15.4
X$1316 278 311 242 32 297 59 AOI21_X1
* cell instance $1318 r0 *1 35.91,15.4
X$1318 278 311 277 32 299 59 AOI21_X1
* cell instance $1319 r0 *1 36.67,15.4
X$1319 278 311 300 32 301 59 AOI21_X1
* cell instance $1320 r0 *1 37.43,15.4
X$1320 179 274 32 59 300 NAND2_X1
* cell instance $1322 r0 *1 38.19,15.4
X$1322 178 205 32 59 312 NOR2_X1
* cell instance $1324 m0 *1 38.76,15.4
X$1324 301 243 55 32 59 260 MUX2_X1
* cell instance $1326 m0 *1 41.8,15.4
X$1326 245 59 226 32 BUF_X4
* cell instance $1329 r0 *1 39.14,15.4
X$1329 302 336 32 59 181 NOR2_X1
* cell instance $1334 r0 *1 42.56,15.4
X$1334 95 59 58 32 BUF_X4
* cell instance $1335 m0 *1 43.7,15.4
X$1335 246 59 279 32 BUF_X4
* cell instance $1340 r0 *1 44.65,15.4
X$1340 337 32 59 1676 INV_X4
* cell instance $1342 m0 *1 46.93,15.4
X$1342 78 59 184 32 BUF_X4
* cell instance $1348 r0 *1 53.58,15.4
X$1348 254 98 280 32 59 317 MUX2_X1
* cell instance $1349 m0 *1 55.1,15.4
X$1349 280 279 55 32 59 298 MUX2_X1
* cell instance $1354 m0 *1 58.9,15.4
X$1354 282 226 295 32 59 281 MUX2_X1
* cell instance $1356 m0 *1 60.99,15.4
X$1356 295 152 247 32 59 248 MUX2_X1
* cell instance $1357 m0 *1 62.32,15.4
X$1357 228 279 72 32 59 249 MUX2_X1
* cell instance $1363 r0 *1 61.37,15.4
X$1363 247 279 282 32 59 351 MUX2_X1
* cell instance $1367 m0 *1 65.74,15.4
X$1367 282 184 290 32 59 250 MUX2_X1
* cell instance $1371 r0 *1 68.59,15.4
X$1371 282 185 283 32 59 285 MUX2_X1
* cell instance $1375 m0 *1 1.33,18.2
X$1375 32 344 323 343 139 59 DFF_X1
* cell instance $1377 m0 *1 4.56,18.2
X$1377 345 323 32 59 325 OR2_X1
* cell instance $1386 r0 *1 3.61,18.2
X$1386 138 344 32 59 343 NOR2_X1
* cell instance $1387 r0 *1 4.18,18.2
X$1387 32 348 378 346 139 59 DFF_X1
* cell instance $1389 m0 *1 6.46,18.2
X$1389 93 348 32 59 346 NOR2_X1
* cell instance $1391 m0 *1 9.31,18.2
X$1391 32 349 321 350 139 59 DFF_X1
* cell instance $1393 m0 *1 12.73,18.2
X$1393 327 93 32 59 350 NOR2_X1
* cell instance $1394 m0 *1 13.3,18.2
X$1394 304 321 1685 59 32 272 HA_X1
* cell instance $1399 r0 *1 8.55,18.2
X$1399 32 324 408 326 392 269 59 OAI211_X4
* cell instance $1402 r0 *1 12.35,18.2
X$1402 349 303 328 32 59 327 MUX2_X1
* cell instance $1405 r0 *1 14.25,18.2
X$1405 321 304 303 59 32 173 AND3_X1
* cell instance $1409 m0 *1 18.62,18.2
X$1409 32 305 306 1681 330 59 DFF_X2
* cell instance $1410 m0 *1 22.99,18.2
X$1410 32 1787 333 332 306 59 DFF_X1
* cell instance $1412 m0 *1 26.98,18.2
X$1412 307 32 59 306 CLKBUF_X3
* cell instance $1413 m0 *1 27.93,18.2
X$1413 306 32 59 1672 INV_X4
* cell instance $1416 r0 *1 19.19,18.2
X$1416 331 329 59 32 305 AND2_X1
* cell instance $1419 r0 *1 23.37,18.2
X$1419 331 380 59 32 332 AND2_X1
* cell instance $1421 r0 *1 24.89,18.2
X$1421 220 32 59 331 BUF_X2
* cell instance $1422 r0 *1 25.65,18.2
X$1422 32 1819 94 477 306 59 DFF_X1
* cell instance $1424 m0 *1 29.45,18.2
X$1424 32 1741 309 322 306 59 DFF_X1
* cell instance $1426 m0 *1 32.68,18.2
X$1426 309 308 310 32 59 356 MUX2_X1
* cell instance $1427 m0 *1 34.01,18.2
X$1427 310 246 97 32 59 352 MUX2_X1
* cell instance $1431 m0 *1 37.81,18.2
X$1431 262 165 130 32 59 387 NOR3_X1
* cell instance $1432 m0 *1 38.57,18.2
X$1432 356 336 32 59 358 NOR2_X1
* cell instance $1433 m0 *1 39.14,18.2
X$1433 339 155 313 32 59 359 MUX2_X1
* cell instance $1434 m0 *1 40.47,18.2
X$1434 32 1763 313 359 337 59 DFF_X1
* cell instance $1435 m0 *1 43.7,18.2
X$1435 314 95 339 32 59 338 MUX2_X1
* cell instance $1436 m0 *1 45.03,18.2
X$1436 307 32 59 337 CLKBUF_X3
* cell instance $1437 m0 *1 45.98,18.2
X$1437 313 183 314 32 59 355 MUX2_X1
* cell instance $1438 m0 *1 47.31,18.2
X$1438 339 61 320 32 59 357 MUX2_X1
* cell instance $1439 m0 *1 48.64,18.2
X$1439 339 78 316 32 59 315 MUX2_X1
* cell instance $1441 m0 *1 50.16,18.2
X$1441 316 183 320 32 59 354 MUX2_X1
* cell instance $1444 m0 *1 52.44,18.2
X$1444 101 59 308 32 BUF_X4
* cell instance $1446 m0 *1 55.29,18.2
X$1446 317 336 32 59 187 NOR2_X1
* cell instance $1450 r0 *1 29.26,18.2
X$1450 94 59 398 32 BUF_X4
* cell instance $1454 r0 *1 31.92,18.2
X$1454 32 1891 310 352 306 59 DFF_X1
* cell instance $1456 r0 *1 35.34,18.2
X$1456 97 78 334 32 59 384 MUX2_X1
* cell instance $1457 r0 *1 36.67,18.2
X$1457 52 32 59 366 INV_X1
* cell instance $1460 r0 *1 38.19,18.2
X$1460 312 358 367 387 59 335 32 NOR4_X2
* cell instance $1461 r0 *1 39.9,18.2
X$1461 335 182 59 353 32 XOR2_X2
* cell instance $1464 r0 *1 43.89,18.2
X$1464 32 1808 314 338 337 59 DFF_X1
* cell instance $1465 r0 *1 47.12,18.2
X$1465 32 1861 320 357 337 59 DFF_X1
* cell instance $1466 r0 *1 50.35,18.2
X$1466 355 205 32 59 370 NOR2_X1
* cell instance $1468 r0 *1 51.3,18.2
X$1468 354 127 162 32 59 371 NOR3_X1
* cell instance $1471 r0 *1 53.01,18.2
X$1471 101 59 152 32 BUF_X4
* cell instance $1472 r0 *1 54.34,18.2
X$1472 32 1805 373 383 318 59 DFF_X1
* cell instance $1473 r0 *1 57.57,18.2
X$1473 373 58 282 32 59 383 MUX2_X1
* cell instance $1479 m0 *1 61.75,18.2
X$1479 32 1769 247 351 318 59 DFF_X1
* cell instance $1482 m0 *1 66.69,18.2
X$1482 290 183 283 32 59 340 MUX2_X1
* cell instance $1485 r0 *1 60.42,18.2
X$1485 307 32 59 318 CLKBUF_X3
* cell instance $1486 r0 *1 61.37,18.2
X$1486 318 32 59 1680 INV_X2
* cell instance $1487 r0 *1 61.94,18.2
X$1487 248 336 32 59 375 NOR2_X1
* cell instance $1489 r0 *1 62.89,18.2
X$1489 340 127 162 32 59 379 NOR3_X1
* cell instance $1492 r0 *1 64.22,18.2
X$1492 282 85 376 32 59 341 MUX2_X1
* cell instance $1495 r0 *1 66.12,18.2
X$1495 376 183 347 32 59 342 MUX2_X1
* cell instance $1496 r0 *1 67.45,18.2
X$1496 32 1806 347 377 318 59 DFF_X1
* cell instance $1499 m0 *1 6.84,23.8
X$1499 430 59 440 32 BUF_X4
* cell instance $1501 m0 *1 8.17,23.8
X$1501 460 440 32 59 138 NAND2_X2
* cell instance $1503 m0 *1 9.31,23.8
X$1503 139 32 59 1670 INV_X4
* cell instance $1504 m0 *1 10.26,23.8
X$1504 442 392 32 59 460 NAND2_X1
* cell instance $1505 m0 *1 10.83,23.8
X$1505 461 415 32 59 416 NOR2_X1
* cell instance $1506 m0 *1 11.4,23.8
X$1506 464 424 417 32 461 59 AOI21_X1
* cell instance $1508 m0 *1 12.35,23.8
X$1508 442 465 32 59 464 NOR2_X1
* cell instance $1510 m0 *1 13.11,23.8
X$1510 393 303 465 59 32 417 HA_X1
* cell instance $1514 m0 *1 1.33,23.8
X$1514 414 32 59 430 BUF_X1
* cell instance $1518 m0 *1 4.18,23.8
X$1518 138 458 32 59 439 NOR2_X1
* cell instance $1528 r0 *1 3.42,23.8
X$1528 32 458 360 439 390 59 DFF_X1
* cell instance $1531 r0 *1 8.93,23.8
X$1531 138 459 32 59 457 NOR2_X1
* cell instance $1534 r0 *1 11.4,23.8
X$1534 474 462 362 32 441 59 AOI21_X1
* cell instance $1535 r0 *1 12.16,23.8
X$1535 462 418 362 32 443 59 AOI21_X1
* cell instance $1536 r0 *1 12.92,23.8
X$1536 443 415 32 59 475 NOR2_X1
* cell instance $1540 r0 *1 14.82,23.8
X$1540 32 1866 395 466 390 59 DFF_X1
* cell instance $1541 m0 *1 19,23.8
X$1541 32 467 306 1683 361 59 DFF_X2
* cell instance $1542 m0 *1 17.67,23.8
X$1542 418 362 396 32 59 436 MUX2_X1
* cell instance $1545 r0 *1 18.05,23.8
X$1545 331 485 59 32 466 AND2_X1
* cell instance $1548 r0 *1 19.95,23.8
X$1548 32 361 396 363 330 444 59 NOR4_X4
* cell instance $1549 r0 *1 23.37,23.8
X$1549 32 496 468 440 265 422 59 NAND4_X4
* cell instance $1550 m0 *1 23.94,23.8
X$1550 440 32 59 220 CLKBUF_X3
* cell instance $1554 m0 *1 25.84,23.8
X$1554 419 32 59 396 CLKBUF_X3
* cell instance $1555 m0 *1 26.79,23.8
X$1555 420 421 365 32 245 59 NAND3_X4
* cell instance $1556 m0 *1 29.26,23.8
X$1556 37 32 59 420 INV_X2
* cell instance $1558 r0 *1 26.79,23.8
X$1558 445 59 176 32 BUF_X4
* cell instance $1560 r0 *1 28.31,23.8
X$1560 398 32 59 421 INV_X4
* cell instance $1561 r0 *1 29.26,23.8
X$1561 422 446 398 32 59 61 OR3_X4
* cell instance $1563 m0 *1 30.21,23.8
X$1563 32 421 446 422 95 59 NOR3_X4
* cell instance $1566 r0 *1 32.3,23.8
X$1566 438 445 43 32 59 470 MUX2_X1
* cell instance $1568 m0 *1 33.25,23.8
X$1568 438 265 32 59 447 NAND2_X1
* cell instance $1569 r0 *1 33.63,23.8
X$1569 479 447 59 32 425 AND2_X1
* cell instance $1570 m0 *1 34.39,23.8
X$1570 470 424 32 59 448 NAND2_X1
* cell instance $1572 m0 *1 34.96,23.8
X$1572 448 425 423 366 243 74 59 32 AOI221_X2
* cell instance $1576 r0 *1 34.39,23.8
X$1576 471 243 440 59 423 32 OAI21_X1
* cell instance $1577 r0 *1 35.15,23.8
X$1577 278 363 32 59 471 NAND2_X1
* cell instance $1580 r0 *1 39.52,23.8
X$1580 32 1863 449 473 337 59 DFF_X1
* cell instance $1581 m0 *1 42.56,23.8
X$1581 449 152 412 32 59 435 MUX2_X1
* cell instance $1582 m0 *1 41.23,23.8
X$1582 339 245 449 32 59 473 MUX2_X1
* cell instance $1588 r0 *1 43.7,23.8
X$1588 32 1834 450 472 337 59 DFF_X1
* cell instance $1590 m0 *1 46.55,23.8
X$1590 435 336 32 59 434 NOR2_X1
* cell instance $1593 m0 *1 52.44,23.8
X$1593 451 184 452 32 59 433 MUX2_X1
* cell instance $1595 m0 *1 53.96,23.8
X$1595 451 185 469 32 59 432 MUX2_X1
* cell instance $1602 r0 *1 51.3,23.8
X$1602 32 1814 452 433 318 59 DFF_X1
* cell instance $1603 r0 *1 54.53,23.8
X$1603 452 98 469 32 59 453 MUX2_X1
* cell instance $1605 r0 *1 56.62,23.8
X$1605 32 1796 455 454 318 59 DFF_X1
* cell instance $1607 m0 *1 57.19,23.8
X$1607 451 132 455 32 59 454 MUX2_X1
* cell instance $1612 m0 *1 59.85,23.8
X$1612 456 58 451 32 59 426 MUX2_X1
* cell instance $1616 r0 *1 59.85,23.8
X$1616 32 1813 456 426 318 59 DFF_X1
* cell instance $1618 m0 *1 62.32,23.8
X$1618 483 85 427 32 59 406 MUX2_X1
* cell instance $1619 m0 *1 64.41,23.8
X$1619 427 101 428 32 59 463 MUX2_X1
* cell instance $1622 m0 *1 66.69,23.8
X$1622 428 69 483 32 59 429 MUX2_X1
* cell instance $1626 r0 *1 63.27,23.8
X$1626 463 372 385 32 59 506 NOR3_X1
* cell instance $1628 r0 *1 64.79,23.8
X$1628 32 1827 428 429 318 59 DFF_X1
* cell instance $1631 m0 *1 1.33,60.2
X$1631 1359 1326 1360 32 59 1380 MUX2_X1
* cell instance $1636 r0 *1 1.71,60.2
X$1636 32 1802 1360 1380 992 59 DFF_X1
* cell instance $1641 m0 *1 3.04,60.2
X$1641 1343 32 59 1358 BUF_X1
* cell instance $1642 m0 *1 4.18,60.2
X$1642 1311 32 59 1344 BUF_X1
* cell instance $1646 m0 *1 5.32,60.2
X$1646 1167 1287 1343 32 59 1371 MUX2_X1
* cell instance $1648 m0 *1 6.65,60.2
X$1648 1344 1166 1361 32 59 1381 MUX2_X1
* cell instance $1649 m0 *1 7.98,60.2
X$1649 32 1737 1343 1371 992 59 DFF_X1
* cell instance $1653 r0 *1 5.32,60.2
X$1653 1361 32 59 1342 BUF_X1
* cell instance $1656 r0 *1 6.46,60.2
X$1656 1284 32 59 1384 BUF_X1
* cell instance $1657 r0 *1 7.03,60.2
X$1657 32 1887 1361 1381 992 59 DFF_X1
* cell instance $1660 r0 *1 11.4,60.2
X$1660 1287 32 59 1326 CLKBUF_X3
* cell instance $1662 m0 *1 15.58,60.2
X$1662 1332 1279 32 59 1314 XOR2_X1
* cell instance $1667 r0 *1 15.58,60.2
X$1667 1330 1166 1388 32 59 1400 MUX2_X1
* cell instance $1670 m0 *1 18.05,60.2
X$1670 1362 805 32 59 1356 NOR2_X1
* cell instance $1675 r0 *1 18.05,60.2
X$1675 1287 32 59 1166 CLKBUF_X3
* cell instance $1676 r0 *1 19,60.2
X$1676 1345 32 59 1489 BUF_X1
* cell instance $1678 r0 *1 19.76,60.2
X$1678 1344 32 59 1405 BUF_X1
* cell instance $1680 m0 *1 21.47,60.2
X$1680 1373 805 32 59 1316 NOR2_X1
* cell instance $1691 r0 *1 30.97,60.2
X$1691 1287 32 59 1438 CLKBUF_X3
* cell instance $1695 r0 *1 41.42,60.2
X$1695 1287 32 59 1346 CLKBUF_X3
* cell instance $1699 r0 *1 44.84,60.2
X$1699 32 1804 1376 1374 992 59 DFF_X1
* cell instance $1701 m0 *1 45.98,60.2
X$1701 1352 1346 1376 32 59 1374 MUX2_X1
* cell instance $1703 m0 *1 49.02,60.2
X$1703 1363 1346 1377 32 59 1372 MUX2_X1
* cell instance $1705 m0 *1 51.11,60.2
X$1705 1297 1346 1364 32 59 1365 MUX2_X1
* cell instance $1709 m0 *1 56.43,60.2
X$1709 1366 1041 1370 32 59 1367 MUX2_X1
* cell instance $1712 r0 *1 48.07,60.2
X$1712 32 1879 1377 1372 992 59 DFF_X1
* cell instance $1713 r0 *1 51.3,60.2
X$1713 32 1791 1364 1365 992 59 DFF_X1
* cell instance $1715 r0 *1 55.29,60.2
X$1715 1366 32 59 1402 BUF_X1
* cell instance $1717 r0 *1 56.24,60.2
X$1717 32 1864 1370 1367 992 59 DFF_X1
* cell instance $1721 r0 *1 59.47,60.2
X$1721 1383 1378 1390 32 59 1401 MUX2_X1
* cell instance $1723 r0 *1 60.99,60.2
X$1723 32 1878 1382 1398 992 59 DFF_X1
* cell instance $1724 r0 *1 64.22,60.2
X$1724 1287 32 59 1378 CLKBUF_X3
* cell instance $1725 m0 *1 64.41,60.2
X$1725 1323 32 59 1363 BUF_X1
* cell instance $1727 m0 *1 64.98,60.2
X$1727 1324 32 59 1351 BUF_X1
* cell instance $1732 r0 *1 67.45,60.2
X$1732 997 1378 1393 32 59 1394 MUX2_X1
* cell instance $1733 m0 *1 67.64,60.2
X$1733 32 1705 1322 1350 992 59 DFF_X1
* cell instance $1739 r0 *1 69.35,60.2
X$1739 1325 32 59 1321 BUF_X1
* cell instance $1742 r0 *1 70.49,60.2
X$1742 1368 32 59 1366 BUF_X1
* cell instance $1744 m0 *1 51.87,7
X$1744 55 85 120 32 59 105 MUX2_X1
* cell instance $1747 m0 *1 53.96,7
X$1747 120 98 56 32 59 166 MUX2_X1
* cell instance $1750 m0 *1 55.86,7
X$1750 55 132 82 32 59 119 MUX2_X1
* cell instance $1760 m0 *1 59.85,7
X$1760 72 132 117 32 59 118 MUX2_X1
* cell instance $1761 m0 *1 62.89,7
X$1761 106 84 115 32 59 107 MUX2_X1
* cell instance $1762 m0 *1 61.56,7
X$1762 117 101 71 32 59 106 MUX2_X1
* cell instance $1763 m0 *1 64.22,7
X$1763 72 85 116 32 59 87 MUX2_X1
* cell instance $1765 m0 *1 66.31,7
X$1765 86 69 72 32 59 114 MUX2_X1
* cell instance $1769 r0 *1 62.89,7
X$1769 102 32 59 84 INV_X1
* cell instance $1772 r0 *1 64.41,7
X$1772 116 101 86 32 59 115 MUX2_X1
* cell instance $1775 r0 *1 69.73,7
X$1775 108 32 59 112 BUF_X1
* cell instance $1776 r0 *1 70.3,7
X$1776 112 32 59 109 BUF_X1
* cell instance $1784 r0 *1 1.33,43.4
X$1784 1046 32 59 995 BUF_X1
* cell instance $1788 m0 *1 2.47,43.4
X$1788 995 32 59 975 BUF_X1
* cell instance $1789 r0 *1 2.47,43.4
X$1789 976 32 59 1012 BUF_X1
* cell instance $1791 m0 *1 5.32,43.4
X$1791 996 32 59 711 CLKBUF_X2
* cell instance $1792 m0 *1 3.42,43.4
X$1792 933 965 638 59 32 996 HA_X1
* cell instance $1794 m0 *1 6.27,43.4
X$1794 965 32 59 639 BUF_X1
* cell instance $1795 m0 *1 6.84,43.4
X$1795 978 711 32 977 59 NAND2_X4
* cell instance $1796 m0 *1 8.55,43.4
X$1796 894 979 999 59 934 32 OAI21_X1
* cell instance $1801 r0 *1 5.13,43.4
X$1801 894 965 1692 59 32 1085 HA_X1
* cell instance $1803 r0 *1 7.22,43.4
X$1803 1071 878 32 59 978 NOR2_X2
* cell instance $1805 r0 *1 8.55,43.4
X$1805 639 978 59 32 1013 AND2_X1
* cell instance $1807 r0 *1 9.69,43.4
X$1807 1013 1089 942 59 825 32 NOR3_X2
* cell instance $1809 m0 *1 10.45,43.4
X$1809 936 825 937 32 59 999 OR3_X1
* cell instance $1811 r0 *1 11.02,43.4
X$1811 1014 709 32 59 936 NOR2_X1
* cell instance $1812 r0 *1 11.59,43.4
X$1812 1014 942 32 59 1015 NOR2_X1
* cell instance $1814 r0 *1 12.35,43.4
X$1814 1015 939 32 59 1016 NOR2_X1
* cell instance $1816 m0 *1 12.54,43.4
X$1816 32 849 977 942 641 59 NOR3_X4
* cell instance $1817 m0 *1 15.96,43.4
X$1817 943 768 981 942 977 59 32 1001 OAI221_X1
* cell instance $1819 m0 *1 17.86,43.4
X$1819 827 1054 59 32 944 XNOR2_X1
* cell instance $1821 m0 *1 19.76,43.4
X$1821 942 977 603 32 59 NOR2_X4
* cell instance $1824 r0 *1 12.92,43.4
X$1824 1016 825 32 59 940 NOR2_X1
* cell instance $1826 r0 *1 13.87,43.4
X$1826 644 980 59 32 822 AND2_X1
* cell instance $1828 r0 *1 15.01,43.4
X$1828 525 920 1001 32 1017 59 AOI21_X1
* cell instance $1830 r0 *1 16.15,43.4
X$1830 852 977 32 59 981 XOR2_X1
* cell instance $1831 r0 *1 17.29,43.4
X$1831 32 827 1019 1003 666 59 DFF_X1
* cell instance $1832 r0 *1 20.52,43.4
X$1832 853 644 848 59 1057 32 OAI21_X1
* cell instance $1834 r0 *1 21.47,43.4
X$1834 853 943 1074 59 1073 32 OAI21_X1
* cell instance $1842 m0 *1 2.28,26.6
X$1842 474 32 59 487 BUF_X1
* cell instance $1845 m0 *1 6.08,26.6
X$1845 491 490 1687 59 32 513 HA_X1
* cell instance $1846 m0 *1 7.98,26.6
X$1846 32 1703 474 512 390 59 DFF_X1
* cell instance $1847 m0 *1 11.21,26.6
X$1847 441 415 32 59 512 NOR2_X1
* cell instance $1852 r0 *1 1.9,26.6
X$1852 510 32 59 488 BUF_X1
* cell instance $1853 r0 *1 2.47,26.6
X$1853 32 1881 510 489 390 59 DFF_X1
* cell instance $1859 r0 *1 6.27,26.6
X$1859 550 519 1690 59 32 520 HA_X1
* cell instance $1861 r0 *1 8.36,26.6
X$1861 520 59 324 32 BUF_X4
* cell instance $1862 r0 *1 9.69,26.6
X$1862 513 59 265 32 BUF_X4
* cell instance $1869 m0 *1 5.32,9.8
X$1869 32 121 143 161 139 59 DFF_X1
* cell instance $1871 m0 *1 8.74,9.8
X$1871 121 142 32 59 141 OR2_X1
* cell instance $1872 m0 *1 9.5,9.8
X$1872 164 122 59 32 123 XNOR2_X1
* cell instance $1873 m0 *1 10.64,9.8
X$1873 123 93 32 59 144 NOR2_X1
* cell instance $1874 m0 *1 11.21,9.8
X$1874 32 124 146 163 139 59 DFF_X1
* cell instance $1875 m0 *1 14.44,9.8
X$1875 145 143 146 59 32 147 AND3_X1
* cell instance $1887 r0 *1 7.03,9.8
X$1887 138 32 59 93 CLKBUF_X3
* cell instance $1889 r0 *1 8.36,9.8
X$1889 142 121 32 59 140 NAND2_X1
* cell instance $1890 r0 *1 8.93,9.8
X$1890 138 140 141 32 161 59 AOI21_X1
* cell instance $1892 r0 *1 9.88,9.8
X$1892 173 143 32 59 122 NAND2_X1
* cell instance $1893 r0 *1 10.45,9.8
X$1893 32 164 145 144 139 59 DFF_X1
* cell instance $1894 r0 *1 13.68,9.8
X$1894 142 143 145 32 59 125 NAND3_X1
* cell instance $1895 r0 *1 14.44,9.8
X$1895 146 143 145 32 59 218 NAND3_X1
* cell instance $1896 r0 *1 15.2,9.8
X$1896 173 147 32 59 199 NAND2_X1
* cell instance $1897 r0 *1 15.77,9.8
X$1897 197 93 32 59 175 NOR2_X1
* cell instance $1898 r0 *1 16.34,9.8
X$1898 148 199 59 32 197 XNOR2_X1
* cell instance $1903 r0 *1 26.03,9.8
X$1903 32 1821 149 168 60 59 DFF_X1
* cell instance $1904 m0 *1 28.12,9.8
X$1904 97 155 149 32 59 168 MUX2_X1
* cell instance $1907 m0 *1 29.64,9.8
X$1907 42 155 170 32 59 150 MUX2_X1
* cell instance $1909 m0 *1 31.73,9.8
X$1909 32 1754 151 137 60 59 DFF_X1
* cell instance $1910 m0 *1 34.96,9.8
X$1910 151 95 42 32 59 137 MUX2_X1
* cell instance $1912 m0 *1 37.81,9.8
X$1912 136 165 130 32 59 126 NOR3_X1
* cell instance $1913 m0 *1 38.57,9.8
X$1913 153 32 59 134 INV_X1
* cell instance $1914 m0 *1 38.95,9.8
X$1914 135 127 162 32 59 171 NOR3_X1
* cell instance $1918 r0 *1 29.83,9.8
X$1918 32 1831 170 150 60 59 DFF_X1
* cell instance $1921 r0 *1 34.01,9.8
X$1921 170 152 151 32 59 204 MUX2_X1
* cell instance $1923 r0 *1 35.72,9.8
X$1923 149 152 96 32 59 178 MUX2_X1
* cell instance $1926 r0 *1 38,9.8
X$1926 204 205 32 59 206 NOR2_X1
* cell instance $1927 r0 *1 38.57,9.8
X$1927 126 171 181 206 59 154 32 NOR4_X2
* cell instance $1929 m0 *1 40.09,9.8
X$1929 52 155 99 32 59 128 MUX2_X1
* cell instance $1931 r0 *1 40.28,9.8
X$1931 155 59 132 32 BUF_X4
* cell instance $1933 m0 *1 46.55,9.8
X$1933 99 101 100 32 59 129 MUX2_X1
* cell instance $1934 m0 *1 47.88,9.8
X$1934 156 102 90 32 59 157 MUX2_X1
* cell instance $1935 m0 *1 49.21,9.8
X$1935 133 130 157 32 59 207 MUX2_X1
* cell instance $1938 m0 *1 55.1,9.8
X$1938 166 165 130 32 59 158 NOR3_X1
* cell instance $1940 m0 *1 56.62,9.8
X$1940 82 98 83 32 59 201 MUX2_X1
* cell instance $1944 m0 *1 62.7,9.8
X$1944 84 32 59 127 CLKBUF_X3
* cell instance $1948 r0 *1 48.07,9.8
X$1948 207 43 59 209 32 XOR2_X2
* cell instance $1949 r0 *1 49.78,9.8
X$1949 167 45 59 208 32 XOR2_X2
* cell instance $1952 r0 *1 55.29,9.8
X$1952 187 202 158 159 59 167 32 NOR4_X2
* cell instance $1953 r0 *1 57,9.8
X$1953 189 127 162 32 59 159 NOR3_X1
* cell instance $1954 r0 *1 57.76,9.8
X$1954 201 205 32 59 202 NOR2_X1
* cell instance $1964 r0 *1 64.22,9.8
X$1964 107 130 195 32 59 193 MUX2_X1
* cell instance $1968 m0 *1 68.02,9.8
X$1968 131 59 102 32 BUF_X4
* cell instance $1982 r0 *1 5.13,12.6
X$1982 251 93 32 59 237 NOR2_X1
* cell instance $1983 m0 *1 5.51,12.6
X$1983 32 191 172 212 139 59 DFF_X1
* cell instance $1984 m0 *1 8.74,12.6
X$1984 191 214 32 59 231 XOR2_X1
* cell instance $1988 r0 *1 5.7,12.6
X$1988 213 252 59 32 251 XNOR2_X1
* cell instance $1989 r0 *1 6.84,12.6
X$1989 231 93 32 59 212 NOR2_X1
* cell instance $1991 r0 *1 8.17,12.6
X$1991 214 172 238 32 59 252 NAND3_X1
* cell instance $1992 r0 *1 8.93,12.6
X$1992 142 215 59 32 214 AND2_X1
* cell instance $1994 r0 *1 9.88,12.6
X$1994 173 215 172 32 59 253 NAND3_X1
* cell instance $1995 r0 *1 10.64,12.6
X$1995 32 217 239 216 139 59 DFF_X1
* cell instance $1996 m0 *1 12.73,12.6
X$1996 217 194 59 32 233 XNOR2_X1
* cell instance $1998 m0 *1 13.87,12.6
X$1998 173 147 219 174 32 59 194 NAND4_X1
* cell instance $2000 m0 *1 15.58,12.6
X$2000 32 148 200 175 60 59 DFF_X1
* cell instance $2001 m0 *1 18.81,12.6
X$2001 200 32 59 219 BUF_X1
* cell instance $2006 r0 *1 13.87,12.6
X$2006 239 174 219 147 59 32 215 AND4_X1
* cell instance $2009 r0 *1 15.96,12.6
X$2009 142 147 219 32 59 258 NAND3_X1
* cell instance $2011 r0 *1 17.1,12.6
X$2011 240 258 59 32 257 XNOR2_X1
* cell instance $2015 r0 *1 26.22,12.6
X$2015 32 1820 241 235 60 59 DFF_X1
* cell instance $2016 m0 *1 28.31,12.6
X$2016 241 68 97 32 59 235 MUX2_X1
* cell instance $2020 m0 *1 34.2,12.6
X$2020 44 176 47 32 59 236 MUX2_X1
* cell instance $2023 r0 *1 29.45,12.6
X$2023 32 1830 264 263 60 59 DFF_X1
* cell instance $2024 r0 *1 32.68,12.6
X$2024 42 245 264 32 59 263 MUX2_X1
* cell instance $2027 r0 *1 34.58,12.6
X$2027 44 265 32 59 242 NAND2_X1
* cell instance $2030 r0 *1 35.72,12.6
X$2030 221 236 220 244 32 59 65 AOI22_X1
* cell instance $2032 m0 *1 36.67,12.6
X$2032 177 176 182 32 59 222 MUX2_X1
* cell instance $2033 m0 *1 38.19,12.6
X$2033 179 176 45 32 59 180 MUX2_X1
* cell instance $2034 m0 *1 39.52,12.6
X$2034 154 47 59 211 32 XOR2_X2
* cell instance $2037 r0 *1 37.43,12.6
X$2037 221 222 223 261 32 59 153 AOI22_X1
* cell instance $2038 r0 *1 38.38,12.6
X$2038 180 221 223 260 32 59 92 AOI22_X1
* cell instance $2042 r0 *1 41.61,12.6
X$2042 52 245 225 32 59 224 MUX2_X1
* cell instance $2045 r0 *1 43.51,12.6
X$2045 256 246 52 32 59 259 MUX2_X1
* cell instance $2046 m0 *1 46.55,12.6
X$2046 225 101 256 32 59 156 MUX2_X1
* cell instance $2047 m0 *1 45.22,12.6
X$2047 61 59 185 32 BUF_X4
* cell instance $2049 m0 *1 48.64,12.6
X$2049 32 211 208 209 210 234 59 NOR4_X4
* cell instance $2051 m0 *1 52.82,12.6
X$2051 55 184 186 32 59 203 MUX2_X1
* cell instance $2053 r0 *1 48.07,12.6
X$2053 102 162 32 205 59 NAND2_X4
* cell instance $2057 r0 *1 51.87,12.6
X$2057 55 226 254 32 59 255 MUX2_X1
* cell instance $2060 m0 *1 54.72,12.6
X$2060 55 185 188 32 59 227 MUX2_X1
* cell instance $2062 m0 *1 56.05,12.6
X$2062 186 101 188 32 59 189 MUX2_X1
* cell instance $2070 m0 *1 59.28,12.6
X$2070 72 226 196 32 59 198 MUX2_X1
* cell instance $2073 m0 *1 63.84,12.6
X$2073 192 127 232 32 59 195 MUX2_X1
* cell instance $2074 m0 *1 62.51,12.6
X$2074 196 183 228 32 59 232 MUX2_X1
* cell instance $2075 m0 *1 65.17,12.6
X$2075 72 184 229 32 59 230 MUX2_X1
* cell instance $2076 m0 *1 66.5,12.6
X$2076 229 183 160 32 59 192 MUX2_X1
* cell instance $2077 m0 *1 67.83,12.6
X$2077 72 185 160 32 59 190 MUX2_X1
* cell instance $2115 r0 *1 12.92,7
X$2115 110 93 32 59 163 NOR2_X1
* cell instance $2116 r0 *1 13.49,7
X$2116 124 125 59 32 110 XNOR2_X1
* cell instance $2119 m0 *1 26.98,7
X$2119 32 1753 113 111 60 59 DFF_X1
* cell instance $2124 r0 *1 28.31,7
X$2124 113 68 42 32 59 111 MUX2_X1
* cell instance $2125 r0 *1 29.64,7
X$2125 63 98 113 32 59 136 MUX2_X1
* cell instance $2128 m0 *1 31.35,7
X$2128 42 78 79 32 59 89 MUX2_X1
* cell instance $2129 m0 *1 32.87,7
X$2129 79 98 38 32 59 135 MUX2_X1
* cell instance $2134 m0 *1 35.53,7
X$2134 96 95 97 32 59 91 MUX2_X1
* cell instance $2137 m0 *1 37.24,7
X$2137 80 32 59 97 BUF_X2
* cell instance $2138 m0 *1 41.23,7
X$2138 64 59 98 32 BUF_X4
* cell instance $2140 m0 *1 43.32,7
X$2140 77 59 85 32 BUF_X4
* cell instance $2144 r0 *1 43.32,7
X$2144 100 95 52 32 59 169 MUX2_X1
* cell instance $2145 r0 *1 44.65,7
X$2145 64 59 183 32 BUF_X4
* cell instance $2147 m0 *1 45.03,7
X$2147 32 101 59 64 BUF_X8
* cell instance $2149 m0 *1 48.45,7
X$2149 103 101 53 32 59 90 MUX2_X1
* cell instance $2153 r0 *1 46.74,7
X$2153 81 102 129 32 59 133 MUX2_X1
* cell instance $2155 r0 *1 48.45,7
X$2155 52 78 103 32 59 104 MUX2_X1
* cell instance $2160 m0 *1 29.07,4.2
X$2160 32 1696 38 50 60 59 DFF_X1
* cell instance $2162 m0 *1 45.98,4.2
X$2162 48 68 52 32 59 36 MUX2_X1
* cell instance $2164 m0 *1 47.5,4.2
X$2164 52 61 53 32 59 62 MUX2_X1
* cell instance $2166 m0 *1 52.25,4.2
X$2166 56 69 55 32 59 54 MUX2_X1
* cell instance $2187 r0 *1 25.27,4.2
X$2187 32 1816 63 88 60 59 DFF_X1
* cell instance $2188 r0 *1 28.5,4.2
X$2188 42 77 63 32 59 88 MUX2_X1
* cell instance $2190 r0 *1 30.21,4.2
X$2190 32 1880 79 89 60 59 DFF_X1
* cell instance $2193 r0 *1 36.1,4.2
X$2193 65 32 59 76 INV_X1
* cell instance $2196 r0 *1 38.76,4.2
X$2196 92 32 59 66 INV_X1
* cell instance $2201 r0 *1 43.51,4.2
X$2201 52 77 67 32 59 75 MUX2_X1
* cell instance $2202 r0 *1 44.84,4.2
X$2202 67 64 48 32 59 81 MUX2_X1
* cell instance $2203 r0 *1 46.17,4.2
X$2203 68 59 69 32 BUF_X4
* cell instance $2208 m0 *1 54.72,4.2
X$2208 83 58 55 32 59 70 MUX2_X1
* cell instance $2217 r0 *1 61.56,4.2
X$2217 71 58 72 32 59 73 MUX2_X1
* cell instance $2221 m0 *1 1.33,49
X$2221 1104 32 59 1106 BUF_X1
* cell instance $2224 m0 *1 2.09,49
X$2224 1068 1166 1107 32 59 1145 MUX2_X1
* cell instance $2226 m0 *1 3.61,49
X$2226 1103 32 59 1131 BUF_X1
* cell instance $2228 m0 *1 4.37,49
X$2228 1067 32 59 1138 BUF_X1
* cell instance $2229 m0 *1 4.94,49
X$2229 1071 32 59 1108 INV_X1
* cell instance $2230 m0 *1 5.32,49
X$2230 32 823 1168 1109 666 59 DFF_X1
* cell instance $2231 m0 *1 8.55,49
X$2231 1168 32 59 1071 BUF_X1
* cell instance $2232 m0 *1 9.12,49
X$2232 32 939 1148 1178 1110 59 AOI21_X4
* cell instance $2233 m0 *1 11.59,49
X$2233 1085 1111 1147 1149 32 59 1014 NAND4_X1
* cell instance $2234 m0 *1 12.54,49
X$2234 1111 1149 32 59 1148 NAND2_X1
* cell instance $2237 m0 *1 14.06,49
X$2237 667 32 59 1147 CLKBUF_X2
* cell instance $2241 m0 *1 19.57,49
X$2241 1019 1018 1171 32 59 1210 OR3_X1
* cell instance $2244 r0 *1 1.33,49
X$2244 1105 32 59 1167 BUF_X1
* cell instance $2246 r0 *1 2.28,49
X$2246 32 1840 1107 1145 992 59 DFF_X1
* cell instance $2252 r0 *1 6.08,49
X$2252 1146 32 59 1143 BUF_X1
* cell instance $2255 r0 *1 8.55,49
X$2255 977 979 59 32 1189 AND2_X1
* cell instance $2256 r0 *1 9.31,49
X$2256 1146 1131 1147 32 59 1178 NAND3_X2
* cell instance $2257 r0 *1 10.64,49
X$2257 1089 1131 775 32 1209 59 AOI21_X1
* cell instance $2258 r0 *1 11.4,49
X$2258 1111 1147 1149 32 59 1089 NAND3_X2
* cell instance $2261 r0 *1 13.3,49
X$2261 468 32 59 848 CLKBUF_X3
* cell instance $2264 r0 *1 16.15,49
X$2264 1169 32 59 1149 INV_X1
* cell instance $2265 r0 *1 16.53,49
X$2265 1179 32 59 1673 INV_X4
* cell instance $2266 r0 *1 17.48,49
X$2266 307 32 59 1179 CLKBUF_X3
* cell instance $2267 r0 *1 18.43,49
X$2267 32 1151 1171 1170 1179 59 DFF_X1
* cell instance $2268 m0 *1 21.09,49
X$2268 1112 848 32 59 1150 NOR2_X1
* cell instance $2270 m0 *1 21.66,49
X$2270 1151 1113 888 1057 1180 32 59 1170 AOI221_X1
* cell instance $2273 m0 *1 27.36,49
X$2273 580 1152 845 176 605 32 59 1153 AOI221_X1
* cell instance $2274 m0 *1 28.5,49
X$2274 845 605 176 32 1173 59 AOI21_X2
* cell instance $2278 r0 *1 21.66,49
X$2278 1150 1151 32 59 1180 NOR2_X1
* cell instance $2281 r0 *1 26.79,49
X$2281 845 517 1235 525 1154 1153 32 59 1172 OAI33_X1
* cell instance $2284 r0 *1 29.07,49
X$2284 1191 32 59 1154 INV_X1
* cell instance $2285 r0 *1 29.45,49
X$2285 1154 1192 1174 32 775 59 NAND3_X4
* cell instance $2286 r0 *1 31.92,49
X$2286 220 32 59 223 CLKBUF_X3
* cell instance $2287 m0 *1 32.68,49
X$2287 32 1065 1140 1115 1022 59 DFF_X1
* cell instance $2291 r0 *1 33.63,49
X$2291 686 59 730 32 BUF_X4
* cell instance $2293 m0 *1 36.48,49
X$2293 32 1724 1155 863 1029 59 DFF_X1
* cell instance $2299 r0 *1 38.38,49
X$2299 1155 32 59 908 CLKBUF_X2
* cell instance $2303 r0 *1 41.8,49
X$2303 908 226 1181 32 59 1214 MUX2_X1
* cell instance $2306 r0 *1 43.7,49
X$2306 1181 308 1195 32 59 865 MUX2_X1
* cell instance $2309 m0 *1 46.93,49
X$2309 866 185 1117 32 59 1137 MUX2_X1
* cell instance $2311 m0 *1 49.21,49
X$2311 1157 58 866 32 59 1156 MUX2_X1
* cell instance $2315 r0 *1 49.21,49
X$2315 32 1851 1157 1156 1029 59 DFF_X1
* cell instance $2316 m0 *1 51.11,49
X$2316 1241 372 1157 32 59 1118 MUX2_X1
* cell instance $2320 m0 *1 53.01,49
X$2320 32 1774 1036 1175 1048 59 DFF_X1
* cell instance $2325 r0 *1 56.05,49
X$2325 32 1797 1079 1158 1048 59 DFF_X1
* cell instance $2326 m0 *1 56.81,49
X$2326 1079 279 871 32 59 1158 MUX2_X1
* cell instance $2334 r0 *1 60.04,49
X$2334 1160 58 871 32 59 1182 MUX2_X1
* cell instance $2336 m0 *1 60.04,49
X$2336 1121 372 1160 32 59 1133 MUX2_X1
* cell instance $2338 m0 *1 68.21,49
X$2338 1082 1041 1124 32 59 1129 MUX2_X1
* cell instance $2339 m0 *1 69.54,49
X$2339 1124 32 59 1083 BUF_X1
* cell instance $2343 r0 *1 63.65,49
X$2343 1222 372 1161 32 59 1087 MUX2_X1
* cell instance $2344 r0 *1 64.98,49
X$2344 1161 58 869 32 59 1205 MUX2_X1
* cell instance $2347 r0 *1 67.45,49
X$2347 1127 32 59 1183 BUF_X1
* cell instance $2349 r0 *1 68.21,49
X$2349 1125 32 59 1159 BUF_X1
* cell instance $2350 r0 *1 68.78,49
X$2350 1162 1041 1200 32 59 1203 MUX2_X1
* cell instance $2351 r0 *1 70.11,49
X$2351 1162 32 59 1126 BUF_X1
* cell instance $2353 m0 *1 70.49,49
X$2353 1082 32 59 1044 BUF_X1
* cell instance $2356 m0 *1 1.33,65.8
X$2356 1407 32 59 1423 BUF_X1
* cell instance $2358 m0 *1 1.9,65.8
X$2358 1421 32 59 1349 BUF_X1
* cell instance $2359 m0 *1 2.47,65.8
X$2359 1497 1326 1460 32 59 1461 MUX2_X1
* cell instance $2360 m0 *1 3.8,65.8
X$2360 1548 32 59 LOGIC1_X1
* cell instance $2361 m0 *1 4.18,65.8
X$2361 1386 32 59 1426 BUF_X1
* cell instance $2362 m0 *1 4.75,65.8
X$2362 1425 32 59 LOGIC1_X1
* cell instance $2363 m0 *1 5.13,65.8
X$2363 1387 32 59 1385 BUF_X1
* cell instance $2364 m0 *1 5.7,65.8
X$2364 1427 32 59 LOGIC1_X1
* cell instance $2365 m0 *1 6.08,65.8
X$2365 1462 1326 1463 32 59 1464 MUX2_X1
* cell instance $2366 m0 *1 7.41,65.8
X$2366 1552 32 59 LOGIC1_X1
* cell instance $2367 m0 *1 7.79,65.8
X$2367 1396 32 59 1455 BUF_X1
* cell instance $2370 m0 *1 9.31,65.8
X$2370 32 1731 1466 1488 992 59 DFF_X1
* cell instance $2371 m0 *1 12.54,65.8
X$2371 32 1736 1465 1429 992 59 DFF_X1
* cell instance $2372 m0 *1 15.77,65.8
X$2372 32 1698 1410 1430 992 59 DFF_X1
* cell instance $2376 r0 *1 1.33,65.8
X$2376 1423 32 59 1496 BUF_X1
* cell instance $2377 r0 *1 1.9,65.8
X$2377 1408 32 59 1459 BUF_X1
* cell instance $2378 r0 *1 2.47,65.8
X$2378 32 1788 1460 1461 992 59 DFF_X1
* cell instance $2382 r0 *1 5.7,65.8
X$2382 1465 32 59 1422 BUF_X1
* cell instance $2383 r0 *1 6.27,65.8
X$2383 32 1846 1463 1464 992 59 DFF_X1
* cell instance $2384 r0 *1 9.5,65.8
X$2384 1509 32 59 LOGIC0_X1
* cell instance $2385 r0 *1 9.88,65.8
X$2385 1509 32 59 1600 BUF_X1
* cell instance $2386 r0 *1 10.45,65.8
X$2386 1499 1326 1466 32 59 1488 MUX2_X1
* cell instance $2387 r0 *1 11.78,65.8
X$2387 1510 1326 1465 32 59 1429 MUX2_X1
* cell instance $2391 r0 *1 17.29,65.8
X$2391 1138 1166 1514 32 59 1512 MUX2_X1
* cell instance $2395 m0 *1 20.14,65.8
X$2395 1426 32 59 1513 BUF_X1
* cell instance $2397 m0 *1 25.27,65.8
X$2397 1167 32 59 1457 BUF_X1
* cell instance $2401 r0 *1 20.9,65.8
X$2401 1384 1166 1500 32 59 1570 MUX2_X1
* cell instance $2402 r0 *1 22.23,65.8
X$2402 1069 32 59 1520 BUF_X1
* cell instance $2403 r0 *1 22.8,65.8
X$2403 1349 32 59 1516 BUF_X1
* cell instance $2405 r0 *1 24.89,65.8
X$2405 1455 1438 1519 32 59 1501 MUX2_X1
* cell instance $2409 r0 *1 29.83,65.8
X$2409 1404 1438 1522 32 59 1524 MUX2_X1
* cell instance $2411 r0 *1 31.92,65.8
X$2411 1404 32 59 1525 BUF_X1
* cell instance $2414 r0 *1 33.44,65.8
X$2414 1467 1438 1527 32 59 1526 MUX2_X1
* cell instance $2415 m0 *1 37.05,65.8
X$2415 1395 1346 1468 32 59 1456 MUX2_X1
* cell instance $2416 m0 *1 33.82,65.8
X$2416 32 1772 1468 1456 992 59 DFF_X1
* cell instance $2417 m0 *1 38.38,65.8
X$2417 1395 32 59 1469 BUF_X1
* cell instance $2423 r0 *1 37.43,65.8
X$2423 1450 1438 1470 32 59 1578 MUX2_X1
* cell instance $2425 r0 *1 38.95,65.8
X$2425 1351 32 59 1529 BUF_X1
* cell instance $2426 r0 *1 39.52,65.8
X$2426 1471 32 59 1530 BUF_X1
* cell instance $2428 r0 *1 40.28,65.8
X$2428 1471 1438 1472 32 59 1502 MUX2_X1
* cell instance $2429 m0 *1 41.04,65.8
X$2429 32 1725 1473 1492 992 59 DFF_X1
* cell instance $2434 r0 *1 42.18,65.8
X$2434 880 32 59 1648 BUF_X1
* cell instance $2436 r0 *1 44.27,65.8
X$2436 1541 1438 1474 32 59 1535 MUX2_X1
* cell instance $2437 m0 *1 47.88,65.8
X$2437 32 1751 1413 1453 992 59 DFF_X1
* cell instance $2438 m0 *1 44.65,65.8
X$2438 32 1742 1454 1491 992 59 DFF_X1
* cell instance $2440 r0 *1 45.6,65.8
X$2440 1159 32 59 1534 BUF_X1
* cell instance $2441 r0 *1 46.17,65.8
X$2441 1352 32 59 1533 BUF_X1
* cell instance $2444 r0 *1 47.69,65.8
X$2444 1347 32 59 1532 BUF_X1
* cell instance $2445 r0 *1 48.26,65.8
X$2445 1436 32 59 1531 BUF_X1
* cell instance $2448 r0 *1 50.54,65.8
X$2448 1445 1438 1542 32 59 1575 MUX2_X1
* cell instance $2450 m0 *1 51.49,65.8
X$2450 32 1770 1490 1433 992 59 DFF_X1
* cell instance $2452 m0 *1 56.43,65.8
X$2452 1478 1378 1434 32 59 1452 MUX2_X1
* cell instance $2454 r0 *1 51.87,65.8
X$2454 1399 32 59 1528 BUF_X1
* cell instance $2458 r0 *1 53.77,65.8
X$2458 32 1792 1523 1521 992 59 DFF_X1
* cell instance $2459 r0 *1 57,65.8
X$2459 1475 1378 1523 32 59 1521 MUX2_X1
* cell instance $2460 m0 *1 61.37,65.8
X$2460 1414 32 59 1451 BUF_X1
* cell instance $2461 m0 *1 58.14,65.8
X$2461 32 1728 1477 1476 992 59 DFF_X1
* cell instance $2463 m0 *1 62.13,65.8
X$2463 1515 32 59 1475 BUF_X1
* cell instance $2465 m0 *1 62.89,65.8
X$2465 1436 1438 1437 32 59 1518 MUX2_X1
* cell instance $2467 m0 *1 64.41,65.8
X$2467 1442 32 59 1450 BUF_X1
* cell instance $2469 m0 *1 65.17,65.8
X$2469 32 1766 1479 1486 992 59 DFF_X1
* cell instance $2470 m0 *1 68.4,65.8
X$2470 1481 32 59 1545 BUF_X1
* cell instance $2471 m0 *1 68.97,65.8
X$2471 1485 32 59 1445 BUF_X1
* cell instance $2472 m0 *1 69.54,65.8
X$2472 1441 32 59 1446 BUF_X1
* cell instance $2476 r0 *1 58.9,65.8
X$2476 1503 1378 1477 32 59 1476 MUX2_X1
* cell instance $2482 r0 *1 61.18,65.8
X$2482 1505 32 59 1503 BUF_X1
* cell instance $2485 r0 *1 62.7,65.8
X$2485 1478 32 59 1517 BUF_X1
* cell instance $2486 r0 *1 63.27,65.8
X$2486 32 1801 1437 1518 992 59 DFF_X1
* cell instance $2488 r0 *1 66.69,65.8
X$2488 1445 32 59 1511 BUF_X1
* cell instance $2489 r0 *1 67.26,65.8
X$2489 1480 1378 1479 32 59 1486 MUX2_X1
* cell instance $2490 r0 *1 68.59,65.8
X$2490 1507 32 59 1504 BUF_X1
* cell instance $2491 r0 *1 69.16,65.8
X$2491 1480 32 59 1508 BUF_X1
* cell instance $2492 r0 *1 69.73,65.8
X$2492 1483 32 59 1478 BUF_X1
* cell instance $2493 r0 *1 70.3,65.8
X$2493 1446 32 59 1506 BUF_X1
* cell instance $2495 m0 *1 70.49,65.8
X$2495 1484 32 59 1439 BUF_X1
* cell instance $2498 m0 *1 1.33,68.6
X$2498 1547 32 59 1462 BUF_X1
* cell instance $2500 m0 *1 1.9,68.6
X$2500 1493 32 59 1497 BUF_X1
* cell instance $2501 m0 *1 2.47,68.6
X$2501 1466 32 59 1495 BUF_X1
* cell instance $2503 m0 *1 3.23,68.6
X$2503 1460 32 59 1652 BUF_X1
* cell instance $2504 m0 *1 3.8,68.6
X$2504 1548 32 59 1549 BUF_X1
* cell instance $2505 m0 *1 4.37,68.6
X$2505 1463 32 59 1651 BUF_X1
* cell instance $2506 m0 *1 4.94,68.6
X$2506 1458 32 59 1499 BUF_X1
* cell instance $2507 m0 *1 5.51,68.6
X$2507 1427 32 59 1551 BUF_X1
* cell instance $2509 m0 *1 6.27,68.6
X$2509 1494 32 59 1510 BUF_X1
* cell instance $2510 m0 *1 6.84,68.6
X$2510 1409 32 59 1420 BUF_X1
* cell instance $2511 m0 *1 7.41,68.6
X$2511 1552 32 59 1539 BUF_X1
* cell instance $2512 m0 *1 7.98,68.6
X$2512 1536 32 59 1467 BUF_X1
* cell instance $2513 m0 *1 8.55,68.6
X$2513 1554 32 59 LOGIC1_X1
* cell instance $2515 m0 *1 9.12,68.6
X$2515 1553 32 59 LOGIC1_X1
* cell instance $2516 m0 *1 9.5,68.6
X$2516 1556 32 59 1557 BUF_X1
* cell instance $2517 m0 *1 10.07,68.6
X$2517 1556 32 59 LOGIC0_X1
* cell instance $2519 m0 *1 10.64,68.6
X$2519 1540 32 59 LOGIC1_X1
* cell instance $2520 m0 *1 11.02,68.6
X$2520 1128 32 59 1558 BUF_X1
* cell instance $2522 m0 *1 11.78,68.6
X$2522 1563 32 59 1562 BUF_X1
* cell instance $2524 m0 *1 12.54,68.6
X$2524 1563 32 59 LOGIC0_X1
* cell instance $2526 m0 *1 13.68,68.6
X$2526 1564 32 59 1561 BUF_X1
* cell instance $2527 m0 *1 14.25,68.6
X$2527 1564 32 59 LOGIC0_X1
* cell instance $2530 r0 *1 1.33,68.6
X$2530 1106 32 59 1582 BUF_X1
* cell instance $2531 r0 *1 1.9,68.6
X$2531 1579 32 59 1584 BUF_X1
* cell instance $2532 r0 *1 2.47,68.6
X$2532 1537 32 59 1538 BUF_X1
* cell instance $2533 r0 *1 3.04,68.6
X$2533 1538 32 59 1654 BUF_X1
* cell instance $2535 r0 *1 3.8,68.6
X$2535 1584 32 59 1586 BUF_X1
* cell instance $2537 r0 *1 4.56,68.6
X$2537 1425 32 59 1587 BUF_X1
* cell instance $2538 r0 *1 5.13,68.6
X$2538 1519 32 59 1653 BUF_X1
* cell instance $2539 r0 *1 5.7,68.6
X$2539 1498 32 59 1590 BUF_X1
* cell instance $2540 r0 *1 6.27,68.6
X$2540 1428 32 59 1591 BUF_X1
* cell instance $2543 r0 *1 7.41,68.6
X$2543 1553 32 59 1593 BUF_X1
* cell instance $2544 r0 *1 7.98,68.6
X$2544 1554 32 59 1596 BUF_X1
* cell instance $2545 r0 *1 8.55,68.6
X$2545 1597 32 59 1595 BUF_X1
* cell instance $2546 r0 *1 9.12,68.6
X$2546 1597 32 59 LOGIC0_X1
* cell instance $2547 r0 *1 9.5,68.6
X$2547 1598 32 59 LOGIC0_X1
* cell instance $2548 r0 *1 9.88,68.6
X$2548 1598 32 59 1601 BUF_X1
* cell instance $2549 r0 *1 10.45,68.6
X$2549 1540 32 59 1602 BUF_X1
* cell instance $2550 r0 *1 11.02,68.6
X$2550 1604 32 59 1605 BUF_X1
* cell instance $2551 r0 *1 11.59,68.6
X$2551 1604 32 59 LOGIC0_X1
* cell instance $2552 r0 *1 11.97,68.6
X$2552 1607 32 59 1609 BUF_X1
* cell instance $2553 r0 *1 12.54,68.6
X$2553 1607 32 59 LOGIC1_X1
* cell instance $2554 r0 *1 12.92,68.6
X$2554 1610 32 59 1606 BUF_X1
* cell instance $2555 r0 *1 13.49,68.6
X$2555 1610 32 59 LOGIC0_X1
* cell instance $2556 r0 *1 13.87,68.6
X$2556 1612 32 59 LOGIC1_X1
* cell instance $2557 r0 *1 14.25,68.6
X$2557 1612 32 59 1655 BUF_X1
* cell instance $2559 r0 *1 15.01,68.6
X$2559 1613 32 59 1614 BUF_X1
* cell instance $2561 m0 *1 15.01,68.6
X$2561 1613 32 59 LOGIC1_X1
* cell instance $2563 m0 *1 16.34,68.6
X$2563 1410 32 59 1656 BUF_X1
* cell instance $2564 m0 *1 15.77,68.6
X$2564 1330 32 59 1565 BUF_X1
* cell instance $2565 m0 *1 16.91,68.6
X$2565 32 1697 1514 1512 992 59 DFF_X1
* cell instance $2568 r0 *1 16.15,68.6
X$2568 1510 32 59 1657 BUF_X1
* cell instance $2570 r0 *1 16.91,68.6
X$2570 1388 32 59 1616 BUF_X1
* cell instance $2571 r0 *1 17.48,68.6
X$2571 1230 32 59 1617 BUF_X1
* cell instance $2572 r0 *1 18.05,68.6
X$2572 1514 32 59 1618 BUF_X1
* cell instance $2573 r0 *1 18.62,68.6
X$2573 1138 32 59 1619 BUF_X1
* cell instance $2574 r0 *1 19.19,68.6
X$2574 1169 32 59 1620 BUF_X1
* cell instance $2575 r0 *1 19.76,68.6
X$2575 1499 32 59 1658 BUF_X1
* cell instance $2576 r0 *1 20.33,68.6
X$2576 1569 32 59 1355 BUF_X1
* cell instance $2577 m0 *1 20.71,68.6
X$2577 1266 32 59 1573 BUF_X1
* cell instance $2579 m0 *1 21.28,68.6
X$2579 32 1716 1500 1570 992 59 DFF_X1
* cell instance $2580 m0 *1 24.51,68.6
X$2580 1012 32 59 1660 BUF_X1
* cell instance $2581 m0 *1 25.08,68.6
X$2581 32 1755 1519 1501 992 59 DFF_X1
* cell instance $2582 m0 *1 28.31,68.6
X$2582 1462 32 59 1577 BUF_X1
* cell instance $2584 m0 *1 29.07,68.6
X$2584 32 1748 1522 1524 992 59 DFF_X1
* cell instance $2585 m0 *1 32.3,68.6
X$2585 1661 32 59 1250 BUF_X1
* cell instance $2586 m0 *1 32.87,68.6
X$2586 32 1758 1527 1526 992 59 DFF_X1
* cell instance $2590 r0 *1 22.04,68.6
X$2590 1190 32 59 1624 BUF_X1
* cell instance $2592 r0 *1 22.99,68.6
X$2592 1623 32 59 1221 BUF_X1
* cell instance $2595 r0 *1 24.13,68.6
X$2595 1111 32 59 1626 BUF_X1
* cell instance $2596 r0 *1 24.7,68.6
X$2596 1572 32 59 1411 BUF_X1
* cell instance $2599 r0 *1 25.84,68.6
X$2599 667 32 59 1628 BUF_X1
* cell instance $2600 r0 *1 26.41,68.6
X$2600 1497 32 59 1630 BUF_X1
* cell instance $2601 r0 *1 26.98,68.6
X$2601 1384 32 59 1659 BUF_X1
* cell instance $2602 r0 *1 27.55,68.6
X$2602 1500 32 59 1633 BUF_X1
* cell instance $2605 r0 *1 28.69,68.6
X$2605 1068 32 59 1635 BUF_X1
* cell instance $2607 r0 *1 30.02,68.6
X$2607 1455 32 59 1662 BUF_X1
* cell instance $2609 r0 *1 31.35,68.6
X$2609 1522 32 59 1639 BUF_X1
* cell instance $2612 r0 *1 33.63,68.6
X$2612 1467 32 59 1642 BUF_X1
* cell instance $2613 r0 *1 34.2,68.6
X$2613 1468 32 59 1643 BUF_X1
* cell instance $2614 r0 *1 34.77,68.6
X$2614 1663 32 59 817 BUF_X1
* cell instance $2615 r0 *1 35.34,68.6
X$2615 1527 32 59 1644 BUF_X1
* cell instance $2617 m0 *1 39.71,68.6
X$2617 32 1720 1472 1502 992 59 DFF_X1
* cell instance $2618 m0 *1 36.48,68.6
X$2618 32 1719 1470 1578 992 59 DFF_X1
* cell instance $2621 m0 *1 43.89,68.6
X$2621 32 1743 1474 1535 992 59 DFF_X1
* cell instance $2624 m0 *1 48.07,68.6
X$2624 1412 32 59 1576 BUF_X1
* cell instance $2625 m0 *1 48.64,68.6
X$2625 32 1752 1542 1575 992 59 DFF_X1
* cell instance $2626 m0 *1 51.87,68.6
X$2626 1364 32 59 1574 BUF_X1
* cell instance $2627 m0 *1 52.44,68.6
X$2627 32 1771 1567 1568 992 59 DFF_X1
* cell instance $2628 m0 *1 55.67,68.6
X$2628 1475 32 59 1571 BUF_X1
* cell instance $2630 m0 *1 56.43,68.6
X$2630 1545 1378 1567 32 59 1568 MUX2_X1
* cell instance $2631 m0 *1 57.76,68.6
X$2631 1523 32 59 1566 BUF_X1
* cell instance $2633 r0 *1 36.67,68.6
X$2633 1155 32 59 1647 BUF_X1
* cell instance $2634 r0 *1 37.24,68.6
X$2634 1450 32 59 1646 BUF_X1
* cell instance $2636 r0 *1 39.33,68.6
X$2636 1470 32 59 1664 BUF_X1
* cell instance $2637 r0 *1 39.9,68.6
X$2637 1431 32 59 1650 BUF_X1
* cell instance $2640 r0 *1 41.04,68.6
X$2640 1472 32 59 1649 BUF_X1
* cell instance $2641 r0 *1 41.61,68.6
X$2641 1665 32 59 843 BUF_X1
* cell instance $2643 r0 *1 42.94,68.6
X$2643 1541 32 59 1645 BUF_X1
* cell instance $2645 r0 *1 43.7,68.6
X$2645 1473 32 59 1641 BUF_X1
* cell instance $2646 r0 *1 44.27,68.6
X$2646 1418 32 59 1640 BUF_X1
* cell instance $2647 r0 *1 44.84,68.6
X$2647 1474 32 59 1638 BUF_X1
* cell instance $2649 r0 *1 46.17,68.6
X$2649 1454 32 59 1637 BUF_X1
* cell instance $2650 r0 *1 46.74,68.6
X$2650 1376 32 59 1636 BUF_X1
* cell instance $2652 r0 *1 48.83,68.6
X$2652 1413 32 59 1634 BUF_X1
* cell instance $2654 r0 *1 49.78,68.6
X$2654 1377 32 59 1632 BUF_X1
* cell instance $2658 r0 *1 51.68,68.6
X$2658 1542 32 59 1631 BUF_X1
* cell instance $2660 r0 *1 52.63,68.6
X$2660 1490 32 59 1629 BUF_X1
* cell instance $2662 r0 *1 53.96,68.6
X$2662 1567 32 59 1627 BUF_X1
* cell instance $2664 r0 *1 56.05,68.6
X$2664 1370 32 59 1625 BUF_X1
* cell instance $2665 r0 *1 56.62,68.6
X$2665 1318 32 59 1622 BUF_X1
* cell instance $2666 r0 *1 57.19,68.6
X$2666 1434 32 59 1621 BUF_X1
* cell instance $2669 r0 *1 58.33,68.6
X$2669 1503 32 59 1580 BUF_X1
* cell instance $2671 m0 *1 58.71,68.6
X$2671 1550 32 59 1541 BUF_X1
* cell instance $2672 r0 *1 58.9,68.6
X$2672 1304 32 59 1669 BUF_X1
* cell instance $2673 r0 *1 59.47,68.6
X$2673 1340 32 59 1615 BUF_X1
* cell instance $2675 m0 *1 59.66,68.6
X$2675 1477 32 59 1543 BUF_X1
* cell instance $2676 r0 *1 60.04,68.6
X$2676 1390 32 59 1611 BUF_X1
* cell instance $2678 m0 *1 60.8,68.6
X$2678 1439 1378 1559 32 59 1560 MUX2_X1
* cell instance $2681 m0 *1 62.32,68.6
X$2681 32 1768 1559 1560 992 59 DFF_X1
* cell instance $2682 m0 *1 65.55,68.6
X$2682 1504 1378 1546 32 59 1555 MUX2_X1
* cell instance $2683 m0 *1 66.88,68.6
X$2683 32 1765 1546 1555 992 59 DFF_X1
* cell instance $2685 r0 *1 60.99,68.6
X$2685 1439 32 59 1608 BUF_X1
* cell instance $2686 r0 *1 61.56,68.6
X$2686 1382 32 59 1603 BUF_X1
* cell instance $2687 r0 *1 62.13,68.6
X$2687 1559 32 59 1599 BUF_X1
* cell instance $2689 r0 *1 62.89,68.6
X$2689 1544 32 59 1471 BUF_X1
* cell instance $2690 r0 *1 63.46,68.6
X$2690 1437 32 59 1667 BUF_X1
* cell instance $2693 r0 *1 64.6,68.6
X$2693 1504 32 59 1594 BUF_X1
* cell instance $2694 r0 *1 65.17,68.6
X$2694 1449 32 59 1589 BUF_X1
* cell instance $2695 r0 *1 65.74,68.6
X$2695 1545 32 59 1592 BUF_X1
* cell instance $2696 r0 *1 66.31,68.6
X$2696 1546 32 59 1588 BUF_X1
* cell instance $2697 r0 *1 66.88,68.6
X$2697 1389 32 59 1585 BUF_X1
* cell instance $2698 r0 *1 67.45,68.6
X$2698 1183 32 59 1668 BUF_X1
* cell instance $2699 r0 *1 68.02,68.6
X$2699 1479 32 59 1583 BUF_X1
* cell instance $2700 r0 *1 68.59,68.6
X$2700 32 992 59 1581 BUF_X8
* cell instance $2702 m0 *1 70.49,68.6
X$2702 1482 32 59 1480 BUF_X1
* cell instance $2710 m0 *1 1.9,40.6
X$2710 846 32 59 850 BUF_X1
* cell instance $2715 m0 *1 6.46,40.6
X$2715 894 847 1688 59 32 918 HA_X1
* cell instance $2716 m0 *1 8.36,40.6
X$2716 917 576 32 59 897 NAND2_X1
* cell instance $2717 m0 *1 8.93,40.6
X$2717 897 765 754 527 918 59 32 935 OAI221_X1
* cell instance $2718 m0 *1 10.07,40.6
X$2718 468 681 32 59 898 NOR2_X1
* cell instance $2720 m0 *1 12.16,40.6
X$2720 775 848 639 32 59 919 NAND3_X1
* cell instance $2722 m0 *1 13.11,40.6
X$2722 847 900 884 32 662 59 AOI21_X1
* cell instance $2724 m0 *1 14.06,40.6
X$2724 850 274 681 32 59 884 NAND3_X1
* cell instance $2726 m0 *1 15.01,40.6
X$2726 392 641 176 32 901 59 AOI21_X1
* cell instance $2728 m0 *1 15.96,40.6
X$2728 922 424 851 32 920 59 AOI21_X1
* cell instance $2729 m0 *1 16.72,40.6
X$2729 392 754 536 32 59 967 NAND3_X1
* cell instance $2730 m0 *1 17.48,40.6
X$2730 826 644 640 32 59 902 NOR3_X1
* cell instance $2731 m0 *1 18.24,40.6
X$2731 827 902 32 59 969 OR2_X1
* cell instance $2732 m0 *1 19,40.6
X$2732 847 624 886 32 903 59 AOI21_X1
* cell instance $2734 m0 *1 19.95,40.6
X$2734 274 644 628 901 32 59 982 OR4_X1
* cell instance $2735 m0 *1 21.09,40.6
X$2735 853 822 32 59 854 OR2_X1
* cell instance $2736 m0 *1 21.85,40.6
X$2736 854 274 220 59 888 32 OAI21_X1
* cell instance $2737 m0 *1 22.61,40.6
X$2737 890 855 925 32 904 59 AOI21_X1
* cell instance $2738 m0 *1 23.37,40.6
X$2738 848 857 32 59 925 NAND2_X1
* cell instance $2739 m0 *1 23.94,40.6
X$2739 716 220 855 32 927 59 AOI21_X1
* cell instance $2740 m0 *1 24.7,40.6
X$2740 526 32 59 525 CLKBUF_X3
* cell instance $2748 r0 *1 2.28,40.6
X$2748 32 966 666 933 894 59 DFF_X2
* cell instance $2752 r0 *1 5.89,40.6
X$2752 933 847 895 59 32 917 HA_X1
* cell instance $2753 r0 *1 7.79,40.6
X$2753 640 895 525 941 896 32 59 966 AOI221_X1
* cell instance $2754 r0 *1 8.93,40.6
X$2754 898 934 935 899 732 32 59 896 AOI221_X1
* cell instance $2756 r0 *1 10.26,40.6
X$2756 895 32 59 899 INV_X1
* cell instance $2757 r0 *1 10.64,40.6
X$2757 895 939 703 32 59 937 MUX2_X1
* cell instance $2758 r0 *1 11.97,40.6
X$2758 919 938 32 59 734 NAND2_X1
* cell instance $2759 r0 *1 12.54,40.6
X$2759 638 940 847 59 938 32 OAI21_X1
* cell instance $2760 r0 *1 13.3,40.6
X$2760 899 641 901 59 941 32 OAI21_X1
* cell instance $2761 r0 *1 14.06,40.6
X$2761 939 825 936 774 32 59 798 NOR4_X1
* cell instance $2764 r0 *1 15.58,40.6
X$2764 940 774 527 59 943 32 OAI21_X1
* cell instance $2767 r0 *1 17.48,40.6
X$2767 943 967 944 59 968 32 OAI21_X1
* cell instance $2768 r0 *1 18.24,40.6
X$2768 968 847 526 969 903 32 59 1003 AOI221_X1
* cell instance $2772 r0 *1 21.85,40.6
X$2772 946 847 526 856 904 32 59 945 AOI221_X1
* cell instance $2773 r0 *1 22.99,40.6
X$2773 970 848 716 32 926 59 AOI21_X1
* cell instance $2774 r0 *1 23.75,40.6
X$2774 906 905 32 59 970 NAND2_X1
* cell instance $2775 r0 *1 24.32,40.6
X$2775 906 905 32 59 947 NOR2_X1
* cell instance $2776 r0 *1 24.89,40.6
X$2776 947 926 927 32 59 948 NOR3_X1
* cell instance $2779 m0 *1 30.78,40.6
X$2779 931 930 861 32 893 59 AOI21_X1
* cell instance $2780 m0 *1 27.55,40.6
X$2780 32 892 930 928 777 59 DFF_X1
* cell instance $2781 m0 *1 31.54,40.6
X$2781 932 747 686 32 59 931 NOR3_X1
* cell instance $2785 r0 *1 28.5,40.6
X$2785 949 415 32 59 1008 NOR2_X1
* cell instance $2786 r0 *1 29.07,40.6
X$2786 777 32 59 INV_X8
* cell instance $2788 r0 *1 30.97,40.6
X$2788 747 32 59 861 BUF_X2
* cell instance $2789 r0 *1 31.73,40.6
X$2789 950 32 59 1005 INV_X1
* cell instance $2791 m0 *1 32.87,40.6
X$2791 32 831 860 859 777 59 DFF_X1
* cell instance $2793 m0 *1 36.1,40.6
X$2793 830 861 730 32 59 862 NOR3_X1
* cell instance $2797 m0 *1 43.89,40.6
X$2797 307 32 59 607 CLKBUF_X3
* cell instance $2798 m0 *1 44.84,40.6
X$2798 908 185 750 32 59 885 MUX2_X1
* cell instance $2801 r0 *1 33.25,40.6
X$2801 891 165 974 32 59 929 MUX2_X1
* cell instance $2803 r0 *1 34.96,40.6
X$2803 778 673 831 32 59 907 MUX2_X1
* cell instance $2805 r0 *1 36.48,40.6
X$2805 907 165 987 32 59 973 MUX2_X1
* cell instance $2806 r0 *1 37.81,40.6
X$2806 929 130 973 32 59 670 MUX2_X1
* cell instance $2809 r0 *1 39.71,40.6
X$2809 908 132 951 32 59 972 MUX2_X1
* cell instance $2810 r0 *1 41.04,40.6
X$2810 32 1854 952 971 607 59 DFF_X1
* cell instance $2811 r0 *1 44.27,40.6
X$2811 908 85 952 32 59 971 MUX2_X1
* cell instance $2813 r0 *1 45.79,40.6
X$2813 32 1832 864 924 607 59 DFF_X1
* cell instance $2815 m0 *1 46.55,40.6
X$2815 866 85 864 32 59 924 MUX2_X1
* cell instance $2817 m0 *1 48.83,40.6
X$2817 866 132 953 32 59 909 MUX2_X1
* cell instance $2818 m0 *1 50.16,40.6
X$2818 836 702 910 32 923 59 AOI21_X1
* cell instance $2819 m0 *1 50.92,40.6
X$2819 669 866 32 59 910 NAND2_X1
* cell instance $2820 m0 *1 51.49,40.6
X$2820 32 1777 867 921 649 59 DFF_X1
* cell instance $2822 m0 *1 54.91,40.6
X$2822 32 1694 911 868 649 59 DFF_X1
* cell instance $2826 m0 *1 60.61,40.6
X$2826 669 869 32 59 870 NAND2_X1
* cell instance $2827 m0 *1 61.18,40.6
X$2827 724 912 870 59 881 32 OAI21_X1
* cell instance $2828 m0 *1 61.94,40.6
X$2828 730 517 913 32 912 59 AOI21_X1
* cell instance $2829 m0 *1 62.7,40.6
X$2829 32 1750 915 873 649 59 DFF_X1
* cell instance $2830 m0 *1 65.93,40.6
X$2830 915 32 59 871 BUF_X2
* cell instance $2832 m0 *1 68.21,40.6
X$2832 874 32 59 869 BUF_X2
* cell instance $2833 m0 *1 68.97,40.6
X$2833 874 32 59 879 BUF_X1
* cell instance $2835 r0 *1 49.02,40.6
X$2835 32 1826 953 909 649 59 DFF_X1
* cell instance $2839 r0 *1 54.34,40.6
X$2839 867 308 911 32 59 954 MUX2_X1
* cell instance $2842 r0 *1 56.62,40.6
X$2842 955 913 59 625 32 XOR2_X2
* cell instance $2849 r0 *1 59.66,40.6
X$2849 871 132 957 32 59 956 MUX2_X1
* cell instance $2850 r0 *1 60.99,40.6
X$2850 307 32 59 649 CLKBUF_X3
* cell instance $2851 r0 *1 61.94,40.6
X$2851 649 32 59 1897 INV_X1
* cell instance $2854 r0 *1 63.46,40.6
X$2854 869 132 914 32 59 958 MUX2_X1
* cell instance $2857 r0 *1 66.69,40.6
X$2857 915 32 59 916 BUF_X1
* cell instance $2858 r0 *1 67.26,40.6
X$2858 32 1875 961 959 992 59 DFF_X1
* cell instance $2859 m0 *1 70.49,40.6
X$2859 877 32 59 872 BUF_X1
* cell instance $2860 m0 *1 69.92,40.6
X$2860 875 32 59 913 BUF_X1
* cell instance $2865 m0 *1 1.33,54.6
X$2865 1215 32 59 1266 BUF_X1
* cell instance $2867 m0 *1 1.9,54.6
X$2867 1228 32 59 1187 BUF_X1
* cell instance $2869 m0 *1 2.66,54.6
X$2869 32 1740 1216 1267 992 59 DFF_X1
* cell instance $2870 m0 *1 5.89,54.6
X$2870 1243 32 59 1256 BUF_X1
* cell instance $2874 m0 *1 13.49,54.6
X$2874 32 1260 1270 1259 1179 59 DFF_X1
* cell instance $2875 m0 *1 16.72,54.6
X$2875 1257 805 32 59 1259 NOR2_X1
* cell instance $2879 r0 *1 1.33,54.6
X$2879 1242 32 59 1359 BUF_X1
* cell instance $2880 r0 *1 1.9,54.6
X$2880 1312 32 59 1244 BUF_X1
* cell instance $2881 r0 *1 2.47,54.6
X$2881 1266 1166 1216 32 59 1267 MUX2_X1
* cell instance $2886 r0 *1 3.99,54.6
X$2886 1106 1287 1268 32 59 1288 MUX2_X1
* cell instance $2887 r0 *1 5.32,54.6
X$2887 1268 32 59 1283 BUF_X1
* cell instance $2891 r0 *1 11.21,54.6
X$2891 1302 32 59 1287 CLKBUF_X3
* cell instance $2896 r0 *1 15.01,54.6
X$2896 1289 1269 59 32 1290 XNOR2_X1
* cell instance $2897 r0 *1 16.15,54.6
X$2897 1269 1271 1270 32 59 1279 NOR3_X1
* cell instance $2898 r0 *1 16.91,54.6
X$2898 1270 1271 1315 32 59 1217 OR3_X2
* cell instance $2899 r0 *1 18.05,54.6
X$2899 1269 1217 1292 32 59 1306 NOR3_X1
* cell instance $2900 r0 *1 18.81,54.6
X$2900 32 1219 1292 1245 1179 59 DFF_X1
* cell instance $2901 m0 *1 19.38,54.6
X$2901 1220 1057 805 1219 1246 32 59 1245 AOI221_X1
* cell instance $2904 m0 *1 20.71,54.6
X$2904 1261 1217 1247 59 32 1269 OAI21_X2
* cell instance $2908 m0 *1 26.03,54.6
X$2908 223 1280 59 32 1281 AND2_X1
* cell instance $2910 m0 *1 27.55,54.6
X$2910 1273 1282 1684 59 32 1248 HA_X1
* cell instance $2912 m0 *1 30.21,54.6
X$2912 1249 1272 1191 59 1236 32 NOR3_X2
* cell instance $2916 r0 *1 23.75,54.6
X$2916 1256 32 59 1308 BUF_X1
* cell instance $2918 r0 *1 24.51,54.6
X$2918 32 1282 1272 1281 1022 59 DFF_X1
* cell instance $2919 r0 *1 27.74,54.6
X$2919 1248 32 59 1152 INV_X1
* cell instance $2921 r0 *1 28.31,54.6
X$2921 1273 1282 1293 59 32 1174 HA_X1
* cell instance $2924 r0 *1 30.78,54.6
X$2924 1249 1173 1294 32 59 1295 MUX2_X1
* cell instance $2925 m0 *1 32.11,54.6
X$2925 580 32 59 686 CLKBUF_X3
* cell instance $2931 m0 *1 46.17,54.6
X$2931 1264 279 866 32 59 1296 MUX2_X1
* cell instance $2934 m0 *1 49.21,54.6
X$2934 32 1785 1241 1263 1029 59 DFF_X1
* cell instance $2937 m0 *1 53.39,54.6
X$2937 32 1775 1251 1262 1048 59 DFF_X1
* cell instance $2938 m0 *1 56.62,54.6
X$2938 1251 279 869 32 59 1262 MUX2_X1
* cell instance $2941 m0 *1 59.66,54.6
X$2941 32 1778 1121 1199 1048 59 DFF_X1
* cell instance $2942 m0 *1 62.89,54.6
X$2942 32 1784 1222 1258 1048 59 DFF_X1
* cell instance $2943 m0 *1 66.12,54.6
X$2943 1255 32 59 1252 BUF_X1
* cell instance $2944 m0 *1 66.69,54.6
X$2944 32 1782 1225 1223 992 59 DFF_X1
* cell instance $2945 m0 *1 69.92,54.6
X$2945 1276 32 59 1185 BUF_X1
* cell instance $2946 m0 *1 70.49,54.6
X$2946 1277 32 59 1184 BUF_X1
* cell instance $2948 r0 *1 32.11,54.6
X$2948 223 1295 59 32 1339 AND2_X1
* cell instance $2953 r0 *1 45.6,54.6
X$2953 32 1809 1264 1296 1029 59 DFF_X1
* cell instance $2954 r0 *1 48.83,54.6
X$2954 32 1882 1304 923 1029 59 DFF_X1
* cell instance $2955 r0 *1 52.06,54.6
X$2955 1304 32 59 866 BUF_X2
* cell instance $2962 r0 *1 61.18,54.6
X$2962 1190 1287 1274 32 59 1303 MUX2_X1
* cell instance $2964 r0 *1 62.89,54.6
X$2964 32 1871 1274 1303 992 59 DFF_X1
* cell instance $2965 r0 *1 66.12,54.6
X$2965 1274 32 59 1226 BUF_X1
* cell instance $2966 r0 *1 66.69,54.6
X$2966 32 1886 1276 1275 992 59 DFF_X1
* cell instance $2967 r0 *1 69.92,54.6
X$2967 1300 32 59 1162 BUF_X1
* cell instance $2968 r0 *1 70.49,54.6
X$2968 1299 32 59 1277 BUF_X1
* cell instance $2970 m0 *1 2.28,51.8
X$2970 1177 32 59 1190 BUF_X1
* cell instance $2971 m0 *1 1.71,51.8
X$2971 1107 32 59 1144 BUF_X1
* cell instance $2974 m0 *1 3.8,51.8
X$2974 1012 1166 1228 32 59 1204 MUX2_X1
* cell instance $2980 r0 *1 1.33,51.8
X$2980 1216 32 59 1186 BUF_X1
* cell instance $2982 r0 *1 2.28,51.8
X$2982 1142 32 59 1230 BUF_X1
* cell instance $2983 r0 *1 2.85,51.8
X$2983 32 1867 1228 1204 992 59 DFF_X1
* cell instance $2987 r0 *1 6.08,51.8
X$2987 1256 1166 1188 32 59 1229 MUX2_X1
* cell instance $2988 m0 *1 6.84,51.8
X$2988 32 1738 1146 1206 1179 59 DFF_X1
* cell instance $2989 m0 *1 6.27,51.8
X$2989 1188 32 59 1176 BUF_X1
* cell instance $2990 m0 *1 10.07,51.8
X$2990 1189 936 848 1209 32 59 1207 AOI22_X1
* cell instance $2992 m0 *1 11.21,51.8
X$2992 1207 1208 32 59 1206 NOR2_X1
* cell instance $2995 r0 *1 7.41,51.8
X$2995 32 1790 1188 1229 992 59 DFF_X1
* cell instance $2996 r0 *1 10.64,51.8
X$2996 681 1089 32 59 1302 OR2_X1
* cell instance $2999 m0 *1 13.68,51.8
X$2999 730 223 32 59 1208 NAND2_X1
* cell instance $3003 m0 *1 15.58,51.8
X$3003 32 1699 1169 799 1179 59 DFF_X1
* cell instance $3006 m0 *1 19.57,51.8
X$3006 1095 1210 32 59 1218 OR2_X1
* cell instance $3007 m0 *1 20.33,51.8
X$3007 32 982 1179 1682 1111 59 DFF_X2
* cell instance $3010 m0 *1 26.22,51.8
X$3010 32 1780 1191 1172 1022 59 DFF_X1
* cell instance $3013 m0 *1 30.4,51.8
X$3013 1193 32 59 1192 INV_X1
* cell instance $3014 m0 *1 30.78,51.8
X$3014 1193 220 32 59 1238 NAND2_X1
* cell instance $3017 r0 *1 15.77,51.8
X$3017 1260 1231 32 59 1257 XOR2_X1
* cell instance $3019 r0 *1 17.1,51.8
X$3019 1139 848 1218 1271 32 59 1231 NOR4_X1
* cell instance $3021 r0 *1 18.43,51.8
X$3021 1139 1218 1217 1219 32 59 1220 NOR4_X1
* cell instance $3022 r0 *1 19.38,51.8
X$3022 1217 1218 468 1139 32 59 1246 OR4_X1
* cell instance $3023 r0 *1 20.52,51.8
X$3023 1218 977 32 59 1261 NOR2_X1
* cell instance $3024 r0 *1 21.09,51.8
X$3024 1217 1247 1095 1210 32 59 1232 OR4_X1
* cell instance $3025 r0 *1 22.23,51.8
X$3025 1232 59 942 32 BUF_X4
* cell instance $3029 r0 *1 24.89,51.8
X$3029 681 1221 59 32 1233 AND2_X1
* cell instance $3033 r0 *1 26.98,51.8
X$3033 1234 1233 220 59 1235 32 OAI21_X1
* cell instance $3034 r0 *1 27.74,51.8
X$3034 1152 1191 681 32 59 1234 NOR3_X1
* cell instance $3038 r0 *1 29.83,51.8
X$3038 1236 1192 686 220 32 59 1237 NAND4_X1
* cell instance $3039 r0 *1 30.78,51.8
X$3039 1238 1173 1237 32 59 1239 MUX2_X1
* cell instance $3040 m0 *1 31.92,51.8
X$3040 1173 1250 681 220 32 59 1240 NAND4_X1
* cell instance $3042 m0 *1 32.87,51.8
X$3042 1193 730 220 32 59 1194 NAND3_X1
* cell instance $3047 r0 *1 32.11,51.8
X$3047 1239 1240 1236 1194 1265 32 59 OAI211_X2
* cell instance $3048 r0 *1 33.82,51.8
X$3048 32 1865 1193 1265 1022 59 DFF_X1
* cell instance $3050 m0 *1 39.52,51.8
X$3050 32 1723 1181 1214 1029 59 DFF_X1
* cell instance $3053 m0 *1 44.27,51.8
X$3053 1195 279 908 32 59 1213 MUX2_X1
* cell instance $3055 m0 *1 46.36,51.8
X$3055 866 226 1196 32 59 1212 MUX2_X1
* cell instance $3059 r0 *1 42.37,51.8
X$3059 32 1847 1195 1213 1029 59 DFF_X1
* cell instance $3060 r0 *1 45.6,51.8
X$3060 32 1852 1196 1212 1029 59 DFF_X1
* cell instance $3062 m0 *1 48.07,51.8
X$3062 1196 308 1264 32 59 1030 MUX2_X1
* cell instance $3067 r0 *1 50.16,51.8
X$3067 1241 69 866 32 59 1263 MUX2_X1
* cell instance $3070 r0 *1 52.06,51.8
X$3070 32 1815 1197 1211 1048 59 DFF_X1
* cell instance $3071 m0 *1 53.01,51.8
X$3071 869 226 1197 32 59 1211 MUX2_X1
* cell instance $3074 m0 *1 54.53,51.8
X$3074 1197 308 1251 32 59 1119 MUX2_X1
* cell instance $3078 r0 *1 55.86,51.8
X$3078 32 1789 1120 1198 1048 59 DFF_X1
* cell instance $3080 m0 *1 56.24,51.8
X$3080 871 226 1120 32 59 1198 MUX2_X1
* cell instance $3088 r0 *1 60.04,51.8
X$3088 1121 69 871 32 59 1199 MUX2_X1
* cell instance $3089 m0 *1 63.46,51.8
X$3089 32 1710 1161 1205 1048 59 DFF_X1
* cell instance $3090 m0 *1 60.23,51.8
X$3090 32 1759 1160 1182 1048 59 DFF_X1
* cell instance $3094 r0 *1 63.65,51.8
X$3094 1222 69 869 32 59 1258 MUX2_X1
* cell instance $3096 r0 *1 66.5,51.8
X$3096 1227 1041 1225 32 59 1223 MUX2_X1
* cell instance $3098 m0 *1 67.07,51.8
X$3098 32 1700 1200 1203 992 59 DFF_X1
* cell instance $3099 m0 *1 70.49,51.8
X$3099 1227 32 59 1163 BUF_X1
* cell instance $3103 r0 *1 68.4,51.8
X$3103 1164 32 59 1224 BUF_X1
* cell instance $3104 r0 *1 68.97,51.8
X$3104 1225 32 59 1202 BUF_X1
* cell instance $3105 r0 *1 69.54,51.8
X$3105 1200 32 59 1165 BUF_X1
* cell instance $3106 r0 *1 70.11,51.8
X$3106 1201 32 59 1227 BUF_X1
* cell instance $3109 m0 *1 1.33,46.2
X$3109 1066 32 59 1088 BUF_X1
* cell instance $3111 m0 *1 1.9,46.2
X$3111 1009 32 59 1068 BUF_X1
* cell instance $3112 m0 *1 2.47,46.2
X$3112 1011 32 59 1069 BUF_X1
* cell instance $3117 r0 *1 1.9,46.2
X$3117 1010 32 59 1128 BUF_X1
* cell instance $3122 m0 *1 6.65,46.2
X$3122 1047 894 878 59 1070 32 NOR3_X2
* cell instance $3123 m0 *1 3.42,46.2
X$3123 32 965 1047 697 666 59 DFF_X1
* cell instance $3125 m0 *1 8.74,46.2
X$3125 878 1071 942 32 59 709 OR3_X2
* cell instance $3126 m0 *1 9.88,46.2
X$3126 942 1089 1013 32 59 979 OR3_X2
* cell instance $3129 r0 *1 5.7,46.2
X$3129 1070 1108 32 59 1139 NAND2_X2
* cell instance $3130 r0 *1 6.65,46.2
X$3130 1071 1070 59 32 1130 XNOR2_X1
* cell instance $3132 r0 *1 8.17,46.2
X$3132 756 1091 525 847 1130 32 59 1109 AOI221_X1
* cell instance $3135 r0 *1 9.88,46.2
X$3135 1088 1134 32 59 1110 NAND2_X1
* cell instance $3137 r0 *1 10.64,46.2
X$3137 1147 32 59 1134 INV_X1
* cell instance $3139 m0 *1 3.04,63
X$3139 1353 32 59 1357 BUF_X1
* cell instance $3141 m0 *1 3.61,63
X$3141 1341 32 59 1404 BUF_X1
* cell instance $3143 m0 *1 4.37,63
X$3143 1426 1326 1387 32 59 1397 MUX2_X1
* cell instance $3144 m0 *1 5.7,63
X$3144 32 1717 1387 1397 992 59 DFF_X1
* cell instance $3147 m0 *1 15.2,63
X$3147 32 1711 1388 1400 992 59 DFF_X1
* cell instance $3153 m0 *1 1.33,63
X$3153 1360 32 59 1375 BUF_X1
* cell instance $3155 m0 *1 1.9,63
X$3155 1359 32 59 1424 BUF_X1
* cell instance $3158 r0 *1 1.33,63
X$3158 1423 1326 1408 32 59 1443 MUX2_X1
* cell instance $3159 r0 *1 2.66,63
X$3159 32 1842 1408 1443 992 59 DFF_X1
* cell instance $3166 r0 *1 5.89,63
X$3166 1498 32 59 LOGIC0_X1
* cell instance $3167 r0 *1 6.27,63
X$3167 1428 32 59 LOGIC0_X1
* cell instance $3168 r0 *1 6.65,63
X$3168 1069 1326 1409 32 59 1447 MUX2_X1
* cell instance $3169 r0 *1 7.98,63
X$3169 32 1884 1409 1447 992 59 DFF_X1
* cell instance $3172 r0 *1 15.77,63
X$3172 1230 1166 1410 32 59 1430 MUX2_X1
* cell instance $3178 r0 *1 37.62,63
X$3178 32 1833 1431 1419 992 59 DFF_X1
* cell instance $3180 m0 *1 38.57,63
X$3180 1351 1346 1431 32 59 1419 MUX2_X1
* cell instance $3181 m0 *1 41.42,63
X$3181 32 1732 1418 1406 992 59 DFF_X1
* cell instance $3182 m0 *1 44.65,63
X$3182 1183 1346 1418 32 59 1406 MUX2_X1
* cell instance $3189 r0 *1 42.18,63
X$3189 880 1438 1473 32 59 1492 MUX2_X1
* cell instance $3192 r0 *1 45.41,63
X$3192 1159 1346 1454 32 59 1491 MUX2_X1
* cell instance $3194 r0 *1 48.26,63
X$3194 1412 1346 1413 32 59 1453 MUX2_X1
* cell instance $3195 m0 *1 48.83,63
X$3195 1363 32 59 1432 BUF_X1
* cell instance $3199 m0 *1 50.35,63
X$3199 1297 32 59 1417 BUF_X1
* cell instance $3203 m0 *1 53.39,63
X$3203 1347 1346 1389 32 59 1403 MUX2_X1
* cell instance $3204 m0 *1 54.72,63
X$3204 32 1715 1389 1403 992 59 DFF_X1
* cell instance $3206 m0 *1 58.14,63
X$3206 32 1706 1390 1401 992 59 DFF_X1
* cell instance $3208 m0 *1 61.56,63
X$3208 1414 1378 1382 32 59 1398 MUX2_X1
* cell instance $3211 m0 *1 63.84,63
X$3211 1379 32 59 1399 BUF_X1
* cell instance $3212 m0 *1 64.41,63
X$3212 1446 1438 1449 32 59 1448 MUX2_X1
* cell instance $3215 m0 *1 66.69,63
X$3215 1392 32 59 1412 BUF_X1
* cell instance $3216 m0 *1 67.26,63
X$3216 1369 32 59 1395 BUF_X1
* cell instance $3217 m0 *1 67.83,63
X$3217 32 1702 1393 1394 992 59 DFF_X1
* cell instance $3221 r0 *1 51.87,63
X$3221 1399 1346 1490 32 59 1433 MUX2_X1
* cell instance $3224 r0 *1 55.1,63
X$3224 32 1838 1434 1452 992 59 DFF_X1
* cell instance $3233 r0 *1 61.75,63
X$3233 1383 32 59 1435 BUF_X1
* cell instance $3234 r0 *1 62.32,63
X$3234 1416 32 59 1383 BUF_X1
* cell instance $3237 r0 *1 63.46,63
X$3237 32 1868 1449 1448 992 59 DFF_X1
* cell instance $3239 r0 *1 67.07,63
X$3239 1444 32 59 1436 BUF_X1
* cell instance $3240 r0 *1 67.64,63
X$3240 997 32 59 1487 BUF_X1
* cell instance $3241 r0 *1 68.21,63
X$3241 1415 32 59 1414 BUF_X1
* cell instance $3244 r0 *1 69.92,63
X$3244 1393 32 59 1440 BUF_X1
* cell instance $3245 r0 *1 70.49,63
X$3245 1391 32 59 960 BUF_X1
* cell instance $3247 r0 *1 42.18,1.4
X$3247 39 32 59 55 BUF_X2
* cell instance $3252 r0 *1 30.21,1.4
X$3252 42 61 38 32 59 50 MUX2_X1
* cell instance $3254 r0 *1 37.62,1.4
X$3254 41 32 59 42 CLKBUF_X2
* cell instance $3282 m0 *1 17.1,26.6
X$3282 395 362 577 32 59 485 MUX2_X1
* cell instance $3283 m0 *1 18.62,26.6
X$3283 362 524 331 59 495 32 OAI21_X1
* cell instance $3287 m0 *1 21.85,26.6
X$3287 396 363 330 32 59 604 OR3_X1
* cell instance $3291 m0 *1 25.27,26.6
X$3291 32 476 306 446 37 59 DFF_X2
* cell instance $3293 m0 *1 29.07,26.6
X$3293 515 497 364 496 32 59 478 NOR4_X1
* cell instance $3295 m0 *1 30.21,26.6
X$3295 478 421 32 59 532 NAND2_X1
* cell instance $3297 m0 *1 15.39,26.6
X$3297 514 32 59 462 BUF_X1
* cell instance $3298 m0 *1 12.16,26.6
X$3298 32 492 514 475 390 59 DFF_X1
* cell instance $3301 r0 *1 12.16,26.6
X$3301 462 418 32 59 553 NOR2_X1
* cell instance $3305 r0 *1 14.82,26.6
X$3305 468 492 462 59 522 32 OAI21_X1
* cell instance $3306 r0 *1 15.58,26.6
X$3306 536 468 462 32 493 59 AOI21_X1
* cell instance $3307 r0 *1 16.34,26.6
X$3307 493 494 32 59 442 NOR2_X1
* cell instance $3309 r0 *1 17.1,26.6
X$3309 418 395 32 59 523 NOR2_X1
* cell instance $3310 r0 *1 17.67,26.6
X$3310 32 1836 558 495 390 59 DFF_X1
* cell instance $3311 r0 *1 20.9,26.6
X$3311 558 32 59 577 BUF_X1
* cell instance $3313 r0 *1 21.66,26.6
X$3313 395 418 32 59 561 OR2_X1
* cell instance $3317 r0 *1 25.08,26.6
X$3317 57 32 59 496 BUF_X2
* cell instance $3318 r0 *1 25.84,26.6
X$3318 331 579 59 32 476 AND2_X1
* cell instance $3321 r0 *1 27.55,26.6
X$3321 421 496 515 59 32 530 AND3_X1
* cell instance $3323 r0 *1 28.88,26.6
X$3323 531 32 59 515 INV_X1
* cell instance $3324 r0 *1 29.26,26.6
X$3324 446 564 497 59 32 533 HA_X1
* cell instance $3325 r0 *1 31.16,26.6
X$3325 446 57 1689 59 32 534 HA_X1
* cell instance $3327 m0 *1 31.16,26.6
X$3327 446 32 59 364 INV_X4
* cell instance $3333 r0 *1 34.39,26.6
X$3333 396 536 278 32 59 NOR2_X4
* cell instance $3334 m0 *1 34.96,26.6
X$3334 32 1760 40 516 337 59 DFF_X1
* cell instance $3336 m0 *1 38.19,26.6
X$3336 40 32 59 499 BUF_X2
* cell instance $3338 r0 *1 36.1,26.6
X$3338 479 498 423 243 570 32 59 516 AOI221_X1
* cell instance $3340 r0 *1 37.62,26.6
X$3340 499 32 59 570 INV_X1
* cell instance $3341 r0 *1 38,26.6
X$3341 517 49 32 59 498 NAND2_X1
* cell instance $3343 m0 *1 39.52,26.6
X$3343 32 1761 500 480 337 59 DFF_X1
* cell instance $3345 m0 *1 42.75,26.6
X$3345 162 32 59 486 CLKBUF_X3
* cell instance $3349 r0 *1 39.52,26.6
X$3349 499 132 537 32 59 572 MUX2_X1
* cell instance $3350 r0 *1 40.85,26.6
X$3350 537 152 500 32 59 573 MUX2_X1
* cell instance $3351 r0 *1 42.18,26.6
X$3351 500 58 499 32 59 480 MUX2_X1
* cell instance $3354 r0 *1 44.46,26.6
X$3354 539 279 499 32 59 538 MUX2_X1
* cell instance $3356 m0 *1 44.84,26.6
X$3356 499 85 450 32 59 472 MUX2_X1
* cell instance $3359 m0 *1 46.74,26.6
X$3359 481 69 499 32 59 501 MUX2_X1
* cell instance $3363 m0 *1 49.02,26.6
X$3363 450 98 481 32 59 567 MUX2_X1
* cell instance $3367 r0 *1 46.93,26.6
X$3367 32 1835 481 501 337 59 DFF_X1
* cell instance $3368 r0 *1 50.16,26.6
X$3368 567 165 385 32 59 568 NOR3_X1
* cell instance $3371 r0 *1 52.63,26.6
X$3371 451 85 540 32 59 565 MUX2_X1
* cell instance $3373 r0 *1 54.72,26.6
X$3373 540 183 503 32 59 563 MUX2_X1
* cell instance $3374 m0 *1 56.05,26.6
X$3374 162 32 59 385 INV_X2
* cell instance $3375 m0 *1 55.29,26.6
X$3375 453 127 486 32 59 502 NOR3_X1
* cell instance $3378 r0 *1 56.05,26.6
X$3378 563 372 385 32 59 543 NOR3_X1
* cell instance $3379 r0 *1 56.81,26.6
X$3379 503 69 451 32 59 544 MUX2_X1
* cell instance $3380 m0 *1 57.95,26.6
X$3380 455 98 456 32 59 504 MUX2_X1
* cell instance $3386 r0 *1 58.33,26.6
X$3386 504 205 32 59 560 NOR2_X1
* cell instance $3391 r0 *1 59.09,26.6
X$3391 431 586 59 545 32 XOR2_X2
* cell instance $3393 r0 *1 60.99,26.6
X$3393 405 589 59 557 32 XOR2_X2
* cell instance $3394 m0 *1 62.13,26.6
X$3394 511 32 59 336 CLKBUF_X3
* cell instance $3396 m0 *1 63.08,26.6
X$3396 482 102 32 59 511 OR2_X1
* cell instance $3398 m0 *1 64.03,26.6
X$3398 482 59 162 32 BUF_X4
* cell instance $3401 r0 *1 63.08,26.6
X$3401 506 547 505 591 59 546 32 NOR4_X2
* cell instance $3403 r0 *1 65.17,26.6
X$3403 32 1883 507 509 318 59 DFF_X1
* cell instance $3404 m0 *1 67.07,26.6
X$3404 32 1721 508 549 318 59 DFF_X1
* cell instance $3405 m0 *1 65.74,26.6
X$3405 483 184 507 32 59 509 MUX2_X1
* cell instance $3406 m0 *1 70.3,26.6
X$3406 484 32 59 482 BUF_X1
* cell instance $3410 r0 *1 68.78,26.6
X$3410 483 185 508 32 59 549 MUX2_X1
* cell instance $3416 m0 *1 1.52,21
X$3416 407 32 59 389 BUF_X1
* cell instance $3420 m0 *1 6.08,21
X$3420 391 360 378 325 59 319 32 OR4_X2
* cell instance $3421 m0 *1 7.41,21
X$3421 32 391 360 378 325 408 59 NOR4_X4
* cell instance $3422 m0 *1 10.83,21
X$3422 307 32 59 139 CLKBUF_X3
* cell instance $3425 r0 *1 1.33,21
X$3425 32 407 1898 430 390 59 DFF_X1
* cell instance $3430 r0 *1 5.32,21
X$3430 32 457 390 459 391 59 DFF_X2
* cell instance $3431 r0 *1 8.93,21
X$3431 390 32 59 1678 INV_X4
* cell instance $3432 r0 *1 9.88,21
X$3432 307 32 59 390 CLKBUF_X3
* cell instance $3433 r0 *1 10.83,21
X$3433 32 393 304 416 390 59 DFF_X1
* cell instance $3434 m0 *1 12.35,21
X$3434 393 321 328 59 32 271 HA_X1
* cell instance $3439 m0 *1 18.62,21
X$3439 331 436 59 32 410 AND2_X1
* cell instance $3440 m0 *1 15.39,21
X$3440 32 1745 394 410 390 59 DFF_X1
* cell instance $3444 r0 *1 18.24,21
X$3444 394 32 59 418 BUF_X1
* cell instance $3447 r0 *1 19.38,21
X$3447 331 437 59 32 467 AND2_X1
* cell instance $3449 m0 *1 19.76,21
X$3449 330 362 361 32 59 329 MUX2_X1
* cell instance $3450 r0 *1 20.14,21
X$3450 361 362 395 32 59 437 MUX2_X1
* cell instance $3451 m0 *1 21.66,21
X$3451 363 362 330 32 59 380 MUX2_X1
* cell instance $3453 m0 *1 22.99,21
X$3453 331 411 59 32 397 AND2_X1
* cell instance $3456 r0 *1 21.47,21
X$3456 396 362 363 32 59 411 MUX2_X1
* cell instance $3458 r0 *1 22.99,21
X$3458 32 1817 419 397 306 59 DFF_X1
* cell instance $3460 m0 *1 25.65,21
X$3460 333 32 59 363 CLKBUF_X3
* cell instance $3462 r0 *1 26.98,21
X$3462 32 421 37 422 68 59 NOR3_X4
* cell instance $3463 m0 *1 26.98,21
X$3463 420 398 365 32 77 59 NAND3_X4
* cell instance $3464 m0 *1 29.45,21
X$3464 364 398 365 32 155 59 NAND3_X4
* cell instance $3467 m0 *1 32.87,21
X$3467 32 1714 334 384 306 59 DFF_X1
* cell instance $3468 m0 *1 36.1,21
X$3468 97 61 400 32 59 399 MUX2_X1
* cell instance $3469 m0 *1 37.43,21
X$3469 334 308 400 32 59 388 MUX2_X1
* cell instance $3471 r0 *1 29.64,21
X$3471 364 421 365 32 78 59 NAND3_X4
* cell instance $3474 r0 *1 32.68,21
X$3474 32 398 364 422 246 59 NOR3_X4
* cell instance $3477 r0 *1 36.29,21
X$3477 32 1885 400 399 337 59 DFF_X1
* cell instance $3478 m0 *1 39.33,21
X$3478 388 127 486 32 59 367 NOR3_X1
* cell instance $3481 m0 *1 41.61,21
X$3481 412 246 339 32 59 413 MUX2_X1
* cell instance $3486 r0 *1 40.47,21
X$3486 32 1859 412 413 337 59 DFF_X1
* cell instance $3488 m0 *1 44.27,21
X$3488 339 77 368 32 59 401 MUX2_X1
* cell instance $3492 r0 *1 44.46,21
X$3492 32 1803 368 401 337 59 DFF_X1
* cell instance $3493 m0 *1 46.93,21
X$3493 369 68 339 32 59 402 MUX2_X1
* cell instance $3495 m0 *1 48.26,21
X$3495 368 101 369 32 59 386 MUX2_X1
* cell instance $3498 r0 *1 47.69,21
X$3498 32 1877 369 402 337 59 DFF_X1
* cell instance $3499 r0 *1 50.92,21
X$3499 403 371 434 370 59 431 32 NOR4_X2
* cell instance $3501 m0 *1 51.49,21
X$3501 386 372 385 32 59 403 NOR3_X1
* cell instance $3505 r0 *1 53.39,21
X$3505 32 1841 469 432 318 59 DFF_X1
* cell instance $3508 r0 *1 57.19,21
X$3508 385 59 130 32 BUF_X4
* cell instance $3509 m0 *1 57.38,21
X$3509 374 98 373 32 59 382 MUX2_X1
* cell instance $3511 m0 *1 58.71,21
X$3511 282 132 374 32 59 404 MUX2_X1
* cell instance $3513 m0 *1 60.23,21
X$3513 382 205 32 59 381 NOR2_X1
* cell instance $3515 m0 *1 60.99,21
X$3515 409 379 375 381 59 405 32 NOR4_X2
* cell instance $3517 m0 *1 62.89,21
X$3517 342 372 385 32 59 409 NOR3_X1
* cell instance $3519 m0 *1 63.84,21
X$3519 32 1729 376 341 318 59 DFF_X1
* cell instance $3520 m0 *1 67.07,21
X$3520 347 69 282 32 59 377 MUX2_X1
* cell instance $3525 r0 *1 58.71,21
X$3525 32 1793 374 404 318 59 DFF_X1
* cell instance $3530 r0 *1 62.13,21
X$3530 32 1870 427 406 318 59 DFF_X1
.ENDS ddr_controller

* cell AND2_X2
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X2 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 3 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND2_X2

* cell NOR4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 11 1 12 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 10 2 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 6 3 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 9 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 13 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 8 1 13 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 4 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 6 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 7 1 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 6 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 7 3 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR4_X2

* cell AND4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X1 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 5 4 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 10 1 5 7 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 11 2 10 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 9 3 11 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 7 4 9 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 5 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND4_X1

* cell OR4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OR4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 ZN
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 11 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 7 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 5 1 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 8 2 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 5 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 8 4 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 7 5 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR4_X2

* cell OR3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 11 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.585,0.995 PMOS_VTL
M$3 4 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.775,0.995 PMOS_VTL
M$4 9 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.965,0.995 PMOS_VTL
M$5 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.155,0.995 PMOS_VTL
M$6 6 1 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.345,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.177975P AD=0.200025P PS=3.085U
+ PD=3.785U
* device instance $11 r0 *1 0.205,0.2975 NMOS_VTL
M$11 4 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.395,0.2975 NMOS_VTL
M$12 5 2 4 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.585,0.2975 NMOS_VTL
M$13 4 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.345,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1172375P AD=0.1317625P PS=2.225U
+ PD=2.71U
.ENDS OR3_X4

* cell NAND4_X4
* pin PWELL,VSS
* pin A3
* pin A4
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X4 1 2 3 7 8 9 10
* net 1 PWELL,VSS
* net 2 A3
* net 3 A4
* net 7 A1
* net 8 A2
* net 9 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 10 7 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 10 8 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.22365P PS=3.08U PD=3.23U
* device instance $9 r0 *1 1.885,0.995 PMOS_VTL
M$9 10 2 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.22365P AD=0.1764P PS=3.23U PD=3.08U
* device instance $13 r0 *1 2.645,0.995 PMOS_VTL
M$13 10 3 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.885,0.2975 NMOS_VTL
M$17 5 2 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.645,0.2975 NMOS_VTL
M$21 1 3 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.215,0.2975 NMOS_VTL
M$25 9 7 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.975,0.2975 NMOS_VTL
M$29 5 8 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND4_X4

* cell OAI211_X4
* pin PWELL,VSS
* pin A
* pin B
* pin C2
* pin ZN
* pin C1
* pin NWELL,VDD
.SUBCKT OAI211_X4 1 3 4 5 6 7 12
* net 1 PWELL,VSS
* net 3 A
* net 4 B
* net 5 C2
* net 6 ZN
* net 7 C1
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 3 12 12 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 12 4 6 12 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 15 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 12 5 15 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 14 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 14 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 12 5 16 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 8 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 1 4 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.55,0.2975 NMOS_VTL
M$19 10 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.74,0.2975 NMOS_VTL
M$20 2 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.93,0.2975 NMOS_VTL
M$21 9 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.12,0.2975 NMOS_VTL
M$22 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.31,0.2975 NMOS_VTL
M$23 11 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.5,0.2975 NMOS_VTL
M$24 2 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI211_X4

* cell AND3_X1
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 4 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 8 1 4 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 9 2 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 6 3 9 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND3_X1

* cell OAI21_X4
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X4 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 11 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 7 3 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 10 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 5 2 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 9 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 7 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 8 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 5 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 6 1 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 7 2 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 3 7 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI21_X4

* cell NAND3_X4
* pin A2
* pin A1
* pin A3
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND3_X4 1 2 3 4 5 6
* net 1 A2
* net 2 A1
* net 3 A3
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 3 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 6 1 5 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.21,0.2975 NMOS_VTL
M$13 13 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.4,0.2975 NMOS_VTL
M$14 12 1 13 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.59,0.2975 NMOS_VTL
M$15 5 2 12 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.78,0.2975 NMOS_VTL
M$16 10 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.97,0.2975 NMOS_VTL
M$17 8 1 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.16,0.2975 NMOS_VTL
M$18 4 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.35,0.2975 NMOS_VTL
M$19 9 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.54,0.2975 NMOS_VTL
M$20 7 1 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.73,0.2975 NMOS_VTL
M$21 5 2 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.92,0.2975 NMOS_VTL
M$22 14 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.11,0.2975 NMOS_VTL
M$23 11 1 14 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.3,0.2975 NMOS_VTL
M$24 4 3 11 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X4

* cell OAI33_X1
* pin B3
* pin B2
* pin B1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OAI33_X1 1 2 3 4 5 6 7 8 10
* net 1 B3
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 14 1 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 13 2 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 10 3 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 12 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 11 5 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 8 6 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.185,0.2975 NMOS_VTL
M$7 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.375,0.2975 NMOS_VTL
M$8 7 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.565,0.2975 NMOS_VTL
M$9 9 3 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.755,0.2975 NMOS_VTL
M$10 10 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.945,0.2975 NMOS_VTL
M$11 9 5 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.135,0.2975 NMOS_VTL
M$12 10 6 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI33_X1

* cell NOR3_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR3_X4 1 2 3 4 5 8
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 ZN
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 2 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 6 3 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 6 4 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 5 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 5 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 5 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS NOR3_X4

* cell AOI21_X2
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X2 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 9 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X2

* cell DFF_X2
* pin PWELL,VSS
* pin D
* pin CK
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFF_X2 1 6 8 10 11 16
* net 1 PWELL,VSS
* net 6 D
* net 8 CK
* net 10 QN
* net 11 Q
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.855,0.995 PMOS_VTL
M$1 10 9 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.235,0.995 PMOS_VTL
M$3 11 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.2,0.9275 PMOS_VTL
M$5 16 7 3 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $6 r0 *1 0.39,1.04 PMOS_VTL
M$6 17 4 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $7 r0 *1 0.58,1.04 PMOS_VTL
M$7 17 7 5 16 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $8 r0 *1 0.77,0.975 PMOS_VTL
M$8 18 3 5 16 PMOS_VTL L=0.05U W=0.42U AS=0.01785P AD=0.0294P PS=0.56U PD=0.56U
* device instance $9 r0 *1 0.96,0.975 PMOS_VTL
M$9 16 6 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 1.15,1.0275 PMOS_VTL
M$10 4 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $11 r0 *1 2.135,0.915 PMOS_VTL
M$11 20 3 9 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $12 r0 *1 2.325,0.915 PMOS_VTL
M$12 20 2 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $13 r0 *1 1.565,1.0275 PMOS_VTL
M$13 16 8 7 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $14 r0 *1 1.755,1.0275 PMOS_VTL
M$14 19 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $15 r0 *1 1.945,1.0275 PMOS_VTL
M$15 9 7 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.515,0.995 PMOS_VTL
M$16 2 9 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 2.855,0.2975 NMOS_VTL
M$17 10 9 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $19 r0 *1 3.235,0.2975 NMOS_VTL
M$19 11 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $21 r0 *1 0.39,0.31 NMOS_VTL
M$21 12 4 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $22 r0 *1 0.58,0.31 NMOS_VTL
M$22 12 3 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $23 r0 *1 1.15,0.25 NMOS_VTL
M$23 4 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $24 r0 *1 0.77,0.2825 NMOS_VTL
M$24 13 7 5 1 NMOS_VTL L=0.05U W=0.275U AS=0.012775P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $25 r0 *1 0.96,0.2825 NMOS_VTL
M$25 1 6 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $26 r0 *1 0.2,0.37 NMOS_VTL
M$26 1 7 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $27 r0 *1 1.565,0.35 NMOS_VTL
M$27 1 8 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $28 r0 *1 1.755,0.35 NMOS_VTL
M$28 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $29 r0 *1 1.945,0.35 NMOS_VTL
M$29 9 3 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $30 r0 *1 2.135,0.41 NMOS_VTL
M$30 15 7 9 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $31 r0 *1 2.325,0.41 NMOS_VTL
M$31 15 2 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $32 r0 *1 2.515,0.2975 NMOS_VTL
M$32 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFF_X2

* cell NAND2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 4 1 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 5 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND2_X4

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell INV_X8
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT INV_X8 1 2 3
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.37485P PS=6.86U PD=6.86U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 4 1 2 2 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.246925P PS=4.925U
+ PD=4.925U
.ENDS INV_X8

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X2 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell OAI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI221_X1 1 2 3 4 5 7 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 12 1 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 12 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 5 11 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 8 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 6 2 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 10 3 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 9 4 10 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 10 5 9 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI221_X1

* cell NOR2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 4 1 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.21,0.2975 NMOS_VTL
M$5 5 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $6 r0 *1 0.4,0.2975 NMOS_VTL
M$6 3 2 5 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR2_X2

* cell OR3_X2
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 5 1 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 4 2 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 5 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR3_X2

* cell LOGIC1_X1
* pin Z
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT LOGIC1_X1 2 3 4
* net 2 Z
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.185,1.2125 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.135U AS=0.014175P AD=0.014175P PS=0.48U
+ PD=0.48U
* device instance $2 r0 *1 0.185,0.21 NMOS_VTL
M$2 3 1 1 3 NMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
.ENDS LOGIC1_X1

* cell LOGIC0_X1
* pin Z
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT LOGIC0_X1 1 3 4
* net 1 Z
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.185,1.19 PMOS_VTL
M$1 4 2 2 4 PMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
* device instance $2 r0 *1 0.185,0.21 NMOS_VTL
M$2 3 2 1 3 NMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
.ENDS LOGIC0_X1

* cell HA_X1
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin CO
.SUBCKT HA_X1 1 2 4 5 6 9
* net 1 A
* net 2 B
* net 4 S
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 9 CO
* device instance $1 r0 *1 0.785,1.0275 PMOS_VTL
M$1 10 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $2 r0 *1 0.975,1.0275 PMOS_VTL
M$2 7 1 10 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $3 r0 *1 0.21,0.995 PMOS_VTL
M$3 4 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $4 r0 *1 0.4,0.995 PMOS_VTL
M$4 3 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.59,0.995 PMOS_VTL
M$5 5 7 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0338625P PS=0.77U PD=0.775U
* device instance $6 r0 *1 1.345,1.0275 PMOS_VTL
M$6 8 1 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $7 r0 *1 1.535,1.0275 PMOS_VTL
M$7 8 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $8 r0 *1 1.725,0.995 PMOS_VTL
M$8 9 8 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.345,0.195 NMOS_VTL
M$9 12 1 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $10 r0 *1 1.535,0.195 NMOS_VTL
M$10 6 2 12 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $11 r0 *1 1.725,0.2975 NMOS_VTL
M$11 9 8 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $12 r0 *1 0.785,0.195 NMOS_VTL
M$12 7 2 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.0224P AD=0.0147P PS=0.56U PD=0.35U
* device instance $13 r0 *1 0.975,0.195 NMOS_VTL
M$13 6 1 7 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $14 r0 *1 0.21,0.2975 NMOS_VTL
M$14 11 2 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $15 r0 *1 0.4,0.2975 NMOS_VTL
M$15 4 1 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.59,0.2975 NMOS_VTL
M$16 6 7 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0224P PS=0.555U PD=0.56U
.ENDS HA_X1

* cell NOR3_X2
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 10 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 9 2 10 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 3 9 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 8 3 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 4 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 5 1 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 6 2 5 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 5 3 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR3_X2

* cell OAI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X1 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 9 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 7 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 5 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 8 3 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 8 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI22_X1

* cell XOR2_X1
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT XOR2_X1 1 3 4 5 6
* net 1 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 8 1 2 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 7 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 6 1 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 7 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 2 1 4 4 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 4 3 2 4 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.555,0.2975 NMOS_VTL
M$8 6 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.745,0.2975 NMOS_VTL
M$9 9 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.935,0.2975 NMOS_VTL
M$10 4 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XOR2_X1

* cell XNOR2_X1
* pin A
* pin B
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT XNOR2_X1 1 2 4 5 7
* net 1 A
* net 2 B
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.18,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.37,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 7 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 8 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 4 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.18,0.195 NMOS_VTL
M$6 9 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.37,0.195 NMOS_VTL
M$7 5 2 9 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.565,0.2975 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.755,0.2975 NMOS_VTL
M$9 7 1 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.945,0.2975 NMOS_VTL
M$10 6 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X1

* cell OAI211_X2
* pin A
* pin B
* pin C2
* pin C1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI211_X2 1 2 3 4 6 7 8
* net 1 A
* net 2 B
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 6 1 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.111825P AD=0.0882P PS=2.245U PD=1.54U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 8 2 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.089775P PS=1.54U PD=1.545U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 9 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 8 3 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.205,0.2975 NMOS_VTL
M$9 12 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.395,0.2975 NMOS_VTL
M$10 7 2 12 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.585,0.2975 NMOS_VTL
M$11 11 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 5 1 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.02905P PS=0.56U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 6 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 5 4 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI211_X2

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell NOR4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 3 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 7 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 5 4 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR4_X1

* cell OR4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR4_X1 1 2 3 4 5 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 10 1 6 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 2 10 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 11 3 9 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 6 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 6 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 5 2 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 5 4 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 6 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR4_X1

* cell OAI221_X2
* pin C2
* pin C1
* pin B1
* pin B2
* pin A
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI221_X2 1 2 3 4 5 7 9 10
* net 1 C2
* net 2 C1
* net 3 B1
* net 4 B2
* net 5 A
* net 7 ZN
* net 9 PWELL,VSS
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 1 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 2 12 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 11 2 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 10 1 11 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 5 10 10 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 14 3 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 10 4 14 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 13 4 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.73,0.995 PMOS_VTL
M$9 7 3 13 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 0.21,0.2975 NMOS_VTL
M$11 7 1 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.4,0.2975 NMOS_VTL
M$12 6 2 7 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.97,0.2975 NMOS_VTL
M$15 8 5 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $16 r0 *1 1.16,0.2975 NMOS_VTL
M$16 9 3 8 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.35,0.2975 NMOS_VTL
M$17 8 4 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI221_X2

* cell XOR2_X2
* pin B
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT XOR2_X2 1 2 4 5 7
* net 1 B
* net 2 A
* net 4 NWELL,VDD
* net 5 Z
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.2,0.995 PMOS_VTL
M$1 8 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.39,0.995 PMOS_VTL
M$2 4 1 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.58,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.77,0.995 PMOS_VTL
M$4 5 2 6 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.96,0.995 PMOS_VTL
M$5 6 1 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.2,0.2975 NMOS_VTL
M$9 3 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.39,0.2975 NMOS_VTL
M$10 7 1 3 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.58,0.2975 NMOS_VTL
M$11 5 3 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $12 r0 *1 0.77,0.2975 NMOS_VTL
M$12 10 2 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.96,0.2975 NMOS_VTL
M$13 7 1 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.15,0.2975 NMOS_VTL
M$14 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.34,0.2975 NMOS_VTL
M$15 5 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
.ENDS XOR2_X2

* cell CLKBUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.17,0.1875 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $5 r0 *1 0.36,0.1875 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.39U AS=0.0273P AD=0.034125P PS=0.67U PD=0.935U
.ENDS CLKBUF_X2

* cell NAND4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 4 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 7 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 13 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 12 1 13 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 11 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 6 3 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 8 3 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 9 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X2

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X4 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell BUF_X8
* pin PWELL,VSS
* pin Z
* pin NWELL,VDD
* pin A
.SUBCKT BUF_X8 1 3 4 5
* net 1 PWELL,VSS
* net 3 Z
* net 4 NWELL,VDD
* net 5 A
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 5 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 3 2 4 4 PMOS_VTL L=0.05U W=5.04U AS=0.3528P AD=0.37485P PS=6.16U PD=6.86U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.2324P AD=0.246925P PS=4.44U PD=4.925U
.ENDS BUF_X8

* cell DFF_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 8 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 2.125,0.345 NMOS_VTL
M$17 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $18 r0 *1 2.32,0.345 NMOS_VTL
M$18 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $19 r0 *1 1.555,0.36 NMOS_VTL
M$19 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $20 r0 *1 1.745,0.36 NMOS_VTL
M$20 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $21 r0 *1 1.935,0.36 NMOS_VTL
M$21 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $22 r0 *1 2.51,0.36 NMOS_VTL
M$22 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
* device instance $23 r0 *1 0.185,0.285 NMOS_VTL
M$23 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $24 r0 *1 0.375,0.345 NMOS_VTL
M$24 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 0.565,0.345 NMOS_VTL
M$25 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $26 r0 *1 1.14,0.285 NMOS_VTL
M$26 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.76,0.3175 NMOS_VTL
M$27 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $28 r0 *1 0.95,0.3175 NMOS_VTL
M$28 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
.ENDS DFF_X1

* cell AOI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X1 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 8 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 8 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 8 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 9 3 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X1

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell AOI221_X2
* pin B1
* pin B2
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI221_X2 1 2 3 4 5 6 8 9
* net 1 B1
* net 2 B2
* net 3 A
* net 4 C2
* net 5 C1
* net 6 ZN
* net 8 NWELL,VDD
* net 9 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 3 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.09135P PS=2.24U PD=1.55U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 1 7 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.32,0.995 PMOS_VTL
M$7 6 4 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.09135P AD=0.11025P PS=1.55U PD=2.24U
* device instance $8 r0 *1 1.51,0.995 PMOS_VTL
M$8 10 5 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 6 3 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.060175P PS=1.595U
+ PD=1.12U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 14 1 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 9 2 14 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 13 2 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 6 1 13 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.32,0.2975 NMOS_VTL
M$17 12 4 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.031125P AD=0.02905P PS=0.565U
+ PD=0.555U
* device instance $18 r0 *1 1.51,0.2975 NMOS_VTL
M$18 6 5 12 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.7,0.2975 NMOS_VTL
M$19 11 5 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.89,0.2975 NMOS_VTL
M$20 9 4 11 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X2

* cell XNOR2_X2
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT XNOR2_X2 2 3 4 5 7
* net 2 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 1.135,0.995 PMOS_VTL
M$1 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 1.325,0.995 PMOS_VTL
M$2 9 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 1.515,0.995 PMOS_VTL
M$3 5 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 1.705,0.995 PMOS_VTL
M$4 8 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.18,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $7 r0 *1 0.56,0.995 PMOS_VTL
M$7 1 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 0.75,0.995 PMOS_VTL
M$8 5 2 1 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.135,0.2975 NMOS_VTL
M$9 6 2 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $11 r0 *1 1.515,0.2975 NMOS_VTL
M$11 6 3 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $13 r0 *1 0.18,0.2975 NMOS_VTL
M$13 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $15 r0 *1 0.56,0.2975 NMOS_VTL
M$15 10 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.75,0.2975 NMOS_VTL
M$16 1 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X2

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell NAND3_X2
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 10 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 9 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 1 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X2

* cell NOR4_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin A4
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR4_X4 1 2 3 4 5 6 10
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 1.92,0.995 PMOS_VTL
M$1 8 4 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 2.68,0.995 PMOS_VTL
M$5 10 5 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.995 PMOS_VTL
M$9 6 2 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $13 r0 *1 0.93,0.995 PMOS_VTL
M$13 8 3 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.92,0.2975 NMOS_VTL
M$17 1 4 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.68,0.2975 NMOS_VTL
M$21 1 5 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.17,0.2975 NMOS_VTL
M$25 6 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.93,0.2975 NMOS_VTL
M$29 6 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NOR4_X4

* cell AOI21_X4
* pin PWELL,VSS
* pin ZN
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
.SUBCKT AOI21_X4 1 2 3 4 5 11
* net 1 PWELL,VSS
* net 2 ZN
* net 3 A
* net 4 B2
* net 5 B1
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 11 3 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 2 4 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 10 5 2 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 2 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 8 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 2 5 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 9 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 6 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.895,0.2975 NMOS_VTL
M$22 2 5 6 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.085,0.2975 NMOS_VTL
M$23 7 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.275,0.2975 NMOS_VTL
M$24 1 4 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X4

* cell OAI21_X2
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X2 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 3 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 5 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 6 1 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 7 2 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 4 3 7 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI21_X2

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell NOR2_X4
* pin A2
* pin A1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT NOR2_X4 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 ZN
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 9 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 3 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 8 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 1 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 3 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 6 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 1 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 3 1 4 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 4 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS NOR2_X4

* cell OR3_X1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 8 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 5 1 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 4 2 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 5 3 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR3_X1

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4
