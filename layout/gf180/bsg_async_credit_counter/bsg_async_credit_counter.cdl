* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT bsg_async_credit_counter r_clk_i r_credits_avail_o
+ r_dec_credit_i r_infinite_credits_i r_reset_i w_clk_i w_inc_token_i
+ w_reset_i
X_30_ net6 _08_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_31_ bapg.w_ptr_n\[0\] bapg.w_ptr_n\[1\] _09_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_32_ bapg.w_ptr_gray_r\[0\] _09_ net5 _10_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_33_ _08_ _10_ _00_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_34_ bapg.w_ptr_binary_r_o\[2\] bapg.w_ptr_n\[1\] _28_ _11_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor3_2
X_35_ bapg.w_ptr_gray_r\[1\] _11_ net5 _12_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_36_ _08_ _12_ _01_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_37_ net5 _28_ _13_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_38_ bapg.w_ptr_binary_r_o\[2\] _13_ _14_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_39_ _08_ _14_ _02_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_40_ bapg.w_ptr_binary_r_o\[0\] bapg.w_ptr_n\[0\] net5 _15_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_41_ _08_ _15_ _03_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_42_ bapg.w_ptr_binary_r_o\[1\] bapg.w_ptr_n\[1\] net5 _16_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_43_ _08_ _16_ _04_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_44_ net4 _17_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_45_ r_counter_r\[0\] net2 _18_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_46_ _17_ _18_ _05_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_47_ r_counter_r\[1\] r_counter_r_hi_bits_gray\[0\] net2
+ _19_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_48_ _17_ _19_ _06_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_49_ _29_ net2 _20_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_50_ r_counter_r\[2\] _20_ _21_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_51_ _17_ _21_ _07_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_52_ r_counter_r\[2\] bapg.w_ptr_gray_r_rsync_o\[2\] _22_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_53_ r_counter_r\[2\] bapg.w_ptr_gray_r_rsync_o\[2\] _23_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_54_ r_counter_r\[1\] bapg.w_ptr_gray_r_rsync_o\[1\] _24_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_55_ _22_ _23_ _24_ _25_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_56_ r_counter_r_hi_bits_gray\[0\] bapg.w_ptr_gray_r_rsync_o\[0\]
+ _26_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_57_ net3 _25_ _26_ net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_58_ net5 bapg.w_ptr_binary_r_o\[0\] _27_ bapg.w_ptr_n\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_59_ bapg.w_ptr_binary_r_o\[1\] _27_ _28_ bapg.w_ptr_n\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_60_ r_counter_r\[0\] r_counter_r\[1\] _29_ r_counter_r_hi_bits_gray\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
Xbapg.w_ptr_gray_r\[0\]$_SDFFE_PP0P_ _00_ clknet_1_1__leaf_w_clk_i
+ bapg.w_ptr_gray_r\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbapg.w_ptr_gray_r\[1\]$_SDFFE_PP0P_ _01_ clknet_1_1__leaf_w_clk_i
+ bapg.w_ptr_gray_r\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbapg.w_ptr_gray_r\[2\]$_SDFFE_PP0P_ _02_ clknet_1_1__leaf_w_clk_i
+ bapg.w_ptr_binary_r_o\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbapg.w_ptr_gray_r_rsync_r\[0\]\[0\]$_DFF_P_ bapg.w_ptr_gray_r\[0\]
+ net1 bapg.w_ptr_gray_r_rsync_r\[0\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbapg.w_ptr_gray_r_rsync_r\[0\]\[1\]$_DFF_P_ bapg.w_ptr_gray_r\[1\]
+ net1 bapg.w_ptr_gray_r_rsync_r\[0\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbapg.w_ptr_gray_r_rsync_r\[0\]\[2\]$_DFF_P_ bapg.w_ptr_binary_r_o\[2\]
+ net1 bapg.w_ptr_gray_r_rsync_r\[0\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbapg.w_ptr_gray_r_rsync_r\[1\]\[0\]$_DFF_P_ bapg.w_ptr_gray_r_rsync_r\[0\]\[0\]
+ net1 bapg.w_ptr_gray_r_rsync_o\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbapg.w_ptr_gray_r_rsync_r\[1\]\[1\]$_DFF_P_ bapg.w_ptr_gray_r_rsync_r\[0\]\[1\]
+ net1 bapg.w_ptr_gray_r_rsync_o\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbapg.w_ptr_gray_r_rsync_r\[1\]\[2\]$_DFF_P_ bapg.w_ptr_gray_r_rsync_r\[0\]\[2\]
+ net1 bapg.w_ptr_gray_r_rsync_o\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbapg.w_ptr_r\[0\]$_SDFFE_PP0P_ _03_ clknet_1_0__leaf_w_clk_i
+ bapg.w_ptr_binary_r_o\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbapg.w_ptr_r\[1\]$_SDFFE_PP0P_ _04_ clknet_1_0__leaf_w_clk_i
+ bapg.w_ptr_binary_r_o\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xr_counter_r\[0\]$_SDFFE_PP0P_ _05_ net1 r_counter_r\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xr_counter_r\[1\]$_SDFFE_PP0P_ _06_ net1 r_counter_r\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xr_counter_r\[2\]$_SDFFE_PP1P_ _07_ net1 r_counter_r\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 r_clk_i net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput2 r_dec_credit_i net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput3 r_infinite_credits_i net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput4 r_reset_i net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput5 w_inc_token_i net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput6 w_reset_i net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput7 net7 r_credits_avail_o VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_0_w_clk_i w_clk_i clknet_0_w_clk_i VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_1_0__f_w_clk_i clknet_0_w_clk_i clknet_1_0__leaf_w_clk_i
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_1_1__f_w_clk_i clknet_0_w_clk_i clknet_1_1__leaf_w_clk_i
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkload0 clknet_1_0__leaf_w_clk_i _unconnected_0 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_1
.ENDS bsg_async_credit_counter
