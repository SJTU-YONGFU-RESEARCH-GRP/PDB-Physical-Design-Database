* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT bidirectional_fifo a_almost_empty a_almost_full a_empty
+ a_full a_rd_data[0] a_rd_data[1] a_rd_data[2] a_rd_data[3]
+ a_rd_data[4] a_rd_data[5] a_rd_data[6] a_rd_data[7] a_rd_en
+ a_to_b_count[0] a_to_b_count[1] a_to_b_count[2] a_to_b_count[3]
+ a_to_b_count[4] a_wr_data[0] a_wr_data[1] a_wr_data[2] a_wr_data[3]
+ a_wr_data[4] a_wr_data[5] a_wr_data[6] a_wr_data[7] a_wr_en
+ b_almost_empty b_almost_full b_empty b_full b_rd_data[0] b_rd_data[1]
+ b_rd_data[2] b_rd_data[3] b_rd_data[4] b_rd_data[5] b_rd_data[6]
+ b_rd_data[7] b_rd_en b_to_a_count[0] b_to_a_count[1] b_to_a_count[2]
+ b_to_a_count[3] b_to_a_count[4] b_wr_data[0] b_wr_data[1]
+ b_wr_data[2] b_wr_data[3] b_wr_data[4] b_wr_data[5] b_wr_data[6]
+ b_wr_data[7] b_wr_en clk rst_n VSS VDD
X_0611_ _0041_ net34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0612_ _0016_ _0021_ _0002_ _0442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_0613_ _0021_ _0015_ _0020_ _0442_ _0443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_0614_ a_wr_ptr\[4\] b_rd_ptr\[4\] _0443_ _0444_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_0615_ _0444_ net38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_0616_ _0018_ _0445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0617_ _0015_ _0017_ _0446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_0618_ _0040_ _0445_ _0446_ _0447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_0619_ _0016_ _0015_ _0448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_0620_ _0021_ _0447_ _0448_ _0449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_0621_ _0447_ _0448_ _0021_ _0450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_0622_ _0449_ _0450_ net37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_0623_ _0011_ _0008_ _0005_ _0451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_0624_ _0008_ _0010_ _0451_ _0007_ _0452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_0625_ b_wr_ptr\[4\] a_rd_ptr\[4\] _0452_ _0453_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_0626_ _0453_ net55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0627_ _0043_ net51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0628_ _0011_ _0454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0629_ _0013_ _0455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0630_ _0011_ _0012_ _0010_ _0456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_0631_ _0454_ _0042_ _0455_ _0456_ _0457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_0632_ _0008_ _0457_ _0458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0633_ _0458_ net54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0634_ _0011_ _0005_ _0459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0635_ _0459_ net53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0636_ _0016_ _0002_ net36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_0637_ net35 net34 net36 _0460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_0638_ _0449_ _0450_ _0460_ net38 _0461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
Xclkbuf_leaf_4_clk clknet_1_1__leaf_clk clknet_leaf_4_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_0640_ _0461_ net42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0641_ net52 _0463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0642_ _0463_ _0043_ _0464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0643_ _0459_ _0464_ _0465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0644_ _0453_ net54 _0465_ _0466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
Xclkbuf_leaf_3_clk clknet_1_1__leaf_clk clknet_leaf_3_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_0646_ _0466_ net25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0647_ _0453_ _0458_ _0459_ _0464_ net24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_0648_ _0449_ _0450_ _0460_ _0444_ _0468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_0649_ _0468_ net41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xclkbuf_leaf_2_clk clknet_1_1__leaf_clk clknet_leaf_2_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_0651_ a_rd_ptr\[3\] _0006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0652_ a_rd_ptr\[2\] _0470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xclkbuf_leaf_1_clk clknet_1_1__leaf_clk clknet_leaf_1_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_0654_ a_rd_ptr\[1\] _0003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_0655_ b_wr_ptr\[0\] _0024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0656_ a_wr_ptr\[0\] _0033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace60 _0486_ net60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_0658_ b_rd_ptr\[2\] _0014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_0659_ b_rd_ptr\[1\] _0000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
Xclkbuf_leaf_0_clk clknet_1_0__leaf_clk clknet_leaf_0_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_0661_ b_rd_ptr\[3\] _0019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0662_ _0040_ _0001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0663_ _0042_ _0004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0664_ b_wr_ptr\[1\] _0025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0665_ a_wr_ptr\[1\] _0034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace63 net21 net63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace62 a_rd_ptr\[0\] net62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace61 b_rd_ptr\[0\] net61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_0669_ b_to_a_mem\[2\]\[0\] b_to_a_mem\[3\]\[0\] b_to_a_mem\[6\]\[0\]
+ b_to_a_mem\[7\]\[0\] net62 a_rd_ptr\[2\] _0476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xoutput55 net55 b_to_a_count[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0671_ b_to_a_mem\[0\]\[0\] b_to_a_mem\[1\]\[0\] b_to_a_mem\[4\]\[0\]
+ b_to_a_mem\[5\]\[0\] net62 a_rd_ptr\[2\] _0478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0672_ _0476_ _0478_ _0003_ _0479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput54 net54 b_to_a_count[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0674_ b_to_a_mem\[12\]\[0\] b_to_a_mem\[13\]\[0\] b_to_a_mem\[14\]\[0\]
+ b_to_a_mem\[15\]\[0\] net62 a_rd_ptr\[1\] _0481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xoutput53 net53 b_to_a_count[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0676_ b_to_a_mem\[8\]\[0\] b_to_a_mem\[9\]\[0\] b_to_a_mem\[10\]\[0\]
+ b_to_a_mem\[11\]\[0\] net62 a_rd_ptr\[1\] _0483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0677_ _0481_ _0483_ _0470_ _0484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0678_ _0479_ _0484_ a_rd_ptr\[3\] _0485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0679_ net55 net54 _0465_ net1 _0486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
Xoutput52 net52 b_to_a_count[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0681_ _0485_ net26 net60 _0044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0682_ b_to_a_mem\[2\]\[1\] b_to_a_mem\[3\]\[1\] b_to_a_mem\[6\]\[1\]
+ b_to_a_mem\[7\]\[1\] net62 a_rd_ptr\[2\] _0488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0683_ b_to_a_mem\[0\]\[1\] b_to_a_mem\[1\]\[1\] b_to_a_mem\[4\]\[1\]
+ b_to_a_mem\[5\]\[1\] net62 a_rd_ptr\[2\] _0489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0684_ _0488_ _0489_ _0003_ _0490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0685_ b_to_a_mem\[12\]\[1\] b_to_a_mem\[13\]\[1\] b_to_a_mem\[14\]\[1\]
+ b_to_a_mem\[15\]\[1\] net62 a_rd_ptr\[1\] _0491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0686_ b_to_a_mem\[8\]\[1\] b_to_a_mem\[9\]\[1\] b_to_a_mem\[10\]\[1\]
+ b_to_a_mem\[11\]\[1\] net62 a_rd_ptr\[1\] _0492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0687_ _0491_ _0492_ _0470_ _0493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0688_ _0490_ _0493_ a_rd_ptr\[3\] _0494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0689_ _0494_ net27 net60 _0045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0690_ b_to_a_mem\[2\]\[2\] b_to_a_mem\[3\]\[2\] b_to_a_mem\[6\]\[2\]
+ b_to_a_mem\[7\]\[2\] net62 a_rd_ptr\[2\] _0495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0691_ b_to_a_mem\[0\]\[2\] b_to_a_mem\[1\]\[2\] b_to_a_mem\[4\]\[2\]
+ b_to_a_mem\[5\]\[2\] net62 a_rd_ptr\[2\] _0496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0692_ _0495_ _0496_ _0003_ _0497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0693_ b_to_a_mem\[12\]\[2\] b_to_a_mem\[13\]\[2\] b_to_a_mem\[14\]\[2\]
+ b_to_a_mem\[15\]\[2\] net62 a_rd_ptr\[1\] _0498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0694_ b_to_a_mem\[8\]\[2\] b_to_a_mem\[9\]\[2\] b_to_a_mem\[10\]\[2\]
+ b_to_a_mem\[11\]\[2\] net62 a_rd_ptr\[1\] _0499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0695_ _0498_ _0499_ _0470_ _0500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0696_ _0497_ _0500_ a_rd_ptr\[3\] _0501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0697_ _0501_ net28 net60 _0046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0698_ b_to_a_mem\[2\]\[3\] b_to_a_mem\[3\]\[3\] b_to_a_mem\[6\]\[3\]
+ b_to_a_mem\[7\]\[3\] net62 a_rd_ptr\[2\] _0502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0699_ b_to_a_mem\[0\]\[3\] b_to_a_mem\[1\]\[3\] b_to_a_mem\[4\]\[3\]
+ b_to_a_mem\[5\]\[3\] net62 a_rd_ptr\[2\] _0503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0700_ _0502_ _0503_ _0003_ _0504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0701_ b_to_a_mem\[12\]\[3\] b_to_a_mem\[13\]\[3\] b_to_a_mem\[14\]\[3\]
+ b_to_a_mem\[15\]\[3\] net62 a_rd_ptr\[1\] _0505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0702_ b_to_a_mem\[8\]\[3\] b_to_a_mem\[9\]\[3\] b_to_a_mem\[10\]\[3\]
+ b_to_a_mem\[11\]\[3\] net62 a_rd_ptr\[1\] _0506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0703_ _0505_ _0506_ _0470_ _0507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0704_ _0504_ _0507_ a_rd_ptr\[3\] _0508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0705_ _0508_ net29 net60 _0047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0706_ b_to_a_mem\[2\]\[4\] b_to_a_mem\[3\]\[4\] b_to_a_mem\[6\]\[4\]
+ b_to_a_mem\[7\]\[4\] net62 a_rd_ptr\[2\] _0509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0707_ b_to_a_mem\[0\]\[4\] b_to_a_mem\[1\]\[4\] b_to_a_mem\[4\]\[4\]
+ b_to_a_mem\[5\]\[4\] net62 a_rd_ptr\[2\] _0510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0708_ _0509_ _0510_ _0003_ _0511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0709_ b_to_a_mem\[12\]\[4\] b_to_a_mem\[13\]\[4\] b_to_a_mem\[14\]\[4\]
+ b_to_a_mem\[15\]\[4\] net62 a_rd_ptr\[1\] _0512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0710_ b_to_a_mem\[8\]\[4\] b_to_a_mem\[9\]\[4\] b_to_a_mem\[10\]\[4\]
+ b_to_a_mem\[11\]\[4\] net62 a_rd_ptr\[1\] _0513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0711_ _0512_ _0513_ _0470_ _0514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0712_ _0511_ _0514_ a_rd_ptr\[3\] _0515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0713_ _0515_ net30 net60 _0048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0714_ b_to_a_mem\[2\]\[5\] b_to_a_mem\[3\]\[5\] b_to_a_mem\[6\]\[5\]
+ b_to_a_mem\[7\]\[5\] net62 a_rd_ptr\[2\] _0516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0715_ b_to_a_mem\[0\]\[5\] b_to_a_mem\[1\]\[5\] b_to_a_mem\[4\]\[5\]
+ b_to_a_mem\[5\]\[5\] net62 a_rd_ptr\[2\] _0517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0716_ _0516_ _0517_ _0003_ _0518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0717_ b_to_a_mem\[12\]\[5\] b_to_a_mem\[13\]\[5\] b_to_a_mem\[14\]\[5\]
+ b_to_a_mem\[15\]\[5\] net62 a_rd_ptr\[1\] _0519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0718_ b_to_a_mem\[8\]\[5\] b_to_a_mem\[9\]\[5\] b_to_a_mem\[10\]\[5\]
+ b_to_a_mem\[11\]\[5\] net62 a_rd_ptr\[1\] _0520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0719_ _0519_ _0520_ _0470_ _0521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0720_ _0518_ _0521_ a_rd_ptr\[3\] _0522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0721_ _0522_ net31 net60 _0049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0722_ b_to_a_mem\[2\]\[6\] b_to_a_mem\[3\]\[6\] b_to_a_mem\[6\]\[6\]
+ b_to_a_mem\[7\]\[6\] net62 a_rd_ptr\[2\] _0523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0723_ b_to_a_mem\[0\]\[6\] b_to_a_mem\[1\]\[6\] b_to_a_mem\[4\]\[6\]
+ b_to_a_mem\[5\]\[6\] net62 a_rd_ptr\[2\] _0524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0724_ _0523_ _0524_ _0003_ _0525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0725_ b_to_a_mem\[12\]\[6\] b_to_a_mem\[13\]\[6\] b_to_a_mem\[14\]\[6\]
+ b_to_a_mem\[15\]\[6\] net62 a_rd_ptr\[1\] _0526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0726_ b_to_a_mem\[8\]\[6\] b_to_a_mem\[9\]\[6\] b_to_a_mem\[10\]\[6\]
+ b_to_a_mem\[11\]\[6\] net62 a_rd_ptr\[1\] _0527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0727_ _0526_ _0527_ _0470_ _0528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0728_ _0525_ _0528_ a_rd_ptr\[3\] _0529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0729_ _0529_ net32 net60 _0050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0730_ b_to_a_mem\[2\]\[7\] b_to_a_mem\[3\]\[7\] b_to_a_mem\[6\]\[7\]
+ b_to_a_mem\[7\]\[7\] net62 a_rd_ptr\[2\] _0530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0731_ b_to_a_mem\[0\]\[7\] b_to_a_mem\[1\]\[7\] b_to_a_mem\[4\]\[7\]
+ b_to_a_mem\[5\]\[7\] net62 a_rd_ptr\[2\] _0531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0732_ _0530_ _0531_ _0003_ _0532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0733_ b_to_a_mem\[12\]\[7\] b_to_a_mem\[13\]\[7\] b_to_a_mem\[14\]\[7\]
+ b_to_a_mem\[15\]\[7\] net62 a_rd_ptr\[1\] _0533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0734_ b_to_a_mem\[8\]\[7\] b_to_a_mem\[9\]\[7\] b_to_a_mem\[10\]\[7\]
+ b_to_a_mem\[11\]\[7\] net62 a_rd_ptr\[1\] _0534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0735_ _0533_ _0534_ _0470_ _0535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0736_ _0532_ _0535_ a_rd_ptr\[3\] _0536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0737_ _0536_ net33 net60 _0051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0738_ net62 net60 _0052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0739_ _0032_ a_rd_ptr\[1\] net60 _0053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0740_ _0031_ _0537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0741_ _0537_ net60 _0538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_0742_ _0470_ _0538_ _0054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0743_ net62 a_rd_ptr\[1\] a_rd_ptr\[2\] _0539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_0744_ net60 _0539_ _0540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_0745_ _0006_ _0540_ _0055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0746_ _0470_ _0006_ _0537_ net60 _0541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_0747_ a_rd_ptr\[4\] _0541_ _0056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xoutput51 net51 b_to_a_count[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput50 net50 b_rd_data[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0750_ a_wr_ptr\[3\] _0544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0751_ a_wr_ptr\[2\] _0545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0752_ _0544_ _0545_ _0546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0753_ net10 _0035_ _0461_ _0546_ _0547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xoutput49 net49 b_rd_data[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0755_ a_to_b_mem\[0\]\[0\] net2 _0547_ _0057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput48 net48 b_rd_data[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0757_ a_to_b_mem\[0\]\[1\] net3 _0547_ _0058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput47 net47 b_rd_data[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0759_ a_to_b_mem\[0\]\[2\] net4 _0547_ _0059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput46 net46 b_rd_data[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0761_ a_to_b_mem\[0\]\[3\] net5 _0547_ _0060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput45 net45 b_rd_data[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0763_ a_to_b_mem\[0\]\[4\] net6 _0547_ _0061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput44 net44 b_rd_data[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0765_ a_to_b_mem\[0\]\[5\] net7 _0547_ _0062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput43 net43 b_rd_data[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0767_ a_to_b_mem\[0\]\[6\] net8 _0547_ _0063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput42 net42 b_full VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0769_ a_to_b_mem\[0\]\[7\] net9 _0547_ _0064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0770_ a_wr_ptr\[3\] _0545_ _0556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0771_ net10 _0037_ _0461_ _0556_ _0557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xoutput41 net41 b_empty VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0773_ a_to_b_mem\[10\]\[0\] net2 _0557_ _0065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0774_ a_to_b_mem\[10\]\[1\] net3 _0557_ _0066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0775_ a_to_b_mem\[10\]\[2\] net4 _0557_ _0067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0776_ a_to_b_mem\[10\]\[3\] net5 _0557_ _0068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0777_ a_to_b_mem\[10\]\[4\] net6 _0557_ _0069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0778_ a_to_b_mem\[10\]\[5\] net7 _0557_ _0070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0779_ a_to_b_mem\[10\]\[6\] net8 _0557_ _0071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0780_ a_to_b_mem\[10\]\[7\] net9 _0557_ _0072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0781_ net10 _0039_ _0559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0782_ _0461_ _0556_ _0559_ _0560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_0783_ a_to_b_mem\[11\]\[0\] net2 _0560_ _0073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0784_ a_to_b_mem\[11\]\[1\] net3 _0560_ _0074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0785_ a_to_b_mem\[11\]\[2\] net4 _0560_ _0075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0786_ a_to_b_mem\[11\]\[3\] net5 _0560_ _0076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0787_ a_to_b_mem\[11\]\[4\] net6 _0560_ _0077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0788_ a_to_b_mem\[11\]\[5\] net7 _0560_ _0078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0789_ a_to_b_mem\[11\]\[6\] net8 _0560_ _0079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0790_ a_to_b_mem\[11\]\[7\] net9 _0560_ _0080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0791_ a_wr_ptr\[3\] a_wr_ptr\[2\] _0561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0792_ net10 _0035_ _0461_ _0561_ _0562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xoutput40 net40 b_almost_full VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0794_ a_to_b_mem\[12\]\[0\] net2 _0562_ _0081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0795_ a_to_b_mem\[12\]\[1\] net3 _0562_ _0082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0796_ a_to_b_mem\[12\]\[2\] net4 _0562_ _0083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0797_ a_to_b_mem\[12\]\[3\] net5 _0562_ _0084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0798_ a_to_b_mem\[12\]\[4\] net6 _0562_ _0085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0799_ a_to_b_mem\[12\]\[5\] net7 _0562_ _0086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0800_ a_to_b_mem\[12\]\[6\] net8 _0562_ _0087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0801_ a_to_b_mem\[12\]\[7\] net9 _0562_ _0088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput39 net39 b_almost_empty VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0803_ net10 _0038_ _0461_ _0561_ _0565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xoutput38 net38 a_to_b_count[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0805_ a_to_b_mem\[13\]\[0\] net2 _0565_ _0089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0806_ a_to_b_mem\[13\]\[1\] net3 _0565_ _0090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0807_ a_to_b_mem\[13\]\[2\] net4 _0565_ _0091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0808_ a_to_b_mem\[13\]\[3\] net5 _0565_ _0092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0809_ a_to_b_mem\[13\]\[4\] net6 _0565_ _0093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0810_ a_to_b_mem\[13\]\[5\] net7 _0565_ _0094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0811_ a_to_b_mem\[13\]\[6\] net8 _0565_ _0095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0812_ a_to_b_mem\[13\]\[7\] net9 _0565_ _0096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0813_ net10 _0037_ _0461_ _0561_ _0567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xoutput37 net37 a_to_b_count[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0815_ a_to_b_mem\[14\]\[0\] net2 _0567_ _0097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0816_ a_to_b_mem\[14\]\[1\] net3 _0567_ _0098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0817_ a_to_b_mem\[14\]\[2\] net4 _0567_ _0099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0818_ a_to_b_mem\[14\]\[3\] net5 _0567_ _0100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0819_ a_to_b_mem\[14\]\[4\] net6 _0567_ _0101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0820_ a_to_b_mem\[14\]\[5\] net7 _0567_ _0102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0821_ a_to_b_mem\[14\]\[6\] net8 _0567_ _0103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0822_ a_to_b_mem\[14\]\[7\] net9 _0567_ _0104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0823_ _0461_ _0559_ _0561_ _0569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
Xoutput36 net36 a_to_b_count[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0825_ a_to_b_mem\[15\]\[0\] net2 _0569_ _0105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0826_ a_to_b_mem\[15\]\[1\] net3 _0569_ _0106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0827_ a_to_b_mem\[15\]\[2\] net4 _0569_ _0107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0828_ a_to_b_mem\[15\]\[3\] net5 _0569_ _0108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0829_ a_to_b_mem\[15\]\[4\] net6 _0569_ _0109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0830_ a_to_b_mem\[15\]\[5\] net7 _0569_ _0110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0831_ a_to_b_mem\[15\]\[6\] net8 _0569_ _0111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0832_ a_to_b_mem\[15\]\[7\] net9 _0569_ _0112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0833_ net10 _0038_ _0461_ _0546_ _0571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput35 net35 a_to_b_count[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0835_ a_to_b_mem\[1\]\[0\] net2 _0571_ _0113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0836_ a_to_b_mem\[1\]\[1\] net3 _0571_ _0114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0837_ a_to_b_mem\[1\]\[2\] net4 _0571_ _0115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0838_ a_to_b_mem\[1\]\[3\] net5 _0571_ _0116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0839_ a_to_b_mem\[1\]\[4\] net6 _0571_ _0117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0840_ a_to_b_mem\[1\]\[5\] net7 _0571_ _0118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0841_ a_to_b_mem\[1\]\[6\] net8 _0571_ _0119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0842_ a_to_b_mem\[1\]\[7\] net9 _0571_ _0120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0843_ net10 _0037_ _0461_ _0546_ _0573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput34 net34 a_to_b_count[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0845_ a_to_b_mem\[2\]\[0\] net2 _0573_ _0121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0846_ a_to_b_mem\[2\]\[1\] net3 _0573_ _0122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0847_ a_to_b_mem\[2\]\[2\] net4 _0573_ _0123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0848_ a_to_b_mem\[2\]\[3\] net5 _0573_ _0124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0849_ a_to_b_mem\[2\]\[4\] net6 _0573_ _0125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0850_ a_to_b_mem\[2\]\[5\] net7 _0573_ _0126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0851_ a_to_b_mem\[2\]\[6\] net8 _0573_ _0127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0852_ a_to_b_mem\[2\]\[7\] net9 _0573_ _0128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0853_ _0461_ _0546_ _0559_ _0575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_0854_ a_to_b_mem\[3\]\[0\] net2 _0575_ _0129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0855_ a_to_b_mem\[3\]\[1\] net3 _0575_ _0130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0856_ a_to_b_mem\[3\]\[2\] net4 _0575_ _0131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0857_ a_to_b_mem\[3\]\[3\] net5 _0575_ _0132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0858_ a_to_b_mem\[3\]\[4\] net6 _0575_ _0133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0859_ a_to_b_mem\[3\]\[5\] net7 _0575_ _0134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0860_ a_to_b_mem\[3\]\[6\] net8 _0575_ _0135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0861_ a_to_b_mem\[3\]\[7\] net9 _0575_ _0136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0862_ _0544_ a_wr_ptr\[2\] _0576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0863_ net10 _0035_ _0461_ _0576_ _0577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput33 net33 a_rd_data[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0865_ a_to_b_mem\[4\]\[0\] net2 _0577_ _0137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0866_ a_to_b_mem\[4\]\[1\] net3 _0577_ _0138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0867_ a_to_b_mem\[4\]\[2\] net4 _0577_ _0139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0868_ a_to_b_mem\[4\]\[3\] net5 _0577_ _0140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0869_ a_to_b_mem\[4\]\[4\] net6 _0577_ _0141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0870_ a_to_b_mem\[4\]\[5\] net7 _0577_ _0142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0871_ a_to_b_mem\[4\]\[6\] net8 _0577_ _0143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0872_ a_to_b_mem\[4\]\[7\] net9 _0577_ _0144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0873_ net10 _0038_ _0461_ _0576_ _0579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput32 net32 a_rd_data[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0875_ a_to_b_mem\[5\]\[0\] net2 _0579_ _0145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0876_ a_to_b_mem\[5\]\[1\] net3 _0579_ _0146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0877_ a_to_b_mem\[5\]\[2\] net4 _0579_ _0147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0878_ a_to_b_mem\[5\]\[3\] net5 _0579_ _0148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0879_ a_to_b_mem\[5\]\[4\] net6 _0579_ _0149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0880_ a_to_b_mem\[5\]\[5\] net7 _0579_ _0150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0881_ a_to_b_mem\[5\]\[6\] net8 _0579_ _0151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0882_ a_to_b_mem\[5\]\[7\] net9 _0579_ _0152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0883_ net10 _0037_ _0461_ _0576_ _0581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput31 net31 a_rd_data[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0885_ a_to_b_mem\[6\]\[0\] net2 _0581_ _0153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0886_ a_to_b_mem\[6\]\[1\] net3 _0581_ _0154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0887_ a_to_b_mem\[6\]\[2\] net4 _0581_ _0155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0888_ a_to_b_mem\[6\]\[3\] net5 _0581_ _0156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0889_ a_to_b_mem\[6\]\[4\] net6 _0581_ _0157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0890_ a_to_b_mem\[6\]\[5\] net7 _0581_ _0158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0891_ a_to_b_mem\[6\]\[6\] net8 _0581_ _0159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0892_ a_to_b_mem\[6\]\[7\] net9 _0581_ _0160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0893_ _0461_ _0559_ _0576_ _0583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_0894_ a_to_b_mem\[7\]\[0\] net2 _0583_ _0161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0895_ a_to_b_mem\[7\]\[1\] net3 _0583_ _0162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0896_ a_to_b_mem\[7\]\[2\] net4 _0583_ _0163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0897_ a_to_b_mem\[7\]\[3\] net5 _0583_ _0164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0898_ a_to_b_mem\[7\]\[4\] net6 _0583_ _0165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0899_ a_to_b_mem\[7\]\[5\] net7 _0583_ _0166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0900_ a_to_b_mem\[7\]\[6\] net8 _0583_ _0167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0901_ a_to_b_mem\[7\]\[7\] net9 _0583_ _0168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0902_ net10 _0035_ _0461_ _0556_ _0584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput30 net30 a_rd_data[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0904_ a_to_b_mem\[8\]\[0\] net2 _0584_ _0169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0905_ a_to_b_mem\[8\]\[1\] net3 _0584_ _0170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0906_ a_to_b_mem\[8\]\[2\] net4 _0584_ _0171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0907_ a_to_b_mem\[8\]\[3\] net5 _0584_ _0172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0908_ a_to_b_mem\[8\]\[4\] net6 _0584_ _0173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0909_ a_to_b_mem\[8\]\[5\] net7 _0584_ _0174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0910_ a_to_b_mem\[8\]\[6\] net8 _0584_ _0175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0911_ a_to_b_mem\[8\]\[7\] net9 _0584_ _0176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0912_ net10 _0038_ _0461_ _0556_ _0586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput29 net29 a_rd_data[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0914_ a_to_b_mem\[9\]\[0\] net2 _0586_ _0177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0915_ a_to_b_mem\[9\]\[1\] net3 _0586_ _0178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0916_ a_to_b_mem\[9\]\[2\] net4 _0586_ _0179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0917_ a_to_b_mem\[9\]\[3\] net5 _0586_ _0180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0918_ a_to_b_mem\[9\]\[4\] net6 _0586_ _0181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0919_ a_to_b_mem\[9\]\[5\] net7 _0586_ _0182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0920_ a_to_b_mem\[9\]\[6\] net8 _0586_ _0183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0921_ a_to_b_mem\[9\]\[7\] net9 _0586_ _0184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0922_ net10 _0461_ _0588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0923_ a_wr_ptr\[0\] _0588_ _0185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0924_ _0036_ a_wr_ptr\[1\] _0588_ _0186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0925_ _0461_ _0559_ _0589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0926_ _0545_ _0589_ _0187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0927_ net10 a_wr_ptr\[2\] a_wr_ptr\[1\] a_wr_ptr\[0\] _0590_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_0928_ _0461_ _0590_ _0591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0929_ _0544_ _0591_ _0188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0930_ a_wr_ptr\[4\] _0569_ _0189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
Xoutput28 net28 a_rd_data[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput27 net27 a_rd_data[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput26 net26 a_rd_data[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0934_ a_to_b_mem\[2\]\[0\] a_to_b_mem\[3\]\[0\] a_to_b_mem\[6\]\[0\]
+ a_to_b_mem\[7\]\[0\] net61 b_rd_ptr\[2\] _0595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xoutput25 net25 a_full VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0936_ a_to_b_mem\[0\]\[0\] a_to_b_mem\[1\]\[0\] a_to_b_mem\[4\]\[0\]
+ a_to_b_mem\[5\]\[0\] net61 b_rd_ptr\[2\] _0597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0937_ _0595_ _0597_ _0000_ _0598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput24 net24 a_empty VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0939_ a_to_b_mem\[12\]\[0\] a_to_b_mem\[13\]\[0\] a_to_b_mem\[14\]\[0\]
+ a_to_b_mem\[15\]\[0\] net61 b_rd_ptr\[1\] _0600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xoutput23 net23 a_almost_full VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0941_ a_to_b_mem\[8\]\[0\] a_to_b_mem\[9\]\[0\] a_to_b_mem\[10\]\[0\]
+ a_to_b_mem\[11\]\[0\] net61 b_rd_ptr\[1\] _0602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0942_ _0600_ _0602_ _0014_ _0603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0943_ _0598_ _0603_ b_rd_ptr\[3\] _0604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0944_ net11 _0468_ _0336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_0945_ _0604_ net43 _0336_ _0190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0946_ a_to_b_mem\[2\]\[1\] a_to_b_mem\[3\]\[1\] a_to_b_mem\[6\]\[1\]
+ a_to_b_mem\[7\]\[1\] net61 b_rd_ptr\[2\] _0337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0947_ a_to_b_mem\[0\]\[1\] a_to_b_mem\[1\]\[1\] a_to_b_mem\[4\]\[1\]
+ a_to_b_mem\[5\]\[1\] net61 b_rd_ptr\[2\] _0338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0948_ _0337_ _0338_ _0000_ _0339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0949_ a_to_b_mem\[12\]\[1\] a_to_b_mem\[13\]\[1\] a_to_b_mem\[14\]\[1\]
+ a_to_b_mem\[15\]\[1\] net61 b_rd_ptr\[1\] _0340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0950_ a_to_b_mem\[8\]\[1\] a_to_b_mem\[9\]\[1\] a_to_b_mem\[10\]\[1\]
+ a_to_b_mem\[11\]\[1\] net61 b_rd_ptr\[1\] _0341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0951_ _0340_ _0341_ _0014_ _0342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0952_ _0339_ _0342_ b_rd_ptr\[3\] _0343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0953_ _0343_ net44 _0336_ _0191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0954_ a_to_b_mem\[2\]\[2\] a_to_b_mem\[3\]\[2\] a_to_b_mem\[6\]\[2\]
+ a_to_b_mem\[7\]\[2\] net61 b_rd_ptr\[2\] _0344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0955_ a_to_b_mem\[0\]\[2\] a_to_b_mem\[1\]\[2\] a_to_b_mem\[4\]\[2\]
+ a_to_b_mem\[5\]\[2\] net61 b_rd_ptr\[2\] _0345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0956_ _0344_ _0345_ _0000_ _0346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0957_ a_to_b_mem\[12\]\[2\] a_to_b_mem\[13\]\[2\] a_to_b_mem\[14\]\[2\]
+ a_to_b_mem\[15\]\[2\] net61 b_rd_ptr\[1\] _0347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0958_ a_to_b_mem\[8\]\[2\] a_to_b_mem\[9\]\[2\] a_to_b_mem\[10\]\[2\]
+ a_to_b_mem\[11\]\[2\] net61 b_rd_ptr\[1\] _0348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0959_ _0347_ _0348_ _0014_ _0349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0960_ _0346_ _0349_ b_rd_ptr\[3\] _0350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0961_ _0350_ net45 _0336_ _0192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0962_ a_to_b_mem\[2\]\[3\] a_to_b_mem\[3\]\[3\] a_to_b_mem\[6\]\[3\]
+ a_to_b_mem\[7\]\[3\] net61 b_rd_ptr\[2\] _0351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0963_ a_to_b_mem\[0\]\[3\] a_to_b_mem\[1\]\[3\] a_to_b_mem\[4\]\[3\]
+ a_to_b_mem\[5\]\[3\] net61 b_rd_ptr\[2\] _0352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0964_ _0351_ _0352_ _0000_ _0353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0965_ a_to_b_mem\[12\]\[3\] a_to_b_mem\[13\]\[3\] a_to_b_mem\[14\]\[3\]
+ a_to_b_mem\[15\]\[3\] net61 b_rd_ptr\[1\] _0354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0966_ a_to_b_mem\[8\]\[3\] a_to_b_mem\[9\]\[3\] a_to_b_mem\[10\]\[3\]
+ a_to_b_mem\[11\]\[3\] net61 b_rd_ptr\[1\] _0355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0967_ _0354_ _0355_ _0014_ _0356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0968_ _0353_ _0356_ b_rd_ptr\[3\] _0357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0969_ _0357_ net46 _0336_ _0193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0970_ a_to_b_mem\[2\]\[4\] a_to_b_mem\[3\]\[4\] a_to_b_mem\[6\]\[4\]
+ a_to_b_mem\[7\]\[4\] net61 b_rd_ptr\[2\] _0358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0971_ a_to_b_mem\[0\]\[4\] a_to_b_mem\[1\]\[4\] a_to_b_mem\[4\]\[4\]
+ a_to_b_mem\[5\]\[4\] net61 b_rd_ptr\[2\] _0359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0972_ _0358_ _0359_ _0000_ _0360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0973_ a_to_b_mem\[12\]\[4\] a_to_b_mem\[13\]\[4\] a_to_b_mem\[14\]\[4\]
+ a_to_b_mem\[15\]\[4\] net61 b_rd_ptr\[1\] _0361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0974_ a_to_b_mem\[8\]\[4\] a_to_b_mem\[9\]\[4\] a_to_b_mem\[10\]\[4\]
+ a_to_b_mem\[11\]\[4\] net61 b_rd_ptr\[1\] _0362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0975_ _0361_ _0362_ _0014_ _0363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0976_ _0360_ _0363_ b_rd_ptr\[3\] _0364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0977_ _0364_ net47 _0336_ _0194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0978_ a_to_b_mem\[2\]\[5\] a_to_b_mem\[3\]\[5\] a_to_b_mem\[6\]\[5\]
+ a_to_b_mem\[7\]\[5\] net61 b_rd_ptr\[2\] _0365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0979_ a_to_b_mem\[0\]\[5\] a_to_b_mem\[1\]\[5\] a_to_b_mem\[4\]\[5\]
+ a_to_b_mem\[5\]\[5\] net61 b_rd_ptr\[2\] _0366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0980_ _0365_ _0366_ _0000_ _0367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0981_ a_to_b_mem\[12\]\[5\] a_to_b_mem\[13\]\[5\] a_to_b_mem\[14\]\[5\]
+ a_to_b_mem\[15\]\[5\] net61 b_rd_ptr\[1\] _0368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0982_ a_to_b_mem\[8\]\[5\] a_to_b_mem\[9\]\[5\] a_to_b_mem\[10\]\[5\]
+ a_to_b_mem\[11\]\[5\] net61 b_rd_ptr\[1\] _0369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0983_ _0368_ _0369_ _0014_ _0370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0984_ _0367_ _0370_ b_rd_ptr\[3\] _0371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0985_ _0371_ net48 _0336_ _0195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0986_ a_to_b_mem\[2\]\[6\] a_to_b_mem\[3\]\[6\] a_to_b_mem\[6\]\[6\]
+ a_to_b_mem\[7\]\[6\] net61 b_rd_ptr\[2\] _0372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0987_ a_to_b_mem\[0\]\[6\] a_to_b_mem\[1\]\[6\] a_to_b_mem\[4\]\[6\]
+ a_to_b_mem\[5\]\[6\] net61 b_rd_ptr\[2\] _0373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0988_ _0372_ _0373_ _0000_ _0374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0989_ a_to_b_mem\[12\]\[6\] a_to_b_mem\[13\]\[6\] a_to_b_mem\[14\]\[6\]
+ a_to_b_mem\[15\]\[6\] net61 b_rd_ptr\[1\] _0375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0990_ a_to_b_mem\[8\]\[6\] a_to_b_mem\[9\]\[6\] a_to_b_mem\[10\]\[6\]
+ a_to_b_mem\[11\]\[6\] net61 b_rd_ptr\[1\] _0376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0991_ _0375_ _0376_ _0014_ _0377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0992_ _0374_ _0377_ b_rd_ptr\[3\] _0378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0993_ _0378_ net49 _0336_ _0196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0994_ a_to_b_mem\[2\]\[7\] a_to_b_mem\[3\]\[7\] a_to_b_mem\[6\]\[7\]
+ a_to_b_mem\[7\]\[7\] net61 b_rd_ptr\[2\] _0379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0995_ a_to_b_mem\[0\]\[7\] a_to_b_mem\[1\]\[7\] a_to_b_mem\[4\]\[7\]
+ a_to_b_mem\[5\]\[7\] net61 b_rd_ptr\[2\] _0380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0996_ _0379_ _0380_ _0000_ _0381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0997_ a_to_b_mem\[12\]\[7\] a_to_b_mem\[13\]\[7\] a_to_b_mem\[14\]\[7\]
+ a_to_b_mem\[15\]\[7\] net61 b_rd_ptr\[1\] _0382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0998_ a_to_b_mem\[8\]\[7\] a_to_b_mem\[9\]\[7\] a_to_b_mem\[10\]\[7\]
+ a_to_b_mem\[11\]\[7\] net61 b_rd_ptr\[1\] _0383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_0999_ _0382_ _0383_ _0014_ _0384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1000_ _0381_ _0384_ b_rd_ptr\[3\] _0385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1001_ _0385_ net50 _0336_ _0197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1002_ net61 _0336_ _0198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1003_ _0023_ b_rd_ptr\[1\] _0336_ _0199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1004_ net11 _0022_ _0468_ _0386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_1005_ b_rd_ptr\[2\] _0386_ _0200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1006_ net11 net61 b_rd_ptr\[1\] b_rd_ptr\[2\] _0387_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1007_ _0468_ _0387_ _0388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1008_ _0019_ _0388_ _0201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1009_ net11 b_rd_ptr\[2\] b_rd_ptr\[3\] _0022_ _0389_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1010_ _0468_ _0389_ _0390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1011_ b_rd_ptr\[4\] _0390_ _0202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xoutput22 net22 a_almost_empty VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput21 rst_n net21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1014_ b_wr_ptr\[3\] _0393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1015_ b_wr_ptr\[2\] _0394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1016_ _0393_ _0394_ _0395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1017_ net20 _0026_ _0466_ _0395_ _0396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput20 b_wr_en net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1019_ b_to_a_mem\[0\]\[0\] net12 _0396_ _0203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput19 b_wr_data[7] net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1021_ b_to_a_mem\[0\]\[1\] net13 _0396_ _0204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput18 b_wr_data[6] net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1023_ b_to_a_mem\[0\]\[2\] net14 _0396_ _0205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput17 b_wr_data[5] net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1025_ b_to_a_mem\[0\]\[3\] net15 _0396_ _0206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput16 b_wr_data[4] net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1027_ b_to_a_mem\[0\]\[4\] net16 _0396_ _0207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput15 b_wr_data[3] net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1029_ b_to_a_mem\[0\]\[5\] net17 _0396_ _0208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput14 b_wr_data[2] net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1031_ b_to_a_mem\[0\]\[6\] net18 _0396_ _0209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput13 b_wr_data[1] net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1033_ b_to_a_mem\[0\]\[7\] net19 _0396_ _0210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1034_ b_wr_ptr\[3\] _0394_ _0405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1035_ net20 _0028_ _0466_ _0405_ _0406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput12 b_wr_data[0] net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1037_ b_to_a_mem\[10\]\[0\] net12 _0406_ _0211_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1038_ b_to_a_mem\[10\]\[1\] net13 _0406_ _0212_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1039_ b_to_a_mem\[10\]\[2\] net14 _0406_ _0213_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1040_ b_to_a_mem\[10\]\[3\] net15 _0406_ _0214_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1041_ b_to_a_mem\[10\]\[4\] net16 _0406_ _0215_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1042_ b_to_a_mem\[10\]\[5\] net17 _0406_ _0216_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1043_ b_to_a_mem\[10\]\[6\] net18 _0406_ _0217_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1044_ b_to_a_mem\[10\]\[7\] net19 _0406_ _0218_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput11 b_rd_en net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1046_ net20 _0030_ _0466_ _0405_ _0409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput10 a_wr_en net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1048_ b_to_a_mem\[11\]\[0\] net12 _0409_ _0219_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1049_ b_to_a_mem\[11\]\[1\] net13 _0409_ _0220_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1050_ b_to_a_mem\[11\]\[2\] net14 _0409_ _0221_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1051_ b_to_a_mem\[11\]\[3\] net15 _0409_ _0222_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1052_ b_to_a_mem\[11\]\[4\] net16 _0409_ _0223_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1053_ b_to_a_mem\[11\]\[5\] net17 _0409_ _0224_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1054_ b_to_a_mem\[11\]\[6\] net18 _0409_ _0225_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1055_ b_to_a_mem\[11\]\[7\] net19 _0409_ _0226_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1056_ b_wr_ptr\[3\] b_wr_ptr\[2\] _0411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1057_ net20 _0026_ _0466_ _0411_ _0412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_1058_ net12 b_to_a_mem\[12\]\[0\] _0412_ _0227_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1059_ net13 b_to_a_mem\[12\]\[1\] _0412_ _0228_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1060_ net14 b_to_a_mem\[12\]\[2\] _0412_ _0229_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1061_ net15 b_to_a_mem\[12\]\[3\] _0412_ _0230_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1062_ net16 b_to_a_mem\[12\]\[4\] _0412_ _0231_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1063_ net17 b_to_a_mem\[12\]\[5\] _0412_ _0232_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1064_ net18 b_to_a_mem\[12\]\[6\] _0412_ _0233_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1065_ net19 b_to_a_mem\[12\]\[7\] _0412_ _0234_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1066_ net20 _0029_ _0466_ _0411_ _0413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_1067_ net12 b_to_a_mem\[13\]\[0\] _0413_ _0235_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1068_ net13 b_to_a_mem\[13\]\[1\] _0413_ _0236_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1069_ net14 b_to_a_mem\[13\]\[2\] _0413_ _0237_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1070_ net15 b_to_a_mem\[13\]\[3\] _0413_ _0238_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1071_ net16 b_to_a_mem\[13\]\[4\] _0413_ _0239_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1072_ net17 b_to_a_mem\[13\]\[5\] _0413_ _0240_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1073_ net18 b_to_a_mem\[13\]\[6\] _0413_ _0241_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1074_ net19 b_to_a_mem\[13\]\[7\] _0413_ _0242_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1075_ net20 _0028_ _0466_ _0411_ _0414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_1076_ net12 b_to_a_mem\[14\]\[0\] _0414_ _0243_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1077_ net13 b_to_a_mem\[14\]\[1\] _0414_ _0244_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1078_ net14 b_to_a_mem\[14\]\[2\] _0414_ _0245_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1079_ net15 b_to_a_mem\[14\]\[3\] _0414_ _0246_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1080_ net16 b_to_a_mem\[14\]\[4\] _0414_ _0247_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1081_ net17 b_to_a_mem\[14\]\[5\] _0414_ _0248_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1082_ net18 b_to_a_mem\[14\]\[6\] _0414_ _0249_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1083_ net19 b_to_a_mem\[14\]\[7\] _0414_ _0250_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1084_ net20 _0030_ _0466_ _0411_ _0415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_1085_ net12 b_to_a_mem\[15\]\[0\] _0415_ _0251_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1086_ net13 b_to_a_mem\[15\]\[1\] _0415_ _0252_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1087_ net14 b_to_a_mem\[15\]\[2\] _0415_ _0253_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1088_ net15 b_to_a_mem\[15\]\[3\] _0415_ _0254_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1089_ net16 b_to_a_mem\[15\]\[4\] _0415_ _0255_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1090_ net17 b_to_a_mem\[15\]\[5\] _0415_ _0256_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1091_ net18 b_to_a_mem\[15\]\[6\] _0415_ _0257_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1092_ net19 b_to_a_mem\[15\]\[7\] _0415_ _0258_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1093_ net20 _0029_ _0466_ _0395_ _0416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput9 a_wr_data[7] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1095_ b_to_a_mem\[1\]\[0\] net12 _0416_ _0259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1096_ b_to_a_mem\[1\]\[1\] net13 _0416_ _0260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1097_ b_to_a_mem\[1\]\[2\] net14 _0416_ _0261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1098_ b_to_a_mem\[1\]\[3\] net15 _0416_ _0262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1099_ b_to_a_mem\[1\]\[4\] net16 _0416_ _0263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1100_ b_to_a_mem\[1\]\[5\] net17 _0416_ _0264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1101_ b_to_a_mem\[1\]\[6\] net18 _0416_ _0265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1102_ b_to_a_mem\[1\]\[7\] net19 _0416_ _0266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1103_ net20 _0028_ _0466_ _0395_ _0418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput8 a_wr_data[6] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1105_ b_to_a_mem\[2\]\[0\] net12 _0418_ _0267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1106_ b_to_a_mem\[2\]\[1\] net13 _0418_ _0268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1107_ b_to_a_mem\[2\]\[2\] net14 _0418_ _0269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1108_ b_to_a_mem\[2\]\[3\] net15 _0418_ _0270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1109_ b_to_a_mem\[2\]\[4\] net16 _0418_ _0271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1110_ b_to_a_mem\[2\]\[5\] net17 _0418_ _0272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1111_ b_to_a_mem\[2\]\[6\] net18 _0418_ _0273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1112_ b_to_a_mem\[2\]\[7\] net19 _0418_ _0274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1113_ net20 _0030_ _0466_ _0395_ _0420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput7 a_wr_data[5] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1115_ b_to_a_mem\[3\]\[0\] net12 _0420_ _0275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1116_ b_to_a_mem\[3\]\[1\] net13 _0420_ _0276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1117_ b_to_a_mem\[3\]\[2\] net14 _0420_ _0277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1118_ b_to_a_mem\[3\]\[3\] net15 _0420_ _0278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1119_ b_to_a_mem\[3\]\[4\] net16 _0420_ _0279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1120_ b_to_a_mem\[3\]\[5\] net17 _0420_ _0280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1121_ b_to_a_mem\[3\]\[6\] net18 _0420_ _0281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1122_ b_to_a_mem\[3\]\[7\] net19 _0420_ _0282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1123_ _0393_ b_wr_ptr\[2\] _0422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1124_ net20 _0026_ _0466_ _0422_ _0423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput6 a_wr_data[4] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1126_ b_to_a_mem\[4\]\[0\] net12 _0423_ _0283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1127_ b_to_a_mem\[4\]\[1\] net13 _0423_ _0284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1128_ b_to_a_mem\[4\]\[2\] net14 _0423_ _0285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1129_ b_to_a_mem\[4\]\[3\] net15 _0423_ _0286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1130_ b_to_a_mem\[4\]\[4\] net16 _0423_ _0287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1131_ b_to_a_mem\[4\]\[5\] net17 _0423_ _0288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1132_ b_to_a_mem\[4\]\[6\] net18 _0423_ _0289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1133_ b_to_a_mem\[4\]\[7\] net19 _0423_ _0290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1134_ net20 _0029_ _0466_ _0422_ _0425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput5 a_wr_data[3] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1136_ b_to_a_mem\[5\]\[0\] net12 _0425_ _0291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1137_ b_to_a_mem\[5\]\[1\] net13 _0425_ _0292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1138_ b_to_a_mem\[5\]\[2\] net14 _0425_ _0293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1139_ b_to_a_mem\[5\]\[3\] net15 _0425_ _0294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1140_ b_to_a_mem\[5\]\[4\] net16 _0425_ _0295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1141_ b_to_a_mem\[5\]\[5\] net17 _0425_ _0296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1142_ b_to_a_mem\[5\]\[6\] net18 _0425_ _0297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1143_ b_to_a_mem\[5\]\[7\] net19 _0425_ _0298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1144_ net20 _0028_ _0466_ _0422_ _0427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput4 a_wr_data[2] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1146_ b_to_a_mem\[6\]\[0\] net12 _0427_ _0299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1147_ b_to_a_mem\[6\]\[1\] net13 _0427_ _0300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1148_ b_to_a_mem\[6\]\[2\] net14 _0427_ _0301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1149_ b_to_a_mem\[6\]\[3\] net15 _0427_ _0302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1150_ b_to_a_mem\[6\]\[4\] net16 _0427_ _0303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1151_ b_to_a_mem\[6\]\[5\] net17 _0427_ _0304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1152_ b_to_a_mem\[6\]\[6\] net18 _0427_ _0305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1153_ b_to_a_mem\[6\]\[7\] net19 _0427_ _0306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1154_ net20 _0030_ _0466_ _0422_ _0429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput3 a_wr_data[1] net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1156_ b_to_a_mem\[7\]\[0\] net12 _0429_ _0307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1157_ b_to_a_mem\[7\]\[1\] net13 _0429_ _0308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1158_ b_to_a_mem\[7\]\[2\] net14 _0429_ _0309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1159_ b_to_a_mem\[7\]\[3\] net15 _0429_ _0310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1160_ b_to_a_mem\[7\]\[4\] net16 _0429_ _0311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1161_ b_to_a_mem\[7\]\[5\] net17 _0429_ _0312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1162_ b_to_a_mem\[7\]\[6\] net18 _0429_ _0313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1163_ b_to_a_mem\[7\]\[7\] net19 _0429_ _0314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1164_ net20 _0026_ _0466_ _0405_ _0431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput2 a_wr_data[0] net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1166_ b_to_a_mem\[8\]\[0\] net12 _0431_ _0315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1167_ b_to_a_mem\[8\]\[1\] net13 _0431_ _0316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1168_ b_to_a_mem\[8\]\[2\] net14 _0431_ _0317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1169_ b_to_a_mem\[8\]\[3\] net15 _0431_ _0318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1170_ b_to_a_mem\[8\]\[4\] net16 _0431_ _0319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1171_ b_to_a_mem\[8\]\[5\] net17 _0431_ _0320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1172_ b_to_a_mem\[8\]\[6\] net18 _0431_ _0321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1173_ b_to_a_mem\[8\]\[7\] net19 _0431_ _0322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1174_ net20 _0029_ _0466_ _0405_ _0433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput1 a_rd_en net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1176_ b_to_a_mem\[9\]\[0\] net12 _0433_ _0323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1177_ b_to_a_mem\[9\]\[1\] net13 _0433_ _0324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1178_ b_to_a_mem\[9\]\[2\] net14 _0433_ _0325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1179_ b_to_a_mem\[9\]\[3\] net15 _0433_ _0326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1180_ b_to_a_mem\[9\]\[4\] net16 _0433_ _0327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1181_ b_to_a_mem\[9\]\[5\] net17 _0433_ _0328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1182_ b_to_a_mem\[9\]\[6\] net18 _0433_ _0329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1183_ b_to_a_mem\[9\]\[7\] net19 _0433_ _0330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1184_ net20 _0466_ _0435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1185_ b_wr_ptr\[0\] _0435_ _0331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1186_ _0027_ b_wr_ptr\[1\] _0435_ _0332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1187_ net20 _0030_ _0466_ _0436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1188_ _0394_ _0436_ _0333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1189_ net20 b_wr_ptr\[2\] b_wr_ptr\[1\] b_wr_ptr\[0\] _0437_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1190_ _0466_ _0437_ _0438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1191_ _0393_ _0438_ _0334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1192_ b_wr_ptr\[4\] _0415_ _0335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1193_ net52 _0043_ _0439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1194_ _0453_ _0458_ _0459_ _0439_ net22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1195_ _0463_ _0458_ _0459_ _0453_ net23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1196_ net35 _0041_ _0440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_1197_ net38 net37 net36 _0440_ net39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_1198_ net35 net37 net36 _0441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1199_ net38 _0441_ net40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1200_ a_wr_ptr\[1\] _0000_ _0001_ _0002_ net35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_1201_ _0003_ b_wr_ptr\[1\] _0004_ _0005_ net52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_1202_ _0006_ b_wr_ptr\[3\] _0007_ _0008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1203_ _0470_ b_wr_ptr\[2\] _0010_ _0011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1204_ _0003_ b_wr_ptr\[1\] _0012_ _0013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1205_ a_wr_ptr\[2\] _0014_ _0015_ _0016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1206_ a_wr_ptr\[1\] _0000_ _0017_ _0018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1207_ a_wr_ptr\[3\] _0019_ _0020_ _0021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1208_ net61 b_rd_ptr\[1\] _0022_ _0023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1209_ _0024_ _0025_ _0026_ _0027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1210_ _0024_ b_wr_ptr\[1\] _0028_ _0605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1211_ b_wr_ptr\[0\] _0025_ _0029_ _0606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1212_ b_wr_ptr\[0\] b_wr_ptr\[1\] _0030_ _0607_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1213_ net62 a_rd_ptr\[1\] _0031_ _0032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1214_ _0033_ _0034_ _0035_ _0036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1215_ _0033_ a_wr_ptr\[1\] _0037_ _0608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1216_ a_wr_ptr\[0\] _0034_ _0038_ _0609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1217_ a_wr_ptr\[0\] a_wr_ptr\[1\] _0039_ _0610_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1218_ _0033_ b_rd_ptr\[0\] _0040_ _0041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1219_ net62 _0024_ _0042_ _0043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
Xa_rd_data_reg\[0\]$_DFFE_PN0P_ _0044_ net63 clknet_leaf_10_clk
+ net26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_data_reg\[1\]$_DFFE_PN0P_ _0045_ net63 clknet_leaf_7_clk
+ net27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_data_reg\[2\]$_DFFE_PN0P_ _0046_ net63 clknet_leaf_9_clk
+ net28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_data_reg\[3\]$_DFFE_PN0P_ _0047_ net63 clknet_leaf_9_clk
+ net29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_data_reg\[4\]$_DFFE_PN0P_ _0048_ net63 clknet_leaf_11_clk
+ net30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_data_reg\[5\]$_DFFE_PN0P_ _0049_ net63 clknet_leaf_11_clk
+ net31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_data_reg\[6\]$_DFFE_PN0P_ _0050_ net63 clknet_leaf_12_clk
+ net32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_data_reg\[7\]$_DFFE_PN0P_ _0051_ net63 clknet_leaf_7_clk
+ net33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_ptr\[0\]$_DFFE_PN0P_ _0052_ net63 clknet_leaf_12_clk
+ a_rd_ptr\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_ptr\[1\]$_DFFE_PN0P_ _0053_ net63 clknet_leaf_11_clk
+ a_rd_ptr\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_ptr\[2\]$_DFFE_PN0P_ _0054_ net63 clknet_leaf_11_clk
+ a_rd_ptr\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_ptr\[3\]$_DFFE_PN0P_ _0055_ net63 clknet_leaf_11_clk
+ a_rd_ptr\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_rd_ptr\[4\]$_DFFE_PN0P_ _0056_ net63 clknet_leaf_12_clk
+ a_rd_ptr\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_to_b_mem\[0\]\[0\]$_DFFE_PP_ _0057_ clknet_leaf_5_clk a_to_b_mem\[0\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[0\]\[1\]$_DFFE_PP_ _0058_ clknet_leaf_5_clk a_to_b_mem\[0\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[0\]\[2\]$_DFFE_PP_ _0059_ clknet_leaf_6_clk a_to_b_mem\[0\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[0\]\[3\]$_DFFE_PP_ _0060_ clknet_leaf_4_clk a_to_b_mem\[0\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[0\]\[4\]$_DFFE_PP_ _0061_ clknet_leaf_3_clk a_to_b_mem\[0\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[0\]\[5\]$_DFFE_PP_ _0062_ clknet_leaf_6_clk a_to_b_mem\[0\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[0\]\[6\]$_DFFE_PP_ _0063_ clknet_leaf_4_clk a_to_b_mem\[0\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[0\]\[7\]$_DFFE_PP_ _0064_ clknet_leaf_5_clk a_to_b_mem\[0\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[10\]\[0\]$_DFFE_PP_ _0065_ clknet_leaf_3_clk
+ a_to_b_mem\[10\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[10\]\[1\]$_DFFE_PP_ _0066_ clknet_leaf_3_clk
+ a_to_b_mem\[10\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[10\]\[2\]$_DFFE_PP_ _0067_ clknet_leaf_3_clk
+ a_to_b_mem\[10\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[10\]\[3\]$_DFFE_PP_ _0068_ clknet_leaf_1_clk
+ a_to_b_mem\[10\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[10\]\[4\]$_DFFE_PP_ _0069_ clknet_leaf_1_clk
+ a_to_b_mem\[10\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[10\]\[5\]$_DFFE_PP_ _0070_ clknet_leaf_2_clk
+ a_to_b_mem\[10\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[10\]\[6\]$_DFFE_PP_ _0071_ clknet_leaf_2_clk
+ a_to_b_mem\[10\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[10\]\[7\]$_DFFE_PP_ _0072_ clknet_leaf_2_clk
+ a_to_b_mem\[10\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[11\]\[0\]$_DFFE_PP_ _0073_ clknet_leaf_3_clk
+ a_to_b_mem\[11\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[11\]\[1\]$_DFFE_PP_ _0074_ clknet_leaf_3_clk
+ a_to_b_mem\[11\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[11\]\[2\]$_DFFE_PP_ _0075_ clknet_leaf_3_clk
+ a_to_b_mem\[11\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[11\]\[3\]$_DFFE_PP_ _0076_ clknet_leaf_1_clk
+ a_to_b_mem\[11\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[11\]\[4\]$_DFFE_PP_ _0077_ clknet_leaf_1_clk
+ a_to_b_mem\[11\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[11\]\[5\]$_DFFE_PP_ _0078_ clknet_leaf_2_clk
+ a_to_b_mem\[11\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[11\]\[6\]$_DFFE_PP_ _0079_ clknet_leaf_2_clk
+ a_to_b_mem\[11\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[11\]\[7\]$_DFFE_PP_ _0080_ clknet_leaf_2_clk
+ a_to_b_mem\[11\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[12\]\[0\]$_DFFE_PP_ _0081_ clknet_leaf_4_clk
+ a_to_b_mem\[12\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[12\]\[1\]$_DFFE_PP_ _0082_ clknet_leaf_4_clk
+ a_to_b_mem\[12\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[12\]\[2\]$_DFFE_PP_ _0083_ clknet_leaf_4_clk
+ a_to_b_mem\[12\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[12\]\[3\]$_DFFE_PP_ _0084_ clknet_leaf_1_clk
+ a_to_b_mem\[12\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[12\]\[4\]$_DFFE_PP_ _0085_ clknet_leaf_3_clk
+ a_to_b_mem\[12\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[12\]\[5\]$_DFFE_PP_ _0086_ clknet_leaf_2_clk
+ a_to_b_mem\[12\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[12\]\[6\]$_DFFE_PP_ _0087_ clknet_leaf_2_clk
+ a_to_b_mem\[12\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[12\]\[7\]$_DFFE_PP_ _0088_ clknet_leaf_3_clk
+ a_to_b_mem\[12\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[13\]\[0\]$_DFFE_PP_ _0089_ clknet_leaf_3_clk
+ a_to_b_mem\[13\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[13\]\[1\]$_DFFE_PP_ _0090_ clknet_leaf_3_clk
+ a_to_b_mem\[13\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[13\]\[2\]$_DFFE_PP_ _0091_ clknet_leaf_3_clk
+ a_to_b_mem\[13\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[13\]\[3\]$_DFFE_PP_ _0092_ clknet_leaf_1_clk
+ a_to_b_mem\[13\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[13\]\[4\]$_DFFE_PP_ _0093_ clknet_leaf_1_clk
+ a_to_b_mem\[13\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[13\]\[5\]$_DFFE_PP_ _0094_ clknet_leaf_2_clk
+ a_to_b_mem\[13\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[13\]\[6\]$_DFFE_PP_ _0095_ clknet_leaf_2_clk
+ a_to_b_mem\[13\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[13\]\[7\]$_DFFE_PP_ _0096_ clknet_leaf_3_clk
+ a_to_b_mem\[13\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[14\]\[0\]$_DFFE_PP_ _0097_ clknet_leaf_3_clk
+ a_to_b_mem\[14\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[14\]\[1\]$_DFFE_PP_ _0098_ clknet_leaf_3_clk
+ a_to_b_mem\[14\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[14\]\[2\]$_DFFE_PP_ _0099_ clknet_leaf_3_clk
+ a_to_b_mem\[14\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[14\]\[3\]$_DFFE_PP_ _0100_ clknet_leaf_1_clk
+ a_to_b_mem\[14\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[14\]\[4\]$_DFFE_PP_ _0101_ clknet_leaf_1_clk
+ a_to_b_mem\[14\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[14\]\[5\]$_DFFE_PP_ _0102_ clknet_leaf_2_clk
+ a_to_b_mem\[14\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[14\]\[6\]$_DFFE_PP_ _0103_ clknet_leaf_1_clk
+ a_to_b_mem\[14\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[14\]\[7\]$_DFFE_PP_ _0104_ clknet_leaf_2_clk
+ a_to_b_mem\[14\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[15\]\[0\]$_DFFE_PP_ _0105_ clknet_leaf_4_clk
+ a_to_b_mem\[15\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[15\]\[1\]$_DFFE_PP_ _0106_ clknet_leaf_3_clk
+ a_to_b_mem\[15\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[15\]\[2\]$_DFFE_PP_ _0107_ clknet_leaf_4_clk
+ a_to_b_mem\[15\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[15\]\[3\]$_DFFE_PP_ _0108_ clknet_leaf_1_clk
+ a_to_b_mem\[15\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[15\]\[4\]$_DFFE_PP_ _0109_ clknet_leaf_1_clk
+ a_to_b_mem\[15\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[15\]\[5\]$_DFFE_PP_ _0110_ clknet_leaf_2_clk
+ a_to_b_mem\[15\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[15\]\[6\]$_DFFE_PP_ _0111_ clknet_leaf_1_clk
+ a_to_b_mem\[15\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[15\]\[7\]$_DFFE_PP_ _0112_ clknet_leaf_2_clk
+ a_to_b_mem\[15\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[1\]\[0\]$_DFFE_PP_ _0113_ clknet_leaf_5_clk a_to_b_mem\[1\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[1\]\[1\]$_DFFE_PP_ _0114_ clknet_leaf_5_clk a_to_b_mem\[1\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[1\]\[2\]$_DFFE_PP_ _0115_ clknet_leaf_6_clk a_to_b_mem\[1\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[1\]\[3\]$_DFFE_PP_ _0116_ clknet_leaf_4_clk a_to_b_mem\[1\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[1\]\[4\]$_DFFE_PP_ _0117_ clknet_leaf_3_clk a_to_b_mem\[1\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[1\]\[5\]$_DFFE_PP_ _0118_ clknet_leaf_6_clk a_to_b_mem\[1\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[1\]\[6\]$_DFFE_PP_ _0119_ clknet_leaf_5_clk a_to_b_mem\[1\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[1\]\[7\]$_DFFE_PP_ _0120_ clknet_leaf_5_clk a_to_b_mem\[1\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[2\]\[0\]$_DFFE_PP_ _0121_ clknet_leaf_6_clk a_to_b_mem\[2\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[2\]\[1\]$_DFFE_PP_ _0122_ clknet_leaf_6_clk a_to_b_mem\[2\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[2\]\[2\]$_DFFE_PP_ _0123_ clknet_leaf_6_clk a_to_b_mem\[2\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[2\]\[3\]$_DFFE_PP_ _0124_ clknet_leaf_4_clk a_to_b_mem\[2\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[2\]\[4\]$_DFFE_PP_ _0125_ clknet_leaf_3_clk a_to_b_mem\[2\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[2\]\[5\]$_DFFE_PP_ _0126_ clknet_leaf_6_clk a_to_b_mem\[2\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[2\]\[6\]$_DFFE_PP_ _0127_ clknet_leaf_4_clk a_to_b_mem\[2\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[2\]\[7\]$_DFFE_PP_ _0128_ clknet_leaf_4_clk a_to_b_mem\[2\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[3\]\[0\]$_DFFE_PP_ _0129_ clknet_leaf_6_clk a_to_b_mem\[3\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[3\]\[1\]$_DFFE_PP_ _0130_ clknet_leaf_6_clk a_to_b_mem\[3\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[3\]\[2\]$_DFFE_PP_ _0131_ clknet_leaf_6_clk a_to_b_mem\[3\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[3\]\[3\]$_DFFE_PP_ _0132_ clknet_leaf_7_clk a_to_b_mem\[3\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[3\]\[4\]$_DFFE_PP_ _0133_ clknet_leaf_3_clk a_to_b_mem\[3\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[3\]\[5\]$_DFFE_PP_ _0134_ clknet_leaf_6_clk a_to_b_mem\[3\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[3\]\[6\]$_DFFE_PP_ _0135_ clknet_leaf_4_clk a_to_b_mem\[3\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[3\]\[7\]$_DFFE_PP_ _0136_ clknet_leaf_5_clk a_to_b_mem\[3\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[4\]\[0\]$_DFFE_PP_ _0137_ clknet_leaf_5_clk a_to_b_mem\[4\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[4\]\[1\]$_DFFE_PP_ _0138_ clknet_leaf_5_clk a_to_b_mem\[4\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[4\]\[2\]$_DFFE_PP_ _0139_ clknet_leaf_6_clk a_to_b_mem\[4\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[4\]\[3\]$_DFFE_PP_ _0140_ clknet_leaf_4_clk a_to_b_mem\[4\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[4\]\[4\]$_DFFE_PP_ _0141_ clknet_leaf_3_clk a_to_b_mem\[4\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[4\]\[5\]$_DFFE_PP_ _0142_ clknet_leaf_6_clk a_to_b_mem\[4\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[4\]\[6\]$_DFFE_PP_ _0143_ clknet_leaf_4_clk a_to_b_mem\[4\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[4\]\[7\]$_DFFE_PP_ _0144_ clknet_leaf_5_clk a_to_b_mem\[4\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[5\]\[0\]$_DFFE_PP_ _0145_ clknet_leaf_5_clk a_to_b_mem\[5\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[5\]\[1\]$_DFFE_PP_ _0146_ clknet_leaf_5_clk a_to_b_mem\[5\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[5\]\[2\]$_DFFE_PP_ _0147_ clknet_leaf_6_clk a_to_b_mem\[5\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[5\]\[3\]$_DFFE_PP_ _0148_ clknet_leaf_4_clk a_to_b_mem\[5\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[5\]\[4\]$_DFFE_PP_ _0149_ clknet_leaf_3_clk a_to_b_mem\[5\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[5\]\[5\]$_DFFE_PP_ _0150_ clknet_leaf_6_clk a_to_b_mem\[5\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[5\]\[6\]$_DFFE_PP_ _0151_ clknet_leaf_4_clk a_to_b_mem\[5\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[5\]\[7\]$_DFFE_PP_ _0152_ clknet_leaf_5_clk a_to_b_mem\[5\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[6\]\[0\]$_DFFE_PP_ _0153_ clknet_leaf_6_clk a_to_b_mem\[6\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[6\]\[1\]$_DFFE_PP_ _0154_ clknet_leaf_6_clk a_to_b_mem\[6\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[6\]\[2\]$_DFFE_PP_ _0155_ clknet_leaf_6_clk a_to_b_mem\[6\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[6\]\[3\]$_DFFE_PP_ _0156_ clknet_leaf_4_clk a_to_b_mem\[6\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[6\]\[4\]$_DFFE_PP_ _0157_ clknet_leaf_3_clk a_to_b_mem\[6\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[6\]\[5\]$_DFFE_PP_ _0158_ clknet_leaf_6_clk a_to_b_mem\[6\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[6\]\[6\]$_DFFE_PP_ _0159_ clknet_leaf_4_clk a_to_b_mem\[6\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[6\]\[7\]$_DFFE_PP_ _0160_ clknet_leaf_4_clk a_to_b_mem\[6\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[7\]\[0\]$_DFFE_PP_ _0161_ clknet_leaf_6_clk a_to_b_mem\[7\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[7\]\[1\]$_DFFE_PP_ _0162_ clknet_leaf_6_clk a_to_b_mem\[7\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[7\]\[2\]$_DFFE_PP_ _0163_ clknet_leaf_6_clk a_to_b_mem\[7\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[7\]\[3\]$_DFFE_PP_ _0164_ clknet_leaf_7_clk a_to_b_mem\[7\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[7\]\[4\]$_DFFE_PP_ _0165_ clknet_leaf_3_clk a_to_b_mem\[7\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[7\]\[5\]$_DFFE_PP_ _0166_ clknet_leaf_7_clk a_to_b_mem\[7\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[7\]\[6\]$_DFFE_PP_ _0167_ clknet_leaf_4_clk a_to_b_mem\[7\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[7\]\[7\]$_DFFE_PP_ _0168_ clknet_leaf_4_clk a_to_b_mem\[7\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[8\]\[0\]$_DFFE_PP_ _0169_ clknet_leaf_5_clk a_to_b_mem\[8\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[8\]\[1\]$_DFFE_PP_ _0170_ clknet_leaf_5_clk a_to_b_mem\[8\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[8\]\[2\]$_DFFE_PP_ _0171_ clknet_leaf_4_clk a_to_b_mem\[8\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[8\]\[3\]$_DFFE_PP_ _0172_ clknet_leaf_1_clk a_to_b_mem\[8\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[8\]\[4\]$_DFFE_PP_ _0173_ clknet_leaf_1_clk a_to_b_mem\[8\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[8\]\[5\]$_DFFE_PP_ _0174_ clknet_leaf_2_clk a_to_b_mem\[8\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[8\]\[6\]$_DFFE_PP_ _0175_ clknet_leaf_2_clk a_to_b_mem\[8\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[8\]\[7\]$_DFFE_PP_ _0176_ clknet_leaf_2_clk a_to_b_mem\[8\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[9\]\[0\]$_DFFE_PP_ _0177_ clknet_leaf_4_clk a_to_b_mem\[9\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[9\]\[1\]$_DFFE_PP_ _0178_ clknet_leaf_3_clk a_to_b_mem\[9\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[9\]\[2\]$_DFFE_PP_ _0179_ clknet_leaf_4_clk a_to_b_mem\[9\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[9\]\[3\]$_DFFE_PP_ _0180_ clknet_leaf_1_clk a_to_b_mem\[9\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[9\]\[4\]$_DFFE_PP_ _0181_ clknet_leaf_1_clk a_to_b_mem\[9\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[9\]\[5\]$_DFFE_PP_ _0182_ clknet_leaf_2_clk a_to_b_mem\[9\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[9\]\[6\]$_DFFE_PP_ _0183_ clknet_leaf_2_clk a_to_b_mem\[9\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_to_b_mem\[9\]\[7\]$_DFFE_PP_ _0184_ clknet_leaf_2_clk a_to_b_mem\[9\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xa_wr_ptr\[0\]$_DFFE_PN0P_ _0185_ net63 clknet_leaf_0_clk
+ a_wr_ptr\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_wr_ptr\[1\]$_DFFE_PN0P_ _0186_ net63 clknet_leaf_0_clk
+ a_wr_ptr\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_wr_ptr\[2\]$_DFFE_PN0P_ _0187_ net63 clknet_leaf_1_clk
+ a_wr_ptr\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_wr_ptr\[3\]$_DFFE_PN0P_ _0188_ net63 clknet_leaf_1_clk
+ a_wr_ptr\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xa_wr_ptr\[4\]$_DFFE_PN0P_ _0189_ net63 clknet_leaf_1_clk
+ a_wr_ptr\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_data_reg\[0\]$_DFFE_PN0P_ _0190_ net63 clknet_leaf_5_clk
+ net43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_data_reg\[1\]$_DFFE_PN0P_ _0191_ net63 clknet_leaf_5_clk
+ net44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_data_reg\[2\]$_DFFE_PN0P_ _0192_ net63 clknet_leaf_5_clk
+ net45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_data_reg\[3\]$_DFFE_PN0P_ _0193_ net63 clknet_leaf_1_clk
+ net46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_data_reg\[4\]$_DFFE_PN0P_ _0194_ net63 clknet_leaf_2_clk
+ net47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_data_reg\[5\]$_DFFE_PN0P_ _0195_ net63 clknet_leaf_2_clk
+ net48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_data_reg\[6\]$_DFFE_PN0P_ _0196_ net63 clknet_leaf_2_clk
+ net49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_data_reg\[7\]$_DFFE_PN0P_ _0197_ net63 clknet_leaf_2_clk
+ net50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_ptr\[0\]$_DFFE_PN0P_ _0198_ net63 clknet_leaf_1_clk
+ b_rd_ptr\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_ptr\[1\]$_DFFE_PN0P_ _0199_ net63 clknet_leaf_1_clk
+ b_rd_ptr\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_ptr\[2\]$_DFFE_PN0P_ _0200_ net63 clknet_leaf_1_clk
+ b_rd_ptr\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_ptr\[3\]$_DFFE_PN0P_ _0201_ net63 clknet_leaf_1_clk
+ b_rd_ptr\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_rd_ptr\[4\]$_DFFE_PN0P_ _0202_ net63 clknet_leaf_1_clk
+ b_rd_ptr\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_to_a_mem\[0\]\[0\]$_DFFE_PP_ _0203_ clknet_leaf_8_clk b_to_a_mem\[0\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[0\]\[1\]$_DFFE_PP_ _0204_ clknet_leaf_8_clk b_to_a_mem\[0\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[0\]\[2\]$_DFFE_PP_ _0205_ clknet_leaf_8_clk b_to_a_mem\[0\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[0\]\[3\]$_DFFE_PP_ _0206_ clknet_leaf_9_clk b_to_a_mem\[0\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[0\]\[4\]$_DFFE_PP_ _0207_ clknet_leaf_10_clk
+ b_to_a_mem\[0\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[0\]\[5\]$_DFFE_PP_ _0208_ clknet_leaf_10_clk
+ b_to_a_mem\[0\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[0\]\[6\]$_DFFE_PP_ _0209_ clknet_leaf_10_clk
+ b_to_a_mem\[0\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[0\]\[7\]$_DFFE_PP_ _0210_ clknet_leaf_8_clk b_to_a_mem\[0\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[10\]\[0\]$_DFFE_PP_ _0211_ clknet_leaf_7_clk
+ b_to_a_mem\[10\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[10\]\[1\]$_DFFE_PP_ _0212_ clknet_leaf_7_clk
+ b_to_a_mem\[10\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[10\]\[2\]$_DFFE_PP_ _0213_ clknet_leaf_10_clk
+ b_to_a_mem\[10\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[10\]\[3\]$_DFFE_PP_ _0214_ clknet_leaf_7_clk
+ b_to_a_mem\[10\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[10\]\[4\]$_DFFE_PP_ _0215_ clknet_leaf_0_clk
+ b_to_a_mem\[10\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[10\]\[5\]$_DFFE_PP_ _0216_ clknet_leaf_10_clk
+ b_to_a_mem\[10\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[10\]\[6\]$_DFFE_PP_ _0217_ clknet_leaf_11_clk
+ b_to_a_mem\[10\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[10\]\[7\]$_DFFE_PP_ _0218_ clknet_leaf_10_clk
+ b_to_a_mem\[10\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[11\]\[0\]$_DFFE_PP_ _0219_ clknet_leaf_7_clk
+ b_to_a_mem\[11\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[11\]\[1\]$_DFFE_PP_ _0220_ clknet_leaf_7_clk
+ b_to_a_mem\[11\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[11\]\[2\]$_DFFE_PP_ _0221_ clknet_leaf_10_clk
+ b_to_a_mem\[11\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[11\]\[3\]$_DFFE_PP_ _0222_ clknet_leaf_7_clk
+ b_to_a_mem\[11\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[11\]\[4\]$_DFFE_PP_ _0223_ clknet_leaf_11_clk
+ b_to_a_mem\[11\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[11\]\[5\]$_DFFE_PP_ _0224_ clknet_leaf_10_clk
+ b_to_a_mem\[11\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[11\]\[6\]$_DFFE_PP_ _0225_ clknet_leaf_11_clk
+ b_to_a_mem\[11\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[11\]\[7\]$_DFFE_PP_ _0226_ clknet_leaf_7_clk
+ b_to_a_mem\[11\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[12\]\[0\]$_DFFE_PP_ _0227_ clknet_leaf_11_clk
+ b_to_a_mem\[12\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[12\]\[1\]$_DFFE_PP_ _0228_ clknet_leaf_11_clk
+ b_to_a_mem\[12\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[12\]\[2\]$_DFFE_PP_ _0229_ clknet_leaf_11_clk
+ b_to_a_mem\[12\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[12\]\[3\]$_DFFE_PP_ _0230_ clknet_leaf_0_clk
+ b_to_a_mem\[12\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[12\]\[4\]$_DFFE_PP_ _0231_ clknet_leaf_0_clk
+ b_to_a_mem\[12\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[12\]\[5\]$_DFFE_PP_ _0232_ clknet_leaf_11_clk
+ b_to_a_mem\[12\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[12\]\[6\]$_DFFE_PP_ _0233_ clknet_leaf_0_clk
+ b_to_a_mem\[12\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[12\]\[7\]$_DFFE_PP_ _0234_ clknet_leaf_0_clk
+ b_to_a_mem\[12\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[13\]\[0\]$_DFFE_PP_ _0235_ clknet_leaf_0_clk
+ b_to_a_mem\[13\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[13\]\[1\]$_DFFE_PP_ _0236_ clknet_leaf_11_clk
+ b_to_a_mem\[13\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[13\]\[2\]$_DFFE_PP_ _0237_ clknet_leaf_0_clk
+ b_to_a_mem\[13\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[13\]\[3\]$_DFFE_PP_ _0238_ clknet_leaf_0_clk
+ b_to_a_mem\[13\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[13\]\[4\]$_DFFE_PP_ _0239_ clknet_leaf_0_clk
+ b_to_a_mem\[13\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[13\]\[5\]$_DFFE_PP_ _0240_ clknet_leaf_11_clk
+ b_to_a_mem\[13\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[13\]\[6\]$_DFFE_PP_ _0241_ clknet_leaf_0_clk
+ b_to_a_mem\[13\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[13\]\[7\]$_DFFE_PP_ _0242_ clknet_leaf_0_clk
+ b_to_a_mem\[13\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[14\]\[0\]$_DFFE_PP_ _0243_ clknet_leaf_0_clk
+ b_to_a_mem\[14\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[14\]\[1\]$_DFFE_PP_ _0244_ clknet_leaf_11_clk
+ b_to_a_mem\[14\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[14\]\[2\]$_DFFE_PP_ _0245_ clknet_leaf_0_clk
+ b_to_a_mem\[14\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[14\]\[3\]$_DFFE_PP_ _0246_ clknet_leaf_0_clk
+ b_to_a_mem\[14\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[14\]\[4\]$_DFFE_PP_ _0247_ clknet_leaf_0_clk
+ b_to_a_mem\[14\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[14\]\[5\]$_DFFE_PP_ _0248_ clknet_leaf_11_clk
+ b_to_a_mem\[14\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[14\]\[6\]$_DFFE_PP_ _0249_ clknet_leaf_12_clk
+ b_to_a_mem\[14\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[14\]\[7\]$_DFFE_PP_ _0250_ clknet_leaf_0_clk
+ b_to_a_mem\[14\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[15\]\[0\]$_DFFE_PP_ _0251_ clknet_leaf_0_clk
+ b_to_a_mem\[15\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[15\]\[1\]$_DFFE_PP_ _0252_ clknet_leaf_11_clk
+ b_to_a_mem\[15\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[15\]\[2\]$_DFFE_PP_ _0253_ clknet_leaf_0_clk
+ b_to_a_mem\[15\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[15\]\[3\]$_DFFE_PP_ _0254_ clknet_leaf_0_clk
+ b_to_a_mem\[15\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[15\]\[4\]$_DFFE_PP_ _0255_ clknet_leaf_12_clk
+ b_to_a_mem\[15\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[15\]\[5\]$_DFFE_PP_ _0256_ clknet_leaf_11_clk
+ b_to_a_mem\[15\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[15\]\[6\]$_DFFE_PP_ _0257_ clknet_leaf_12_clk
+ b_to_a_mem\[15\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[15\]\[7\]$_DFFE_PP_ _0258_ clknet_leaf_0_clk
+ b_to_a_mem\[15\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[1\]\[0\]$_DFFE_PP_ _0259_ clknet_leaf_8_clk b_to_a_mem\[1\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[1\]\[1\]$_DFFE_PP_ _0260_ clknet_leaf_8_clk b_to_a_mem\[1\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[1\]\[2\]$_DFFE_PP_ _0261_ clknet_leaf_8_clk b_to_a_mem\[1\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[1\]\[3\]$_DFFE_PP_ _0262_ clknet_leaf_9_clk b_to_a_mem\[1\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[1\]\[4\]$_DFFE_PP_ _0263_ clknet_leaf_10_clk
+ b_to_a_mem\[1\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[1\]\[5\]$_DFFE_PP_ _0264_ clknet_leaf_10_clk
+ b_to_a_mem\[1\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[1\]\[6\]$_DFFE_PP_ _0265_ clknet_leaf_11_clk
+ b_to_a_mem\[1\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[1\]\[7\]$_DFFE_PP_ _0266_ clknet_leaf_8_clk b_to_a_mem\[1\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[2\]\[0\]$_DFFE_PP_ _0267_ clknet_leaf_8_clk b_to_a_mem\[2\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[2\]\[1\]$_DFFE_PP_ _0268_ clknet_leaf_8_clk b_to_a_mem\[2\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[2\]\[2\]$_DFFE_PP_ _0269_ clknet_leaf_8_clk b_to_a_mem\[2\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[2\]\[3\]$_DFFE_PP_ _0270_ clknet_leaf_9_clk b_to_a_mem\[2\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[2\]\[4\]$_DFFE_PP_ _0271_ clknet_leaf_9_clk b_to_a_mem\[2\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[2\]\[5\]$_DFFE_PP_ _0272_ clknet_leaf_9_clk b_to_a_mem\[2\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[2\]\[6\]$_DFFE_PP_ _0273_ clknet_leaf_11_clk
+ b_to_a_mem\[2\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[2\]\[7\]$_DFFE_PP_ _0274_ clknet_leaf_8_clk b_to_a_mem\[2\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[3\]\[0\]$_DFFE_PP_ _0275_ clknet_leaf_8_clk b_to_a_mem\[3\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[3\]\[1\]$_DFFE_PP_ _0276_ clknet_leaf_8_clk b_to_a_mem\[3\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[3\]\[2\]$_DFFE_PP_ _0277_ clknet_leaf_8_clk b_to_a_mem\[3\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[3\]\[3\]$_DFFE_PP_ _0278_ clknet_leaf_9_clk b_to_a_mem\[3\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[3\]\[4\]$_DFFE_PP_ _0279_ clknet_leaf_9_clk b_to_a_mem\[3\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[3\]\[5\]$_DFFE_PP_ _0280_ clknet_leaf_9_clk b_to_a_mem\[3\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[3\]\[6\]$_DFFE_PP_ _0281_ clknet_leaf_11_clk
+ b_to_a_mem\[3\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[3\]\[7\]$_DFFE_PP_ _0282_ clknet_leaf_8_clk b_to_a_mem\[3\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[4\]\[0\]$_DFFE_PP_ _0283_ clknet_leaf_7_clk b_to_a_mem\[4\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[4\]\[1\]$_DFFE_PP_ _0284_ clknet_leaf_7_clk b_to_a_mem\[4\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[4\]\[2\]$_DFFE_PP_ _0285_ clknet_leaf_8_clk b_to_a_mem\[4\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[4\]\[3\]$_DFFE_PP_ _0286_ clknet_leaf_9_clk b_to_a_mem\[4\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[4\]\[4\]$_DFFE_PP_ _0287_ clknet_leaf_10_clk
+ b_to_a_mem\[4\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[4\]\[5\]$_DFFE_PP_ _0288_ clknet_leaf_10_clk
+ b_to_a_mem\[4\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[4\]\[6\]$_DFFE_PP_ _0289_ clknet_leaf_11_clk
+ b_to_a_mem\[4\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[4\]\[7\]$_DFFE_PP_ _0290_ clknet_leaf_8_clk b_to_a_mem\[4\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[5\]\[0\]$_DFFE_PP_ _0291_ clknet_leaf_7_clk b_to_a_mem\[5\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[5\]\[1\]$_DFFE_PP_ _0292_ clknet_leaf_8_clk b_to_a_mem\[5\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[5\]\[2\]$_DFFE_PP_ _0293_ clknet_leaf_8_clk b_to_a_mem\[5\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[5\]\[3\]$_DFFE_PP_ _0294_ clknet_leaf_9_clk b_to_a_mem\[5\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[5\]\[4\]$_DFFE_PP_ _0295_ clknet_leaf_10_clk
+ b_to_a_mem\[5\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[5\]\[5\]$_DFFE_PP_ _0296_ clknet_leaf_10_clk
+ b_to_a_mem\[5\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[5\]\[6\]$_DFFE_PP_ _0297_ clknet_leaf_11_clk
+ b_to_a_mem\[5\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[5\]\[7\]$_DFFE_PP_ _0298_ clknet_leaf_7_clk b_to_a_mem\[5\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[6\]\[0\]$_DFFE_PP_ _0299_ clknet_leaf_9_clk b_to_a_mem\[6\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[6\]\[1\]$_DFFE_PP_ _0300_ clknet_leaf_9_clk b_to_a_mem\[6\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[6\]\[2\]$_DFFE_PP_ _0301_ clknet_leaf_9_clk b_to_a_mem\[6\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[6\]\[3\]$_DFFE_PP_ _0302_ clknet_leaf_9_clk b_to_a_mem\[6\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[6\]\[4\]$_DFFE_PP_ _0303_ clknet_leaf_9_clk b_to_a_mem\[6\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[6\]\[5\]$_DFFE_PP_ _0304_ clknet_leaf_10_clk
+ b_to_a_mem\[6\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[6\]\[6\]$_DFFE_PP_ _0305_ clknet_leaf_12_clk
+ b_to_a_mem\[6\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[6\]\[7\]$_DFFE_PP_ _0306_ clknet_leaf_8_clk b_to_a_mem\[6\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[7\]\[0\]$_DFFE_PP_ _0307_ clknet_leaf_9_clk b_to_a_mem\[7\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[7\]\[1\]$_DFFE_PP_ _0308_ clknet_leaf_8_clk b_to_a_mem\[7\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[7\]\[2\]$_DFFE_PP_ _0309_ clknet_leaf_9_clk b_to_a_mem\[7\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[7\]\[3\]$_DFFE_PP_ _0310_ clknet_leaf_9_clk b_to_a_mem\[7\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[7\]\[4\]$_DFFE_PP_ _0311_ clknet_leaf_9_clk b_to_a_mem\[7\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[7\]\[5\]$_DFFE_PP_ _0312_ clknet_leaf_10_clk
+ b_to_a_mem\[7\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[7\]\[6\]$_DFFE_PP_ _0313_ clknet_leaf_12_clk
+ b_to_a_mem\[7\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[7\]\[7\]$_DFFE_PP_ _0314_ clknet_leaf_8_clk b_to_a_mem\[7\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[8\]\[0\]$_DFFE_PP_ _0315_ clknet_leaf_7_clk b_to_a_mem\[8\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[8\]\[1\]$_DFFE_PP_ _0316_ clknet_leaf_7_clk b_to_a_mem\[8\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[8\]\[2\]$_DFFE_PP_ _0317_ clknet_leaf_8_clk b_to_a_mem\[8\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[8\]\[3\]$_DFFE_PP_ _0318_ clknet_leaf_7_clk b_to_a_mem\[8\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[8\]\[4\]$_DFFE_PP_ _0319_ clknet_leaf_10_clk
+ b_to_a_mem\[8\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[8\]\[5\]$_DFFE_PP_ _0320_ clknet_leaf_10_clk
+ b_to_a_mem\[8\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[8\]\[6\]$_DFFE_PP_ _0321_ clknet_leaf_10_clk
+ b_to_a_mem\[8\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[8\]\[7\]$_DFFE_PP_ _0322_ clknet_leaf_7_clk b_to_a_mem\[8\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[9\]\[0\]$_DFFE_PP_ _0323_ clknet_leaf_6_clk b_to_a_mem\[9\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[9\]\[1\]$_DFFE_PP_ _0324_ clknet_leaf_7_clk b_to_a_mem\[9\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[9\]\[2\]$_DFFE_PP_ _0325_ clknet_leaf_9_clk b_to_a_mem\[9\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[9\]\[3\]$_DFFE_PP_ _0326_ clknet_leaf_7_clk b_to_a_mem\[9\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[9\]\[4\]$_DFFE_PP_ _0327_ clknet_leaf_7_clk b_to_a_mem\[9\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[9\]\[5\]$_DFFE_PP_ _0328_ clknet_leaf_10_clk
+ b_to_a_mem\[9\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[9\]\[6\]$_DFFE_PP_ _0329_ clknet_leaf_10_clk
+ b_to_a_mem\[9\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_to_a_mem\[9\]\[7\]$_DFFE_PP_ _0330_ clknet_leaf_7_clk b_to_a_mem\[9\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xb_wr_ptr\[0\]$_DFFE_PN0P_ _0331_ net63 clknet_leaf_12_clk
+ b_wr_ptr\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_wr_ptr\[1\]$_DFFE_PN0P_ _0332_ net63 clknet_leaf_12_clk
+ b_wr_ptr\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_wr_ptr\[2\]$_DFFE_PN0P_ _0333_ net63 clknet_leaf_11_clk
+ b_wr_ptr\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_wr_ptr\[3\]$_DFFE_PN0P_ _0334_ net63 clknet_leaf_12_clk
+ b_wr_ptr\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xb_wr_ptr\[4\]$_DFFE_PN0P_ _0335_ net63 clknet_leaf_12_clk
+ b_wr_ptr\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Right_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Right_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Right_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Right_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Right_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Right_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Right_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Right_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Right_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Right_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Right_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Right_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Right_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Right_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Right_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Right_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Right_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Right_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Right_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Right_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Right_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Right_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Right_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Right_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Right_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Right_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Right_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Right_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Right_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Right_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Right_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Right_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Right_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Right_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Right_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Right_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Right_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Right_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_67_Right_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_68_Right_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_69_Right_69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_70_Right_70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_71_Right_71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Left_99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Left_100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Left_101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Left_102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Left_103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Left_104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Left_105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Left_106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Left_107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Left_108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Left_109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Left_110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Left_111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Left_112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Left_113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Left_114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Left_115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Left_116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Left_117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Left_118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Left_119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Left_120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Left_121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Left_122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Left_123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Left_124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Left_125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Left_126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Left_127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Left_128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Left_129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Left_130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Left_131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Left_132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Left_133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Left_134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Left_135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Left_136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Left_137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Left_138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_67_Left_139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_68_Left_140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_69_Left_141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_70_Left_142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_71_Left_143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_241 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_242 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_243 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_244 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_245 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_246 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_247 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_248 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_249 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_250 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_251 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_252 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_253 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_254 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xclkbuf_leaf_5_clk clknet_1_1__leaf_clk clknet_leaf_5_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_leaf_6_clk clknet_1_1__leaf_clk clknet_leaf_6_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_leaf_7_clk clknet_1_0__leaf_clk clknet_leaf_7_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_leaf_8_clk clknet_1_0__leaf_clk clknet_leaf_8_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_leaf_9_clk clknet_1_0__leaf_clk clknet_leaf_9_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_leaf_10_clk clknet_1_0__leaf_clk clknet_leaf_10_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_leaf_11_clk clknet_1_0__leaf_clk clknet_leaf_11_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_leaf_12_clk clknet_1_0__leaf_clk clknet_leaf_12_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xclkload0 clknet_1_1__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkload1 clknet_leaf_0_clk _unconnected_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload2 clknet_leaf_7_clk _unconnected_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xclkload3 clknet_leaf_8_clk _unconnected_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xclkload4 clknet_leaf_9_clk _unconnected_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload5 clknet_leaf_10_clk _unconnected_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload6 clknet_leaf_12_clk _unconnected_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkload7 clknet_leaf_2_clk _unconnected_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload8 clknet_leaf_3_clk _unconnected_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xclkload9 clknet_leaf_4_clk _unconnected_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload10 clknet_leaf_5_clk _unconnected_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload11 clknet_leaf_6_clk _unconnected_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
.ENDS bidirectional_fifo
