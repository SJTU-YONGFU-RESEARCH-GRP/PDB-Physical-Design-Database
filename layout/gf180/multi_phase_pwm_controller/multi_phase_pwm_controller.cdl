* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT multi_phase_pwm_controller clk deadtime[0] deadtime[1]
+ deadtime[2] deadtime[3] deadtime[4] deadtime[5] duty[0] duty[1]
+ duty[2] duty[3] duty[4] duty[5] duty[6] duty[7] enable pwm_n_out[0]
+ pwm_n_out[1] pwm_n_out[2] pwm_p_out[0] pwm_p_out[1] pwm_p_out[2]
+ rst_n
X_499_ net13 _464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_500_ _327_ _247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_501_ net14 _461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_502_ counter\[4\] _270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_503_ counter\[6\] _262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_504_ counter\[2\] _278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_505_ counter\[7\] _258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_506_ counter\[3\] _274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_507_ counter\[0\] _411_ counter\[2\] _014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_508_ _274_ _014_ _270_ _015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_509_ counter\[5\] _015_ counter\[6\] _016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_510_ _258_ _016_ _347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_511_ counter\[2\] _365_ counter\[3\] _017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_512_ _270_ _017_ _018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_513_ counter\[5\] _018_ _019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_514_ _262_ _019_ _020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_515_ _020_ _350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_516_ counter\[5\] _015_ _353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_517_ counter\[4\] _017_ _356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_518_ _274_ _014_ _359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_519_ counter\[2\] _365_ _362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_520_ _413_ _021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_521_ _274_ _021_ _270_ _022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_522_ counter\[5\] _022_ counter\[6\] _023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_523_ counter\[7\] _023_ _396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_524_ counter\[5\] _266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_525_ counter\[2\] counter\[1\] counter\[3\] _024_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_526_ _270_ _024_ _266_ _025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_527_ counter\[6\] _025_ _399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_528_ _266_ _022_ _402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_529_ _270_ _024_ _405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_530_ counter\[3\] _413_ _408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_531_ counter\[0\] _330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_532_ net2 _246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_533_ counter\[1\] _321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_534_ net6 _285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_535_ net5 _290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_536_ net4 _295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_537_ net3 _253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_538_ _297_ _026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_539_ _026_ _256_ _298_ _027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_540_ _282_ _028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_541_ _028_ _250_ _301_ _029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_542_ _255_ _292_ _297_ _030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_543_ _292_ _027_ _029_ _030_ _031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_544_ net13 _461_ _032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_545_ _287_ _032_ _033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_546_ _287_ _034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_547_ _034_ _293_ _288_ _035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_548_ _288_ _036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_549_ _287_ _036_ _464_ _037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_550_ _032_ _035_ _037_ _461_ _038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_551_ _292_ _039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_552_ _256_ _040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_553_ _298_ _041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_554_ _297_ _040_ _041_ _042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_555_ _250_ _043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_556_ _301_ _044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_557_ _282_ _043_ _044_ _045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_558_ _030_ _046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_559_ _293_ _461_ _288_ _047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_560_ _039_ _042_ _045_ _046_ _047_ _048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_561_ _031_ _033_ _038_ _048_ _049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_562_ _049_ _303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_563_ _366_ _367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_564_ _300_ _050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_565_ _028_ _327_ _050_ _051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_566_ _255_ _051_ _254_ _052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_567_ _296_ _053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_568_ _026_ _052_ _053_ _054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_569_ _292_ _054_ _055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_570_ net13 _286_ _291_ _056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_571_ net13 _287_ _286_ _055_ _056_ _057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_572_ _461_ _057_ _259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_573_ _255_ _248_ _254_ _058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_574_ _026_ _058_ _053_ _059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_575_ _292_ _059_ _060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_576_ _291_ _060_ _061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_577_ _287_ _061_ _286_ _062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_578_ _464_ _062_ _263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_579_ _291_ _055_ _063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_580_ _287_ _063_ _267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_581_ _039_ _059_ _271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_582_ _297_ _052_ _275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_583_ _255_ _248_ _279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_584_ _255_ _064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_585_ _064_ _251_ _256_ _065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_586_ _297_ _065_ _041_ _066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_587_ _039_ _066_ _293_ _067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_588_ _287_ _067_ _036_ _068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_589_ _464_ _068_ _306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_590_ _293_ _031_ _069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_591_ _287_ _069_ _309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_592_ _292_ _066_ _312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_593_ _064_ _045_ _256_ _070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_594_ _026_ _070_ _315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_595_ _255_ _251_ _318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_596_ net1 _437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_597_ net8 _456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_598_ net12 _467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_599_ net11 _470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_600_ net10 _473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_601_ net9 _476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_602_ net7 _326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_603_ counter\[6\] counter\[7\] _071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_604_ net15 _365_ _072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_605_ counter\[3\] counter\[2\] _072_ _073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_606_ counter\[5\] counter\[4\] _073_ _074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_607_ _071_ _074_ net16 _075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_608_ _075_ _076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_609_ net15 counter\[0\] _077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_610_ _076_ _077_ _000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_611_ counter\[1\] _366_ net15 _078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_612_ _076_ _078_ _001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_613_ _278_ _072_ _079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_614_ net16 _079_ _002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_615_ net15 counter\[0\] _413_ _080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_616_ _274_ _080_ _081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_617_ _076_ _081_ _003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_618_ _270_ _073_ _082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_619_ net16 _082_ _004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_620_ counter\[3\] _080_ _083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_621_ counter\[4\] _083_ _084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_622_ _266_ _084_ _085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_623_ _076_ _085_ _005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_624_ counter\[6\] _074_ _086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_625_ net16 _086_ _006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_626_ counter\[6\] counter\[5\] counter\[4\] _083_ _087_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_627_ _258_ _087_ _088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_628_ _076_ _088_ _007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_629_ _261_ _265_ _269_ _273_ _089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_630_ _284_ _371_ _090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_631_ _277_ _281_ _089_ _090_ _091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_632_ _280_ _092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_633_ _372_ _284_ _093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_634_ _417_ _093_ _281_ _094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_635_ _277_ _095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_636_ _092_ _094_ _095_ _096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_637_ _276_ _096_ _097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_638_ _264_ _098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_639_ _272_ _269_ _099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_640_ _268_ _099_ _265_ _100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_641_ _098_ _100_ _101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_642_ _089_ _097_ _101_ _261_ _260_ _102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_643_ _091_ _102_ _103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_644_ _341_ _104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_645_ _438_ _344_ _105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_646_ _345_ _105_ _342_ _106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_647_ _340_ _338_ _107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_648_ _104_ _106_ _107_ _108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_649_ _338_ _339_ _109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_650_ _337_ _108_ _109_ _110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_651_ _336_ _110_ _335_ _111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_652_ _332_ _112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_653_ _305_ _308_ _311_ _314_ _113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_654_ _317_ _323_ _114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_655_ _112_ _320_ _113_ _114_ _115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_656_ _317_ _116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_657_ _323_ _117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_658_ _322_ _118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_659_ _117_ _333_ _118_ _119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_660_ _320_ _119_ _319_ _120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_661_ _316_ _121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_662_ _116_ _120_ _121_ _122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_663_ _307_ _123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_664_ _313_ _311_ _124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_665_ _310_ _124_ _308_ _125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_666_ _123_ _125_ _126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_667_ _113_ _122_ _126_ _305_ _304_ _127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_668_ _071_ _111_ _115_ _127_ _128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_669_ net16 net15 _129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_670_ _103_ _128_ _129_ _008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_671_ _381_ _377_ _379_ _130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_672_ _385_ _383_ _130_ _131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_673_ _332_ _375_ _132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_674_ _377_ _379_ _380_ _133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_675_ _374_ _376_ _134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_676_ _378_ _377_ _133_ _134_ _135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_677_ _383_ _384_ _136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_678_ _382_ _136_ _130_ _137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_679_ _331_ _131_ _135_ _137_ _138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_680_ _375_ _374_ _131_ _132_ _138_ _139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_681_ _049_ _139_ _140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_682_ _391_ _389_ _393_ _141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_683_ _387_ _395_ _142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_684_ _439_ _141_ _142_ _143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_685_ _440_ _144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_686_ _144_ _395_ _394_ _145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_687_ _388_ _386_ _146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_688_ _391_ _392_ _147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_689_ _390_ _147_ _389_ _148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_690_ _141_ _145_ _146_ _148_ _149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_691_ _387_ _386_ _143_ _149_ _150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_692_ _020_ _150_ _347_ _151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_693_ _347_ _049_ _139_ _152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_694_ _349_ _352_ _355_ _358_ _153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_695_ _371_ _361_ _364_ _369_ _154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_696_ _351_ _155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_697_ _357_ _355_ _156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_698_ _354_ _156_ _352_ _157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_699_ _155_ _157_ _158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_700_ _361_ _364_ _159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_701_ _370_ _160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_702_ _369_ _160_ _368_ _161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_703_ _361_ _363_ _360_ _162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_704_ _159_ _161_ _162_ _163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_705_ _349_ _158_ _163_ _153_ _348_ _164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_706_ _153_ _154_ _164_ _165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_707_ _140_ _151_ _152_ _165_ _166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_708_ _129_ _166_ _009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_709_ _398_ _401_ _404_ _407_ _167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_710_ _410_ _168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_711_ _416_ _169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_712_ _371_ _168_ _418_ _169_ _170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_713_ _167_ _170_ _171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_714_ _400_ _172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_715_ _406_ _404_ _173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_716_ _403_ _173_ _401_ _174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_717_ _172_ _174_ _175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_718_ _415_ _176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_719_ _372_ _418_ _177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_720_ _283_ _177_ _416_ _178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_721_ _176_ _178_ _168_ _179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_722_ _409_ _179_ _180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_723_ _398_ _175_ _180_ _167_ _397_ _181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_724_ _427_ _182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_725_ _323_ _333_ _183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_726_ _324_ _183_ _428_ _184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_727_ _426_ _422_ _424_ _185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_728_ _182_ _184_ _185_ _186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_729_ _422_ _187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_730_ _424_ _425_ _423_ _188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_731_ _187_ _188_ _189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_732_ _419_ _421_ _189_ _190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_733_ _420_ _428_ _191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_734_ _323_ _332_ _185_ _191_ _192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_735_ _420_ _419_ _186_ _190_ _192_ _193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_736_ _431_ _430_ _429_ _433_ _194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_737_ _436_ _343_ _195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_738_ _442_ _196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_739_ _344_ _436_ _196_ _197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_740_ _435_ _195_ _197_ _434_ _198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_741_ _434_ _344_ _436_ _199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_742_ _439_ _430_ _432_ _199_ _200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_743_ _431_ _432_ _201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_744_ _430_ _201_ _429_ _202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_745_ _194_ _198_ _200_ _202_ _203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_746_ _049_ _193_ _203_ _399_ _204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_747_ _396_ _049_ _193_ _205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_748_ _171_ _181_ _204_ _396_ _205_ _206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_749_ net16 net15 _206_ _010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_750_ _477_ _207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_751_ _495_ _208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_752_ _458_ _208_ _209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_753_ _457_ _209_ _478_ _210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_754_ _207_ _210_ _211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_755_ _475_ _211_ _474_ _212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_756_ _469_ _472_ _213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_757_ _471_ _469_ _468_ _214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_758_ _212_ _213_ _214_ _215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_759_ _463_ _466_ _216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_760_ _462_ _129_ _217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_761_ _463_ _465_ _215_ _216_ _217_ _011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_762_ _480_ _484_ _486_ _482_ _218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_763_ _494_ _488_ _490_ _492_ _219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_764_ _489_ _220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_765_ _493_ _221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_766_ _492_ _221_ _222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_767_ _491_ _222_ _490_ _223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_768_ _220_ _223_ _224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_769_ _488_ _224_ _225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_770_ _487_ _225_ _218_ _226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_771_ _481_ _227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_772_ _484_ _485_ _228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_773_ _483_ _228_ _482_ _229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_774_ _227_ _229_ _230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_775_ _480_ _230_ _479_ _231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_776_ _218_ _219_ _226_ _231_ _129_ _012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_777_ _454_ _232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_778_ _458_ _497_ _233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_779_ _459_ _233_ _455_ _234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_780_ _232_ _234_ _235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_781_ _453_ _235_ _236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_782_ _445_ _447_ _449_ _451_ _237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_783_ _452_ _236_ _237_ _238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_784_ _446_ _239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_785_ _450_ _449_ _240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_786_ _448_ _240_ _447_ _241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_787_ _239_ _241_ _242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_788_ _445_ _242_ _444_ _243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_789_ _458_ _494_ _244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_790_ _453_ _455_ _237_ _244_ _245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_791_ _238_ _243_ _129_ _245_ _013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_792_ _246_ net8 _247_ _248_ _249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_793_ net2 net8 _250_ _251_ _252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_794_ _253_ net9 _254_ _255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_795_ net3 net9 _256_ _257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_796_ _258_ _259_ _260_ _261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_797_ _262_ _263_ _264_ _265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_798_ _266_ _267_ _268_ _269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_799_ _270_ _271_ _272_ _273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_800_ _274_ _275_ _276_ _277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_801_ _278_ _279_ _280_ _281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_802_ _249_ counter\[1\] _283_ _284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_803_ _285_ net12 _286_ _287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_804_ net6 net12 _288_ _289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_805_ _290_ net11 _291_ _292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_806_ net5 net11 _293_ _294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_807_ _295_ net10 _296_ _297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_808_ net4 net10 _298_ _299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_809_ _246_ net8 _300_ _282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_810_ net2 net8 _301_ _302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_811_ _258_ _303_ _304_ _305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_812_ _262_ _306_ _307_ _308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_813_ _266_ _309_ _310_ _311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_814_ _270_ _312_ _313_ _314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_815_ _274_ _315_ _316_ _317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_816_ _278_ _318_ _319_ _320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_817_ _321_ _252_ _322_ _323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_818_ counter\[1\] _252_ _324_ _325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_819_ net1 _326_ _327_ _328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_820_ net1 net7 _250_ _329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_821_ _330_ _328_ _331_ _332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_822_ counter\[0\] _328_ _333_ _334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_823_ counter\[5\] net6 _335_ _336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_824_ counter\[4\] net5 _337_ _338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_825_ counter\[3\] net4 _339_ _340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_826_ counter\[2\] net3 _341_ _342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_827_ counter\[1\] _246_ _343_ _344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_828_ counter\[1\] net2 _345_ _346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_829_ _259_ _347_ _348_ _349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_830_ _263_ _350_ _351_ _352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_831_ _267_ _353_ _354_ _355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_832_ _271_ _356_ _357_ _358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_833_ _275_ _359_ _360_ _361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_834_ _279_ _362_ _363_ _364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_835_ counter\[0\] counter\[1\] _365_ _366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_836_ _249_ _367_ _368_ _369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_837_ _330_ _328_ _370_ _371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_838_ counter\[0\] _328_ _372_ _373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_839_ _306_ _350_ _374_ _375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_840_ _309_ _353_ _376_ _377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_841_ _312_ _356_ _378_ _379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_842_ _315_ _359_ _380_ _381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_843_ _318_ _362_ _382_ _383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_844_ _252_ _367_ _384_ _385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_845_ _285_ _353_ _386_ _387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_846_ _290_ _356_ _388_ _389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_847_ _295_ _359_ _390_ _391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_848_ _253_ _362_ _392_ _393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_849_ _246_ _367_ _394_ _395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_850_ _396_ _259_ _397_ _398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_851_ _399_ _263_ _400_ _401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_852_ _402_ _267_ _403_ _404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_853_ _405_ _271_ _406_ _407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_854_ _408_ _275_ _409_ _410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_855_ counter\[1\] _278_ _411_ _412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_856_ counter\[1\] counter\[2\] _413_ _414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_857_ _412_ _279_ _415_ _416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_858_ _321_ _249_ _417_ _418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_859_ _399_ _306_ _419_ _420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_860_ _402_ _309_ _421_ _422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_861_ _405_ _312_ _423_ _424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_862_ _408_ _315_ _425_ _426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_863_ _412_ _318_ _427_ _428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_864_ _285_ _402_ _429_ _430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_865_ _290_ _405_ _431_ _432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_866_ _295_ _408_ _433_ _434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_867_ _253_ _412_ _435_ _436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_868_ _330_ _437_ _438_ _439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_869_ _330_ net1 _440_ _441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_870_ counter\[0\] net1 _442_ _443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_871_ _396_ net14 _444_ _445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_872_ _399_ net13 _446_ _447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_873_ net12 _402_ _448_ _449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_874_ net11 _405_ _450_ _451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_875_ net10 _408_ _452_ _453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_876_ net9 _412_ _454_ _455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_877_ counter\[1\] _456_ _457_ _458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_878_ counter\[1\] net8 _459_ _460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_879_ counter\[7\] _461_ _462_ _463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_880_ counter\[6\] _464_ _465_ _466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_881_ counter\[5\] _467_ _468_ _469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_882_ counter\[4\] _470_ _471_ _472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_883_ counter\[3\] _473_ _474_ _475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_884_ counter\[2\] _476_ _477_ _478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_885_ net14 _347_ _479_ _480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_886_ net13 _350_ _481_ _482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_887_ net12 _353_ _483_ _484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_888_ net11 _356_ _485_ _486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_889_ net10 _359_ _487_ _488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_890_ net9 _362_ _489_ _490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_891_ net8 _367_ _491_ _492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_892_ _330_ _326_ _493_ _494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_893_ _330_ net7 _495_ _496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_894_ counter\[0\] _326_ _497_ _498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
Xcounter\[0\]$_SDFFE_PN0P_ _000_ clknet_1_1__leaf_clk counter\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xcounter\[1\]$_SDFFE_PN0P_ _001_ clknet_1_1__leaf_clk counter\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xcounter\[2\]$_SDFFE_PN0P_ _002_ clknet_1_1__leaf_clk counter\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xcounter\[3\]$_SDFFE_PN0P_ _003_ clknet_1_0__leaf_clk counter\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xcounter\[4\]$_SDFFE_PN0P_ _004_ clknet_1_1__leaf_clk counter\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xcounter\[5\]$_SDFFE_PN0P_ _005_ clknet_1_0__leaf_clk counter\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xcounter\[6\]$_SDFFE_PN0P_ _006_ clknet_1_0__leaf_clk counter\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xcounter\[7\]$_SDFFE_PN0P_ _007_ clknet_1_0__leaf_clk counter\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xpwm_n_reg\[0\]$_SDFF_PN0_ _008_ clknet_1_0__leaf_clk net17
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xpwm_n_reg\[1\]$_SDFF_PN0_ _009_ clknet_1_0__leaf_clk net18
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xpwm_n_reg\[2\]$_SDFF_PN0_ _010_ clknet_1_0__leaf_clk net19
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xpwm_p_reg\[0\]$_SDFF_PN0_ _011_ clknet_1_0__leaf_clk net20
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xpwm_p_reg\[1\]$_SDFF_PN0_ _012_ clknet_1_1__leaf_clk net21
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xpwm_p_reg\[2\]$_SDFF_PN0_ _013_ clknet_1_1__leaf_clk net22
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Right_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Right_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Right_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Right_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Right_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Right_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Right_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Right_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Right_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Right_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Right_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Right_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Right_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Right_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Right_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Right_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Right_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Right_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Right_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Right_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Left_76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Left_77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Left_78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Left_79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Left_80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Left_81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Left_82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Left_83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Left_84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Left_85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Left_86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Left_87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Left_88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Left_89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Left_90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Left_91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Left_92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Left_93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Left_94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Left_95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Left_96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Left_97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 deadtime[0] net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput2 deadtime[1] net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput3 deadtime[2] net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput4 deadtime[3] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput5 deadtime[4] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput6 deadtime[5] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput7 duty[0] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput8 duty[1] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput9 duty[2] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput10 duty[3] net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput11 duty[4] net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput12 duty[5] net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput13 duty[6] net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput14 duty[7] net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xinput15 enable net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput16 rst_n net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xoutput17 net17 pwm_n_out[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput18 net18 pwm_n_out[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput19 net19 pwm_n_out[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput20 net20 pwm_p_out[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput21 net21 pwm_p_out[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput22 net22 pwm_p_out[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xclkload0 clknet_1_1__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
.ENDS multi_phase_pwm_controller
