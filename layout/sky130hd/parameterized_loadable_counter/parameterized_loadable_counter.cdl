* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_loadable_counter clk count[0] count[1]
+ count[2] count[3] count[4] count[5] count[6] count[7] data_in[0]
+ data_in[1] data_in[2] data_in[3] data_in[4] data_in[5] data_in[6]
+ data_in[7] enable load rst_n
X_42_ load VSS VSS VDD VDD _08_ sky130_fd_sc_hd__buf_2
X_43_ _08_ VSS VSS VDD VDD _09_ sky130_fd_sc_hd__buf_4
X_44_ enable VSS VSS VDD VDD _10_ sky130_fd_sc_hd__buf_4
X_45_ _10_ net10 VSS VSS VDD VDD _11_ sky130_fd_sc_hd__xnor2_1
X_46_ _09_ net2 VSS VSS VDD VDD _12_ sky130_fd_sc_hd__nand2_1
X_47_ _09_ _11_ _12_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__o21ai_0
X_48_ net11 _41_ _10_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__mux2i_1
X_49_ _09_ net3 VSS VSS VDD VDD _14_ sky130_fd_sc_hd__nand2_1
X_50_ _09_ _13_ _14_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__o21ai_0
X_51_ _10_ _40_ VSS VSS VDD VDD _15_ sky130_fd_sc_hd__nand2_1
X_52_ net12 _15_ VSS VSS VDD VDD _16_ sky130_fd_sc_hd__xor2_1
X_53_ _09_ net4 VSS VSS VDD VDD _17_ sky130_fd_sc_hd__nand2_1
X_54_ _08_ _16_ _17_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__o21ai_0
X_55_ _10_ net10 net12 net11 VSS VSS VDD VDD _18_ sky130_fd_sc_hd__nand4_2
X_56_ net13 _18_ VSS VSS VDD VDD _19_ sky130_fd_sc_hd__xor2_1
X_57_ _09_ net5 VSS VSS VDD VDD _20_ sky130_fd_sc_hd__nand2_1
X_58_ _08_ _19_ _20_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__o21ai_0
X_59_ _10_ _40_ net12 net13 VSS VSS VDD VDD _21_ sky130_fd_sc_hd__nand4_1
X_60_ net14 _21_ VSS VSS VDD VDD _22_ sky130_fd_sc_hd__xor2_1
X_61_ _09_ net6 VSS VSS VDD VDD _23_ sky130_fd_sc_hd__nand2_1
X_62_ _08_ _22_ _23_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__o21ai_0
X_63_ _09_ net7 VSS VSS VDD VDD _24_ sky130_fd_sc_hd__nand2_1
X_64_ net13 net14 VSS VSS VDD VDD _25_ sky130_fd_sc_hd__nand2_1
X_65_ _08_ net15 VSS VSS VDD VDD _26_ sky130_fd_sc_hd__nor2b_1
X_66_ _18_ _25_ _26_ VSS VSS VDD VDD _27_ sky130_fd_sc_hd__o21ai_0
X_67_ _08_ net15 _18_ _25_ VSS VSS VDD VDD _28_ sky130_fd_sc_hd__or4_1
X_68_ _24_ _27_ _28_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__nand3_1
X_69_ _09_ net8 VSS VSS VDD VDD _29_ sky130_fd_sc_hd__nand2_1
X_70_ _10_ _40_ net12 VSS VSS VDD VDD _30_ sky130_fd_sc_hd__nand3_1
X_71_ net13 net14 net15 VSS VSS VDD VDD _31_ sky130_fd_sc_hd__nand3_1
X_72_ _08_ net16 VSS VSS VDD VDD _32_ sky130_fd_sc_hd__nor2b_1
X_73_ _30_ _31_ _32_ VSS VSS VDD VDD _33_ sky130_fd_sc_hd__o21ai_0
X_74_ _08_ net16 _30_ _31_ VSS VSS VDD VDD _34_ sky130_fd_sc_hd__or4_1
X_75_ _29_ _33_ _34_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__nand3_1
X_76_ net13 net14 net15 net16 VSS VSS VDD VDD _35_ sky130_fd_sc_hd__nand4_1
X_77_ _08_ net17 VSS VSS VDD VDD _36_ sky130_fd_sc_hd__nor2b_1
X_78_ _18_ _35_ _36_ VSS VSS VDD VDD _37_ sky130_fd_sc_hd__o21ai_0
X_79_ _08_ net17 _18_ _35_ VSS VSS VDD VDD _38_ sky130_fd_sc_hd__or4_1
X_80_ _09_ net9 VSS VSS VDD VDD _39_ sky130_fd_sc_hd__nand2_1
X_81_ _37_ _38_ _39_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__nand3_1
X_82_ net10 net11 VSS VSS VDD VDD _40_ _41_ sky130_fd_sc_hd__ha_1
Xcounter_reg\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _00_ net1
+ VSS VSS VDD VDD net10 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _01_ net1
+ VSS VSS VDD VDD net11 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1
+ VSS VSS VDD VDD net12 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _03_ net1
+ VSS VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_2
Xcounter_reg\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _04_ net1
+ VSS VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[5\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _05_ net1
+ VSS VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _06_ net1
+ VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[7\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _07_ net1
+ VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xhold1 net18 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 data_in[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 data_in[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 data_in[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 data_in[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 data_in[4] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 data_in[5] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 data_in[6] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 data_in[7] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xoutput9 net10 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net11 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput11 net12 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD count[5] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD count[6] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD count[7] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net18 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_loadable_counter
