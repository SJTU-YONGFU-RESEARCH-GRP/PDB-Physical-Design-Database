* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_fft busy clk data_in_imag[0] data_in_imag[10]
+ data_in_imag[11] data_in_imag[12] data_in_imag[13] data_in_imag[14]
+ data_in_imag[15] data_in_imag[1] data_in_imag[2] data_in_imag[3]
+ data_in_imag[4] data_in_imag[5] data_in_imag[6] data_in_imag[7]
+ data_in_imag[8] data_in_imag[9] data_in_real[0] data_in_real[10]
+ data_in_real[11] data_in_real[12] data_in_real[13] data_in_real[14]
+ data_in_real[15] data_in_real[1] data_in_real[2] data_in_real[3]
+ data_in_real[4] data_in_real[5] data_in_real[6] data_in_real[7]
+ data_in_real[8] data_in_real[9] data_out_imag[0] data_out_imag[100]
+ data_out_imag[101] data_out_imag[102] data_out_imag[103] data_out_imag[104]
+ data_out_imag[105] data_out_imag[106] data_out_imag[107] data_out_imag[108]
+ data_out_imag[109] data_out_imag[10] data_out_imag[110] data_out_imag[111]
+ data_out_imag[112] data_out_imag[113] data_out_imag[114] data_out_imag[115]
+ data_out_imag[116] data_out_imag[117] data_out_imag[118] data_out_imag[119]
+ data_out_imag[11] data_out_imag[120] data_out_imag[121] data_out_imag[122]
+ data_out_imag[123] data_out_imag[124] data_out_imag[125] data_out_imag[126]
+ data_out_imag[127] data_out_imag[12] data_out_imag[13] data_out_imag[14]
+ data_out_imag[15] data_out_imag[16] data_out_imag[17] data_out_imag[18]
+ data_out_imag[19] data_out_imag[1] data_out_imag[20] data_out_imag[21]
+ data_out_imag[22] data_out_imag[23] data_out_imag[24] data_out_imag[25]
+ data_out_imag[26] data_out_imag[27] data_out_imag[28] data_out_imag[29]
+ data_out_imag[2] data_out_imag[30] data_out_imag[31] data_out_imag[32]
+ data_out_imag[33] data_out_imag[34] data_out_imag[35] data_out_imag[36]
+ data_out_imag[37] data_out_imag[38] data_out_imag[39] data_out_imag[3]
+ data_out_imag[40] data_out_imag[41] data_out_imag[42] data_out_imag[43]
+ data_out_imag[44] data_out_imag[45] data_out_imag[46] data_out_imag[47]
+ data_out_imag[48] data_out_imag[49] data_out_imag[4] data_out_imag[50]
+ data_out_imag[51] data_out_imag[52] data_out_imag[53] data_out_imag[54]
+ data_out_imag[55] data_out_imag[56] data_out_imag[57] data_out_imag[58]
+ data_out_imag[59] data_out_imag[5] data_out_imag[60] data_out_imag[61]
+ data_out_imag[62] data_out_imag[63] data_out_imag[64] data_out_imag[65]
+ data_out_imag[66] data_out_imag[67] data_out_imag[68] data_out_imag[69]
+ data_out_imag[6] data_out_imag[70] data_out_imag[71] data_out_imag[72]
+ data_out_imag[73] data_out_imag[74] data_out_imag[75] data_out_imag[76]
+ data_out_imag[77] data_out_imag[78] data_out_imag[79] data_out_imag[7]
+ data_out_imag[80] data_out_imag[81] data_out_imag[82] data_out_imag[83]
+ data_out_imag[84] data_out_imag[85] data_out_imag[86] data_out_imag[87]
+ data_out_imag[88] data_out_imag[89] data_out_imag[8] data_out_imag[90]
+ data_out_imag[91] data_out_imag[92] data_out_imag[93] data_out_imag[94]
+ data_out_imag[95] data_out_imag[96] data_out_imag[97] data_out_imag[98]
+ data_out_imag[99] data_out_imag[9] data_out_real[0] data_out_real[100]
+ data_out_real[101] data_out_real[102] data_out_real[103] data_out_real[104]
+ data_out_real[105] data_out_real[106] data_out_real[107] data_out_real[108]
+ data_out_real[109] data_out_real[10] data_out_real[110] data_out_real[111]
+ data_out_real[112] data_out_real[113] data_out_real[114] data_out_real[115]
+ data_out_real[116] data_out_real[117] data_out_real[118] data_out_real[119]
+ data_out_real[11] data_out_real[120] data_out_real[121] data_out_real[122]
+ data_out_real[123] data_out_real[124] data_out_real[125] data_out_real[126]
+ data_out_real[127] data_out_real[12] data_out_real[13] data_out_real[14]
+ data_out_real[15] data_out_real[16] data_out_real[17] data_out_real[18]
+ data_out_real[19] data_out_real[1] data_out_real[20] data_out_real[21]
+ data_out_real[22] data_out_real[23] data_out_real[24] data_out_real[25]
+ data_out_real[26] data_out_real[27] data_out_real[28] data_out_real[29]
+ data_out_real[2] data_out_real[30] data_out_real[31] data_out_real[32]
+ data_out_real[33] data_out_real[34] data_out_real[35] data_out_real[36]
+ data_out_real[37] data_out_real[38] data_out_real[39] data_out_real[3]
+ data_out_real[40] data_out_real[41] data_out_real[42] data_out_real[43]
+ data_out_real[44] data_out_real[45] data_out_real[46] data_out_real[47]
+ data_out_real[48] data_out_real[49] data_out_real[4] data_out_real[50]
+ data_out_real[51] data_out_real[52] data_out_real[53] data_out_real[54]
+ data_out_real[55] data_out_real[56] data_out_real[57] data_out_real[58]
+ data_out_real[59] data_out_real[5] data_out_real[60] data_out_real[61]
+ data_out_real[62] data_out_real[63] data_out_real[64] data_out_real[65]
+ data_out_real[66] data_out_real[67] data_out_real[68] data_out_real[69]
+ data_out_real[6] data_out_real[70] data_out_real[71] data_out_real[72]
+ data_out_real[73] data_out_real[74] data_out_real[75] data_out_real[76]
+ data_out_real[77] data_out_real[78] data_out_real[79] data_out_real[7]
+ data_out_real[80] data_out_real[81] data_out_real[82] data_out_real[83]
+ data_out_real[84] data_out_real[85] data_out_real[86] data_out_real[87]
+ data_out_real[88] data_out_real[89] data_out_real[8] data_out_real[90]
+ data_out_real[91] data_out_real[92] data_out_real[93] data_out_real[94]
+ data_out_real[95] data_out_real[96] data_out_real[97] data_out_real[98]
+ data_out_real[99] data_out_real[9] data_ready data_valid_in
+ data_valid_out rst_n start
X_09753_ rst_n _00841_ VDD VSS BUF_X2
X_09754_ _00841_ _00842_ VDD VSS BUF_X4
X_09755_ _00842_ _00843_ VDD VSS INV_X4
X_09756_ _00843_ _00844_ VDD VSS BUF_X4
X_09757_ _00844_ _00845_ VDD VSS BUF_X4
X_09758_ state\[1\] _00846_ VDD VSS BUF_X2
X_09759_ stage\[2\] _00847_ VDD VSS CLKBUF_X3
X_09760_ _00847_ _00848_ VDD VSS BUF_X4
X_09761_ stage\[0\] _00849_ VDD VSS BUF_X2
X_09762_ stage\[1\] _00850_ VDD VSS BUF_X2
X_09763_ _00848_ _00849_ _00850_ _00851_ VDD VSS AOI21_X4
X_09764_ _00846_ _00851_ _00852_ VDD VSS NAND2_X1
X_09765_ state\[2\] _00853_ VDD VSS CLKBUF_X3
X_09766_ net86 _09382_ _00853_ _00854_ VDD VSS NAND3_X1
X_09767_ _00845_ _00852_ _00854_ _00011_ VDD VSS AOI21_X1
X_09768_ _00842_ _00855_ VDD VSS CLKBUF_X3
X_09769_ _00855_ _00856_ VDD VSS BUF_X4
X_09770_ state\[3\] _00857_ VDD VSS BUF_X4
X_09771_ _00857_ _00858_ VDD VSS INV_X4
X_09772_ _00858_ _00859_ VDD VSS CLKBUF_X3
X_09773_ state\[0\] _00860_ VDD VSS BUF_X2
X_09774_ net87 _00861_ VDD VSS INV_X1
X_09775_ _00860_ _00861_ _00862_ VDD VSS NAND2_X1
X_09776_ _00856_ _00859_ _00862_ _00010_ VDD VSS NAND3_X1
Xsplit56 net61 net56 VDD VSS CLKBUF_X2
Xclone60 net452 net60 VDD VSS BUF_X4
X_09779_ samples_imag\[0\]\[15\] samples_imag\[2\]\[15\] net56
+ _00865_ VDD VSS MUX2_X1
X_09780_ samples_imag\[1\]\[15\] samples_imag\[3\]\[15\] net56
+ _00866_ VDD VSS MUX2_X1
X_09781_ _00000_ _00867_ VDD VSS BUF_X4
X_09782_ _00865_ _00866_ _00867_ _00868_ VDD VSS MUX2_X1
X_09783_ samples_imag\[4\]\[15\] samples_imag\[6\]\[15\] net56
+ _00869_ VDD VSS MUX2_X1
X_09784_ samples_imag\[5\]\[15\] samples_imag\[7\]\[15\] net56
+ _00870_ VDD VSS MUX2_X1
X_09785_ _00869_ _00870_ _00867_ _00871_ VDD VSS MUX2_X1
X_09786_ _00002_ _00872_ VDD VSS BUF_X2
X_09787_ _00868_ _00871_ _00872_ _08561_ VDD VSS MUX2_X2
X_09788_ _00001_ _00873_ VDD VSS BUF_X16
X_09789_ net57 _00874_ VDD VSS BUF_X4
X_09790_ samples_imag\[0\]\[14\] samples_imag\[2\]\[14\] _00874_
+ _00875_ VDD VSS MUX2_X1
X_09791_ samples_imag\[1\]\[14\] samples_imag\[3\]\[14\] _00874_
+ _00876_ VDD VSS MUX2_X1
X_09792_ _00867_ _00877_ VDD VSS BUF_X4
X_09793_ _00875_ _00876_ _00877_ _00878_ VDD VSS MUX2_X1
X_09794_ samples_imag\[4\]\[14\] samples_imag\[6\]\[14\] _00874_
+ _00879_ VDD VSS MUX2_X1
X_09795_ samples_imag\[5\]\[14\] samples_imag\[7\]\[14\] _00874_
+ _00880_ VDD VSS MUX2_X1
X_09796_ _00879_ _00880_ _00877_ _00881_ VDD VSS MUX2_X1
X_09797_ _00872_ _00882_ VDD VSS BUF_X4
X_09798_ _00878_ _00881_ _00882_ _08553_ VDD VSS MUX2_X2
X_09799_ _00873_ _00883_ VDD VSS BUF_X16
X_09800_ samples_imag\[0\]\[13\] samples_imag\[2\]\[13\] _00883_
+ _00884_ VDD VSS MUX2_X1
X_09801_ samples_imag\[1\]\[13\] samples_imag\[3\]\[13\] _00883_
+ _00885_ VDD VSS MUX2_X1
X_09802_ _00867_ _00886_ VDD VSS BUF_X4
X_09803_ _00884_ _00885_ _00886_ _00887_ VDD VSS MUX2_X1
X_09804_ samples_imag\[4\]\[13\] samples_imag\[6\]\[13\] _00883_
+ _00888_ VDD VSS MUX2_X1
X_09805_ samples_imag\[5\]\[13\] samples_imag\[7\]\[13\] _00883_
+ _00889_ VDD VSS MUX2_X1
X_09806_ _00888_ _00889_ _00886_ _00890_ VDD VSS MUX2_X1
X_09807_ _00887_ _00890_ _00882_ _08569_ VDD VSS MUX2_X2
X_09808_ net57 _00891_ VDD VSS BUF_X4
X_09809_ samples_imag\[0\]\[12\] samples_imag\[2\]\[12\] _00891_
+ _00892_ VDD VSS MUX2_X1
X_09810_ samples_imag\[1\]\[12\] samples_imag\[3\]\[12\] _00891_
+ _00893_ VDD VSS MUX2_X1
X_09811_ _00867_ _00894_ VDD VSS BUF_X4
X_09812_ _00892_ _00893_ _00894_ _00895_ VDD VSS MUX2_X1
X_09813_ net57 _00896_ VDD VSS BUF_X4
X_09814_ samples_imag\[4\]\[12\] samples_imag\[6\]\[12\] _00896_
+ _00897_ VDD VSS MUX2_X1
X_09815_ samples_imag\[5\]\[12\] samples_imag\[7\]\[12\] _00896_
+ _00898_ VDD VSS MUX2_X1
X_09816_ _00867_ _00899_ VDD VSS BUF_X4
X_09817_ _00897_ _00898_ _00899_ _00900_ VDD VSS MUX2_X1
X_09818_ _00872_ _00901_ VDD VSS BUF_X4
X_09819_ _00895_ _00900_ _00901_ _08574_ VDD VSS MUX2_X2
X_09820_ _00873_ _00902_ VDD VSS BUF_X4
X_09821_ samples_imag\[0\]\[11\] samples_imag\[2\]\[11\] net59
+ _00903_ VDD VSS MUX2_X1
X_09822_ samples_imag\[1\]\[11\] samples_imag\[3\]\[11\] net59
+ _00904_ VDD VSS MUX2_X1
X_09823_ _00903_ _00904_ _00886_ _00905_ VDD VSS MUX2_X1
X_09824_ net57 _00906_ VDD VSS BUF_X4
X_09825_ samples_imag\[4\]\[11\] samples_imag\[6\]\[11\] _00906_
+ _00907_ VDD VSS MUX2_X1
X_09826_ samples_imag\[5\]\[11\] samples_imag\[7\]\[11\] _00906_
+ _00908_ VDD VSS MUX2_X1
X_09827_ _00907_ _00908_ _00877_ _00909_ VDD VSS MUX2_X1
X_09828_ _00905_ _00909_ _00882_ _08579_ VDD VSS MUX2_X2
X_09829_ _00873_ _00910_ VDD VSS BUF_X8
X_09830_ samples_imag\[0\]\[10\] samples_imag\[2\]\[10\] net129
+ _00911_ VDD VSS MUX2_X1
X_09831_ samples_imag\[1\]\[10\] samples_imag\[3\]\[10\] _00910_
+ _00912_ VDD VSS MUX2_X1
X_09832_ _00867_ _00913_ VDD VSS BUF_X4
X_09833_ _00911_ _00912_ _00913_ _00914_ VDD VSS MUX2_X1
X_09834_ samples_imag\[4\]\[10\] samples_imag\[6\]\[10\] _00910_
+ _00915_ VDD VSS MUX2_X1
X_09835_ samples_imag\[5\]\[10\] samples_imag\[7\]\[10\] _00910_
+ _00916_ VDD VSS MUX2_X1
X_09836_ _00915_ _00916_ _00913_ _00917_ VDD VSS MUX2_X1
X_09837_ _00872_ _00918_ VDD VSS BUF_X4
X_09838_ _00914_ _00917_ _00918_ _08584_ VDD VSS MUX2_X2
X_09839_ _00001_ _00919_ VDD VSS BUF_X8
X_09840_ samples_imag\[0\]\[9\] samples_imag\[2\]\[9\] net60
+ _00920_ VDD VSS MUX2_X1
X_09841_ _00001_ _00921_ VDD VSS BUF_X4
X_09842_ samples_imag\[1\]\[9\] samples_imag\[3\]\[9\] _00921_
+ _00922_ VDD VSS MUX2_X1
X_09843_ _00867_ _00923_ VDD VSS BUF_X4
X_09844_ _00920_ _00922_ _00923_ _00924_ VDD VSS MUX2_X1
X_09845_ samples_imag\[4\]\[9\] samples_imag\[6\]\[9\] _00921_
+ _00925_ VDD VSS MUX2_X1
X_09846_ samples_imag\[5\]\[9\] samples_imag\[7\]\[9\] _00921_
+ _00926_ VDD VSS MUX2_X1
X_09847_ _00925_ _00926_ _00923_ _00927_ VDD VSS MUX2_X1
X_09848_ _00924_ _00927_ _00918_ _08589_ VDD VSS MUX2_X2
X_09849_ samples_imag\[0\]\[8\] samples_imag\[2\]\[8\] _00921_
+ _00928_ VDD VSS MUX2_X1
X_09850_ samples_imag\[1\]\[8\] samples_imag\[3\]\[8\] _00921_
+ _00929_ VDD VSS MUX2_X1
X_09851_ _00928_ _00929_ _00923_ _00930_ VDD VSS MUX2_X1
X_09852_ _00873_ _00931_ VDD VSS BUF_X16
X_09853_ samples_imag\[4\]\[8\] samples_imag\[6\]\[8\] net476
+ _00932_ VDD VSS MUX2_X1
X_09854_ samples_imag\[5\]\[8\] samples_imag\[7\]\[8\] net476
+ _00933_ VDD VSS MUX2_X1
X_09855_ _00932_ _00933_ _00913_ _00934_ VDD VSS MUX2_X1
X_09856_ _00930_ _00934_ _00918_ _08594_ VDD VSS MUX2_X2
X_09857_ net57 _00935_ VDD VSS BUF_X4
X_09858_ samples_imag\[0\]\[7\] samples_imag\[2\]\[7\] _00935_
+ _00936_ VDD VSS MUX2_X1
X_09859_ samples_imag\[1\]\[7\] samples_imag\[3\]\[7\] _00935_
+ _00937_ VDD VSS MUX2_X1
X_09860_ _00936_ _00937_ _00899_ _00938_ VDD VSS MUX2_X1
X_09861_ samples_imag\[4\]\[7\] samples_imag\[6\]\[7\] _00935_
+ _00939_ VDD VSS MUX2_X1
X_09862_ samples_imag\[5\]\[7\] samples_imag\[7\]\[7\] _00935_
+ _00940_ VDD VSS MUX2_X1
X_09863_ _00939_ _00940_ _00899_ _00941_ VDD VSS MUX2_X1
X_09864_ _00938_ _00941_ _00901_ _08599_ VDD VSS MUX2_X2
X_09865_ _00873_ _00942_ VDD VSS BUF_X8
X_09866_ samples_imag\[0\]\[6\] samples_imag\[2\]\[6\] _00942_
+ _00943_ VDD VSS MUX2_X1
X_09867_ samples_imag\[1\]\[6\] samples_imag\[3\]\[6\] _00891_
+ _00944_ VDD VSS MUX2_X1
X_09868_ _00943_ _00944_ _00894_ _00945_ VDD VSS MUX2_X1
X_09869_ samples_imag\[4\]\[6\] samples_imag\[6\]\[6\] _00891_
+ _00946_ VDD VSS MUX2_X1
X_09870_ samples_imag\[5\]\[6\] samples_imag\[7\]\[6\] _00891_
+ _00947_ VDD VSS MUX2_X1
X_09871_ _00946_ _00947_ _00894_ _00948_ VDD VSS MUX2_X1
X_09872_ _00945_ _00948_ _00901_ _08604_ VDD VSS MUX2_X2
X_09873_ samples_imag\[0\]\[5\] samples_imag\[2\]\[5\] _00906_
+ _00949_ VDD VSS MUX2_X1
X_09874_ samples_imag\[1\]\[5\] samples_imag\[3\]\[5\] _00906_
+ _00950_ VDD VSS MUX2_X1
X_09875_ _00949_ _00950_ _00877_ _00951_ VDD VSS MUX2_X1
X_09876_ samples_imag\[4\]\[5\] samples_imag\[6\]\[5\] _00906_
+ _00952_ VDD VSS MUX2_X1
X_09877_ samples_imag\[5\]\[5\] samples_imag\[7\]\[5\] _00874_
+ _00953_ VDD VSS MUX2_X1
X_09878_ _00952_ _00953_ _00877_ _00954_ VDD VSS MUX2_X1
X_09879_ _00951_ _00954_ _00882_ _08609_ VDD VSS MUX2_X2
X_09880_ samples_imag\[0\]\[4\] samples_imag\[2\]\[4\] _00896_
+ _00955_ VDD VSS MUX2_X1
X_09881_ samples_imag\[1\]\[4\] samples_imag\[3\]\[4\] _00896_
+ _00956_ VDD VSS MUX2_X1
X_09882_ _00955_ _00956_ _00899_ _00957_ VDD VSS MUX2_X1
X_09883_ samples_imag\[4\]\[4\] samples_imag\[6\]\[4\] _00896_
+ _00958_ VDD VSS MUX2_X1
X_09884_ samples_imag\[5\]\[4\] samples_imag\[7\]\[4\] _00935_
+ _00959_ VDD VSS MUX2_X1
X_09885_ _00958_ _00959_ _00899_ _00960_ VDD VSS MUX2_X1
X_09886_ _00957_ _00960_ _00901_ _08614_ VDD VSS MUX2_X2
X_09887_ samples_imag\[0\]\[3\] samples_imag\[2\]\[3\] _00942_
+ _00961_ VDD VSS MUX2_X1
X_09888_ samples_imag\[1\]\[3\] samples_imag\[3\]\[3\] _00942_
+ _00962_ VDD VSS MUX2_X1
X_09889_ _00961_ _00962_ _00894_ _00963_ VDD VSS MUX2_X1
X_09890_ samples_imag\[4\]\[3\] samples_imag\[6\]\[3\] _00942_
+ _00964_ VDD VSS MUX2_X1
X_09891_ samples_imag\[5\]\[3\] samples_imag\[7\]\[3\] _00942_
+ _00965_ VDD VSS MUX2_X1
X_09892_ _00964_ _00965_ _00894_ _00966_ VDD VSS MUX2_X1
X_09893_ _00963_ _00966_ _00901_ _08619_ VDD VSS MUX2_X2
X_09894_ samples_imag\[0\]\[2\] samples_imag\[2\]\[2\] _00883_
+ _00967_ VDD VSS MUX2_X1
X_09895_ samples_imag\[1\]\[2\] samples_imag\[3\]\[2\] _00902_
+ _00968_ VDD VSS MUX2_X1
X_09896_ _00967_ _00968_ _00886_ _00969_ VDD VSS MUX2_X1
X_09897_ samples_imag\[4\]\[2\] samples_imag\[6\]\[2\] _00902_
+ _00970_ VDD VSS MUX2_X1
X_09898_ samples_imag\[5\]\[2\] samples_imag\[7\]\[2\] _00902_
+ _00971_ VDD VSS MUX2_X1
X_09899_ _00970_ _00971_ _00886_ _00972_ VDD VSS MUX2_X1
X_09900_ _00969_ _00972_ _00882_ _08624_ VDD VSS MUX2_X2
X_09901_ samples_imag\[0\]\[1\] samples_imag\[2\]\[1\] _00919_
+ _00973_ VDD VSS MUX2_X1
X_09902_ samples_imag\[1\]\[1\] samples_imag\[3\]\[1\] _00919_
+ _00974_ VDD VSS MUX2_X1
X_09903_ _00973_ _00974_ _00923_ _00975_ VDD VSS MUX2_X1
X_09904_ samples_imag\[4\]\[1\] samples_imag\[6\]\[1\] _00919_
+ _00976_ VDD VSS MUX2_X1
X_09905_ samples_imag\[5\]\[1\] samples_imag\[7\]\[1\] _00919_
+ _00977_ VDD VSS MUX2_X1
X_09906_ _00976_ _00977_ _00923_ _00978_ VDD VSS MUX2_X1
X_09907_ _00975_ _00978_ _00918_ _08629_ VDD VSS MUX2_X2
X_09908_ samples_imag\[0\]\[0\] samples_imag\[2\]\[0\] net511
+ _00979_ VDD VSS MUX2_X1
X_09909_ samples_imag\[1\]\[0\] samples_imag\[3\]\[0\] net511
+ _00980_ VDD VSS MUX2_X1
X_09910_ _00979_ _00980_ _00913_ _00981_ VDD VSS MUX2_X1
X_09911_ samples_imag\[4\]\[0\] samples_imag\[6\]\[0\] net511
+ _00982_ VDD VSS MUX2_X1
X_09912_ samples_imag\[5\]\[0\] samples_imag\[7\]\[0\] _00910_
+ _00983_ VDD VSS MUX2_X1
X_09913_ _00982_ _00983_ _00913_ _00984_ VDD VSS MUX2_X1
X_09914_ _00981_ _00984_ _00918_ _08559_ VDD VSS MUX2_X2
X_09915_ samples_real\[0\]\[15\] samples_real\[2\]\[15\] net56
+ _00985_ VDD VSS MUX2_X1
X_09916_ samples_real\[1\]\[15\] samples_real\[3\]\[15\] net61
+ _00986_ VDD VSS MUX2_X1
X_09917_ _00985_ _00986_ _00867_ _00987_ VDD VSS MUX2_X1
X_09918_ samples_real\[4\]\[15\] samples_real\[6\]\[15\] net61
+ _00988_ VDD VSS MUX2_X1
X_09919_ samples_real\[5\]\[15\] samples_real\[7\]\[15\] net61
+ _00989_ VDD VSS MUX2_X1
X_09920_ _00988_ _00989_ _00867_ _00990_ VDD VSS MUX2_X1
X_09921_ _00987_ _00990_ _00872_ _08642_ VDD VSS MUX2_X2
X_09922_ samples_real\[0\]\[14\] samples_real\[2\]\[14\] _00874_
+ _00991_ VDD VSS MUX2_X1
X_09923_ samples_real\[1\]\[14\] samples_real\[3\]\[14\] _00874_
+ _00992_ VDD VSS MUX2_X1
X_09924_ _00991_ _00992_ _00877_ _00993_ VDD VSS MUX2_X1
X_09925_ samples_real\[4\]\[14\] samples_real\[6\]\[14\] _00874_
+ _00994_ VDD VSS MUX2_X1
X_09926_ samples_real\[5\]\[14\] samples_real\[7\]\[14\] _00874_
+ _00995_ VDD VSS MUX2_X1
X_09927_ _00994_ _00995_ _00877_ _00996_ VDD VSS MUX2_X1
X_09928_ _00993_ _00996_ _00882_ _08634_ VDD VSS MUX2_X2
X_09929_ samples_real\[0\]\[13\] samples_real\[2\]\[13\] _00883_
+ _00997_ VDD VSS MUX2_X1
X_09930_ samples_real\[1\]\[13\] samples_real\[3\]\[13\] _00883_
+ _00998_ VDD VSS MUX2_X1
X_09931_ _00997_ _00998_ _00886_ _00999_ VDD VSS MUX2_X1
X_09932_ samples_real\[4\]\[13\] samples_real\[6\]\[13\] _00883_
+ _01000_ VDD VSS MUX2_X1
X_09933_ samples_real\[5\]\[13\] samples_real\[7\]\[13\] _00883_
+ _01001_ VDD VSS MUX2_X1
X_09934_ _01000_ _01001_ _00886_ _01002_ VDD VSS MUX2_X1
X_09935_ _00999_ _01002_ _00882_ _08650_ VDD VSS MUX2_X2
X_09936_ samples_real\[0\]\[12\] samples_real\[2\]\[12\] _00891_
+ _01003_ VDD VSS MUX2_X1
X_09937_ samples_real\[1\]\[12\] samples_real\[3\]\[12\] _00891_
+ _01004_ VDD VSS MUX2_X1
X_09938_ _01003_ _01004_ _00894_ _01005_ VDD VSS MUX2_X1
X_09939_ samples_real\[4\]\[12\] samples_real\[6\]\[12\] _00896_
+ _01006_ VDD VSS MUX2_X1
X_09940_ samples_real\[5\]\[12\] samples_real\[7\]\[12\] _00896_
+ _01007_ VDD VSS MUX2_X1
X_09941_ _01006_ _01007_ _00899_ _01008_ VDD VSS MUX2_X1
X_09942_ _01005_ _01008_ _00901_ _08655_ VDD VSS MUX2_X2
X_09943_ samples_real\[0\]\[11\] samples_real\[2\]\[11\] net59
+ _01009_ VDD VSS MUX2_X1
X_09944_ samples_real\[1\]\[11\] samples_real\[3\]\[11\] net59
+ _01010_ VDD VSS MUX2_X1
X_09945_ _01009_ _01010_ _00886_ _01011_ VDD VSS MUX2_X1
X_09946_ samples_real\[4\]\[11\] samples_real\[6\]\[11\] _00906_
+ _01012_ VDD VSS MUX2_X1
X_09947_ samples_real\[5\]\[11\] samples_real\[7\]\[11\] _00906_
+ _01013_ VDD VSS MUX2_X1
X_09948_ _01012_ _01013_ _00877_ _01014_ VDD VSS MUX2_X1
X_09949_ _01011_ _01014_ _00882_ _08660_ VDD VSS MUX2_X2
X_09950_ samples_real\[0\]\[10\] samples_real\[2\]\[10\] net129
+ _01015_ VDD VSS MUX2_X1
X_09951_ samples_real\[1\]\[10\] samples_real\[3\]\[10\] net129
+ _01016_ VDD VSS MUX2_X1
X_09952_ _01015_ _01016_ _00913_ _01017_ VDD VSS MUX2_X1
X_09953_ samples_real\[4\]\[10\] samples_real\[6\]\[10\] net129
+ _01018_ VDD VSS MUX2_X1
X_09954_ samples_real\[5\]\[10\] samples_real\[7\]\[10\] net129
+ _01019_ VDD VSS MUX2_X1
X_09955_ _01018_ _01019_ _00913_ _01020_ VDD VSS MUX2_X1
X_09956_ _01017_ _01020_ _00918_ _08665_ VDD VSS MUX2_X2
X_09957_ samples_real\[0\]\[9\] samples_real\[2\]\[9\] net60
+ _01021_ VDD VSS MUX2_X1
X_09958_ samples_real\[1\]\[9\] samples_real\[3\]\[9\] _00921_
+ _01022_ VDD VSS MUX2_X1
X_09959_ _01021_ _01022_ _00923_ _01023_ VDD VSS MUX2_X1
X_09960_ samples_real\[4\]\[9\] samples_real\[6\]\[9\] _00921_
+ _01024_ VDD VSS MUX2_X1
X_09961_ samples_real\[5\]\[9\] samples_real\[7\]\[9\] _00921_
+ _01025_ VDD VSS MUX2_X1
X_09962_ _01024_ _01025_ _00923_ _01026_ VDD VSS MUX2_X1
X_09963_ _01023_ _01026_ _00918_ _08670_ VDD VSS MUX2_X2
X_09964_ samples_real\[0\]\[8\] samples_real\[2\]\[8\] _00921_
+ _01027_ VDD VSS MUX2_X1
X_09965_ samples_real\[1\]\[8\] samples_real\[3\]\[8\] _00921_
+ _01028_ VDD VSS MUX2_X1
X_09966_ _01027_ _01028_ _00923_ _01029_ VDD VSS MUX2_X1
X_09967_ samples_real\[4\]\[8\] samples_real\[6\]\[8\] net477
+ _01030_ VDD VSS MUX2_X1
X_09968_ samples_real\[5\]\[8\] samples_real\[7\]\[8\] net477
+ _01031_ VDD VSS MUX2_X1
X_09969_ _01030_ _01031_ _00913_ _01032_ VDD VSS MUX2_X1
X_09970_ _01029_ _01032_ _00918_ _08675_ VDD VSS MUX2_X2
X_09971_ samples_real\[0\]\[7\] samples_real\[2\]\[7\] _00935_
+ _01033_ VDD VSS MUX2_X1
X_09972_ samples_real\[1\]\[7\] samples_real\[3\]\[7\] _00935_
+ _01034_ VDD VSS MUX2_X1
X_09973_ _01033_ _01034_ _00899_ _01035_ VDD VSS MUX2_X1
X_09974_ samples_real\[4\]\[7\] samples_real\[6\]\[7\] _00935_
+ _01036_ VDD VSS MUX2_X1
X_09975_ samples_real\[5\]\[7\] samples_real\[7\]\[7\] _00935_
+ _01037_ VDD VSS MUX2_X1
X_09976_ _01036_ _01037_ _00899_ _01038_ VDD VSS MUX2_X1
X_09977_ _01035_ _01038_ _00901_ _08680_ VDD VSS MUX2_X2
X_09978_ samples_real\[0\]\[6\] samples_real\[2\]\[6\] _00942_
+ _01039_ VDD VSS MUX2_X1
X_09979_ samples_real\[1\]\[6\] samples_real\[3\]\[6\] _00891_
+ _01040_ VDD VSS MUX2_X1
X_09980_ _01039_ _01040_ _00894_ _01041_ VDD VSS MUX2_X1
X_09981_ samples_real\[4\]\[6\] samples_real\[6\]\[6\] _00891_
+ _01042_ VDD VSS MUX2_X1
X_09982_ samples_real\[5\]\[6\] samples_real\[7\]\[6\] _00891_
+ _01043_ VDD VSS MUX2_X1
X_09983_ _01042_ _01043_ _00894_ _01044_ VDD VSS MUX2_X1
X_09984_ _01041_ _01044_ _00901_ _08685_ VDD VSS MUX2_X2
X_09985_ samples_real\[0\]\[5\] samples_real\[2\]\[5\] _00906_
+ _01045_ VDD VSS MUX2_X1
X_09986_ samples_real\[1\]\[5\] samples_real\[3\]\[5\] _00906_
+ _01046_ VDD VSS MUX2_X1
X_09987_ _01045_ _01046_ _00877_ _01047_ VDD VSS MUX2_X1
X_09988_ samples_real\[4\]\[5\] samples_real\[6\]\[5\] _00906_
+ _01048_ VDD VSS MUX2_X1
X_09989_ samples_real\[5\]\[5\] samples_real\[7\]\[5\] _00874_
+ _01049_ VDD VSS MUX2_X1
X_09990_ _01048_ _01049_ _00877_ _01050_ VDD VSS MUX2_X1
X_09991_ _01047_ _01050_ _00882_ _08690_ VDD VSS MUX2_X2
X_09992_ samples_real\[0\]\[4\] samples_real\[2\]\[4\] _00896_
+ _01051_ VDD VSS MUX2_X1
X_09993_ samples_real\[1\]\[4\] samples_real\[3\]\[4\] _00896_
+ _01052_ VDD VSS MUX2_X1
X_09994_ _01051_ _01052_ _00899_ _01053_ VDD VSS MUX2_X1
X_09995_ samples_real\[4\]\[4\] samples_real\[6\]\[4\] _00896_
+ _01054_ VDD VSS MUX2_X1
X_09996_ samples_real\[5\]\[4\] samples_real\[7\]\[4\] _00935_
+ _01055_ VDD VSS MUX2_X1
X_09997_ _01054_ _01055_ _00899_ _01056_ VDD VSS MUX2_X1
X_09998_ _01053_ _01056_ _00901_ _08695_ VDD VSS MUX2_X2
X_09999_ samples_real\[0\]\[3\] samples_real\[2\]\[3\] _00942_
+ _01057_ VDD VSS MUX2_X1
X_10000_ samples_real\[1\]\[3\] samples_real\[3\]\[3\] _00942_
+ _01058_ VDD VSS MUX2_X1
X_10001_ _01057_ _01058_ _00894_ _01059_ VDD VSS MUX2_X1
X_10002_ samples_real\[4\]\[3\] samples_real\[6\]\[3\] _00942_
+ _01060_ VDD VSS MUX2_X1
X_10003_ samples_real\[5\]\[3\] samples_real\[7\]\[3\] _00942_
+ _01061_ VDD VSS MUX2_X1
X_10004_ _01060_ _01061_ _00894_ _01062_ VDD VSS MUX2_X1
X_10005_ _01059_ _01062_ _00901_ _08700_ VDD VSS MUX2_X2
X_10006_ samples_real\[0\]\[2\] samples_real\[2\]\[2\] _00883_
+ _01063_ VDD VSS MUX2_X1
X_10007_ samples_real\[1\]\[2\] samples_real\[3\]\[2\] _00902_
+ _01064_ VDD VSS MUX2_X1
X_10008_ _01063_ _01064_ _00886_ _01065_ VDD VSS MUX2_X1
X_10009_ samples_real\[4\]\[2\] samples_real\[6\]\[2\] net59
+ _01066_ VDD VSS MUX2_X1
X_10010_ samples_real\[5\]\[2\] samples_real\[7\]\[2\] _00902_
+ _01067_ VDD VSS MUX2_X1
X_10011_ _01066_ _01067_ _00886_ _01068_ VDD VSS MUX2_X1
X_10012_ _01065_ _01068_ _00882_ _08705_ VDD VSS MUX2_X2
X_10013_ samples_real\[0\]\[1\] samples_real\[2\]\[1\] net60
+ _01069_ VDD VSS MUX2_X1
X_10014_ samples_real\[1\]\[1\] samples_real\[3\]\[1\] net60
+ _01070_ VDD VSS MUX2_X1
X_10015_ _01069_ _01070_ _00923_ _01071_ VDD VSS MUX2_X1
X_10016_ samples_real\[4\]\[1\] samples_real\[6\]\[1\] net60
+ _01072_ VDD VSS MUX2_X1
X_10017_ samples_real\[5\]\[1\] samples_real\[7\]\[1\] _00919_
+ _01073_ VDD VSS MUX2_X1
X_10018_ _01072_ _01073_ _00923_ _01074_ VDD VSS MUX2_X1
X_10019_ _01071_ _01074_ _00918_ _08710_ VDD VSS MUX2_X2
X_10020_ samples_real\[0\]\[0\] samples_real\[2\]\[0\] net130
+ _01075_ VDD VSS MUX2_X1
X_10021_ samples_real\[1\]\[0\] samples_real\[3\]\[0\] _00931_
+ _01076_ VDD VSS MUX2_X1
X_10022_ _01075_ _01076_ _00913_ _01077_ VDD VSS MUX2_X1
X_10023_ samples_real\[4\]\[0\] samples_real\[6\]\[0\] _00931_
+ _01078_ VDD VSS MUX2_X1
X_10024_ samples_real\[5\]\[0\] samples_real\[7\]\[0\] _00910_
+ _01079_ VDD VSS MUX2_X1
X_10025_ _01078_ _01079_ _00913_ _01080_ VDD VSS MUX2_X1
X_10026_ _01077_ _01080_ _00918_ _08640_ VDD VSS MUX2_X2
X_10027_ _00847_ _01081_ VDD VSS INV_X4
X_10028_ _09363_ _01082_ VDD VSS BUF_X4
X_10029_ _01082_ _01081_ _08715_ VDD VSS NAND2_X4
X_10030_ _09367_ _01083_ VDD VSS BUF_X4
X_10031_ _00847_ _01083_ _08777_ VDD VSS NAND2_X4
X_10032_ _08777_ _09313_ VDD VSS INV_X1
X_10033_ _09369_ _01084_ VDD VSS BUF_X4
X_10034_ _00848_ _01084_ _08764_ VDD VSS NAND2_X4
X_10035_ _08764_ _09317_ VDD VSS INV_X1
X_10036_ _00848_ _01082_ _08743_ VDD VSS NAND2_X4
X_10037_ _08743_ _09321_ VDD VSS INV_X1
X_10038_ _09340_ _01083_ _08721_ VDD VSS NAND2_X4
X_10039_ _08721_ _09329_ VDD VSS INV_X2
X_10040_ _09340_ _01084_ _07367_ VDD VSS NAND2_X4
X_10041_ _07367_ _07363_ VDD VSS INV_X2
X_10042_ _09345_ _01085_ VDD VSS BUF_X4
X_10043_ _01085_ _01086_ VDD VSS INV_X4
X_10044_ _01086_ _01087_ VDD VSS BUF_X4
X_10045_ _01087_ _01088_ VDD VSS CLKBUF_X3
X_10046_ _01088_ _01089_ VDD VSS CLKBUF_X3
X_10047_ _01089_ _01090_ VDD VSS BUF_X4
X_10048_ _01090_ _01091_ VDD VSS BUF_X4
X_10049_ _01091_ _08819_ VDD VSS BUF_X8
X_10050_ _01082_ _01092_ VDD VSS INV_X1
X_10051_ _00847_ _09340_ _01083_ _01084_ _01093_ VDD VSS OAI22_X1
X_10052_ _09342_ _01094_ VDD VSS BUF_X2
X_10053_ _00040_ _01095_ VDD VSS BUF_X4
X_10054_ _09357_ _01096_ VDD VSS BUF_X4
X_10055_ _01095_ _01096_ _01097_ VDD VSS NAND2_X4
X_10056_ _09309_ _01098_ VDD VSS BUF_X4
X_10057_ _09325_ _01098_ _01099_ VDD VSS OR2_X4
X_10058_ _01094_ _01085_ _01099_ _01097_ _01100_ VDD VSS OAI22_X4
X_10059_ _01092_ _08717_ _01093_ _01100_ _08718_ VDD VSS AND4_X4
X_10060_ net42 _09286_ VDD VSS INV_X2
X_10061_ _01082_ _01083_ _01084_ _01101_ VDD VSS NOR3_X1
X_10062_ _01086_ _01101_ _01081_ _01102_ VDD VSS OAI21_X2
X_10063_ _01094_ _01083_ _09340_ _01103_ VDD VSS AOI21_X4
X_10064_ _01103_ _01104_ VDD VSS INV_X1
X_10065_ _08720_ _01092_ _00847_ _01105_ VDD VSS OAI21_X2
Xclone22 _04633_ _04647_ _04634_ net22 VDD VSS NOR3_X2
X_10067_ _08719_ _01107_ VDD VSS INV_X2
X_10068_ _01102_ _01104_ _01107_ _01105_ _01108_ VDD VSS AOI211_X2
X_10069_ butterfly_count\[2\] _01109_ VDD VSS BUF_X4
X_10070_ _01095_ _01109_ _01110_ VDD VSS OR2_X2
X_10071_ _01096_ _01111_ VDD VSS INV_X2
X_10072_ _01110_ _01111_ _01107_ _01112_ VDD VSS AOI21_X2
X_10073_ _01110_ _01112_ _08715_ _01113_ VDD VSS MUX2_X1
X_10074_ net383 _01113_ _01114_ VDD VSS NAND2_X4
X_10075_ _01114_ _08725_ VDD VSS INV_X2
X_10076_ net31 _01115_ VDD VSS BUF_X4
X_10077_ _01115_ _01116_ VDD VSS BUF_X4
X_10078_ _01116_ _01117_ VDD VSS BUF_X4
X_10079_ _01085_ _01118_ VDD VSS BUF_X4
X_10080_ _01118_ _01119_ VDD VSS BUF_X4
X_10081_ _01119_ _01120_ VDD VSS CLKBUF_X3
X_10082_ _01120_ _01121_ VDD VSS BUF_X4
X_10083_ _01121_ _01122_ VDD VSS CLKBUF_X3
X_10084_ _09002_ _01123_ VDD VSS INV_X1
X_10085_ _08996_ _01124_ VDD VSS INV_X1
X_10086_ _08990_ _01125_ VDD VSS INV_X1
X_10087_ _08991_ _08984_ _08985_ _01126_ VDD VSS OAI21_X2
X_10088_ _01126_ _01125_ _01127_ VDD VSS NAND2_X2
X_10089_ _08988_ _01127_ _01128_ VDD VSS AND2_X4
X_10090_ _08997_ _01128_ _08987_ _01129_ VDD VSS OAI21_X4
X_10091_ _01124_ _01129_ _01130_ VDD VSS NAND2_X4
X_10092_ _08993_ _08994_ _01130_ _01131_ VDD VSS AOI21_X4
X_10093_ _09003_ _01132_ VDD VSS INV_X1
X_10094_ _01123_ _01131_ _01132_ _01133_ VDD VSS OAI21_X4
X_10095_ _09000_ _01133_ _01134_ VDD VSS AND2_X4
X_10096_ _08999_ _01134_ _01135_ VDD VSS OR2_X4
X_10097_ _01122_ _01135_ _01136_ VDD VSS NAND2_X1
X_10098_ _01117_ _01136_ _01137_ VDD VSS NAND2_X1
Xclone6 _09201_ _03966_ _09202_ net6 VDD VSS AOI21_X4
X_10100_ _08967_ _01139_ VDD VSS INV_X1
X_10101_ _08974_ _01140_ VDD VSS BUF_X2
X_10102_ _01140_ _08977_ _01141_ VDD VSS NAND2_X1
X_10103_ _08983_ _01142_ VDD VSS CLKBUF_X2
X_10104_ _01142_ _01143_ VDD VSS INV_X1
X_10105_ _01082_ _01083_ _01084_ _01144_ VDD VSS OR3_X2
X_10106_ _01085_ _01144_ _00848_ _01145_ VDD VSS AOI21_X4
X_10107_ _08720_ _01146_ VDD VSS INV_X1
X_10108_ _01146_ _01082_ _01081_ _01147_ VDD VSS AOI21_X2
X_10109_ _01145_ _01103_ _01147_ _08719_ _01148_ VDD VSS OAI211_X4
X_10110_ _01095_ _01109_ _01149_ VDD VSS AND2_X2
X_10111_ _01149_ _01150_ VDD VSS BUF_X4
X_10112_ _01148_ _01150_ _01151_ VDD VSS NAND2_X1
X_10113_ _01098_ _01152_ VDD VSS INV_X1
X_10114_ _01152_ _01153_ VDD VSS BUF_X4
X_10115_ _08733_ _01154_ VDD VSS INV_X1
X_10116_ _08742_ _08741_ _01155_ VDD VSS OR2_X1
X_10117_ _08736_ _08739_ _01156_ VDD VSS AND2_X2
X_10118_ _08735_ _01155_ _01156_ _08738_ _08736_ _01157_ VDD
+ VSS AOI221_X2
X_10119_ _01154_ _01157_ _01158_ VDD VSS NOR2_X4
X_10120_ _01145_ _01158_ _08732_ _01159_ VDD VSS OAI21_X4
X_10121_ _09325_ _08730_ VDD VSS INV_X16
X_10122_ _08724_ _01160_ VDD VSS INV_X1
X_10123_ _08727_ _08729_ _08728_ _01161_ VDD VSS OAI21_X2
X_10124_ _08726_ _01162_ VDD VSS INV_X1
X_10125_ _01160_ _01161_ _01162_ _01163_ VDD VSS AOI21_X4
X_10126_ _08730_ _01145_ _01163_ _08723_ _01164_ VDD VSS OAI211_X4
X_10127_ _01164_ _01165_ VDD VSS INV_X1
X_10128_ _08726_ _08724_ _01166_ VDD VSS NOR2_X1
X_10129_ _01163_ _01166_ _01161_ _01167_ VDD VSS AOI21_X2
X_10130_ _01159_ _01165_ _01167_ _01168_ VDD VSS NAND3_X2
X_10131_ _01109_ _01169_ VDD VSS INV_X2
X_10132_ _01169_ _01096_ _01170_ VDD VSS NAND2_X4
X_10133_ _01098_ _01170_ _01171_ VDD VSS NOR2_X2
X_10134_ _08724_ _08727_ _08730_ _08729_ _01172_ VDD VSS NAND4_X1
X_10135_ _01172_ _01144_ _00848_ _01173_ VDD VSS AOI21_X2
X_10136_ _01112_ _01149_ _01174_ VDD VSS NOR2_X4
X_10137_ _01171_ _01173_ _01148_ _01174_ _01175_ VDD VSS OAI211_X4
X_10138_ _08716_ _08720_ _01176_ VDD VSS XOR2_X1
X_10139_ _08719_ _01109_ _01095_ _01096_ _01177_ VDD VSS OR4_X4
X_10140_ _01177_ _01103_ _01178_ VDD VSS NAND2_X2
X_10141_ _01178_ _01102_ _01105_ _01107_ _01179_ VDD VSS AOI211_X4
X_10142_ _08718_ _01176_ _01179_ _08722_ VDD VSS MUX2_X2
X_10143_ _01159_ _01164_ _01175_ _08722_ _01180_ VDD VSS NAND4_X4
X_10144_ _01085_ _09313_ _01181_ VDD VSS NOR2_X2
X_10145_ _01181_ _01182_ VDD VSS INV_X1
X_10146_ _08767_ _01183_ VDD VSS INV_X1
X_10147_ _08770_ _01184_ VDD VSS BUF_X2
X_10148_ _08769_ _08772_ _01184_ _01185_ VDD VSS AOI21_X2
X_10149_ _08767_ _01184_ _08773_ _01186_ VDD VSS NAND3_X2
X_10150_ _08760_ _01187_ VDD VSS BUF_X1
Xclone8 net12 _03926_ _03910_ net8 VDD VSS NAND3_X4
X_10152_ _08763_ _01189_ VDD VSS BUF_X1
X_10153_ _08776_ _01187_ _08762_ _01189_ _01190_ VDD VSS OAI211_X2
X_10154_ _08775_ _08776_ _08759_ _01191_ VDD VSS AOI21_X2
X_10155_ _01191_ _01190_ _01192_ VDD VSS AND2_X4
X_10156_ _01183_ _01185_ _01192_ _01186_ _01193_ VDD VSS OAI22_X4
X_10157_ _08773_ _01194_ VDD VSS INV_X1
X_10158_ _01194_ _01191_ _01190_ _01195_ VDD VSS AOI21_X2
X_10159_ _08767_ _08769_ _08772_ _01195_ _01196_ VDD VSS NOR4_X4
X_10160_ _08767_ _01184_ _08769_ _01197_ VDD VSS NOR3_X2
X_10161_ _01196_ _01193_ _01182_ _01197_ _01198_ VDD VSS NOR4_X4
X_10162_ _01189_ _01187_ _08776_ _01199_ VDD VSS NAND3_X1
X_10163_ _01186_ _01170_ _01199_ _01200_ VDD VSS OR3_X4
X_10164_ _01095_ _01109_ _01201_ VDD VSS NOR2_X1
X_10165_ _01201_ _01096_ _08719_ _01202_ VDD VSS OAI21_X1
X_10166_ _01095_ _01109_ _01203_ VDD VSS NAND2_X2
X_10167_ _01202_ _01203_ _01204_ VDD VSS NAND2_X2
X_10168_ _01200_ _01204_ net383 _01205_ VDD VSS AOI21_X4
X_10169_ _01198_ _08766_ _01205_ _01206_ VDD VSS OAI21_X4
X_10170_ _08733_ _01157_ _01207_ VDD VSS XNOR2_X1
X_10171_ _08732_ _01145_ _01207_ _01208_ VDD VSS NAND3_X2
X_10172_ _08751_ _08754_ _08752_ _01209_ VDD VSS AOI21_X2
X_10173_ _08752_ _08755_ _01210_ VDD VSS NAND2_X1
X_10174_ _08757_ _08756_ _01211_ VDD VSS NOR2_X2
X_10175_ _01209_ _01210_ _01211_ _01212_ VDD VSS OAI21_X4
X_10176_ _08746_ _01213_ VDD VSS BUF_X2
X_10177_ _01213_ _08749_ _01214_ VDD VSS AND2_X2
X_10178_ _08745_ _01212_ _01214_ _01213_ _08748_ _01215_ VDD
+ VSS AOI221_X2
X_10179_ _00848_ _01083_ _01084_ _01216_ VDD VSS OAI21_X2
X_10180_ _01086_ _01216_ _01217_ VDD VSS NAND2_X2
X_10181_ _01215_ _01217_ _01218_ VDD VSS OR2_X4
X_10182_ _01169_ _01152_ _01096_ _01219_ VDD VSS NAND3_X2
X_10183_ _08752_ _08755_ _01220_ VDD VSS AND2_X1
X_10184_ _08757_ _01220_ _01214_ _01216_ _01221_ VDD VSS NAND4_X1
X_10185_ _01219_ _01221_ _01222_ VDD VSS NOR2_X1
X_10186_ _01222_ _01174_ _01148_ _01223_ VDD VSS OAI21_X2
X_10187_ _01208_ _01218_ _01223_ _01224_ VDD VSS AND3_X1
X_10188_ _01168_ _01180_ _01206_ _01224_ _01225_ VDD VSS NAND4_X4
X_10189_ _08748_ _08749_ _01212_ _01226_ VDD VSS AOI21_X4
X_10190_ _01213_ _01226_ _01227_ VDD VSS XNOR2_X2
X_10191_ _01227_ _01223_ _01218_ _01228_ VDD VSS AOI21_X4
X_10192_ _01181_ _01193_ _08766_ _01229_ VDD VSS OAI21_X4
X_10193_ _01229_ _01230_ VDD VSS INV_X4
X_10194_ _01206_ _01228_ _01230_ _01231_ VDD VSS OAI21_X4
X_10195_ _01153_ _01225_ _01231_ _01232_ VDD VSS NAND3_X4
X_10196_ _08783_ _08789_ _08786_ _01233_ VDD VSS NAND3_X2
Xclone10 _01588_ net10 VDD VSS BUF_X2
X_10198_ _08791_ _08792_ _08794_ _01235_ VDD VSS AOI21_X2
X_10199_ _08795_ _01236_ VDD VSS BUF_X1
X_10200_ _08797_ _01237_ VDD VSS BUF_X4
X_10201_ _01236_ _08792_ _08796_ _01237_ _01238_ VDD VSS OAI211_X2
X_10202_ _01233_ _01238_ _01235_ _01239_ VDD VSS AOI21_X4
X_10203_ _08783_ _01240_ VDD VSS INV_X1
X_10204_ _08785_ _08786_ _08788_ _01241_ VDD VSS AOI21_X1
X_10205_ _01240_ _01241_ _01242_ VDD VSS NOR2_X2
X_10206_ _01239_ _08779_ _01242_ _08782_ _01243_ VDD VSS NOR4_X4
Xclone7 _02124_ net15 _02125_ net7 VDD VSS NAND3_X4
X_10208_ _08780_ _08779_ _01245_ VDD VSS NOR2_X1
X_10209_ _01085_ _01243_ _01245_ _01246_ VDD VSS NOR3_X2
X_10210_ _01219_ _01204_ net383 _01247_ VDD VSS AOI21_X2
X_10211_ _01094_ _01248_ VDD VSS INV_X1
X_10212_ _01248_ _08721_ _01149_ _01249_ VDD VSS NAND3_X1
X_10213_ _01102_ _01249_ _01105_ _01107_ _08740_ VDD VSS AOI211_X4
X_10214_ _01237_ _08780_ _08792_ _01236_ _01250_ VDD VSS NAND4_X2
X_10215_ _01233_ _08740_ _01250_ _01251_ VDD VSS NOR3_X2
X_10216_ _01246_ _01247_ _01251_ _01252_ VDD VSS AOI21_X4
X_10217_ _08799_ _01253_ VDD VSS INV_X1
X_10218_ _08805_ _01254_ VDD VSS INV_X1
X_10219_ _08808_ _08811_ _08809_ _01255_ VDD VSS AOI21_X2
X_10220_ _08806_ _01256_ VDD VSS INV_X1
X_10221_ _01254_ _01256_ _01255_ _01257_ VDD VSS OAI21_X4
X_10222_ _01257_ _01258_ VDD VSS INV_X4
X_10223_ _08814_ _08817_ _08815_ _01259_ VDD VSS AOI21_X1
X_10224_ _01148_ _01149_ _01258_ _01259_ _01260_ VDD VSS NAND4_X2
X_10225_ _08803_ _01261_ VDD VSS INV_X1
X_10226_ _08806_ _08809_ _01262_ VDD VSS AND2_X1
X_10227_ _08812_ _01263_ VDD VSS INV_X1
X_10228_ _08814_ _01264_ VDD VSS INV_X1
X_10229_ _08815_ _08817_ _08818_ _01265_ VDD VSS OAI21_X2
X_10230_ _01263_ _01264_ _01265_ _01266_ VDD VSS AOI21_X2
X_10231_ _01257_ _01262_ _01266_ _01267_ VDD VSS AOI21_X4
X_10232_ _01261_ _01267_ _01268_ VDD VSS NOR2_X4
X_10233_ _08802_ _01260_ _01268_ _01269_ VDD VSS AOI21_X4
X_10234_ _08800_ _01270_ VDD VSS BUF_X1
X_10235_ _01270_ _01271_ VDD VSS INV_X1
X_10236_ _01253_ _01269_ _01271_ _01272_ VDD VSS OAI21_X4
X_10237_ net31 _01206_ _01273_ VDD VSS NAND2_X1
X_10238_ _01252_ _01273_ _01272_ _01274_ VDD VSS AND3_X4
X_10239_ _01232_ _01274_ _01275_ VDD VSS NAND2_X4
X_10240_ _08780_ _01276_ VDD VSS INV_X1
X_10241_ _08782_ _01239_ _01242_ _01277_ VDD VSS NOR3_X2
X_10242_ _01276_ _01277_ _01278_ VDD VSS NOR2_X1
X_10243_ _01276_ _01277_ _01279_ VDD VSS AND2_X1
X_10244_ net3 _01165_ _01167_ _01280_ VDD VSS AND3_X2
X_10245_ net3 _01164_ _01175_ _08722_ _01281_ VDD VSS AND4_X2
X_10246_ _01182_ _01193_ _01196_ _01197_ _01282_ VDD VSS OR4_X2
X_10247_ _01170_ _01186_ _01199_ _01283_ VDD VSS NOR3_X1
X_10248_ _01283_ _01174_ _01148_ _01284_ VDD VSS OAI21_X2
X_10249_ _08766_ _01285_ VDD VSS INV_X1
X_10250_ _01282_ _01284_ _01285_ _01286_ VDD VSS AOI21_X4
X_10251_ _01208_ _01218_ _01223_ _01287_ VDD VSS NAND3_X4
X_10252_ _01280_ _01281_ _01286_ _01287_ _01288_ VDD VSS NOR4_X4
X_10253_ _01213_ _01226_ _01289_ VDD VSS XOR2_X2
X_10254_ _01219_ _01221_ _01290_ VDD VSS OR2_X1
X_10255_ _01290_ _01204_ net383 _01291_ VDD VSS AOI21_X4
X_10256_ _01215_ _01217_ _01292_ VDD VSS NOR2_X4
X_10257_ _01289_ _01291_ _01292_ _01293_ VDD VSS OAI21_X2
X_10258_ _01286_ _01293_ _01229_ _01294_ VDD VSS AOI21_X4
X_10259_ _01086_ _01252_ _01295_ VDD VSS NAND2_X1
X_10260_ _01278_ _01252_ _01279_ _01288_ _01294_ _01295_ _01296_
+ VDD VSS OAI33_X1
X_10261_ _01243_ _01085_ _01245_ _01297_ VDD VSS OR3_X4
X_10262_ _01171_ _01174_ _01148_ _01298_ VDD VSS OAI21_X2
X_10263_ _01233_ _01250_ _08740_ _01299_ VDD VSS OR3_X4
X_10264_ _01297_ _01298_ _01299_ _01300_ VDD VSS OAI21_X4
X_10265_ _08780_ _01277_ _01301_ VDD VSS XNOR2_X1
X_10266_ _01098_ _01301_ _01302_ VDD VSS XNOR2_X1
X_10267_ _01300_ _01302_ _01303_ VDD VSS NAND2_X1
X_10268_ _01098_ _01252_ _01229_ _01293_ _01304_ VDD VSS NAND4_X2
X_10269_ _01287_ _01281_ _01280_ _01305_ VDD VSS NOR3_X4
X_10270_ _01303_ _01304_ _01305_ _01306_ VDD VSS OAI21_X4
X_10271_ _01296_ _01272_ _01306_ _01307_ VDD VSS AOI21_X4
X_10272_ _01275_ _01307_ _01308_ VDD VSS NAND2_X4
X_10273_ _01308_ _01309_ VDD VSS BUF_X8
X_10274_ _01151_ net36 _01310_ VDD VSS NOR2_X2
X_10275_ _01095_ _01311_ VDD VSS INV_X2
X_10276_ _08822_ _01312_ VDD VSS BUF_X2
X_10277_ _08824_ _01313_ VDD VSS INV_X1
X_10278_ _08827_ _01314_ VDD VSS BUF_X2
Xclone9 _01720_ net9 VDD VSS BUF_X2
X_10280_ _01314_ _08828_ _08830_ _01316_ VDD VSS AOI21_X2
X_10281_ _08825_ _01317_ VDD VSS INV_X1
X_10282_ _01313_ _01316_ _01317_ _01318_ VDD VSS OAI21_X1
X_10283_ _08821_ _01318_ _01312_ _01319_ VDD VSS AOI21_X2
X_10284_ _08831_ _01320_ VDD VSS CLKBUF_X2
X_10285_ _01312_ _08825_ _08828_ _01320_ _01321_ VDD VSS NAND4_X2
X_10286_ _08836_ _01322_ VDD VSS INV_X1
X_10287_ _08837_ _08839_ _08838_ _01323_ VDD VSS OAI21_X2
X_10288_ _01322_ _01323_ _01324_ VDD VSS NAND2_X2
X_10289_ _08833_ _01324_ _08834_ _01325_ VDD VSS AOI21_X4
X_10290_ _01325_ _01094_ _01326_ VDD VSS OR2_X4
X_10291_ _01319_ _01321_ _01326_ _01327_ VDD VSS OAI21_X4
X_10292_ _01327_ _01328_ VDD VSS INV_X1
X_10293_ _01300_ _01329_ VDD VSS BUF_X8
X_10294_ _01301_ _01330_ VDD VSS INV_X1
X_10295_ net25 _01330_ _01085_ _01331_ VDD VSS OAI21_X1
X_10296_ _08799_ _08802_ _01270_ _01332_ VDD VSS AOI21_X1
X_10297_ _01270_ _08803_ _01333_ VDD VSS NAND2_X1
X_10298_ _01332_ _01333_ _01267_ _01334_ VDD VSS OAI21_X1
X_10299_ net31 _01334_ _01335_ VDD VSS XNOR2_X1
X_10300_ _01086_ _01335_ _01336_ VDD VSS NAND2_X1
X_10301_ _01331_ _01336_ _01337_ VDD VSS NAND2_X2
X_10302_ net25 _01225_ _01231_ _01338_ VDD VSS AOI21_X4
X_10303_ _01328_ _01337_ _01338_ _01339_ VDD VSS OAI21_X2
X_10304_ _09325_ _01248_ _01325_ _01340_ VDD VSS OAI21_X4
X_10305_ _01340_ _01341_ VDD VSS INV_X4
X_10306_ _01319_ _01341_ _01321_ _01342_ VDD VSS OAI21_X4
X_10307_ _01342_ _01343_ VDD VSS INV_X1
X_10308_ _01343_ _01337_ _01338_ _01344_ VDD VSS OAI21_X4
X_10309_ _01264_ _01265_ _01345_ VDD VSS NAND2_X1
X_10310_ _08814_ _08817_ _01203_ _01346_ VDD VSS OR3_X1
X_10311_ _01345_ _01346_ _01108_ _01347_ VDD VSS OAI21_X2
X_10312_ _08812_ _01347_ _01348_ VDD VSS XNOR2_X2
X_10313_ _01296_ _01348_ _01349_ VDD VSS NAND2_X1
X_10314_ _01272_ _01348_ _01350_ VDD VSS AND2_X1
X_10315_ _01252_ _01272_ _01273_ _01348_ _01351_ VDD VSS AND4_X1
X_10316_ _01306_ _01350_ _01351_ _01232_ _01352_ VDD VSS AOI22_X4
X_10317_ _01225_ _01231_ _01353_ VDD VSS NAND2_X2
X_10318_ _01272_ _01354_ VDD VSS INV_X1
X_10319_ _01168_ _01180_ _01224_ _01355_ VDD VSS NAND3_X1
X_10320_ _01153_ _01300_ _01230_ _01228_ _01356_ VDD VSS NOR4_X2
X_10321_ _01355_ _01356_ _01302_ net25 _01357_ VDD VSS AOI22_X2
X_10322_ _01252_ _01330_ _01353_ _01295_ _01354_ _01357_ _01358_
+ VDD VSS OAI222_X2
X_10323_ _01189_ _01359_ VDD VSS INV_X1
X_10324_ _01148_ _01202_ _08761_ VDD VSS NOR2_X1
X_10325_ _01359_ _08761_ _01229_ _08793_ VDD VSS MUX2_X1
X_10326_ _01236_ _08796_ _01237_ _01360_ VDD VSS OAI21_X1
X_10327_ _01237_ _01236_ _08796_ _01361_ VDD VSS OR3_X1
X_10328_ _01360_ _01361_ _01362_ VDD VSS AND2_X1
X_10329_ _08793_ _01362_ _01300_ _08810_ VDD VSS MUX2_X2
X_10330_ net31 _01288_ _01294_ _01363_ VDD VSS NOR3_X4
X_10331_ _01252_ _01272_ _01273_ _01364_ VDD VSS NAND3_X2
X_10332_ _08810_ _01363_ _01364_ _01365_ VDD VSS OAI21_X2
X_10333_ _01349_ _01352_ _01358_ _01365_ _01366_ VDD VSS OAI211_X4
X_10334_ _01339_ _01344_ _01366_ _01367_ VDD VSS MUX2_X2
X_10335_ _01367_ _01368_ VDD VSS BUF_X8
X_10336_ _01311_ _01179_ _01368_ _01369_ VDD VSS OAI21_X2
X_10337_ _08871_ _01370_ VDD VSS BUF_X2
X_10338_ _08877_ _08863_ _08874_ _08880_ _01371_ VDD VSS NAND4_X1
X_10339_ _01170_ _01371_ _01372_ VDD VSS NOR2_X2
X_10340_ _08868_ _08866_ _01370_ _01372_ _01373_ VDD VSS NAND4_X4
X_10341_ _01373_ _01374_ VDD VSS INV_X4
X_10342_ _01118_ _01369_ _01374_ _01375_ VDD VSS AND3_X1
X_10343_ _01312_ _01313_ _01376_ VDD VSS NAND2_X1
X_10344_ _01314_ _01376_ _01377_ VDD VSS OR2_X1
X_10345_ _08830_ _01378_ VDD VSS INV_X1
X_10346_ _08833_ _01379_ VDD VSS INV_X1
X_10347_ _08838_ _01380_ VDD VSS INV_X1
X_10348_ _08839_ _01110_ _01179_ _01381_ VDD VSS OAI21_X1
X_10349_ _01380_ _01381_ _01382_ VDD VSS NAND2_X1
X_10350_ _08836_ _01382_ _08837_ _01383_ VDD VSS AOI21_X1
X_10351_ _08834_ _01384_ VDD VSS INV_X1
X_10352_ _01379_ _01383_ _01384_ _01385_ VDD VSS OAI21_X1
X_10353_ _01320_ _01385_ _01386_ VDD VSS NAND2_X1
X_10354_ _01248_ _08810_ _01387_ VDD VSS OR2_X1
X_10355_ _01248_ _08810_ _01388_ VDD VSS NAND2_X1
X_10356_ _08830_ _01232_ _01274_ _01387_ _01388_ _01389_ VDD
+ VSS AOI221_X2
X_10357_ _01378_ _01386_ _01389_ _01307_ _01390_ VDD VSS AOI22_X4
X_10358_ _01094_ _01348_ _01391_ VDD VSS XNOR2_X1
X_10359_ _08830_ _01391_ _01392_ VDD VSS NOR2_X2
X_10360_ _01363_ _01364_ _01393_ VDD VSS NOR2_X4
X_10361_ _01392_ _01358_ _01393_ _01394_ VDD VSS OAI21_X4
X_10362_ _01320_ _01395_ VDD VSS INV_X1
X_10363_ _09325_ _01395_ _01396_ VDD VSS NOR2_X2
X_10364_ _01377_ _01390_ _01394_ _01366_ _01396_ _01397_ VDD
+ VSS AOI221_X2
X_10365_ _01312_ _01398_ VDD VSS INV_X1
X_10366_ _01398_ _08824_ _01399_ VDD VSS NAND2_X1
X_10367_ _08825_ _08828_ _01314_ _01400_ VDD VSS OAI21_X1
X_10368_ _01312_ _01313_ _01400_ _01401_ VDD VSS NAND3_X1
X_10369_ _01399_ _01401_ _01402_ VDD VSS NAND2_X1
X_10370_ _01367_ _01397_ _01402_ _01403_ VDD VSS OAI21_X4
X_10371_ _01338_ _01337_ _01404_ VDD VSS NOR2_X4
X_10372_ _01327_ _01404_ _01405_ VDD VSS NOR2_X2
X_10373_ _01342_ _01404_ _01406_ VDD VSS NOR2_X2
X_10374_ _01405_ _01406_ _01366_ _01407_ VDD VSS MUX2_X2
X_10375_ _01314_ _01394_ _01390_ _01396_ _01366_ _01408_ VDD
+ VSS AOI221_X2
X_10376_ _01312_ _01400_ _01409_ VDD VSS OR2_X1
X_10377_ _01407_ _01408_ _01409_ _01410_ VDD VSS OR3_X4
X_10378_ _01407_ _01411_ VDD VSS BUF_X4
X_10379_ _08785_ _01412_ VDD VSS INV_X1
X_10380_ _01238_ _01235_ _01413_ VDD VSS NAND2_X1
X_10381_ _08788_ _01413_ _08789_ _01414_ VDD VSS AOI21_X1
X_10382_ _08786_ _01415_ VDD VSS INV_X1
X_10383_ _01412_ _01414_ _01415_ _01416_ VDD VSS OAI21_X1
X_10384_ _01240_ _01416_ _01417_ VDD VSS XNOR2_X1
X_10385_ net25 _01417_ _01418_ VDD VSS NAND2_X1
X_10386_ _01292_ _01291_ _01419_ VDD VSS NOR2_X4
X_10387_ _01419_ _01420_ VDD VSS INV_X2
X_10388_ _08738_ _01421_ VDD VSS INV_X1
X_10389_ _08739_ _01155_ _01422_ VDD VSS NAND2_X1
X_10390_ _01421_ _01422_ _01423_ VDD VSS NAND2_X1
X_10391_ _08736_ _01423_ _01424_ VDD VSS XOR2_X1
X_10392_ _01159_ _01424_ _01425_ VDD VSS NOR2_X1
X_10393_ _08727_ _08729_ _08728_ _01426_ VDD VSS OR3_X1
X_10394_ _01161_ _01426_ _01427_ VDD VSS NAND2_X1
X_10395_ _01164_ _01175_ _01428_ VDD VSS NAND2_X2
X_10396_ _01114_ _01427_ _01428_ _01429_ VDD VSS MUX2_X2
X_10397_ _01420_ _01425_ _01429_ net3 _01430_ VDD VSS AOI211_X2
X_10398_ _08749_ _01212_ _01431_ VDD VSS XOR2_X1
X_10399_ _01431_ _01291_ _01292_ _01432_ VDD VSS OAI21_X1
X_10400_ _01229_ _01432_ _01433_ VDD VSS NAND2_X1
X_10401_ _08772_ _01195_ _01434_ VDD VSS NOR2_X1
X_10402_ _01184_ _01434_ _01435_ VDD VSS XNOR2_X2
X_10403_ _01430_ _01433_ _01435_ _01229_ _01436_ VDD VSS OAI22_X4
X_10404_ _01418_ _01436_ net25 _08798_ VDD VSS OAI21_X2
X_10405_ _01270_ _01269_ _01437_ VDD VSS XNOR2_X1
X_10406_ _08798_ _01437_ _01308_ _08820_ VDD VSS MUX2_X2
X_10407_ _01411_ _08820_ _01438_ VDD VSS NAND2_X2
X_10408_ _01403_ _01410_ _01438_ _01439_ VDD VSS AND3_X1
X_10409_ _01439_ _01440_ VDD VSS BUF_X4
X_10410_ _08841_ _01441_ VDD VSS INV_X1
X_10411_ _08845_ _01442_ VDD VSS INV_X1
X_10412_ _08859_ _01443_ VDD VSS INV_X1
X_10413_ _08853_ _01444_ VDD VSS INV_X1
X_10414_ _08854_ _08857_ _08856_ _01445_ VDD VSS OAI21_X2
X_10415_ _01444_ _01445_ _01446_ VDD VSS NAND2_X2
X_10416_ _08848_ _01446_ _01447_ VDD VSS AND2_X4
X_10417_ _08860_ _08847_ _01447_ _01448_ VDD VSS OAI21_X4
X_10418_ _01442_ _01443_ _01448_ _01449_ VDD VSS AOI21_X4
X_10419_ _08842_ _08844_ _01449_ _01450_ VDD VSS OAI21_X4
X_10420_ _01441_ _01450_ _01451_ VDD VSS NAND2_X2
X_10421_ _08851_ _01451_ _01452_ VDD VSS XNOR2_X2
X_10422_ _01440_ _01452_ _01453_ VDD VSS NOR2_X1
X_10423_ _08851_ _01454_ VDD VSS INV_X1
X_10424_ _01454_ _01441_ _01450_ _01455_ VDD VSS AOI21_X4
X_10425_ _01455_ _08850_ _01456_ VDD VSS OR2_X4
X_10426_ _01086_ _01456_ _01457_ VDD VSS NAND2_X4
X_10427_ _01272_ _01348_ _01458_ VDD VSS NAND2_X1
X_10428_ _01252_ _01272_ _01273_ _01348_ _01459_ VDD VSS NAND4_X1
X_10429_ _01357_ _01458_ _01459_ _01363_ _01460_ VDD VSS OAI22_X1
X_10430_ _08810_ _01461_ VDD VSS INV_X1
X_10431_ _01461_ _01232_ _01274_ _01462_ VDD VSS AOI21_X1
X_10432_ _01460_ _01462_ _01307_ _01296_ _01348_ _01463_ VDD
+ VSS AOI221_X4
X_10433_ _01261_ _01267_ _01464_ VDD VSS XNOR2_X2
X_10434_ _01331_ _01336_ _01465_ VDD VSS AND2_X1
X_10435_ _01252_ _01288_ _01294_ _01466_ VDD VSS OAI21_X1
X_10436_ _01327_ _01464_ _01465_ _01466_ _01467_ VDD VSS AOI211_X2
X_10437_ _01467_ _01358_ _01393_ _01468_ VDD VSS OAI21_X2
X_10438_ _01415_ _01414_ _01469_ VDD VSS XNOR2_X1
X_10439_ _01329_ _01469_ _01470_ VDD VSS NAND2_X1
X_10440_ _08757_ _08756_ _01471_ VDD VSS OR2_X1
X_10441_ _08754_ _01471_ _08755_ _01472_ VDD VSS AOI21_X1
X_10442_ _08752_ _01472_ _01473_ VDD VSS XNOR2_X1
X_10443_ _08739_ _01155_ _01474_ VDD VSS XOR2_X1
X_10444_ _08729_ _01164_ _08737_ VDD VSS NOR2_X1
X_10445_ _01474_ _08737_ _01159_ _08750_ VDD VSS MUX2_X1
X_10446_ _01473_ _08750_ _01419_ _08771_ VDD VSS MUX2_X1
X_10447_ _08773_ _01192_ _01475_ VDD VSS XNOR2_X1
X_10448_ _08771_ _01475_ _01230_ _08784_ VDD VSS MUX2_X2
X_10449_ _01470_ _08784_ _01329_ _01476_ VDD VSS OAI21_X4
X_10450_ _01393_ _01358_ _01339_ _01476_ _01477_ VDD VSS OR4_X2
X_10451_ _08828_ _01320_ _01478_ VDD VSS NAND2_X1
X_10452_ _01316_ _01478_ _01326_ _01479_ VDD VSS OAI21_X1
X_10453_ _01317_ _01479_ _01480_ VDD VSS XNOR2_X1
X_10454_ _01339_ _01480_ _01481_ VDD VSS NAND2_X2
X_10455_ _01463_ _01468_ _01477_ _01481_ _01482_ VDD VSS NAND4_X4
X_10456_ _01344_ _01464_ _01275_ _01307_ _01483_ VDD VSS AOI211_X2
X_10457_ _01393_ _01358_ _01344_ _01476_ _01484_ VDD VSS NOR4_X4
X_10458_ _01316_ _01478_ _01341_ _01485_ VDD VSS OAI21_X1
X_10459_ _01317_ _01485_ _01486_ VDD VSS XNOR2_X1
X_10460_ _01344_ _01486_ _01487_ VDD VSS AND2_X1
X_10461_ _01463_ _01483_ _01484_ _01487_ _01488_ VDD VSS OR4_X1
X_10462_ _01488_ _01489_ VDD VSS BUF_X4
X_10463_ _01457_ _01482_ _01489_ _01490_ VDD VSS AOI21_X4
X_10464_ _01456_ _01085_ _01491_ VDD VSS NAND2_X4
X_10465_ _01491_ _01115_ _01492_ VDD VSS NAND2_X4
X_10466_ _01492_ _01482_ _01489_ _01493_ VDD VSS AND3_X4
X_10467_ _01493_ _01490_ _01494_ VDD VSS NOR2_X4
X_10468_ _08740_ _01159_ _01495_ VDD VSS NAND2_X1
X_10469_ _01495_ net3 _08742_ _08753_ VDD VSS OAI21_X1
X_10470_ _08755_ _01211_ _01496_ VDD VSS XNOR2_X1
X_10471_ _08753_ _01496_ _01420_ _08774_ VDD VSS MUX2_X1
X_10472_ _01189_ _08762_ _01497_ VDD VSS OR2_X1
X_10473_ _08759_ _01497_ _01187_ _01498_ VDD VSS AOI21_X1
X_10474_ _08776_ _01498_ _01499_ VDD VSS XNOR2_X1
X_10475_ _08774_ _01499_ _01230_ _08787_ VDD VSS MUX2_X1
X_10476_ _08789_ _01413_ _01500_ VDD VSS XOR2_X1
X_10477_ _08787_ _01500_ _01329_ _08804_ VDD VSS MUX2_X1
X_10478_ _08811_ _01501_ VDD VSS INV_X1
X_10479_ _01501_ _01347_ _01263_ _01502_ VDD VSS OAI21_X1
X_10480_ _08808_ _01502_ _08809_ _01503_ VDD VSS AOI21_X1
X_10481_ _08806_ _01503_ _01504_ VDD VSS XNOR2_X1
X_10482_ _08804_ _01504_ _01308_ _08826_ VDD VSS MUX2_X2
X_10483_ _01368_ _08826_ _01505_ VDD VSS NOR2_X1
X_10484_ _01394_ _01390_ _01396_ _01366_ _01506_ VDD VSS AOI22_X4
X_10485_ _08828_ _01506_ _01507_ VDD VSS XOR2_X2
X_10486_ _01505_ _01507_ _01368_ _08849_ VDD VSS AOI21_X4
X_10487_ _01440_ _01494_ _08849_ _01508_ VDD VSS AND3_X1
X_10488_ _01375_ _01453_ _01508_ _01509_ VDD VSS OAI21_X2
X_10489_ _01327_ _01342_ _01366_ _01510_ VDD VSS MUX2_X2
X_10490_ _01404_ _01510_ _01511_ VDD VSS AND2_X1
X_10491_ _08850_ _01455_ _01512_ VDD VSS NOR2_X4
X_10492_ _01118_ _01512_ _01513_ VDD VSS NOR2_X2
X_10493_ _01463_ _01468_ _01477_ _01481_ _01514_ VDD VSS AND4_X4
X_10494_ _01463_ _01483_ _01484_ _01487_ _01515_ VDD VSS NOR4_X4
X_10495_ _01513_ _01514_ _01515_ _01516_ VDD VSS OAI21_X4
X_10496_ _01489_ _01482_ _01492_ _01517_ VDD VSS NAND3_X4
X_10497_ _01516_ _01517_ _01518_ VDD VSS NAND2_X4
X_10498_ net383 _01177_ _01519_ VDD VSS NAND2_X4
X_10499_ _01086_ _01519_ _01374_ _01520_ VDD VSS NAND3_X1
X_10500_ _01095_ _01086_ _01521_ VDD VSS NAND2_X1
X_10501_ _01367_ _01520_ _01521_ _01373_ _01522_ VDD VSS OAI22_X2
X_10502_ _01149_ _01179_ _01308_ _01523_ VDD VSS OAI21_X2
X_10503_ _08842_ _08854_ _08860_ _08851_ _01524_ VDD VSS NAND4_X1
X_10504_ _08857_ _08845_ _08848_ _01525_ VDD VSS NAND3_X1
X_10505_ _01097_ _01524_ _01525_ _01526_ VDD VSS NOR3_X1
X_10506_ _01523_ _01526_ _01527_ VDD VSS NAND2_X1
X_10507_ _01515_ _01514_ _01528_ VDD VSS NOR2_X4
X_10508_ _01522_ _01507_ net11 _01527_ _01528_ _01529_ VDD
+ VSS OAI221_X2
X_10509_ _01368_ _08820_ _08826_ _01530_ VDD VSS NOR3_X2
X_10510_ _01398_ _08825_ _01314_ _01531_ VDD VSS NAND3_X1
X_10511_ _01399_ _01401_ _01531_ _01532_ VDD VSS NAND3_X1
X_10512_ net11 _01532_ _01533_ VDD VSS NOR2_X1
X_10513_ _01409_ _01377_ _01506_ _01534_ VDD VSS MUX2_X1
X_10514_ _01530_ _01533_ _01534_ _01535_ VDD VSS AOI21_X1
X_10515_ _01518_ _01529_ _01535_ _01536_ VDD VSS NOR3_X2
X_10516_ _01369_ _01374_ _01490_ _01493_ _01537_ VDD VSS OAI211_X2
X_10517_ _01454_ _01451_ _01538_ VDD VSS XNOR2_X2
X_10518_ _01118_ _01538_ _01539_ VDD VSS XNOR2_X2
X_10519_ _01539_ _01540_ VDD VSS INV_X1
X_10520_ _01440_ _01537_ _01540_ _01541_ VDD VSS OAI21_X1
X_10521_ _01452_ _01522_ _01542_ VDD VSS AND2_X1
X_10522_ _01518_ _01542_ _01543_ VDD VSS OR2_X1
X_10523_ _01511_ _01536_ _01541_ _01543_ _01544_ VDD VSS AOI211_X4
X_10524_ _01118_ _01512_ _01545_ VDD VSS NAND2_X1
X_10525_ _01489_ _01482_ _01457_ _01545_ _01546_ VDD VSS AOI22_X2
X_10526_ _01115_ _01118_ _01547_ VDD VSS NOR2_X2
X_10527_ _01547_ _01512_ _01548_ VDD VSS NAND2_X1
X_10528_ _01515_ _01514_ _01491_ _01548_ _01549_ VDD VSS AOI211_X2
X_10529_ _01118_ _01456_ _01550_ VDD VSS NOR2_X1
X_10530_ _01404_ _01489_ _01482_ _01510_ _01551_ VDD VSS AND4_X1
X_10531_ _01546_ _01549_ _01550_ _01551_ _01552_ VDD VSS AOI211_X2
X_10532_ _01528_ _01550_ _01553_ VDD VSS NAND2_X1
X_10533_ _01404_ _01510_ _01554_ VDD VSS NAND2_X4
X_10534_ _01403_ _01410_ _01438_ _01554_ _01555_ VDD VSS NAND4_X4
X_10535_ _01552_ _01553_ _01440_ _01528_ _01555_ _01556_ VDD
+ VSS OAI221_X2
X_10536_ _01367_ _08820_ _08826_ _01557_ VDD VSS OR3_X1
X_10537_ _01411_ _01532_ _01558_ VDD VSS OR2_X1
X_10538_ net43 _01409_ _01559_ VDD VSS NAND2_X1
X_10539_ _01314_ _01376_ _01560_ VDD VSS NOR2_X1
X_10540_ net43 _01560_ _01561_ VDD VSS OR2_X1
X_10541_ _01559_ _01561_ _01506_ _01562_ VDD VSS MUX2_X1
X_10542_ _01557_ _01558_ _01562_ _01563_ VDD VSS OAI21_X4
X_10543_ _08873_ _01564_ VDD VSS INV_X1
X_10544_ _08879_ _01565_ VDD VSS INV_X1
X_10545_ _08865_ _01566_ VDD VSS INV_X1
X_10546_ _08866_ _08867_ _08868_ _01567_ VDD VSS OAI21_X1
X_10547_ _01566_ _01567_ _01568_ VDD VSS NAND2_X1
X_10548_ _01568_ _08863_ _01569_ VDD VSS AND2_X4
X_10549_ _08880_ _01569_ _08862_ _01570_ VDD VSS OAI21_X4
X_10550_ _01565_ _01570_ _01571_ VDD VSS NAND2_X4
X_10551_ _08876_ _01571_ _08877_ _01572_ VDD VSS AOI21_X4
X_10552_ _08874_ _01573_ VDD VSS INV_X1
X_10553_ _01564_ _01573_ _01572_ _01574_ VDD VSS OAI21_X4
X_10554_ _01574_ _01370_ _01575_ VDD VSS AND2_X4
X_10555_ _08870_ _01575_ _01576_ VDD VSS NOR2_X4
X_10556_ _01576_ _01118_ _01577_ VDD VSS NOR2_X4
X_10557_ _01494_ _01554_ _01563_ _01577_ _01578_ VDD VSS AND4_X2
X_10558_ _01452_ _01577_ _01579_ VDD VSS NAND2_X1
X_10559_ _01403_ _01410_ _01438_ _01554_ _01580_ VDD VSS AND4_X4
X_10560_ _01579_ _01580_ _01494_ _01581_ VDD VSS AOI21_X1
X_10561_ _01490_ _01493_ _01511_ _01582_ VDD VSS NOR3_X2
X_10562_ _08870_ _01575_ _01583_ VDD VSS OR2_X2
X_10563_ _01118_ _01583_ _01584_ VDD VSS NAND2_X2
X_10564_ _01582_ _01563_ _01584_ _01115_ _01585_ VDD VSS AOI22_X2
X_10565_ _01452_ _01555_ _01518_ _01586_ VDD VSS OAI21_X4
X_10566_ _01578_ _01581_ _01585_ _01586_ _01587_ VDD VSS AOI211_X2
X_10567_ _01509_ _01544_ _01556_ _01587_ _01588_ VDD VSS NAND4_X2
X_10568_ _01588_ _01589_ VDD VSS BUF_X4
X_10569_ _01370_ _01574_ _01590_ VDD VSS XOR2_X2
X_10570_ _08894_ _08897_ _08900_ _01591_ VDD VSS NOR3_X2
X_10571_ _08901_ _08882_ _08883_ _01592_ VDD VSS OAI21_X2
X_10572_ _08882_ _08885_ _01593_ VDD VSS OR2_X1
X_10573_ _08888_ _01594_ VDD VSS INV_X1
X_10574_ _01108_ _01203_ _01595_ VDD VSS NOR2_X4
X_10575_ _01595_ _01275_ _01307_ _01596_ VDD VSS NAND3_X2
X_10576_ _08892_ _01597_ VDD VSS BUF_X1
X_10577_ _08891_ _01596_ _01597_ _01598_ VDD VSS AOI21_X1
X_10578_ _08889_ _01599_ VDD VSS INV_X1
X_10579_ _01594_ _01598_ _01599_ _01600_ VDD VSS OAI21_X2
Xclone3 _01145_ _08732_ _01158_ net3 VDD VSS OAI21_X4
X_10581_ _01593_ _01600_ _08886_ _01602_ VDD VSS AOI21_X4
X_10582_ _01591_ _01602_ _01592_ _01603_ VDD VSS OAI21_X4
Xclone4 _01493_ _01490_ net4 VDD VSS NOR2_X4
X_10584_ _08898_ _08894_ _08897_ _01605_ VDD VSS NOR3_X2
X_10585_ _08895_ _08894_ _01606_ VDD VSS NOR2_X2
X_10586_ _01606_ _01605_ _01607_ VDD VSS NOR2_X4
X_10587_ _01603_ _01607_ _01608_ VDD VSS NAND2_X2
X_10588_ _01608_ _01590_ _01119_ _01609_ VDD VSS NOR3_X4
X_10589_ _01370_ _01574_ _01610_ VDD VSS XNOR2_X1
X_10590_ _01603_ _01119_ _01607_ _01611_ VDD VSS NAND3_X4
X_10591_ _01610_ _01611_ _01115_ _01612_ VDD VSS AOI21_X4
X_10592_ net10 _01609_ _01612_ _01613_ VDD VSS OAI21_X2
X_10593_ _01119_ _01369_ _01374_ _01614_ VDD VSS NAND3_X1
X_10594_ _01403_ _01410_ _01438_ _01615_ VDD VSS NAND3_X2
X_10595_ _01615_ _01538_ _01616_ VDD VSS NAND2_X1
X_10596_ _01440_ _01494_ _08849_ _01617_ VDD VSS NAND3_X2
X_10597_ _01614_ _01616_ _01617_ _01618_ VDD VSS AOI21_X4
X_10598_ _01518_ _01529_ _01535_ _01619_ VDD VSS OR3_X1
X_10599_ _01411_ _01519_ _01620_ VDD VSS NAND2_X4
X_10600_ _01373_ _01517_ _01516_ _01311_ _01620_ _01621_ VDD
+ VSS AOI221_X2
X_10601_ _01615_ _01621_ _01539_ _01622_ VDD VSS AOI21_X2
X_10602_ _01518_ _01542_ _01623_ VDD VSS NOR2_X1
X_10603_ _01554_ _01619_ _01622_ _01623_ _01624_ VDD VSS OAI211_X4
X_10604_ _01086_ _01456_ _01625_ VDD VSS NOR2_X1
X_10605_ _01515_ _01514_ _01513_ _01625_ _01626_ VDD VSS OAI22_X2
X_10606_ _01491_ _01627_ VDD VSS INV_X1
X_10607_ _01547_ _01512_ _01628_ VDD VSS AND2_X1
X_10608_ _01489_ _01482_ _01627_ _01628_ _01629_ VDD VSS OAI211_X2
X_10609_ _01550_ _01630_ VDD VSS INV_X1
X_10610_ _01404_ _01489_ _01482_ _01510_ _01631_ VDD VSS NAND4_X1
X_10611_ _01626_ _01629_ _01630_ _01631_ _01632_ VDD VSS OAI211_X2
X_10612_ _01489_ _01482_ _01633_ VDD VSS NAND2_X2
X_10613_ _01633_ _01630_ _01634_ VDD VSS NOR2_X1
X_10614_ _01632_ _01634_ _01615_ _01633_ _01580_ _01635_ VDD
+ VSS AOI221_X2
X_10615_ _01635_ _01636_ VDD VSS CLKBUF_X3
X_10616_ net4 _01554_ _01563_ _01577_ _01637_ VDD VSS NAND4_X2
X_10617_ _01119_ _01538_ _01576_ _01638_ VDD VSS NOR3_X1
X_10618_ _01638_ _01555_ _01518_ _01639_ VDD VSS OAI21_X2
X_10619_ _01115_ _01584_ _01640_ VDD VSS NAND2_X1
X_10620_ net43 _01409_ _01641_ VDD VSS AND2_X1
X_10621_ net43 _01560_ _01642_ VDD VSS NOR2_X1
X_10622_ _01641_ _01642_ _01506_ _01643_ VDD VSS MUX2_X1
X_10623_ _01530_ _01533_ _01643_ _01644_ VDD VSS AOI21_X2
X_10624_ _01516_ _01517_ _01554_ _01645_ VDD VSS NAND3_X2
X_10625_ _01640_ _01644_ _01645_ _01646_ VDD VSS OAI21_X2
X_10626_ _01538_ _01580_ net4 _01647_ VDD VSS AOI21_X4
X_10627_ _01637_ _01639_ _01646_ _01647_ _01648_ VDD VSS OAI211_X4
X_10628_ _01618_ _01624_ _01636_ _01648_ _01649_ VDD VSS NOR4_X4
X_10629_ _01187_ _01497_ _01650_ VDD VSS XOR2_X1
X_10630_ _08757_ _01215_ _01217_ _08758_ VDD VSS NOR3_X2
X_10631_ _01650_ _08758_ _01229_ _08790_ VDD VSS MUX2_X1
X_10632_ _01329_ _08790_ _01651_ VDD VSS NOR2_X1
X_10633_ _08794_ _01652_ VDD VSS INV_X1
X_10634_ _01652_ _01360_ _01653_ VDD VSS NAND2_X1
X_10635_ _08792_ _01653_ _01654_ VDD VSS XNOR2_X1
X_10636_ _01651_ _01654_ _01329_ _08807_ VDD VSS AOI21_X2
X_10637_ _08811_ _01266_ _01655_ VDD VSS NOR2_X1
X_10638_ _08809_ _01655_ _01656_ VDD VSS XNOR2_X1
X_10639_ _08807_ _01656_ _01308_ _08829_ VDD VSS MUX2_X1
X_10640_ _01326_ _01341_ _01366_ _01657_ VDD VSS MUX2_X1
X_10641_ _01320_ _01657_ _01658_ VDD VSS XNOR2_X1
X_10642_ _08829_ _01658_ _01368_ _08840_ VDD VSS MUX2_X2
X_10643_ net4 _01580_ _08840_ _01659_ VDD VSS NAND3_X2
X_10644_ _01494_ _01580_ _01660_ VDD VSS NAND2_X4
X_10645_ _08842_ _08844_ _01449_ _01661_ VDD VSS OR3_X1
X_10646_ _01450_ _01661_ _01662_ VDD VSS AND2_X1
X_10647_ _01660_ _01662_ _01663_ VDD VSS NAND2_X1
X_10648_ _01659_ _01663_ _01115_ _01611_ _01664_ VDD VSS AOI22_X4
X_10649_ _08840_ _01662_ _01660_ _08869_ VDD VSS MUX2_X2
X_10650_ _01608_ _08869_ _01119_ _01665_ VDD VSS NOR3_X4
X_10651_ _01649_ _01664_ _01665_ _01666_ VDD VSS OAI21_X4
X_10652_ _01118_ _01576_ _01667_ VDD VSS NAND2_X1
X_10653_ _01528_ _01512_ _01667_ _01668_ VDD VSS NOR3_X1
X_10654_ _01456_ _01667_ _01669_ VDD VSS NOR2_X1
X_10655_ _01555_ _01668_ _01669_ _01528_ _01670_ VDD VSS AOI22_X2
X_10656_ _01645_ _01644_ _01671_ VDD VSS NOR2_X2
X_10657_ _01670_ _01671_ _01647_ _01672_ VDD VSS OAI21_X2
X_10658_ _01672_ _01544_ _01509_ _01087_ _01583_ _01673_ VDD
+ VSS AOI221_X2
X_10659_ _01582_ _01563_ _01674_ VDD VSS NAND2_X2
X_10660_ _01586_ _01674_ _01636_ _01670_ _01675_ VDD VSS AOI22_X1
X_10661_ _01087_ _01576_ _01676_ VDD VSS NAND2_X2
X_10662_ _01153_ _01633_ _01512_ _01677_ VDD VSS NAND3_X1
X_10663_ _01115_ _01528_ _01512_ _01678_ VDD VSS NAND3_X1
X_10664_ _01580_ _01677_ _01678_ _01679_ VDD VSS AOI21_X1
X_10665_ _01115_ _01633_ _01456_ _01680_ VDD VSS NAND3_X1
X_10666_ _01153_ _01456_ _01681_ VDD VSS NAND2_X1
X_10667_ _01680_ _01681_ _01633_ _01682_ VDD VSS OAI21_X1
X_10668_ _01153_ _01528_ _01555_ _01683_ VDD VSS NOR3_X1
X_10669_ _01676_ _01679_ _01682_ _01683_ _01684_ VDD VSS NOR4_X2
X_10670_ _01647_ _01671_ _01685_ VDD VSS NOR2_X2
X_10671_ _01675_ _01684_ _01685_ _01686_ VDD VSS AOI21_X2
X_10672_ _01584_ _01636_ _01687_ VDD VSS OR2_X1
X_10673_ _01672_ _01544_ _01509_ _01688_ VDD VSS AOI21_X2
X_10674_ _01673_ _01686_ _01687_ _01688_ _01689_ VDD VSS OAI22_X4
X_10675_ _01490_ _01493_ _01554_ _01690_ VDD VSS NOR3_X1
X_10676_ _01518_ _01690_ _01440_ _01691_ VDD VSS MUX2_X2
X_10677_ _01554_ net4 _01440_ _01692_ VDD VSS AOI21_X4
X_10678_ _01556_ _01587_ _01693_ VDD VSS NAND2_X2
X_10679_ _01691_ _01692_ _01693_ _01694_ VDD VSS AOI21_X4
X_10680_ _01613_ _01666_ _01689_ _01694_ _01695_ VDD VSS AND4_X1
X_10681_ _01695_ _01696_ VDD VSS BUF_X4
X_10682_ _01143_ _01310_ _01696_ _01697_ VDD VSS AOI21_X1
X_10683_ _08980_ _08982_ _01697_ _01698_ VDD VSS OAI21_X1
X_10684_ _08979_ _01699_ VDD VSS INV_X1
X_10685_ _01141_ _01698_ _01699_ _01700_ VDD VSS AOI21_X1
X_10686_ _08973_ _08976_ _01140_ _01701_ VDD VSS AOI21_X1
X_10687_ _01701_ _01702_ VDD VSS INV_X1
X_10688_ _01700_ _01702_ _01703_ VDD VSS OR2_X1
X_10689_ _08970_ _01703_ _08971_ _01704_ VDD VSS AOI21_X1
X_10690_ _08968_ _01705_ VDD VSS BUF_X1
X_10691_ _01705_ _01706_ VDD VSS INV_X1
X_10692_ _01139_ _01704_ _01706_ _01707_ VDD VSS OAI21_X1
X_10693_ _08965_ _01707_ _01708_ VDD VSS XOR2_X2
X_10694_ _01137_ _01708_ _01709_ VDD VSS NAND2_X1
X_10695_ _01201_ _01710_ VDD VSS BUF_X4
X_10696_ _01595_ _01309_ _01620_ _01710_ _01711_ VDD VSS AOI22_X4
X_10697_ _01711_ _08855_ VDD VSS INV_X4
X_10698_ _01660_ _08855_ _01712_ VDD VSS NOR2_X4
X_10699_ _01712_ _01660_ _08857_ _08864_ VDD VSS AOI21_X2
X_10700_ _08868_ _08866_ _08867_ _01713_ VDD VSS OR3_X1
X_10701_ _01567_ _01713_ _01714_ VDD VSS AND2_X1
X_10702_ _08864_ _01714_ _01589_ _08884_ VDD VSS MUX2_X1
X_10703_ _08891_ _01715_ VDD VSS INV_X1
X_10704_ _01597_ _01716_ VDD VSS INV_X1
X_10705_ _01715_ _01310_ _01716_ _01717_ VDD VSS OAI21_X1
X_10706_ _08888_ _01717_ _08889_ _01718_ VDD VSS AOI21_X1
X_10707_ _08886_ _01718_ _01719_ VDD VSS XNOR2_X1
X_10708_ _01666_ _01613_ _01689_ _01694_ _01720_ VDD VSS NAND4_X4
X_10709_ _01720_ _01721_ VDD VSS BUF_X4
X_10710_ _08884_ _01719_ _01721_ _08911_ VDD VSS MUX2_X1
X_10711_ _08903_ _08906_ _08904_ _01722_ VDD VSS AOI21_X2
X_10712_ _08915_ _08914_ _01723_ VDD VSS OR2_X1
X_10713_ _08907_ _08904_ _01723_ _01724_ VDD VSS NAND3_X1
X_10714_ _08914_ _01110_ _01368_ _01725_ VDD VSS OR3_X1
X_10715_ _01725_ _01308_ _01595_ _01710_ _01620_ _01726_ VDD
+ VSS AOI221_X2
X_10716_ _01722_ _01724_ _01726_ _01727_ VDD VSS OAI21_X4
X_10717_ _08913_ _01727_ _01728_ VDD VSS XOR2_X1
X_10718_ _01556_ _01587_ _01618_ _01624_ _01729_ VDD VSS OAI211_X4
X_10719_ _01647_ _01671_ _01576_ _01730_ VDD VSS NOR3_X1
X_10720_ _01556_ _01674_ _01586_ _01731_ VDD VSS AOI21_X1
X_10721_ _01087_ _01556_ _01730_ _01731_ _01576_ _01732_ VDD
+ VSS AOI221_X2
X_10722_ _01647_ _01671_ _01583_ _01733_ VDD VSS NOR3_X1
X_10723_ _01115_ _01636_ _01734_ VDD VSS XNOR2_X1
X_10724_ _01636_ _01674_ _01586_ _01735_ VDD VSS AOI21_X1
X_10725_ _01119_ _01733_ _01734_ _01735_ _01583_ _01736_ VDD
+ VSS AOI221_X2
X_10726_ _01691_ _01732_ _01736_ _01737_ VDD VSS NOR3_X2
X_10727_ _01685_ _01577_ _01636_ _01738_ VDD VSS NOR3_X2
X_10728_ _01618_ _01624_ _01739_ VDD VSS NOR2_X2
X_10729_ _01737_ _01738_ _01739_ _01740_ VDD VSS AOI21_X4
X_10730_ _08897_ _01741_ VDD VSS INV_X1
X_10731_ _08882_ _01742_ VDD VSS INV_X1
X_10732_ _08889_ _08891_ _01597_ _01743_ VDD VSS OAI21_X1
X_10733_ _01594_ _01743_ _01744_ VDD VSS NAND2_X1
X_10734_ _08885_ _01744_ _08886_ _01745_ VDD VSS AOI21_X1
X_10735_ _08883_ _01746_ VDD VSS INV_X1
X_10736_ _01742_ _01745_ _01746_ _01747_ VDD VSS OAI21_X1
X_10737_ _08900_ _01747_ _08901_ _01748_ VDD VSS AOI21_X2
X_10738_ _08898_ _01749_ VDD VSS INV_X1
X_10739_ _01741_ _01748_ _01749_ _01750_ VDD VSS OAI21_X1
X_10740_ _08894_ _01750_ _08895_ _01751_ VDD VSS AOI21_X2
X_10741_ _01119_ _01751_ _01752_ VDD VSS NOR2_X1
X_10742_ _01116_ _01087_ _01751_ _01753_ VDD VSS OAI21_X1
X_10743_ _08869_ _01590_ _01588_ _01754_ VDD VSS MUX2_X1
X_10744_ _01752_ _01753_ _01754_ _01755_ VDD VSS MUX2_X1
X_10745_ _01692_ _01729_ _01691_ _01740_ _01755_ _01756_ VDD
+ VSS OAI221_X2
X_10746_ net10 _01664_ _01665_ _01757_ VDD VSS OR3_X1
X_10747_ _01649_ _01609_ _01612_ _01758_ VDD VSS OR3_X1
X_10748_ _01757_ _01758_ _01759_ VDD VSS NAND2_X1
X_10749_ _01691_ _01676_ _01584_ _01674_ _01586_ _01760_ VDD
+ VSS AOI221_X2
X_10750_ _01584_ _01676_ _01761_ VDD VSS NAND2_X1
X_10751_ _01647_ _01671_ _01691_ _01761_ _01762_ VDD VSS NOR4_X1
X_10752_ _01636_ _01648_ _01760_ _01762_ _01763_ VDD VSS OAI22_X1
X_10753_ _01586_ _01674_ _01764_ VDD VSS NAND2_X1
X_10754_ _01764_ _01691_ _01761_ _01765_ VDD VSS NAND3_X1
X_10755_ _01763_ _01765_ _01729_ _01766_ VDD VSS OAI21_X1
X_10756_ _01440_ net4 _01767_ VDD VSS NOR2_X1
X_10757_ _01767_ _01690_ _01440_ _01768_ VDD VSS AOI21_X1
X_10758_ _01764_ _01768_ _01761_ _01769_ VDD VSS OR3_X1
X_10759_ _01764_ net10 _01769_ _01693_ _01770_ VDD VSS OAI22_X2
X_10760_ _01766_ _01770_ _01689_ _01694_ _01771_ VDD VSS AOI211_X2
X_10761_ _01636_ _01648_ _01772_ VDD VSS NAND2_X1
X_10762_ _01729_ _01772_ _01773_ VDD VSS AND2_X1
X_10763_ _01649_ _01609_ _01612_ _01774_ VDD VSS NOR3_X2
X_10764_ net10 _01664_ _01665_ _01775_ VDD VSS NOR3_X2
X_10765_ _01773_ _01774_ _01775_ _01776_ VDD VSS OAI21_X2
X_10766_ _01740_ _01759_ _01771_ _01776_ _01777_ VDD VSS OAI22_X4
X_10767_ _01119_ _01751_ _01778_ VDD VSS XNOR2_X1
X_10768_ _01754_ _01778_ _01779_ VDD VSS AND2_X1
X_10769_ _01754_ _01778_ _01694_ _01689_ _01780_ VDD VSS AOI211_X2
X_10770_ _01153_ _01603_ _01607_ _01781_ VDD VSS AOI21_X1
X_10771_ _01754_ _01689_ _01694_ _01781_ _01782_ VDD VSS AND4_X1
X_10772_ _01779_ _01780_ _01782_ _01783_ VDD VSS NOR3_X4
X_10773_ _08909_ _01784_ VDD VSS INV_X1
X_10774_ _01724_ _01722_ _01785_ VDD VSS NAND2_X1
X_10775_ _08912_ _08913_ _01785_ _01786_ VDD VSS AOI21_X2
X_10776_ _08910_ _01787_ VDD VSS INV_X1
X_10777_ _01784_ _01787_ _01786_ _01788_ VDD VSS OAI21_X2
X_10778_ _08920_ _08921_ _01788_ _01789_ VDD VSS AOI21_X4
X_10779_ _01789_ _01790_ VDD VSS INV_X4
X_10780_ _08917_ _08918_ _01790_ _01791_ VDD VSS AOI21_X2
X_10781_ _01791_ _01792_ VDD VSS INV_X2
X_10782_ _01792_ _01087_ _01793_ VDD VSS NAND2_X1
X_10783_ _08918_ _08910_ _08913_ _08921_ _01794_ VDD VSS AND4_X1
X_10784_ _08920_ _01795_ VDD VSS INV_X1
X_10785_ _08909_ _08912_ _08910_ _01796_ VDD VSS AOI21_X1
X_10786_ _08921_ _01797_ VDD VSS INV_X1
X_10787_ _01795_ _01796_ _01797_ _01798_ VDD VSS OAI21_X1
X_10788_ _08917_ _01794_ _01727_ _01798_ _08918_ _01799_ VDD
+ VSS AOI221_X2
X_10789_ _01116_ _01087_ _01799_ _01800_ VDD VSS OAI21_X2
X_10790_ _01800_ _01801_ VDD VSS INV_X1
X_10791_ _01248_ _01385_ _01802_ VDD VSS XNOR2_X1
X_10792_ _01411_ _01802_ _01803_ VDD VSS NOR2_X1
X_10793_ _01463_ _01803_ _08843_ VDD VSS XNOR2_X1
X_10794_ _01443_ _01448_ _01804_ VDD VSS NAND2_X1
X_10795_ _01442_ _01804_ _01805_ VDD VSS XNOR2_X1
X_10796_ _08843_ _01805_ _01660_ _08872_ VDD VSS MUX2_X1
X_10797_ _08872_ _01806_ VDD VSS INV_X1
X_10798_ _01573_ _01572_ _01807_ VDD VSS XNOR2_X1
X_10799_ _01806_ _01807_ _01589_ _01808_ VDD VSS MUX2_X2
X_10800_ _01808_ _08893_ VDD VSS INV_X4
X_10801_ _01793_ _01801_ _08893_ _01809_ VDD VSS MUX2_X1
X_10802_ _08900_ _01810_ VDD VSS INV_X1
X_10803_ _01810_ _01602_ _01592_ _01811_ VDD VSS OAI21_X1
X_10804_ _08897_ _01811_ _08898_ _01812_ VDD VSS AOI21_X2
X_10805_ _08895_ _01812_ _01813_ VDD VSS XOR2_X2
X_10806_ _01813_ _01814_ VDD VSS INV_X1
X_10807_ _01087_ _01813_ _01815_ VDD VSS XNOR2_X1
X_10808_ _01153_ _01814_ _01792_ _01815_ _01816_ VDD VSS AOI22_X1
X_10809_ _01809_ _01816_ _01720_ _01817_ VDD VSS MUX2_X2
X_10810_ _01756_ _01777_ _01783_ _01817_ _01818_ VDD VSS NAND4_X4
X_10811_ _01818_ _01819_ VDD VSS BUF_X4
X_10812_ _08911_ _01728_ _01819_ _08928_ VDD VSS MUX2_X1
X_10813_ _08932_ _01820_ VDD VSS INV_X1
X_10814_ _08938_ _01821_ VDD VSS INV_X1
X_10815_ _08939_ _08942_ _08941_ _01822_ VDD VSS OAI21_X2
X_10816_ _01822_ _01821_ _01823_ VDD VSS NAND2_X2
X_10817_ _08936_ _01823_ _01824_ VDD VSS AND2_X4
X_10818_ _08933_ _01824_ _08935_ _01825_ VDD VSS OAI21_X4
X_10819_ _01820_ _01825_ _01826_ VDD VSS NAND2_X4
X_10820_ _08930_ _01826_ _01827_ VDD VSS XOR2_X1
X_10821_ _01779_ _01780_ _01782_ _01828_ VDD VSS OR3_X2
X_10822_ _01120_ _01791_ _01829_ VDD VSS NOR2_X1
X_10823_ _01829_ _01800_ _08893_ _01830_ VDD VSS MUX2_X1
X_10824_ _01119_ _01813_ _01831_ VDD VSS XNOR2_X1
X_10825_ _01116_ _01813_ _01791_ _01831_ _01832_ VDD VSS OAI22_X1
X_10826_ _01830_ _01832_ _01720_ _01833_ VDD VSS MUX2_X2
X_10827_ _01828_ _01833_ _01834_ VDD VSS NOR2_X4
X_10828_ _01311_ _01111_ _01835_ VDD VSS NOR2_X1
X_10829_ _01109_ _01179_ net36 _01836_ VDD VSS OAI21_X1
X_10830_ _08907_ _08904_ _08915_ _01837_ VDD VSS AND3_X1
X_10831_ _01835_ _01836_ _01794_ _01837_ _01838_ VDD VSS AND4_X1
X_10832_ _01120_ _01808_ _01839_ VDD VSS NAND2_X1
X_10833_ _01838_ _01839_ net9 _01840_ VDD VSS OAI21_X1
X_10834_ _01120_ _01813_ _01841_ VDD VSS NAND2_X1
X_10835_ _01179_ net36 _01842_ VDD VSS XNOR2_X2
X_10836_ _01150_ _01842_ _01843_ VDD VSS NAND2_X1
X_10837_ _01696_ _01841_ _01843_ _01844_ VDD VSS AOI21_X1
X_10838_ _01814_ _08893_ _01696_ _01845_ VDD VSS MUX2_X2
X_10839_ _01840_ _01844_ _01088_ _01845_ _01846_ VDD VSS AOI211_X2
X_10840_ _01756_ _01777_ _01847_ VDD VSS NAND2_X1
X_10841_ _01834_ _01846_ _01847_ _01848_ VDD VSS OAI21_X2
X_10842_ _08918_ _01789_ _01849_ VDD VSS XNOR2_X2
X_10843_ _01849_ _01850_ VDD VSS INV_X1
X_10844_ _01087_ _01849_ _01851_ VDD VSS XNOR2_X1
X_10845_ _08926_ _01852_ VDD VSS INV_X1
X_10846_ _08929_ _08930_ _01826_ _01853_ VDD VSS AOI21_X4
X_10847_ _08927_ _01854_ VDD VSS INV_X1
X_10848_ _01852_ _01853_ _01854_ _01855_ VDD VSS OAI21_X4
X_10849_ _08924_ _01855_ _01856_ VDD VSS AND2_X4
X_10850_ _08923_ _01856_ _01857_ VDD VSS NOR2_X4
X_10851_ _01116_ _01850_ _01851_ _01857_ _01858_ VDD VSS OAI22_X2
X_10852_ _01858_ _01859_ VDD VSS INV_X1
X_10853_ _01813_ _01808_ _01696_ _01860_ VDD VSS MUX2_X2
X_10854_ _01120_ _01799_ _01861_ VDD VSS XNOR2_X2
X_10855_ _01860_ _01861_ _01862_ VDD VSS XNOR2_X1
X_10856_ _01818_ _01859_ _01862_ _01863_ VDD VSS AND3_X1
X_10857_ _01120_ _01857_ _01864_ VDD VSS NOR2_X2
X_10858_ _01116_ _01857_ _01087_ _01865_ VDD VSS OAI21_X1
X_10859_ _01237_ _01297_ _08813_ VDD VSS NOR2_X2
X_10860_ _01309_ _08813_ _01866_ VDD VSS NOR2_X1
X_10861_ _01308_ _01867_ VDD VSS INV_X1
X_10862_ _08818_ _08815_ _08817_ _01868_ VDD VSS OR3_X1
X_10863_ _01867_ _01868_ _01265_ _01869_ VDD VSS AOI21_X1
X_10864_ _01866_ _01869_ _08832_ VDD VSS NOR2_X1
X_10865_ _08834_ _01324_ _01870_ VDD VSS XOR2_X1
X_10866_ _08832_ _01870_ _01368_ _08858_ VDD VSS MUX2_X1
X_10867_ _08860_ _08847_ _01447_ _01871_ VDD VSS OR3_X1
X_10868_ _01448_ _01871_ _01872_ VDD VSS AND2_X1
X_10869_ _08858_ _01872_ _01660_ _08875_ VDD VSS MUX2_X1
X_10870_ _08877_ _01571_ _01873_ VDD VSS XOR2_X1
X_10871_ _08875_ _01873_ _01589_ _08896_ VDD VSS MUX2_X1
X_10872_ _08898_ _01748_ _01874_ VDD VSS XNOR2_X1
X_10873_ _08896_ _01874_ _01720_ _08916_ VDD VSS MUX2_X2
X_10874_ _01864_ _01865_ _08916_ _01875_ VDD VSS MUX2_X1
X_10875_ _01818_ _01875_ _01845_ _01876_ VDD VSS NOR3_X4
X_10876_ _01848_ _01863_ _01876_ _01817_ _01783_ _01877_ VDD
+ VSS OAI221_X2
X_10877_ _08939_ _08942_ _08924_ _08936_ _01878_ VDD VSS AND4_X1
X_10878_ _08927_ _08930_ _08933_ _01878_ _01879_ VDD VSS NAND4_X2
X_10879_ _01756_ _01777_ _01783_ _01817_ _01880_ VDD VSS AND4_X4
X_10880_ _01710_ _01519_ _01881_ VDD VSS NAND2_X1
X_10881_ _01368_ _01881_ _01882_ VDD VSS OR2_X2
X_10882_ _01711_ _01880_ _01882_ _01883_ VDD VSS OAI21_X4
X_10883_ _01088_ _08916_ _01884_ VDD VSS XNOR2_X1
X_10884_ _01851_ _01884_ _01880_ _01885_ VDD VSS MUX2_X1
X_10885_ _01170_ _01879_ _01883_ _01885_ _01886_ VDD VSS NOR4_X4
X_10886_ _01729_ _01772_ _01887_ VDD VSS NAND2_X1
X_10887_ net10 _01761_ _01888_ VDD VSS NAND2_X1
X_10888_ _01685_ _01888_ _01889_ VDD VSS XNOR2_X2
X_10889_ _01755_ _01889_ _01696_ _01890_ VDD VSS NOR3_X2
X_10890_ _01887_ _01890_ _01891_ VDD VSS XNOR2_X1
X_10891_ _01691_ _01729_ _01892_ VDD VSS NOR2_X1
X_10892_ _01768_ _01692_ _01893_ VDD VSS AND2_X1
X_10893_ _01689_ _01774_ _01775_ _01894_ VDD VSS OAI21_X1
X_10894_ _01893_ _01691_ _01894_ _01895_ VDD VSS MUX2_X1
X_10895_ _01892_ _01895_ _01693_ _01896_ VDD VSS AOI21_X2
X_10896_ _01891_ _01896_ _01897_ VDD VSS NAND2_X1
X_10897_ _01757_ _01758_ _01689_ _01694_ _01898_ VDD VSS AOI22_X2
X_10898_ _01889_ _01898_ _01899_ VDD VSS XNOR2_X2
X_10899_ _01120_ _01799_ _01900_ VDD VSS NOR2_X1
X_10900_ _01813_ _01900_ _01901_ VDD VSS NAND2_X1
X_10901_ _01808_ _01900_ _01902_ VDD VSS NAND2_X1
X_10902_ _01901_ _01902_ _01696_ _01903_ VDD VSS MUX2_X1
X_10903_ _08893_ _01800_ _01904_ VDD VSS NAND2_X1
X_10904_ _01814_ _01800_ _01905_ VDD VSS NAND2_X1
X_10905_ _01904_ _01905_ _01720_ _01906_ VDD VSS MUX2_X1
X_10906_ _01783_ _01903_ _01906_ _01907_ VDD VSS AND3_X1
X_10907_ _01899_ _01818_ _01907_ _01908_ VDD VSS AOI21_X4
X_10908_ _01899_ _01909_ VDD VSS INV_X1
X_10909_ _01783_ _01903_ _01906_ _01910_ VDD VSS NAND3_X2
X_10910_ _01909_ _01880_ _01910_ _01911_ VDD VSS NOR3_X4
X_10911_ _01756_ _01777_ _01834_ _01912_ VDD VSS AOI21_X4
X_10912_ _01897_ _01908_ _01911_ _01912_ _01913_ VDD VSS OR4_X4
X_10913_ _01877_ _01886_ _01913_ _01914_ VDD VSS OR3_X4
Xclone33 _01914_ net33 VDD VSS BUF_X4
X_10915_ _01914_ _01916_ VDD VSS BUF_X8
X_10916_ _08928_ _01827_ net33 _08946_ VDD VSS MUX2_X1
X_10917_ _08948_ _01917_ VDD VSS BUF_X1
X_10918_ _08953_ _01918_ VDD VSS INV_X1
X_10919_ _08959_ _01919_ VDD VSS INV_X1
X_10920_ _08962_ _01920_ VDD VSS BUF_X1
X_10921_ _08960_ _01920_ _08961_ _01921_ VDD VSS OAI21_X2
X_10922_ _01921_ _01919_ _01922_ VDD VSS NAND2_X2
X_10923_ _08957_ _01922_ _01923_ VDD VSS AND2_X4
X_10924_ _08954_ _01923_ _08956_ _01924_ VDD VSS OAI21_X4
X_10925_ _01918_ _01924_ _01925_ VDD VSS NAND2_X4
X_10926_ _08951_ _01926_ VDD VSS BUF_X1
X_10927_ _08950_ _01926_ _01925_ _01927_ VDD VSS AOI21_X4
X_10928_ _01917_ _01927_ _01928_ VDD VSS XNOR2_X1
X_10929_ _01203_ _01929_ VDD VSS BUF_X4
X_10930_ _08818_ _01519_ _01309_ _01930_ VDD VSS AND3_X2
X_10931_ _01930_ _01867_ _01179_ _01931_ VDD VSS AOI21_X2
X_10932_ _08740_ _01309_ _01929_ _01932_ VDD VSS AOI21_X1
X_10933_ _01929_ _01931_ _01932_ _08818_ _08835_ VDD VSS OAI22_X2
X_10934_ _08837_ _01933_ VDD VSS INV_X1
X_10935_ _01933_ _01382_ _01934_ VDD VSS XNOR2_X1
X_10936_ _08835_ _01934_ _01368_ _08846_ VDD VSS MUX2_X1
X_10937_ _08848_ _01446_ _01935_ VDD VSS XOR2_X1
X_10938_ _08846_ _01935_ _01660_ _08878_ VDD VSS MUX2_X1
X_10939_ _08880_ _08862_ _01569_ _01936_ VDD VSS OR3_X1
X_10940_ _01570_ _01936_ _01937_ VDD VSS AND2_X1
X_10941_ _08878_ _01937_ _01589_ _08899_ VDD VSS MUX2_X1
X_10942_ _08885_ _01600_ _08886_ _01938_ VDD VSS AOI21_X1
X_10943_ _01742_ _01938_ _01746_ _01939_ VDD VSS OAI21_X1
X_10944_ _08901_ _01939_ _01940_ VDD VSS XOR2_X1
X_10945_ _08899_ _01940_ _01721_ _08919_ VDD VSS MUX2_X1
X_10946_ _08912_ _01727_ _08913_ _01941_ VDD VSS AOI21_X1
X_10947_ _01784_ _01941_ _01787_ _01942_ VDD VSS OAI21_X1
X_10948_ _01797_ _01942_ _01943_ VDD VSS XNOR2_X1
X_10949_ _08919_ _01943_ _01819_ _01944_ VDD VSS MUX2_X1
X_10950_ _01944_ _08922_ VDD VSS BUF_X2
X_10951_ _01121_ _08922_ _01945_ VDD VSS XNOR2_X1
X_10952_ _08945_ _01946_ VDD VSS BUF_X2
X_10953_ _08947_ _01947_ VDD VSS INV_X1
X_10954_ _01917_ _01948_ VDD VSS INV_X1
X_10955_ _01947_ _01927_ _01948_ _01949_ VDD VSS OAI21_X4
X_10956_ _01949_ _01946_ _01950_ VDD VSS AND2_X4
X_10957_ _01950_ _08944_ _01951_ VDD VSS OR2_X2
X_10958_ _01153_ _08922_ _01951_ _01945_ _01952_ VDD VSS AOI22_X2
X_10959_ _01950_ _08944_ _01953_ VDD VSS NOR2_X4
X_10960_ _08924_ _01855_ _01954_ VDD VSS XOR2_X2
X_10961_ _01121_ _01954_ _01955_ VDD VSS NOR2_X1
X_10962_ _01954_ _01956_ VDD VSS INV_X1
X_10963_ _01088_ _01956_ _01957_ VDD VSS NOR2_X1
X_10964_ _01955_ _01957_ _01958_ VDD VSS NOR2_X1
X_10965_ _01953_ _01958_ _01959_ VDD VSS NOR2_X1
X_10966_ _01153_ _01960_ VDD VSS BUF_X4
X_10967_ _01959_ _01954_ _01960_ _01961_ VDD VSS AOI21_X1
X_10968_ _01952_ _01961_ _01914_ _01962_ VDD VSS MUX2_X2
X_10969_ _08923_ _01120_ _01856_ _01963_ VDD VSS NOR3_X1
X_10970_ _01153_ _01845_ _01964_ VDD VSS XNOR2_X1
X_10971_ _01880_ _01965_ VDD VSS BUF_X4
X_10972_ _01964_ _01861_ _01965_ _01966_ VDD VSS OAI21_X1
X_10973_ _01965_ _01861_ _01964_ _01967_ VDD VSS OR3_X1
X_10974_ _01849_ _08916_ _01965_ _01968_ VDD VSS MUX2_X2
X_10975_ _01963_ _01966_ _01967_ _01968_ _01969_ VDD VSS NAND4_X2
X_10976_ _01845_ _01965_ _01861_ _01970_ VDD VSS OAI21_X2
X_10977_ _01088_ _01799_ _01971_ VDD VSS XNOR2_X2
X_10978_ _01860_ _01819_ _01971_ _01972_ VDD VSS NAND3_X2
X_10979_ _08916_ _01973_ VDD VSS INV_X1
X_10980_ _01850_ _01973_ _01965_ _01974_ VDD VSS MUX2_X2
X_10981_ _01864_ _01970_ _01972_ _01974_ _01975_ VDD VSS NAND4_X2
X_10982_ _01845_ _01819_ _01971_ _01976_ VDD VSS AOI21_X1
X_10983_ _01860_ _01965_ _01861_ _01977_ VDD VSS NOR3_X1
X_10984_ _01120_ _01857_ _01978_ VDD VSS NAND2_X1
X_10985_ _01976_ _01977_ _01968_ _01978_ _01979_ VDD VSS OR4_X1
X_10986_ _01088_ _01857_ _01980_ VDD VSS NOR2_X1
X_10987_ _01980_ _01970_ _01972_ _01968_ _01981_ VDD VSS NAND4_X2
X_10988_ _01969_ _01975_ _01979_ _01981_ _01982_ VDD VSS NAND4_X4
X_10989_ _01864_ _01968_ _01983_ VDD VSS OR2_X1
X_10990_ _01877_ _01886_ _01913_ _01983_ _01984_ VDD VSS NOR4_X4
X_10991_ _01982_ _01984_ _01985_ VDD VSS OR2_X4
X_10992_ _01863_ _01876_ _01986_ VDD VSS NOR2_X2
X_10993_ _01818_ _01875_ _01987_ VDD VSS NOR2_X1
X_10994_ _01828_ _01833_ _01988_ VDD VSS NAND2_X2
X_10995_ _01863_ _01987_ _01860_ _01848_ _01988_ _01989_ VDD
+ VSS AOI221_X2
X_10996_ _01908_ _01911_ _01990_ VDD VSS OR2_X2
X_10997_ _01988_ _01991_ VDD VSS INV_X1
X_10998_ _01818_ _01859_ _01862_ _01992_ VDD VSS NAND3_X1
X_10999_ _01845_ _01818_ _01875_ _01993_ VDD VSS OR3_X1
X_11000_ _01756_ _01777_ _01994_ VDD VSS AND2_X1
X_11001_ _01835_ _01836_ _01794_ _01837_ _01995_ VDD VSS NAND4_X1
X_11002_ _01088_ _08893_ _01996_ VDD VSS NOR2_X1
X_11003_ _01995_ _01996_ _01696_ _01997_ VDD VSS AOI21_X1
X_11004_ _01088_ _01814_ _01998_ VDD VSS NOR2_X1
X_11005_ _01150_ _01842_ _01999_ VDD VSS AND2_X1
X_11006_ net9 _01998_ _01999_ _02000_ VDD VSS OAI21_X1
X_11007_ _01997_ _02000_ _01120_ _01860_ _02001_ VDD VSS OAI211_X2
X_11008_ _01994_ _02001_ _02002_ VDD VSS NAND2_X1
X_11009_ _01991_ _01992_ _01993_ _01834_ _02002_ _02003_ VDD
+ VSS AOI221_X2
X_11010_ _01986_ _01886_ _01913_ _01989_ _01990_ _02003_ _02004_
+ VDD VSS OAI33_X1
X_11011_ _01887_ _01909_ _01965_ _01910_ _02005_ VDD VSS NOR4_X2
X_11012_ _01896_ _02005_ _02006_ VDD VSS XNOR2_X2
X_11013_ _01773_ _01890_ _02007_ VDD VSS XNOR2_X2
X_11014_ _02007_ _01908_ _01911_ _02008_ VDD VSS OR3_X2
X_11015_ _02006_ _02008_ _01877_ _02009_ VDD VSS OAI21_X4
X_11016_ _01912_ _02010_ VDD VSS INV_X1
X_11017_ _01899_ _01783_ _01817_ _02011_ VDD VSS NAND3_X1
X_11018_ _02011_ _02001_ _01994_ _02012_ VDD VSS AOI21_X2
X_11019_ _02007_ _02012_ _02013_ VDD VSS XNOR2_X2
X_11020_ _02010_ _02013_ _02014_ VDD VSS AND2_X2
X_11021_ net381 _02009_ _02014_ _02015_ VDD VSS AND3_X2
X_11022_ _02015_ _01962_ _01985_ _02016_ VDD VSS NAND3_X4
X_11023_ _02016_ _02017_ VDD VSS BUF_X8
X_11024_ _08946_ _01928_ _02017_ _08963_ VDD VSS MUX2_X2
X_11025_ _01137_ _08963_ _02018_ VDD VSS NAND2_X1
X_11026_ _01886_ _01913_ _02019_ VDD VSS OR2_X2
X_11027_ _01986_ _02019_ _02020_ VDD VSS NOR2_X2
X_11028_ _02003_ _01990_ _01989_ _02021_ VDD VSS NOR3_X2
X_11029_ _02020_ _02021_ _02022_ VDD VSS NOR2_X4
X_11030_ net381 _02009_ _02014_ _02023_ VDD VSS NAND3_X4
X_11031_ _08922_ _02024_ VDD VSS INV_X1
X_11032_ _01088_ _02024_ _02025_ VDD VSS NOR2_X1
X_11033_ _02025_ _01957_ _01914_ _02026_ VDD VSS MUX2_X2
X_11034_ _01121_ _08922_ _02027_ VDD VSS NOR2_X1
X_11035_ _02027_ _01955_ _01914_ _02028_ VDD VSS MUX2_X2
X_11036_ _02023_ _02026_ _02028_ _02029_ VDD VSS NOR3_X4
X_11037_ _01170_ _01883_ _02030_ VDD VSS NOR2_X1
X_11038_ _08960_ _01920_ _01946_ _08957_ _02031_ VDD VSS NAND4_X1
X_11039_ _01917_ _01926_ _08954_ _02032_ VDD VSS NAND3_X1
X_11040_ _02031_ _02032_ _02033_ VDD VSS NOR2_X1
X_11041_ _02030_ _02004_ _02033_ _02034_ VDD VSS AND3_X1
X_11042_ _01962_ _01982_ _01984_ _02023_ _02034_ _02035_ VDD
+ VSS OAI221_X2
X_11043_ _02029_ _02035_ _02036_ VDD VSS NOR2_X4
X_11044_ _01088_ _08922_ _02037_ VDD VSS XNOR2_X1
X_11045_ _01116_ _02024_ _02037_ _01953_ _02038_ VDD VSS OAI22_X1
X_11046_ _01116_ _01956_ _01958_ _01953_ _02039_ VDD VSS OAI22_X1
X_11047_ _02038_ _02039_ _01914_ _02040_ VDD VSS MUX2_X2
X_11048_ _01980_ _01963_ _02041_ VDD VSS OR2_X1
X_11049_ _02041_ _02042_ VDD VSS INV_X1
X_11050_ _01877_ _01886_ _01913_ _02043_ VDD VSS NOR3_X2
X_11051_ _01974_ _02042_ _02043_ _02044_ VDD VSS OAI21_X2
X_11052_ net33 _01968_ _02041_ _02045_ VDD VSS NAND3_X2
X_11053_ _02040_ _02044_ _02045_ _02046_ VDD VSS AOI21_X4
X_11054_ _01986_ _02047_ VDD VSS INV_X1
X_11055_ _01848_ _01988_ _02048_ VDD VSS NAND2_X2
X_11056_ _02047_ _02019_ _02048_ _02049_ VDD VSS OAI21_X1
X_11057_ _01965_ _01858_ _02050_ VDD VSS NOR2_X1
X_11058_ _01987_ _01976_ _01977_ _02050_ _02051_ VDD VSS OR4_X1
X_11059_ _02049_ _02051_ _02052_ VDD VSS AND2_X1
X_11060_ _02046_ _02052_ _02053_ VDD VSS NOR2_X4
X_11061_ _02022_ _02036_ _02053_ _02054_ VDD VSS OR3_X4
X_11062_ _02024_ _01956_ net33 _02055_ VDD VSS MUX2_X2
X_11063_ _01121_ _01953_ _02056_ VDD VSS XNOR2_X2
X_11064_ _02055_ _02056_ _02057_ VDD VSS NAND2_X1
X_11065_ _01985_ _02055_ _02058_ VDD VSS NAND2_X1
X_11066_ _01962_ _02015_ _02059_ VDD VSS NAND2_X1
X_11067_ _08922_ _01954_ net33 _02060_ VDD VSS MUX2_X1
X_11068_ _01089_ _01953_ _02061_ VDD VSS XNOR2_X1
X_11069_ _02060_ _02061_ _02062_ VDD VSS NAND2_X1
X_11070_ _01982_ _01984_ _02063_ VDD VSS NOR2_X4
X_11071_ _02040_ _02063_ _02023_ _02064_ VDD VSS NOR3_X4
X_11072_ _02057_ _02058_ _02059_ _02062_ _02064_ _02065_ VDD
+ VSS OAI221_X2
X_11073_ _01968_ _02041_ net33 _02066_ VDD VSS AOI21_X2
X_11074_ _02043_ _01974_ _02042_ _02067_ VDD VSS NOR3_X2
X_11075_ _01962_ _02066_ _02067_ _02068_ VDD VSS NOR3_X2
X_11076_ net28 _02068_ _02046_ _02069_ VDD VSS OAI21_X4
X_11077_ _08839_ _01411_ _08852_ VDD VSS NOR2_X1
X_11078_ _08854_ _08857_ _08856_ _02070_ VDD VSS OR3_X1
X_11079_ _01445_ _02070_ _02071_ VDD VSS AND2_X1
X_11080_ _08852_ _02071_ _01660_ _08861_ VDD VSS MUX2_X1
X_11081_ _08863_ _01568_ _02072_ VDD VSS XOR2_X1
X_11082_ _08861_ _02072_ _01589_ _08881_ VDD VSS MUX2_X1
X_11083_ _08883_ _01745_ _02073_ VDD VSS XNOR2_X1
X_11084_ _08881_ _02073_ _01721_ _08908_ VDD VSS MUX2_X1
X_11085_ _08910_ _01786_ _02074_ VDD VSS XNOR2_X1
X_11086_ _08908_ _02074_ _01819_ _08925_ VDD VSS MUX2_X1
X_11087_ _08925_ _02075_ VDD VSS INV_X1
X_11088_ _01854_ _01853_ _02076_ VDD VSS XNOR2_X1
X_11089_ _02075_ _02076_ _01914_ _02077_ VDD VSS MUX2_X2
X_11090_ _01962_ _01985_ _02015_ _02077_ _02078_ VDD VSS NAND4_X2
X_11091_ _01946_ _01949_ _02079_ VDD VSS XOR2_X2
X_11092_ _08964_ _02080_ VDD VSS BUF_X2
X_11093_ _08965_ _01705_ _08967_ _02081_ VDD VSS OAI21_X1
X_11094_ _08967_ _08970_ _02082_ VDD VSS NOR2_X1
X_11095_ _08971_ _01700_ _01702_ _02083_ VDD VSS OAI21_X1
X_11096_ _02081_ _02082_ _02083_ _02084_ VDD VSS AOI21_X2
X_11097_ _02080_ _02084_ _02085_ VDD VSS NOR2_X1
X_11098_ _01089_ _02085_ _02086_ VDD VSS NOR2_X1
X_11099_ _02078_ _02079_ _02064_ _02086_ _01960_ _02087_ VDD
+ VSS OAI221_X2
X_11100_ _02077_ _08943_ VDD VSS INV_X2
X_11101_ _01962_ _01985_ _02015_ _08943_ _02088_ VDD VSS NAND4_X2
X_11102_ _01121_ _02085_ _02089_ VDD VSS NOR2_X1
X_11103_ _01946_ _01949_ _02090_ VDD VSS XNOR2_X2
X_11104_ _02088_ _02089_ _02064_ _02090_ _02091_ VDD VSS OAI211_X4
X_11105_ _02065_ _02069_ _02087_ _02091_ _02092_ VDD VSS NAND4_X4
X_11106_ _01877_ _02008_ _02093_ VDD VSS OR2_X1
X_11107_ _01912_ _02006_ _02093_ _02094_ VDD VSS OAI21_X1
X_11108_ net381 _02013_ _02094_ _02095_ VDD VSS AND3_X1
X_11109_ _02040_ _02063_ _02096_ VDD VSS NOR2_X2
X_11110_ _02009_ _02014_ _02095_ _02096_ _02097_ VDD VSS AOI22_X4
X_11111_ net9 net36 _01519_ _02098_ VDD VSS OAI21_X1
X_11112_ _02098_ _02099_ VDD VSS INV_X1
X_11113_ _02099_ net36 _01519_ _02100_ VDD VSS AOI21_X2
X_11114_ _01179_ _01368_ _01819_ _02101_ VDD VSS OAI21_X1
X_11115_ _02101_ _01819_ _01620_ _02102_ VDD VSS OAI21_X2
X_11116_ _01110_ _02103_ VDD VSS BUF_X4
X_11117_ _01929_ _02100_ _02102_ _02103_ _02104_ VDD VSS OAI22_X4
X_11118_ _08971_ _02105_ VDD VSS INV_X1
X_11119_ _08980_ _01142_ _08965_ _01705_ _02106_ VDD VSS NAND4_X1
X_11120_ _02106_ _01170_ _01141_ _02105_ _02107_ VDD VSS OR4_X4
X_11121_ _01696_ _01842_ _02108_ VDD VSS XNOR2_X1
X_11122_ _02103_ net11 _02108_ _01929_ _02109_ VDD VSS OAI22_X2
X_11123_ _01710_ _01819_ _02110_ VDD VSS NAND2_X1
X_11124_ net11 _02109_ _02110_ _02111_ VDD VSS MUX2_X1
X_11125_ _02111_ _02112_ VDD VSS BUF_X4
X_11126_ _02107_ _02104_ _02112_ _02113_ VDD VSS OR3_X4
X_11127_ _01121_ _02079_ _02114_ VDD VSS NAND2_X1
X_11128_ _01089_ _02090_ _02115_ VDD VSS NAND2_X1
X_11129_ _02113_ _02114_ _02115_ _02096_ _02015_ _02116_ VDD
+ VSS AOI221_X2
X_11130_ _02104_ _02107_ _02112_ _02117_ VDD VSS NOR3_X2
X_11131_ _01121_ _08943_ _02117_ _02118_ VDD VSS NAND3_X2
X_11132_ _01089_ _02077_ _02117_ _02119_ VDD VSS NAND3_X2
X_11133_ _02016_ _02118_ _02119_ _02120_ VDD VSS AOI21_X4
X_11134_ _02097_ _02116_ _02120_ _02121_ VDD VSS OR3_X4
X_11135_ _02054_ _02092_ _02121_ _02122_ VDD VSS NOR3_X4
X_11136_ _01709_ _02018_ _02122_ _02123_ VDD VSS MUX2_X2
X_11137_ _02022_ _02036_ _02053_ _02124_ VDD VSS NOR3_X4
X_11138_ _02065_ _02069_ _02087_ _02091_ _02125_ VDD VSS AND4_X2
X_11139_ _02125_ _02126_ VDD VSS BUF_X4
X_11140_ _02097_ _02116_ _02120_ _02127_ VDD VSS NOR3_X4
X_11141_ _01089_ _01135_ _02128_ VDD VSS NAND2_X4
X_11142_ _08963_ _02128_ _02129_ VDD VSS NOR2_X1
X_11143_ _02124_ _02126_ _02127_ _02129_ _02130_ VDD VSS AND4_X1
X_11144_ _01708_ _02128_ _02131_ VDD VSS NOR2_X4
X_11145_ _02124_ _02125_ _02127_ _02132_ VDD VSS NAND3_X4
X_11146_ _02130_ _02131_ net7 _02133_ VDD VSS AOI21_X4
X_11147_ _02060_ _02061_ _02134_ VDD VSS NOR2_X1
X_11148_ _02063_ _02060_ _02135_ VDD VSS NOR2_X1
X_11149_ _02040_ _02023_ _02136_ VDD VSS NOR2_X1
X_11150_ _02055_ _02056_ _02137_ VDD VSS NOR2_X1
X_11151_ _02134_ _02135_ _02136_ _02137_ net28 _02138_ VDD
+ VSS AOI221_X2
X_11152_ _02040_ _02063_ _02023_ _02077_ _02139_ VDD VSS NOR4_X2
X_11153_ _08973_ _02140_ VDD VSS INV_X1
X_11154_ _08980_ _01142_ _08982_ _02141_ VDD VSS OAI21_X1
X_11155_ _01699_ _02141_ _02142_ VDD VSS NAND2_X1
X_11156_ _08976_ _02142_ _08977_ _02143_ VDD VSS AOI21_X1
X_11157_ _01140_ _02144_ VDD VSS INV_X1
X_11158_ _02140_ _02143_ _02144_ _02145_ VDD VSS OAI21_X1
X_11159_ _08970_ _02145_ _08971_ _02146_ VDD VSS AOI21_X2
X_11160_ _01139_ _02146_ _01706_ _02147_ VDD VSS OAI21_X1
X_11161_ _02080_ _02147_ _08965_ _02148_ VDD VSS AOI21_X2
X_11162_ _01121_ _02148_ _02149_ VDD VSS OR2_X1
X_11163_ _02139_ _02149_ net28 _02079_ _02150_ VDD VSS AOI211_X2
X_11164_ _02040_ _02063_ _02023_ _08943_ _02151_ VDD VSS NOR4_X4
X_11165_ _01089_ _02148_ _02152_ VDD VSS OR2_X1
X_11166_ _02151_ _02090_ _02016_ _02152_ _01116_ _02153_ VDD
+ VSS AOI221_X2
X_11167_ _02138_ _02150_ _02153_ _02154_ VDD VSS NOR3_X2
X_11168_ _02069_ _02154_ _02155_ VDD VSS XNOR2_X1
X_11169_ _02087_ _02091_ _02156_ VDD VSS AND2_X2
X_11170_ _02065_ _02156_ _02157_ VDD VSS XNOR2_X1
X_11171_ _02132_ _02155_ _02157_ _02158_ VDD VSS OAI21_X2
X_11172_ _02151_ _02090_ net28 _02159_ VDD VSS AOI21_X4
X_11173_ _01121_ _02148_ _02160_ VDD VSS XNOR2_X2
X_11174_ _02159_ _02160_ _02161_ VDD VSS AND2_X1
X_11175_ _02040_ _02044_ _02045_ _02162_ VDD VSS NAND3_X2
X_11176_ _01962_ _02066_ _02067_ _02163_ VDD VSS OAI21_X2
X_11177_ _02064_ _02162_ _02163_ _02164_ VDD VSS AOI21_X4
X_11178_ net28 _02137_ _02165_ VDD VSS NAND2_X1
X_11179_ _02055_ _02064_ _02056_ _02166_ VDD VSS OAI21_X2
X_11180_ _02164_ _02165_ _02166_ _01960_ _02159_ _02167_ VDD
+ VSS AOI221_X2
X_11181_ _02078_ _02079_ _02064_ _02168_ VDD VSS OAI21_X1
X_11182_ _02080_ _02084_ _02169_ VDD VSS OR2_X1
X_11183_ _02168_ _02169_ _01122_ _02170_ VDD VSS AOI21_X1
X_11184_ _02124_ _02167_ _02127_ _02170_ _02171_ VDD VSS AND4_X1
X_11185_ _02159_ _02160_ _02172_ VDD VSS NOR2_X1
X_11186_ _02161_ _02171_ _02132_ _02172_ _02173_ VDD VSS AOI211_X2
X_11187_ _02123_ _02133_ _02158_ _02173_ _02174_ VDD VSS NAND4_X4
X_11188_ net382 _02036_ _02175_ VDD VSS NAND2_X2
X_11189_ _02013_ _02176_ VDD VSS INV_X1
X_11190_ _01908_ _01911_ _02177_ VDD VSS NOR2_X2
X_11191_ _02003_ _02177_ _02019_ _02178_ VDD VSS NAND3_X1
X_11192_ _02176_ _02178_ _02179_ VDD VSS XNOR2_X2
X_11193_ _02175_ _02179_ _02180_ VDD VSS XNOR2_X2
X_11194_ _02138_ _02164_ _02150_ _02153_ _02181_ VDD VSS NOR4_X2
X_11195_ _02124_ _02181_ _02182_ VDD VSS NAND2_X1
X_11196_ _01962_ _01985_ net382 _02013_ _02183_ VDD VSS NAND4_X2
X_11197_ _08960_ _01926_ _08954_ _08957_ _02184_ VDD VSS NAND4_X1
X_11198_ _01920_ _01946_ _01917_ _02185_ VDD VSS NAND3_X1
X_11199_ _01170_ _01883_ _02184_ _02185_ _02186_ VDD VSS NOR4_X2
X_11200_ _02186_ _02028_ _02026_ _02020_ _02021_ _02187_ VDD
+ VSS OAI221_X1
X_11201_ _02183_ _02094_ _02187_ _02188_ VDD VSS AOI21_X1
X_11202_ _01886_ _01912_ _02189_ VDD VSS NOR2_X1
X_11203_ _02093_ _02189_ _02190_ VDD VSS NOR2_X1
X_11204_ _02190_ _02093_ _02006_ _02191_ VDD VSS MUX2_X1
X_11205_ _02188_ _02183_ _02191_ _02192_ VDD VSS MUX2_X2
X_11206_ _02180_ _02122_ _02182_ _02192_ _02193_ VDD VSS NOR4_X4
X_11207_ _01912_ _02006_ _02093_ _02183_ _02191_ _02194_ VDD
+ VSS OAI221_X2
X_11208_ _02193_ _02194_ _02195_ VDD VSS OR2_X1
X_11209_ _02195_ _02196_ VDD VSS BUF_X4
X_11210_ _02175_ _02179_ _02197_ VDD VSS XOR2_X2
X_11211_ _02047_ _02019_ _02198_ VDD VSS NAND2_X2
X_11212_ _02048_ _02198_ _02199_ VDD VSS NOR2_X1
X_11213_ _01989_ _02036_ _02053_ _02199_ _02200_ VDD VSS NOR4_X4
X_11214_ _01990_ _02019_ _02047_ _02201_ VDD VSS AOI21_X1
X_11215_ _02201_ _02035_ _02029_ _02202_ VDD VSS OAI21_X2
X_11216_ _02048_ _02203_ VDD VSS INV_X2
X_11217_ _02203_ _01990_ _02204_ VDD VSS NAND2_X1
X_11218_ _02198_ _02204_ _02205_ VDD VSS NOR2_X1
X_11219_ _02205_ _02177_ _02048_ _02206_ VDD VSS AOI21_X2
X_11220_ _02029_ _02035_ _02207_ VDD VSS OR2_X4
X_11221_ _02202_ _02206_ _02204_ _02207_ _02208_ VDD VSS OAI211_X4
X_11222_ _02200_ _02208_ _02126_ _02121_ _02209_ VDD VSS AND4_X2
X_11223_ _02054_ _02126_ _02121_ _02210_ VDD VSS AOI21_X4
X_11224_ _02198_ _02035_ _02029_ _02211_ VDD VSS OAI21_X4
X_11225_ _01989_ _02046_ _02052_ _02212_ VDD VSS OR3_X1
X_11226_ _02203_ _02211_ _02212_ _02207_ _02213_ VDD VSS AOI22_X4
X_11227_ _02177_ _02126_ _02213_ _02214_ VDD VSS AND3_X1
X_11228_ _02197_ _02209_ _02210_ _02214_ _02215_ VDD VSS OAI22_X4
X_11229_ _02208_ _02156_ net15 _02216_ VDD VSS AND3_X1
X_11230_ _02176_ _02166_ _02165_ _02159_ _01960_ _02217_ VDD
+ VSS AOI221_X2
X_11231_ _02022_ _02036_ _02053_ _02164_ _02218_ VDD VSS NOR4_X2
X_11232_ _02192_ _02217_ _02218_ _02219_ VDD VSS AOI21_X2
X_11233_ _02084_ _02065_ _02069_ _02220_ VDD VSS NAND3_X1
X_11234_ _02080_ _02221_ VDD VSS INV_X1
X_11235_ _01122_ _02159_ _02222_ VDD VSS NAND2_X1
X_11236_ _01089_ _02168_ _02223_ VDD VSS NAND2_X1
X_11237_ _02192_ _02220_ _02221_ _02222_ _02223_ _02224_ VDD
+ VSS AOI221_X2
X_11238_ _02216_ _02219_ _02224_ _02225_ VDD VSS NOR3_X4
X_11239_ _02208_ _02156_ _02127_ _02226_ VDD VSS NAND3_X2
X_11240_ _02218_ _02217_ _02227_ VDD VSS AND2_X1
X_11241_ _01122_ _02159_ _02228_ VDD VSS XNOR2_X1
X_11242_ _02084_ _02065_ _02069_ _02229_ VDD VSS AND3_X1
X_11243_ _02228_ _02229_ _02080_ _02230_ VDD VSS OAI21_X2
X_11244_ _02192_ _02226_ _02227_ _02230_ _02231_ VDD VSS NAND4_X4
X_11245_ _02215_ _02225_ _02231_ _02232_ VDD VSS AOI21_X4
X_11246_ _02174_ _02196_ _02232_ _02233_ VDD VSS AOI21_X4
X_11247_ _02164_ _02154_ _02234_ VDD VSS XNOR2_X2
X_11248_ _02054_ _02092_ _02121_ _08963_ _02235_ VDD VSS NOR4_X4
X_11249_ _01708_ _02236_ VDD VSS INV_X2
X_11250_ _02235_ _02236_ _02132_ _01136_ _01116_ _02237_ VDD
+ VSS AOI221_X2
X_11251_ _02131_ _02129_ _02122_ _02238_ VDD VSS MUX2_X2
X_11252_ _02159_ _02160_ _02239_ VDD VSS NAND2_X1
X_11253_ _02167_ _02170_ _02240_ VDD VSS NAND2_X1
X_11254_ _02124_ _02127_ _02241_ VDD VSS NAND2_X1
X_11255_ _02159_ _02160_ _02242_ VDD VSS OR2_X1
X_11256_ _02239_ _02240_ _02241_ _02122_ _02242_ _02243_ VDD
+ VSS OAI221_X2
X_11257_ _02243_ _02244_ VDD VSS BUF_X4
X_11258_ _02065_ _02156_ _02245_ VDD VSS OR2_X1
X_11259_ _02200_ _02208_ _02069_ net15 _02246_ VDD VSS AND4_X1
X_11260_ _02065_ _02156_ _02247_ VDD VSS NAND2_X1
X_11261_ _02245_ _02246_ _02247_ _02248_ VDD VSS OAI21_X2
X_11262_ _02237_ _02238_ _02244_ _02248_ _02249_ VDD VSS NOR4_X4
X_11263_ _02122_ _02234_ _02249_ _02250_ VDD VSS NOR3_X2
X_11264_ _02123_ _02133_ _02173_ _02251_ VDD VSS NAND3_X1
X_11265_ _02251_ _02248_ _02252_ VDD VSS AND2_X1
X_11266_ _02138_ _02156_ _02253_ VDD VSS XNOR2_X2
X_11267_ _02122_ _02234_ _02253_ _02254_ VDD VSS AOI21_X4
X_11268_ _02254_ _02249_ _02255_ VDD VSS AND2_X1
X_11269_ _02233_ _02250_ _02252_ _02255_ _02256_ VDD VSS NOR4_X4
X_11270_ _02126_ _02241_ _02257_ VDD VSS NAND2_X2
X_11271_ _02200_ _02126_ _02213_ _02257_ _02258_ VDD VSS OAI22_X4
X_11272_ _02237_ _02238_ _02254_ _02244_ _02259_ VDD VSS NOR4_X4
X_11273_ _02200_ _02126_ _02260_ VDD VSS AND2_X1
X_11274_ _02208_ _02260_ _02261_ VDD VSS NOR2_X1
X_11275_ _02209_ _02261_ _02262_ VDD VSS NOR2_X1
X_11276_ _02259_ _02262_ _02263_ VDD VSS NOR2_X1
X_11277_ _02258_ _02263_ _02264_ VDD VSS NOR2_X4
X_11278_ _02256_ _02264_ _02265_ VDD VSS AND2_X2
X_11279_ _02193_ _02194_ _02266_ VDD VSS NOR2_X4
X_11280_ _02216_ _02219_ _02224_ _02267_ VDD VSS OR3_X2
X_11281_ _02192_ _02226_ _02227_ _02230_ _02268_ VDD VSS AND4_X2
X_11282_ _02267_ _02268_ _02269_ VDD VSS NOR2_X4
X_11283_ _02200_ _02208_ _02126_ _02121_ _02270_ VDD VSS NAND4_X2
X_11284_ _02124_ _02092_ net15 _02271_ VDD VSS OAI21_X2
X_11285_ _02177_ _02126_ _02213_ _02272_ VDD VSS NAND3_X2
X_11286_ _02180_ _02270_ _02271_ _02272_ _02273_ VDD VSS AOI22_X4
X_11287_ _02259_ _02273_ _02274_ VDD VSS NAND2_X2
X_11288_ _02266_ _02269_ _02274_ _02275_ VDD VSS AOI21_X4
X_11289_ _02180_ _02209_ _02276_ VDD VSS XNOR2_X2
X_11290_ _02276_ _02277_ VDD VSS INV_X1
X_11291_ _02259_ _02196_ _02232_ _02278_ VDD VSS NAND3_X4
X_11292_ _02235_ _02236_ net7 _02279_ VDD VSS AOI21_X4
X_11293_ _08999_ _01134_ _02280_ VDD VSS NOR2_X1
X_11294_ _01122_ _02280_ _02281_ VDD VSS NAND2_X1
X_11295_ _02128_ _02173_ _02281_ _02282_ VDD VSS OAI21_X1
X_11296_ _02279_ _02282_ _02283_ VDD VSS NOR2_X1
X_11297_ _02279_ _02244_ _01090_ _02284_ VDD VSS AOI21_X1
X_11298_ _01135_ _02279_ _02244_ _01136_ _02285_ VDD VSS OAI22_X1
X_11299_ _02284_ _02285_ _02286_ VDD VSS NOR2_X1
X_11300_ _01960_ _02244_ _02287_ VDD VSS XNOR2_X1
X_11301_ _01122_ _01135_ _02287_ _02288_ VDD VSS OR3_X1
X_11302_ _02277_ _02278_ _02283_ _02286_ _02288_ _02289_ VDD
+ VSS AOI221_X2
X_11303_ _02289_ _02290_ VDD VSS BUF_X4
X_11304_ _08868_ _01649_ _08887_ VDD VSS NOR2_X1
X_11305_ _01716_ _01599_ _01715_ _02291_ VDD VSS NAND3_X1
X_11306_ _01743_ _02291_ _02292_ VDD VSS AND2_X1
X_11307_ _08887_ _02292_ _01721_ _08902_ VDD VSS MUX2_X1
X_11308_ _08906_ _01723_ _08907_ _02293_ VDD VSS AOI21_X1
X_11309_ _08904_ _02293_ _02294_ VDD VSS XNOR2_X1
X_11310_ _08902_ _02294_ _01819_ _08931_ VDD VSS MUX2_X1
X_11311_ _08933_ _08935_ _01824_ _02295_ VDD VSS OR3_X1
X_11312_ _01825_ _02295_ _02296_ VDD VSS AND2_X1
X_11313_ _08931_ _02296_ _01916_ _08949_ VDD VSS MUX2_X1
X_11314_ _01926_ _01925_ _02297_ VDD VSS XOR2_X1
X_11315_ _08949_ _02297_ _02017_ _08966_ VDD VSS MUX2_X1
X_11316_ _01705_ _02146_ _02298_ VDD VSS XNOR2_X1
X_11317_ _08966_ _02298_ _02132_ _02299_ VDD VSS MUX2_X1
X_11318_ _02299_ _08998_ VDD VSS CLKBUF_X3
X_11319_ _01960_ _08998_ _02300_ VDD VSS AND2_X1
X_11320_ _09011_ _02301_ VDD VSS INV_X2
X_11321_ _09012_ _02302_ VDD VSS INV_X1
X_11322_ _09017_ _02303_ VDD VSS INV_X1
X_11323_ _09023_ _02304_ VDD VSS INV_X1
X_11324_ _09008_ _02305_ VDD VSS INV_X1
X_11325_ _01883_ net9 _01310_ _02306_ VDD VSS AOI21_X4
X_11326_ _02306_ _08940_ VDD VSS INV_X4
X_11327_ _01696_ _01843_ _02307_ VDD VSS NOR2_X1
X_11328_ _01523_ _01881_ net11 _08890_ VDD VSS OAI21_X2
X_11329_ _02307_ _08890_ _02308_ VDD VSS OR2_X1
X_11330_ _02103_ _08940_ _02308_ _02309_ VDD VSS NOR3_X2
X_11331_ _09009_ _02310_ VDD VSS BUF_X1
X_11332_ _02310_ _02311_ VDD VSS INV_X1
X_11333_ _02305_ _02309_ _02311_ _02312_ VDD VSS OAI21_X1
X_11334_ _09005_ _02312_ _09006_ _02313_ VDD VSS AOI21_X1
X_11335_ _09024_ _02314_ VDD VSS INV_X2
X_11336_ _02304_ _02314_ _02313_ _02315_ VDD VSS OAI21_X4
X_11337_ _09021_ _02316_ VDD VSS BUF_X1
X_11338_ _09020_ _02315_ _02316_ _02317_ VDD VSS AOI21_X4
X_11339_ _09018_ _02318_ VDD VSS BUF_X1
X_11340_ _02318_ _02319_ VDD VSS INV_X1
X_11341_ _02303_ _02319_ _02317_ _02320_ VDD VSS OAI21_X4
X_11342_ _09015_ _02321_ VDD VSS BUF_X1
X_11343_ _09014_ _02320_ _02321_ _02322_ VDD VSS AOI21_X4
X_11344_ _02302_ _02322_ _02323_ VDD VSS OR2_X4
X_11345_ _02301_ _02323_ _02324_ VDD VSS NAND2_X1
X_11346_ _01122_ _08998_ _02325_ VDD VSS XNOR2_X1
X_11347_ _02300_ _02325_ _02324_ _02326_ VDD VSS AOI21_X1
X_11348_ _09000_ _01133_ _02327_ VDD VSS XNOR2_X2
X_11349_ _01117_ _02327_ _02328_ VDD VSS NOR2_X2
X_11350_ _01089_ _02327_ _02329_ VDD VSS NAND2_X1
X_11351_ _09000_ _01133_ _02330_ VDD VSS XOR2_X2
X_11352_ _01122_ _02330_ _02331_ VDD VSS NAND2_X1
X_11353_ _02323_ _02301_ _02329_ _02331_ _02332_ VDD VSS AOI22_X4
X_11354_ _02332_ _02328_ _02333_ VDD VSS NOR2_X1
X_11355_ _02326_ _02333_ _02278_ _02334_ VDD VSS MUX2_X1
X_11356_ _02334_ _02335_ VDD VSS BUF_X4
X_11357_ _02275_ _02290_ _02335_ _02336_ VDD VSS AND3_X4
X_11358_ _01597_ _01310_ _02337_ VDD VSS XNOR2_X1
X_11359_ _08890_ _02337_ _01721_ _08905_ VDD VSS MUX2_X1
X_11360_ _08914_ _01882_ _08915_ _02338_ VDD VSS AOI21_X1
X_11361_ _08907_ _02338_ _02339_ VDD VSS XNOR2_X1
X_11362_ _08905_ _02339_ _01819_ _08934_ VDD VSS MUX2_X1
X_11363_ _08936_ _01823_ _02340_ VDD VSS XOR2_X1
X_11364_ _08934_ _02340_ _01916_ _08952_ VDD VSS MUX2_X1
X_11365_ _08954_ _08956_ _01923_ _02341_ VDD VSS OR3_X1
X_11366_ _01924_ _02341_ _02342_ VDD VSS AND2_X1
X_11367_ _08952_ _02342_ _02017_ _08969_ VDD VSS MUX2_X1
X_11368_ _02105_ _01703_ _02343_ VDD VSS XNOR2_X1
X_11369_ _02132_ _02344_ VDD VSS BUF_X8
X_11370_ _08969_ _02343_ _02344_ _09001_ VDD VSS MUX2_X2
X_11371_ _02259_ _02196_ _02232_ _09001_ _02345_ VDD VSS AND4_X2
X_11372_ _09003_ _01131_ _02346_ VDD VSS XNOR2_X2
X_11373_ _02278_ _02347_ VDD VSS BUF_X8
X_11374_ _02345_ _02346_ _02347_ _02348_ VDD VSS AOI21_X4
X_11375_ _02348_ _09010_ VDD VSS INV_X1
X_11376_ _02265_ _02336_ _09010_ _02349_ VDD VSS NAND3_X1
X_11377_ _02302_ _02322_ _02350_ VDD VSS XNOR2_X2
X_11378_ _02256_ _02264_ _02351_ VDD VSS NAND2_X4
X_11379_ _02275_ _02290_ _02335_ _02352_ VDD VSS NAND3_X4
X_11380_ _02351_ _02352_ _02353_ VDD VSS NOR2_X4
X_11381_ _02349_ _02350_ _02353_ _02354_ VDD VSS OAI21_X4
X_11382_ _01122_ _02355_ VDD VSS CLKBUF_X3
X_11383_ _02355_ _02356_ VDD VSS CLKBUF_X3
X_11384_ _09037_ _02357_ VDD VSS INV_X1
X_11385_ _09043_ _02358_ VDD VSS INV_X1
X_11386_ _09031_ _02359_ VDD VSS INV_X1
X_11387_ _09032_ _09025_ _09026_ _02360_ VDD VSS OAI21_X2
X_11388_ _02360_ _02359_ _02361_ VDD VSS NAND2_X2
X_11389_ _09029_ _02361_ _02362_ VDD VSS AND2_X4
X_11390_ _09044_ _02362_ _09028_ _02363_ VDD VSS OAI21_X4
X_11391_ _02358_ _02363_ _02364_ VDD VSS NAND2_X4
X_11392_ _09040_ _02364_ _09041_ _02365_ VDD VSS AOI21_X4
X_11393_ _09038_ _02366_ VDD VSS INV_X1
X_11394_ _02357_ _02366_ _02365_ _02367_ VDD VSS OAI21_X4
X_11395_ _09035_ _02367_ _02368_ VDD VSS AND2_X4
X_11396_ _02368_ _09034_ _02369_ VDD VSS NOR2_X4
X_11397_ _02356_ _02369_ _02370_ VDD VSS XNOR2_X2
X_11398_ _02273_ _02267_ _02268_ _02371_ VDD VSS OAI21_X4
X_11399_ _02259_ _02266_ _02371_ _02214_ _02210_ _02372_ VDD
+ VSS OAI221_X2
X_11400_ _02276_ _02372_ _02373_ VDD VSS XNOR2_X2
X_11401_ _02174_ _02266_ _02371_ _02374_ VDD VSS NOR3_X4
X_11402_ _02279_ _02300_ _02375_ VDD VSS NOR2_X2
X_11403_ _08963_ _02376_ VDD VSS INV_X1
X_11404_ _02376_ _02236_ net7 _02377_ VDD VSS MUX2_X2
X_11405_ _01089_ _02280_ _02378_ VDD VSS XNOR2_X1
X_11406_ _02377_ _02378_ _02379_ VDD VSS XNOR2_X1
X_11407_ _02328_ _02379_ _02380_ VDD VSS NOR2_X2
X_11408_ _02237_ _02238_ _02244_ _02381_ VDD VSS NOR3_X4
X_11409_ _02173_ _02133_ _02123_ _02382_ VDD VSS AOI21_X4
X_11410_ _02381_ _02382_ _02383_ VDD VSS NOR2_X2
X_11411_ _02374_ _02375_ _02380_ _02383_ _02384_ VDD VSS AOI22_X4
X_11412_ _02384_ _02385_ VDD VSS INV_X1
X_11413_ _02174_ _02266_ _02371_ _02248_ _02382_ _02381_ _02386_
+ VDD VSS OAI33_X1
X_11414_ _02321_ _02387_ VDD VSS INV_X1
X_11415_ _09020_ _02388_ VDD VSS INV_X1
X_11416_ _09005_ _02389_ VDD VSS INV_X1
X_11417_ _09006_ _02310_ _09008_ _02390_ VDD VSS OAI21_X1
X_11418_ _02314_ _02389_ _02390_ _02391_ VDD VSS AOI21_X1
X_11419_ _09023_ _02391_ _02392_ VDD VSS NOR2_X1
X_11420_ _02316_ _02393_ VDD VSS INV_X1
X_11421_ _02388_ _02392_ _02393_ _02394_ VDD VSS OAI21_X1
X_11422_ _09017_ _02394_ _02318_ _02395_ VDD VSS AOI21_X2
X_11423_ _02387_ _02395_ _02396_ VDD VSS NOR2_X1
X_11424_ _09012_ _09014_ _02396_ _02397_ VDD VSS OAI21_X1
X_11425_ _02301_ _02397_ _02398_ VDD VSS AND2_X2
X_11426_ _01090_ _02398_ _02399_ VDD VSS NOR2_X2
X_11427_ _02386_ _02399_ _02400_ VDD VSS NAND2_X1
X_11428_ _02355_ _02398_ _02401_ VDD VSS NOR2_X1
X_11429_ _02386_ _02401_ _02402_ VDD VSS NAND2_X1
X_11430_ _08998_ _02403_ VDD VSS INV_X1
X_11431_ _02403_ _02327_ net2 _02404_ VDD VSS MUX2_X1
X_11432_ _02404_ _02405_ VDD VSS CLKBUF_X3
X_11433_ _02400_ _02402_ _02405_ _02406_ VDD VSS MUX2_X1
X_11434_ _02265_ _02385_ _02352_ _02406_ _02407_ VDD VSS NAND4_X2
X_11435_ _02373_ _02407_ _02408_ VDD VSS XOR2_X2
X_11436_ _02174_ _02215_ _02269_ _02409_ VDD VSS NOR3_X2
X_11437_ _02196_ _02409_ _02410_ VDD VSS NOR2_X4
X_11438_ _02279_ _02300_ _02411_ VDD VSS OR2_X1
X_11439_ _02328_ _02379_ _02412_ VDD VSS OR2_X1
X_11440_ _02411_ _02412_ _02278_ _02413_ VDD VSS MUX2_X1
X_11441_ _02301_ _02397_ _02414_ VDD VSS NAND2_X2
X_11442_ _01090_ _02327_ _02414_ _02415_ VDD VSS NAND3_X1
X_11443_ _02355_ _02330_ _02414_ _02416_ VDD VSS NAND3_X1
X_11444_ _02374_ _02415_ _02416_ _02417_ VDD VSS AOI21_X1
X_11445_ _08998_ _02399_ _02418_ VDD VSS NAND2_X1
X_11446_ _02403_ _02401_ _02419_ VDD VSS NAND2_X1
X_11447_ net2 _02418_ _02419_ _02420_ VDD VSS AOI21_X1
X_11448_ _02413_ _02417_ _02420_ _02421_ VDD VSS OR3_X2
X_11449_ _02158_ _02196_ _02273_ _02422_ VDD VSS NAND3_X1
X_11450_ _02382_ _02422_ _02381_ _02225_ _02231_ _02423_ VDD
+ VSS AOI221_X2
X_11451_ _02373_ _02256_ _02264_ _02423_ _02424_ VDD VSS NAND4_X2
X_11452_ _02410_ _02421_ _02424_ _02425_ VDD VSS OAI21_X4
X_11453_ _02174_ _02196_ _02215_ _02269_ _02426_ VDD VSS NOR4_X2
X_11454_ _02426_ _02274_ _02269_ _02427_ VDD VSS AOI21_X4
X_11455_ _02427_ _02428_ VDD VSS INV_X1
X_11456_ _02290_ net19 _02429_ VDD VSS NAND2_X1
X_11457_ _02428_ _02429_ _02351_ _02430_ VDD VSS OAI21_X2
X_11458_ _01097_ _02104_ _02431_ VDD VSS NOR2_X1
X_11459_ _02112_ net7 _01150_ _02432_ VDD VSS AOI21_X1
X_11460_ _02112_ _02433_ VDD VSS INV_X1
X_11461_ _01929_ _02433_ _02122_ _02434_ VDD VSS NOR3_X4
X_11462_ _02431_ _02432_ _02434_ _02435_ VDD VSS OAI21_X2
X_11463_ _09006_ _02310_ _09012_ _09024_ _02436_ VDD VSS AND4_X1
X_11464_ _02321_ _02318_ _02316_ _02436_ _02437_ VDD VSS NAND4_X1
X_11465_ _08940_ _02308_ _02435_ _02437_ _02438_ VDD VSS OR4_X2
X_11466_ _02266_ _02371_ _02439_ VDD VSS NOR2_X2
X_11467_ _02438_ _02331_ _02329_ _02259_ _02439_ _02440_ VDD
+ VSS AOI221_X2
X_11468_ _01090_ _02403_ _02441_ VDD VSS NAND2_X1
X_11469_ _01122_ _08998_ _02442_ VDD VSS NAND2_X1
X_11470_ net2 _02438_ _02441_ _02442_ _02443_ VDD VSS AOI211_X2
X_11471_ _02410_ _02440_ _02443_ _02444_ VDD VSS OR3_X1
X_11472_ _02444_ _02445_ VDD VSS BUF_X4
X_11473_ _02256_ _02264_ _02427_ _02290_ _02446_ VDD VSS AND4_X2
X_11474_ _02335_ _02445_ _02446_ _02447_ VDD VSS NAND3_X2
X_11475_ _02425_ _02430_ _02447_ _02448_ VDD VSS NAND3_X4
X_11476_ _02174_ _02258_ _02449_ VDD VSS NOR2_X1
X_11477_ _02262_ _02449_ _02450_ VDD VSS NOR2_X1
X_11478_ _02410_ _02440_ _02443_ _02451_ VDD VSS NOR3_X4
X_11479_ _02256_ _02427_ _02290_ _02452_ VDD VSS AND3_X1
X_11480_ _02450_ _02451_ _02452_ _02453_ VDD VSS AOI21_X1
X_11481_ _02372_ _02262_ _02449_ _02454_ VDD VSS OAI21_X1
X_11482_ _02301_ _02323_ _02455_ VDD VSS AND2_X1
X_11483_ _01090_ _08998_ _02456_ VDD VSS XNOR2_X1
X_11484_ _01117_ _02403_ _02455_ _02456_ _02457_ VDD VSS OAI22_X1
X_11485_ _02328_ _02332_ _02458_ VDD VSS OR2_X1
X_11486_ _02457_ _02458_ _02278_ _02459_ VDD VSS MUX2_X2
X_11487_ _02279_ _02238_ _02244_ _02460_ VDD VSS NOR3_X2
X_11488_ _01135_ _02173_ _02461_ VDD VSS NAND2_X1
X_11489_ _02377_ _02244_ _02462_ VDD VSS NAND2_X1
X_11490_ _02355_ _02377_ _02461_ _02462_ _01135_ _02463_ VDD
+ VSS OAI221_X2
X_11491_ _02280_ _02279_ _02464_ VDD VSS NAND2_X1
X_11492_ _01090_ _02279_ _02461_ _02464_ _02287_ _02465_ VDD
+ VSS OAI221_X2
X_11493_ _02439_ _02460_ _02463_ _02465_ _02466_ VDD VSS AOI22_X4
X_11494_ _02254_ _02459_ _02466_ _02467_ VDD VSS NOR3_X4
X_11495_ _02036_ _02053_ _02468_ VDD VSS NOR2_X2
X_11496_ _02126_ _02257_ _02468_ _02469_ VDD VSS MUX2_X2
X_11497_ _02233_ _02469_ _02470_ VDD VSS XOR2_X2
X_11498_ _01989_ _02207_ _02211_ _02203_ _02471_ VDD VSS AOI22_X4
X_11499_ _02471_ _02181_ _02468_ _02472_ VDD VSS AOI21_X2
X_11500_ _02208_ net15 _02471_ _02473_ VDD VSS NAND3_X2
X_11501_ _02472_ _02473_ _02260_ _02474_ VDD VSS AOI21_X4
X_11502_ _02467_ _02470_ _02474_ _02475_ VDD VSS NAND3_X1
X_11503_ _02453_ _02454_ _02475_ _02476_ VDD VSS MUX2_X1
X_11504_ _02476_ _02477_ VDD VSS BUF_X4
X_11505_ _08998_ _02330_ net2 _02478_ VDD VSS MUX2_X2
X_11506_ _02355_ _02414_ _02479_ VDD VSS NOR2_X1
X_11507_ _02351_ _02352_ _02399_ _02479_ _02480_ VDD VSS OAI22_X4
X_11508_ _02478_ _02480_ _02481_ VDD VSS XNOR2_X2
X_11509_ _02408_ _02448_ _02477_ _02481_ _02482_ VDD VSS NOR4_X2
X_11510_ _02256_ _02264_ _02427_ _02290_ _02483_ VDD VSS NAND4_X4
X_11511_ _02467_ _02483_ _02445_ _02484_ VDD VSS OAI21_X2
X_11512_ _02470_ _02484_ _02485_ VDD VSS XOR2_X2
X_11513_ _02259_ _02474_ _02486_ VDD VSS NOR2_X1
X_11514_ _02174_ _02258_ _02469_ _02474_ _02487_ VDD VSS OAI22_X4
X_11515_ _02196_ _02232_ _02488_ VDD VSS NAND2_X2
X_11516_ _02486_ _02487_ _02488_ _02489_ VDD VSS AOI21_X4
X_11517_ _02455_ _02456_ _02490_ VDD VSS NOR2_X1
X_11518_ _02490_ _02332_ net17 _02491_ VDD VSS MUX2_X2
X_11519_ _02234_ _02254_ _02380_ _02383_ _02492_ VDD VSS NAND4_X4
X_11520_ _02244_ _02238_ _02237_ _02493_ VDD VSS OAI21_X1
X_11521_ _02381_ _02488_ _02494_ VDD VSS NAND2_X1
X_11522_ _02254_ _02455_ _02495_ VDD VSS NOR2_X1
X_11523_ _02493_ _02494_ _02495_ _02496_ VDD VSS NAND3_X1
X_11524_ _02355_ _02405_ _02497_ VDD VSS XNOR2_X2
X_11525_ _02385_ _02491_ _02492_ _02496_ _02497_ _02498_ VDD
+ VSS OAI221_X2
X_11526_ _02491_ _02492_ _02499_ VDD VSS NOR2_X4
X_11527_ _02489_ _02498_ _02353_ _02256_ _02499_ _02500_ VDD
+ VSS OAI221_X2
X_11528_ _02335_ _02445_ _02483_ _02501_ VDD VSS OAI21_X2
X_11529_ net17 _02378_ _02502_ VDD VSS NAND2_X1
X_11530_ _02377_ _02502_ _02503_ VDD VSS XNOR2_X2
X_11531_ _02501_ _02503_ _02504_ VDD VSS XOR2_X2
X_11532_ _02413_ _02417_ _02420_ _02505_ VDD VSS NOR3_X1
X_11533_ _02382_ net17 _02381_ _02506_ VDD VSS AOI21_X4
X_11534_ _02506_ _02350_ _01117_ _02507_ VDD VSS OAI21_X1
X_11535_ _02505_ _02507_ _02265_ _02336_ _02508_ VDD VSS AOI211_X2
X_11536_ _02256_ _02264_ _02423_ _02509_ VDD VSS NAND3_X1
X_11537_ _02290_ _02335_ _02348_ _01117_ _02510_ VDD VSS OAI211_X2
X_11538_ _01117_ _02350_ _02511_ VDD VSS NOR2_X2
X_11539_ _02445_ _02509_ _02510_ _02511_ _02506_ _02421_ _02512_
+ VDD VSS OAI33_X1
X_11540_ _02508_ _02512_ _02513_ VDD VSS NOR2_X4
X_11541_ _02485_ _02500_ _02504_ _02513_ _02514_ VDD VSS NOR4_X2
X_11542_ _02354_ _02370_ _02482_ _02514_ _02515_ VDD VSS AOI211_X2
X_11543_ _01091_ _02369_ _02516_ VDD VSS XNOR2_X2
X_11544_ _02408_ _02448_ _02477_ _02513_ _02517_ VDD VSS OR4_X4
X_11545_ _02470_ _02484_ _02518_ VDD VSS XNOR2_X2
X_11546_ _02489_ _02499_ _02256_ _02519_ VDD VSS OAI21_X2
X_11547_ _02493_ _02494_ _02495_ _02520_ VDD VSS AND3_X1
X_11548_ _01090_ _02405_ _02521_ VDD VSS XNOR2_X2
X_11549_ _02384_ _02499_ _02520_ _02521_ _02522_ VDD VSS AOI211_X2
X_11550_ _02336_ _02265_ _02523_ VDD VSS NAND2_X4
X_11551_ _02519_ _02522_ _02523_ _02524_ VDD VSS AOI21_X4
X_11552_ _02369_ _02350_ _02525_ VDD VSS OR2_X4
X_11553_ _02399_ _02525_ _02526_ VDD VSS AND2_X1
X_11554_ _02355_ _02398_ _02525_ _02527_ VDD VSS AND3_X1
X_11555_ _02526_ _02527_ _02405_ _02528_ VDD VSS MUX2_X1
X_11556_ _02368_ _09034_ _02529_ VDD VSS OR2_X4
X_11557_ _02350_ _02529_ _02530_ VDD VSS AND2_X1
X_11558_ _02530_ _02398_ _02355_ _02531_ VDD VSS NOR3_X1
X_11559_ _02530_ _02414_ _02355_ _02532_ VDD VSS NOR3_X1
X_11560_ _02531_ _02532_ _02478_ _02533_ VDD VSS MUX2_X1
X_11561_ _02351_ _02352_ _02533_ _02528_ _02534_ VDD VSS OAI22_X4
X_11562_ _02174_ _02266_ _02371_ _09001_ _02535_ VDD VSS NOR4_X2
X_11563_ _01132_ _01131_ _02536_ VDD VSS XNOR2_X1
X_11564_ _01090_ _02535_ _02536_ net17 _02537_ VDD VSS AOI211_X2
X_11565_ _02355_ _02345_ _02346_ net2 _02538_ VDD VSS AOI211_X2
X_11566_ _02529_ _02537_ _02538_ _02539_ VDD VSS OAI21_X2
X_11567_ _02265_ _02405_ _02336_ _02539_ _02540_ VDD VSS NAND4_X2
X_11568_ _02534_ _02540_ _02541_ VDD VSS NAND2_X2
X_11569_ _02501_ _02503_ _02542_ VDD VSS XNOR2_X2
X_11570_ _02518_ _02524_ _02541_ _02542_ _02543_ VDD VSS NAND4_X4
X_11571_ _02516_ _02517_ _02543_ _02544_ VDD VSS OAI21_X1
X_11572_ _02515_ _02544_ _02354_ _02545_ VDD VSS AOI21_X2
X_11573_ _02540_ _02534_ _02546_ VDD VSS AND2_X4
X_11574_ _02504_ _02500_ _02485_ _02546_ _02547_ VDD VSS NOR4_X4
X_11575_ _02408_ _02448_ _02477_ _02513_ _02548_ VDD VSS NOR4_X4
X_11576_ _09059_ _02549_ VDD VSS CLKBUF_X2
X_11577_ _09061_ _02550_ VDD VSS INV_X1
X_11578_ _09046_ _02551_ VDD VSS INV_X1
X_11579_ _09052_ _02552_ VDD VSS INV_X1
X_11580_ _09053_ _09055_ _09056_ _02553_ VDD VSS OAI21_X1
X_11581_ _02552_ _02553_ _02554_ VDD VSS NAND2_X1
X_11582_ _02554_ _09050_ _02555_ VDD VSS AND2_X2
X_11583_ _09047_ _02555_ _09049_ _02556_ VDD VSS OAI21_X4
X_11584_ _02556_ _02551_ _02557_ VDD VSS NAND2_X4
X_11585_ _09065_ _02557_ _02558_ VDD VSS AND2_X4
X_11586_ _09062_ _09064_ _02558_ _02559_ VDD VSS OAI21_X4
X_11587_ _02559_ _02550_ _02560_ VDD VSS NAND2_X4
X_11588_ _02549_ _02560_ _02561_ VDD VSS AND2_X4
X_11589_ _02561_ _09058_ _02562_ VDD VSS OR2_X4
X_11590_ _01090_ _02562_ _02563_ VDD VSS NAND2_X1
X_11591_ _01960_ _02356_ _02562_ _02564_ VDD VSS AOI21_X2
X_11592_ _08915_ _01965_ _08937_ VDD VSS NOR2_X1
X_11593_ _08939_ _08942_ _08941_ _02565_ VDD VSS OR3_X1
X_11594_ _01822_ _02565_ _02566_ VDD VSS AND2_X1
X_11595_ _08937_ _02566_ _01916_ _08955_ VDD VSS MUX2_X1
X_11596_ _08957_ _01922_ _02567_ VDD VSS XOR2_X1
X_11597_ _08955_ _02567_ _02017_ _08972_ VDD VSS MUX2_X1
X_11598_ _01140_ _02143_ _02568_ VDD VSS XNOR2_X1
X_11599_ _08972_ _02568_ _02344_ _08992_ VDD VSS MUX2_X1
X_11600_ _08994_ _01130_ _02569_ VDD VSS XOR2_X1
X_11601_ _08992_ _02569_ _02347_ _09013_ VDD VSS MUX2_X1
X_11602_ _02321_ _02395_ _02570_ VDD VSS XNOR2_X1
X_11603_ _09013_ _02570_ _02523_ _09033_ VDD VSS MUX2_X2
X_11604_ _02563_ _02564_ _09033_ _02571_ VDD VSS MUX2_X2
X_11605_ _02547_ _02548_ _02571_ _02572_ VDD VSS AND3_X2
X_11606_ _01960_ _02573_ VDD VSS BUF_X4
X_11607_ _09035_ _02367_ _02574_ VDD VSS XOR2_X2
X_11608_ _02573_ _02574_ _02575_ VDD VSS NAND2_X1
X_11609_ _02356_ _02574_ _02576_ VDD VSS OR2_X1
X_11610_ _02356_ _02574_ _02577_ VDD VSS NAND2_X1
X_11611_ _02576_ _02577_ _02578_ VDD VSS AND2_X1
X_11612_ _09058_ _02561_ _02579_ VDD VSS NOR2_X4
X_11613_ _02575_ _02578_ _02579_ _02580_ VDD VSS OAI21_X2
X_11614_ _02580_ _02548_ _02547_ _02581_ VDD VSS AOI21_X1
X_11615_ _02572_ _02581_ _02582_ VDD VSS OR2_X1
X_11616_ _02545_ _02582_ _02583_ VDD VSS NOR2_X2
X_11617_ _02545_ _02582_ _02584_ VDD VSS AND2_X1
X_11618_ _02523_ _02585_ VDD VSS BUF_X8
X_11619_ _02252_ net17 _02249_ _02586_ VDD VSS AOI21_X2
X_11620_ _02586_ _02491_ _02384_ _02587_ VDD VSS OAI21_X2
X_11621_ _02384_ _02491_ _02586_ _02588_ VDD VSS OR3_X2
X_11622_ net35 _02587_ _02588_ _02589_ VDD VSS NAND3_X4
X_11623_ _02467_ _02470_ _02445_ _02483_ _02590_ VDD VSS OAI211_X2
X_11624_ _02590_ _02489_ _02591_ VDD VSS XNOR2_X1
X_11625_ _02518_ _02589_ _02591_ _02592_ VDD VSS NAND3_X1
X_11626_ _01117_ _02351_ _02352_ _02348_ _02593_ VDD VSS NOR4_X4
X_11627_ _02593_ _02540_ _02534_ _02523_ _02511_ _02594_ VDD
+ VSS AOI221_X2
X_11628_ _02542_ _02594_ _02595_ VDD VSS NAND2_X1
X_11629_ _02421_ _02353_ _02596_ VDD VSS NOR2_X1
X_11630_ _02506_ _02596_ _02597_ VDD VSS XNOR2_X2
X_11631_ _02592_ _02595_ _02597_ _02598_ VDD VSS AOI21_X2
X_11632_ _02542_ _02513_ _02594_ _02599_ VDD VSS AND3_X1
X_11633_ _02542_ _02594_ _02600_ VDD VSS NOR2_X2
X_11634_ _02599_ _02600_ _02601_ VDD VSS NOR2_X4
X_11635_ _02546_ _02504_ _02513_ _02602_ VDD VSS NOR3_X4
X_11636_ _02518_ _02524_ _02603_ VDD VSS NAND2_X2
X_11637_ _02408_ _02448_ _02477_ _02604_ VDD VSS OR3_X2
X_11638_ _02602_ _02603_ _02604_ _02605_ VDD VSS OAI21_X4
X_11639_ _02508_ _02512_ _02606_ VDD VSS OR2_X2
X_11640_ _02541_ _02542_ _02606_ _02607_ VDD VSS NAND3_X2
X_11641_ _02506_ _02499_ _02256_ _02608_ VDD VSS OAI21_X1
X_11642_ _02413_ _02499_ _02520_ _02521_ _02609_ VDD VSS AOI211_X2
X_11643_ _02608_ _02609_ net35 _02610_ VDD VSS AOI21_X1
X_11644_ _02542_ _02594_ _02610_ _02611_ VDD VSS AND3_X1
X_11645_ _02233_ _02250_ _02612_ VDD VSS NOR2_X1
X_11646_ _02586_ _02398_ _02497_ _02613_ VDD VSS OAI21_X1
X_11647_ _02384_ _02353_ _02613_ _02614_ VDD VSS NOR3_X2
X_11648_ _02612_ _02614_ _02615_ VDD VSS XNOR2_X2
X_11649_ _02607_ _02611_ _02615_ _02616_ VDD VSS OAI21_X2
X_11650_ _02598_ _02601_ _02605_ _02616_ _02617_ VDD VSS AND4_X1
X_11651_ _02617_ _02618_ VDD VSS BUF_X4
X_11652_ _02405_ _02529_ _02619_ VDD VSS NAND2_X1
X_11653_ _02459_ _02445_ _02483_ _02619_ _02620_ VDD VSS NOR4_X1
X_11654_ _02478_ _02414_ _02529_ _02621_ VDD VSS NAND3_X1
X_11655_ _02621_ _02451_ net19 _02622_ VDD VSS AOI21_X1
X_11656_ _02398_ _02529_ _02623_ VDD VSS NAND2_X1
X_11657_ _02356_ _02446_ _02621_ _02623_ _02478_ _02624_ VDD
+ VSS OAI221_X1
X_11658_ _02620_ _02622_ _02624_ _02625_ VDD VSS NOR3_X1
X_11659_ _01960_ _02478_ _02626_ VDD VSS NOR2_X1
X_11660_ _02265_ _02336_ _02539_ _02626_ _02627_ VDD VSS NAND4_X1
X_11661_ _01117_ _02528_ _02533_ _02628_ VDD VSS OAI21_X1
X_11662_ _02627_ _02628_ _02353_ _02356_ _02369_ _02629_ VDD
+ VSS OAI221_X2
X_11663_ _02625_ _02629_ _02481_ _01960_ _02630_ VDD VSS AOI211_X2
X_11664_ _02356_ _02369_ _02631_ VDD VSS NOR2_X1
X_11665_ _02354_ _02631_ _02481_ _02632_ VDD VSS AOI21_X2
X_11666_ _02630_ _02632_ _02633_ VDD VSS NOR2_X2
X_11667_ _02408_ _02448_ _02477_ _02634_ VDD VSS NOR3_X4
X_11668_ _02408_ _02448_ _02485_ _02500_ _02635_ VDD VSS NOR4_X4
X_11669_ _02634_ _02602_ _02635_ _02636_ VDD VSS AOI21_X4
X_11670_ _02547_ _02548_ _02571_ _02637_ VDD VSS NAND3_X4
X_11671_ _02354_ _02370_ _02638_ VDD VSS NOR2_X2
X_11672_ _02580_ _02594_ _02638_ _02639_ VDD VSS OR3_X2
X_11673_ _02633_ _02636_ _02637_ _02639_ _02640_ VDD VSS AOI211_X2
X_11674_ _02618_ _02640_ _02641_ VDD VSS NAND2_X4
X_11675_ _02641_ _02642_ VDD VSS BUF_X8
X_11676_ _02583_ _02584_ net18 _02643_ VDD VSS AOI21_X2
X_11677_ _02356_ _02644_ VDD VSS CLKBUF_X3
X_11678_ _09082_ _02645_ VDD VSS BUF_X2
X_11679_ _09084_ _02646_ VDD VSS INV_X1
X_11680_ _09067_ _02647_ VDD VSS INV_X1
X_11681_ _09085_ _02648_ VDD VSS BUF_X2
X_11682_ _02648_ _02649_ VDD VSS INV_X1
X_11683_ _02646_ _02647_ _02649_ _02650_ VDD VSS OAI21_X1
X_11684_ _02645_ _02650_ _02651_ VDD VSS NAND2_X1
X_11685_ _02644_ _02651_ _02652_ VDD VSS NOR2_X1
X_11686_ _09081_ _02653_ VDD VSS INV_X1
X_11687_ _09070_ _02654_ VDD VSS INV_X1
X_11688_ _09071_ _02655_ VDD VSS BUF_X1
X_11689_ _09076_ _02656_ VDD VSS INV_X1
Xrebuffer56 net415 net414 VDD VSS BUF_X1
X_11691_ _09077_ _09078_ _09079_ _02658_ VDD VSS OAI21_X2
X_11692_ _02656_ _02658_ _02659_ VDD VSS NAND2_X2
X_11693_ _09074_ _02659_ _02660_ VDD VSS AND2_X4
X_11694_ _02655_ _02660_ _09073_ _02661_ VDD VSS OAI21_X2
X_11695_ _02654_ _02661_ _02662_ VDD VSS NAND2_X2
X_11696_ _09068_ _02645_ _02648_ _02662_ _02663_ VDD VSS NAND4_X4
X_11697_ _02653_ _02663_ _02664_ VDD VSS NAND2_X4
X_11698_ _02664_ _02665_ VDD VSS INV_X4
X_11699_ _02644_ _02665_ _02666_ VDD VSS NOR2_X2
X_11700_ _02666_ _02652_ _02667_ VDD VSS NOR2_X1
X_11701_ _01117_ _01091_ _02651_ _02668_ VDD VSS OAI21_X1
X_11702_ _02668_ _02669_ VDD VSS INV_X1
X_11703_ _08940_ _01916_ _02670_ VDD VSS NOR2_X4
X_11704_ _02670_ _01916_ _08942_ _08958_ VDD VSS AOI21_X2
X_11705_ _08960_ _01920_ _08961_ _02671_ VDD VSS OR3_X1
X_11706_ _01921_ _02671_ _02672_ VDD VSS AND2_X1
X_11707_ _08958_ _02672_ _02017_ _08975_ VDD VSS MUX2_X1
X_11708_ _01699_ _01698_ _02673_ VDD VSS AND2_X1
X_11709_ _08977_ _02673_ _02674_ VDD VSS XNOR2_X1
X_11710_ _08975_ _02674_ _02344_ _08995_ VDD VSS MUX2_X1
X_11711_ _08997_ _08987_ _01128_ _02675_ VDD VSS OR3_X1
X_11712_ _01129_ _02675_ _02676_ VDD VSS AND2_X1
X_11713_ _08995_ _02676_ _02347_ _09016_ VDD VSS MUX2_X1
X_11714_ _02318_ _02317_ _02677_ VDD VSS XNOR2_X1
X_11715_ _09016_ _02677_ _02585_ _09036_ VDD VSS MUX2_X2
X_11716_ _02547_ _02548_ _09036_ _02678_ VDD VSS NAND3_X2
X_11717_ _09038_ _02365_ _02679_ VDD VSS XNOR2_X1
X_11718_ _02679_ _02517_ _02543_ _02680_ VDD VSS OAI21_X2
X_11719_ _02678_ _02680_ _09057_ VDD VSS NAND2_X1
X_11720_ _02667_ _02669_ _09057_ _02681_ VDD VSS MUX2_X1
X_11721_ _02549_ _02560_ _02682_ VDD VSS XNOR2_X2
X_11722_ _02668_ _02652_ _02682_ _02683_ VDD VSS MUX2_X1
X_11723_ _02683_ _02684_ VDD VSS INV_X1
X_11724_ _02681_ _02684_ _02641_ _02685_ VDD VSS MUX2_X2
X_11725_ _02598_ _02601_ _02605_ _02616_ _02686_ VDD VSS NAND4_X4
X_11726_ _02630_ _02632_ _02687_ VDD VSS OR2_X2
X_11727_ _02602_ _02635_ _02688_ VDD VSS AND2_X1
X_11728_ _02580_ _02594_ _02638_ _02689_ VDD VSS NOR3_X4
X_11729_ _02687_ _02688_ _02634_ _02572_ _02689_ _02690_ VDD
+ VSS OAI221_X2
X_11730_ _02666_ _02682_ _02691_ VDD VSS AND2_X1
X_11731_ _02644_ _02664_ _02692_ VDD VSS NAND2_X1
X_11732_ _02682_ _02692_ _02693_ VDD VSS NOR2_X1
X_11733_ _02686_ _02690_ _02691_ _02693_ _02694_ VDD VSS OAI22_X2
X_11734_ _02692_ _02680_ _02678_ _02695_ VDD VSS AOI21_X1
X_11735_ _02618_ _02640_ _02695_ _02696_ VDD VSS NAND3_X1
X_11736_ _02696_ _02694_ _02697_ VDD VSS AND2_X4
X_11737_ _02548_ _02547_ _02698_ VDD VSS NAND2_X4
X_11738_ _09033_ _02574_ _02698_ _02699_ VDD VSS MUX2_X2
X_11739_ _02518_ _02524_ _02542_ _02606_ _02700_ VDD VSS NAND4_X1
X_11740_ _02638_ _02481_ _02700_ _02701_ VDD VSS OAI21_X1
X_11741_ _02354_ _02516_ _02604_ _02702_ VDD VSS AOI21_X2
X_11742_ _02354_ _02516_ _02703_ VDD VSS NAND2_X1
X_11743_ _02703_ _02548_ _02547_ _02704_ VDD VSS AOI21_X2
X_11744_ _02701_ _02702_ _02704_ _02705_ VDD VSS OAI21_X1
X_11745_ _01547_ _02562_ _02705_ _02706_ VDD VSS NOR3_X1
X_11746_ _02644_ _02579_ _02707_ VDD VSS XNOR2_X2
X_11747_ _02699_ _02707_ _02708_ VDD VSS XNOR2_X1
X_11748_ _02699_ _02641_ _02705_ _02706_ _02583_ _02708_ _02709_
+ VDD VSS OAI33_X1
X_11749_ _02543_ _02517_ _02710_ VDD VSS NOR2_X4
X_11750_ _02541_ _02542_ _02606_ _02589_ _02711_ VDD VSS NAND4_X1
X_11751_ _02611_ _02615_ _02711_ _02712_ VDD VSS AOI21_X1
X_11752_ _02710_ _02712_ _02713_ VDD VSS OR2_X2
X_11753_ _02518_ _02611_ _02714_ VDD VSS OR2_X1
X_11754_ _02597_ _02595_ _02715_ VDD VSS NAND2_X1
X_11755_ _02715_ _02605_ _02716_ VDD VSS AND2_X1
X_11756_ _02713_ _02714_ _02716_ _02717_ VDD VSS AND3_X1
X_11757_ _02601_ _02605_ _02718_ VDD VSS NAND2_X1
X_11758_ _02593_ _02511_ net35 _02719_ VDD VSS AOI21_X2
X_11759_ _02541_ _02719_ _02720_ VDD VSS NAND2_X1
X_11760_ _02405_ _02480_ _02721_ VDD VSS XNOR2_X1
X_11761_ _02719_ _02722_ VDD VSS INV_X1
X_11762_ _02644_ _02354_ _02723_ VDD VSS XNOR2_X1
X_11763_ _02722_ _02723_ _02529_ _02724_ VDD VSS AOI21_X1
X_11764_ _02710_ _02720_ _02721_ _02724_ _02725_ VDD VSS OAI22_X2
X_11765_ _02701_ _02702_ _02704_ _02581_ _02572_ _02726_ VDD
+ VSS OAI221_X2
X_11766_ _02718_ _02725_ _02726_ _02727_ VDD VSS AOI21_X2
X_11767_ _02589_ _02605_ _02728_ VDD VSS XOR2_X2
X_11768_ _02633_ _02639_ _02637_ _02729_ VDD VSS AOI21_X4
X_11769_ _02686_ _02690_ _02728_ _02729_ _02730_ VDD VSS OAI22_X1
X_11770_ _02717_ _02727_ _02730_ _02731_ VDD VSS AND3_X2
X_11771_ _02685_ _02697_ net379 _02731_ _02732_ VDD VSS NAND4_X4
X_11772_ _02408_ _02733_ VDD VSS INV_X1
X_11773_ _02477_ _02734_ VDD VSS INV_X1
X_11774_ _02733_ _02734_ _02735_ VDD VSS NOR2_X1
X_11775_ _02408_ _02477_ _02736_ VDD VSS OR2_X2
X_11776_ _02736_ _02634_ _02603_ _02607_ _02737_ VDD VSS NOR4_X2
X_11777_ _02735_ _02737_ _02738_ VDD VSS OR2_X1
X_11778_ _02687_ _02689_ _02572_ _02739_ VDD VSS OAI21_X4
X_11779_ _02433_ net29 _01150_ _02740_ VDD VSS AOI21_X2
X_11780_ net19 _02451_ _02446_ _02740_ _02741_ VDD VSS NAND4_X2
X_11781_ _02103_ _02112_ _02742_ VDD VSS NOR2_X4
X_11782_ _02742_ _02445_ _02459_ _02743_ VDD VSS OAI21_X2
X_11783_ _02109_ net29 _01150_ _02744_ VDD VSS AOI21_X2
X_11784_ _01710_ _02434_ _02744_ _02745_ VDD VSS NOR3_X4
X_11785_ _02745_ _02742_ _02483_ _02746_ VDD VSS AOI21_X2
X_11786_ _09047_ _09056_ _09050_ _09053_ _02747_ VDD VSS NAND4_X1
X_11787_ _02549_ _09062_ _09065_ _02748_ VDD VSS NAND3_X1
X_11788_ _01170_ _02747_ _02748_ _02749_ VDD VSS NOR3_X1
X_11789_ _02741_ _02743_ _02746_ _02749_ _02750_ VDD VSS AND4_X1
X_11790_ _01596_ net9 _02751_ VDD VSS NOR2_X2
X_11791_ _08940_ net29 _02751_ _02752_ VDD VSS AOI21_X4
X_11792_ _02750_ _02752_ _02753_ VDD VSS NAND2_X1
X_11793_ _02753_ _02577_ _02576_ _02547_ _02548_ _02754_ VDD
+ VSS AOI221_X2
X_11794_ _02356_ _09033_ _02750_ _02752_ _02755_ VDD VSS NAND4_X1
X_11795_ _02543_ _02517_ _02755_ _02756_ VDD VSS NOR3_X2
X_11796_ _02741_ _02743_ _02746_ _02757_ VDD VSS NAND3_X4
X_11797_ _02749_ _02752_ _02758_ VDD VSS NAND2_X1
X_11798_ _02356_ _09033_ _02757_ _02758_ _02759_ VDD VSS OR4_X1
X_11799_ _02543_ _02517_ _02759_ _02760_ VDD VSS NOR3_X2
X_11800_ _02636_ _02754_ _02756_ _02760_ _02761_ VDD VSS NOR4_X4
X_11801_ _02736_ _02739_ _02686_ _02761_ _02762_ VDD VSS NOR4_X4
X_11802_ _02636_ _02754_ _02756_ _02760_ _02763_ VDD VSS OR4_X1
X_11803_ _02729_ _02618_ _02763_ _02764_ VDD VSS NAND3_X1
X_11804_ _02603_ _02607_ _02765_ VDD VSS NOR2_X1
X_11805_ _02733_ _02765_ _02766_ VDD VSS NOR2_X1
X_11806_ _02738_ _02762_ _02764_ _02766_ _02767_ VDD VSS AOI211_X2
X_11807_ _02739_ _02686_ _02761_ _02768_ VDD VSS NOR3_X4
X_11808_ _02518_ _02715_ _02589_ _02769_ VDD VSS AND3_X1
X_11809_ _02601_ _02605_ _02770_ VDD VSS AND2_X2
X_11810_ _02729_ _02769_ _02770_ _02713_ _02771_ VDD VSS NAND4_X2
X_11811_ _02591_ _02611_ _02518_ _02772_ VDD VSS AOI21_X1
X_11812_ _02772_ _02765_ _02604_ _02773_ VDD VSS AOI21_X1
X_11813_ _02773_ _02774_ VDD VSS INV_X1
X_11814_ _02768_ _02771_ _02774_ _02775_ VDD VSS AOI21_X4
X_11815_ _02408_ _02448_ _02776_ VDD VSS OR2_X1
X_11816_ _02485_ _02500_ _02777_ VDD VSS NOR2_X1
X_11817_ _02776_ _02734_ _02777_ _02602_ _02778_ VDD VSS NAND4_X1
X_11818_ _02477_ _02603_ _02607_ _02779_ VDD VSS OAI21_X1
X_11819_ _02778_ _02779_ _02780_ VDD VSS NAND2_X1
X_11820_ _02768_ _02780_ _02781_ VDD VSS XNOR2_X2
X_11821_ _02425_ _02777_ _02602_ _02782_ VDD VSS NAND3_X1
X_11822_ _02448_ _02736_ _02782_ _02783_ VDD VSS OAI21_X1
X_11823_ _02430_ _02447_ _02784_ VDD VSS NAND2_X1
X_11824_ _02408_ _02784_ _02785_ VDD VSS NOR2_X2
X_11825_ _02547_ _02606_ _02785_ _02786_ VDD VSS NAND3_X1
X_11826_ _02425_ _02734_ _02785_ _02787_ VDD VSS AOI21_X1
X_11827_ _02633_ _02786_ _02787_ _02639_ _02637_ _02788_ VDD
+ VSS AOI221_X2
X_11828_ _02783_ _02788_ _02618_ _02789_ VDD VSS AOI21_X1
X_11829_ _02784_ _02737_ _02790_ VDD VSS XNOR2_X2
X_11830_ _02733_ _02778_ _02779_ _02791_ VDD VSS AND3_X1
X_11831_ _02790_ _02791_ _02636_ _02792_ VDD VSS AOI21_X1
X_11832_ _02789_ _02792_ _02790_ _02762_ _02793_ VDD VSS AOI211_X2
X_11833_ _02767_ _02775_ _02781_ _02793_ _02794_ VDD VSS NAND4_X4
X_11834_ _02794_ _02732_ _02795_ VDD VSS NOR2_X4
X_11835_ _02795_ _02796_ VDD VSS BUF_X8
X_11836_ _01117_ _02797_ VDD VSS BUF_X4
X_11837_ _02644_ _09081_ _02645_ _02798_ VDD VSS OAI21_X1
X_11838_ _01150_ net29 _02799_ VDD VSS NAND2_X1
X_11839_ _02104_ _02112_ _02799_ _02800_ VDD VSS OR3_X1
X_11840_ _02104_ _02112_ _02799_ _02801_ VDD VSS OAI21_X1
X_11841_ _02800_ _02801_ _02802_ VDD VSS AND2_X2
X_11842_ _01965_ _01882_ _02803_ VDD VSS NOR2_X1
X_11843_ _02307_ _08890_ _02804_ VDD VSS NAND2_X1
X_11844_ _02803_ _02308_ _02804_ _02805_ VDD VSS AOI21_X1
X_11845_ _02800_ _02805_ _02806_ VDD VSS XNOR2_X1
X_11846_ _01710_ _02806_ _02807_ VDD VSS NAND2_X1
X_11847_ _02112_ _02802_ _02807_ _02808_ VDD VSS OR3_X2
X_11848_ _02808_ _02451_ net19 _02809_ VDD VSS AOI21_X2
X_11849_ _01710_ _02802_ _02810_ VDD VSS NAND2_X1
X_11850_ _02459_ _02445_ _02483_ _02810_ _02811_ VDD VSS NOR4_X4
X_11851_ _02112_ _02802_ _02812_ VDD VSS NAND2_X1
X_11852_ _02446_ _02808_ _02812_ _02807_ _02813_ VDD VSS OAI22_X4
X_11853_ _02809_ _02811_ _02813_ _02814_ VDD VSS NOR3_X4
X_11854_ _02752_ _09007_ VDD VSS INV_X2
X_11855_ _02742_ _02802_ _02351_ _02352_ _02815_ VDD VSS OAI211_X4
X_11856_ _09007_ _02815_ _02816_ VDD VSS XNOR2_X2
X_11857_ _09076_ _09078_ _09077_ _02817_ VDD VSS AOI21_X1
X_11858_ _02817_ _02818_ VDD VSS INV_X1
X_11859_ _02757_ _02814_ _02816_ _02818_ _02819_ VDD VSS NOR4_X2
X_11860_ _09068_ _02655_ _02820_ VDD VSS AND2_X1
X_11861_ _02660_ _02820_ _02821_ VDD VSS NAND2_X1
X_11862_ _02819_ _02821_ _02822_ VDD VSS NOR2_X1
X_11863_ _09070_ _09073_ _02655_ _02823_ VDD VSS AOI21_X1
X_11864_ _09068_ _02824_ VDD VSS INV_X1
X_11865_ _02647_ _02823_ _02824_ _02825_ VDD VSS OAI21_X1
X_11866_ _02648_ _02822_ _02825_ _02826_ VDD VSS OAI21_X1
X_11867_ _02573_ _09081_ _09084_ _02827_ VDD VSS NOR3_X1
X_11868_ _02797_ _02798_ _02826_ _02827_ _02828_ VDD VSS AOI22_X2
X_11869_ _02682_ _02640_ _02618_ _02829_ VDD VSS AOI21_X2
X_11870_ _02636_ _02678_ _02680_ _02830_ VDD VSS AOI21_X2
X_11871_ _02729_ _02618_ _02830_ _02831_ VDD VSS AND3_X1
X_11872_ _02828_ _02829_ _02831_ _02832_ VDD VSS OAI21_X2
X_11873_ _02707_ _02833_ VDD VSS INV_X1
X_11874_ _02833_ _02690_ _02686_ _02834_ VDD VSS OAI21_X4
X_11875_ _02699_ _02834_ _02835_ VDD VSS XOR2_X2
X_11876_ _02645_ _02648_ _09084_ _02836_ VDD VSS OAI21_X1
X_11877_ _02653_ _02836_ _02837_ VDD VSS NAND2_X1
X_11878_ _09081_ _09084_ _02825_ _02838_ VDD VSS OR3_X1
X_11879_ _02837_ _02838_ _02822_ _02839_ VDD VSS OAI21_X1
X_11880_ _02644_ _02831_ _02829_ _02839_ _02840_ VDD VSS OR4_X2
X_11881_ _02832_ _02835_ _02840_ _02841_ VDD VSS NAND3_X1
X_11882_ _02796_ _02841_ _02842_ VDD VSS NOR2_X1
X_11883_ _02643_ _02842_ _02843_ VDD VSS XOR2_X2
X_11884_ _02835_ _02697_ _02685_ _02844_ VDD VSS AOI21_X2
X_11885_ _02729_ _02618_ _02830_ _02845_ VDD VSS NAND3_X2
X_11886_ _02549_ _02560_ _02846_ VDD VSS XOR2_X2
X_11887_ _02846_ _02690_ _02686_ _02847_ VDD VSS OAI21_X2
X_11888_ _02845_ _02847_ _02848_ VDD VSS NAND2_X2
X_11889_ _02644_ _02839_ _02849_ VDD VSS XNOR2_X1
X_11890_ _02848_ _02849_ _02850_ VDD VSS XNOR2_X2
X_11891_ _02644_ _02651_ _02665_ _02851_ VDD VSS AOI21_X1
X_11892_ _02851_ _02668_ _09057_ _02852_ VDD VSS MUX2_X1
X_11893_ _02852_ _02683_ net18 _02853_ VDD VSS MUX2_X1
X_11894_ _02694_ _02696_ _02854_ VDD VSS NAND2_X1
X_11895_ _02699_ _02834_ _02855_ VDD VSS XNOR2_X2
X_11896_ _02853_ _02854_ _02855_ _02856_ VDD VSS NOR3_X2
X_11897_ _02844_ _02850_ _02856_ _02857_ VDD VSS NOR3_X2
X_11898_ _02848_ _02855_ _02858_ VDD VSS NOR2_X2
X_11899_ _02857_ _02858_ _02796_ _02859_ VDD VSS AOI21_X1
X_11900_ _01920_ _02064_ _08978_ VDD VSS NOR2_X1
X_11901_ _08980_ _01142_ _08982_ _02860_ VDD VSS OR3_X1
X_11902_ _02141_ _02860_ _02861_ VDD VSS AND2_X1
X_11903_ _08978_ _02861_ _02344_ _08986_ VDD VSS MUX2_X1
X_11904_ _08988_ _01127_ _02862_ VDD VSS XOR2_X1
X_11905_ _08986_ _02862_ _02347_ _09019_ VDD VSS MUX2_X1
X_11906_ _02316_ _02392_ _02863_ VDD VSS XNOR2_X1
X_11907_ _09019_ _02863_ _02585_ _09039_ VDD VSS MUX2_X1
X_11908_ _09041_ _02364_ _02864_ VDD VSS XOR2_X1
X_11909_ _09039_ _02864_ _02698_ _09060_ VDD VSS MUX2_X1
X_11910_ _09062_ _09064_ _02558_ _02865_ VDD VSS OR3_X1
X_11911_ _02559_ _02865_ _02866_ VDD VSS AND2_X1
X_11912_ _09060_ _02866_ net18 _09080_ VDD VSS MUX2_X2
X_11913_ _02732_ _02794_ _09080_ _02867_ VDD VSS NOR3_X4
X_11914_ _02644_ _02868_ VDD VSS CLKBUF_X3
Xclone13 _02886_ _02888_ net13 VDD VSS NAND2_X2
X_11916_ _09087_ _09088_ _09090_ _02870_ VDD VSS AOI21_X2
X_11917_ _02870_ _02871_ VDD VSS INV_X2
X_11918_ _09106_ _02872_ VDD VSS BUF_X2
X_11919_ _09105_ _02872_ _02871_ _02873_ VDD VSS AOI21_X4
X_11920_ _02873_ _02868_ _02874_ VDD VSS OR2_X4
X_11921_ _09074_ _02659_ _02875_ VDD VSS NAND2_X1
X_11922_ _02752_ _02815_ _02876_ VDD VSS XNOR2_X1
X_11923_ _02875_ _02876_ _02817_ _02877_ VDD VSS AOI21_X1
X_11924_ _02655_ _09073_ _02877_ _02878_ VDD VSS OAI21_X1
X_11925_ _02824_ _02654_ _02878_ _02879_ VDD VSS AOI21_X1
X_11926_ _09079_ _09074_ _09077_ _02820_ _02880_ VDD VSS NAND4_X2
X_11927_ _02880_ _02816_ _02881_ VDD VSS NOR2_X1
X_11928_ _09067_ _02879_ _02881_ _02882_ VDD VSS NOR3_X1
X_11929_ _02646_ _02882_ _02649_ _02883_ VDD VSS OAI21_X2
X_11930_ _02645_ _02883_ _02884_ VDD VSS XNOR2_X2
X_11931_ _02884_ _02874_ _02885_ VDD VSS AND2_X4
X_11932_ _02697_ _02685_ _02709_ _02731_ _02886_ VDD VSS AND4_X4
Xclone12 _03988_ net12 VDD VSS BUF_X2
X_11934_ _02767_ _02775_ _02781_ _02793_ _02888_ VDD VSS AND4_X4
X_11935_ _02888_ _02886_ _02889_ VDD VSS NAND2_X4
X_11936_ _02867_ _02874_ _02885_ net13 _02890_ VDD VSS AOI22_X4
X_11937_ _02645_ _02883_ _02891_ VDD VSS XOR2_X2
X_11938_ _02891_ _02888_ _02886_ _02892_ VDD VSS AOI21_X4
X_11939_ _02797_ _01091_ _02873_ _02893_ VDD VSS OAI21_X2
X_11940_ _02892_ _02867_ _02893_ _02894_ VDD VSS OR3_X4
X_11941_ _02859_ _02890_ _02894_ _02895_ VDD VSS AOI21_X1
X_11942_ _09091_ _02896_ VDD VSS BUF_X1
X_11943_ _09088_ _02896_ _02872_ _02897_ VDD VSS NAND3_X2
X_11944_ _02868_ _02897_ _02898_ VDD VSS OR2_X1
X_11945_ net27 _02794_ _09080_ _02899_ VDD VSS OR3_X2
X_11946_ _02884_ _02794_ _02732_ _02900_ VDD VSS OAI21_X4
X_11947_ _02898_ _02899_ _02900_ _02901_ VDD VSS AOI21_X1
X_11948_ _01091_ _02897_ _02902_ VDD VSS OR2_X2
X_11949_ _02892_ _02867_ _02902_ _02903_ VDD VSS NOR3_X1
X_11950_ _09096_ _02904_ VDD VSS INV_X1
X_11951_ _09100_ _02905_ VDD VSS BUF_X2
X_11952_ _09099_ _09102_ _02905_ _02906_ VDD VSS AOI21_X1
X_11953_ _09097_ _02907_ VDD VSS INV_X1
X_11954_ _02904_ _02906_ _02907_ _02908_ VDD VSS OAI21_X1
X_11955_ _09094_ _02909_ VDD VSS BUF_X4
X_11956_ _09093_ _02908_ _02909_ _02910_ VDD VSS AOI21_X2
X_11957_ _02910_ _02911_ VDD VSS INV_X1
X_11958_ _09103_ _02912_ VDD VSS BUF_X4
X_11959_ _09097_ _02909_ _02912_ _02905_ _02913_ VDD VSS NAND4_X4
X_11960_ _02757_ _02914_ VDD VSS INV_X1
X_11961_ _02914_ _02814_ _02888_ _02886_ _02915_ VDD VSS AOI211_X2
X_11962_ _02757_ _02814_ _02916_ VDD VSS NOR2_X1
X_11963_ _02886_ _02888_ _02916_ _02917_ VDD VSS AND3_X2
X_11964_ _02913_ _02915_ _02917_ _02918_ VDD VSS NOR3_X2
X_11965_ _02901_ _02903_ _02911_ _02918_ _02919_ VDD VSS OAI22_X2
X_11966_ _02919_ _02920_ VDD VSS BUF_X4
X_11967_ _02843_ _02895_ _02920_ _02921_ VDD VSS AOI21_X2
X_11968_ _02913_ _02915_ _02917_ _02922_ VDD VSS OR3_X1
X_11969_ _01091_ _02892_ _02867_ _02923_ VDD VSS OAI21_X1
X_11970_ _02868_ _02900_ _02899_ _02924_ VDD VSS NAND3_X1
X_11971_ _02897_ _02910_ _02922_ _02923_ _02924_ _02925_ VDD
+ VSS AOI221_X2
X_11972_ _02925_ _02926_ VDD VSS BUF_X4
X_11973_ _02890_ _02894_ _02927_ VDD VSS AND2_X4
X_11974_ _02927_ _02928_ VDD VSS BUF_X16
X_11975_ _02841_ _02643_ _02929_ VDD VSS AND2_X1
X_11976_ _02795_ _02858_ _02857_ _02929_ _02930_ VDD VSS AOI22_X4
X_11977_ _02926_ _02928_ _02930_ _02931_ VDD VSS NOR3_X2
X_11978_ _02686_ _02690_ _02932_ VDD VSS NOR2_X2
X_11979_ _02729_ _02601_ _02716_ _02933_ VDD VSS NAND3_X2
X_11980_ _02932_ _02728_ _02933_ _02934_ VDD VSS NOR3_X2
X_11981_ _02518_ _02611_ _02935_ VDD VSS NAND2_X1
X_11982_ _02714_ _02935_ _02710_ _02936_ VDD VSS OAI21_X2
X_11983_ _02713_ _02936_ _02937_ VDD VSS AND2_X1
X_11984_ _02934_ _02937_ _02938_ VDD VSS NAND2_X1
X_11985_ _02938_ _02936_ _02713_ _02939_ VDD VSS OAI21_X2
X_11986_ _01091_ _02354_ _02940_ VDD VSS XNOR2_X1
X_11987_ _02719_ _02940_ _02369_ _02941_ VDD VSS OAI21_X2
X_11988_ _02698_ _02594_ _02481_ _02941_ _02942_ VDD VSS AOI22_X4
X_11989_ _02942_ _02726_ _02943_ VDD VSS NAND2_X1
X_11990_ _02583_ _02943_ _02641_ _02944_ VDD VSS AOI21_X2
X_11991_ _02832_ _02835_ _02840_ _02944_ _02945_ VDD VSS NAND4_X4
X_11992_ _02715_ _02605_ _02946_ VDD VSS NAND2_X2
X_11993_ _02589_ _02601_ _02605_ _02947_ VDD VSS NAND3_X1
X_11994_ _02589_ _02599_ _02600_ _02948_ VDD VSS OAI21_X1
X_11995_ _02947_ _02948_ _02729_ _02949_ VDD VSS MUX2_X2
X_11996_ _02946_ _02949_ net18 _02950_ VDD VSS AOI21_X2
X_11997_ _02937_ _02950_ _02951_ VDD VSS NAND2_X1
X_11998_ net27 _02794_ _02945_ _02951_ _02952_ VDD VSS OAI22_X2
X_11999_ _02934_ _02936_ _02953_ VDD VSS OR2_X1
X_12000_ _02832_ _02835_ _02840_ _02944_ _02954_ VDD VSS AND4_X2
X_12001_ _02953_ _02950_ _02954_ _02955_ VDD VSS AOI21_X2
X_12002_ _02939_ _02952_ _02955_ _02956_ VDD VSS NOR3_X4
X_12003_ _02781_ _02957_ VDD VSS INV_X1
X_12004_ _02713_ _02714_ _02716_ _02958_ VDD VSS NAND3_X2
X_12005_ _02958_ _02949_ _02641_ _02959_ VDD VSS AOI21_X4
X_12006_ _02775_ _02959_ _02960_ VDD VSS AND2_X1
X_12007_ _02957_ _02954_ _02960_ _02961_ VDD VSS AOI21_X2
X_12008_ net27 _02775_ _02962_ VDD VSS XNOR2_X2
X_12009_ _02795_ _02961_ _02962_ _02963_ VDD VSS AOI21_X4
X_12010_ _02728_ _02933_ _02964_ VDD VSS XOR2_X2
X_12011_ _02739_ _02618_ _02761_ _02965_ VDD VSS AOI21_X2
X_12012_ _02770_ _02965_ _02966_ VDD VSS XNOR2_X2
X_12013_ _02946_ _02966_ _02967_ VDD VSS OR2_X1
X_12014_ _02945_ _02967_ _02886_ _02888_ _02968_ VDD VSS AOI211_X2
X_12015_ _02806_ _02815_ _02969_ VDD VSS AND2_X1
X_12016_ _02645_ _02648_ _02970_ VDD VSS NAND2_X1
X_12017_ _02435_ _09007_ _02970_ _02880_ _02971_ VDD VSS NOR4_X1
X_12018_ _02969_ _02971_ _02972_ VDD VSS AND2_X1
X_12019_ _02942_ _02972_ _02545_ _02582_ _02973_ VDD VSS OAI211_X2
X_12020_ _02726_ _02707_ _02699_ _02974_ VDD VSS OAI21_X1
X_12021_ _02973_ _02974_ _02641_ _02699_ _02834_ _02975_ VDD
+ VSS AOI221_X2
X_12022_ _02868_ _02831_ _02829_ _02976_ VDD VSS NOR3_X2
X_12023_ _01091_ _02845_ _02847_ _02977_ VDD VSS AOI21_X2
X_12024_ _02959_ _02975_ _02976_ _02977_ _02978_ VDD VSS OAI211_X4
X_12025_ _02767_ _02775_ _02781_ _02979_ VDD VSS AND3_X1
X_12026_ net380 _02731_ _02793_ _02980_ VDD VSS AND3_X1
X_12027_ _02978_ _02979_ _02980_ _02981_ VDD VSS AND3_X1
X_12028_ _02713_ _02934_ _02982_ VDD VSS XNOR2_X1
X_12029_ _02685_ _02697_ _02709_ _02983_ VDD VSS AND3_X2
X_12030_ _02716_ _02727_ _02730_ _02984_ VDD VSS AND3_X1
X_12031_ _02982_ _02983_ _02984_ _02985_ VDD VSS AOI21_X2
X_12032_ _02982_ _02983_ _02984_ _02986_ VDD VSS AND3_X1
X_12033_ _02932_ _02964_ _02968_ _02981_ _02985_ _02986_ _02987_
+ VDD VSS OAI33_X1
X_12034_ _02775_ _02781_ _02988_ VDD VSS NAND2_X1
X_12035_ _02732_ _02988_ _02989_ VDD VSS OR2_X1
X_12036_ net27 _02988_ _02793_ _02978_ _02990_ VDD VSS AOI211_X2
X_12037_ _02989_ _02990_ _02767_ _02991_ VDD VSS MUX2_X2
X_12038_ _02956_ _02963_ net378 _02991_ _02992_ VDD VSS NOR4_X4
X_12039_ _02765_ _02729_ _02618_ _02993_ VDD VSS AOI21_X1
X_12040_ _02477_ _02993_ _02994_ VDD VSS NOR2_X1
X_12041_ _02762_ _02790_ _02995_ VDD VSS XOR2_X2
X_12042_ _02886_ _02979_ _02996_ VDD VSS AND2_X1
X_12043_ _02425_ _02785_ _02994_ _02995_ _02996_ _02997_ VDD
+ VSS AOI221_X2
X_12044_ _02767_ _02775_ _02781_ _02959_ _02998_ VDD VSS NAND4_X1
X_12045_ _02945_ _02998_ _02886_ _02888_ _02999_ VDD VSS AOI211_X2
X_12046_ _02995_ _02999_ _03000_ VDD VSS XNOR2_X2
X_12047_ _02969_ _03001_ VDD VSS INV_X1
X_12048_ net35 _02742_ _03002_ VDD VSS NAND2_X1
X_12049_ _02802_ _03002_ _03003_ VDD VSS XOR2_X2
X_12050_ _02913_ _01097_ _03001_ _03003_ _03004_ VDD VSS OR4_X4
X_12051_ _02898_ _03004_ _03005_ VDD VSS OR2_X4
X_12052_ _03005_ _02899_ _02900_ _03006_ VDD VSS AOI21_X4
X_12053_ _03004_ _02867_ _02892_ _02902_ _03007_ VDD VSS NOR4_X4
X_12054_ _03006_ _03000_ _02997_ _03007_ _03008_ VDD VSS NOR4_X4
X_12055_ _02729_ _02686_ _02763_ _03009_ VDD VSS OAI21_X1
X_12056_ _03009_ _02584_ _02942_ _03010_ VDD VSS OAI21_X2
X_12057_ _02770_ _02685_ _02697_ _02709_ _03011_ VDD VSS NAND4_X1
X_12058_ _03010_ _03011_ _02946_ _03012_ VDD VSS AOI21_X2
X_12059_ _02978_ _02979_ _02980_ _03013_ VDD VSS NAND3_X4
X_12060_ _03012_ _02983_ _03013_ _03014_ VDD VSS AOI21_X4
X_12061_ _02954_ _02794_ net27 _03015_ VDD VSS OAI21_X2
X_12062_ _03015_ _02966_ _03016_ VDD VSS XNOR2_X2
X_12063_ _03014_ _02930_ _03016_ _03017_ VDD VSS NOR3_X4
X_12064_ _02992_ _03008_ _03017_ _03018_ VDD VSS NAND3_X4
X_12065_ _03018_ _03019_ VDD VSS BUF_X4
X_12066_ _02921_ _02931_ _03019_ _03020_ VDD VSS AOI21_X4
X_12067_ _09109_ _03021_ VDD VSS INV_X1
X_12068_ _09114_ _03022_ VDD VSS INV_X1
X_12069_ _09120_ _09123_ _09121_ _03023_ VDD VSS AOI21_X2
X_12070_ _09124_ _09125_ _09126_ _03024_ VDD VSS OAI21_X1
X_12071_ _09121_ _03025_ VDD VSS INV_X1
X_12072_ _03023_ _03024_ _03025_ _03026_ VDD VSS OAI21_X4
X_12073_ _09117_ _03026_ _09118_ _03027_ VDD VSS AOI21_X4
X_12074_ _09115_ _03028_ VDD VSS INV_X1
X_12075_ _03022_ _03027_ _03028_ _03029_ VDD VSS OAI21_X4
X_12076_ _09111_ _03029_ _09112_ _03030_ VDD VSS AOI21_X4
X_12077_ _03030_ _03021_ _03031_ VDD VSS NOR2_X4
X_12078_ _09108_ _03031_ _03032_ VDD VSS NOR2_X4
X_12079_ _02915_ _02917_ _03033_ VDD VSS NOR2_X2
X_12080_ _02894_ _02890_ _03034_ VDD VSS NAND2_X4
X_12081_ _02920_ _03034_ _03035_ VDD VSS NAND2_X1
X_12082_ _03035_ _03036_ VDD VSS BUF_X4
X_12083_ _09114_ _09125_ _03037_ VDD VSS NOR2_X1
X_12084_ _03023_ _03038_ VDD VSS INV_X1
X_12085_ _09117_ _03038_ _09118_ _03039_ VDD VSS AOI21_X1
X_12086_ _03037_ _03039_ _03028_ _03040_ VDD VSS OAI21_X1
X_12087_ _09109_ _09111_ _03041_ VDD VSS AND2_X1
X_12088_ _09108_ _03040_ _03041_ _03042_ VDD VSS OR3_X2
X_12089_ _03033_ _03036_ _03019_ _03042_ _03043_ VDD VSS NOR4_X4
X_12090_ _02914_ net13 _03003_ _03044_ VDD VSS NOR3_X1
X_12091_ _02809_ _02811_ _02813_ _03045_ VDD VSS OR3_X1
X_12092_ _02757_ _02795_ _03045_ _03046_ VDD VSS NOR3_X1
X_12093_ _01710_ _03044_ _03046_ _03047_ VDD VSS OAI21_X1
X_12094_ _02889_ _02916_ _03048_ VDD VSS NAND2_X4
X_12095_ _02969_ _03048_ _03049_ VDD VSS NAND2_X1
X_12096_ _03042_ _03047_ _03049_ _03050_ VDD VSS OR3_X1
X_12097_ _02992_ _03017_ _03008_ _03051_ VDD VSS AND3_X4
X_12098_ _03051_ _03052_ VDD VSS BUF_X8
X_12099_ _02928_ _02926_ _03053_ VDD VSS NOR2_X4
X_12100_ _03053_ _03054_ VDD VSS BUF_X8
X_12101_ _03050_ net41 _03054_ _03055_ VDD VSS AOI21_X2
X_12102_ _03032_ _03043_ _03055_ _03056_ VDD VSS NOR3_X4
X_12103_ _02900_ _02899_ _03057_ VDD VSS NAND2_X4
X_12104_ _09105_ _03058_ VDD VSS INV_X1
X_12105_ _02896_ _03059_ VDD VSS INV_X1
X_12106_ _03059_ _02913_ _02910_ _03060_ VDD VSS AOI21_X1
X_12107_ _09090_ _03060_ _03061_ VDD VSS OR2_X1
X_12108_ _09088_ _03061_ _03062_ VDD VSS AND2_X1
X_12109_ _02872_ _09087_ _03062_ _03063_ VDD VSS OAI21_X1
X_12110_ _03058_ _03063_ _03064_ VDD VSS AND2_X1
X_12111_ _03064_ _03065_ VDD VSS INV_X1
X_12112_ _02868_ _03065_ _03066_ VDD VSS NAND2_X1
X_12113_ _09088_ _03061_ _03067_ VDD VSS NAND2_X1
X_12114_ _02872_ _02915_ _02917_ _03067_ _03068_ VDD VSS NOR4_X2
X_12115_ _02872_ _09087_ _03069_ VDD VSS NOR2_X1
X_12116_ _09093_ _09096_ _02909_ _03070_ VDD VSS AOI21_X1
X_12117_ _03070_ _03071_ VDD VSS INV_X1
X_12118_ _09090_ _03071_ _02896_ _03072_ VDD VSS AOI21_X1
X_12119_ _09088_ _03073_ VDD VSS INV_X1
X_12120_ _02906_ _03072_ _03073_ _03074_ VDD VSS OAI21_X1
X_12121_ _03074_ _03075_ VDD VSS INV_X1
X_12122_ _03069_ _03075_ _03067_ _03076_ VDD VSS OAI21_X1
X_12123_ _02872_ _03077_ VDD VSS INV_X1
X_12124_ _03077_ _09087_ _03074_ _03078_ VDD VSS NOR3_X1
X_12125_ _02915_ _02917_ _03079_ VDD VSS OR2_X1
X_12126_ _03068_ _03076_ _03063_ _03078_ _03079_ _03080_ VDD
+ VSS AOI221_X1
X_12127_ _03080_ _03081_ VDD VSS CLKBUF_X3
X_12128_ _03057_ _03066_ _03081_ _03082_ VDD VSS NOR3_X2
X_12129_ _02868_ _03083_ VDD VSS BUF_X2
X_12130_ _03083_ _03057_ _03065_ _03084_ VDD VSS NOR3_X1
X_12131_ _03082_ _03084_ _03081_ _03052_ net424 _03085_ VDD
+ VSS AOI221_X2
X_12132_ _02803_ _02308_ _08981_ VDD VSS OR2_X1
X_12133_ _01142_ _02751_ _03086_ VDD VSS XNOR2_X1
X_12134_ _08981_ _03086_ _02344_ _08989_ VDD VSS MUX2_X1
X_12135_ _08985_ _08991_ _08984_ _03087_ VDD VSS OR3_X1
X_12136_ _01126_ _03087_ _03088_ VDD VSS AND2_X1
X_12137_ _08989_ _03088_ _02347_ _09022_ VDD VSS MUX2_X1
X_12138_ _09024_ _02313_ _03089_ VDD VSS XNOR2_X1
X_12139_ _09022_ _03089_ _02585_ _09042_ VDD VSS MUX2_X1
X_12140_ _09044_ _09028_ _02362_ _03090_ VDD VSS OR3_X1
X_12141_ _02363_ _03090_ _03091_ VDD VSS AND2_X1
X_12142_ _09042_ _03091_ _02698_ _09063_ VDD VSS MUX2_X1
X_12143_ _09065_ _02557_ _03092_ VDD VSS XOR2_X1
X_12144_ _09063_ _03092_ _02642_ _09083_ VDD VSS MUX2_X1
X_12145_ _02732_ _02794_ _09083_ _03093_ VDD VSS OR3_X2
X_12146_ _02822_ _02825_ _03094_ VDD VSS NOR2_X1
X_12147_ _02648_ _03094_ _03095_ VDD VSS XNOR2_X2
X_12148_ _03093_ _03095_ _02795_ _03096_ VDD VSS OAI21_X4
X_12149_ _01091_ _03096_ _03097_ VDD VSS XNOR2_X1
X_12150_ _03082_ _03097_ _03057_ _03098_ VDD VSS AOI21_X1
X_12151_ _03035_ _03018_ _03099_ VDD VSS NOR2_X1
X_12152_ _03099_ _03100_ VDD VSS BUF_X4
X_12153_ _03085_ _03098_ _03100_ _03101_ VDD VSS AOI21_X2
X_12154_ _03083_ _03102_ VDD VSS CLKBUF_X3
X_12155_ _03068_ _03078_ _03079_ _03103_ VDD VSS AOI21_X1
X_12156_ _03063_ _03076_ _03104_ VDD VSS NAND2_X1
X_12157_ _03103_ _03104_ _03105_ VDD VSS NAND2_X2
X_12158_ _03057_ _03065_ _03106_ VDD VSS NAND2_X1
X_12159_ _03083_ _03057_ _03064_ _03107_ VDD VSS NAND3_X1
X_12160_ _03062_ _03074_ _03033_ _03108_ VDD VSS OAI21_X1
X_12161_ _03069_ _03108_ _03109_ VDD VSS AND2_X1
X_12162_ _03102_ _03105_ _03106_ _03107_ _03109_ _03100_ _03110_
+ VDD VSS OAI33_X1
X_12163_ _03056_ _03101_ _03110_ _03111_ VDD VSS OAI21_X4
X_12164_ _03054_ _03052_ _03112_ VDD VSS NAND2_X4
X_12165_ _02859_ _03113_ VDD VSS INV_X1
X_12166_ _03113_ net425 _02926_ _03114_ VDD VSS OAI21_X2
X_12167_ _02855_ _02854_ _02853_ _03115_ VDD VSS OAI21_X1
X_12168_ net13 _02856_ _03116_ VDD VSS NAND2_X1
X_12169_ _03115_ _03116_ _03117_ VDD VSS NAND2_X1
X_12170_ _02850_ _03118_ VDD VSS INV_X1
X_12171_ _03118_ _02858_ _02795_ _03119_ VDD VSS MUX2_X1
X_12172_ _02926_ _02928_ _03117_ _03119_ _03120_ VDD VSS OR4_X2
X_12173_ _03112_ _03114_ _03120_ _03121_ VDD VSS AND3_X2
X_12174_ _01091_ _03064_ _03122_ VDD VSS XNOR2_X2
X_12175_ _03057_ _03122_ _03123_ VDD VSS NOR2_X1
X_12176_ _02894_ _03014_ _02930_ _03016_ _03124_ VDD VSS NOR4_X1
X_12177_ _02992_ _03008_ _02920_ _03124_ _03125_ VDD VSS AND4_X1
X_12178_ _03123_ _03125_ _03126_ VDD VSS NOR2_X2
X_12179_ _03057_ _03122_ _03127_ VDD VSS NAND2_X2
X_12180_ _02992_ _03008_ _03128_ VDD VSS NAND2_X1
X_12181_ _02920_ _03034_ _03017_ _03096_ _03129_ VDD VSS NAND4_X1
X_12182_ _02573_ _03128_ _03129_ _03130_ VDD VSS OAI21_X1
X_12183_ _03105_ _03051_ _03054_ _03131_ VDD VSS AOI21_X1
X_12184_ _03126_ _03127_ _03099_ _03130_ _03131_ _03132_ VDD
+ VSS OAI221_X1
X_12185_ _03132_ _03133_ VDD VSS CLKBUF_X3
X_12186_ _03121_ _03133_ _03134_ VDD VSS NOR2_X2
X_12187_ _03114_ _03120_ _03036_ _03019_ _03135_ VDD VSS OAI211_X4
X_12188_ _02844_ _02856_ _03136_ VDD VSS OR2_X1
X_12189_ _02841_ _02643_ _03137_ VDD VSS NAND2_X1
X_12190_ _02848_ net13 _02855_ _02850_ _03136_ _03137_ _03138_
+ VDD VSS OAI33_X1
X_12191_ _03010_ _02983_ _03013_ _03139_ VDD VSS AOI21_X2
X_12192_ _03013_ _02983_ _03010_ _03140_ VDD VSS AND3_X1
X_12193_ _03138_ _03139_ _03140_ _03141_ VDD VSS OAI21_X2
X_12194_ _03016_ _03141_ _03142_ VDD VSS AND2_X1
X_12195_ _03015_ _02966_ _03143_ VDD VSS XOR2_X1
X_12196_ _03143_ _03034_ _02920_ _03144_ VDD VSS AOI21_X1
X_12197_ _02926_ _02928_ _03016_ _03141_ _03145_ VDD VSS NOR4_X1
X_12198_ _03142_ _03144_ _03145_ _03018_ _03146_ VDD VSS AOI211_X2
X_12199_ _02797_ _03066_ _03147_ VDD VSS NAND2_X1
X_12200_ _02868_ _03064_ _03148_ VDD VSS NOR2_X1
X_12201_ _03147_ _03148_ _03057_ _03149_ VDD VSS MUX2_X2
X_12202_ _02930_ _03149_ _03150_ VDD VSS NOR2_X1
X_12203_ _03139_ _03140_ _03150_ _03151_ VDD VSS OR3_X4
X_12204_ _03135_ _03146_ _03151_ _03020_ _03152_ VDD VSS NAND4_X4
X_12205_ _02868_ _03032_ _03153_ VDD VSS NOR2_X1
X_12206_ _03081_ _03153_ _03154_ VDD VSS AND2_X2
X_12207_ _03031_ _09108_ _03155_ VDD VSS OR2_X4
X_12208_ _03155_ _02868_ _03156_ VDD VSS NAND2_X4
X_12209_ _03156_ _03157_ VDD VSS INV_X4
X_12210_ _03157_ _02573_ _03158_ VDD VSS NOR2_X4
X_12211_ _03081_ _03158_ _03159_ VDD VSS NOR2_X2
X_12212_ _03036_ _03018_ _03159_ _03154_ _03160_ VDD VSS OAI22_X4
X_12213_ _03158_ _03096_ _03161_ VDD VSS NOR2_X1
X_12214_ _03096_ _03153_ _03162_ VDD VSS AND2_X1
X_12215_ _03054_ _03052_ _03162_ _03161_ _03163_ VDD VSS OAI211_X2
X_12216_ _03163_ _03160_ _03164_ VDD VSS NAND2_X4
X_12217_ _02932_ _02964_ _02968_ _03165_ VDD VSS NOR3_X2
X_12218_ _02950_ _03166_ VDD VSS INV_X1
X_12219_ _03015_ _03166_ _03167_ VDD VSS NOR2_X1
X_12220_ _03165_ _03167_ _03168_ VDD VSS NOR2_X2
X_12221_ _02920_ _03168_ _03169_ VDD VSS NOR2_X1
X_12222_ _03168_ _03017_ _03034_ _03170_ VDD VSS AOI21_X1
X_12223_ _03165_ _03167_ _03171_ VDD VSS OR2_X1
X_12224_ _03171_ _03008_ _02992_ _03172_ VDD VSS AOI21_X1
X_12225_ _02919_ _03034_ _03017_ _03173_ VDD VSS AND3_X1
X_12226_ _03169_ _03170_ _03172_ _03173_ _03174_ VDD VSS AOI211_X4
X_12227_ _02981_ _02985_ _02986_ _03175_ VDD VSS NOR3_X4
X_12228_ _02573_ _02868_ _03065_ _03176_ VDD VSS AOI21_X1
X_12229_ _03148_ _03177_ VDD VSS INV_X1
X_12230_ _03176_ _03177_ _03057_ _03178_ VDD VSS MUX2_X1
X_12231_ _03017_ _03178_ _03168_ _03179_ VDD VSS NAND3_X2
X_12232_ _02987_ _03014_ _02930_ _03016_ _03180_ VDD VSS NOR4_X4
X_12233_ _02920_ _03034_ _03180_ _03181_ VDD VSS NAND3_X2
X_12234_ _03175_ _03179_ _03181_ _02956_ _03182_ VDD VSS AOI22_X4
X_12235_ _02987_ _03014_ _02930_ _03016_ _03183_ VDD VSS OR4_X2
X_12236_ _03149_ _03183_ _03184_ VDD VSS NOR2_X2
X_12237_ _02956_ _02963_ _02991_ _03185_ VDD VSS OR3_X4
X_12238_ _02997_ _03000_ _03186_ VDD VSS OR2_X1
X_12239_ _03185_ _03186_ _02926_ _02928_ _03187_ VDD VSS OR4_X2
X_12240_ _02963_ _03184_ _03187_ _03188_ VDD VSS AOI21_X2
X_12241_ _02991_ _02997_ _03189_ VDD VSS OR2_X1
X_12242_ _02992_ _02920_ _03034_ _03017_ _03190_ VDD VSS NAND4_X1
X_12243_ _03189_ _03190_ _03000_ _03191_ VDD VSS AOI21_X2
X_12244_ _03174_ _03182_ _03188_ _03191_ _03192_ VDD VSS NAND4_X4
X_12245_ _02770_ _02965_ _02983_ _02727_ _03193_ VDD VSS AOI22_X1
X_12246_ _03013_ _02983_ _03194_ VDD VSS AND2_X1
X_12247_ _02727_ _02965_ _03194_ _03195_ VDD VSS OAI21_X1
X_12248_ _03195_ _03196_ VDD VSS INV_X1
X_12249_ _03193_ _03196_ _02716_ _03197_ VDD VSS MUX2_X1
X_12250_ _03016_ _03141_ _03149_ _03198_ VDD VSS NOR3_X1
X_12251_ _03198_ _03018_ _03035_ _03199_ VDD VSS OAI21_X1
X_12252_ _03197_ _03199_ _03200_ VDD VSS XNOR2_X2
X_12253_ _03126_ _03127_ _03100_ _03201_ VDD VSS OAI21_X4
X_12254_ _03164_ _03192_ _03200_ _03201_ _03202_ VDD VSS OR4_X4
Xclone16 _03192_ _03164_ _03200_ _03201_ net16 VDD VSS OR4_X4
X_12256_ _03111_ _03134_ _03152_ _03202_ _03204_ VDD VSS OAI211_X2
X_12257_ _03020_ _03204_ _03205_ VDD VSS XNOR2_X2
X_12258_ _02775_ _02959_ _03206_ VDD VSS NAND2_X1
X_12259_ _02796_ _02962_ _03207_ VDD VSS NOR2_X2
X_12260_ _03184_ _03187_ _03208_ VDD VSS NAND2_X1
X_12261_ _02796_ _02945_ _03206_ _03207_ _03208_ _02956_ _03209_
+ VDD VSS OAI33_X1
X_12262_ _02957_ _03209_ _03210_ VDD VSS XNOR2_X2
X_12263_ _03152_ _03200_ _03133_ _03211_ VDD VSS NOR3_X4
X_12264_ _03178_ _03180_ _03212_ VDD VSS NAND2_X2
X_12265_ _03185_ _03186_ _02926_ net425 _03213_ VDD VSS NOR4_X4
X_12266_ _02956_ _03212_ _03213_ _03214_ VDD VSS NOR3_X4
X_12267_ _03207_ _03214_ _03215_ VDD VSS XNOR2_X2
X_12268_ _03174_ _03182_ _03215_ _03216_ VDD VSS AND3_X1
X_12269_ net16 _03111_ _03211_ _03216_ _03217_ VDD VSS NAND4_X4
X_12270_ _03210_ _03217_ _03218_ VDD VSS XNOR2_X2
X_12271_ _02956_ _02963_ _03212_ _03213_ _03219_ VDD VSS NOR4_X2
X_12272_ _02991_ _03219_ _03220_ VDD VSS XNOR2_X2
X_12273_ _03174_ _03182_ _03188_ _03221_ VDD VSS NAND3_X1
X_12274_ _03146_ _03151_ _03020_ _03222_ VDD VSS NAND3_X4
X_12275_ _03155_ _03097_ _03223_ VDD VSS AND2_X1
X_12276_ _03036_ _03019_ _03223_ _03224_ VDD VSS NOR3_X1
X_12277_ _03154_ _03105_ _03157_ _03053_ _03051_ _03225_ VDD
+ VSS AOI221_X2
X_12278_ _03135_ _03224_ _03225_ _03226_ VDD VSS OAI21_X1
X_12279_ _03222_ _03200_ _03133_ _03226_ _03227_ VDD VSS OR4_X2
X_12280_ _03191_ _03221_ _03227_ _03228_ VDD VSS NOR3_X1
X_12281_ _03220_ _03228_ _03229_ VDD VSS XOR2_X2
X_12282_ _02995_ _02999_ _03230_ VDD VSS XOR2_X2
X_12283_ _03185_ _02926_ net425 _03183_ _03231_ VDD VSS NOR4_X4
X_12284_ _03000_ _02894_ _02890_ _03232_ VDD VSS AOI21_X1
X_12285_ _03232_ _03141_ _02920_ _03233_ VDD VSS OAI21_X2
X_12286_ _02992_ _03017_ _02926_ _02997_ _03234_ VDD VSS OAI211_X2
X_12287_ _03230_ _03231_ _03233_ _03234_ _03235_ VDD VSS OAI22_X4
X_12288_ _03083_ _03081_ _03236_ VDD VSS AND2_X1
X_12289_ _03083_ _03081_ _03237_ VDD VSS NOR2_X1
X_12290_ _03036_ _03019_ _03236_ _03237_ _03238_ VDD VSS OAI22_X2
X_12291_ _03083_ _03096_ _03239_ VDD VSS NOR2_X1
X_12292_ _03096_ _09104_ VDD VSS INV_X1
X_12293_ _08819_ _09104_ _03240_ VDD VSS NOR2_X1
X_12294_ net424 net41 _03239_ _03240_ _03241_ VDD VSS OAI211_X2
X_12295_ _03238_ _03241_ _03242_ VDD VSS AND2_X2
X_12296_ _03056_ _03242_ _03243_ VDD VSS NAND2_X1
X_12297_ _03174_ _03182_ _03188_ _03244_ VDD VSS AND3_X1
X_12298_ _03244_ _03220_ _03245_ VDD VSS AND2_X1
X_12299_ _03202_ _03211_ _03243_ _03245_ _03246_ VDD VSS NAND4_X2
X_12300_ _03235_ _03246_ _03247_ VDD VSS XOR2_X2
X_12301_ _03205_ _03218_ _03229_ _03247_ _03248_ VDD VSS NAND4_X4
X_12302_ _03119_ _03034_ _02920_ _03249_ VDD VSS AOI21_X2
X_12303_ _03119_ _03250_ VDD VSS INV_X1
X_12304_ _02926_ net425 _03250_ _03251_ VDD VSS NOR3_X2
X_12305_ _03249_ _03251_ _03019_ _03252_ VDD VSS AOI21_X4
X_12306_ _03133_ _03242_ _03056_ _03253_ VDD VSS AOI21_X1
X_12307_ _03253_ net16 _03152_ _03254_ VDD VSS OAI21_X1
X_12308_ _03252_ _03254_ _03255_ VDD VSS XOR2_X2
X_12309_ _02992_ _03017_ _03256_ VDD VSS NAND2_X1
X_12310_ _02997_ _03233_ _03256_ _03257_ VDD VSS OAI21_X1
X_12311_ _03257_ _03258_ VDD VSS INV_X1
X_12312_ net424 net41 _03096_ _03259_ VDD VSS NAND3_X1
X_12313_ _03081_ _03019_ _03036_ _03260_ VDD VSS OAI21_X1
X_12314_ _09108_ _03083_ _03259_ _03260_ _03261_ VDD VSS AND4_X1
X_12315_ _03152_ _03200_ _03133_ _03261_ _03262_ VDD VSS OR4_X2
X_12316_ _09108_ _08819_ _03263_ VDD VSS AND2_X1
X_12317_ _03081_ _03263_ _03264_ VDD VSS NAND2_X1
X_12318_ _03264_ net41 net424 _03265_ VDD VSS AOI21_X2
X_12319_ net424 _03052_ _03096_ _03263_ _03266_ VDD VSS AND4_X1
X_12320_ _02991_ _03235_ _03265_ _03266_ _03267_ VDD VSS NOR4_X2
X_12321_ _03031_ _03238_ _03241_ _03268_ VDD VSS NAND3_X1
X_12322_ _03201_ _03269_ VDD VSS BUF_X4
X_12323_ _03244_ _03267_ _03268_ _03269_ _03270_ VDD VSS OAI211_X2
X_12324_ _03258_ _03262_ _03270_ _03271_ VDD VSS OAI21_X4
X_12325_ _03164_ _03269_ _03272_ VDD VSS NOR2_X1
X_12326_ _03032_ _03043_ _03055_ _03273_ VDD VSS OR3_X2
X_12327_ _03273_ _03242_ _03274_ VDD VSS XNOR2_X2
X_12328_ _03164_ _03269_ _03275_ VDD VSS AND2_X1
X_12329_ _03192_ _03269_ _03276_ VDD VSS OR2_X1
X_12330_ _03259_ _03260_ _03277_ VDD VSS AND2_X2
X_12331_ _03272_ _03274_ _03275_ _03227_ _03276_ _03277_ _03278_
+ VDD VSS OAI33_X1
X_12332_ _03250_ _03149_ _03279_ VDD VSS NOR2_X1
X_12333_ _03279_ _03019_ _03036_ _03280_ VDD VSS OAI21_X1
X_12334_ _03117_ _03280_ _03281_ VDD VSS XNOR2_X2
X_12335_ net41 _03141_ _03149_ _03282_ VDD VSS OR3_X1
X_12336_ _03151_ _03282_ _03283_ VDD VSS NAND2_X1
X_12337_ _03281_ _03283_ _03284_ VDD VSS NOR2_X1
X_12338_ _03271_ _03278_ _03284_ _03285_ VDD VSS NAND3_X2
X_12339_ _09131_ _03286_ VDD VSS INV_X1
X_12340_ _09137_ _03287_ VDD VSS INV_X1
X_12341_ _09143_ _03288_ VDD VSS INV_X1
X_12342_ _09144_ _09147_ _09146_ _03289_ VDD VSS OAI21_X2
X_12343_ _03289_ _03288_ _03290_ VDD VSS NAND2_X2
X_12344_ _09141_ _03290_ _03291_ VDD VSS AND2_X4
X_12345_ _09138_ _03291_ _09140_ _03292_ VDD VSS OAI21_X4
X_12346_ _03287_ _03292_ _03293_ VDD VSS NAND2_X4
X_12347_ _09134_ _03293_ _09135_ _03294_ VDD VSS AOI21_X4
X_12348_ _09132_ _03295_ VDD VSS INV_X1
X_12349_ _03286_ _03295_ _03294_ _03296_ VDD VSS OAI21_X4
X_12350_ _09129_ _03296_ _03297_ VDD VSS AND2_X4
X_12351_ _09128_ _03297_ _03298_ VDD VSS NOR2_X1
X_12352_ _03102_ _03298_ _03299_ VDD VSS NOR2_X1
X_12353_ _03297_ _09128_ _03300_ VDD VSS OR2_X4
X_12354_ _03300_ _03102_ _03301_ VDD VSS NAND2_X2
X_12355_ _02797_ _03301_ _03302_ VDD VSS NAND2_X1
X_12356_ _09109_ _03030_ _03303_ VDD VSS XNOR2_X2
X_12357_ _03299_ _03302_ _03303_ _03304_ VDD VSS MUX2_X1
X_12358_ _08985_ _02374_ _09004_ VDD VSS NOR2_X1
X_12359_ _09006_ _02310_ _09008_ _03305_ VDD VSS OR3_X1
X_12360_ _02390_ _03305_ _03306_ VDD VSS AND2_X1
X_12361_ _09004_ _03306_ _02585_ _09027_ VDD VSS MUX2_X1
X_12362_ _09029_ _02361_ _03307_ VDD VSS XOR2_X1
X_12363_ _09027_ _03307_ _02698_ _09045_ VDD VSS MUX2_X1
X_12364_ _09047_ _09049_ _02555_ _03308_ VDD VSS OR3_X1
X_12365_ _02556_ _03308_ _03309_ VDD VSS AND2_X1
X_12366_ _09045_ _03309_ net18 _09066_ VDD VSS MUX2_X1
X_12367_ _09068_ _02662_ _03310_ VDD VSS NOR2_X1
X_12368_ _02879_ _02881_ _03310_ _03311_ VDD VSS NOR3_X1
X_12369_ _09066_ _03311_ _02889_ _09086_ VDD VSS MUX2_X1
X_12370_ _03073_ _03061_ _03312_ VDD VSS XNOR2_X1
X_12371_ _03112_ _03313_ VDD VSS BUF_X8
X_12372_ _09086_ _03312_ net39 _09107_ VDD VSS MUX2_X2
X_12373_ _03299_ _03302_ _09107_ _03314_ VDD VSS MUX2_X1
X_12374_ _03152_ _03202_ _03315_ VDD VSS NOR2_X4
X_12375_ _03304_ _03314_ _03315_ _03316_ VDD VSS MUX2_X2
X_12376_ _03255_ _03316_ _03285_ _03317_ VDD VSS OR3_X4
X_12377_ _03174_ _03192_ _03269_ _03318_ VDD VSS OAI21_X1
X_12378_ _03227_ _03318_ _03319_ VDD VSS OR2_X2
X_12379_ _03175_ _03179_ _03320_ VDD VSS AND2_X1
X_12380_ _03320_ _03321_ VDD VSS INV_X1
X_12381_ _03036_ _03183_ _03322_ VDD VSS NOR2_X1
X_12382_ _02956_ _03323_ VDD VSS INV_X1
X_12383_ _03212_ _03322_ _03323_ _03324_ VDD VSS OAI21_X1
X_12384_ _03321_ _03324_ net39 _03325_ VDD VSS AOI21_X1
X_12385_ _03323_ _03181_ _03326_ VDD VSS NOR2_X1
X_12386_ _03100_ _03149_ _03327_ VDD VSS NOR2_X1
X_12387_ _03325_ _03326_ _03327_ _03328_ VDD VSS AOI21_X2
X_12388_ _03174_ _03202_ _03211_ _03243_ _03329_ VDD VSS AND4_X1
X_12389_ _03320_ _03184_ _03187_ _03181_ _02956_ _03330_ VDD
+ VSS AOI221_X2
X_12390_ _03330_ _03318_ _03227_ _03331_ VDD VSS OAI21_X2
X_12391_ _03319_ _03328_ _03329_ _03331_ _03332_ VDD VSS OAI22_X4
X_12392_ _03202_ _03111_ _03211_ _03333_ VDD VSS NAND3_X1
X_12393_ _03174_ _03333_ _03334_ VDD VSS XNOR2_X2
X_12394_ _03197_ _03198_ net39 _03335_ VDD VSS AOI21_X1
X_12395_ net39 _03197_ _03198_ _03336_ VDD VSS AND3_X1
X_12396_ _03222_ _03133_ _03226_ _03337_ VDD VSS NOR3_X1
X_12397_ _03222_ _03200_ _03338_ VDD VSS OR2_X1
X_12398_ _03121_ _03164_ _03192_ _03269_ _03339_ VDD VSS NOR4_X1
X_12399_ _03133_ _03226_ _03340_ VDD VSS OR2_X1
X_12400_ _03335_ _03336_ _03337_ _03338_ _03339_ _03340_ _03341_
+ VDD VSS OAI33_X1
X_12401_ _03151_ _03020_ _03342_ VDD VSS NAND2_X1
X_12402_ _03342_ _03056_ _03242_ _03343_ VDD VSS AOI21_X2
X_12403_ _03146_ _03134_ _03343_ _03344_ VDD VSS AOI21_X2
X_12404_ _03146_ _03134_ _03343_ _03345_ VDD VSS AND3_X1
X_12405_ _03121_ _03222_ _03346_ VDD VSS NOR2_X4
X_12406_ _03164_ _03192_ _03200_ _03269_ _03347_ VDD VSS NOR4_X4
X_12407_ _03346_ _03347_ _03348_ VDD VSS NAND2_X4
X_12408_ _03341_ _03344_ _03345_ _03348_ _03349_ VDD VSS AOI211_X2
X_12409_ _03215_ _03332_ _03334_ _03349_ _03350_ VDD VSS NAND4_X4
X_12410_ _03317_ _03248_ _03350_ _03351_ VDD VSS OR3_X4
Xclone30 _03317_ _03248_ _03350_ net30 VDD VSS OR3_X4
X_12412_ _03351_ _03353_ VDD VSS BUF_X8
X_12413_ _03353_ _03354_ VDD VSS BUF_X8
X_12414_ _03295_ _03294_ _03355_ VDD VSS XNOR2_X1
X_12415_ _03354_ _03355_ _03356_ VDD VSS NAND2_X1
X_12416_ _09026_ _02710_ _09051_ VDD VSS NOR2_X1
X_12417_ _09056_ _09053_ _09055_ _03357_ VDD VSS OR3_X1
X_12418_ _02553_ _03357_ _03358_ VDD VSS AND2_X1
X_12419_ _09051_ _03358_ _02642_ _09072_ VDD VSS MUX2_X1
X_12420_ _09074_ _02659_ _03359_ VDD VSS XOR2_X1
X_12421_ _09072_ _03359_ _02889_ _09092_ VDD VSS MUX2_X1
X_12422_ _09099_ _03360_ VDD VSS INV_X1
X_12423_ _02905_ _09102_ _02912_ _03361_ VDD VSS OAI21_X1
X_12424_ _02907_ _03360_ _03361_ _03362_ VDD VSS AOI21_X1
X_12425_ _09096_ _03362_ _03363_ VDD VSS NOR2_X1
X_12426_ _02909_ _03363_ _03364_ VDD VSS XNOR2_X1
X_12427_ _09092_ _03364_ _03313_ _09113_ VDD VSS MUX2_X1
X_12428_ _09115_ _03027_ _03365_ VDD VSS XNOR2_X1
X_12429_ _09113_ _03365_ _03348_ _09130_ VDD VSS MUX2_X1
X_12430_ _03356_ _03354_ _09130_ _03366_ VDD VSS OAI21_X1
X_12431_ _09154_ _03367_ VDD VSS INV_X1
X_12432_ _09160_ _03368_ VDD VSS INV_X1
X_12433_ _09161_ _09163_ _09164_ _03369_ VDD VSS OAI21_X2
X_12434_ _09163_ _09160_ _09166_ _03370_ VDD VSS NOR3_X4
X_12435_ _09167_ _09148_ _09149_ _03371_ VDD VSS OAI21_X2
X_12436_ _03368_ _03369_ _03370_ _03371_ _03372_ VDD VSS AOI22_X2
X_12437_ _03372_ _09158_ _03373_ VDD VSS NAND2_X2
X_12438_ _03373_ _03374_ VDD VSS INV_X4
X_12439_ _09155_ _03374_ _09157_ _03375_ VDD VSS OAI21_X4
X_12440_ _03367_ _03375_ _03376_ VDD VSS NAND2_X4
X_12441_ _09152_ _03376_ _03377_ VDD VSS XNOR2_X1
X_12442_ _03301_ _03378_ VDD VSS INV_X1
X_12443_ _03346_ _03347_ _09107_ _03379_ VDD VSS AND3_X1
X_12444_ _03303_ _03380_ VDD VSS INV_X1
X_12445_ _03380_ _03347_ _03346_ _03381_ VDD VSS AOI21_X4
X_12446_ _02573_ _03378_ _03379_ _03381_ _03382_ VDD VSS OAI22_X2
X_12447_ _03346_ _03347_ _09107_ _03383_ VDD VSS NAND3_X2
X_12448_ _03303_ net16 _03152_ _03384_ VDD VSS OAI21_X2
X_12449_ _03299_ _03383_ _03384_ _03385_ VDD VSS NAND3_X1
X_12450_ _03278_ _03382_ _03385_ _03386_ VDD VSS NAND3_X2
X_12451_ _03255_ _03386_ _03387_ VDD VSS AND2_X2
X_12452_ _03160_ _03163_ _03269_ _03252_ _03388_ VDD VSS AND4_X1
X_12453_ _03122_ _03019_ _03036_ _03389_ VDD VSS OAI21_X1
X_12454_ _03057_ _03389_ _03390_ VDD VSS XNOR2_X1
X_12455_ _03390_ _03252_ _03391_ VDD VSS AND2_X1
X_12456_ _03259_ _03260_ _03392_ VDD VSS NAND2_X1
X_12457_ _03238_ _03241_ _03393_ VDD VSS NAND2_X1
X_12458_ _02797_ _03392_ _03273_ _03393_ _03394_ VDD VSS OAI22_X2
X_12459_ _03032_ _03252_ _03395_ VDD VSS OR2_X1
X_12460_ _03083_ _09104_ _03396_ VDD VSS NOR2_X1
X_12461_ _02797_ _03083_ _03397_ VDD VSS NAND2_X1
X_12462_ _03096_ _03397_ _03398_ VDD VSS NOR2_X1
X_12463_ _03100_ _03396_ _03398_ _03399_ VDD VSS OAI21_X1
X_12464_ _03083_ _03105_ _03400_ VDD VSS NOR2_X1
X_12465_ _03081_ _03397_ _03401_ VDD VSS NOR2_X1
X_12466_ net39 _03400_ _03401_ _03402_ VDD VSS OAI21_X1
X_12467_ _03395_ _03399_ _03402_ _03056_ _03242_ _03403_ VDD
+ VSS AOI221_X2
X_12468_ _03388_ _03391_ _03394_ _03390_ _03403_ _03404_ VDD
+ VSS AOI221_X2
X_12469_ _03304_ _03405_ VDD VSS INV_X1
X_12470_ _03405_ net16 _03152_ _03406_ VDD VSS OAI21_X1
X_12471_ _03277_ _03348_ _03314_ _03404_ _03274_ _03406_ _03407_
+ VDD VSS OAI33_X1
X_12472_ _03407_ _03408_ VDD VSS BUF_X4
X_12473_ _03255_ _03285_ _03409_ VDD VSS OR2_X1
X_12474_ _03409_ _03248_ _03350_ _03410_ VDD VSS OR3_X1
X_12475_ _03410_ _03411_ VDD VSS BUF_X4
X_12476_ _03387_ _03408_ _03411_ _03412_ VDD VSS AOI21_X4
X_12477_ _09151_ _03376_ _09152_ _03413_ VDD VSS AOI21_X4
X_12478_ _03102_ _03413_ _03414_ VDD VSS NOR2_X1
X_12479_ _02797_ _03413_ _08819_ _03415_ VDD VSS OAI21_X4
X_12480_ _02310_ _02309_ _03416_ VDD VSS XNOR2_X1
X_12481_ _09007_ _03416_ _02585_ _09030_ VDD VSS MUX2_X1
X_12482_ _09026_ _09032_ _09025_ _03417_ VDD VSS OR3_X1
X_12483_ _02360_ _03417_ _03418_ VDD VSS AND2_X1
X_12484_ _09030_ _03418_ _02698_ _09048_ VDD VSS MUX2_X1
X_12485_ _09050_ _02554_ _03419_ VDD VSS XOR2_X1
X_12486_ _09048_ _03419_ _02642_ _09069_ VDD VSS MUX2_X1
X_12487_ _09073_ _03420_ VDD VSS INV_X1
X_12488_ _03420_ _02875_ _02819_ _03421_ VDD VSS OAI21_X1
X_12489_ _02655_ _03421_ _03422_ VDD VSS XOR2_X1
X_12490_ _09069_ _03422_ _02889_ _09089_ VDD VSS MUX2_X1
X_12491_ _02911_ _02918_ _03423_ VDD VSS NOR2_X1
X_12492_ _02896_ _03423_ _03424_ VDD VSS XNOR2_X1
X_12493_ _09089_ _03424_ _03313_ _09110_ VDD VSS MUX2_X1
X_12494_ _03100_ _03047_ _03049_ _03425_ VDD VSS NOR3_X1
X_12495_ _03425_ _03100_ _03079_ _03426_ VDD VSS AOI21_X1
X_12496_ _03029_ _03040_ _03426_ _03427_ VDD VSS OAI21_X1
X_12497_ _09112_ _03427_ _03428_ VDD VSS XNOR2_X1
X_12498_ _09110_ _03428_ _03348_ _03429_ VDD VSS MUX2_X1
X_12499_ _03429_ _09127_ VDD VSS CLKBUF_X3
X_12500_ _03414_ _03415_ _09127_ _03430_ VDD VSS MUX2_X1
X_12501_ _09129_ _03296_ _03431_ VDD VSS XOR2_X2
X_12502_ _03414_ _03415_ _03431_ _03432_ VDD VSS MUX2_X1
X_12503_ _03300_ _03379_ _03381_ _03433_ VDD VSS OAI21_X1
X_12504_ _03298_ _03383_ _03384_ _03434_ VDD VSS NAND3_X1
X_12505_ _03102_ _03056_ _03435_ VDD VSS XNOR2_X1
X_12506_ _03435_ net16 _03152_ _03436_ VDD VSS OAI21_X2
X_12507_ _03277_ _03436_ _03437_ VDD VSS XNOR2_X2
X_12508_ _03433_ _03434_ _03437_ _03438_ VDD VSS MUX2_X1
X_12509_ _02797_ _03277_ _03439_ VDD VSS XNOR2_X1
X_12510_ _03436_ _03439_ _03440_ VDD VSS XNOR2_X1
X_12511_ _03300_ _03383_ _03384_ _03441_ VDD VSS AOI21_X1
X_12512_ _03298_ _03379_ _03381_ _03442_ VDD VSS NOR3_X1
X_12513_ _03392_ _03436_ _03443_ VDD VSS XNOR2_X1
X_12514_ _03440_ _03441_ _03442_ _03443_ _03444_ VDD VSS AOI22_X1
X_12515_ _03438_ _03444_ _08819_ _03445_ VDD VSS MUX2_X1
X_12516_ _03351_ _03430_ _03432_ _03445_ _03446_ VDD VSS OAI22_X4
X_12517_ _03348_ _03345_ _03447_ VDD VSS AND2_X1
X_12518_ _03447_ _03344_ _03448_ VDD VSS OR2_X1
X_12519_ _03151_ _03281_ _03282_ _03449_ VDD VSS AND3_X1
X_12520_ _03252_ _03225_ _03224_ _03450_ VDD VSS OAI21_X1
X_12521_ _03133_ _03450_ _03451_ VDD VSS OR2_X1
X_12522_ _03449_ _03284_ _03451_ _03452_ VDD VSS MUX2_X1
X_12523_ _03315_ _03452_ _03453_ VDD VSS OR2_X2
X_12524_ _03205_ _03453_ _03454_ VDD VSS AND2_X1
X_12525_ _03164_ _03269_ _03455_ VDD VSS NAND2_X1
X_12526_ _03164_ _03269_ _03456_ VDD VSS OR2_X1
X_12527_ _03455_ _03315_ _03456_ _03457_ VDD VSS OAI21_X1
X_12528_ _03457_ _03458_ VDD VSS INV_X1
X_12529_ _03277_ _03348_ _03314_ _03459_ VDD VSS NOR3_X1
X_12530_ _03274_ _03406_ _03460_ VDD VSS NOR2_X1
X_12531_ _03459_ _03460_ _03461_ VDD VSS OR2_X2
X_12532_ _03454_ _03386_ _03458_ _03461_ _03462_ VDD VSS OAI211_X2
X_12533_ _03102_ _03300_ _03463_ VDD VSS NOR2_X1
X_12534_ _03379_ _03381_ _03464_ VDD VSS NOR2_X2
X_12535_ _02573_ _03443_ _03464_ _03465_ VDD VSS NOR3_X1
X_12536_ _02797_ _03437_ _03466_ VDD VSS NOR2_X1
X_12537_ _03463_ _03465_ _03466_ _03467_ VDD VSS OAI21_X2
X_12538_ _03383_ _03384_ _03468_ VDD VSS NAND2_X1
X_12539_ _03437_ _03468_ _03469_ VDD VSS NOR2_X2
X_12540_ _03300_ _03437_ _03470_ VDD VSS NAND2_X1
X_12541_ _08819_ _03441_ _03471_ VDD VSS NOR2_X1
X_12542_ _03469_ _03470_ _03471_ _03472_ VDD VSS AOI21_X2
X_12543_ _03448_ _03351_ _03462_ _03467_ _03472_ _03473_ VDD
+ VSS AOI221_X2
X_12544_ _03446_ _03412_ _03473_ _03474_ VDD VSS AND3_X4
Xclone11 _01407_ net11 VDD VSS BUF_X2
X_12546_ _03207_ _03214_ _03476_ VDD VSS XOR2_X2
X_12547_ _03171_ _03172_ _03173_ _03477_ VDD VSS MUX2_X1
X_12548_ _03323_ _03322_ _03478_ VDD VSS NOR2_X1
X_12549_ _03227_ _03339_ _03479_ VDD VSS OR2_X1
X_12550_ _03477_ _03320_ _03478_ _03479_ _03480_ VDD VSS NOR4_X2
X_12551_ _03476_ _03480_ _03481_ VDD VSS XNOR2_X2
X_12552_ _03332_ _03334_ _03349_ _03482_ VDD VSS AND3_X1
X_12553_ _03205_ _03453_ _03408_ _03483_ VDD VSS AND3_X2
X_12554_ _03481_ _03482_ _03483_ _03484_ VDD VSS AOI21_X4
X_12555_ _03218_ _03229_ _03247_ _03485_ VDD VSS AND3_X1
X_12556_ _03271_ _03485_ _03486_ VDD VSS NAND2_X1
X_12557_ _03484_ _03486_ _03487_ VDD VSS NOR2_X4
X_12558_ _03200_ _03340_ _03222_ _03488_ VDD VSS OAI21_X1
X_12559_ _03479_ _03488_ _03489_ VDD VSS AND2_X1
X_12560_ _03447_ _03344_ _03490_ VDD VSS NOR2_X2
X_12561_ _03489_ _03490_ _03483_ _03491_ VDD VSS AOI21_X2
X_12562_ _03349_ _03483_ _03492_ VDD VSS AND2_X1
X_12563_ _03491_ _03492_ _03351_ _03493_ VDD VSS AOI21_X4
X_12564_ _03332_ _03494_ VDD VSS INV_X1
X_12565_ _03334_ _03349_ _03495_ VDD VSS NAND2_X1
X_12566_ _03205_ _03453_ _03408_ _03496_ VDD VSS NAND3_X4
X_12567_ _03495_ _03496_ _03497_ VDD VSS NOR2_X1
X_12568_ _03349_ _03483_ _03498_ VDD VSS NAND2_X1
X_12569_ _03334_ _03499_ VDD VSS INV_X1
X_12570_ _03494_ _03351_ _03497_ _03498_ _03499_ _03500_ VDD
+ VSS AOI221_X4
X_12571_ _03487_ _03493_ _03500_ _03501_ VDD VSS AND3_X4
X_12572_ _03474_ _03501_ _03502_ VDD VSS NAND2_X4
X_12573_ _03366_ _03377_ _03502_ _03503_ VDD VSS MUX2_X2
X_12574_ _03503_ _09186_ VDD VSS INV_X1
X_12575_ _03446_ _03412_ _03473_ _03504_ VDD VSS NAND3_X4
X_12576_ _03487_ _03493_ _03500_ _03505_ VDD VSS NAND3_X4
X_12577_ _03504_ _03505_ _03506_ VDD VSS NOR2_X4
X_12578_ _02751_ net29 _03507_ VDD VSS NAND2_X1
X_12579_ _08981_ _03508_ VDD VSS INV_X1
X_12580_ _02309_ net35 _03509_ VDD VSS NAND2_X1
X_12581_ _03507_ _03508_ _03509_ _09054_ VDD VSS NAND3_X2
X_12582_ _09054_ _02642_ _03510_ VDD VSS NOR2_X4
X_12583_ _03510_ _02642_ _09056_ _09075_ VDD VSS AOI21_X4
X_12584_ _03045_ _02876_ _03511_ VDD VSS NAND2_X1
X_12585_ _09078_ _03511_ _09079_ _03512_ VDD VSS AOI21_X1
X_12586_ _09077_ _03512_ _03513_ VDD VSS XNOR2_X1
X_12587_ _09075_ _03513_ _02889_ _09095_ VDD VSS MUX2_X1
X_12588_ _09102_ _03033_ _02912_ _03514_ VDD VSS AOI21_X1
X_12589_ _02905_ _03515_ VDD VSS INV_X1
X_12590_ _03360_ _03514_ _03515_ _03516_ VDD VSS OAI21_X1
X_12591_ _02907_ _03516_ _03517_ VDD VSS XNOR2_X1
X_12592_ _09095_ _03517_ _03313_ _09116_ VDD VSS MUX2_X1
X_12593_ _09125_ _03426_ _09126_ _03518_ VDD VSS AOI21_X1
X_12594_ _09121_ _09124_ _03519_ VDD VSS NAND2_X1
X_12595_ _03023_ _03518_ _03519_ _03520_ VDD VSS OAI21_X1
X_12596_ _09118_ _03520_ _03521_ VDD VSS XOR2_X1
X_12597_ _09116_ _03521_ _03348_ _09133_ VDD VSS MUX2_X1
X_12598_ _09135_ _03293_ _03522_ VDD VSS XOR2_X1
X_12599_ _09133_ _03522_ _03354_ _09153_ VDD VSS MUX2_X1
X_12600_ _03506_ _09153_ _03523_ VDD VSS NAND2_X1
X_12601_ _03502_ _03524_ VDD VSS BUF_X8
X_12602_ _09148_ _03003_ _03525_ VDD VSS NOR2_X1
X_12603_ _03048_ _03525_ _03526_ VDD VSS NAND2_X1
X_12604_ _02103_ _02796_ _03527_ VDD VSS NOR2_X1
X_12605_ _02757_ _03527_ _03528_ VDD VSS XNOR2_X1
X_12606_ _03054_ _03052_ _03528_ _03529_ VDD VSS NAND3_X2
X_12607_ _02799_ _02353_ _03530_ VDD VSS NAND2_X1
X_12608_ _02112_ _02796_ _03531_ VDD VSS XNOR2_X1
X_12609_ _03530_ _03531_ _03532_ VDD VSS XNOR2_X1
X_12610_ _02745_ _03532_ _01710_ _03533_ VDD VSS AOI21_X2
X_12611_ _03533_ _03019_ _03036_ _03534_ VDD VSS OAI21_X4
X_12612_ _01929_ _03526_ _03529_ _03534_ _03535_ VDD VSS AOI211_X2
X_12613_ _03373_ _03535_ _03370_ _03536_ VDD VSS AOI21_X2
X_12614_ _09157_ _03536_ _03537_ VDD VSS NOR2_X1
X_12615_ _09155_ _03537_ _03538_ VDD VSS XNOR2_X1
X_12616_ _03524_ _03538_ _03539_ VDD VSS NAND2_X1
X_12617_ _03523_ _03539_ _03540_ VDD VSS AND2_X1
X_12618_ _09191_ _03541_ VDD VSS CLKBUF_X2
X_12619_ _03541_ _03542_ VDD VSS INV_X1
X_12620_ _09169_ _09172_ _09170_ _03543_ VDD VSS AOI21_X2
X_12621_ _09178_ _03544_ VDD VSS INV_X1
X_12622_ _09182_ _03545_ VDD VSS BUF_X1
X_12623_ _09181_ _09184_ _03545_ _03546_ VDD VSS AOI21_X1
X_12624_ _09179_ _03547_ VDD VSS INV_X1
X_12625_ _03544_ _03546_ _03547_ _03548_ VDD VSS OAI21_X1
X_12626_ _09176_ _03549_ VDD VSS BUF_X2
X_12627_ _09175_ _03548_ _03549_ _03550_ VDD VSS AOI21_X1
X_12628_ _09170_ _09173_ _03551_ VDD VSS AND2_X1
X_12629_ _03534_ _03529_ _03552_ VDD VSS NAND2_X4
X_12630_ net38 _03552_ _03553_ VDD VSS XNOR2_X2
X_12631_ _03551_ _03553_ _01929_ _03554_ VDD VSS OAI21_X2
X_12632_ _03542_ _03543_ _03550_ _03554_ _03555_ VDD VSS NAND4_X1
X_12633_ _03545_ _09185_ _03556_ VDD VSS NAND2_X1
X_12634_ _03549_ _09179_ _03557_ VDD VSS NAND2_X1
X_12635_ _03542_ _03556_ _03557_ _03554_ _03558_ VDD VSS OR4_X1
X_12636_ _03542_ _03543_ _03556_ _03557_ _03559_ VDD VSS NOR4_X1
X_12637_ _03556_ _03557_ _03560_ VDD VSS NOR2_X2
X_12638_ _03541_ _03560_ _03561_ VDD VSS NOR2_X1
X_12639_ _03541_ _03561_ _03550_ _03562_ VDD VSS MUX2_X1
X_12640_ _03559_ _03562_ _03563_ VDD VSS NOR2_X1
X_12641_ _03555_ _03558_ _03563_ _03564_ VDD VSS NAND3_X1
X_12642_ _09188_ _03565_ VDD VSS BUF_X2
X_12643_ _09190_ _03566_ VDD VSS INV_X1
X_12644_ _09184_ _03567_ VDD VSS INV_X1
X_12645_ _09185_ _03568_ VDD VSS INV_X1
X_12646_ _03567_ _03568_ _03543_ _03569_ VDD VSS OAI21_X2
X_12647_ _09181_ _03569_ _03545_ _03570_ VDD VSS AOI21_X2
X_12648_ _03544_ _03570_ _03547_ _03571_ VDD VSS OAI21_X2
X_12649_ _09175_ _03549_ _03571_ _03572_ VDD VSS AOI21_X2
X_12650_ _03566_ _03572_ _03542_ _03573_ VDD VSS OAI21_X2
X_12651_ _09187_ _03565_ _03573_ _03574_ VDD VSS AOI21_X2
X_12652_ _03565_ _03541_ _03560_ _03551_ _03575_ VDD VSS NAND4_X2
X_12653_ _01929_ _03534_ _03529_ _03576_ VDD VSS AOI21_X1
X_12654_ _03574_ _03575_ _03576_ _03577_ VDD VSS OAI21_X1
X_12655_ _03468_ _09127_ _03578_ VDD VSS AND2_X1
X_12656_ _03431_ _03579_ VDD VSS INV_X1
X_12657_ _03378_ _03463_ _03580_ VDD VSS NOR2_X1
X_12658_ _03464_ _03580_ _03581_ VDD VSS XNOR2_X1
X_12659_ _03579_ _03581_ _03582_ VDD VSS NOR2_X1
X_12660_ _03578_ _03582_ net32 _03583_ VDD VSS MUX2_X1
X_12661_ _09152_ _09155_ _03584_ VDD VSS AND2_X1
X_12662_ _09155_ _09157_ _03585_ VDD VSS NAND2_X1
X_12663_ _03367_ _03585_ _03586_ VDD VSS NAND2_X1
X_12664_ _09151_ _03536_ _03584_ _03586_ _09152_ _03587_ VDD
+ VSS AOI221_X2
X_12665_ _03102_ _03587_ _03588_ VDD VSS XNOR2_X2
X_12666_ _03415_ _03588_ _03589_ VDD VSS NOR2_X1
X_12667_ _03415_ _03590_ VDD VSS INV_X1
X_12668_ _03590_ _03588_ _03591_ VDD VSS NOR2_X1
X_12669_ _03464_ _03580_ _03592_ VDD VSS NAND2_X1
X_12670_ _03464_ _03580_ _03593_ VDD VSS OR2_X1
X_12671_ _03248_ _03317_ _03350_ _03594_ VDD VSS NOR3_X4
X_12672_ _03350_ _03468_ _03595_ VDD VSS OR2_X1
X_12673_ _03248_ _03317_ _03596_ VDD VSS OR2_X2
X_12674_ _03592_ _03593_ _03594_ _03595_ _03596_ _03597_ VDD
+ VSS OAI221_X2
X_12675_ _03597_ _03598_ VDD VSS BUF_X4
X_12676_ _03583_ _03589_ _03591_ _03598_ _03599_ VDD VSS AOI22_X2
X_12677_ _03102_ _03413_ _03600_ VDD VSS OR2_X1
X_12678_ _03600_ _03588_ _03601_ VDD VSS NAND2_X1
X_12679_ _09127_ _03601_ _03602_ VDD VSS NOR2_X1
X_12680_ _03431_ _03601_ _03603_ VDD VSS NOR2_X1
X_12681_ _03602_ _03603_ _03353_ _03604_ VDD VSS MUX2_X1
X_12682_ _09127_ _03605_ VDD VSS INV_X1
X_12683_ _03605_ _03579_ _03353_ _03606_ VDD VSS MUX2_X2
X_12684_ _03604_ _03598_ _03606_ _03607_ VDD VSS AOI21_X2
X_12685_ _03599_ _03607_ _03608_ VDD VSS AND2_X1
X_12686_ _03102_ _03587_ _03609_ VDD VSS OR2_X1
X_12687_ _09127_ _03609_ _03610_ VDD VSS NOR2_X1
X_12688_ _03431_ _03609_ _03611_ VDD VSS NOR2_X1
X_12689_ _03610_ _03611_ net30 _03612_ VDD VSS MUX2_X2
X_12690_ _03604_ _03612_ _03597_ _03613_ VDD VSS MUX2_X1
X_12691_ _03606_ _03588_ _03614_ VDD VSS NOR2_X1
X_12692_ _03415_ _03598_ _03615_ VDD VSS XNOR2_X1
X_12693_ _03613_ _03614_ _03615_ _03616_ VDD VSS AOI21_X1
X_12694_ _02745_ _03575_ _03617_ VDD VSS OR2_X1
X_12695_ _03574_ _03617_ _03618_ VDD VSS NAND2_X1
X_12696_ _03408_ _03248_ _03409_ _03619_ VDD VSS OAI21_X1
X_12697_ _03255_ _03386_ _03408_ _03350_ _03620_ VDD VSS AOI22_X2
X_12698_ _03619_ _03620_ _03621_ VDD VSS NAND2_X2
X_12699_ _03316_ _03437_ _03622_ VDD VSS AND2_X1
X_12700_ _03622_ _03623_ VDD VSS INV_X1
X_12701_ _03459_ _03460_ _03624_ VDD VSS NOR2_X1
X_12702_ _03623_ _03594_ _03624_ _03625_ VDD VSS OAI21_X2
X_12703_ _03621_ _03625_ _03626_ VDD VSS OR2_X1
X_12704_ _03412_ _03625_ _03627_ VDD VSS NAND2_X1
X_12705_ _09127_ _03609_ _03628_ VDD VSS OR2_X1
X_12706_ _03431_ _03609_ _03629_ VDD VSS OR2_X1
X_12707_ _03628_ _03629_ net30 _03630_ VDD VSS MUX2_X2
X_12708_ _02797_ _08819_ _03587_ _03631_ VDD VSS OAI21_X2
X_12709_ _09127_ _03631_ _03632_ VDD VSS NAND2_X1
X_12710_ _03431_ _03631_ _03633_ VDD VSS NAND2_X1
X_12711_ _03632_ _03633_ net30 _03634_ VDD VSS MUX2_X1
X_12712_ _03630_ _03634_ _03597_ _03635_ VDD VSS AND3_X2
X_12713_ _03626_ _03627_ _03635_ _03636_ VDD VSS MUX2_X2
X_12714_ _03577_ _03502_ _03608_ _03618_ _03616_ _03636_ _03637_
+ VDD VSS OAI33_X1
X_12715_ _03625_ _03638_ VDD VSS INV_X1
X_12716_ _03467_ _03472_ _03639_ VDD VSS NAND2_X2
X_12717_ net403 _03639_ _03640_ VDD VSS NAND2_X2
X_12718_ _03638_ _03635_ _03640_ _03641_ VDD VSS AOI21_X4
X_12719_ _03386_ _03458_ _03461_ _03642_ VDD VSS OAI21_X2
X_12720_ _03354_ _03642_ _03643_ VDD VSS NAND2_X1
X_12721_ _03281_ _03451_ _03644_ VDD VSS NAND2_X1
X_12722_ _03644_ _03340_ _03315_ _03645_ VDD VSS OAI21_X2
X_12723_ _03645_ _03408_ _03646_ VDD VSS NAND2_X1
X_12724_ _03645_ _03408_ _03647_ VDD VSS OR2_X1
X_12725_ _03411_ _03646_ _03647_ _03648_ VDD VSS NAND3_X4
X_12726_ _03643_ _03648_ _03649_ VDD VSS NAND2_X1
X_12727_ _03641_ _03649_ _03650_ VDD VSS NOR2_X2
X_12728_ _03645_ _03651_ VDD VSS INV_X1
X_12729_ _03205_ _03651_ _03408_ _03652_ VDD VSS AOI21_X2
X_12730_ _03020_ _03204_ _03653_ VDD VSS XOR2_X1
X_12731_ _03653_ _03645_ _03654_ VDD VSS NOR2_X1
X_12732_ _03408_ _03654_ _03655_ VDD VSS AND2_X1
X_12733_ _03652_ _03655_ _03411_ _03656_ VDD VSS AOI21_X4
X_12734_ _03656_ _03657_ VDD VSS INV_X1
X_12735_ _03645_ _03622_ _03457_ _03658_ VDD VSS OR3_X1
X_12736_ _03658_ _03387_ _03411_ _03461_ _03659_ VDD VSS AOI211_X2
X_12737_ _03630_ _03634_ _03598_ _03659_ _03660_ VDD VSS NAND4_X2
X_12738_ _03657_ _03660_ _03474_ _03501_ _03661_ VDD VSS AOI211_X2
X_12739_ _03630_ _03634_ _03598_ _03659_ _03662_ VDD VSS AND4_X1
X_12740_ _03656_ _03662_ _03663_ VDD VSS NOR2_X2
X_12741_ _03353_ _03462_ _03664_ VDD VSS NAND2_X2
X_12742_ _03412_ _03664_ _03446_ _03639_ _03665_ VDD VSS NAND4_X4
X_12743_ _03448_ _03483_ _03666_ VDD VSS NAND2_X2
X_12744_ _03490_ _03496_ _03667_ VDD VSS NAND2_X2
X_12745_ net30 _03666_ _03667_ _03668_ VDD VSS NAND3_X4
X_12746_ _03487_ _03493_ _03500_ _03668_ _03669_ VDD VSS AND4_X2
X_12747_ _03387_ _03408_ _03411_ _03642_ _03353_ _03670_ VDD
+ VSS AOI221_X2
X_12748_ _03446_ _03639_ _03654_ _03670_ _03671_ VDD VSS AND4_X1
X_12749_ _03594_ _03496_ _03672_ VDD VSS NOR2_X1
X_12750_ _03135_ _03020_ _03272_ _03673_ VDD VSS NAND3_X1
X_12751_ _03315_ _03283_ _03673_ _03674_ VDD VSS NOR3_X1
X_12752_ _03674_ _03673_ _03283_ _03675_ VDD VSS AOI21_X1
X_12753_ _03675_ _03655_ _03411_ _03676_ VDD VSS AOI21_X1
X_12754_ _03672_ _03676_ _03677_ VDD VSS NOR2_X1
X_12755_ _03665_ _03669_ _03671_ _03677_ _03678_ VDD VSS OAI22_X4
X_12756_ _03661_ _03663_ _03678_ _03679_ VDD VSS NOR3_X4
X_12757_ _03679_ _03650_ net376 _03680_ VDD VSS NAND3_X4
X_12758_ _03210_ _03217_ _03681_ VDD VSS XOR2_X2
X_12759_ _03271_ _03218_ _03229_ _03247_ _03682_ VDD VSS AND4_X1
X_12760_ _03350_ _03496_ _03682_ _03683_ VDD VSS NOR3_X4
X_12761_ _03681_ _03683_ _03684_ VDD VSS XNOR2_X2
X_12762_ _03684_ _03685_ VDD VSS INV_X1
X_12763_ _03490_ _03483_ _03686_ VDD VSS XNOR2_X1
X_12764_ _03489_ _03334_ _03687_ VDD VSS NAND2_X1
X_12765_ net32 _03686_ _03687_ _03688_ VDD VSS OAI21_X1
X_12766_ _03478_ _03214_ _03689_ VDD VSS NOR2_X1
X_12767_ _03321_ _03208_ _03329_ _03690_ VDD VSS AND3_X1
X_12768_ _03689_ _03690_ _03691_ VDD VSS XNOR2_X2
X_12769_ _03495_ _03496_ _03692_ VDD VSS OR2_X1
X_12770_ _03691_ _03692_ _03594_ _03693_ VDD VSS OAI21_X1
X_12771_ _03332_ _03334_ _03349_ _03694_ VDD VSS NAND3_X1
X_12772_ _03255_ _03285_ _03476_ _03316_ _03695_ VDD VSS NOR4_X2
X_12773_ _03205_ _03218_ _03229_ _03247_ _03696_ VDD VSS AND4_X1
X_12774_ _03496_ _03694_ _03695_ _03696_ _03697_ VDD VSS AOI211_X2
X_12775_ _03321_ _03208_ _03698_ VDD VSS NAND2_X1
X_12776_ _03319_ _03698_ _03699_ VDD VSS XNOR2_X2
X_12777_ _03484_ _03697_ _03699_ _03683_ _03700_ VDD VSS NOR4_X2
X_12778_ _03688_ _03693_ _03700_ _03701_ VDD VSS AND3_X2
X_12779_ _03701_ _03702_ VDD VSS INV_X1
X_12780_ _03412_ _03664_ _03703_ VDD VSS AND2_X2
X_12781_ _09127_ _03631_ _03704_ VDD VSS AND2_X1
X_12782_ _03431_ _03631_ _03705_ VDD VSS AND2_X1
X_12783_ _03704_ _03705_ net30 _03706_ VDD VSS MUX2_X2
X_12784_ _03102_ _03438_ _03707_ VDD VSS NAND2_X1
X_12785_ _08819_ _03444_ _03708_ VDD VSS NAND2_X1
X_12786_ _03594_ _03469_ _03707_ _03708_ _03709_ VDD VSS AOI22_X4
X_12787_ _03612_ _03706_ _03709_ _03710_ VDD VSS NOR3_X4
X_12788_ _03703_ _03710_ _03505_ net402 _03711_ VDD VSS OAI211_X4
X_12789_ _03685_ _03702_ _03711_ _03712_ VDD VSS OAI21_X4
X_12790_ _03412_ _03664_ _03713_ VDD VSS NAND2_X1
X_12791_ _03612_ _03706_ _03709_ _03714_ VDD VSS OR3_X2
X_12792_ _03713_ _03714_ _03501_ _03474_ _03715_ VDD VSS AOI211_X4
X_12793_ _03684_ _03701_ _03715_ _03716_ VDD VSS NAND3_X4
X_12794_ _03484_ _03683_ _03717_ VDD VSS NOR2_X1
X_12795_ _03484_ _03486_ _03718_ VDD VSS OR2_X1
X_12796_ _03718_ _03717_ _03719_ VDD VSS NAND2_X1
X_12797_ _03493_ _03500_ _03720_ VDD VSS NAND2_X1
X_12798_ _03504_ _03720_ _03721_ VDD VSS NOR2_X1
X_12799_ _03717_ _03719_ _03721_ _03722_ VDD VSS MUX2_X2
X_12800_ _03712_ _03716_ _03722_ _03723_ VDD VSS NAND3_X4
X_12801_ _03350_ _03496_ _03724_ VDD VSS OR2_X1
X_12802_ _03681_ _03724_ _03725_ VDD VSS NAND2_X1
X_12803_ _03688_ _03693_ _03700_ _03725_ _03726_ VDD VSS NAND4_X1
X_12804_ _03681_ _03682_ _03724_ _03726_ _03665_ _03669_ _03727_
+ VDD VSS OAI33_X1
X_12805_ _03229_ _03727_ _03728_ VDD VSS XOR2_X2
X_12806_ _03350_ _03496_ _03729_ VDD VSS NOR2_X2
X_12807_ _03218_ _03229_ _03596_ _03729_ _03730_ VDD VSS NAND4_X2
X_12808_ _03247_ _03730_ _03731_ VDD VSS XOR2_X2
X_12809_ _03229_ _03684_ _03732_ VDD VSS AND2_X1
X_12810_ _03701_ _03732_ _03733_ VDD VSS AND2_X1
X_12811_ _03731_ _03733_ _03715_ _03734_ VDD VSS AOI21_X4
X_12812_ _03701_ _03715_ _03731_ _03732_ _03735_ VDD VSS AND4_X2
X_12813_ _03728_ _03734_ _03735_ _03736_ VDD VSS OAI21_X4
X_12814_ net32 _03497_ _03737_ VDD VSS NAND2_X2
X_12815_ _03499_ _03498_ _03738_ VDD VSS NAND2_X1
X_12816_ _03737_ _03738_ _03739_ VDD VSS AND2_X2
X_12817_ net32 _03666_ _03667_ _03740_ VDD VSS AND3_X2
X_12818_ net377 _03740_ _03741_ VDD VSS NOR2_X4
X_12819_ net402 _03741_ _03714_ _03713_ _03742_ VDD VSS OAI211_X4
X_12820_ _03703_ _03493_ _03740_ _03710_ _03743_ VDD VSS NAND4_X4
X_12821_ _03502_ _03742_ _03743_ _03744_ VDD VSS NAND3_X4
X_12822_ _03737_ _03699_ _03745_ VDD VSS XNOR2_X2
X_12823_ _03697_ _03691_ _03745_ _03746_ VDD VSS OR3_X1
X_12824_ _03746_ _03747_ VDD VSS INV_X2
X_12825_ _03739_ _03744_ _03747_ _03748_ VDD VSS NAND3_X4
X_12826_ _03680_ _03723_ _03736_ _03748_ _03749_ VDD VSS NOR4_X4
X_12827_ _03504_ _03720_ _03750_ VDD VSS OR2_X1
X_12828_ _03724_ _03750_ _03484_ _03751_ VDD VSS OAI21_X2
X_12829_ _03271_ _03485_ _03751_ _03752_ VDD VSS AOI21_X4
X_12830_ _03504_ _03505_ _03599_ _03607_ _03753_ VDD VSS AOI211_X2
X_12831_ _09127_ _03601_ _03754_ VDD VSS OR2_X1
X_12832_ _03600_ _03579_ _03588_ _03755_ VDD VSS NAND3_X1
X_12833_ _03754_ _03755_ _03354_ _03756_ VDD VSS MUX2_X1
X_12834_ _03756_ _03630_ _03598_ _03757_ VDD VSS MUX2_X1
X_12835_ _03606_ _03588_ _03758_ VDD VSS OR2_X1
X_12836_ _03590_ _03598_ _03759_ VDD VSS XNOR2_X1
X_12837_ _03757_ _03758_ _03759_ _03760_ VDD VSS OAI21_X2
X_12838_ net32 _03642_ _03761_ VDD VSS AND2_X2
X_12839_ _03761_ _03625_ _03762_ VDD VSS NOR2_X1
X_12840_ _03643_ _03625_ _03763_ VDD VSS AND2_X1
X_12841_ _03762_ _03763_ _03635_ _03764_ VDD VSS MUX2_X1
X_12842_ _03753_ _03760_ _03764_ _03765_ VDD VSS AOI21_X1
X_12843_ _03656_ _03662_ _03504_ _03505_ _03766_ VDD VSS OAI211_X2
X_12844_ _03657_ _03660_ _03767_ VDD VSS NAND2_X1
X_12845_ _03412_ _03664_ net403 _03639_ _03768_ VDD VSS AND4_X1
X_12846_ _03487_ _03493_ _03500_ _03668_ _03769_ VDD VSS NAND4_X2
X_12847_ _03446_ _03639_ _03654_ _03670_ _03770_ VDD VSS NAND4_X2
X_12848_ _03672_ _03676_ _03771_ VDD VSS OR2_X1
X_12849_ _03768_ _03769_ _03770_ _03771_ _03772_ VDD VSS AOI22_X4
X_12850_ _03315_ _02103_ _03773_ VDD VSS NOR2_X4
X_12851_ _03552_ _03773_ _03774_ VDD VSS XNOR2_X1
X_12852_ _01170_ _03575_ _03774_ _03775_ VDD VSS NOR3_X1
X_12853_ _03766_ _03767_ _03772_ _03775_ _03776_ VDD VSS NAND4_X1
X_12854_ _01150_ _03552_ _03777_ VDD VSS NAND2_X1
X_12855_ _03412_ _03648_ _03778_ VDD VSS AND2_X1
X_12856_ _03621_ _03648_ _03779_ VDD VSS AND2_X1
X_12857_ _03761_ _03612_ _03706_ _03709_ _03780_ VDD VSS NOR4_X4
X_12858_ _03778_ _03779_ _03780_ _03781_ VDD VSS MUX2_X1
X_12859_ _03703_ _03493_ _03740_ _03710_ _03782_ VDD VSS AND4_X1
X_12860_ _03489_ _03668_ _03783_ VDD VSS NAND2_X2
X_12861_ _03474_ _03783_ _03710_ _03703_ _03784_ VDD VSS AOI211_X2
X_12862_ _03777_ _03781_ _03782_ _03784_ _03785_ VDD VSS OAI211_X2
X_12863_ _03765_ _03776_ _03502_ _03785_ _03786_ VDD VSS AOI211_X2
X_12864_ _03752_ _03786_ _03787_ VDD VSS NOR2_X4
X_12865_ _03787_ _03788_ VDD VSS BUF_X8
X_12866_ _03749_ _03788_ _03789_ VDD VSS NAND2_X4
X_12867_ _03540_ _03564_ _03789_ _03790_ VDD VSS MUX2_X2
X_12868_ _03790_ _09200_ VDD VSS INV_X1
X_12869_ _03789_ _03791_ VDD VSS BUF_X8
X_12870_ _09181_ _03792_ VDD VSS INV_X1
X_12871_ _09170_ _09173_ _03793_ VDD VSS NAND2_X1
X_12872_ _03543_ _03793_ _03794_ VDD VSS NAND2_X1
X_12873_ _09184_ _03794_ _09185_ _03795_ VDD VSS AOI21_X1
X_12874_ _03545_ _03796_ VDD VSS INV_X1
X_12875_ _03792_ _03795_ _03796_ _03797_ VDD VSS OAI21_X1
X_12876_ _09178_ _03797_ _09179_ _03798_ VDD VSS AOI21_X2
X_12877_ _03549_ _03798_ _03799_ VDD VSS XOR2_X1
X_12878_ net23 _03799_ _03800_ VDD VSS NAND2_X1
X_12879_ _09079_ _02796_ _09098_ VDD VSS NOR2_X2
X_12880_ _02912_ _02905_ _09102_ _03801_ VDD VSS OR3_X1
X_12881_ _03361_ _03801_ _03802_ VDD VSS AND2_X1
X_12882_ _09098_ _03802_ _03313_ _09119_ VDD VSS MUX2_X1
X_12883_ _09123_ _03803_ VDD VSS INV_X1
X_12884_ _03803_ _03024_ _03804_ VDD VSS NAND2_X1
X_12885_ _03025_ _03804_ _03805_ VDD VSS XNOR2_X1
X_12886_ _09119_ _03805_ _03348_ _09136_ VDD VSS MUX2_X1
X_12887_ _09138_ _09140_ _03291_ _03806_ VDD VSS OR3_X1
X_12888_ _03292_ _03806_ _03807_ VDD VSS AND2_X1
X_12889_ _09136_ _03807_ _03354_ _09156_ VDD VSS MUX2_X1
X_12890_ _09158_ _03372_ _03808_ VDD VSS XOR2_X1
X_12891_ _09156_ _03808_ _03524_ _09174_ VDD VSS MUX2_X1
X_12892_ _03800_ _09174_ net23 _03809_ VDD VSS OAI21_X1
X_12893_ _03809_ _09203_ VDD VSS INV_X1
X_12894_ _09207_ _03810_ VDD VSS INV_X1
X_12895_ _09213_ _03811_ VDD VSS INV_X1
X_12896_ _09196_ _03812_ VDD VSS INV_X1
X_12897_ _09197_ _09198_ _09199_ _03813_ VDD VSS OAI21_X2
X_12898_ _03813_ _03812_ _03814_ VDD VSS NAND2_X2
X_12899_ _09194_ _03814_ _03815_ VDD VSS AND2_X4
X_12900_ _09214_ _09193_ _03815_ _03816_ VDD VSS OAI21_X4
X_12901_ _03816_ _03811_ _03817_ VDD VSS NAND2_X4
X_12902_ _09211_ _03817_ _03818_ VDD VSS AND2_X4
X_12903_ _09208_ _03818_ _09210_ _03819_ VDD VSS OAI21_X4
X_12904_ _03810_ _03819_ _03820_ VDD VSS NAND2_X4
X_12905_ _09205_ _03820_ _03821_ VDD VSS XNOR2_X1
X_12906_ _03821_ _03822_ VDD VSS INV_X1
X_12907_ _03739_ _03823_ VDD VSS INV_X1
X_12908_ _03823_ _03741_ _03715_ _03824_ VDD VSS AOI21_X4
X_12909_ _03739_ _03783_ _03711_ _03825_ VDD VSS NOR3_X4
X_12910_ _03747_ _03824_ _03825_ _03826_ VDD VSS OAI21_X2
X_12911_ _03668_ _03710_ _03703_ _03827_ VDD VSS AOI21_X2
X_12912_ _03678_ _03827_ _03715_ _03668_ _03828_ VDD VSS AOI211_X2
X_12913_ _03332_ _03737_ _03738_ _03829_ VDD VSS NAND3_X1
X_12914_ _03493_ _03829_ _03718_ _03830_ VDD VSS OAI21_X1
X_12915_ _03493_ _03830_ net21 _03831_ VDD VSS MUX2_X2
X_12916_ _03828_ _03831_ _03832_ VDD VSS NAND2_X1
X_12917_ _03826_ _03832_ _03833_ VDD VSS OR2_X2
X_12918_ _03712_ _03716_ _03834_ VDD VSS NAND2_X2
X_12919_ _03598_ _03656_ _03835_ VDD VSS NAND2_X1
X_12920_ _03630_ _03634_ _03659_ _03836_ VDD VSS NAND3_X1
X_12921_ _03415_ _03414_ _03606_ _03837_ VDD VSS MUX2_X2
X_12922_ _03835_ _03836_ _03837_ _03474_ _03501_ _03838_ VDD
+ VSS AOI221_X2
X_12923_ _03411_ _03655_ _03839_ VDD VSS AND2_X1
X_12924_ _03598_ _03652_ _03839_ _03840_ VDD VSS NOR3_X1
X_12925_ _03657_ _03840_ _03837_ _03841_ VDD VSS MUX2_X1
X_12926_ _03663_ _03838_ _03841_ _03842_ VDD VSS NOR3_X2
X_12927_ _03549_ _03565_ _03541_ _03843_ VDD VSS NAND3_X1
X_12928_ _03798_ _03843_ _03844_ VDD VSS NOR2_X1
X_12929_ _03565_ _03845_ VDD VSS INV_X1
X_12930_ _09190_ _09175_ _03541_ _03846_ VDD VSS AOI21_X1
X_12931_ _03845_ _03846_ _03847_ VDD VSS NOR2_X1
X_12932_ _09187_ _03844_ _03847_ _03848_ VDD VSS NOR3_X2
X_12933_ _03606_ _03588_ _03849_ VDD VSS XNOR2_X2
X_12934_ _03643_ _03648_ _03850_ VDD VSS AND2_X1
X_12935_ _03849_ _03850_ net402 _03505_ _03851_ VDD VSS OAI211_X2
X_12936_ _03718_ _03750_ _03608_ _03636_ _03641_ _03851_ _03852_
+ VDD VSS OAI33_X1
X_12937_ _03842_ _03848_ _03852_ _03853_ VDD VSS NAND3_X2
X_12938_ _03834_ _03722_ _03853_ _03854_ VDD VSS NOR3_X1
X_12939_ _03641_ _03649_ _03661_ _03663_ _03855_ VDD VSS NOR4_X2
X_12940_ net376 _03855_ _03856_ VDD VSS AND2_X1
X_12941_ _03834_ _03722_ _03856_ _03857_ VDD VSS AND3_X1
X_12942_ _03854_ _03857_ _03853_ _03858_ VDD VSS AOI21_X1
X_12943_ net376 _03855_ _03859_ VDD VSS NAND2_X1
X_12944_ _03859_ _03833_ _03860_ VDD VSS NOR2_X1
X_12945_ _03789_ _03833_ _03858_ _03860_ _03723_ _03861_ VDD
+ VSS OAI221_X2
X_12946_ _03826_ _03832_ _03862_ VDD VSS NOR2_X1
X_12947_ _03723_ _03853_ _03863_ VDD VSS NOR2_X2
X_12948_ _03728_ _03862_ _03863_ _03864_ VDD VSS AOI21_X2
X_12949_ _03728_ _03862_ _03863_ _03865_ VDD VSS AND3_X1
X_12950_ _03864_ _03865_ _03789_ _03866_ VDD VSS AOI21_X4
X_12951_ _03866_ _03867_ VDD VSS BUF_X4
X_12952_ _03271_ _03868_ VDD VSS INV_X1
X_12953_ _03218_ _03229_ _03247_ _03869_ VDD VSS NAND3_X2
X_12954_ _03729_ _03717_ _03721_ _03870_ VDD VSS AOI21_X2
X_12955_ _03868_ _03869_ _03870_ _03871_ VDD VSS OAI21_X4
X_12956_ _03736_ _03826_ _03832_ _03872_ VDD VSS NOR3_X2
X_12957_ _03871_ _03863_ _03872_ _03873_ VDD VSS AOI21_X4
X_12958_ _03680_ _03723_ _03736_ _03748_ _03874_ VDD VSS OR4_X1
X_12959_ _03874_ _03875_ VDD VSS BUF_X4
X_12960_ _03747_ _03728_ _03824_ _03825_ _03876_ VDD VSS OAI211_X4
X_12961_ _03744_ _03712_ _03716_ _03722_ _03877_ VDD VSS NAND4_X4
X_12962_ _03680_ _03876_ _03877_ _03878_ VDD VSS NOR3_X4
X_12963_ _03734_ _03735_ _03879_ VDD VSS OR2_X2
X_12964_ _03875_ _03787_ _03878_ _03879_ _03880_ VDD VSS OAI22_X4
X_12965_ _03873_ _03880_ _03881_ VDD VSS NOR2_X4
X_12966_ _03737_ _03699_ _03882_ VDD VSS OR2_X1
X_12967_ _03697_ _03882_ _03691_ _03883_ VDD VSS AOI21_X2
X_12968_ _03687_ _03686_ _03884_ VDD VSS NOR2_X1
X_12969_ _03594_ _03884_ _03885_ VDD VSS NOR2_X2
X_12970_ _03699_ _03885_ _03711_ _03886_ VDD VSS NOR3_X2
X_12971_ _03883_ _03886_ _03887_ VDD VSS XOR2_X2
X_12972_ _03577_ _03888_ VDD VSS INV_X2
X_12973_ _03888_ _03753_ _03889_ VDD VSS NAND2_X2
X_12974_ _03574_ _03617_ _03890_ VDD VSS AND2_X2
X_12975_ _03760_ _03890_ _03764_ _03891_ VDD VSS NAND3_X1
X_12976_ _03889_ _03891_ _03892_ VDD VSS NAND2_X1
X_12977_ _03781_ _03782_ _03784_ _03893_ VDD VSS OAI21_X1
X_12978_ net38 _03893_ _03894_ VDD VSS NAND2_X1
X_12979_ _03679_ _03892_ _03894_ _03895_ VDD VSS AND3_X2
X_12980_ _03824_ _03825_ _03896_ VDD VSS NOR2_X2
X_12981_ _03665_ _03669_ _03885_ _03897_ VDD VSS NOR3_X4
X_12982_ _03745_ _03897_ _03898_ VDD VSS XOR2_X2
X_12983_ _03896_ _03898_ _03899_ VDD VSS NOR2_X1
X_12984_ _03887_ _03895_ _03899_ _03900_ VDD VSS AOI21_X4
X_12985_ _03723_ _03736_ _03748_ _03901_ VDD VSS NOR3_X4
X_12986_ _03859_ _03833_ _03901_ _03787_ _03902_ VDD VSS AOI211_X2
X_12987_ _03827_ _03715_ _03668_ _03903_ VDD VSS AOI21_X2
X_12988_ _03678_ _03903_ _03904_ VDD VSS AND2_X1
X_12989_ _03842_ _03848_ _03852_ _03905_ VDD VSS AND3_X2
X_12990_ _03772_ _03904_ _03905_ _03906_ VDD VSS MUX2_X1
X_12991_ _03856_ _03680_ _03903_ _03907_ VDD VSS MUX2_X1
X_12992_ _03749_ _03788_ _03906_ _03907_ _03908_ VDD VSS AOI22_X4
X_12993_ _03900_ _03902_ _03908_ _03909_ VDD VSS NOR3_X4
X_12994_ _03861_ _03867_ _03881_ _03909_ _03910_ VDD VSS AND4_X4
X_12995_ _03745_ _03897_ _03911_ VDD VSS XNOR2_X2
X_12996_ _03896_ _03911_ _03912_ VDD VSS NAND2_X1
X_12997_ _03766_ _03767_ _03772_ _03775_ _03913_ VDD VSS AND4_X1
X_12998_ _03760_ _03764_ _03914_ VDD VSS AND2_X1
X_12999_ _03412_ _03648_ _03915_ VDD VSS NAND2_X1
X_13000_ _03621_ _03648_ _03916_ VDD VSS NAND2_X1
X_13001_ _03915_ _03916_ _03780_ _03917_ VDD VSS MUX2_X1
X_13002_ _03917_ _03743_ _03742_ _01150_ _03552_ _03918_ VDD
+ VSS AOI221_X2
X_13003_ _03913_ _03914_ _03753_ net428 _03918_ _03919_ VDD
+ VSS OAI221_X2
X_13004_ _03871_ _03919_ _03920_ VDD VSS NAND2_X4
X_13005_ _03895_ _03920_ _03875_ _03921_ VDD VSS OAI21_X2
X_13006_ _03912_ _03896_ _03921_ _03922_ VDD VSS MUX2_X1
X_13007_ _03828_ _03905_ _03923_ VDD VSS NAND2_X1
X_13008_ _03923_ _03787_ _03749_ _03924_ VDD VSS AOI21_X4
X_13009_ _03831_ _03924_ _03925_ VDD VSS XNOR2_X2
X_13010_ _03898_ _03922_ _03925_ _03926_ VDD VSS NOR3_X4
X_13011_ net38 _03636_ _03761_ _03927_ VDD VSS OAI21_X1
X_13012_ _03598_ _03837_ _03928_ VDD VSS XNOR2_X2
X_13013_ _03506_ _03928_ _03929_ VDD VSS OR2_X2
X_13014_ _03849_ _03505_ net402 _03930_ VDD VSS OAI21_X1
X_13015_ _03930_ _03608_ net20 _03931_ VDD VSS OAI21_X2
X_13016_ _03848_ _03931_ _03932_ VDD VSS AND2_X1
X_13017_ _03927_ _03929_ _03932_ _03933_ VDD VSS NAND3_X1
X_13018_ _03933_ _03787_ _03749_ _03934_ VDD VSS AOI21_X2
X_13019_ net38 _03648_ _03935_ VDD VSS NAND2_X1
X_13020_ _03621_ _03761_ _03640_ _03936_ VDD VSS NOR3_X1
X_13021_ _03648_ _03935_ _03936_ _03937_ VDD VSS MUX2_X2
X_13022_ _03934_ _03937_ _03938_ VDD VSS XOR2_X2
X_13023_ _03412_ _03780_ _03939_ VDD VSS NOR2_X1
X_13024_ _03621_ net21 _03501_ _03940_ VDD VSS AOI21_X1
X_13025_ _03939_ _03940_ _03780_ _03941_ VDD VSS AOI21_X2
X_13026_ net38 _03608_ _03616_ _03636_ _03942_ VDD VSS OAI22_X1
X_13027_ _03650_ _03679_ _03942_ _03943_ VDD VSS NAND3_X1
X_13028_ _03892_ _03941_ _03943_ _03944_ VDD VSS NAND3_X2
X_13029_ _03621_ _03940_ _03780_ _03945_ VDD VSS MUX2_X1
X_13030_ _03945_ _03891_ _03889_ _03946_ VDD VSS AOI21_X2
X_13031_ _03946_ _03877_ _03876_ _03947_ VDD VSS OAI21_X2
X_13032_ _03946_ _03786_ _03752_ _03948_ VDD VSS OAI21_X2
X_13033_ _03734_ _03735_ _03945_ _03949_ VDD VSS OR3_X1
X_13034_ _03941_ _03949_ _03892_ _03950_ VDD VSS MUX2_X1
X_13035_ _03944_ _03947_ _03948_ _03950_ _03951_ VDD VSS NAND4_X4
X_13036_ _03679_ _03901_ _03788_ _03952_ VDD VSS NAND3_X4
X_13037_ _03637_ _03650_ _03766_ _03767_ _03953_ VDD VSS AOI22_X1
X_13038_ _03856_ _03953_ _03954_ VDD VSS OR2_X2
X_13039_ _03951_ _03952_ _03954_ _03955_ VDD VSS AOI21_X4
X_13040_ _03714_ _03501_ net21 _03956_ VDD VSS AOI21_X1
X_13041_ _03641_ _03956_ _03957_ VDD VSS NOR2_X2
X_13042_ _03761_ net428 _03958_ VDD VSS NOR2_X1
X_13043_ _03958_ _03761_ _03640_ _03959_ VDD VSS MUX2_X2
X_13044_ _03888_ _03753_ _03760_ _03890_ _03960_ VDD VSS AOI22_X4
X_13045_ _03957_ _03959_ _03960_ _03961_ VDD VSS NOR3_X1
X_13046_ net428 _03764_ _03962_ VDD VSS OR2_X1
X_13047_ _03962_ _03960_ _03963_ VDD VSS AND2_X1
X_13048_ _03961_ _03963_ _03749_ _03788_ _03964_ VDD VSS AOI211_X2
X_13049_ _09204_ _03820_ _09205_ _03965_ VDD VSS AOI21_X4
X_13050_ _03965_ _03966_ VDD VSS INV_X4
X_13051_ _09201_ _03966_ _09202_ _03967_ VDD VSS AOI21_X4
X_13052_ _09175_ _03560_ _03794_ _03548_ _03549_ _03968_ VDD
+ VSS AOI221_X2
X_13053_ _03566_ _03968_ _03542_ _03969_ VDD VSS OAI21_X2
X_13054_ _03565_ _03969_ _03970_ VDD VSS XNOR2_X2
X_13055_ _03967_ _03970_ _03971_ VDD VSS NAND2_X1
X_13056_ _03888_ _03890_ net20 _03972_ VDD VSS MUX2_X1
X_13057_ _03931_ _03972_ _03973_ VDD VSS XNOR2_X2
X_13058_ _03971_ _03973_ _03974_ VDD VSS NOR2_X2
X_13059_ _03967_ _03849_ _03928_ net20 _03975_ VDD VSS AND4_X4
X_13060_ _09201_ _03976_ VDD VSS INV_X1
X_13061_ _09202_ _03977_ VDD VSS INV_X1
X_13062_ _03976_ _03977_ _03965_ _03978_ VDD VSS OAI21_X4
X_13063_ net20 _03608_ _03978_ _03979_ VDD VSS NOR3_X2
X_13064_ _03845_ _03969_ _03980_ VDD VSS XNOR2_X2
X_13065_ _03890_ _03980_ _03981_ VDD VSS NOR2_X1
X_13066_ _03888_ _03980_ _03982_ VDD VSS NOR2_X1
X_13067_ _03981_ _03982_ _03506_ _03983_ VDD VSS MUX2_X1
X_13068_ _03734_ _03735_ _03975_ _03979_ _03983_ _03503_ _03984_
+ VDD VSS OAI222_X2
X_13069_ _03877_ _03876_ _03984_ _03680_ _03985_ VDD VSS NOR4_X4
X_13070_ _03929_ _03974_ _03985_ _03787_ _03986_ VDD VSS AOI22_X4
X_13071_ _03964_ _03986_ _03987_ VDD VSS NOR2_X4
X_13072_ _03938_ _03955_ _03987_ _03988_ VDD VSS AND3_X4
X_13073_ _03988_ _03989_ VDD VSS BUF_X8
X_13074_ _03989_ _03926_ _03910_ _03990_ VDD VSS NAND3_X4
X_13075_ _03990_ _03991_ VDD VSS BUF_X8
X_13076_ _09203_ _03822_ net14 _09227_ VDD VSS MUX2_X2
X_13077_ _03048_ _02816_ _09101_ VDD VSS XNOR2_X2
X_13078_ _02912_ _03079_ _03992_ VDD VSS XNOR2_X1
X_13079_ _09101_ _03992_ _03313_ _09122_ VDD VSS MUX2_X1
X_13080_ _09124_ _03518_ _03993_ VDD VSS XNOR2_X1
X_13081_ _09122_ _03993_ _03348_ _09139_ VDD VSS MUX2_X1
X_13082_ _09141_ _03290_ _03994_ VDD VSS XOR2_X1
X_13083_ _09139_ _03994_ _03354_ _09159_ VDD VSS MUX2_X1
X_13084_ _09149_ _09148_ _03995_ VDD VSS NOR2_X1
X_13085_ _03995_ _03535_ _03996_ VDD VSS NOR2_X1
X_13086_ _09166_ _03996_ _09167_ _03997_ VDD VSS AOI21_X1
X_13087_ _03997_ _03998_ VDD VSS INV_X1
X_13088_ _09163_ _03998_ _09164_ _03999_ VDD VSS AOI21_X1
X_13089_ _09161_ _03999_ _04000_ VDD VSS XNOR2_X1
X_13090_ _09159_ _04000_ _03524_ _09177_ VDD VSS MUX2_X1
X_13091_ _03570_ _03556_ _03554_ _04001_ VDD VSS OAI21_X1
X_13092_ _03547_ _04001_ _04002_ VDD VSS XNOR2_X1
X_13093_ _09177_ _04002_ _03791_ _09206_ VDD VSS MUX2_X1
X_13094_ _09208_ _09210_ _03818_ _04003_ VDD VSS OR3_X1
X_13095_ _03819_ _04003_ _04004_ VDD VSS AND2_X1
X_13096_ _09206_ _04004_ _03991_ _09230_ VDD VSS MUX2_X1
X_13097_ _09232_ _04005_ VDD VSS BUF_X2
X_13098_ _09237_ _04006_ VDD VSS INV_X1
X_13099_ _09219_ _04007_ VDD VSS INV_X1
X_13100_ _09226_ _04008_ VDD VSS BUF_X1
X_13101_ _09225_ _02103_ _04008_ _04009_ VDD VSS AOI21_X1
X_13102_ _04009_ _04010_ VDD VSS INV_X1
X_13103_ _09222_ _04010_ _09223_ _04011_ VDD VSS AOI21_X2
X_13104_ _09220_ _04012_ VDD VSS INV_X1
X_13105_ _04007_ _04011_ _04012_ _04013_ VDD VSS OAI21_X2
X_13106_ _09217_ _04014_ VDD VSS BUF_X1
X_13107_ _09216_ _04013_ _04014_ _04015_ VDD VSS AOI21_X2
X_13108_ _09238_ _04016_ VDD VSS INV_X1
X_13109_ _04006_ _04015_ _04016_ _04017_ VDD VSS OAI21_X2
X_13110_ _09235_ _04018_ VDD VSS BUF_X1
X_13111_ _09234_ _04018_ _04017_ _04019_ VDD VSS AOI21_X2
X_13112_ _04005_ _04019_ _04020_ VDD VSS XNOR2_X1
X_13113_ _03896_ _04021_ VDD VSS INV_X1
X_13114_ _04021_ _03898_ _04022_ VDD VSS NOR2_X1
X_13115_ _04022_ _04021_ _03921_ _04023_ VDD VSS MUX2_X2
X_13116_ _03831_ _03924_ _04024_ VDD VSS XOR2_X2
X_13117_ _03911_ _04023_ _04024_ _04025_ VDD VSS NAND3_X4
X_13118_ _03861_ _03866_ _03881_ _03909_ _04026_ VDD VSS NAND4_X4
X_13119_ _03989_ _04025_ _04026_ _04027_ VDD VSS OAI21_X4
X_13120_ _03938_ _03955_ _03987_ _04028_ VDD VSS NAND3_X4
X_13121_ _03772_ net5 _03905_ _04029_ VDD VSS NAND3_X1
X_13122_ _04029_ _03905_ _03772_ _04030_ VDD VSS OAI21_X2
X_13123_ _04028_ _04030_ _04031_ VDD VSS NAND2_X2
X_13124_ _03934_ _03937_ _04032_ VDD VSS XNOR2_X2
X_13125_ _03951_ _03964_ _03986_ _04033_ VDD VSS OR3_X2
X_13126_ _04032_ _04033_ _04034_ VDD VSS NOR2_X4
X_13127_ _03952_ _03954_ _04035_ VDD VSS NAND2_X4
X_13128_ _04027_ _04031_ _04034_ _04035_ _04036_ VDD VSS OAI211_X4
X_13129_ _03911_ _04023_ _04024_ _04035_ _04037_ VDD VSS NAND4_X2
X_13130_ _04034_ _04037_ _04026_ _04038_ VDD VSS OAI21_X4
X_13131_ _03944_ _03947_ _04039_ VDD VSS AND2_X1
X_13132_ _03948_ _03950_ _04040_ VDD VSS AND2_X1
X_13133_ _03957_ _03959_ _03960_ _04041_ VDD VSS OR3_X1
X_13134_ _03962_ _03960_ _04042_ VDD VSS NAND2_X1
X_13135_ _04041_ _04042_ _03875_ _03920_ _04043_ VDD VSS OAI211_X2
X_13136_ net428 _03928_ _04044_ VDD VSS NOR2_X1
X_13137_ _03503_ _03967_ _04045_ VDD VSS NAND2_X1
X_13138_ _04044_ _03971_ _03973_ _04045_ _03875_ _03920_ _04046_
+ VDD VSS OAI33_X1
X_13139_ _04039_ _04040_ _04043_ net375 _04047_ VDD VSS AOI22_X4
X_13140_ _03641_ _03956_ _04048_ VDD VSS OR2_X1
X_13141_ _04048_ _03960_ _04049_ VDD VSS OR2_X2
X_13142_ _04049_ _03919_ _03871_ _04050_ VDD VSS AOI21_X2
X_13143_ _03744_ _03712_ _03716_ _03722_ _04051_ VDD VSS AND4_X1
X_13144_ _03229_ _03727_ _04052_ VDD VSS XNOR2_X1
X_13145_ _03500_ _03783_ _03711_ _04053_ VDD VSS OAI21_X1
X_13146_ _03739_ _03745_ _04054_ VDD VSS NOR2_X1
X_13147_ _03883_ _03741_ _03715_ _04054_ _04055_ VDD VSS NAND4_X1
X_13148_ _04052_ _04053_ _04055_ _04056_ VDD VSS AOI21_X1
X_13149_ _04049_ _04051_ _04056_ _04057_ VDD VSS AOI21_X2
X_13150_ _03734_ _03735_ _04048_ _03960_ _04058_ VDD VSS OR4_X1
X_13151_ _04048_ _03960_ _04059_ VDD VSS NAND2_X1
X_13152_ net376 _03650_ _03679_ _04060_ VDD VSS AND3_X1
X_13153_ _04058_ _04059_ _04060_ _04049_ _04061_ VDD VSS OAI211_X2
X_13154_ _04050_ _04057_ _04061_ _04062_ VDD VSS NOR3_X2
X_13155_ net375 _04062_ _04063_ VDD VSS NAND2_X2
X_13156_ _03957_ _03929_ _03932_ _04064_ VDD VSS NAND3_X2
X_13157_ _04064_ _03788_ net1 _04065_ VDD VSS AOI21_X4
X_13158_ _03959_ _04065_ _04066_ VDD VSS XOR2_X2
X_13159_ _04047_ _04063_ _04066_ _04067_ VDD VSS AOI21_X4
X_13160_ _04032_ _04033_ _04068_ VDD VSS NAND2_X2
X_13161_ _04038_ _04067_ _04068_ _04069_ VDD VSS NAND3_X4
X_13162_ _04025_ _04028_ _04026_ _04070_ VDD VSS NOR3_X4
X_13163_ _03503_ _03967_ _04071_ VDD VSS NOR2_X1
X_13164_ net5 _04071_ _04072_ VDD VSS NOR2_X1
X_13165_ _04044_ _03932_ _04073_ VDD VSS XNOR2_X2
X_13166_ _04073_ _03970_ _03967_ _04074_ VDD VSS AOI21_X2
X_13167_ _03973_ _04074_ _04075_ VDD VSS NOR2_X1
X_13168_ _03978_ _03980_ _04076_ VDD VSS NAND2_X1
X_13169_ _04072_ _04075_ _04076_ _04077_ VDD VSS AOI21_X2
X_13170_ net5 _03973_ _04074_ _04078_ VDD VSS OAI21_X1
X_13171_ _03986_ _04062_ _04078_ _04079_ VDD VSS NAND3_X2
X_13172_ _03503_ _03875_ _03920_ _04080_ VDD VSS NOR3_X4
X_13173_ _03970_ _03788_ net1 _04081_ VDD VSS AOI21_X4
X_13174_ _03978_ _04080_ _04081_ _04082_ VDD VSS NOR3_X4
X_13175_ _04077_ _04079_ _04082_ _04083_ VDD VSS NOR3_X2
X_13176_ _04070_ _04083_ _04084_ VDD VSS NOR2_X4
X_13177_ _09228_ _04085_ VDD VSS INV_X1
X_13178_ _09229_ _04086_ VDD VSS CLKBUF_X2
X_13179_ _04086_ _04087_ VDD VSS INV_X1
X_13180_ _04019_ _04088_ VDD VSS INV_X2
X_13181_ _09231_ _04088_ _04005_ _04089_ VDD VSS AOI21_X4
X_13182_ _04085_ _04087_ _04089_ _04090_ VDD VSS OAI21_X4
X_13183_ _04090_ _04091_ VDD VSS INV_X4
X_13184_ _03977_ _03965_ _04092_ VDD VSS XNOR2_X2
X_13185_ _04091_ _04092_ _04093_ VDD VSS NAND2_X1
X_13186_ _03790_ _04091_ _04094_ VDD VSS NAND2_X1
X_13187_ _04093_ _04094_ _04070_ _04095_ VDD VSS MUX2_X2
X_13188_ _04095_ _04036_ _04084_ _04069_ _04096_ VDD VSS OR4_X4
X_13189_ _03789_ _03862_ _03905_ _04097_ VDD VSS AND3_X1
X_13190_ _03722_ _04097_ _04098_ VDD VSS XNOR2_X2
X_13191_ _03911_ _03909_ _04023_ _04024_ _04099_ VDD VSS AND4_X2
X_13192_ _03989_ _04098_ _04099_ _04100_ VDD VSS NAND3_X2
X_13193_ _03722_ _04097_ _04101_ VDD VSS XOR2_X2
X_13194_ _03989_ _04101_ _04099_ _04102_ VDD VSS AND3_X1
X_13195_ _04102_ _04103_ VDD VSS BUF_X4
X_13196_ _03990_ _04100_ _04103_ _04098_ _04104_ VDD VSS OAI211_X4
X_13197_ _03861_ _03867_ _03881_ _04105_ VDD VSS NAND3_X1
X_13198_ _03900_ _03902_ _04106_ VDD VSS NOR2_X1
X_13199_ _03959_ _04065_ _04107_ VDD VSS XNOR2_X2
X_13200_ _04050_ _04057_ _04061_ _04108_ VDD VSS OR3_X2
X_13201_ _03908_ _03986_ _04108_ _04109_ VDD VSS NOR3_X2
X_13202_ _03938_ _03955_ _04107_ _04109_ _04110_ VDD VSS AND4_X2
X_13203_ _04105_ _04106_ _03926_ _04110_ _04111_ VDD VSS NAND4_X2
X_13204_ _03938_ _03955_ _04107_ _04109_ _04112_ VDD VSS NAND4_X4
X_13205_ _03900_ _03902_ _04025_ _04112_ _04113_ VDD VSS OAI22_X4
X_13206_ _04024_ _04110_ _04025_ _04026_ _04114_ VDD VSS OAI211_X2
X_13207_ _03911_ _03924_ _03831_ _04115_ VDD VSS AOI21_X1
X_13208_ _03922_ _04115_ _04116_ VDD VSS OR2_X1
X_13209_ _04116_ _04112_ _03925_ _04117_ VDD VSS AOI21_X1
X_13210_ _04111_ _04113_ _04114_ _04117_ _04118_ VDD VSS AND4_X4
X_13211_ _03722_ _03856_ _04119_ VDD VSS NAND2_X1
X_13212_ _03833_ _04119_ net1 _03788_ _04120_ VDD VSS AOI211_X2
X_13213_ _03834_ _04120_ _04121_ VDD VSS XOR2_X2
X_13214_ _03867_ _03881_ _04121_ _04122_ VDD VSS AND3_X1
X_13215_ _03989_ _04101_ _04099_ _04122_ _04123_ VDD VSS NAND4_X2
X_13216_ _03834_ _04120_ _04124_ VDD VSS XNOR2_X2
X_13217_ _03867_ _03881_ _04124_ _04125_ VDD VSS NAND3_X1
X_13218_ _03990_ _04123_ _04125_ _04103_ _04126_ VDD VSS OAI211_X4
X_13219_ _04110_ _04025_ _04026_ _04127_ VDD VSS OAI21_X1
X_13220_ _03680_ _03903_ _04128_ VDD VSS XNOR2_X1
X_13221_ _04128_ _03788_ _03901_ _04129_ VDD VSS AOI21_X2
X_13222_ _04129_ _04030_ _04028_ _04130_ VDD VSS OAI21_X1
X_13223_ _04127_ _04130_ _04131_ VDD VSS AND2_X1
X_13224_ _04131_ _04132_ VDD VSS BUF_X4
X_13225_ _04104_ _04118_ _04126_ _04132_ _04133_ VDD VSS NAND4_X4
X_13226_ _04096_ _04133_ _04134_ VDD VSS OR2_X4
X_13227_ _04134_ _04135_ VDD VSS BUF_X8
X_13228_ _09230_ _04020_ net40 _09259_ VDD VSS MUX2_X1
X_13229_ _09255_ _04136_ VDD VSS INV_X1
X_13230_ _09257_ _04137_ VDD VSS INV_X1
X_13231_ _09251_ _04138_ VDD VSS INV_X1
X_13232_ _09245_ _04139_ VDD VSS INV_X1
X_13233_ _09246_ _09240_ _09239_ _04140_ VDD VSS OAI21_X2
X_13234_ _04140_ _04139_ _04141_ VDD VSS NAND2_X2
X_13235_ _09242_ _09243_ _04141_ _04142_ VDD VSS AOI21_X4
X_13236_ _09252_ _04143_ VDD VSS INV_X1
X_13237_ _04138_ _04142_ _04143_ _04144_ VDD VSS OAI21_X4
X_13238_ _09248_ _09249_ _04144_ _04145_ VDD VSS AOI21_X4
X_13239_ _09258_ _04146_ VDD VSS INV_X1
X_13240_ _04137_ _04145_ _04146_ _04147_ VDD VSS OAI21_X4
X_13241_ _04136_ _04147_ _04148_ VDD VSS XNOR2_X1
X_13242_ _09126_ _03315_ _09142_ VDD VSS NOR2_X1
X_13243_ _09147_ _09144_ _09146_ _04149_ VDD VSS OR3_X1
X_13244_ _03289_ _04149_ _04150_ VDD VSS AND2_X1
X_13245_ _09142_ _04150_ _03354_ _09162_ VDD VSS MUX2_X1
X_13246_ _09166_ _04151_ VDD VSS INV_X1
X_13247_ _04151_ _03371_ _04152_ VDD VSS NAND2_X1
X_13248_ _09164_ _04152_ _04153_ VDD VSS XOR2_X1
X_13249_ _09162_ _04153_ _03524_ _09180_ VDD VSS MUX2_X1
X_13250_ _03545_ _03795_ _04154_ VDD VSS XNOR2_X1
X_13251_ _09180_ _04154_ _03791_ _09209_ VDD VSS MUX2_X1
X_13252_ _09211_ _03817_ _04155_ VDD VSS XOR2_X1
X_13253_ _09209_ _04155_ _03991_ _09233_ VDD VSS MUX2_X1
X_13254_ _09216_ _04156_ VDD VSS INV_X1
X_13255_ _09222_ _04157_ VDD VSS INV_X1
X_13256_ _09223_ _09225_ _04008_ _04158_ VDD VSS OAI21_X1
X_13257_ _04012_ _04157_ _04158_ _04159_ VDD VSS AOI21_X1
X_13258_ _09219_ _04159_ _04160_ VDD VSS NOR2_X1
X_13259_ _04014_ _04161_ VDD VSS INV_X1
X_13260_ _04156_ _04160_ _04161_ _04162_ VDD VSS OAI21_X1
X_13261_ _09237_ _04162_ _09238_ _04163_ VDD VSS AOI21_X2
X_13262_ _04018_ _04163_ _04164_ VDD VSS XNOR2_X1
X_13263_ _09233_ _04164_ net40 _09253_ VDD VSS MUX2_X1
X_13264_ _04070_ _04165_ VDD VSS BUF_X8
X_13265_ _04063_ _04165_ _04166_ VDD VSS NOR2_X1
X_13266_ _03986_ _04108_ _04167_ VDD VSS NAND2_X1
X_13267_ _09186_ net1 _03788_ _04168_ VDD VSS NAND3_X1
X_13268_ _03980_ _03920_ _03875_ _04169_ VDD VSS OAI21_X1
X_13269_ _03978_ _04168_ _04169_ _04170_ VDD VSS AOI21_X2
X_13270_ net6 _04080_ _04081_ _04171_ VDD VSS NOR3_X2
X_13271_ _04091_ _04092_ _04170_ _04171_ _04172_ VDD VSS OAI211_X2
X_13272_ _04080_ _04081_ _04173_ VDD VSS NOR2_X2
X_13273_ _03540_ _09189_ VDD VSS INV_X1
X_13274_ _09202_ _03965_ _04174_ VDD VSS XNOR2_X1
X_13275_ net6 _04174_ _04175_ VDD VSS NOR2_X1
X_13276_ _04175_ _04176_ VDD VSS INV_X1
X_13277_ _09189_ _04176_ _04177_ VDD VSS NAND2_X1
X_13278_ _03555_ _03558_ _03563_ _04176_ _04178_ VDD VSS NAND4_X1
X_13279_ _04177_ _04178_ net5 _04179_ VDD VSS MUX2_X1
X_13280_ _04091_ _04173_ _04179_ _04180_ VDD VSS NAND3_X1
X_13281_ _04172_ _04180_ _03990_ _04181_ VDD VSS OAI21_X2
X_13282_ _04167_ _04181_ _04078_ _04182_ VDD VSS AOI21_X1
X_13283_ _04166_ _04182_ _04183_ VDD VSS OR2_X1
X_13284_ _04036_ _04069_ _04084_ _04095_ _04184_ VDD VSS NOR4_X4
X_13285_ _04184_ _04185_ VDD VSS BUF_X4
X_13286_ _04104_ _04118_ _04186_ VDD VSS AND2_X2
X_13287_ _04126_ _04132_ _04187_ VDD VSS AND2_X2
X_13288_ _04185_ _04186_ _04187_ _04188_ VDD VSS NAND3_X2
X_13289_ _04092_ _04170_ _04171_ _04189_ VDD VSS OAI21_X1
X_13290_ _04090_ _04189_ _04190_ VDD VSS NOR2_X1
X_13291_ _04180_ _04191_ VDD VSS INV_X1
X_13292_ _04190_ _04191_ net408 _04192_ VDD VSS AOI21_X2
X_13293_ net14 _04192_ _04193_ VDD VSS NOR2_X1
X_13294_ _04172_ _04180_ _04194_ VDD VSS AND2_X1
X_13295_ _04079_ _04172_ _04195_ VDD VSS OR2_X1
X_13296_ _04194_ _04195_ _03990_ _04196_ VDD VSS AOI21_X2
X_13297_ _04183_ _04188_ _04193_ _04134_ _04196_ _04197_ VDD
+ VSS AOI221_X2
X_13298_ _03974_ _04073_ _04198_ VDD VSS NOR2_X2
X_13299_ net426 net14 _04198_ net23 _04199_ VDD VSS AOI22_X4
X_13300_ _04185_ _04186_ _04187_ _04200_ VDD VSS AND3_X2
X_13301_ net5 _03972_ _04201_ VDD VSS NAND2_X1
X_13302_ _03931_ _04201_ _04202_ VDD VSS XOR2_X2
X_13303_ _03978_ _04080_ _04081_ _04203_ VDD VSS OAI21_X1
X_13304_ net6 _04173_ _04204_ VDD VSS NAND2_X1
X_13305_ _04203_ _04204_ _04165_ _04205_ VDD VSS OAI21_X2
X_13306_ _04202_ _04205_ _04206_ VDD VSS OR2_X1
X_13307_ _04086_ _04005_ _04018_ _04207_ VDD VSS NAND3_X1
X_13308_ _04163_ _04207_ _04208_ VDD VSS NOR2_X2
X_13309_ _09231_ _09234_ _04005_ _04209_ VDD VSS AOI21_X1
X_13310_ _04209_ _04210_ VDD VSS INV_X1
X_13311_ _09228_ _04086_ _04210_ _04211_ VDD VSS AOI21_X2
X_13312_ _04211_ _04212_ VDD VSS INV_X1
X_13313_ _04208_ _04212_ _04213_ VDD VSS NOR2_X1
X_13314_ _04092_ _04213_ _04214_ VDD VSS NAND2_X1
X_13315_ _03790_ _04213_ _04215_ VDD VSS NAND2_X1
X_13316_ _04214_ _04215_ _04070_ _04216_ VDD VSS MUX2_X2
X_13317_ _04200_ _04206_ _04216_ _04217_ VDD VSS NOR3_X4
X_13318_ _04199_ _04217_ _04218_ VDD VSS XOR2_X2
X_13319_ _04026_ _04025_ _04028_ _04215_ _04219_ VDD VSS OR4_X2
X_13320_ _04219_ _04214_ _04070_ _04220_ VDD VSS OAI21_X4
X_13321_ net8 _04173_ _04221_ VDD VSS NAND2_X1
X_13322_ _04202_ _04220_ _04192_ _04221_ _03978_ _04222_ VDD
+ VSS OAI221_X2
X_13323_ _04202_ _04223_ VDD VSS INV_X1
X_13324_ net6 net8 _04173_ _04223_ _04224_ VDD VSS NAND4_X1
X_13325_ net408 _04204_ _04223_ _04225_ VDD VSS NOR3_X1
X_13326_ _04202_ _04203_ _04226_ VDD VSS NOR2_X1
X_13327_ _04216_ _04225_ _04226_ _04227_ VDD VSS OAI21_X1
X_13328_ _04222_ _04224_ _04227_ _04228_ VDD VSS NAND3_X2
X_13329_ _09200_ _04174_ net8 _04229_ VDD VSS MUX2_X2
X_13330_ _04090_ _04229_ _04230_ VDD VSS XNOR2_X2
X_13331_ _09260_ _04231_ VDD VSS INV_X2
X_13332_ _09261_ _04232_ VDD VSS INV_X1
X_13333_ _09254_ _09255_ _04147_ _04233_ VDD VSS AOI21_X4
X_13334_ _04231_ _04233_ _04232_ _04234_ VDD VSS OAI21_X4
X_13335_ _09234_ _04235_ VDD VSS INV_X1
X_13336_ _04018_ _04236_ VDD VSS INV_X1
X_13337_ _04235_ _04163_ _04236_ _04237_ VDD VSS OAI21_X1
X_13338_ _09231_ _04237_ _04005_ _04238_ VDD VSS AOI21_X2
X_13339_ _04086_ _04238_ _04239_ VDD VSS XNOR2_X2
X_13340_ _04230_ _04234_ _04239_ _04240_ VDD VSS NOR3_X2
X_13341_ _04234_ _03822_ net408 _04241_ VDD VSS NOR3_X4
X_13342_ _04234_ net8 _09203_ _04242_ VDD VSS NOR3_X4
X_13343_ _04241_ _04242_ _04243_ VDD VSS NOR2_X4
X_13344_ _04243_ _04229_ _04244_ VDD VSS NOR2_X4
X_13345_ _04096_ _04133_ _04245_ VDD VSS NOR2_X4
X_13346_ _04240_ _04244_ _04245_ _04246_ VDD VSS AOI21_X4
X_13347_ _04228_ _04246_ _04247_ VDD VSS NOR2_X4
X_13348_ _04197_ _04218_ _04247_ _04248_ VDD VSS NAND3_X4
X_13349_ _03831_ _03924_ _04249_ VDD VSS NAND2_X1
X_13350_ _04024_ _04110_ _04025_ _04026_ _04250_ VDD VSS OAI211_X4
X_13351_ _03896_ _04249_ _04250_ _04251_ VDD VSS AOI21_X2
X_13352_ _03911_ _04251_ _04252_ VDD VSS XNOR2_X2
X_13353_ _04027_ _04034_ _04035_ _04253_ VDD VSS OAI21_X4
X_13354_ _04129_ _04254_ VDD VSS INV_X1
X_13355_ _04077_ _04030_ _04079_ _04082_ _04255_ VDD VSS NOR4_X1
X_13356_ _04254_ _04255_ net12 _04256_ VDD VSS OAI21_X1
X_13357_ _04253_ _04069_ _04256_ _04257_ VDD VSS NOR3_X2
X_13358_ _04092_ _04211_ _04258_ VDD VSS NAND2_X1
X_13359_ _03790_ _04211_ _04259_ VDD VSS NAND2_X1
X_13360_ _04258_ _04259_ _04070_ _04260_ VDD VSS MUX2_X1
X_13361_ _03925_ _04112_ _04261_ VDD VSS NAND2_X2
X_13362_ _04021_ _03921_ _04262_ VDD VSS XNOR2_X2
X_13363_ _04261_ _04250_ _04262_ _04263_ VDD VSS NAND3_X2
X_13364_ net6 _03970_ _04264_ VDD VSS NOR2_X1
X_13365_ _03875_ _03920_ _04071_ _04074_ _04264_ _03973_ _04265_
+ VDD VSS OAI33_X1
X_13366_ _03790_ _04265_ _04266_ VDD VSS NAND2_X1
X_13367_ _04026_ _04025_ _04028_ _04266_ _04267_ VDD VSS NOR4_X4
X_13368_ _04079_ _04189_ _04268_ VDD VSS NOR2_X2
X_13369_ _04267_ _04268_ _04269_ VDD VSS OR2_X1
X_13370_ _04260_ _04263_ _04269_ _04208_ _04270_ VDD VSS AOI211_X2
X_13371_ _04257_ _04270_ _04096_ _04133_ _04271_ VDD VSS OAI211_X2
X_13372_ _04252_ _04271_ _04272_ VDD VSS XNOR2_X2
X_13373_ _04263_ _04273_ VDD VSS INV_X1
X_13374_ _04250_ _04262_ _04274_ VDD VSS XOR2_X2
X_13375_ _04014_ _04008_ _09220_ _09223_ _04275_ VDD VSS NAND4_X1
X_13376_ _04016_ _01097_ _04207_ _04275_ _04276_ VDD VSS OR4_X1
X_13377_ _04276_ _04277_ VDD VSS INV_X1
X_13378_ _04067_ _04068_ _04277_ _04278_ VDD VSS AND3_X1
X_13379_ _04038_ _04278_ _04268_ _04267_ _04279_ VDD VSS OAI211_X4
X_13380_ _04104_ _04118_ _04126_ _04279_ _04280_ VDD VSS NAND4_X4
X_13381_ _04185_ _04132_ _04280_ _04281_ VDD VSS NAND3_X4
X_13382_ _04273_ _04274_ _04281_ _04282_ VDD VSS MUX2_X1
X_13383_ _04261_ _04250_ _04283_ VDD VSS NAND2_X2
X_13384_ _04274_ _04284_ VDD VSS INV_X1
X_13385_ _04283_ _04284_ _04285_ VDD VSS NAND2_X1
X_13386_ _04253_ _04069_ _04216_ _04256_ _04286_ VDD VSS OR4_X2
X_13387_ _04200_ _04285_ _04286_ _04287_ VDD VSS OR3_X1
X_13388_ _04261_ _04250_ _04288_ VDD VSS AND2_X1
X_13389_ _04288_ _04200_ _04286_ _04289_ VDD VSS OAI21_X1
X_13390_ _04272_ _04282_ _04287_ _04289_ _04290_ VDD VSS AOI211_X4
X_13391_ net12 _04101_ _04099_ _04291_ VDD VSS NAND3_X2
X_13392_ net408 _04291_ _04101_ _04292_ VDD VSS AOI21_X1
X_13393_ _04292_ _04100_ _04293_ VDD VSS AND2_X1
X_13394_ _04293_ _04187_ _04185_ _04294_ VDD VSS AOI21_X1
X_13395_ _04118_ _04220_ _04257_ _04295_ VDD VSS NAND3_X1
X_13396_ _04294_ _04293_ _04295_ _04296_ VDD VSS MUX2_X2
X_13397_ _04111_ _04113_ _04297_ VDD VSS NAND2_X2
X_13398_ _04116_ _04283_ _04298_ VDD VSS NOR2_X1
X_13399_ _04185_ _04298_ _04132_ _04280_ _04299_ VDD VSS NAND4_X4
X_13400_ _04297_ _04299_ _04300_ VDD VSS XNOR2_X2
X_13401_ _04296_ _04300_ _04301_ VDD VSS NOR2_X4
X_13402_ _03910_ _03926_ _03938_ _03955_ _04302_ VDD VSS NAND4_X4
X_13403_ _03951_ _03964_ _03986_ _04303_ VDD VSS NOR3_X2
X_13404_ _04047_ _04302_ _04303_ _04304_ VDD VSS AOI21_X4
X_13405_ _04196_ _04304_ _04305_ VDD VSS NOR2_X1
X_13406_ _04026_ _04025_ _04028_ _04077_ _04079_ _04082_ _04306_
+ VDD VSS OAI33_X1
X_13407_ _04306_ _04220_ _04304_ _04307_ VDD VSS NAND3_X1
X_13408_ _04066_ _04063_ _04308_ VDD VSS AND2_X1
X_13409_ _04308_ _04302_ _03987_ _04309_ VDD VSS AOI21_X2
X_13410_ _04309_ _04310_ VDD VSS INV_X1
X_13411_ _04305_ _04307_ _04310_ _04311_ VDD VSS AOI21_X2
X_13412_ _04196_ _04304_ _04312_ VDD VSS NAND2_X1
X_13413_ _04084_ _04216_ _04313_ VDD VSS NOR2_X1
X_13414_ _04312_ _04310_ _04313_ _04314_ VDD VSS MUX2_X1
X_13415_ _04311_ _04314_ _04245_ _04315_ VDD VSS OAI21_X4
X_13416_ _04069_ _04084_ _04216_ _04316_ VDD VSS NOR3_X2
X_13417_ _04316_ _04133_ _04096_ _04317_ VDD VSS OAI21_X2
X_13418_ _04253_ _04069_ _04084_ _04095_ _04318_ VDD VSS NOR4_X2
X_13419_ _04031_ _04091_ _04319_ VDD VSS NAND2_X1
X_13420_ _04318_ _04319_ _04133_ _04320_ VDD VSS OAI21_X2
X_13421_ _04067_ _04306_ _04321_ VDD VSS AND2_X1
X_13422_ _04038_ _04068_ _04220_ _04321_ _04322_ VDD VSS AOI22_X4
X_13423_ _04069_ _04084_ _04095_ _04323_ VDD VSS OR3_X1
X_13424_ _04322_ _04323_ _04253_ _04324_ VDD VSS AOI21_X2
X_13425_ _04317_ _04320_ _04324_ _04325_ VDD VSS NAND3_X4
X_13426_ _04185_ _04132_ _04326_ VDD VSS OR2_X1
X_13427_ _04253_ _04069_ _04084_ _04216_ _04327_ VDD VSS NOR4_X1
X_13428_ _04027_ net12 _04030_ _04328_ VDD VSS MUX2_X1
X_13429_ _04327_ _04328_ _04329_ VDD VSS OR2_X1
X_13430_ _04281_ _04326_ _04329_ _04330_ VDD VSS NAND3_X2
X_13431_ _04315_ _04325_ _04330_ _04331_ VDD VSS NOR3_X4
X_13432_ _04165_ _04121_ _04332_ VDD VSS NOR2_X1
X_13433_ _03880_ _04291_ _04332_ _04333_ VDD VSS NOR3_X1
X_13434_ _04126_ _04279_ _04334_ VDD VSS NAND2_X1
X_13435_ _04185_ _04186_ _04132_ _04334_ _04335_ VDD VSS NAND4_X4
X_13436_ _03880_ _04103_ _04121_ _04336_ VDD VSS NOR3_X1
X_13437_ _03880_ _04103_ _04124_ _04337_ VDD VSS NOR3_X1
X_13438_ _04185_ _04186_ _04132_ _04338_ VDD VSS AND3_X1
X_13439_ _04333_ _04335_ _04336_ _04337_ _04338_ _04339_ VDD
+ VSS AOI221_X2
X_13440_ _03867_ _04103_ _04124_ _04340_ VDD VSS NAND3_X2
X_13441_ _03873_ _03880_ _04340_ _04341_ VDD VSS OAI21_X2
X_13442_ _03880_ net8 _04103_ _04342_ VDD VSS AOI21_X1
X_13443_ _03867_ _04342_ _04343_ VDD VSS NAND2_X1
X_13444_ _03867_ _03880_ _04291_ _04344_ VDD VSS OR3_X1
X_13445_ _04286_ _04343_ _04344_ _04345_ VDD VSS AOI21_X2
X_13446_ _04104_ _04118_ _04124_ _04346_ VDD VSS NAND3_X2
X_13447_ _04346_ _04187_ _04185_ _04347_ VDD VSS AOI21_X2
X_13448_ _04341_ _04345_ _04347_ _04348_ VDD VSS AOI21_X4
X_13449_ _04286_ _04346_ _04184_ _04187_ _04349_ VDD VSS AOI211_X2
X_13450_ _04103_ _04124_ _04350_ VDD VSS NAND2_X1
X_13451_ _04165_ _04350_ _04351_ VDD VSS NOR2_X1
X_13452_ _04350_ _04351_ _03867_ _04352_ VDD VSS MUX2_X1
X_13453_ _04349_ _04352_ _04353_ VDD VSS XOR2_X2
X_13454_ _04339_ _04348_ _04353_ _04354_ VDD VSS NOR3_X2
X_13455_ _04290_ _04301_ _04331_ _04354_ _04355_ VDD VSS NAND4_X4
X_13456_ _04248_ _04355_ _04356_ VDD VSS NOR2_X4
X_13457_ _04356_ _04357_ VDD VSS BUF_X4
X_13458_ _04148_ _09253_ net26 _09279_ VDD VSS MUX2_X2
X_13459_ _04348_ _04358_ VDD VSS INV_X1
X_13460_ _04339_ _04353_ _04359_ VDD VSS NOR2_X2
X_13461_ _04290_ _04301_ _04358_ _04359_ _04360_ VDD VSS NAND4_X2
X_13462_ _04197_ _04218_ _04247_ _04331_ _04361_ VDD VSS AND4_X1
X_13463_ _04245_ _04286_ _04362_ VDD VSS OR2_X2
X_13464_ _04285_ _04362_ _04363_ VDD VSS OR2_X1
X_13465_ _04284_ _04281_ _04364_ VDD VSS XNOR2_X1
X_13466_ _04288_ _04362_ _04364_ _04365_ VDD VSS NAND3_X1
X_13467_ _04363_ _04365_ _04366_ VDD VSS NAND2_X1
X_13468_ _04360_ _04361_ _04366_ _04367_ VDD VSS NAND3_X1
X_13469_ _04272_ _04367_ _04368_ VDD VSS XNOR2_X2
X_13470_ _04273_ _04281_ _04369_ VDD VSS AND2_X1
X_13471_ _04197_ _04218_ net404 _04331_ _04370_ VDD VSS NAND4_X4
X_13472_ _04290_ _04301_ _04358_ _04359_ _04371_ VDD VSS AND4_X1
X_13473_ _04369_ _04370_ _04371_ _04372_ VDD VSS OAI21_X1
X_13474_ _04362_ _04373_ VDD VSS INV_X1
X_13475_ _04263_ _04281_ _04373_ _04374_ VDD VSS NOR3_X1
X_13476_ _04374_ _04370_ _04371_ _04375_ VDD VSS OAI21_X1
X_13477_ _04166_ _04182_ _04376_ VDD VSS NOR2_X1
X_13478_ net408 _04181_ _04377_ VDD VSS NAND2_X1
X_13479_ _04090_ _04229_ _04378_ VDD VSS NOR2_X2
X_13480_ _04306_ _04378_ _04379_ VDD VSS NAND2_X1
X_13481_ _04376_ _04200_ _04377_ _04245_ _04379_ _04380_ VDD
+ VSS OAI221_X2
X_13482_ _04222_ _04224_ _04227_ _04381_ VDD VSS AND3_X1
X_13483_ _04202_ _04205_ _04382_ VDD VSS NOR2_X1
X_13484_ net426 net14 _04378_ _04382_ _04198_ net23 _04383_
+ VDD VSS AOI222_X2
X_13485_ _04381_ _04383_ _04245_ _04384_ VDD VSS OAI21_X4
X_13486_ _04378_ _04096_ _04133_ _04385_ VDD VSS OAI21_X2
X_13487_ _04090_ _04229_ _04386_ VDD VSS NAND2_X1
X_13488_ _04385_ _04386_ _04387_ VDD VSS NAND2_X4
X_13489_ _04380_ _04315_ _04384_ _04387_ _04388_ VDD VSS NOR4_X4
X_13490_ _09227_ _04185_ _04186_ _04187_ _04389_ VDD VSS NAND4_X4
X_13491_ _04239_ _04133_ net407 _04390_ VDD VSS OAI21_X4
X_13492_ _09254_ _04391_ VDD VSS INV_X1
X_13493_ _09248_ _04392_ VDD VSS INV_X1
X_13494_ _09239_ _02103_ _09240_ _04393_ VDD VSS AOI21_X1
X_13495_ _09246_ _04394_ VDD VSS INV_X1
X_13496_ _04139_ _04393_ _04394_ _04395_ VDD VSS OAI21_X1
X_13497_ _09243_ _04395_ _04396_ VDD VSS AND2_X1
X_13498_ _09242_ _04396_ _04397_ VDD VSS OR2_X1
X_13499_ _09251_ _04397_ _09252_ _04398_ VDD VSS AOI21_X1
X_13500_ _09249_ _04399_ VDD VSS INV_X1
X_13501_ _04392_ _04398_ _04399_ _04400_ VDD VSS OAI21_X1
X_13502_ _09257_ _04400_ _09258_ _04401_ VDD VSS AOI21_X1
X_13503_ _04391_ _04401_ _04136_ _04402_ VDD VSS OAI21_X1
X_13504_ _09261_ _04402_ _04403_ VDD VSS NAND2_X1
X_13505_ _04231_ _04389_ _04390_ _04403_ _04404_ VDD VSS NAND4_X4
X_13506_ _04325_ _04330_ _04404_ _04405_ VDD VSS NOR3_X2
X_13507_ _04388_ _04405_ _04406_ VDD VSS NAND2_X1
X_13508_ _04290_ _04301_ _04331_ _04354_ _04407_ VDD VSS AND4_X1
X_13509_ _04407_ _04408_ VDD VSS BUF_X4
X_13510_ _04199_ _04217_ _04409_ VDD VSS XNOR2_X2
X_13511_ _04230_ _04234_ _04239_ _04243_ _04229_ _04134_ _04410_
+ VDD VSS OAI33_X1
X_13512_ _04381_ net374 _04411_ VDD VSS NAND2_X2
X_13513_ _04380_ _04409_ _04411_ _04412_ VDD VSS NOR3_X4
X_13514_ _04406_ _04408_ _04412_ _04413_ VDD VSS AOI21_X2
X_13515_ _04372_ _04375_ _04413_ _04414_ VDD VSS MUX2_X1
X_13516_ _04371_ _04370_ _04415_ VDD VSS NOR2_X1
X_13517_ _04283_ _04284_ _04362_ _04416_ VDD VSS NAND3_X1
X_13518_ _04416_ _04417_ VDD VSS INV_X1
X_13519_ _04363_ _04361_ _04360_ _04418_ VDD VSS AOI21_X1
X_13520_ _04388_ _04405_ _04419_ VDD VSS AND2_X1
X_13521_ _04419_ _04355_ net406 _04420_ VDD VSS OAI21_X1
X_13522_ _04415_ _04417_ _04418_ _04420_ _04421_ VDD VSS AOI22_X2
X_13523_ _04360_ _04361_ _04422_ VDD VSS NAND2_X1
X_13524_ _04283_ _04284_ _04281_ _04423_ VDD VSS OR3_X1
X_13525_ _04422_ _04362_ _04423_ _04424_ VDD VSS OR3_X1
X_13526_ _04373_ _04423_ _04425_ VDD VSS NOR2_X1
X_13527_ _04425_ _04370_ _04371_ _04426_ VDD VSS OAI21_X1
X_13528_ _04288_ _04274_ _04281_ _04427_ VDD VSS AND3_X1
X_13529_ _04427_ _04370_ _04371_ _04428_ VDD VSS OAI21_X1
X_13530_ _04426_ _04428_ _04413_ _04429_ VDD VSS MUX2_X1
X_13531_ _04414_ _04421_ _04424_ _04429_ _04430_ VDD VSS NAND4_X4
X_13532_ _04232_ _04402_ _04431_ VDD VSS XNOR2_X1
X_13533_ _04389_ _04390_ _04432_ VDD VSS NAND2_X2
X_13534_ _04234_ _04432_ _04433_ VDD VSS XNOR2_X1
X_13535_ _04387_ _04404_ _04434_ VDD VSS XNOR2_X1
X_13536_ _04385_ _04386_ _04435_ VDD VSS AND2_X2
X_13537_ _09227_ _09230_ net40 _04436_ VDD VSS NOR3_X1
X_13538_ _04245_ _04020_ _04239_ _04437_ VDD VSS NOR3_X1
X_13539_ _04435_ _04436_ _04437_ _04438_ VDD VSS OAI21_X1
X_13540_ _04431_ _04433_ _04434_ _04438_ _04248_ _04355_ _04439_
+ VDD VSS OAI33_X1
X_13541_ _09281_ _04440_ VDD VSS CLKBUF_X3
X_13542_ _09283_ _04441_ VDD VSS INV_X1
X_13543_ _09271_ _04442_ VDD VSS INV_X1
X_13544_ _09277_ _04443_ VDD VSS INV_X1
X_13545_ _09265_ _04444_ VDD VSS INV_X1
X_13546_ _09266_ _09285_ butterfly_count\[1\] _04445_ VDD
+ VSS OAI21_X1
X_13547_ _04444_ _04445_ _04446_ VDD VSS NAND2_X1
Xclone5 _03788_ _03749_ net5 VDD VSS NAND2_X2
X_13549_ _09263_ _04446_ _09264_ _04448_ VDD VSS AOI21_X1
X_13550_ _09278_ _04449_ VDD VSS INV_X1
X_13551_ _04443_ _04448_ _04449_ _04450_ VDD VSS OAI21_X1
X_13552_ _09274_ _04450_ _09275_ _04451_ VDD VSS AOI21_X1
X_13553_ _09272_ _04452_ VDD VSS INV_X1
X_13554_ _04442_ _04451_ _04452_ _04453_ VDD VSS OAI21_X2
X_13555_ _09268_ _04453_ _09269_ _04454_ VDD VSS AOI21_X2
X_13556_ _09284_ _04455_ VDD VSS INV_X2
X_13557_ _04441_ _04454_ _04455_ _04456_ VDD VSS OAI21_X4
X_13558_ _09280_ _04440_ _04456_ _04457_ VDD VSS AOI21_X4
X_13559_ net373 _04457_ _04458_ VDD VSS NAND2_X4
X_13560_ _04327_ _04328_ _04459_ VDD VSS NAND2_X1
X_13561_ _04329_ _04459_ _04245_ _04460_ VDD VSS OAI21_X2
X_13562_ _04248_ _04315_ _04325_ _04408_ _04461_ VDD VSS OR4_X1
X_13563_ _04460_ _04461_ _04462_ VDD VSS XOR2_X2
X_13564_ _04281_ _04326_ _04463_ VDD VSS AND2_X1
X_13565_ _04325_ _04404_ _04460_ _04464_ VDD VSS NOR3_X1
X_13566_ _04388_ _04464_ _04465_ VDD VSS NAND2_X1
X_13567_ _04465_ _04408_ _04412_ _04466_ VDD VSS AOI21_X4
X_13568_ _04463_ _04466_ _04467_ VDD VSS XOR2_X2
X_13569_ _04380_ _04384_ _04387_ _04468_ VDD VSS NOR3_X2
X_13570_ _04387_ _04404_ _04469_ VDD VSS NOR2_X2
X_13571_ _04181_ _04134_ _04470_ VDD VSS NAND2_X1
X_13572_ _04202_ _04082_ net14 _04471_ VDD VSS AOI21_X1
X_13573_ _04225_ _04471_ _04472_ VDD VSS NOR2_X1
X_13574_ _04470_ _04472_ _04473_ VDD VSS XNOR2_X2
X_13575_ _04205_ _04220_ _04188_ _04474_ VDD VSS AOI21_X2
X_13576_ _04188_ _04205_ _04220_ _04475_ VDD VSS AND3_X1
X_13577_ _04474_ _04475_ _04476_ VDD VSS OR2_X1
X_13578_ _04246_ _04469_ _04473_ _04476_ _04477_ VDD VSS NAND4_X1
X_13579_ _04199_ _04206_ _04095_ _04478_ VDD VSS OAI21_X1
X_13580_ _04228_ _04478_ net40 _04479_ VDD VSS AOI21_X2
X_13581_ _04197_ net374 _04479_ _04435_ _04480_ VDD VSS NAND4_X1
X_13582_ _04410_ _04387_ _04404_ _04481_ VDD VSS OR3_X1
X_13583_ net374 _04474_ _04475_ _04482_ VDD VSS OAI21_X2
X_13584_ _04410_ _04474_ _04475_ _04483_ VDD VSS OR3_X2
X_13585_ _04480_ _04481_ _04482_ _04483_ _04484_ VDD VSS NAND4_X1
X_13586_ net405 _04355_ _04468_ _04477_ _04484_ _04473_ _04485_
+ VDD VSS OAI222_X2
X_13587_ _04218_ _04247_ _04486_ VDD VSS XNOR2_X2
X_13588_ _04197_ _04479_ _04469_ _04487_ VDD VSS AOI21_X4
X_13589_ _04197_ _04218_ _04247_ _04488_ VDD VSS OAI21_X2
X_13590_ _04486_ _04487_ _04488_ _04355_ _04489_ VDD VSS OAI22_X4
X_13591_ _04134_ _04309_ _04490_ VDD VSS NAND2_X2
X_13592_ _04309_ _04490_ _04313_ _04491_ VDD VSS MUX2_X2
X_13593_ _04248_ _04408_ _04491_ _04492_ VDD VSS NOR3_X2
X_13594_ _04491_ _04493_ VDD VSS INV_X1
X_13595_ _04493_ _04355_ _04412_ _04494_ VDD VSS AOI21_X2
X_13596_ _04485_ _04489_ _04492_ _04494_ _04495_ VDD VSS OAI211_X4
X_13597_ _04379_ _04310_ _04496_ VDD VSS NOR2_X1
X_13598_ _04312_ _04490_ _04496_ _04304_ _04497_ VDD VSS OAI22_X4
X_13599_ _04231_ _04403_ _04498_ VDD VSS NAND2_X1
X_13600_ _04432_ _04498_ _04499_ VDD VSS NOR2_X2
X_13601_ _04499_ _04468_ _04491_ _04500_ VDD VSS AND3_X1
X_13602_ _04500_ _04355_ _04248_ _04501_ VDD VSS OAI21_X2
X_13603_ _04497_ _04501_ _04502_ VDD VSS XNOR2_X2
X_13604_ _04322_ _04316_ net40 _04503_ VDD VSS AOI21_X2
X_13605_ _04380_ _04409_ _04411_ _04315_ _04504_ VDD VSS NOR4_X1
X_13606_ _04503_ _04504_ _04505_ VDD VSS OR2_X1
X_13607_ _04503_ _04504_ _04506_ VDD VSS NAND2_X1
X_13608_ _04505_ _04506_ net399 _04507_ VDD VSS OAI21_X4
X_13609_ _04253_ _04323_ _04508_ VDD VSS NAND2_X1
X_13610_ _04320_ _04508_ _04509_ VDD VSS AND2_X1
X_13611_ _04503_ _04388_ _04499_ _04510_ VDD VSS NAND3_X2
X_13612_ _04510_ _04408_ _04412_ _04511_ VDD VSS AOI21_X4
X_13613_ _04509_ _04511_ _04512_ VDD VSS XNOR2_X2
X_13614_ _04495_ _04502_ _04507_ _04512_ _04513_ VDD VSS NOR4_X4
X_13615_ _04462_ _04467_ _04513_ _04514_ VDD VSS NAND3_X1
X_13616_ _04495_ _04502_ _04507_ _04515_ VDD VSS NOR3_X4
X_13617_ _04509_ _04511_ _04516_ VDD VSS XOR2_X2
X_13618_ _04462_ _04516_ _04517_ VDD VSS AND2_X2
X_13619_ _04463_ _04466_ _04518_ VDD VSS XNOR2_X2
X_13620_ _04368_ _04518_ _04519_ VDD VSS NOR2_X2
X_13621_ _04430_ _04515_ _04517_ _04519_ _04520_ VDD VSS AND4_X4
X_13622_ _04520_ _04521_ VDD VSS BUF_X8
X_13623_ _04297_ _04299_ _04522_ VDD VSS XOR2_X2
X_13624_ _04432_ _04408_ _04412_ _04523_ VDD VSS AOI21_X2
X_13625_ _04290_ _04331_ _04468_ _04524_ VDD VSS AND3_X1
X_13626_ _04498_ _04491_ _09260_ _04525_ VDD VSS OAI21_X1
X_13627_ _04523_ _04524_ _04525_ _04526_ VDD VSS NAND3_X2
X_13628_ _04522_ _04526_ _04527_ VDD VSS XNOR2_X2
X_13629_ _04351_ _04121_ _04291_ _04528_ VDD VSS AOI21_X2
X_13630_ _04335_ _04528_ _04529_ VDD VSS XNOR2_X2
X_13631_ _04325_ _04330_ _04530_ VDD VSS NOR2_X1
X_13632_ _04290_ _04301_ _04530_ _04388_ _04531_ VDD VSS NAND4_X1
X_13633_ _04404_ _04531_ _04412_ _04408_ _04532_ VDD VSS AOI211_X2
X_13634_ _04529_ _04532_ _04533_ VDD VSS XNOR2_X2
X_13635_ _04290_ _04522_ _04360_ _04361_ _04534_ VDD VSS AND4_X1
X_13636_ _04296_ _04534_ _04535_ VDD VSS XOR2_X2
X_13637_ _04335_ _04528_ _04536_ VDD VSS XOR2_X1
X_13638_ _04296_ _04300_ _04353_ _04536_ _04537_ VDD VSS NOR4_X1
X_13639_ _04290_ _04388_ _04405_ _04537_ _04538_ VDD VSS NAND4_X1
X_13640_ _04538_ _04408_ _04412_ _04539_ VDD VSS AOI21_X1
X_13641_ _03880_ _04340_ _04540_ VDD VSS NAND2_X1
X_13642_ _03873_ _03878_ _03879_ _03875_ _03788_ _04541_ VDD
+ VSS OAI221_X2
X_13643_ _04540_ _04541_ _04340_ _04542_ VDD VSS OAI21_X1
X_13644_ _03867_ _03881_ _04103_ _04543_ VDD VSS OAI21_X1
X_13645_ _03867_ _04103_ _04544_ VDD VSS OR2_X1
X_13646_ _04124_ _04338_ _04543_ _04544_ _04545_ VDD VSS AND4_X1
X_13647_ _04542_ _04545_ _04546_ VDD VSS XNOR2_X2
X_13648_ _04539_ _04546_ _04547_ VDD VSS XNOR2_X2
X_13649_ _04353_ _04533_ _04535_ _04547_ _04548_ VDD VSS NOR4_X4
X_13650_ _04290_ _04301_ _04549_ VDD VSS AND2_X1
X_13651_ _04549_ _04331_ _04359_ _04550_ VDD VSS NAND3_X1
X_13652_ _04348_ _04550_ net406 _04551_ VDD VSS OAI21_X2
X_13653_ _09268_ _04552_ VDD VSS INV_X1
X_13654_ _09274_ _04553_ VDD VSS INV_X1
X_13655_ _09263_ _04554_ VDD VSS INV_X1
X_13656_ _09264_ _09266_ _09265_ _04555_ VDD VSS OAI21_X2
X_13657_ _04555_ _04554_ _04556_ VDD VSS NAND2_X2
X_13658_ _09277_ _04556_ _09278_ _04557_ VDD VSS AOI21_X2
X_13659_ _09275_ _04558_ VDD VSS INV_X1
X_13660_ _04553_ _04558_ _04557_ _04559_ VDD VSS OAI21_X4
X_13661_ _09271_ _09272_ _04559_ _04560_ VDD VSS AOI21_X4
X_13662_ _09269_ _04561_ VDD VSS INV_X1
X_13663_ _04552_ _04560_ _04561_ _04562_ VDD VSS OAI21_X4
X_13664_ _09283_ _04562_ _09284_ _04563_ VDD VSS AOI21_X4
X_13665_ _04563_ _04564_ VDD VSS INV_X2
X_13666_ _09280_ _04440_ _04564_ _04565_ VDD VSS AOI21_X4
X_13667_ _04565_ _04551_ net373 _04566_ VDD VSS AND3_X4
X_13668_ _04527_ _04548_ _04566_ _04567_ VDD VSS AND3_X4
X_13669_ _04567_ _04568_ VDD VSS BUF_X8
X_13670_ _04458_ _04514_ _04521_ net34 _04569_ VDD VSS AOI211_X2
X_13671_ _04430_ _04569_ _04570_ VDD VSS NAND2_X1
X_13672_ _04368_ _04570_ _04571_ VDD VSS XNOR2_X2
X_13673_ _04462_ _04513_ _04572_ VDD VSS NAND2_X1
X_13674_ _04439_ _04565_ _04573_ VDD VSS NAND2_X4
X_13675_ _04572_ _04573_ _04521_ _04568_ _04574_ VDD VSS AOI211_X2
X_13676_ _04518_ _04574_ _04575_ VDD VSS XNOR2_X2
X_13677_ _04495_ _04576_ VDD VSS INV_X1
X_13678_ _04497_ _04501_ _04577_ VDD VSS XOR2_X2
X_13679_ _04577_ _04507_ _04573_ _04578_ VDD VSS NOR3_X1
X_13680_ _04527_ _04548_ net413 _04579_ VDD VSS NAND3_X4
X_13681_ _04430_ _04515_ _04517_ _04519_ _04580_ VDD VSS NAND4_X4
X_13682_ _04576_ _04578_ _04579_ _04580_ _04581_ VDD VSS OAI211_X2
X_13683_ net373 _04457_ _04582_ VDD VSS AND2_X1
X_13684_ _04507_ _04582_ _04583_ VDD VSS NOR2_X1
X_13685_ _04507_ _04582_ _04584_ VDD VSS AND2_X1
X_13686_ _04583_ _04584_ _04576_ _04585_ VDD VSS AOI21_X1
X_13687_ _04577_ _04573_ _04586_ VDD VSS NAND2_X1
X_13688_ _04495_ _04521_ net34 _04587_ VDD VSS AOI21_X1
X_13689_ _04502_ _04507_ _04588_ VDD VSS OR2_X1
X_13690_ _04581_ _04585_ _04586_ _04587_ _04588_ _04589_ VDD
+ VSS OAI221_X2
X_13691_ _04573_ _04590_ VDD VSS INV_X1
X_13692_ _04462_ _04512_ _04590_ _04591_ VDD VSS AND3_X1
X_13693_ _04515_ _04580_ _04579_ _04592_ VDD VSS OAI21_X2
X_13694_ _04591_ _04517_ _04592_ _04593_ VDD VSS MUX2_X2
X_13695_ _04517_ _04458_ _04573_ _04594_ VDD VSS NAND3_X1
X_13696_ _04462_ _04512_ _04458_ _04590_ _04595_ VDD VSS OR4_X1
X_13697_ _04594_ _04595_ _04592_ _04596_ VDD VSS OAI21_X2
X_13698_ _04575_ _04589_ _04593_ _04596_ _04597_ VDD VSS OAI211_X4
X_13699_ _04413_ _04362_ _04598_ VDD VSS NAND2_X1
X_13700_ _04281_ _04598_ _04599_ VDD VSS XNOR2_X1
X_13701_ _04274_ _04599_ _04600_ VDD VSS NAND2_X1
X_13702_ _04274_ _04413_ _04373_ _04601_ VDD VSS AOI21_X1
X_13703_ _04600_ _04601_ _04288_ _04263_ _04599_ _04602_ VDD
+ VSS OAI221_X2
X_13704_ _04283_ _04362_ _04603_ VDD VSS XNOR2_X1
X_13705_ _04422_ _04603_ _04604_ VDD VSS XNOR2_X2
X_13706_ _04604_ _04605_ VDD VSS INV_X1
X_13707_ _04462_ _04467_ _04513_ _04605_ _04606_ VDD VSS NAND4_X1
X_13708_ _04573_ _04606_ _04521_ net34 _04607_ VDD VSS AOI211_X2
X_13709_ _04602_ _04607_ _04608_ VDD VSS XNOR2_X2
X_13710_ _04569_ _04604_ _04609_ VDD VSS XNOR2_X2
X_13711_ _04608_ _04609_ _04610_ VDD VSS NAND2_X1
X_13712_ _04571_ _04597_ _04610_ _04611_ VDD VSS NOR3_X4
X_13713_ _04146_ _04400_ _04612_ VDD VSS XNOR2_X1
X_13714_ _02757_ _02796_ _04613_ VDD VSS XNOR2_X1
X_13715_ _02103_ _03003_ _04613_ _03100_ _04614_ VDD VSS OR4_X1
X_13716_ _03048_ _04614_ _04615_ VDD VSS NAND2_X1
X_13717_ _02103_ _02796_ _03100_ _04616_ VDD VSS AOI21_X1
X_13718_ _02757_ _02796_ _03100_ _04617_ VDD VSS OAI21_X1
X_13719_ _04616_ _04617_ _04618_ VDD VSS NAND2_X1
X_13720_ _04615_ _04618_ _03003_ _04619_ VDD VSS AOI21_X2
X_13721_ _03773_ _04619_ _03552_ _04620_ VDD VSS NAND3_X4
X_13722_ _03049_ _04614_ _04621_ VDD VSS XOR2_X2
X_13723_ _04621_ _04620_ _09145_ VDD VSS XOR2_X2
X_13724_ _03354_ _09145_ _04622_ VDD VSS NOR2_X2
X_13725_ _04622_ _03354_ _09147_ _09165_ VDD VSS AOI21_X2
X_13726_ _09167_ _03996_ _04623_ VDD VSS XOR2_X1
X_13727_ _09165_ _04623_ _03524_ _09183_ VDD VSS MUX2_X1
X_13728_ _03543_ _03554_ _04624_ VDD VSS NAND2_X1
X_13729_ _03568_ _04624_ _04625_ VDD VSS XNOR2_X1
X_13730_ _09183_ _04625_ _03791_ _09212_ VDD VSS MUX2_X1
X_13731_ _09214_ _09193_ _03815_ _04626_ VDD VSS OR3_X1
X_13732_ _03816_ _04626_ _04627_ VDD VSS AND2_X1
X_13733_ _09212_ _04627_ _03991_ _09236_ VDD VSS MUX2_X1
X_13734_ _09238_ _04015_ _04628_ VDD VSS XNOR2_X1
X_13735_ _09236_ _04628_ _04135_ _09256_ VDD VSS MUX2_X1
X_13736_ _04612_ _09256_ net26 _09282_ VDD VSS MUX2_X1
X_13737_ _04580_ _04579_ _09282_ _04629_ VDD VSS OR3_X2
X_13738_ _04455_ _04562_ _04630_ VDD VSS XNOR2_X1
X_13739_ _04630_ _04631_ VDD VSS INV_X1
X_13740_ _04631_ _04579_ _04580_ _04632_ VDD VSS OAI21_X4
X_13741_ _08819_ _04629_ _04632_ _04633_ VDD VSS AOI21_X4
X_13742_ _08819_ _04629_ _04632_ _04634_ VDD VSS AND3_X2
X_13743_ _09301_ _04635_ VDD VSS INV_X1
X_13744_ _09305_ _04636_ VDD VSS INV_X1
X_13745_ _09307_ _04637_ VDD VSS INV_X1
X_13746_ _09293_ _04638_ VDD VSS INV_X1
X_13747_ _09295_ _04639_ VDD VSS INV_X1
X_13748_ _09296_ _09288_ _09289_ _04640_ VDD VSS OAI21_X2
X_13749_ _04638_ _04640_ _04639_ _04641_ VDD VSS AOI21_X4
X_13750_ _09308_ _09292_ _04641_ _04642_ VDD VSS OAI21_X4
X_13751_ _04636_ _04637_ _04642_ _04643_ VDD VSS AOI21_X4
X_13752_ _09302_ _04643_ _09304_ _04644_ VDD VSS OAI21_X4
X_13753_ _04635_ _04644_ _04645_ VDD VSS NAND2_X4
X_13754_ _09299_ _04646_ VDD VSS BUF_X2
X_13755_ _09298_ _04645_ _04646_ _04647_ VDD VSS AOI21_X4
X_13756_ _04647_ _04633_ _04634_ _04648_ VDD VSS NOR3_X4
X_13757_ net26 _04404_ _04649_ VDD VSS NOR2_X2
X_13758_ _04431_ _04433_ _04650_ VDD VSS OR2_X1
X_13759_ _04565_ _04651_ VDD VSS INV_X1
X_13760_ _04650_ _04651_ net410 _04520_ _04652_ VDD VSS AOI211_X2
X_13761_ _04435_ _04649_ _04652_ _04653_ VDD VSS OAI21_X2
X_13762_ _04435_ _04649_ _04652_ _04654_ VDD VSS OR3_X2
X_13763_ _02573_ _04629_ _04632_ _04655_ VDD VSS NAND3_X2
X_13764_ _04457_ _04656_ VDD VSS INV_X1
X_13765_ _04234_ _04389_ _04390_ _04657_ VDD VSS NAND3_X1
X_13766_ _04657_ _04523_ _04234_ _04658_ VDD VSS OAI21_X1
X_13767_ _04431_ _09259_ _04356_ _04659_ VDD VSS MUX2_X2
X_13768_ net412 _04656_ _04658_ _04659_ _04660_ VDD VSS OR4_X1
X_13769_ _04651_ _04659_ _04661_ VDD VSS AND2_X1
X_13770_ _04658_ _04659_ _04656_ _04662_ VDD VSS OAI21_X1
X_13771_ _04660_ _04661_ _04662_ _04663_ VDD VSS OAI21_X1
X_13772_ _04440_ _04456_ _04664_ VDD VSS XNOR2_X2
X_13773_ _04663_ _04664_ _04580_ _04579_ _04665_ VDD VSS OAI211_X2
X_13774_ _04568_ _04521_ _04666_ VDD VSS NAND2_X4
X_13775_ _04665_ net37 _09279_ _04667_ VDD VSS OAI21_X2
X_13776_ _04653_ _04654_ _04655_ _04667_ _04668_ VDD VSS NAND4_X4
X_13777_ _04494_ _04492_ _04669_ VDD VSS NOR2_X1
X_13778_ _04485_ _04489_ _04670_ VDD VSS NAND2_X1
X_13779_ _04458_ _04670_ _04521_ _04568_ _04671_ VDD VSS AOI211_X2
X_13780_ _04669_ _04671_ _04672_ VDD VSS XNOR2_X2
X_13781_ _04409_ _04411_ _04673_ VDD VSS NAND2_X1
X_13782_ _04218_ _04247_ _04674_ VDD VSS NAND2_X1
X_13783_ _04673_ net401 _04674_ _04675_ VDD VSS OAI21_X2
X_13784_ _04469_ _04473_ _04676_ VDD VSS XNOR2_X1
X_13785_ _04246_ _04476_ _04677_ VDD VSS AND2_X1
X_13786_ _04473_ _04476_ _04678_ VDD VSS NOR2_X1
X_13787_ net400 _04676_ _04677_ _04678_ _04410_ _04679_ VDD
+ VSS AOI221_X2
X_13788_ _04675_ _04679_ _04680_ VDD VSS OR2_X1
X_13789_ _04573_ _04680_ _04520_ _04568_ _04681_ VDD VSS AOI211_X2
X_13790_ _04435_ _04499_ _04682_ VDD VSS NAND2_X1
X_13791_ _04380_ net26 _04384_ _04682_ _04683_ VDD VSS NOR4_X2
X_13792_ _04487_ _04683_ _04684_ VDD VSS NOR2_X2
X_13793_ _04681_ _04684_ _04685_ VDD VSS XOR2_X2
X_13794_ _04458_ net423 _04520_ _04686_ VDD VSS AOI21_X4
X_13795_ _04483_ _04482_ net26 _04687_ VDD VSS OAI21_X4
X_13796_ _04686_ _04687_ _04688_ VDD VSS XNOR2_X2
X_13797_ _04435_ _04476_ _04649_ _04689_ VDD VSS NAND3_X1
X_13798_ _04473_ _04689_ _04690_ VDD VSS XOR2_X2
X_13799_ _04690_ _04691_ VDD VSS INV_X1
X_13800_ _04675_ _04691_ _04692_ VDD VSS NOR2_X2
X_13801_ _04672_ _04685_ _04688_ _04692_ _04693_ VDD VSS NAND4_X4
X_13802_ _04648_ _04668_ _04693_ _04694_ VDD VSS NOR3_X4
X_13803_ _04300_ _04526_ _04695_ VDD VSS XNOR2_X2
X_13804_ _04580_ _04695_ net34 _04458_ _04696_ VDD VSS NOR4_X4
X_13805_ _04548_ _04696_ _04697_ VDD VSS NAND2_X1
X_13806_ _04551_ _04697_ _04698_ VDD VSS XNOR2_X2
X_13807_ _04521_ _04590_ _04699_ VDD VSS NAND2_X1
X_13808_ net409 _09272_ _09275_ _09278_ _04700_ VDD VSS NAND4_X1
X_13809_ _09269_ _09266_ _04440_ _04701_ VDD VSS NAND3_X1
X_13810_ _04455_ _01111_ _04700_ _04701_ _04702_ VDD VSS NOR4_X2
X_13811_ _04439_ _04702_ _04703_ VDD VSS NAND2_X1
X_13812_ _04548_ _04551_ _04703_ _04704_ VDD VSS AND3_X1
X_13813_ _04527_ _04699_ _04704_ _04705_ VDD VSS OAI21_X2
X_13814_ _04521_ _04695_ _04590_ _04706_ VDD VSS NAND3_X2
X_13815_ _04549_ _04415_ _04529_ _04707_ VDD VSS AND3_X1
X_13816_ _04353_ _04707_ _04708_ VDD VSS XOR2_X2
X_13817_ _04708_ _04709_ VDD VSS INV_X1
X_13818_ _04521_ _04527_ _04579_ _04582_ _04710_ VDD VSS NAND4_X1
X_13819_ _04533_ _04535_ _04711_ VDD VSS OR2_X1
X_13820_ _04709_ _04710_ _04711_ _04712_ VDD VSS OAI21_X2
X_13821_ _04711_ _04710_ _04709_ _04713_ VDD VSS OR3_X1
X_13822_ _04705_ _04706_ _04712_ _04713_ _04714_ VDD VSS AOI22_X4
X_13823_ _04695_ _04535_ _04699_ _04704_ _04715_ VDD VSS NOR4_X2
X_13824_ _04533_ _04715_ _04716_ VDD VSS XNOR2_X2
X_13825_ _04535_ _04696_ _04717_ VDD VSS XNOR2_X2
X_13826_ _04580_ _04579_ _04718_ VDD VSS NOR2_X2
X_13827_ _04580_ _04695_ _04711_ _04708_ _04719_ VDD VSS OR4_X1
X_13828_ _04718_ _04573_ _04719_ _04720_ VDD VSS NOR3_X1
X_13829_ _04547_ _04720_ _04721_ VDD VSS XNOR2_X1
X_13830_ _04714_ _04716_ _04717_ _04721_ _04722_ VDD VSS AND4_X1
X_13831_ _04611_ _04694_ _04698_ _04722_ _04723_ VDD VSS NAND4_X4
X_13832_ _04723_ _04724_ VDD VSS BUF_X8
X_13833_ _04724_ _04725_ VDD VSS BUF_X8
X_13834_ _04646_ _04645_ _04726_ VDD VSS XNOR2_X1
X_13835_ _04725_ _04726_ _04727_ VDD VSS NAND2_X1
X_13836_ _04399_ _04144_ _04728_ VDD VSS XNOR2_X1
X_13837_ _09149_ _03506_ _09168_ VDD VSS NOR2_X1
X_13838_ _09173_ _09172_ _04729_ VDD VSS NOR2_X1
X_13839_ _09170_ _04729_ _04730_ VDD VSS XNOR2_X1
X_13840_ _09168_ _04730_ _03791_ _09192_ VDD VSS MUX2_X1
X_13841_ _09194_ _03814_ _04731_ VDD VSS XOR2_X1
X_13842_ _09192_ _04731_ _03991_ _09215_ VDD VSS MUX2_X1
X_13843_ _04014_ _04160_ _04732_ VDD VSS XNOR2_X1
X_13844_ _09215_ _04732_ _04135_ _09247_ VDD VSS MUX2_X1
X_13845_ _04728_ _09247_ _04357_ _09267_ VDD VSS MUX2_X1
X_13846_ _04561_ _04453_ _04733_ VDD VSS XNOR2_X1
X_13847_ _09267_ _04733_ net37 _09297_ VDD VSS MUX2_X1
X_13848_ _04727_ net44 _09297_ _09310_ VDD VSS OAI21_X1
X_13849_ _09302_ _04734_ VDD VSS INV_X1
X_13850_ _09296_ _04735_ VDD VSS INV_X1
X_13851_ _04639_ _09287_ _04735_ _04736_ VDD VSS OAI21_X1
X_13852_ _09292_ _04736_ _09293_ _04737_ VDD VSS AOI21_X2
X_13853_ _09308_ _04738_ VDD VSS INV_X1
X_13854_ _04637_ _04737_ _04738_ _04739_ VDD VSS OAI21_X1
X_13855_ _09304_ _04739_ _09305_ _04740_ VDD VSS AOI21_X2
X_13856_ _04734_ _04740_ _04741_ VDD VSS XNOR2_X1
X_13857_ _04725_ _04741_ _04742_ VDD VSS NAND2_X1
X_13858_ _04143_ _04397_ _04743_ VDD VSS XNOR2_X1
X_13859_ _01929_ _03506_ _04744_ VDD VSS NOR2_X2
X_13860_ _03552_ _03773_ _04744_ _04745_ VDD VSS OAI21_X1
X_13861_ _04619_ _04745_ _09171_ VDD VSS XOR2_X2
X_13862_ _01929_ _03553_ _04746_ VDD VSS NOR2_X1
X_13863_ _09173_ _04746_ _04747_ VDD VSS XNOR2_X1
X_13864_ _09171_ _04747_ _03791_ _09195_ VDD VSS MUX2_X1
X_13865_ _09199_ _09197_ _09198_ _04748_ VDD VSS OR3_X1
X_13866_ _03813_ _04748_ _04749_ VDD VSS AND2_X1
X_13867_ _09195_ _04749_ _03991_ _09218_ VDD VSS MUX2_X1
X_13868_ _09220_ _04011_ _04750_ VDD VSS XNOR2_X1
X_13869_ _09218_ _04750_ _04135_ _09250_ VDD VSS MUX2_X1
X_13870_ _04743_ _09250_ _04357_ _09270_ VDD VSS MUX2_X1
X_13871_ _04452_ _04559_ _04751_ VDD VSS XNOR2_X1
X_13872_ _09270_ _04751_ _04666_ _09300_ VDD VSS MUX2_X1
X_13873_ _04742_ _09300_ net44 _09314_ VDD VSS OAI21_X1
X_13874_ _04636_ _04637_ _04642_ _04752_ VDD VSS AND3_X1
X_13875_ _04725_ _04752_ _04643_ _04753_ VDD VSS OAI21_X1
X_13876_ _09243_ _04141_ _04754_ VDD VSS XOR2_X1
X_13877_ _09199_ _04165_ _09221_ VDD VSS NOR2_X1
X_13878_ _04008_ _09223_ _09225_ _04755_ VDD VSS OR3_X1
X_13879_ _04158_ _04755_ _04756_ VDD VSS AND2_X1
X_13880_ _09221_ _04756_ _04135_ _09241_ VDD VSS MUX2_X1
X_13881_ _04754_ _09241_ _04357_ _09273_ VDD VSS MUX2_X1
X_13882_ _04558_ _04450_ _04757_ VDD VSS XNOR2_X1
X_13883_ _09273_ _04757_ _04666_ _09303_ VDD VSS MUX2_X1
X_13884_ _04753_ _09303_ net44 _09318_ VDD VSS OAI21_X2
X_13885_ _04738_ _04737_ _04758_ VDD VSS XNOR2_X1
X_13886_ _04725_ _04758_ _04759_ VDD VSS NAND2_X1
X_13887_ _09246_ _04393_ _04760_ VDD VSS XNOR2_X1
X_13888_ _03773_ _03889_ _01150_ _04761_ VDD VSS AOI21_X1
X_13889_ _04761_ _04744_ net23 _04762_ VDD VSS AOI21_X2
X_13890_ _03552_ _04762_ _09224_ VDD VSS XNOR2_X2
X_13891_ _04008_ _01710_ _04763_ VDD VSS XNOR2_X1
X_13892_ _09224_ _04763_ _04135_ _09244_ VDD VSS MUX2_X1
X_13893_ _04760_ _09244_ _04357_ _09276_ VDD VSS MUX2_X1
X_13894_ _04449_ _04556_ _04764_ VDD VSS XNOR2_X1
X_13895_ _09276_ _04764_ _04666_ _09306_ VDD VSS MUX2_X1
X_13896_ _04759_ _09306_ net44 _09322_ VDD VSS OAI21_X1
X_13897_ _04638_ _04639_ _04640_ _04765_ VDD VSS AND3_X1
X_13898_ _04725_ _04765_ _04641_ _04766_ VDD VSS OAI21_X2
X_13899_ _09240_ _04357_ _09262_ VDD VSS NOR2_X1
X_13900_ _09264_ _04446_ _04767_ VDD VSS XOR2_X1
X_13901_ _09262_ _04767_ _04666_ _09291_ VDD VSS MUX2_X1
X_13902_ _04766_ _09291_ net44 _09326_ VDD VSS OAI21_X2
X_13903_ _01095_ _09266_ _04666_ _04768_ VDD VSS MUX2_X1
X_13904_ _04768_ _09294_ VDD VSS INV_X2
X_13905_ _00860_ net87 _04769_ VDD VSS NAND2_X1
X_13906_ _09382_ _04770_ VDD VSS INV_X1
X_13907_ net86 _04771_ VDD VSS INV_X1
X_13908_ _00853_ _04770_ _04771_ _04772_ VDD VSS OAI21_X1
X_13909_ _00845_ _04769_ _04772_ _00012_ VDD VSS AOI21_X1
X_13910_ _00848_ _00849_ _00850_ _04773_ VDD VSS NAND3_X1
X_13911_ _09343_ _04773_ _04774_ VDD VSS AND2_X1
X_13912_ _09374_ group\[0\] _04774_ _09348_ VDD VSS AND3_X1
X_13913_ _00846_ _04775_ VDD VSS INV_X2
X_13914_ _04775_ _01109_ _04776_ VDD VSS NOR2_X4
X_13915_ _00842_ _00851_ _04776_ _04777_ VDD VSS AND3_X1
X_13916_ _04777_ _04778_ VDD VSS BUF_X4
X_13917_ _04778_ _04779_ VDD VSS BUF_X4
X_13918_ idx1\[0\] _00042_ _04779_ _00013_ VDD VSS MUX2_X1
X_13919_ _09374_ group\[1\] _04774_ _09350_ VDD VSS AND3_X1
X_13920_ group\[0\] _09365_ _04774_ _09353_ VDD VSS AND3_X1
X_13921_ idx1\[1\] _00043_ _04779_ _00014_ VDD VSS MUX2_X1
X_13922_ _09354_ _09356_ _04780_ VDD VSS XOR2_X1
X_13923_ butterfly_in_group\[2\] _09351_ _04781_ VDD VSS XNOR2_X1
X_13924_ _04780_ _04781_ _04782_ VDD VSS XNOR2_X1
X_13925_ _09374_ group\[2\] _04783_ VDD VSS NAND2_X1
X_13926_ group\[0\] _09371_ _04784_ VDD VSS NAND2_X1
X_13927_ group\[1\] _09365_ _04785_ VDD VSS NAND2_X1
X_13928_ _04784_ _04785_ _04786_ VDD VSS XOR2_X1
X_13929_ _04783_ _04786_ _04787_ VDD VSS XNOR2_X1
X_13930_ _04774_ _04787_ _04788_ VDD VSS NAND2_X1
X_13931_ _04782_ _04788_ _04789_ VDD VSS XNOR2_X2
X_13932_ idx1\[2\] _04789_ _04779_ _00015_ VDD VSS MUX2_X1
X_13933_ idx2\[0\] _04790_ VDD VSS BUF_X4
X_13934_ _04790_ _00044_ _04779_ _00016_ VDD VSS MUX2_X1
X_13935_ idx2\[1\] _04791_ VDD VSS BUF_X4
X_13936_ _00842_ _00851_ _04776_ _04792_ VDD VSS NAND3_X4
X_13937_ _04791_ _04792_ _04793_ VDD VSS NAND2_X1
X_13938_ _04793_ _04792_ _07366_ _00017_ VDD VSS OAI21_X1
X_13939_ idx2\[2\] _04794_ VDD VSS BUF_X4
X_13940_ _07365_ _09329_ _04795_ VDD VSS XNOR2_X1
X_13941_ _04789_ _04795_ _04796_ VDD VSS XNOR2_X1
X_13942_ _04794_ _04796_ _04779_ _00018_ VDD VSS MUX2_X1
X_13943_ twiddle_idx\[0\] _04792_ _04797_ VDD VSS NAND2_X1
X_13944_ _00849_ _04798_ VDD VSS INV_X1
X_13945_ _00848_ _04798_ butterfly_in_group\[2\] _09362_ _04799_
+ VDD VSS AND4_X1
X_13946_ butterfly_in_group\[0\] butterfly_in_group\[1\] _00849_
+ _04800_ VDD VSS MUX2_X1
X_13947_ _00848_ _09362_ _04801_ VDD VSS NOR2_X2
X_13948_ _04799_ _04800_ _04801_ _04802_ VDD VSS AOI21_X4
X_13949_ _04797_ _04802_ _04792_ _00006_ VDD VSS OAI21_X4
X_13950_ butterfly_in_group\[0\] butterfly_in_group\[2\] _00850_
+ _04803_ VDD VSS MUX2_X1
X_13951_ _00849_ _04803_ _04804_ VDD VSS NAND2_X1
X_13952_ _04798_ _00850_ butterfly_in_group\[1\] _04805_ VDD
+ VSS NAND3_X1
X_13953_ _04804_ _04805_ _04806_ VDD VSS NAND2_X1
X_13954_ twiddle_idx\[1\] _04806_ _04778_ _00019_ VDD VSS
+ MUX2_X2
X_13955_ _00006_ _00019_ _00007_ VDD VSS XNOR2_X1
X_13956_ _00019_ _00008_ VDD VSS INV_X1
X_13957_ _00033_ _04807_ VDD VSS CLKBUF_X3
X_13958_ _04807_ _04808_ VDD VSS CLKBUF_X3
X_13959_ _00005_ _04809_ VDD VSS BUF_X4
X_13960_ _00003_ _04810_ VDD VSS BUF_X4
Xclone52 _04812_ net52 VDD VSS BUF_X4
X_13962_ _00004_ _04812_ VDD VSS BUF_X16
X_13963_ samples_imag\[0\]\[0\] samples_imag\[2\]\[0\] net51
+ _04813_ VDD VSS MUX2_X1
X_13964_ _04810_ _04813_ _04814_ VDD VSS NOR2_X1
X_13965_ _00003_ _04815_ VDD VSS INV_X2
X_13966_ samples_imag\[1\]\[0\] samples_imag\[3\]\[0\] _00004_
+ _04816_ VDD VSS MUX2_X1
X_13967_ _04815_ _04816_ _04817_ VDD VSS NOR2_X1
X_13968_ _04809_ _04814_ _04817_ _04818_ VDD VSS NOR3_X2
X_13969_ samples_imag\[4\]\[0\] samples_imag\[6\]\[0\] net51
+ _04819_ VDD VSS MUX2_X1
X_13970_ samples_imag\[5\]\[0\] samples_imag\[7\]\[0\] net51
+ _04820_ VDD VSS MUX2_X1
X_13971_ _04819_ _04820_ _04810_ _04821_ VDD VSS MUX2_X1
X_13972_ _04818_ _04821_ _04809_ _04822_ VDD VSS AOI21_X4
X_13973_ _04808_ _04822_ _07701_ VDD VSS OR2_X1
X_13974_ _07701_ _09384_ VDD VSS INV_X2
X_13975_ _00032_ _04823_ VDD VSS BUF_X4
X_13976_ _04823_ _04824_ VDD VSS BUF_X4
X_13977_ _04824_ _04825_ VDD VSS BUF_X8
X_13978_ _04812_ _04826_ VDD VSS BUF_X8
X_13979_ _04826_ _04827_ VDD VSS BUF_X8
X_13980_ samples_real\[0\]\[13\] samples_real\[2\]\[13\] _04827_
+ _04828_ VDD VSS MUX2_X1
X_13981_ samples_real\[1\]\[13\] samples_real\[3\]\[13\] _04827_
+ _04829_ VDD VSS MUX2_X1
X_13982_ _04810_ _04830_ VDD VSS BUF_X4
X_13983_ _04828_ _04829_ _04830_ _04831_ VDD VSS MUX2_X1
X_13984_ samples_real\[4\]\[13\] samples_real\[6\]\[13\] _04827_
+ _04832_ VDD VSS MUX2_X1
X_13985_ samples_real\[5\]\[13\] samples_real\[7\]\[13\] _04827_
+ _04833_ VDD VSS MUX2_X1
X_13986_ _04810_ _04834_ VDD VSS BUF_X4
X_13987_ _04832_ _04833_ _04834_ _04835_ VDD VSS MUX2_X1
X_13988_ _04809_ _04836_ VDD VSS BUF_X8
X_13989_ _04836_ _04837_ VDD VSS BUF_X8
X_13990_ _04831_ _04835_ _04837_ _04838_ VDD VSS MUX2_X2
X_13991_ _04838_ _04839_ VDD VSS INV_X1
X_13992_ _04825_ _04839_ _09385_ VDD VSS NOR2_X1
X_13993_ _04812_ _04840_ VDD VSS BUF_X16
X_13994_ samples_imag\[0\]\[1\] samples_imag\[2\]\[1\] _04840_
+ _04841_ VDD VSS MUX2_X1
X_13995_ samples_imag\[1\]\[1\] samples_imag\[3\]\[1\] _04840_
+ _04842_ VDD VSS MUX2_X1
X_13996_ _04841_ _04842_ _04830_ _04843_ VDD VSS MUX2_X1
X_13997_ samples_imag\[4\]\[1\] samples_imag\[6\]\[1\] _04840_
+ _04844_ VDD VSS MUX2_X1
X_13998_ samples_imag\[5\]\[1\] samples_imag\[7\]\[1\] _04840_
+ _04845_ VDD VSS MUX2_X1
X_13999_ _04844_ _04845_ _04830_ _04846_ VDD VSS MUX2_X1
X_14000_ _04836_ _04847_ VDD VSS BUF_X8
X_14001_ _04843_ _04846_ _04847_ _04848_ VDD VSS MUX2_X2
X_14002_ _04848_ _04849_ VDD VSS INV_X2
X_14003_ _04807_ _04849_ _07377_ VDD VSS NOR2_X4
X_14004_ _00035_ _04850_ VDD VSS CLKBUF_X3
X_14005_ _04810_ _04851_ VDD VSS BUF_X4
X_14006_ _04812_ _04852_ VDD VSS BUF_X8
X_14007_ samples_imag\[0\]\[2\] samples_imag\[2\]\[2\] _04852_
+ _04853_ VDD VSS MUX2_X1
X_14008_ _04851_ _04853_ _04854_ VDD VSS NOR2_X1
X_14009_ _04815_ _04855_ VDD VSS CLKBUF_X3
X_14010_ samples_imag\[1\]\[2\] samples_imag\[3\]\[2\] _04852_
+ _04856_ VDD VSS MUX2_X1
X_14011_ _04855_ _04856_ _04857_ VDD VSS NOR2_X1
X_14012_ _04836_ _04854_ _04857_ _04858_ VDD VSS NOR3_X2
X_14013_ net51 _04859_ VDD VSS BUF_X4
X_14014_ samples_imag\[4\]\[2\] samples_imag\[6\]\[2\] _04859_
+ _04860_ VDD VSS MUX2_X1
X_14015_ samples_imag\[5\]\[2\] samples_imag\[7\]\[2\] _04859_
+ _04861_ VDD VSS MUX2_X1
X_14016_ _04810_ _04862_ VDD VSS BUF_X4
X_14017_ _04860_ _04861_ _04862_ _04863_ VDD VSS MUX2_X1
X_14018_ _04858_ _04863_ _04847_ _04864_ VDD VSS AOI21_X4
X_14019_ _04850_ _04864_ _07702_ VDD VSS OR2_X4
X_14020_ _07702_ _07443_ VDD VSS INV_X2
X_14021_ _00023_ _04865_ VDD VSS INV_X1
X_14022_ _04865_ _04849_ _07372_ VDD VSS NOR2_X4
X_14023_ _07372_ _07498_ VDD VSS INV_X2
X_14024_ _04808_ _04864_ _07499_ VDD VSS OR2_X1
X_14025_ _07499_ _07373_ VDD VSS INV_X2
X_14026_ _04837_ _04866_ VDD VSS BUF_X8
X_14027_ _04830_ _04867_ VDD VSS BUF_X4
X_14028_ _04867_ _04868_ VDD VSS BUF_X4
X_14029_ _04812_ _04869_ VDD VSS BUF_X16
X_14030_ _04869_ _04870_ VDD VSS BUF_X16
X_14031_ _04870_ _04871_ VDD VSS BUF_X16
X_14032_ samples_imag\[0\]\[3\] samples_imag\[2\]\[3\] _04871_
+ _04872_ VDD VSS MUX2_X1
X_14033_ _04868_ _04872_ _04873_ VDD VSS NOR2_X2
X_14034_ _04855_ _04874_ VDD VSS CLKBUF_X3
X_14035_ _04840_ _04875_ VDD VSS BUF_X8
X_14036_ samples_imag\[1\]\[3\] samples_imag\[3\]\[3\] _04875_
+ _04876_ VDD VSS MUX2_X1
X_14037_ _04874_ _04876_ _04877_ VDD VSS NOR2_X1
X_14038_ _04866_ _04873_ _04877_ _04878_ VDD VSS NOR3_X2
X_14039_ samples_imag\[4\]\[3\] samples_imag\[6\]\[3\] _04871_
+ _04879_ VDD VSS MUX2_X1
X_14040_ samples_imag\[5\]\[3\] samples_imag\[7\]\[3\] _04871_
+ _04880_ VDD VSS MUX2_X1
X_14041_ _04879_ _04880_ _04868_ _04881_ VDD VSS MUX2_X1
X_14042_ _04878_ _04881_ _04866_ _04882_ VDD VSS AOI21_X4
X_14043_ _04808_ _04882_ _07374_ VDD VSS NOR2_X2
X_14044_ _04812_ _04883_ VDD VSS BUF_X16
X_14045_ _04883_ _04884_ VDD VSS BUF_X8
X_14046_ samples_imag\[0\]\[4\] samples_imag\[2\]\[4\] _04884_
+ _04885_ VDD VSS MUX2_X1
X_14047_ _04867_ _04885_ _04886_ VDD VSS NOR2_X1
X_14048_ samples_imag\[1\]\[4\] samples_imag\[3\]\[4\] _04884_
+ _04887_ VDD VSS MUX2_X1
X_14049_ _04874_ _04887_ _04888_ VDD VSS NOR2_X1
X_14050_ _04837_ _04886_ _04888_ _04889_ VDD VSS NOR3_X2
X_14051_ samples_imag\[4\]\[4\] samples_imag\[6\]\[4\] net53
+ _04890_ VDD VSS MUX2_X1
X_14052_ samples_imag\[5\]\[4\] samples_imag\[7\]\[4\] _04870_
+ _04891_ VDD VSS MUX2_X1
X_14053_ _04890_ _04891_ _04867_ _04892_ VDD VSS MUX2_X1
X_14054_ _04847_ _04893_ VDD VSS BUF_X8
X_14055_ _04889_ _04892_ _04893_ _04894_ VDD VSS AOI21_X4
X_14056_ _04808_ _04894_ _07409_ VDD VSS NOR2_X2
X_14057_ _04850_ _04895_ VDD VSS BUF_X4
X_14058_ net51 _04896_ VDD VSS BUF_X4
X_14059_ samples_imag\[0\]\[5\] samples_imag\[2\]\[5\] _04896_
+ _04897_ VDD VSS MUX2_X1
X_14060_ _04862_ _04897_ _04898_ VDD VSS NOR2_X1
X_14061_ samples_imag\[1\]\[5\] samples_imag\[3\]\[5\] _04896_
+ _04899_ VDD VSS MUX2_X1
X_14062_ _04815_ _04899_ _04900_ VDD VSS NOR2_X1
X_14063_ _04836_ _04898_ _04900_ _04901_ VDD VSS NOR3_X2
X_14064_ samples_imag\[4\]\[5\] samples_imag\[6\]\[5\] _04826_
+ _04902_ VDD VSS MUX2_X1
X_14065_ samples_imag\[5\]\[5\] samples_imag\[7\]\[5\] _04826_
+ _04903_ VDD VSS MUX2_X1
X_14066_ _04902_ _04903_ _04810_ _04904_ VDD VSS MUX2_X1
X_14067_ _04809_ _04905_ VDD VSS BUF_X8
X_14068_ _04901_ _04904_ _04905_ _04906_ VDD VSS AOI21_X4
X_14069_ _04895_ _04906_ _07410_ VDD VSS NOR2_X4
X_14070_ _04895_ _04907_ VDD VSS BUF_X4
X_14071_ _04907_ _04894_ _07381_ VDD VSS NOR2_X4
X_14072_ _04808_ _04906_ _07382_ VDD VSS NOR2_X1
X_14073_ samples_imag\[0\]\[6\] samples_imag\[2\]\[6\] _04871_
+ _04908_ VDD VSS MUX2_X1
X_14074_ samples_imag\[1\]\[6\] samples_imag\[3\]\[6\] _04871_
+ _04909_ VDD VSS MUX2_X1
X_14075_ _04908_ _04909_ _04868_ _04910_ VDD VSS MUX2_X1
X_14076_ _04871_ _04911_ VDD VSS BUF_X16
X_14077_ samples_imag\[4\]\[6\] samples_imag\[6\]\[6\] _04911_
+ _04912_ VDD VSS MUX2_X1
X_14078_ samples_imag\[5\]\[6\] samples_imag\[7\]\[6\] _04911_
+ _04913_ VDD VSS MUX2_X1
X_14079_ _04912_ _04913_ _04868_ _04914_ VDD VSS MUX2_X1
X_14080_ _04910_ _04914_ _04866_ _04915_ VDD VSS MUX2_X2
X_14081_ _04915_ _04916_ VDD VSS INV_X4
X_14082_ _04916_ _04907_ _07383_ VDD VSS NOR2_X4
X_14083_ _04907_ _04822_ _07853_ VDD VSS OR2_X2
X_14084_ _07853_ _07378_ VDD VSS INV_X4
X_14085_ samples_real\[0\]\[12\] samples_real\[2\]\[12\] _04896_
+ _04917_ VDD VSS MUX2_X1
X_14086_ _04862_ _04917_ _04918_ VDD VSS NOR2_X1
X_14087_ samples_real\[1\]\[12\] samples_real\[3\]\[12\] _04896_
+ _04919_ VDD VSS MUX2_X1
X_14088_ _04815_ _04919_ _04920_ VDD VSS NOR2_X1
X_14089_ _04836_ _04918_ _04920_ _04921_ VDD VSS NOR3_X2
X_14090_ samples_real\[4\]\[12\] samples_real\[6\]\[12\] _04852_
+ _04922_ VDD VSS MUX2_X1
X_14091_ samples_real\[5\]\[12\] samples_real\[7\]\[12\] _04852_
+ _04923_ VDD VSS MUX2_X1
X_14092_ _04922_ _04923_ _04810_ _04924_ VDD VSS MUX2_X1
X_14093_ _04921_ _04924_ _04905_ _04925_ VDD VSS AOI21_X4
X_14094_ _04825_ _04925_ _07481_ VDD VSS NOR2_X2
X_14095_ _04907_ _04882_ _07500_ VDD VSS OR2_X2
X_14096_ _07500_ _07411_ VDD VSS INV_X2
X_14097_ _00024_ _04915_ _09390_ VDD VSS AND2_X1
X_14098_ _09390_ _07422_ VDD VSS INV_X1
X_14099_ samples_imag\[0\]\[7\] samples_imag\[2\]\[7\] _04827_
+ _04926_ VDD VSS MUX2_X1
X_14100_ _04834_ _04926_ _04927_ VDD VSS NOR2_X1
X_14101_ samples_imag\[1\]\[7\] samples_imag\[3\]\[7\] _04840_
+ _04928_ VDD VSS MUX2_X1
X_14102_ _04855_ _04928_ _04929_ VDD VSS NOR2_X1
X_14103_ _04837_ _04927_ _04929_ _04930_ VDD VSS NOR3_X2
X_14104_ samples_imag\[4\]\[7\] samples_imag\[6\]\[7\] _04884_
+ _04931_ VDD VSS MUX2_X1
X_14105_ samples_imag\[5\]\[7\] samples_imag\[7\]\[7\] _04884_
+ _04932_ VDD VSS MUX2_X1
X_14106_ _04931_ _04932_ _04834_ _04933_ VDD VSS MUX2_X1
X_14107_ _04930_ _04933_ _04893_ _04934_ VDD VSS AOI21_X4
X_14108_ _04907_ _04934_ _07423_ VDD VSS OR2_X2
X_14109_ _07423_ _07449_ VDD VSS INV_X2
X_14110_ _04934_ _04935_ VDD VSS INV_X1
X_14111_ _00024_ _04935_ _07396_ VDD VSS NAND2_X1
X_14112_ samples_imag\[0\]\[8\] samples_imag\[2\]\[8\] _04870_
+ _04936_ VDD VSS MUX2_X1
X_14113_ _04867_ _04936_ _04937_ VDD VSS NOR2_X1
X_14114_ samples_imag\[1\]\[8\] samples_imag\[3\]\[8\] _04870_
+ _04938_ VDD VSS MUX2_X1
X_14115_ _04874_ _04938_ _04939_ VDD VSS NOR2_X1
X_14116_ _04893_ _04937_ _04939_ _04940_ VDD VSS NOR3_X2
X_14117_ samples_imag\[4\]\[8\] samples_imag\[6\]\[8\] _04875_
+ _04941_ VDD VSS MUX2_X1
X_14118_ samples_imag\[5\]\[8\] samples_imag\[7\]\[8\] _04875_
+ _04942_ VDD VSS MUX2_X1
X_14119_ _04941_ _04942_ _04867_ _04943_ VDD VSS MUX2_X1
X_14120_ _04940_ _04943_ _04893_ _04944_ VDD VSS AOI21_X4
X_14121_ _04907_ _04944_ _07397_ VDD VSS OR2_X2
X_14122_ _07397_ _07552_ VDD VSS INV_X1
X_14123_ samples_imag\[0\]\[9\] samples_imag\[2\]\[9\] _04871_
+ _04945_ VDD VSS MUX2_X1
X_14124_ _04868_ _04945_ _04946_ VDD VSS NOR2_X1
X_14125_ samples_imag\[1\]\[9\] samples_imag\[3\]\[9\] _04871_
+ _04947_ VDD VSS MUX2_X1
X_14126_ _04874_ _04947_ _04948_ VDD VSS NOR2_X1
X_14127_ _04866_ _04946_ _04948_ _04949_ VDD VSS NOR3_X2
X_14128_ samples_imag\[4\]\[9\] samples_imag\[6\]\[9\] _04911_
+ _04950_ VDD VSS MUX2_X1
X_14129_ samples_imag\[5\]\[9\] samples_imag\[7\]\[9\] _04911_
+ _04951_ VDD VSS MUX2_X1
X_14130_ _04950_ _04951_ _04868_ _04952_ VDD VSS MUX2_X1
X_14131_ _04949_ _04952_ _04866_ _04953_ VDD VSS AOI21_X4
X_14132_ _04907_ _04953_ _07398_ VDD VSS OR2_X2
X_14133_ _07398_ _07391_ VDD VSS INV_X1
X_14134_ samples_imag\[0\]\[10\] samples_imag\[2\]\[10\] _04871_
+ _04954_ VDD VSS MUX2_X1
X_14135_ _04868_ _04954_ _04955_ VDD VSS NOR2_X1
X_14136_ samples_imag\[1\]\[10\] samples_imag\[3\]\[10\] _04871_
+ _04956_ VDD VSS MUX2_X1
X_14137_ _04874_ _04956_ _04957_ VDD VSS NOR2_X1
X_14138_ _04866_ _04955_ _04957_ _04958_ VDD VSS NOR3_X2
X_14139_ samples_imag\[4\]\[10\] samples_imag\[6\]\[10\] _04911_
+ _04959_ VDD VSS MUX2_X1
X_14140_ samples_imag\[5\]\[10\] samples_imag\[7\]\[10\] _04911_
+ _04960_ VDD VSS MUX2_X1
X_14141_ _04959_ _04960_ _04868_ _04961_ VDD VSS MUX2_X1
X_14142_ _04958_ _04866_ _04961_ _04962_ VDD VSS AOI21_X4
X_14143_ _04907_ _04962_ _07451_ VDD VSS OR2_X1
X_14144_ _07451_ _07392_ VDD VSS INV_X1
X_14145_ samples_imag\[0\]\[11\] samples_imag\[2\]\[11\] _04911_
+ _04963_ VDD VSS MUX2_X1
X_14146_ _04868_ _04963_ _04964_ VDD VSS NOR2_X1
X_14147_ samples_imag\[1\]\[11\] samples_imag\[3\]\[11\] _04911_
+ _04965_ VDD VSS MUX2_X1
X_14148_ _04874_ _04965_ _04966_ VDD VSS NOR2_X1
X_14149_ _04866_ _04964_ _04966_ _04967_ VDD VSS NOR3_X2
X_14150_ samples_imag\[4\]\[11\] samples_imag\[6\]\[11\] _04911_
+ _04968_ VDD VSS MUX2_X1
X_14151_ samples_imag\[5\]\[11\] samples_imag\[7\]\[11\] _04911_
+ _04969_ VDD VSS MUX2_X1
X_14152_ _04968_ _04969_ _04868_ _04970_ VDD VSS MUX2_X1
X_14153_ _04967_ _04970_ _04866_ _04971_ VDD VSS AOI21_X4
X_14154_ _04907_ _04971_ _07393_ VDD VSS NOR2_X1
X_14155_ samples_imag\[0\]\[12\] samples_imag\[2\]\[12\] _04884_
+ _04972_ VDD VSS MUX2_X1
X_14156_ _04867_ _04972_ _04973_ VDD VSS NOR2_X1
X_14157_ samples_imag\[1\]\[12\] samples_imag\[3\]\[12\] _04884_
+ _04974_ VDD VSS MUX2_X1
X_14158_ _04874_ _04974_ _04975_ VDD VSS NOR2_X1
X_14159_ _04837_ _04973_ _04975_ _04976_ VDD VSS NOR3_X2
X_14160_ samples_imag\[4\]\[12\] samples_imag\[6\]\[12\] net53
+ _04977_ VDD VSS MUX2_X1
X_14161_ samples_imag\[5\]\[12\] samples_imag\[7\]\[12\] net53
+ _04978_ VDD VSS MUX2_X1
X_14162_ _04977_ _04978_ _04834_ _04979_ VDD VSS MUX2_X1
X_14163_ _04976_ _04979_ _04893_ _04980_ VDD VSS AOI21_X4
X_14164_ _04895_ _04980_ _07401_ VDD VSS NOR2_X1
X_14165_ _04823_ _04981_ VDD VSS INV_X4
X_14166_ samples_real\[0\]\[11\] samples_real\[2\]\[11\] _04896_
+ _04982_ VDD VSS MUX2_X1
X_14167_ _04810_ _04982_ _04983_ VDD VSS NOR2_X1
X_14168_ samples_real\[1\]\[11\] samples_real\[3\]\[11\] _04896_
+ _04984_ VDD VSS MUX2_X1
X_14169_ _04815_ _04984_ _04985_ VDD VSS NOR2_X1
X_14170_ _04836_ _04983_ _04985_ _04986_ VDD VSS NOR3_X2
X_14171_ samples_real\[4\]\[11\] samples_real\[6\]\[11\] _04852_
+ _04987_ VDD VSS MUX2_X1
X_14172_ samples_real\[5\]\[11\] samples_real\[7\]\[11\] _04826_
+ _04988_ VDD VSS MUX2_X1
X_14173_ _04987_ _04988_ _04810_ _04989_ VDD VSS MUX2_X1
X_14174_ _04986_ _04989_ _04905_ _04990_ VDD VSS AOI21_X2
X_14175_ _04990_ _04991_ VDD VSS INV_X1
X_14176_ _04981_ _04991_ _07471_ VDD VSS NAND2_X1
X_14177_ _07471_ _07529_ VDD VSS INV_X1
X_14178_ _00036_ _04992_ VDD VSS CLKBUF_X3
X_14179_ samples_imag\[0\]\[13\] samples_imag\[2\]\[13\] _04827_
+ _04993_ VDD VSS MUX2_X1
X_14180_ _04834_ _04993_ _04994_ VDD VSS NOR2_X1
X_14181_ samples_imag\[1\]\[13\] samples_imag\[3\]\[13\] _04827_
+ _04995_ VDD VSS MUX2_X1
X_14182_ _04874_ _04995_ _04996_ VDD VSS NOR2_X1
X_14183_ _04837_ _04994_ _04996_ _04997_ VDD VSS NOR3_X2
X_14184_ samples_imag\[4\]\[13\] samples_imag\[6\]\[13\] net53
+ _04998_ VDD VSS MUX2_X1
X_14185_ samples_imag\[5\]\[13\] samples_imag\[7\]\[13\] net53
+ _04999_ VDD VSS MUX2_X1
X_14186_ _04998_ _04999_ _04834_ _05000_ VDD VSS MUX2_X1
X_14187_ _04997_ _05000_ _04893_ _05001_ VDD VSS AOI21_X4
X_14188_ _04992_ _05001_ _09394_ VDD VSS NOR2_X1
X_14189_ samples_imag\[0\]\[14\] samples_imag\[2\]\[14\] _04883_
+ _05002_ VDD VSS MUX2_X1
X_14190_ _04830_ _05002_ _05003_ VDD VSS NOR2_X1
X_14191_ samples_imag\[1\]\[14\] samples_imag\[3\]\[14\] _04883_
+ _05004_ VDD VSS MUX2_X1
X_14192_ _04855_ _05004_ _05005_ VDD VSS NOR2_X1
X_14193_ _04905_ _05003_ _05005_ _05006_ VDD VSS NOR3_X2
X_14194_ samples_imag\[4\]\[14\] samples_imag\[6\]\[14\] net52
+ _05007_ VDD VSS MUX2_X1
X_14195_ samples_imag\[5\]\[14\] samples_imag\[7\]\[14\] _04869_
+ _05008_ VDD VSS MUX2_X1
X_14196_ _05007_ _05008_ _04830_ _05009_ VDD VSS MUX2_X1
X_14197_ _05006_ _05009_ _04837_ _05010_ VDD VSS AOI21_X4
X_14198_ _00037_ _05010_ _09395_ VDD VSS NOR2_X1
X_14199_ samples_real\[0\]\[2\] samples_real\[2\]\[2\] _04827_
+ _05011_ VDD VSS MUX2_X1
X_14200_ _04834_ _05011_ _05012_ VDD VSS NOR2_X2
X_14201_ samples_real\[1\]\[2\] samples_real\[3\]\[2\] _04827_
+ _05013_ VDD VSS MUX2_X1
X_14202_ _04874_ _05013_ _05014_ VDD VSS NOR2_X2
X_14203_ _04837_ _05012_ _05014_ _05015_ VDD VSS NOR3_X2
X_14204_ samples_real\[4\]\[2\] samples_real\[6\]\[2\] _04884_
+ _05016_ VDD VSS MUX2_X1
X_14205_ samples_real\[5\]\[2\] samples_real\[7\]\[2\] _04884_
+ _05017_ VDD VSS MUX2_X1
X_14206_ _05016_ _05017_ _04834_ _05018_ VDD VSS MUX2_X1
X_14207_ _05015_ _05018_ _04893_ _05019_ VDD VSS AOI21_X4
X_14208_ _04823_ _05019_ _07559_ VDD VSS NOR2_X4
X_14209_ samples_real\[0\]\[1\] samples_real\[2\]\[1\] _04827_
+ _05020_ VDD VSS MUX2_X1
X_14210_ _04834_ _05020_ _05021_ VDD VSS NOR2_X1
X_14211_ samples_real\[1\]\[1\] samples_real\[3\]\[1\] _04840_
+ _05022_ VDD VSS MUX2_X1
X_14212_ _04855_ _05022_ _05023_ VDD VSS NOR2_X1
X_14213_ _04837_ _05021_ _05023_ _05024_ VDD VSS NOR3_X2
X_14214_ samples_real\[4\]\[1\] samples_real\[6\]\[1\] _04884_
+ _05025_ VDD VSS MUX2_X1
X_14215_ samples_real\[5\]\[1\] samples_real\[7\]\[1\] _04884_
+ _05026_ VDD VSS MUX2_X1
X_14216_ _05025_ _05026_ _04834_ _05027_ VDD VSS MUX2_X1
X_14217_ _05024_ _04893_ _05027_ _05028_ VDD VSS AOI21_X4
X_14218_ _04825_ _05028_ _07603_ VDD VSS NOR2_X4
X_14219_ samples_real\[0\]\[4\] samples_real\[2\]\[4\] _04852_
+ _05029_ VDD VSS MUX2_X1
X_14220_ _04862_ _05029_ _05030_ VDD VSS NOR2_X1
X_14221_ samples_real\[1\]\[4\] samples_real\[3\]\[4\] _04896_
+ _05031_ VDD VSS MUX2_X1
X_14222_ _04815_ _05031_ _05032_ VDD VSS NOR2_X1
X_14223_ _04836_ _05030_ _05032_ _05033_ VDD VSS NOR3_X2
X_14224_ samples_real\[4\]\[4\] samples_real\[6\]\[4\] _04859_
+ _05034_ VDD VSS MUX2_X1
X_14225_ samples_real\[5\]\[4\] samples_real\[7\]\[4\] _04859_
+ _05035_ VDD VSS MUX2_X1
X_14226_ _05034_ _05035_ _04862_ _05036_ VDD VSS MUX2_X1
X_14227_ _05033_ _05036_ _04847_ _05037_ VDD VSS AOI21_X4
X_14228_ _04825_ _05037_ _07671_ VDD VSS NOR2_X4
X_14229_ samples_real\[0\]\[10\] samples_real\[2\]\[10\] _04875_
+ _05038_ VDD VSS MUX2_X1
X_14230_ _04867_ _05038_ _05039_ VDD VSS NOR2_X1
X_14231_ samples_real\[1\]\[10\] samples_real\[3\]\[10\] _04870_
+ _05040_ VDD VSS MUX2_X1
X_14232_ _04874_ _05040_ _05041_ VDD VSS NOR2_X1
X_14233_ _04893_ _05039_ _05041_ _05042_ VDD VSS NOR3_X2
X_14234_ samples_real\[4\]\[10\] samples_real\[6\]\[10\] _04875_
+ _05043_ VDD VSS MUX2_X1
X_14235_ samples_real\[5\]\[10\] samples_real\[7\]\[10\] _04875_
+ _05044_ VDD VSS MUX2_X1
X_14236_ _05043_ _05044_ _04867_ _05045_ VDD VSS MUX2_X1
X_14237_ _05042_ _04866_ _05045_ _05046_ VDD VSS AOI21_X4
X_14238_ _04825_ _05046_ _07472_ VDD VSS NOR2_X4
X_14239_ samples_real\[0\]\[0\] samples_real\[2\]\[0\] _04826_
+ _05047_ VDD VSS MUX2_X1
X_14240_ _04851_ _05047_ _05048_ VDD VSS NOR2_X1
X_14241_ samples_real\[1\]\[0\] samples_real\[3\]\[0\] _04826_
+ _05049_ VDD VSS MUX2_X1
X_14242_ _04855_ _05049_ _05050_ VDD VSS NOR2_X1
X_14243_ _04905_ _05048_ _05050_ _05051_ VDD VSS NOR3_X2
X_14244_ samples_real\[4\]\[0\] samples_real\[6\]\[0\] _04883_
+ _05052_ VDD VSS MUX2_X1
X_14245_ samples_real\[5\]\[0\] samples_real\[7\]\[0\] _04883_
+ _05053_ VDD VSS MUX2_X1
X_14246_ _05052_ _05053_ _04851_ _05054_ VDD VSS MUX2_X1
X_14247_ _05051_ _05054_ _04847_ _05055_ VDD VSS AOI21_X4
X_14248_ _04823_ _05055_ _07653_ VDD VSS NOR2_X4
X_14249_ samples_real\[0\]\[3\] samples_real\[2\]\[3\] _04852_
+ _05056_ VDD VSS MUX2_X1
X_14250_ _04851_ _05056_ _05057_ VDD VSS NOR2_X1
X_14251_ samples_real\[1\]\[3\] samples_real\[3\]\[3\] _04896_
+ _05058_ VDD VSS MUX2_X1
X_14252_ _04855_ _05058_ _05059_ VDD VSS NOR2_X1
X_14253_ _04836_ _05057_ _05059_ _05060_ VDD VSS NOR3_X2
X_14254_ samples_real\[4\]\[3\] samples_real\[6\]\[3\] _04859_
+ _05061_ VDD VSS MUX2_X1
X_14255_ samples_real\[5\]\[3\] samples_real\[7\]\[3\] _04859_
+ _05062_ VDD VSS MUX2_X1
X_14256_ _05061_ _05062_ _04862_ _05063_ VDD VSS MUX2_X1
X_14257_ _05060_ _05063_ _04847_ _05064_ VDD VSS AOI21_X4
X_14258_ _04825_ _05064_ _07718_ VDD VSS NOR2_X4
X_14259_ samples_real\[0\]\[5\] samples_real\[2\]\[5\] _04826_
+ _05065_ VDD VSS MUX2_X1
X_14260_ _04851_ _05065_ _05066_ VDD VSS NOR2_X1
X_14261_ samples_real\[1\]\[5\] samples_real\[3\]\[5\] _04852_
+ _05067_ VDD VSS MUX2_X1
X_14262_ _04855_ _05067_ _05068_ VDD VSS NOR2_X1
X_14263_ _04905_ _05066_ _05068_ _05069_ VDD VSS NOR3_X2
X_14264_ samples_real\[4\]\[5\] samples_real\[6\]\[5\] _04883_
+ _05070_ VDD VSS MUX2_X1
X_14265_ samples_real\[5\]\[5\] samples_real\[7\]\[5\] _04883_
+ _05071_ VDD VSS MUX2_X1
X_14266_ _05070_ _05071_ _04851_ _05072_ VDD VSS MUX2_X1
X_14267_ _05069_ _05072_ _04847_ _05073_ VDD VSS AOI21_X4
X_14268_ _04825_ _05073_ _07621_ VDD VSS NOR2_X4
X_14269_ samples_real\[0\]\[7\] samples_real\[2\]\[7\] _04852_
+ _05074_ VDD VSS MUX2_X1
X_14270_ _04862_ _05074_ _05075_ VDD VSS NOR2_X1
X_14271_ samples_real\[1\]\[7\] samples_real\[3\]\[7\] _04896_
+ _05076_ VDD VSS MUX2_X1
X_14272_ _04815_ _05076_ _05077_ VDD VSS NOR2_X1
X_14273_ _04836_ _05075_ _05077_ _05078_ VDD VSS NOR3_X2
X_14274_ samples_real\[4\]\[7\] samples_real\[6\]\[7\] _04826_
+ _05079_ VDD VSS MUX2_X1
X_14275_ samples_real\[5\]\[7\] samples_real\[7\]\[7\] _04859_
+ _05080_ VDD VSS MUX2_X1
X_14276_ _05079_ _05080_ _04862_ _05081_ VDD VSS MUX2_X1
X_14277_ _05078_ _05081_ _04905_ _05082_ VDD VSS AOI21_X4
X_14278_ _04825_ _05082_ _07533_ VDD VSS NOR2_X4
X_14279_ samples_real\[0\]\[8\] samples_real\[2\]\[8\] _04883_
+ _05083_ VDD VSS MUX2_X1
X_14280_ _04830_ _05083_ _05084_ VDD VSS NOR2_X1
X_14281_ samples_real\[1\]\[8\] samples_real\[3\]\[8\] _04859_
+ _05085_ VDD VSS MUX2_X1
X_14282_ _04855_ _05085_ _05086_ VDD VSS NOR2_X1
X_14283_ _04905_ _05084_ _05086_ _05087_ VDD VSS NOR3_X2
X_14284_ samples_real\[4\]\[8\] samples_real\[6\]\[8\] _04869_
+ _05088_ VDD VSS MUX2_X1
X_14285_ samples_real\[5\]\[8\] samples_real\[7\]\[8\] _04869_
+ _05089_ VDD VSS MUX2_X1
X_14286_ _05088_ _05089_ _04851_ _05090_ VDD VSS MUX2_X1
X_14287_ _05087_ _05090_ _04837_ _05091_ VDD VSS AOI21_X4
X_14288_ _04825_ _05091_ _07485_ VDD VSS NOR2_X4
X_14289_ samples_real\[0\]\[6\] samples_real\[2\]\[6\] _04852_
+ _05092_ VDD VSS MUX2_X1
X_14290_ _04862_ _05092_ _05093_ VDD VSS NOR2_X2
X_14291_ samples_real\[1\]\[6\] samples_real\[3\]\[6\] _04896_
+ _05094_ VDD VSS MUX2_X1
X_14292_ _04815_ _05094_ _05095_ VDD VSS NOR2_X2
X_14293_ _04836_ _05093_ _05095_ _05096_ VDD VSS NOR3_X4
X_14294_ samples_real\[4\]\[6\] samples_real\[6\]\[6\] _04826_
+ _05097_ VDD VSS MUX2_X1
X_14295_ samples_real\[5\]\[6\] samples_real\[7\]\[6\] _04826_
+ _05098_ VDD VSS MUX2_X1
X_14296_ _05097_ _05098_ _04862_ _05099_ VDD VSS MUX2_X1
X_14297_ _05096_ _05099_ _04905_ _05100_ VDD VSS AOI21_X4
X_14298_ _04825_ _05100_ _07578_ VDD VSS NOR2_X4
X_14299_ samples_real\[0\]\[9\] samples_real\[2\]\[9\] _04859_
+ _05101_ VDD VSS MUX2_X1
X_14300_ _04851_ _05101_ _05102_ VDD VSS NOR2_X1
X_14301_ samples_real\[1\]\[9\] samples_real\[3\]\[9\] _04859_
+ _05103_ VDD VSS MUX2_X1
X_14302_ _04855_ _05103_ _05104_ VDD VSS NOR2_X1
X_14303_ _04905_ _05102_ _05104_ _05105_ VDD VSS NOR3_X4
X_14304_ samples_real\[4\]\[9\] samples_real\[6\]\[9\] _04883_
+ _05106_ VDD VSS MUX2_X1
X_14305_ samples_real\[5\]\[9\] samples_real\[7\]\[9\] _04883_
+ _05107_ VDD VSS MUX2_X1
X_14306_ _05106_ _05107_ _04851_ _05108_ VDD VSS MUX2_X1
X_14307_ _05105_ _05108_ _04847_ _05109_ VDD VSS AOI21_X4
X_14308_ _04824_ _05109_ _07473_ VDD VSS NOR2_X4
X_14309_ _09580_ _07653_ _09581_ VDD VSS AND2_X1
X_14310_ _04823_ _04864_ _08332_ VDD VSS OR2_X4
X_14311_ _08332_ _08285_ VDD VSS INV_X2
X_14312_ _04981_ _04848_ _08333_ VDD VSS NAND2_X4
X_14313_ _08333_ _08336_ VDD VSS INV_X4
X_14314_ _04823_ _04906_ _08105_ VDD VSS OR2_X4
X_14315_ _08105_ _08108_ VDD VSS INV_X2
X_14316_ _05046_ _04907_ _08077_ VDD VSS OR2_X2
X_14317_ _08077_ _07989_ VDD VSS INV_X1
X_14318_ _04823_ _04822_ _08424_ VDD VSS OR2_X4
X_14319_ _08424_ _08426_ VDD VSS INV_X4
X_14320_ _04824_ _04894_ _08168_ VDD VSS OR2_X4
X_14321_ _08168_ _07921_ VDD VSS INV_X2
X_14322_ _04981_ _04935_ _07953_ VDD VSS NAND2_X4
X_14323_ _07953_ _07956_ VDD VSS INV_X1
X_14324_ _04981_ _04915_ _08040_ VDD VSS NAND2_X4
X_14325_ _08040_ _08043_ VDD VSS INV_X2
X_14326_ _04824_ _04944_ _07928_ VDD VSS OR2_X4
X_14327_ _07928_ _07933_ VDD VSS INV_X1
X_14328_ _04953_ _04824_ _07929_ VDD VSS OR2_X4
X_14329_ _07929_ _07914_ VDD VSS INV_X2
X_14330_ _04824_ _04962_ _07930_ VDD VSS OR2_X4
X_14331_ _07930_ _07915_ VDD VSS INV_X1
X_14332_ _04824_ _04971_ _07916_ VDD VSS NOR2_X2
X_14333_ _04824_ net437 _08230_ VDD VSS OR2_X4
X_14334_ _08230_ _08233_ VDD VSS INV_X2
X_14335_ _04824_ _04980_ _09592_ VDD VSS NOR2_X2
X_14336_ _04824_ _05001_ _09593_ VDD VSS NOR2_X1
X_14337_ _05028_ _04807_ _08126_ VDD VSS OR2_X2
X_14338_ _08126_ _07967_ VDD VSS INV_X2
X_14339_ _04895_ _05028_ _08190_ VDD VSS OR2_X2
X_14340_ _08190_ _08352_ VDD VSS INV_X2
X_14341_ _04808_ _05055_ _08191_ VDD VSS OR2_X1
X_14342_ _08191_ _08054_ VDD VSS INV_X2
X_14343_ _04850_ _05019_ _08127_ VDD VSS OR2_X4
X_14344_ _08127_ _08055_ VDD VSS INV_X2
X_14345_ _04807_ _05064_ _08004_ VDD VSS OR2_X2
X_14346_ _08004_ _07939_ VDD VSS INV_X1
X_14347_ _04808_ _05019_ _08065_ VDD VSS OR2_X4
X_14348_ _08065_ _07940_ VDD VSS INV_X1
X_14349_ _04895_ _05037_ _08005_ VDD VSS OR2_X2
X_14350_ _08005_ _07941_ VDD VSS INV_X2
X_14351_ _04850_ _05109_ _08135_ VDD VSS OR2_X2
X_14352_ _08135_ _07990_ VDD VSS INV_X1
X_14353_ _04895_ _05055_ _08536_ VDD VSS OR2_X2
X_14354_ _08536_ _08234_ VDD VSS INV_X4
X_14355_ _04895_ _05064_ _08066_ VDD VSS OR2_X2
X_14356_ _08066_ _07968_ VDD VSS INV_X2
X_14357_ _04850_ _05073_ _07985_ VDD VSS OR2_X2
X_14358_ _07985_ _08133_ VDD VSS INV_X2
X_14359_ _04850_ _05082_ _08256_ VDD VSS OR2_X2
X_14360_ _08256_ _08017_ VDD VSS INV_X2
X_14361_ _05073_ _04808_ _08006_ VDD VSS OR2_X1
X_14362_ _08006_ _07976_ VDD VSS INV_X1
X_14363_ _05100_ _04895_ _08303_ VDD VSS OR2_X2
X_14364_ _08303_ _07977_ VDD VSS INV_X2
X_14365_ _04808_ _05082_ _07978_ VDD VSS NOR2_X1
X_14366_ _04895_ _05091_ _08198_ VDD VSS OR2_X2
X_14367_ _08198_ _07991_ VDD VSS INV_X1
X_14368_ _00022_ _05110_ VDD VSS CLKBUF_X3
X_14369_ samples_real\[0\]\[14\] samples_real\[2\]\[14\] _04869_
+ _05111_ VDD VSS MUX2_X1
X_14370_ samples_real\[1\]\[14\] samples_real\[3\]\[14\] _04840_
+ _05112_ VDD VSS MUX2_X1
X_14371_ _05111_ _05112_ _04830_ _05113_ VDD VSS MUX2_X1
X_14372_ samples_real\[4\]\[14\] samples_real\[6\]\[14\] _04840_
+ _05114_ VDD VSS MUX2_X1
X_14373_ samples_real\[5\]\[14\] samples_real\[7\]\[14\] _04840_
+ _05115_ VDD VSS MUX2_X1
X_14374_ _05114_ _05115_ _04830_ _05116_ VDD VSS MUX2_X1
X_14375_ _05113_ _05116_ _04847_ _05117_ VDD VSS MUX2_X1
X_14376_ _05110_ _05117_ _07995_ VDD VSS NAND2_X1
X_14377_ _05110_ _04838_ _08020_ VDD VSS NAND2_X1
X_14378_ _04925_ _05118_ VDD VSS INV_X1
X_14379_ _05110_ _05118_ _08078_ VDD VSS NAND2_X1
X_14380_ _05110_ _04991_ _08136_ VDD VSS NAND2_X1
X_14381_ _05046_ _05119_ VDD VSS INV_X1
X_14382_ _05110_ _05119_ _08199_ VDD VSS NAND2_X1
X_14383_ _08242_ _09637_ VDD VSS INV_X1
X_14384_ _05109_ _05120_ VDD VSS INV_X1
X_14385_ _05110_ _05120_ _08257_ VDD VSS NAND2_X1
X_14386_ _05091_ _05121_ VDD VSS INV_X1
X_14387_ _05110_ _05121_ _08304_ VDD VSS NAND2_X1
X_14388_ _04992_ _05100_ _08355_ VDD VSS NOR2_X1
X_14389_ _05110_ _05122_ VDD VSS INV_X2
X_14390_ _05122_ _05100_ _08394_ VDD VSS OR2_X1
X_14391_ _05073_ _05123_ VDD VSS INV_X1
X_14392_ _05110_ _05123_ _08448_ VDD VSS NAND2_X1
X_14393_ _00037_ _05037_ _08493_ VDD VSS NOR2_X1
X_14394_ _04992_ _05064_ _08494_ VDD VSS NOR2_X1
X_14395_ _05122_ _05064_ _08515_ VDD VSS OR2_X1
X_14396_ _05019_ _05124_ VDD VSS INV_X1
X_14397_ _05110_ _05124_ _08537_ VDD VSS NAND2_X1
X_14398_ _00845_ _04775_ _00851_ _00009_ VDD VSS NOR3_X2
X_14399_ _09406_ _07476_ VDD VSS INV_X1
X_14400_ _09460_ _07659_ VDD VSS INV_X1
X_14401_ _09473_ _07710_ VDD VSS INV_X1
X_14402_ _09489_ _07753_ VDD VSS INV_X1
X_14403_ _09502_ _07792_ VDD VSS INV_X1
X_14404_ _09519_ _07833_ VDD VSS INV_X1
X_14405_ _07746_ _07742_ VDD VSS INV_X1
X_14406_ _09521_ _07877_ VDD VSS INV_X1
X_14407_ _04850_ _04925_ _07994_ VDD VSS OR2_X1
X_14408_ _09600_ _07999_ VDD VSS INV_X1
X_14409_ _04807_ _05037_ _07984_ VDD VSS OR2_X2
X_14410_ _08059_ _08086_ VDD VSS INV_X1
X_14411_ _08138_ _08140_ VDD VSS INV_X1
X_14412_ _08120_ _08144_ VDD VSS INV_X1
X_14413_ _08297_ _08292_ VDD VSS INV_X1
X_14414_ _08280_ _08320_ VDD VSS INV_X1
X_14415_ _08447_ _08444_ VDD VSS INV_X1
X_14416_ _08501_ _08497_ VDD VSS INV_X1
X_14417_ _08513_ _08532_ VDD VSS INV_X1
X_14418_ _08629_ _07348_ VDD VSS INV_X1
X_14419_ _08710_ _07356_ VDD VSS INV_X1
X_14420_ _09403_ _07495_ VDD VSS INV_X1
X_14421_ _09419_ _07525_ VDD VSS INV_X1
X_14422_ _09432_ _07572_ VDD VSS INV_X1
X_14423_ _09444_ _07615_ VDD VSS INV_X1
X_14424_ _09457_ _07665_ VDD VSS INV_X1
X_14425_ _09462_ _07694_ VDD VSS INV_X1
X_14426_ _09551_ _07878_ VDD VSS INV_X1
X_14427_ _09562_ _07905_ VDD VSS INV_X1
X_14428_ _07913_ _07908_ VDD VSS INV_X1
X_14429_ _09601_ _08062_ VDD VSS INV_X1
X_14430_ _09606_ _08124_ VDD VSS INV_X1
X_14431_ _08125_ _08145_ VDD VSS INV_X1
X_14432_ _09614_ _08187_ VDD VSS INV_X1
X_14433_ _09625_ _08249_ VDD VSS INV_X1
X_14434_ _08509_ _08507_ VDD VSS INV_X1
X_14435_ _08514_ _08511_ VDD VSS INV_X1
X_14436_ _08535_ _08533_ VDD VSS INV_X1
X_14437_ _08539_ _08540_ VDD VSS INV_X1
X_14438_ _08551_ _08544_ VDD VSS INV_X1
X_14439_ _09743_ _08549_ VDD VSS INV_X1
X_14440_ _08556_ _07349_ VDD VSS INV_X2
X_14441_ _08637_ _07357_ VDD VSS INV_X2
X_14442_ _09413_ _07478_ VDD VSS INV_X1
X_14443_ _09402_ _07496_ VDD VSS INV_X1
X_14444_ _09418_ _07526_ VDD VSS INV_X1
X_14445_ _09431_ _07573_ VDD VSS INV_X1
X_14446_ _09443_ _07616_ VDD VSS INV_X1
X_14447_ _09465_ _07661_ VDD VSS INV_X1
X_14448_ _09456_ _07666_ VDD VSS INV_X1
X_14449_ _09461_ _07695_ VDD VSS INV_X1
X_14450_ _09479_ _07712_ VDD VSS INV_X1
X_14451_ _07705_ _07743_ VDD VSS INV_X1
X_14452_ _09494_ _07755_ VDD VSS INV_X1
X_14453_ _09507_ _07794_ VDD VSS INV_X1
X_14454_ _09525_ _07835_ VDD VSS INV_X1
X_14455_ _09531_ _07857_ VDD VSS INV_X1
X_14456_ _09561_ _07906_ VDD VSS INV_X1
X_14457_ _04807_ _05100_ _07986_ VDD VSS OR2_X1
X_14458_ _04992_ _05125_ VDD VSS INV_X2
X_14459_ _05125_ _04838_ _07996_ VDD VSS NAND2_X1
X_14460_ _08011_ _08001_ VDD VSS INV_X1
X_14461_ _05125_ _05118_ _08021_ VDD VSS NAND2_X1
X_14462_ _05125_ _04991_ _08079_ VDD VSS NAND2_X1
X_14463_ _05125_ _05119_ _08137_ VDD VSS NAND2_X1
X_14464_ _05125_ _05120_ _08200_ VDD VSS NAND2_X1
X_14465_ _05125_ _05121_ _08258_ VDD VSS NAND2_X1
X_14466_ _04992_ _05082_ _08305_ VDD VSS OR2_X1
X_14467_ _05125_ _05123_ _08395_ VDD VSS NAND2_X1
X_14468_ _04992_ _05037_ _08449_ VDD VSS OR2_X1
X_14469_ _08502_ _08498_ VDD VSS INV_X1
X_14470_ _08500_ _08512_ VDD VSS INV_X1
X_14471_ _05125_ _05124_ _08516_ VDD VSS NAND2_X1
X_14472_ _08519_ _08524_ VDD VSS INV_X1
X_14473_ _04992_ _05028_ _08538_ VDD VSS OR2_X1
X_14474_ _08542_ _08550_ VDD VSS INV_X1
X_14475_ _07376_ _09388_ VDD VSS INV_X1
X_14476_ _07385_ _07387_ VDD VSS INV_X1
X_14477_ _07408_ _07435_ VDD VSS INV_X1
X_14478_ _07421_ _07427_ VDD VSS INV_X1
X_14479_ _07442_ _07490_ VDD VSS INV_X1
X_14480_ _07457_ _07492_ VDD VSS INV_X1
X_14481_ _07461_ _07467_ VDD VSS INV_X1
X_14482_ _07515_ _07521_ VDD VSS INV_X1
X_14483_ _07546_ _07591_ VDD VSS INV_X1
X_14484_ _07562_ _07567_ VDD VSS INV_X1
X_14485_ _07597_ _07638_ VDD VSS INV_X1
X_14486_ _07613_ _07640_ VDD VSS INV_X1
X_14487_ _07646_ _07690_ VDD VSS INV_X1
X_14488_ _07655_ _07660_ VDD VSS INV_X1
X_14489_ _07677_ _07688_ VDD VSS INV_X1
X_14490_ _07724_ _07735_ VDD VSS INV_X1
X_14491_ _07741_ _07776_ VDD VSS INV_X1
X_14492_ _07766_ _07778_ VDD VSS INV_X1
X_14493_ _07784_ _07815_ VDD VSS INV_X1
X_14494_ _07805_ _07817_ VDD VSS INV_X1
X_14495_ _07876_ _07879_ VDD VSS INV_X1
X_14496_ _07932_ _07950_ VDD VSS INV_X1
X_14497_ _07955_ _08037_ VDD VSS INV_X1
X_14498_ _07961_ _07972_ VDD VSS INV_X1
X_14499_ _07983_ _08000_ VDD VSS INV_X1
X_14500_ _08042_ _08102_ VDD VSS INV_X1
X_14501_ _08089_ _08091_ VDD VSS INV_X1
X_14502_ _08107_ _08165_ VDD VSS INV_X1
X_14503_ _08111_ _08118_ VDD VSS INV_X1
X_14504_ _08170_ _08227_ VDD VSS INV_X1
X_14505_ _08174_ _08181_ VDD VSS INV_X1
X_14506_ _08232_ _09633_ VDD VSS INV_X1
X_14507_ _08246_ _08283_ VDD VSS INV_X1
X_14508_ _08254_ _08261_ VDD VSS INV_X1
X_14509_ _08268_ _08279_ VDD VSS INV_X1
X_14510_ _08296_ _08330_ VDD VSS INV_X1
X_14511_ _08301_ _08308_ VDD VSS INV_X1
X_14512_ _08315_ _08326_ VDD VSS INV_X1
X_14513_ _08335_ _09663_ VDD VSS INV_X2
X_14514_ _08346_ _08381_ VDD VSS INV_X1
X_14515_ _08351_ _08358_ VDD VSS INV_X1
X_14516_ _08357_ _08390_ VDD VSS INV_X1
X_14517_ _08366_ _08377_ VDD VSS INV_X1
X_14518_ _08392_ _08398_ VDD VSS INV_X1
X_14519_ _08393_ _08445_ VDD VSS INV_X1
X_14520_ _08406_ _08418_ VDD VSS INV_X1
X_14521_ _08425_ _09690_ VDD VSS INV_X1
X_14522_ _08492_ _08510_ VDD VSS INV_X1
X_14523_ _07379_ _07386_ VDD VSS INV_X1
X_14524_ _07412_ _07388_ VDD VSS INV_X1
X_14525_ _07416_ _07426_ VDD VSS INV_X1
X_14526_ _07441_ _07436_ VDD VSS INV_X1
X_14527_ _07447_ _07428_ VDD VSS INV_X1
X_14528_ _07456_ _07466_ VDD VSS INV_X1
X_14529_ _07510_ _07520_ VDD VSS INV_X1
X_14530_ _07514_ _07468_ VDD VSS INV_X1
X_14531_ _07545_ _07541_ VDD VSS INV_X1
X_14532_ _07557_ _07566_ VDD VSS INV_X1
X_14533_ _07561_ _07522_ VDD VSS INV_X1
X_14534_ _07596_ _07592_ VDD VSS INV_X1
X_14535_ _07605_ _07568_ VDD VSS INV_X1
X_14536_ _07612_ _07623_ VDD VSS INV_X1
X_14537_ _07645_ _07639_ VDD VSS INV_X1
X_14538_ _07740_ _07734_ VDD VSS INV_X1
X_14539_ _07783_ _07777_ VDD VSS INV_X1
X_14540_ _07822_ _07816_ VDD VSS INV_X1
X_14541_ _07931_ _07935_ VDD VSS INV_X1
X_14542_ _07954_ _07963_ VDD VSS INV_X1
X_14543_ _07987_ _07981_ VDD VSS INV_X1
X_14544_ _08007_ _08010_ VDD VSS INV_X1
X_14545_ _08041_ _08050_ VDD VSS INV_X1
X_14546_ _08047_ _07973_ VDD VSS INV_X1
X_14547_ _08067_ _08070_ VDD VSS INV_X1
X_14548_ _08106_ _08113_ VDD VSS INV_X1
X_14549_ _08128_ _09612_ VDD VSS INV_X1
X_14550_ _08169_ _08177_ VDD VSS INV_X1
X_14551_ _08122_ _08119_ VDD VSS INV_X1
X_14552_ _08192_ _09623_ VDD VSS INV_X1
X_14553_ _08231_ _08239_ VDD VSS INV_X1
X_14554_ _08185_ _08182_ VDD VSS INV_X1
X_14555_ _08300_ _08262_ VDD VSS INV_X1
X_14556_ _08334_ _08338_ VDD VSS INV_X1
X_14557_ _08350_ _08309_ VDD VSS INV_X1
X_14558_ _08356_ _08360_ VDD VSS INV_X1
X_14559_ _08391_ _08359_ VDD VSS INV_X1
X_14560_ _08388_ _08384_ VDD VSS INV_X1
X_14561_ _08495_ _08475_ VDD VSS INV_X1
X_14562_ _07400_ _07418_ VDD VSS INV_X1
X_14563_ _07390_ _07406_ VDD VSS INV_X1
X_14564_ _07425_ _07445_ VDD VSS INV_X1
X_14565_ _00025_ _05126_ VDD VSS INV_X2
X_14566_ _05126_ _05127_ VDD VSS CLKBUF_X3
X_14567_ _05127_ _04980_ _09397_ VDD VSS NOR2_X1
X_14568_ _07452_ _07462_ VDD VSS INV_X1
X_14569_ _05127_ _04971_ _09404_ VDD VSS NOR2_X1
X_14570_ _07502_ _09420_ VDD VSS INV_X1
X_14571_ _07497_ _07543_ VDD VSS INV_X1
X_14572_ _05127_ _04962_ _09423_ VDD VSS NOR2_X1
X_14573_ _05127_ _04953_ _09435_ VDD VSS NOR2_X1
X_14574_ _07581_ _09445_ VDD VSS INV_X1
X_14575_ _07540_ _07583_ VDD VSS INV_X1
X_14576_ _05127_ _04944_ _09448_ VDD VSS NOR2_X1
X_14577_ _07625_ _09458_ VDD VSS INV_X1
X_14578_ _07590_ _07631_ VDD VSS INV_X1
X_14579_ _05127_ _04934_ _09463_ VDD VSS NOR2_X1
X_14580_ _07662_ _07673_ VDD VSS INV_X1
X_14581_ _07637_ _07682_ VDD VSS INV_X1
X_14582_ _05127_ _04916_ _09477_ VDD VSS NOR2_X1
X_14583_ _07696_ _07737_ VDD VSS INV_X1
X_14584_ _07713_ _07720_ VDD VSS INV_X1
X_14585_ _07689_ _07729_ VDD VSS INV_X1
X_14586_ _07714_ _07739_ VDD VSS INV_X1
X_14587_ _07745_ _09487_ VDD VSS INV_X1
X_14588_ _05127_ _04906_ _09492_ VDD VSS NOR2_X1
X_14589_ _07785_ _07787_ VDD VSS INV_X1
X_14590_ _07756_ _07762_ VDD VSS INV_X1
X_14591_ _07736_ _07771_ VDD VSS INV_X1
X_14592_ _07757_ _07782_ VDD VSS INV_X1
X_14593_ _05127_ _04894_ _09505_ VDD VSS NOR2_X1
X_14594_ _07854_ _07824_ VDD VSS INV_X1
X_14595_ _07795_ _07801_ VDD VSS INV_X1
X_14596_ _07814_ _07810_ VDD VSS INV_X1
X_14597_ _07796_ _07821_ VDD VSS INV_X1
X_14598_ _05127_ net437 _09515_ VDD VSS NOR2_X1
X_14599_ _07836_ _09526_ VDD VSS INV_X1
X_14600_ _07818_ _07842_ VDD VSS INV_X1
X_14601_ _07837_ _07847_ VDD VSS INV_X1
X_14602_ _05126_ _04864_ _09532_ VDD VSS NOR2_X1
X_14603_ _07859_ _09542_ VDD VSS INV_X1
X_14604_ _05126_ _04849_ _09547_ VDD VSS NOR2_X1
X_14605_ _07880_ _07887_ VDD VSS INV_X1
X_14606_ _07881_ _07890_ VDD VSS INV_X1
X_14607_ _05126_ _04822_ _09578_ VDD VSS NOR2_X1
X_14608_ _04850_ _04990_ _08019_ VDD VSS OR2_X2
X_14609_ _07938_ _07957_ VDD VSS INV_X1
X_14610_ _07966_ _08044_ VDD VSS INV_X1
X_14611_ _07998_ _08014_ VDD VSS INV_X1
X_14612_ _08061_ _08057_ VDD VSS INV_X1
X_14613_ _08053_ _08109_ VDD VSS INV_X1
X_14614_ _08023_ _08074_ VDD VSS INV_X1
X_14615_ _08116_ _08171_ VDD VSS INV_X1
X_14616_ _08081_ _08131_ VDD VSS INV_X1
X_14617_ _08093_ _08149_ VDD VSS INV_X1
X_14618_ _08179_ _08235_ VDD VSS INV_X1
X_14619_ _08183_ _08207_ VDD VSS INV_X1
X_14620_ _08139_ _08195_ VDD VSS INV_X1
X_14621_ _08156_ _08216_ VDD VSS INV_X1
X_14622_ _08247_ _08243_ VDD VSS INV_X1
X_14623_ _08202_ _08253_ VDD VSS INV_X1
X_14624_ _08222_ _08273_ VDD VSS INV_X1
X_14625_ _08264_ _09643_ VDD VSS INV_X1
X_14626_ _08260_ _08299_ VDD VSS INV_X1
X_14627_ _08291_ _09652_ VDD VSS INV_X1
X_14628_ _08347_ _08342_ VDD VSS INV_X1
X_14629_ _08311_ _09657_ VDD VSS INV_X1
X_14630_ _08307_ _08349_ VDD VSS INV_X1
X_14631_ _05122_ _05128_ VDD VSS BUF_X4
X_14632_ _05128_ _05082_ _08354_ VDD VSS NOR2_X1
X_14633_ _08327_ _08371_ VDD VSS INV_X1
X_14634_ _08341_ _09665_ VDD VSS INV_X1
X_14635_ _08362_ _09670_ VDD VSS INV_X1
X_14636_ _08407_ _08402_ VDD VSS INV_X1
X_14637_ _08378_ _08412_ VDD VSS INV_X1
X_14638_ _08387_ _09674_ VDD VSS INV_X1
X_14639_ _09682_ _09685_ VDD VSS INV_X1
X_14640_ _08423_ _08435_ VDD VSS INV_X1
X_14641_ _08419_ _08431_ VDD VSS INV_X1
X_14642_ _09679_ _09691_ VDD VSS INV_X1
X_14643_ _08446_ _08452_ VDD VSS INV_X1
X_14644_ _09699_ _09700_ VDD VSS INV_X1
X_14645_ _08443_ _08464_ VDD VSS INV_X1
X_14646_ _09704_ _08489_ VDD VSS INV_X1
X_14647_ _08473_ _09713_ VDD VSS INV_X1
X_14648_ _08472_ _08485_ VDD VSS INV_X1
X_14649_ _08476_ _08483_ VDD VSS INV_X1
X_14650_ _08477_ _08487_ VDD VSS INV_X1
X_14651_ _09720_ _09730_ VDD VSS INV_X1
X_14652_ _08517_ _08523_ VDD VSS INV_X1
X_14653_ _05128_ _05028_ _09748_ VDD VSS NOR2_X1
X_14654_ _08559_ _08557_ VDD VSS INV_X1
X_14655_ _08599_ _08604_ _08609_ _08559_ _05129_ VDD VSS NOR4_X1
X_14656_ _08614_ _08619_ _08624_ _08629_ _05130_ VDD VSS NOR4_X1
X_14657_ _08561_ _08553_ _08569_ _08594_ _05131_ VDD VSS NOR4_X1
X_14658_ _08574_ _08579_ _08584_ _08589_ _05132_ VDD VSS NOR4_X1
X_14659_ _05129_ _05130_ _05131_ _05132_ _08562_ VDD VSS NAND4_X1
X_14660_ _08640_ _08638_ VDD VSS INV_X1
X_14661_ _08680_ _08685_ _08690_ _08640_ _05133_ VDD VSS NOR4_X1
X_14662_ _08695_ _08700_ _08705_ _08710_ _05134_ VDD VSS NOR4_X1
X_14663_ _08642_ _08634_ _08650_ _08675_ _05135_ VDD VSS NOR4_X1
X_14664_ _08655_ _08660_ _08665_ _08670_ _05136_ VDD VSS NOR4_X1
X_14665_ _05133_ _05134_ _05135_ _05136_ _08643_ VDD VSS NAND4_X1
X_14666_ _08722_ _01167_ _01428_ _08731_ VDD VSS MUX2_X1
X_14667_ _01429_ _08734_ VDD VSS INV_X2
X_14668_ _01168_ _01180_ _01208_ _08744_ VDD VSS NAND3_X1
X_14669_ _01425_ _01429_ net3 _08747_ VDD VSS AOI21_X2
X_14670_ _01228_ _01305_ _08765_ VDD VSS NOR2_X1
X_14671_ _01419_ _08747_ _05137_ VDD VSS NAND2_X1
X_14672_ _05137_ _01432_ _08768_ VDD VSS NAND2_X1
X_14673_ _01353_ _08778_ VDD VSS INV_X1
X_14674_ _01436_ _08781_ VDD VSS INV_X1
X_14675_ _01476_ _08801_ VDD VSS INV_X1
X_14676_ _01102_ _01249_ _01105_ _01107_ _08816_ VDD VSS AOI211_X4
X_14677_ _01476_ _01464_ _01309_ _05138_ VDD VSS MUX2_X1
X_14678_ _05138_ _08823_ VDD VSS INV_X1
X_14679_ _03366_ _09150_ VDD VSS INV_X1
X_14680_ _09296_ _09287_ _05139_ VDD VSS XOR2_X1
X_14681_ _04768_ _05139_ _04724_ _09330_ VDD VSS MUX2_X1
X_14682_ _09285_ _09288_ _04724_ _05140_ VDD VSS MUX2_X1
X_14683_ _05140_ _07368_ VDD VSS INV_X1
X_14684_ _09336_ _07369_ VDD VSS INV_X1
X_14685_ _07424_ _07419_ VDD VSS INV_X1
X_14686_ _05128_ _05001_ _09398_ VDD VSS NOR2_X1
X_14687_ _07501_ _09401_ VDD VSS INV_X1
X_14688_ _05128_ _04980_ _09405_ VDD VSS NOR2_X1
X_14689_ _07506_ _07517_ VDD VSS INV_X1
X_14690_ _05128_ _04971_ _09424_ VDD VSS NOR2_X1
X_14691_ _05128_ net438 _09436_ VDD VSS NOR2_X1
X_14692_ _07588_ _07584_ VDD VSS INV_X1
X_14693_ _05128_ _04953_ _09449_ VDD VSS NOR2_X1
X_14694_ _07635_ _07632_ VDD VSS INV_X1
X_14695_ _07700_ _07697_ VDD VSS INV_X1
X_14696_ _05128_ _04944_ _09464_ VDD VSS NOR2_X1
X_14697_ _07667_ _07674_ VDD VSS INV_X1
X_14698_ _07686_ _07683_ VDD VSS INV_X1
X_14699_ _07744_ _09472_ VDD VSS INV_X1
X_14700_ _05128_ _04934_ _09478_ VDD VSS NOR2_X1
X_14701_ _07733_ _07730_ VDD VSS INV_X1
X_14702_ _05128_ _04916_ _09493_ VDD VSS NOR2_X1
X_14703_ _07775_ _07772_ VDD VSS INV_X1
X_14704_ _05122_ _04906_ _09506_ VDD VSS NOR2_X1
X_14705_ _07779_ _07811_ VDD VSS INV_X1
X_14706_ _07786_ _09512_ VDD VSS INV_X1
X_14707_ _05122_ _04894_ _09516_ VDD VSS NOR2_X1
X_14708_ _07858_ _09529_ VDD VSS INV_X1
X_14709_ _05122_ net437 _09533_ VDD VSS NOR2_X1
X_14710_ _07855_ _09541_ VDD VSS INV_X1
X_14711_ _05122_ _04864_ _09548_ VDD VSS NOR2_X1
X_14712_ _07903_ _07900_ VDD VSS INV_X1
X_14713_ _07910_ _09575_ VDD VSS INV_X1
X_14714_ _05122_ _04849_ _09579_ VDD VSS NOR2_X1
X_14715_ _07965_ _07958_ VDD VSS INV_X1
X_14716_ _08052_ _08045_ VDD VSS INV_X1
X_14717_ _08022_ _08025_ VDD VSS INV_X1
X_14718_ _08115_ _08110_ VDD VSS INV_X1
X_14719_ _08012_ _09604_ VDD VSS INV_X1
X_14720_ _08080_ _08083_ VDD VSS INV_X1
X_14721_ _08175_ _08172_ VDD VSS INV_X1
X_14722_ _08072_ _09610_ VDD VSS INV_X1
X_14723_ _08188_ _08146_ VDD VSS INV_X1
X_14724_ _08154_ _08150_ VDD VSS INV_X1
X_14725_ _08241_ _08236_ VDD VSS INV_X1
X_14726_ _08189_ _08208_ VDD VSS INV_X1
X_14727_ _08201_ _08204_ VDD VSS INV_X1
X_14728_ _08250_ _08209_ VDD VSS INV_X1
X_14729_ _08220_ _08217_ VDD VSS INV_X1
X_14730_ _08251_ _08265_ VDD VSS INV_X1
X_14731_ _08277_ _08274_ VDD VSS INV_X1
X_14732_ _08290_ _09638_ VDD VSS INV_X1
X_14733_ _08263_ _09646_ VDD VSS INV_X1
X_14734_ _08324_ _08321_ VDD VSS INV_X1
X_14735_ _08340_ _09653_ VDD VSS INV_X1
X_14736_ _08310_ _09660_ VDD VSS INV_X1
X_14737_ _08375_ _08372_ VDD VSS INV_X1
X_14738_ _08386_ _09666_ VDD VSS INV_X1
X_14739_ _09676_ _09669_ VDD VSS INV_X1
X_14740_ _08361_ _09671_ VDD VSS INV_X1
X_14741_ _08416_ _08413_ VDD VSS INV_X1
X_14742_ _09678_ _09675_ VDD VSS INV_X1
X_14743_ _09693_ _09681_ VDD VSS INV_X1
X_14744_ _08401_ _09683_ VDD VSS INV_X1
X_14745_ _08439_ _08436_ VDD VSS INV_X1
X_14746_ _08400_ _09687_ VDD VSS INV_X1
X_14747_ _09695_ _09692_ VDD VSS INV_X1
X_14748_ _08450_ _08454_ VDD VSS INV_X1
X_14749_ _08468_ _08465_ VDD VSS INV_X1
X_14750_ _09721_ _08490_ VDD VSS INV_X1
X_14751_ _08451_ _09709_ VDD VSS INV_X1
X_14752_ _09707_ _09719_ VDD VSS INV_X1
X_14753_ _09722_ _09731_ VDD VSS INV_X1
X_14754_ _08543_ _09746_ VDD VSS INV_X1
X_14755_ _05126_ _05055_ _09749_ VDD VSS NOR2_X1
X_14756_ _09400_ _07494_ VDD VSS INV_X1
X_14757_ _09412_ _07477_ VDD VSS INV_X1
X_14758_ _09426_ _07571_ VDD VSS INV_X1
X_14759_ _09438_ _07614_ VDD VSS INV_X1
X_14760_ _09451_ _07664_ VDD VSS INV_X1
X_14761_ _09459_ _07693_ VDD VSS INV_X1
X_14762_ _09520_ _07834_ VDD VSS INV_X1
X_14763_ _09559_ _07904_ VDD VSS INV_X1
X_14764_ _09605_ _08123_ VDD VSS INV_X1
X_14765_ _09611_ _08186_ VDD VSS INV_X1
X_14766_ _09622_ _08248_ VDD VSS INV_X1
X_14767_ _09708_ _08491_ VDD VSS INV_X1
X_14768_ _09476_ _07711_ VDD VSS INV_X1
X_14769_ _09491_ _07754_ VDD VSS INV_X1
X_14770_ _09504_ _07793_ VDD VSS INV_X1
X_14771_ _07912_ _07909_ VDD VSS INV_X1
X_14772_ _09517_ _07856_ VDD VSS INV_X1
X_14773_ _08522_ _08518_ VDD VSS INV_X1
X_14774_ _09667_ _09668_ VDD VSS INV_X1
X_14775_ _09677_ _09680_ VDD VSS INV_X1
X_14776_ _09694_ _09697_ VDD VSS INV_X1
X_14777_ _09710_ _08474_ VDD VSS INV_X1
X_14778_ _09732_ _09737_ VDD VSS INV_X1
X_14779_ butterfly_in_group\[0\] _04792_ _05141_ VDD VSS NAND2_X1
X_14780_ _04589_ _05142_ VDD VSS INV_X1
X_14781_ _04668_ _04693_ _05143_ VDD VSS OR2_X1
X_14782_ _05142_ net22 _05143_ _05144_ VDD VSS NOR3_X1
X_14783_ _04718_ _04573_ _05145_ VDD VSS NOR2_X1
X_14784_ _04515_ _05145_ _05146_ VDD VSS NAND2_X1
X_14785_ _04516_ _05146_ _05147_ VDD VSS XNOR2_X1
X_14786_ _04653_ _04654_ _05148_ VDD VSS AND2_X1
X_14787_ _04655_ _04667_ _05149_ VDD VSS AND2_X1
X_14788_ _04635_ _04740_ _04734_ _05150_ VDD VSS OAI21_X1
X_14789_ _09298_ _05150_ _04646_ _05151_ VDD VSS AOI21_X2
X_14790_ _04633_ _04634_ _05151_ _05152_ VDD VSS OR3_X2
X_14791_ _09279_ _04521_ net34 _05153_ VDD VSS NAND3_X1
X_14792_ _04664_ _05154_ VDD VSS INV_X1
X_14793_ _05154_ _04579_ _04580_ _05155_ VDD VSS OAI21_X1
X_14794_ _05153_ _05155_ _05156_ VDD VSS NAND2_X1
X_14795_ _04718_ _04663_ _05157_ VDD VSS NOR2_X1
X_14796_ _05156_ _05157_ _05158_ VDD VSS OR2_X1
X_14797_ _05148_ _05149_ _05152_ _05158_ _05159_ VDD VSS OAI211_X2
X_14798_ _04685_ _04688_ _04692_ _05160_ VDD VSS NAND3_X1
X_14799_ _04653_ _04654_ _05161_ VDD VSS NAND2_X1
X_14800_ _05161_ _05149_ _05152_ _05162_ VDD VSS AOI21_X1
X_14801_ _05161_ _05149_ _05152_ _05163_ VDD VSS AND3_X1
X_14802_ _05147_ _05159_ _05160_ _05162_ _05163_ _05164_ VDD
+ VSS OAI221_X2
X_14803_ _04705_ _04706_ _05165_ VDD VSS NAND2_X1
X_14804_ _04611_ _04694_ _05165_ _05166_ VDD VSS AND3_X1
X_14805_ _05144_ _05164_ _05166_ _05167_ VDD VSS NOR3_X1
X_14806_ _04681_ _04684_ _05168_ VDD VSS XNOR2_X1
X_14807_ _05168_ net24 _05169_ VDD VSS NOR2_X1
X_14808_ _04717_ _05167_ _05169_ _05170_ VDD VSS OAI21_X2
X_14809_ _04611_ _04694_ _05165_ _05171_ VDD VSS NAND3_X1
X_14810_ _04717_ _05144_ _05164_ _05171_ _05172_ VDD VSS OR4_X2
X_14811_ _09288_ _05173_ VDD VSS INV_X1
X_14812_ butterfly_count\[1\] _05173_ _04723_ _05174_ VDD
+ VSS MUX2_X1
X_14813_ _09332_ _05175_ VDD VSS BUF_X1
X_14814_ _09320_ _09324_ _05176_ VDD VSS NAND2_X1
X_14815_ _09316_ _09312_ _09328_ _05177_ VDD VSS NAND3_X1
X_14816_ _05177_ _05176_ _05178_ VDD VSS NOR2_X2
X_14817_ _05175_ _07363_ _05178_ _05179_ VDD VSS NAND3_X1
X_14818_ _05174_ _05179_ _05180_ VDD VSS OR2_X1
X_14819_ _09319_ _09320_ _09323_ _05181_ VDD VSS AOI21_X1
X_14820_ _09331_ _05182_ VDD VSS INV_X1
X_14821_ _09334_ _05175_ _05183_ VDD VSS NAND2_X1
X_14822_ _05182_ _05183_ _09338_ _05184_ VDD VSS OAI21_X1
X_14823_ _09327_ _05184_ _09328_ _05185_ VDD VSS AOI21_X1
X_14824_ _05181_ _05185_ _05176_ _05186_ VDD VSS OAI21_X1
X_14825_ _09315_ _05186_ _09316_ _05187_ VDD VSS AOI21_X1
X_14826_ _05187_ _05188_ VDD VSS INV_X1
X_14827_ _09311_ _05188_ _09312_ _05189_ VDD VSS AOI21_X1
X_14828_ _05170_ _05172_ _05180_ _05189_ _05190_ VDD VSS AOI22_X2
X_14829_ _04688_ _04692_ _05191_ VDD VSS NAND2_X1
X_14830_ _05168_ _05191_ _05159_ _05192_ VDD VSS OAI21_X1
X_14831_ _04576_ _04577_ _04686_ _05193_ VDD VSS NAND3_X1
X_14832_ _04507_ _05193_ _05194_ VDD VSS XOR2_X1
X_14833_ _04576_ _05145_ _05195_ VDD VSS NAND2_X1
X_14834_ _04502_ _05195_ _05196_ VDD VSS XNOR2_X2
X_14835_ _04648_ _05143_ _05196_ _05197_ VDD VSS NOR3_X1
X_14836_ _04589_ _04593_ _04596_ _05198_ VDD VSS OAI21_X1
X_14837_ _04633_ _04634_ _05199_ VDD VSS OR2_X2
X_14838_ _04734_ _04740_ _05200_ VDD VSS NOR2_X1
X_14839_ _05200_ _05153_ _05155_ _05201_ VDD VSS AND3_X1
X_14840_ _04646_ _09301_ _05201_ _05202_ VDD VSS OAI21_X1
X_14841_ _09298_ _05203_ VDD VSS INV_X1
X_14842_ _05199_ _05202_ _05203_ _05204_ VDD VSS AOI21_X2
X_14843_ _05198_ _05143_ _05204_ _05205_ VDD VSS NOR3_X1
X_14844_ _05192_ _05194_ _05197_ _05205_ _04575_ _05206_ VDD
+ VSS OAI221_X1
X_14845_ _04597_ _04610_ _05207_ VDD VSS NOR2_X1
X_14846_ _04648_ _04668_ _05160_ _05208_ VDD VSS NOR3_X1
X_14847_ _05207_ _04672_ _05208_ _05209_ VDD VSS NAND3_X1
X_14848_ _04368_ _04570_ _05210_ VDD VSS XOR2_X1
X_14849_ _05210_ _04672_ _05208_ _05211_ VDD VSS OAI21_X1
X_14850_ _05209_ _05211_ _05212_ VDD VSS AND2_X1
X_14851_ _04718_ _04573_ _04687_ _05213_ VDD VSS NOR3_X2
X_14852_ _04690_ _05213_ _05214_ VDD VSS XNOR2_X2
X_14853_ _04686_ _04687_ _05215_ VDD VSS XOR2_X2
X_14854_ _04668_ _05215_ _05216_ VDD VSS NOR2_X1
X_14855_ _05203_ _05202_ _05217_ VDD VSS AND2_X1
X_14856_ _05216_ _04693_ net22 _05199_ _05217_ _05218_ VDD
+ VSS OAI221_X1
X_14857_ _05214_ _05218_ _05219_ VDD VSS AND2_X1
X_14858_ _04668_ _04672_ _05215_ _05214_ _05220_ VDD VSS NOR4_X1
X_14859_ _05220_ _05217_ _05199_ _05221_ VDD VSS OAI21_X1
X_14860_ _05178_ _09334_ _09337_ _05175_ _05222_ VDD VSS NAND4_X2
X_14861_ _04718_ _04656_ _04659_ _05223_ VDD VSS NOR3_X1
X_14862_ _04658_ _05223_ _05224_ VDD VSS XOR2_X1
X_14863_ _04686_ _04513_ _05225_ VDD VSS NAND2_X1
X_14864_ _04462_ _05225_ _05226_ VDD VSS XNOR2_X1
X_14865_ _05222_ _04608_ _05224_ _05226_ _05227_ VDD VSS AND4_X4
X_14866_ _04714_ _05221_ _05227_ _05228_ VDD VSS NAND3_X4
X_14867_ _05228_ _05212_ _05219_ _05206_ _05229_ VDD VSS NOR4_X4
X_14868_ _04611_ _04694_ _04698_ _04722_ _05230_ VDD VSS AND4_X1
X_14869_ _04597_ _05230_ _05143_ _05204_ _05231_ VDD VSS NOR4_X1
X_14870_ _04668_ _04693_ _05232_ VDD VSS NOR2_X1
X_14871_ _05165_ _04717_ _05233_ VDD VSS AND2_X1
X_14872_ _05152_ _05156_ _05234_ VDD VSS OR2_X1
X_14873_ _04611_ _05232_ _05233_ _05234_ _05235_ VDD VSS AND4_X1
X_14874_ _04716_ net24 _05235_ _05236_ VDD VSS AOI21_X1
X_14875_ _04716_ _04723_ _05235_ _05237_ VDD VSS AND3_X1
X_14876_ _05231_ _05236_ _05237_ _05238_ VDD VSS NOR3_X1
X_14877_ _04565_ net37 _05239_ VDD VSS NAND2_X1
X_14878_ _05239_ _04659_ _05240_ VDD VSS XNOR2_X2
X_14879_ _04629_ _04632_ _05241_ VDD VSS AND2_X1
X_14880_ _05156_ _05241_ _02573_ _05242_ VDD VSS AOI21_X1
X_14881_ _05199_ _05151_ _05242_ _05243_ VDD VSS NAND3_X1
X_14882_ _05240_ _05243_ _05244_ VDD VSS NAND2_X1
X_14883_ _05199_ _05151_ _05245_ VDD VSS XOR2_X1
X_14884_ _05152_ _05217_ _05242_ _05245_ _05246_ VDD VSS OAI22_X1
X_14885_ _05244_ _05246_ _05240_ _05247_ VDD VSS OAI21_X1
X_14886_ _04648_ _05241_ _02573_ _05248_ VDD VSS AOI21_X1
X_14887_ _05156_ _05248_ _05249_ VDD VSS XOR2_X1
X_14888_ _04694_ _05249_ _05250_ VDD VSS OR2_X1
X_14889_ _05216_ _05217_ _05199_ _05251_ VDD VSS OAI21_X1
X_14890_ _05214_ _05251_ _05252_ VDD VSS XNOR2_X1
X_14891_ _05156_ _05240_ _05253_ VDD VSS OR2_X1
X_14892_ _05247_ _05250_ _05252_ _05253_ _05241_ _04724_ _05254_
+ VDD VSS OAI33_X1
X_14893_ net22 _04668_ _05255_ VDD VSS OR2_X1
X_14894_ _04597_ _04648_ _04668_ _04693_ _05256_ VDD VSS NOR4_X1
X_14895_ _04609_ _05256_ _05257_ VDD VSS XNOR2_X1
X_14896_ _05255_ _04688_ _05230_ _05257_ _05258_ VDD VSS OR4_X1
X_14897_ _04609_ _04688_ _05259_ VDD VSS NAND2_X1
X_14898_ _05255_ _05230_ _05260_ VDD VSS NOR2_X1
X_14899_ _05258_ _05259_ _05260_ _05261_ VDD VSS OAI21_X1
X_14900_ _05229_ _05238_ _05254_ _05261_ _05262_ VDD VSS AND4_X4
X_14901_ _05190_ _05262_ _05263_ VDD VSS NAND2_X1
X_14902_ butterfly_count\[0\] _05264_ VDD VSS INV_X1
X_14903_ net22 _04668_ _05265_ VDD VSS NOR2_X1
X_14904_ _05145_ _04679_ _05266_ VDD VSS NOR2_X1
X_14905_ _05265_ net24 _05266_ _05267_ VDD VSS NAND3_X1
X_14906_ _04675_ _05267_ _05268_ VDD VSS AND2_X1
X_14907_ _05265_ _04690_ _05269_ VDD VSS NAND2_X1
X_14908_ _04679_ _05230_ _05269_ _05270_ VDD VSS OAI21_X1
X_14909_ _04686_ _05270_ _05271_ VDD VSS NAND2_X1
X_14910_ _05143_ _05204_ _05272_ VDD VSS NOR2_X1
X_14911_ _04714_ _04716_ _04717_ _05273_ VDD VSS AND3_X1
X_14912_ _04611_ _04698_ _05196_ _05273_ _05274_ VDD VSS AND4_X1
X_14913_ net24 _05272_ _05274_ _05275_ VDD VSS NAND3_X1
X_14914_ _04611_ _04694_ _04722_ _05276_ VDD VSS NAND3_X1
X_14915_ _04698_ _04721_ _05277_ VDD VSS NAND2_X1
X_14916_ _05276_ _05277_ _05278_ VDD VSS NAND2_X1
X_14917_ _05196_ _05272_ _04724_ _05279_ VDD VSS AOI21_X1
X_14918_ _04723_ _05272_ _05196_ _05280_ VDD VSS AND3_X1
X_14919_ _05278_ _05279_ _05280_ _05281_ VDD VSS OAI21_X2
X_14920_ _05268_ _05271_ _05275_ _05281_ _05282_ VDD VSS AOI22_X4
X_14921_ _05264_ _05282_ _05283_ VDD VSS NAND2_X1
X_14922_ _04779_ _05263_ _05283_ _05284_ VDD VSS OAI21_X1
X_14923_ _05190_ _05262_ _05282_ _05285_ VDD VSS NAND3_X4
X_14924_ _09337_ _05285_ _05286_ VDD VSS AND2_X4
X_14925_ _05141_ _05284_ _05286_ _00058_ VDD VSS OAI21_X1
X_14926_ _07371_ _05287_ VDD VSS INV_X1
X_14927_ _05287_ _04779_ _05285_ _05288_ VDD VSS NAND3_X1
X_14928_ _04778_ _05174_ _05289_ VDD VSS NAND2_X1
X_14929_ butterfly_in_group\[1\] _05290_ VDD VSS INV_X1
X_14930_ _05288_ _05289_ _05285_ _04779_ _05290_ _00059_ VDD
+ VSS OAI221_X1
X_14931_ butterfly_in_group\[2\] _04792_ _05291_ VDD VSS NAND2_X1
X_14932_ _09330_ _05282_ _05292_ VDD VSS NAND2_X1
X_14933_ _04779_ _05263_ _05292_ _05293_ VDD VSS OAI21_X1
X_14934_ _07370_ _05175_ _05294_ VDD VSS XNOR2_X1
X_14935_ _05285_ _05294_ _05295_ VDD VSS AND2_X2
X_14936_ _05291_ _05293_ _05295_ _00060_ VDD VSS OAI21_X1
X_14937_ group\[0\] _05285_ _04779_ _00319_ VDD VSS MUX2_X1
X_14938_ group\[1\] net24 _04778_ _00320_ VDD VSS MUX2_X1
X_14939_ group\[2\] net37 _04778_ _00321_ VDD VSS MUX2_X1
X_14940_ _00030_ _05296_ VDD VSS CLKBUF_X3
X_14941_ _04794_ idx2\[1\] _05297_ VDD VSS NOR2_X4
X_14942_ _05296_ _05297_ _05298_ VDD VSS AND2_X1
X_14943_ _00041_ _05299_ VDD VSS INV_X1
X_14944_ _00853_ _00860_ _05299_ _05300_ VDD VSS NOR3_X2
X_14945_ _00841_ _00851_ _05300_ _05301_ VDD VSS NAND3_X2
X_14946_ _01109_ _05301_ _05302_ VDD VSS NOR2_X2
X_14947_ _08570_ _05303_ VDD VSS INV_X1
X_14948_ _08581_ _05304_ VDD VSS INV_X1
X_14949_ _08585_ _05305_ VDD VSS INV_X1
X_14950_ _08586_ _05306_ VDD VSS BUF_X2
X_14951_ _08591_ _05307_ VDD VSS INV_X2
X_14952_ _08595_ _05308_ VDD VSS INV_X1
X_14953_ _08601_ _05309_ VDD VSS INV_X1
X_14954_ _08605_ _05310_ VDD VSS INV_X1
X_14955_ _08606_ _05311_ VDD VSS CLKBUF_X2
X_14956_ _08611_ _05312_ VDD VSS INV_X2
X_14957_ _08615_ _05313_ VDD VSS INV_X1
X_14958_ _08620_ _05314_ VDD VSS INV_X1
X_14959_ _08630_ _05315_ VDD VSS INV_X1
X_14960_ _08631_ _05316_ VDD VSS INV_X1
X_14961_ _05315_ _07352_ _05316_ _05317_ VDD VSS OAI21_X1
Xclone129 net475 net129 VDD VSS BUF_X8
X_14963_ _08625_ _05317_ net493 _05319_ VDD VSS AOI21_X4
X_14964_ _08621_ _05320_ VDD VSS INV_X2
X_14965_ _05314_ _05319_ _05320_ _05321_ VDD VSS OAI21_X1
X_14966_ _08616_ _05321_ _05322_ VDD VSS NAND2_X1
X_14967_ _05312_ _05322_ _05313_ _05323_ VDD VSS AOI21_X2
X_14968_ _05311_ _08610_ _05323_ _05324_ VDD VSS OAI21_X2
X_14969_ _05309_ _05324_ _05310_ _05325_ VDD VSS AOI21_X2
X_14970_ _08596_ _08600_ _05325_ _05326_ VDD VSS OAI21_X2
X_14971_ _05307_ _05326_ _05308_ _05327_ VDD VSS AOI21_X2
X_14972_ _05306_ _08590_ _05327_ _05328_ VDD VSS OAI21_X2
X_14973_ _05304_ _05305_ _05328_ _05329_ VDD VSS AOI21_X2
X_14974_ _08576_ _08580_ _05329_ _05330_ VDD VSS OAI21_X2
X_14975_ _05330_ _05331_ VDD VSS INV_X2
X_14976_ _08571_ _08575_ _05331_ _05332_ VDD VSS OAI21_X4
X_14977_ _05303_ _05332_ _05333_ VDD VSS NAND2_X1
X_14978_ _08554_ _05333_ _08566_ _05334_ VDD VSS AOI21_X2
X_14979_ temp_imag\[0\] _08561_ _05335_ VDD VSS XNOR2_X1
X_14980_ _05334_ _05335_ _05336_ VDD VSS XNOR2_X2
X_14981_ temp_imag\[0\] _08564_ _05336_ _05337_ VDD VSS NAND3_X4
X_14982_ _05337_ _05302_ _05338_ VDD VSS AND2_X4
Xclone132 _05657_ net132 VDD VSS BUF_X16
X_14984_ _05338_ _05340_ VDD VSS INV_X4
X_14985_ _01311_ _05301_ _05341_ VDD VSS OR2_X4
X_14986_ _05340_ _05341_ _05337_ _05342_ VDD VSS OAI21_X4
X_14987_ _05298_ net153 _05343_ VDD VSS NAND2_X1
X_14988_ _00038_ _05344_ VDD VSS CLKBUF_X2
X_14989_ _00026_ _05345_ VDD VSS BUF_X2
X_14990_ _00028_ _05346_ VDD VSS BUF_X2
X_14991_ _05344_ _05345_ _05346_ _05347_ VDD VSS NAND3_X2
X_14992_ _00039_ _05348_ VDD VSS BUF_X2
X_14993_ _00029_ _05349_ VDD VSS INV_X1
X_14994_ sample_count\[2\] _05350_ VDD VSS INV_X1
X_14995_ _05350_ _09378_ _05351_ VDD VSS AND2_X2
X_14996_ _00860_ _00846_ _05352_ VDD VSS NOR2_X1
X_14997_ net86 _00858_ _05352_ _05353_ VDD VSS AND3_X2
X_14998_ _00841_ _05353_ _05354_ VDD VSS NAND2_X2
X_14999_ _05349_ _05351_ _05354_ _05355_ VDD VSS NOR3_X4
X_15000_ _05348_ _00027_ _05355_ _05356_ VDD VSS NAND3_X2
X_15001_ _01109_ _05301_ _05357_ VDD VSS OR2_X1
X_15002_ _05357_ _05358_ VDD VSS BUF_X4
X_15003_ _08567_ _05359_ VDD VSS INV_X1
X_15004_ _08577_ _05360_ VDD VSS INV_X1
X_15005_ _08587_ _05361_ VDD VSS INV_X1
X_15006_ _08597_ _05362_ VDD VSS INV_X1
X_15007_ _08607_ _05363_ VDD VSS INV_X1
X_15008_ _08617_ _05364_ VDD VSS INV_X1
X_15009_ _08627_ _05365_ VDD VSS INV_X1
X_15010_ _08632_ _08556_ _05316_ _05366_ VDD VSS AOI21_X2
X_15011_ _05365_ _08626_ _05366_ _05367_ VDD VSS OAI21_X2
X_15012_ _08622_ _05367_ _05320_ _05368_ VDD VSS AOI21_X2
X_15013_ _05364_ _08616_ _05368_ _05369_ VDD VSS OAI21_X2
X_15014_ _08612_ _05369_ _05312_ _05370_ VDD VSS AOI21_X2
X_15015_ _05363_ _05311_ _05370_ _05371_ VDD VSS OAI21_X2
X_15016_ _08602_ _05371_ _05309_ _05372_ VDD VSS AOI21_X2
X_15017_ _05362_ _05372_ _08596_ _05373_ VDD VSS OAI21_X2
X_15018_ _08592_ _05373_ _05307_ _05374_ VDD VSS AOI21_X2
X_15019_ _05361_ _05306_ _05374_ _05375_ VDD VSS OAI21_X2
X_15020_ _08582_ _05375_ _05304_ _05376_ VDD VSS AOI21_X1
X_15021_ _05360_ _05376_ _08576_ _05377_ VDD VSS OAI21_X2
X_15022_ _08571_ _05378_ VDD VSS INV_X1
X_15023_ _08572_ _05377_ _05378_ _05379_ VDD VSS AOI21_X2
X_15024_ _05359_ _05379_ _08555_ _05380_ VDD VSS OAI21_X2
X_15025_ _07347_ _08561_ _05381_ VDD VSS XNOR2_X1
X_15026_ _05380_ _05381_ _05382_ VDD VSS XNOR2_X2
X_15027_ _05365_ _07350_ net495 _05383_ VDD VSS OAI21_X4
X_15028_ _08622_ _05383_ _05320_ _05384_ VDD VSS AOI21_X4
X_15029_ _05364_ _05384_ _08616_ _05385_ VDD VSS OAI21_X4
X_15030_ _08612_ _05385_ _05312_ _05386_ VDD VSS AOI21_X4
X_15031_ _05363_ _05386_ _05311_ _05387_ VDD VSS OAI21_X4
X_15032_ _08602_ _05387_ _05309_ _05388_ VDD VSS AOI21_X4
X_15033_ _05362_ _05388_ _08596_ _05389_ VDD VSS OAI21_X4
X_15034_ _08592_ _05389_ _05307_ _05390_ VDD VSS AOI21_X4
X_15035_ _05361_ _05390_ _05306_ _05391_ VDD VSS OAI21_X4
X_15036_ _08582_ _05391_ _05304_ _05392_ VDD VSS AOI21_X4
X_15037_ _05360_ _05392_ _08576_ _05393_ VDD VSS OAI21_X4
X_15038_ _08572_ _05393_ _05378_ _05394_ VDD VSS AOI21_X4
X_15039_ _05394_ _08555_ _05395_ VDD VSS XNOR2_X2
X_15040_ _05378_ net509 _05396_ VDD VSS XNOR2_X2
X_15041_ _05307_ net506 _05397_ VDD VSS XNOR2_X2
X_15042_ _05306_ net499 _05398_ VDD VSS XNOR2_X2
X_15043_ _05312_ _05369_ _05399_ VDD VSS XNOR2_X1
X_15044_ _05311_ net507 _05400_ VDD VSS XNOR2_X1
X_15045_ _05320_ net489 _05401_ VDD VSS XNOR2_X2
X_15046_ _08558_ _05402_ VDD VSS INV_X2
X_15047_ net494 net500 _05403_ VDD VSS XOR2_X2
X_15048_ _08616_ _05404_ VDD VSS INV_X1
X_15049_ _05404_ net505 _05405_ VDD VSS XNOR2_X2
X_15050_ _05405_ _05402_ _05403_ _07351_ _05406_ VDD VSS NOR4_X2
X_15051_ _05406_ _05400_ _05401_ _05399_ _05407_ VDD VSS NAND4_X1
X_15052_ _08596_ _05408_ VDD VSS INV_X1
X_15053_ _05408_ net502 _05409_ VDD VSS XNOR2_X2
X_15054_ _08601_ net510 _05410_ VDD VSS XNOR2_X2
X_15055_ _05407_ _05409_ _05410_ _05411_ VDD VSS NOR3_X2
X_15056_ _05398_ _05397_ _05411_ _05412_ VDD VSS NAND3_X2
X_15057_ _08576_ _05413_ VDD VSS INV_X1
X_15058_ _05413_ net504 _05414_ VDD VSS XNOR2_X2
X_15059_ _08581_ net503 _05415_ VDD VSS XNOR2_X2
X_15060_ _05414_ _05412_ _05415_ _05416_ VDD VSS NOR3_X4
X_15061_ _05416_ _05396_ _05395_ _05417_ VDD VSS NAND3_X2
X_15062_ temp_imag\[0\] _05417_ _05382_ _08563_ _05418_ VDD
+ VSS AND4_X4
X_15063_ _05358_ _05341_ _05418_ _05419_ VDD VSS MUX2_X2
Xclone125 _05419_ net125 VDD VSS BUF_X4
X_15065_ _05347_ _05356_ net138 _05421_ VDD VSS MUX2_X2
Xclone137 _05347_ _05356_ net138 net137 VDD VSS MUX2_X2
X_15067_ _00843_ _05351_ _05353_ _05423_ VDD VSS AOI21_X4
X_15068_ _05421_ _05343_ _05423_ _05424_ VDD VSS AND3_X4
X_15069_ _05424_ _05425_ VDD VSS BUF_X8
X_15070_ samples_imag\[0\]\[0\] net140 _05426_ VDD VSS NAND2_X1
X_15071_ _05358_ _05418_ _05427_ VDD VSS NOR2_X4
X_15072_ _05427_ _05428_ VDD VSS BUF_X8
X_15073_ _05419_ _05429_ VDD VSS BUF_X8
X_15074_ _05429_ _05430_ VDD VSS BUF_X16
X_15075_ _05402_ _05428_ net45 _05430_ _05431_ VDD VSS AOI22_X4
X_15076_ _00841_ _05351_ _05353_ _05432_ VDD VSS AND3_X1
X_15077_ _05432_ _05433_ VDD VSS BUF_X1
X_15078_ _05433_ _05434_ VDD VSS CLKBUF_X3
X_15079_ net45 _05434_ _05435_ VDD VSS NAND2_X1
X_15080_ _05421_ _05436_ VDD VSS BUF_X4
X_15081_ _05431_ _05435_ _05436_ _05437_ VDD VSS MUX2_X1
X_15082_ _05298_ net153 _05438_ VDD VSS AND2_X2
X_15083_ _05438_ _05439_ VDD VSS CLKBUF_X3
X_15084_ _05296_ _05297_ _05440_ VDD VSS NAND2_X4
X_15085_ _05440_ _05441_ VDD VSS CLKBUF_X3
X_15086_ _05402_ net520 _05442_ VDD VSS NAND2_X4
X_15087_ _05426_ _05437_ _05439_ _05441_ _05442_ _00325_ VDD
+ VSS OAI221_X1
X_15088_ samples_imag\[0\]\[10\] net140 _05443_ VDD VSS NAND2_X1
X_15089_ _05358_ _05398_ net496 _05444_ VDD VSS NOR3_X2
X_15090_ _05444_ _05430_ net46 _05445_ VDD VSS AOI21_X4
X_15091_ net46 _05434_ _05446_ VDD VSS NAND2_X1
X_15092_ _05445_ _05446_ _05436_ _05447_ VDD VSS MUX2_X1
X_15093_ _05340_ _05448_ VDD VSS BUF_X4
X_15094_ _05306_ _05449_ VDD VSS INV_X1
X_15095_ _08590_ _05450_ VDD VSS INV_X1
X_15096_ _08600_ _05451_ VDD VSS INV_X1
X_15097_ _05311_ _05452_ VDD VSS INV_X1
X_15098_ _08610_ _05453_ VDD VSS INV_X1
X_15099_ net494 _05454_ VDD VSS INV_X1
X_15100_ _05454_ _07353_ _05455_ VDD VSS NOR2_X2
X_15101_ _08621_ _08625_ _05455_ _05456_ VDD VSS OAI21_X1
X_15102_ _05404_ _05314_ _05456_ _05457_ VDD VSS AOI21_X1
X_15103_ _08611_ _08615_ _05457_ _05458_ VDD VSS OAI21_X1
X_15104_ _05452_ _05453_ _05458_ _05459_ VDD VSS AOI21_X2
X_15105_ _08601_ _08605_ _05459_ _05460_ VDD VSS OAI21_X1
X_15106_ _05408_ _05451_ _05460_ _05461_ VDD VSS AOI21_X2
X_15107_ _08591_ _08595_ _05461_ _05462_ VDD VSS OAI21_X1
X_15108_ _05449_ _05450_ _05462_ _05463_ VDD VSS AND3_X1
X_15109_ _05449_ _05450_ _05462_ _05464_ VDD VSS AOI21_X2
X_15110_ _05448_ _05463_ _05464_ _05465_ VDD VSS OR3_X4
Xclone156 _05695_ net156 VDD VSS BUF_X16
X_15112_ _05443_ _05447_ _05439_ _05441_ _05465_ _00326_ VDD
+ VSS OAI221_X1
X_15113_ samples_imag\[0\]\[11\] net140 _05467_ VDD VSS NAND2_X1
X_15114_ _05415_ _05428_ net47 _05430_ _05468_ VDD VSS AOI22_X4
X_15115_ net47 _05434_ _05469_ VDD VSS NAND2_X1
X_15116_ _05468_ _05469_ _05436_ _05470_ VDD VSS MUX2_X1
X_15117_ _05304_ _05305_ _05328_ _05471_ VDD VSS AND3_X1
X_15118_ _05329_ _05448_ _05471_ _05472_ VDD VSS OR3_X4
Xclone149 _05622_ net149 VDD VSS BUF_X4
X_15120_ _05467_ _05470_ _05439_ _05441_ _05472_ _00327_ VDD
+ VSS OAI221_X1
X_15121_ samples_imag\[0\]\[12\] net140 _05474_ VDD VSS NAND2_X1
X_15122_ net512 _05428_ net48 _05430_ _05475_ VDD VSS AOI22_X4
X_15123_ net48 _05434_ _05476_ VDD VSS NAND2_X1
X_15124_ _05475_ _05476_ _05436_ _05477_ VDD VSS MUX2_X1
X_15125_ _08580_ _05478_ VDD VSS INV_X1
X_15126_ _08581_ _08585_ _05464_ _05479_ VDD VSS OAI21_X1
X_15127_ _05413_ _05478_ _05479_ _05480_ VDD VSS AND3_X1
X_15128_ _05413_ _05478_ _05479_ _05481_ VDD VSS AOI21_X2
X_15129_ _05448_ _05480_ _05481_ _05482_ VDD VSS OR3_X4
Xclone154 _05791_ net154 VDD VSS BUF_X8
X_15131_ _05474_ _05477_ _05439_ _05441_ _05482_ _00328_ VDD
+ VSS OAI221_X1
X_15132_ samples_imag\[0\]\[13\] _05425_ _05484_ VDD VSS NAND2_X1
X_15133_ _05358_ _05396_ net496 _05485_ VDD VSS NOR3_X2
X_15134_ _05485_ _05430_ net49 _05486_ VDD VSS AOI21_X4
X_15135_ net49 _05434_ _05487_ VDD VSS NAND2_X1
X_15136_ _05486_ _05487_ _05436_ _05488_ VDD VSS MUX2_X1
X_15137_ _08571_ _08575_ _05331_ _05489_ VDD VSS OR3_X2
X_15138_ _05332_ net520 _05489_ _05490_ VDD VSS NAND3_X4
X_15139_ _05484_ _05488_ _05439_ _05441_ _05490_ _00329_ VDD
+ VSS OAI221_X1
X_15140_ samples_imag\[0\]\[14\] _05425_ _05491_ VDD VSS NAND2_X1
X_15141_ _08555_ net498 _05492_ VDD VSS XOR2_X2
X_15142_ _05492_ _05428_ _05430_ net50 _05493_ VDD VSS AOI22_X4
X_15143_ _05433_ _05494_ VDD VSS CLKBUF_X3
X_15144_ net50 _05494_ _05495_ VDD VSS NAND2_X1
X_15145_ _05493_ _05495_ _05421_ _05496_ VDD VSS MUX2_X1
X_15146_ _08571_ _08575_ _05481_ _05497_ VDD VSS OAI21_X1
X_15147_ _05303_ _05497_ _05498_ VDD VSS NAND2_X1
X_15148_ _08566_ _05498_ _05499_ VDD VSS XOR2_X2
X_15149_ net520 _05499_ _05500_ VDD VSS NAND2_X4
X_15150_ _05491_ _05496_ _05439_ _05441_ _05500_ _00330_ VDD
+ VSS OAI221_X1
X_15151_ _05358_ _05336_ _05501_ VDD VSS OR2_X2
X_15152_ net54 _05502_ VDD VSS INV_X1
X_15153_ net501 _05427_ _05429_ _05502_ _05503_ VDD VSS AOI22_X4
X_15154_ net139 _05503_ _05504_ VDD VSS NOR2_X1
X_15155_ net54 _05434_ _05423_ samples_imag\[0\]\[15\] _05505_
+ VDD VSS AOI22_X1
X_15156_ _05504_ _05505_ net139 _05506_ VDD VSS AOI21_X1
X_15157_ _05501_ _05506_ _05343_ _00331_ VDD VSS MUX2_X1
X_15158_ _05425_ samples_imag\[0\]\[1\] _05507_ VDD VSS NAND2_X4
X_15159_ _07351_ _05428_ net55 _05430_ _05508_ VDD VSS AOI22_X4
X_15160_ net55 _05494_ _05509_ VDD VSS NAND2_X1
X_15161_ _05508_ _05509_ _05421_ _05510_ VDD VSS MUX2_X1
X_15162_ _07354_ net520 _05511_ VDD VSS NAND2_X4
X_15163_ _05507_ _05510_ _05439_ _05441_ _05511_ _00332_ VDD
+ VSS OAI221_X2
X_15164_ _05454_ _07353_ _05512_ VDD VSS AND2_X1
X_15165_ _05448_ _05455_ _05512_ _05513_ VDD VSS NOR3_X4
X_15166_ _05439_ _05513_ _05514_ VDD VSS NAND2_X1
X_15167_ _05403_ _05428_ net62 _05430_ _05515_ VDD VSS AOI22_X4
X_15168_ net62 _05434_ _05423_ samples_imag\[0\]\[2\] _05516_
+ VDD VSS AOI22_X1
X_15169_ _05515_ _05516_ net139 _05517_ VDD VSS MUX2_X1
X_15170_ _05514_ _05517_ _05439_ _00333_ VDD VSS OAI21_X1
X_15171_ net63 net139 _05434_ _05518_ VDD VSS NAND3_X1
X_15172_ _05358_ _05401_ _05418_ _05519_ VDD VSS NOR3_X2
X_15173_ _05519_ net63 _05430_ _05520_ VDD VSS AOI21_X4
X_15174_ _05518_ _05520_ net139 _05521_ VDD VSS OAI21_X1
X_15175_ _05343_ _05521_ _05522_ VDD VSS NAND2_X1
X_15176_ _05320_ _05319_ _05523_ VDD VSS XNOR2_X2
X_15177_ _05448_ _05523_ _05524_ VDD VSS NOR2_X4
X_15178_ net140 samples_imag\[0\]\[3\] _05524_ _05298_ _05525_
+ VDD VSS AOI22_X1
X_15179_ _05525_ _05522_ _00334_ VDD VSS NAND2_X1
X_15180_ samples_imag\[0\]\[4\] _05425_ _05526_ VDD VSS NAND2_X1
X_15181_ _05405_ _05427_ net125 net64 _05527_ VDD VSS AOI22_X4
X_15182_ net64 _05494_ _05528_ VDD VSS NAND2_X1
X_15183_ _05527_ _05528_ _05421_ _05529_ VDD VSS MUX2_X1
X_15184_ _05404_ _05314_ _05456_ _05530_ VDD VSS AND3_X1
X_15185_ _05457_ _05530_ _05531_ VDD VSS NOR2_X1
X_15186_ net520 _05531_ _05532_ VDD VSS NAND2_X2
X_15187_ _05526_ _05529_ _05439_ _05441_ _05532_ _00335_ VDD
+ VSS OAI221_X1
X_15188_ samples_imag\[0\]\[5\] _05425_ _05533_ VDD VSS NAND2_X1
X_15189_ _05399_ _05534_ VDD VSS INV_X1
X_15190_ _05534_ _05428_ net125 net65 _05535_ VDD VSS AOI22_X4
X_15191_ net65 _05494_ _05536_ VDD VSS NAND2_X1
X_15192_ _05535_ _05536_ net137 _05537_ VDD VSS MUX2_X1
X_15193_ _05312_ _05313_ _05322_ _05538_ VDD VSS AND3_X1
X_15194_ _05323_ _05448_ _05538_ _05539_ VDD VSS OR3_X4
X_15195_ _05533_ _05537_ _05438_ _05441_ _05539_ _00336_ VDD
+ VSS OAI221_X1
X_15196_ _05424_ samples_imag\[0\]\[6\] _05540_ VDD VSS NAND2_X1
X_15197_ _05400_ _05541_ VDD VSS INV_X1
X_15198_ _05541_ _05428_ net125 net66 _05542_ VDD VSS AOI22_X4
X_15199_ net66 _05494_ _05543_ VDD VSS NAND2_X1
X_15200_ _05542_ _05543_ net137 _05544_ VDD VSS MUX2_X1
X_15201_ _05452_ _05453_ _05458_ _05545_ VDD VSS AND3_X1
X_15202_ _05448_ _05459_ _05545_ _05546_ VDD VSS OR3_X4
Xclone153 _05340_ _05337_ _05341_ net153 VDD VSS OAI21_X4
X_15204_ _05540_ _05544_ _05438_ _05441_ _05546_ _00337_ VDD
+ VSS OAI221_X1
X_15205_ _05424_ samples_imag\[0\]\[7\] _05548_ VDD VSS NAND2_X1
X_15206_ _05410_ _05428_ net125 net67 _05549_ VDD VSS AOI22_X4
X_15207_ net67 _05494_ _05550_ VDD VSS NAND2_X1
X_15208_ _05549_ _05550_ net137 _05551_ VDD VSS MUX2_X1
X_15209_ _05440_ _05552_ VDD VSS CLKBUF_X3
X_15210_ _05309_ _05310_ _05324_ _05553_ VDD VSS AND3_X1
X_15211_ _05325_ _05448_ _05553_ _05554_ VDD VSS OR3_X4
Xclone152 _05798_ net152 VDD VSS BUF_X8
X_15213_ _05548_ _05551_ _05438_ _05552_ _05554_ _00338_ VDD
+ VSS OAI221_X1
X_15214_ samples_imag\[0\]\[8\] _05424_ _05556_ VDD VSS NAND2_X1
X_15215_ _05409_ _05428_ net125 net68 _05557_ VDD VSS AOI22_X4
X_15216_ net68 _05494_ _05558_ VDD VSS NAND2_X1
X_15217_ _05557_ _05558_ net137 _05559_ VDD VSS MUX2_X1
X_15218_ _05408_ _05451_ _05460_ _05560_ VDD VSS AND3_X1
X_15219_ _05448_ _05461_ _05560_ _05561_ VDD VSS OR3_X4
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
X_15221_ _05556_ _05559_ _05438_ _05552_ _05561_ _00339_ VDD
+ VSS OAI221_X1
X_15222_ samples_imag\[0\]\[9\] _05424_ _05563_ VDD VSS NAND2_X1
X_15223_ _05358_ _05397_ net496 _05564_ VDD VSS NOR3_X2
X_15224_ _05564_ _05430_ net69 _05565_ VDD VSS AOI21_X4
X_15225_ net69 _05494_ _05566_ VDD VSS NAND2_X1
X_15226_ _05565_ _05566_ net137 _05567_ VDD VSS MUX2_X1
X_15227_ _05307_ _05308_ _05326_ _05568_ VDD VSS AND3_X1
X_15228_ _05327_ _05448_ _05568_ _05569_ VDD VSS OR3_X4
Xclone158 _05727_ net158 VDD VSS BUF_X8
X_15230_ _05563_ _05567_ _05438_ _05552_ _05569_ _00340_ VDD
+ VSS OAI221_X1
X_15231_ _00842_ _05571_ VDD VSS BUF_X4
X_15232_ _05344_ _05572_ VDD VSS INV_X1
X_15233_ _05572_ _05345_ _05346_ _05573_ VDD VSS NAND3_X1
X_15234_ _00027_ _05574_ VDD VSS INV_X1
X_15235_ _05348_ _05574_ _05575_ VDD VSS NOR2_X1
X_15236_ _05355_ _05575_ _05576_ VDD VSS NAND2_X1
X_15237_ _05573_ _05576_ _05429_ _05577_ VDD VSS MUX2_X2
X_15238_ _04790_ _05297_ net526 _05578_ VDD VSS NAND3_X4
X_15239_ _05571_ net488 _05578_ _05579_ VDD VSS AND3_X4
Xclone151 _05571_ net488 _05578_ net151 VDD VSS AND3_X4
X_15241_ samples_imag\[1\]\[0\] net151 _05581_ VDD VSS NAND2_X1
X_15242_ _04790_ _05297_ _05582_ VDD VSS NAND2_X2
X_15243_ _05582_ _05583_ VDD VSS CLKBUF_X3
X_15244_ net513 _05584_ VDD VSS INV_X4
X_15245_ _05584_ _05578_ _05585_ VDD VSS NAND2_X4
X_15246_ _05581_ _05583_ _05442_ net530 _05585_ _00341_ VDD
+ VSS OAI221_X1
X_15247_ samples_imag\[1\]\[10\] _05579_ _05586_ VDD VSS NAND2_X1
X_15248_ _05586_ _05583_ _05465_ _05445_ _05585_ _00342_ VDD
+ VSS OAI221_X1
X_15249_ _05579_ samples_imag\[1\]\[11\] _05587_ VDD VSS NAND2_X1
X_15250_ _05587_ _05583_ _05472_ net528 _05585_ _00343_ VDD
+ VSS OAI221_X1
X_15251_ _05579_ samples_imag\[1\]\[12\] _05588_ VDD VSS NAND2_X1
X_15252_ _05588_ _05583_ _05482_ net529 _05585_ _00344_ VDD
+ VSS OAI221_X1
X_15253_ _05579_ samples_imag\[1\]\[13\] _05589_ VDD VSS NAND2_X1
X_15254_ _05589_ _05583_ _05490_ _05486_ _05585_ _00345_ VDD
+ VSS OAI221_X1
X_15255_ _05579_ samples_imag\[1\]\[14\] _05590_ VDD VSS NAND2_X1
X_15256_ _05590_ _05583_ _05500_ _05493_ _05585_ _00346_ VDD
+ VSS OAI221_X1
X_15257_ _05503_ _05584_ _05591_ VDD VSS NAND2_X2
X_15258_ _05577_ _05592_ VDD VSS BUF_X8
X_15259_ _00856_ samples_imag\[1\]\[15\] _05592_ _05593_ VDD
+ VSS NAND3_X1
X_15260_ _05591_ _05593_ _05594_ VDD VSS NAND2_X1
X_15261_ _05501_ _05594_ _05578_ _00347_ VDD VSS MUX2_X1
X_15262_ net151 samples_imag\[1\]\[1\] _05595_ VDD VSS NAND2_X1
X_15263_ _05595_ _05582_ _05511_ net531 _05585_ _00348_ VDD
+ VSS OAI221_X1
X_15264_ _00855_ _05596_ VDD VSS CLKBUF_X3
X_15265_ _05596_ samples_imag\[1\]\[2\] _05592_ _05597_ VDD
+ VSS NAND3_X1
X_15266_ _05597_ net144 _05515_ _05598_ VDD VSS OAI21_X1
X_15267_ _05513_ _05598_ _05578_ _00349_ VDD VSS MUX2_X1
X_15268_ _05596_ samples_imag\[1\]\[3\] _05592_ _05599_ VDD
+ VSS NAND3_X4
X_15269_ _05599_ net144 _05520_ _05600_ VDD VSS OAI21_X2
X_15270_ _05524_ _05600_ _05578_ _00350_ VDD VSS MUX2_X1
X_15271_ net520 _05531_ _05601_ VDD VSS AND2_X1
X_15272_ _05596_ samples_imag\[1\]\[4\] _05592_ _05602_ VDD
+ VSS NAND3_X4
X_15273_ _05602_ net144 _05527_ _05603_ VDD VSS OAI21_X2
X_15274_ _05601_ _05603_ _05578_ _00351_ VDD VSS MUX2_X1
X_15275_ _05539_ _05604_ VDD VSS INV_X1
X_15276_ _05596_ samples_imag\[1\]\[5\] _05592_ _05605_ VDD
+ VSS NAND3_X4
X_15277_ _05605_ net144 _05535_ _05606_ VDD VSS OAI21_X2
X_15278_ _05604_ _05606_ _05578_ _00352_ VDD VSS MUX2_X1
X_15279_ _05546_ _05607_ VDD VSS INV_X1
X_15280_ _05596_ net534 samples_imag\[1\]\[6\] _05608_ VDD
+ VSS NAND3_X1
X_15281_ _05608_ net144 _05542_ _05609_ VDD VSS OAI21_X2
X_15282_ _05607_ _05609_ _05578_ _00353_ VDD VSS MUX2_X1
X_15283_ net151 samples_imag\[1\]\[7\] _05610_ VDD VSS NAND2_X4
X_15284_ _05610_ _05582_ _05554_ _05549_ _05585_ _00354_ VDD
+ VSS OAI221_X2
X_15285_ net151 samples_imag\[1\]\[8\] _05611_ VDD VSS NAND2_X1
X_15286_ _05611_ _05582_ _05561_ _05557_ _05585_ _00355_ VDD
+ VSS OAI221_X1
X_15287_ net151 samples_imag\[1\]\[9\] _05612_ VDD VSS NAND2_X1
X_15288_ _05612_ _05582_ _05569_ _05565_ _05585_ _00356_ VDD
+ VSS OAI221_X1
X_15289_ _05345_ _05613_ VDD VSS INV_X1
X_15290_ _05344_ _05613_ _05346_ _05614_ VDD VSS NAND3_X1
X_15291_ _05348_ _05574_ _05355_ _05615_ VDD VSS NAND3_X2
X_15292_ _05614_ _05615_ net138 _05616_ VDD VSS MUX2_X2
Xclone133 _05614_ _05615_ net138 net133 VDD VSS MUX2_X2
X_15294_ _04794_ _05618_ VDD VSS INV_X1
X_15295_ _05618_ _04791_ _05619_ VDD VSS NAND2_X2
X_15296_ _04790_ _05619_ _05620_ VDD VSS NOR2_X2
X_15297_ net153 _05620_ _05621_ VDD VSS NAND2_X2
X_15298_ _00842_ _05616_ _05621_ _05622_ VDD VSS AND3_X2
X_15299_ _05622_ _05623_ VDD VSS BUF_X4
X_15300_ samples_imag\[2\]\[0\] net149 _05624_ VDD VSS NAND2_X1
X_15301_ _04790_ _05619_ _05625_ VDD VSS OR2_X1
X_15302_ _05625_ _05626_ VDD VSS CLKBUF_X3
X_15303_ _05626_ _05627_ VDD VSS CLKBUF_X3
X_15304_ _05616_ _05628_ VDD VSS INV_X2
X_15305_ _05628_ _05621_ _05629_ VDD VSS NAND2_X2
X_15306_ _05629_ _05630_ VDD VSS BUF_X4
X_15307_ _05624_ _05627_ _05442_ net530 _05630_ _00357_ VDD
+ VSS OAI221_X1
X_15308_ samples_imag\[2\]\[10\] net149 _05631_ VDD VSS NAND2_X1
X_15309_ _05631_ _05627_ _05465_ _05445_ _05630_ _00358_ VDD
+ VSS OAI221_X1
X_15310_ samples_imag\[2\]\[11\] _05623_ _05632_ VDD VSS NAND2_X1
X_15311_ _05632_ _05627_ _05472_ net528 _05630_ _00359_ VDD
+ VSS OAI221_X1
X_15312_ samples_imag\[2\]\[12\] _05623_ _05633_ VDD VSS NAND2_X1
X_15313_ _05633_ _05627_ _05482_ net529 _05630_ _00360_ VDD
+ VSS OAI221_X1
X_15314_ samples_imag\[2\]\[13\] net149 _05634_ VDD VSS NAND2_X1
X_15315_ _05634_ _05627_ _05490_ _05486_ _05630_ _00361_ VDD
+ VSS OAI221_X1
X_15316_ samples_imag\[2\]\[14\] net149 _05635_ VDD VSS NAND2_X1
X_15317_ _05635_ _05627_ _05500_ _05493_ _05630_ _00362_ VDD
+ VSS OAI221_X1
X_15318_ _05503_ _05628_ _05636_ VDD VSS NAND2_X1
X_15319_ _00856_ samples_imag\[2\]\[15\] net133 _05637_ VDD
+ VSS NAND3_X1
X_15320_ _05636_ _05637_ _05638_ VDD VSS NAND2_X1
X_15321_ _05501_ _05638_ _05621_ _00363_ VDD VSS MUX2_X1
X_15322_ samples_imag\[2\]\[1\] net149 _05639_ VDD VSS NAND2_X1
X_15323_ _05639_ _05626_ _05511_ net531 _05630_ _00364_ VDD
+ VSS OAI221_X1
X_15324_ _05596_ samples_imag\[2\]\[2\] _05616_ _05640_ VDD
+ VSS NAND3_X1
X_15325_ _05640_ _05515_ net133 _05641_ VDD VSS OAI21_X1
X_15326_ _05513_ _05641_ _05621_ _00365_ VDD VSS MUX2_X1
X_15327_ _05596_ samples_imag\[2\]\[3\] _05616_ _05642_ VDD
+ VSS NAND3_X1
X_15328_ _05642_ _05520_ net133 _05643_ VDD VSS OAI21_X1
X_15329_ _05524_ _05643_ _05621_ _00366_ VDD VSS MUX2_X1
X_15330_ _05596_ samples_imag\[2\]\[4\] _05616_ _05644_ VDD
+ VSS NAND3_X1
X_15331_ _05644_ net133 _05527_ _05645_ VDD VSS OAI21_X1
X_15332_ _05601_ _05645_ _05621_ _00367_ VDD VSS MUX2_X1
X_15333_ samples_imag\[2\]\[5\] _05623_ _05646_ VDD VSS NAND2_X1
X_15334_ _05646_ _05626_ _05539_ _05535_ _05630_ _00368_ VDD
+ VSS OAI221_X1
X_15335_ samples_imag\[2\]\[6\] _05623_ _05647_ VDD VSS NAND2_X1
X_15336_ _05647_ _05626_ _05546_ _05542_ _05630_ _00369_ VDD
+ VSS OAI221_X1
X_15337_ _05623_ samples_imag\[2\]\[7\] _05648_ VDD VSS NAND2_X1
X_15338_ _05648_ _05626_ _05554_ _05549_ _05630_ _00370_ VDD
+ VSS OAI221_X1
X_15339_ _05622_ samples_imag\[2\]\[8\] _05649_ VDD VSS NAND2_X1
X_15340_ _05649_ _05626_ _05561_ _05557_ _05629_ _00371_ VDD
+ VSS OAI221_X1
X_15341_ _05622_ samples_imag\[2\]\[9\] _05650_ VDD VSS NAND2_X1
X_15342_ _05650_ _05626_ _05569_ _05565_ _05629_ _00372_ VDD
+ VSS OAI221_X1
X_15343_ _05572_ _05613_ _05346_ _05651_ VDD VSS NAND3_X1
X_15344_ _05348_ _00027_ _05652_ VDD VSS NOR2_X1
X_15345_ _05355_ _05652_ _05653_ VDD VSS NAND2_X1
X_15346_ _05651_ _05653_ _05429_ _05654_ VDD VSS MUX2_X2
X_15347_ _05296_ _05619_ _05655_ VDD VSS NOR2_X2
X_15348_ net526 _05655_ _05656_ VDD VSS NAND2_X2
X_15349_ _05654_ _05656_ _05571_ _05657_ VDD VSS AND3_X4
X_15350_ _05657_ _05658_ VDD VSS BUF_X16
X_15351_ samples_imag\[3\]\[0\] net132 _05659_ VDD VSS NAND2_X4
X_15352_ _05296_ _05619_ _05660_ VDD VSS OR2_X1
X_15353_ _05660_ _05661_ VDD VSS CLKBUF_X3
X_15354_ _05661_ _05662_ VDD VSS CLKBUF_X3
X_15355_ _05654_ _05663_ VDD VSS INV_X2
X_15356_ _05663_ _05656_ _05664_ VDD VSS NAND2_X2
X_15357_ _05664_ _05665_ VDD VSS BUF_X4
X_15358_ _05659_ _05662_ _05442_ net530 _05665_ _00373_ VDD
+ VSS OAI221_X2
X_15359_ samples_imag\[3\]\[10\] net132 _05666_ VDD VSS NAND2_X4
X_15360_ _05666_ _05662_ _05465_ _05445_ _05665_ _00374_ VDD
+ VSS OAI221_X2
X_15361_ samples_imag\[3\]\[11\] _05658_ _05667_ VDD VSS NAND2_X4
X_15362_ _05667_ _05662_ _05472_ net528 _05665_ _00375_ VDD
+ VSS OAI221_X2
X_15363_ _05658_ samples_imag\[3\]\[12\] _05668_ VDD VSS NAND2_X4
X_15364_ _05668_ _05662_ _05482_ net529 _05665_ _00376_ VDD
+ VSS OAI221_X2
X_15365_ _05658_ samples_imag\[3\]\[13\] _05669_ VDD VSS NAND2_X4
X_15366_ _05669_ _05662_ _05490_ _05486_ _05665_ _00377_ VDD
+ VSS OAI221_X2
X_15367_ _05658_ samples_imag\[3\]\[14\] _05670_ VDD VSS NAND2_X4
X_15368_ _05670_ _05662_ _05500_ _05493_ _05665_ _00378_ VDD
+ VSS OAI221_X2
X_15369_ _05503_ _05663_ _05671_ VDD VSS NAND2_X1
X_15370_ _00855_ _05672_ VDD VSS CLKBUF_X3
X_15371_ _05672_ samples_imag\[3\]\[15\] _05654_ _05673_ VDD
+ VSS NAND3_X1
X_15372_ _05671_ _05673_ _05674_ VDD VSS NAND2_X1
X_15373_ _05501_ _05674_ _05656_ _00379_ VDD VSS MUX2_X1
X_15374_ net132 samples_imag\[3\]\[1\] _05675_ VDD VSS NAND2_X4
X_15375_ _05675_ _05661_ _05511_ net531 _05665_ _00380_ VDD
+ VSS OAI221_X2
X_15376_ _05571_ _05676_ VDD VSS CLKBUF_X3
X_15377_ _05676_ _05654_ samples_imag\[3\]\[2\] _05677_ VDD
+ VSS NAND3_X1
X_15378_ _05677_ _05654_ _05515_ _05678_ VDD VSS OAI21_X1
X_15379_ _05513_ _05678_ _05656_ _00381_ VDD VSS MUX2_X1
X_15380_ _05524_ _05655_ _05657_ samples_imag\[3\]\[3\] _05679_
+ VDD VSS AOI22_X1
X_15381_ _05679_ _05665_ _05520_ _00382_ VDD VSS OAI21_X1
X_15382_ net132 samples_imag\[3\]\[4\] _05680_ VDD VSS NAND2_X4
X_15383_ _05680_ _05661_ _05532_ _05527_ _05665_ _00383_ VDD
+ VSS OAI221_X2
X_15384_ net132 samples_imag\[3\]\[5\] _05681_ VDD VSS NAND2_X4
X_15385_ _05681_ _05661_ _05539_ _05535_ _05665_ _00384_ VDD
+ VSS OAI221_X2
X_15386_ _05658_ samples_imag\[3\]\[6\] _05682_ VDD VSS NAND2_X4
X_15387_ _05682_ _05661_ _05546_ _05542_ _05664_ _00385_ VDD
+ VSS OAI221_X2
X_15388_ _05657_ samples_imag\[3\]\[7\] _05683_ VDD VSS NAND2_X1
X_15389_ _05683_ _05661_ _05554_ _05549_ _05664_ _00386_ VDD
+ VSS OAI221_X1
X_15390_ _05657_ samples_imag\[3\]\[8\] _05684_ VDD VSS NAND2_X1
X_15391_ _05684_ _05661_ _05561_ _05557_ _05664_ _00387_ VDD
+ VSS OAI221_X1
X_15392_ _05657_ samples_imag\[3\]\[9\] _05685_ VDD VSS NAND2_X1
X_15393_ _05685_ _05661_ _05569_ _05565_ _05664_ _00388_ VDD
+ VSS OAI221_X1
X_15394_ _05346_ _05686_ VDD VSS INV_X1
X_15395_ _05344_ _05345_ _05686_ _05687_ VDD VSS NAND3_X1
X_15396_ _00029_ _05351_ _05354_ _05688_ VDD VSS NOR3_X2
X_15397_ _05348_ _00027_ _05688_ _05689_ VDD VSS NAND3_X1
X_15398_ _05687_ _05689_ net497 _05690_ VDD VSS MUX2_X2
X_15399_ _05618_ _04791_ idx2\[0\] _05691_ VDD VSS OR3_X1
X_15400_ _05691_ _05692_ VDD VSS BUF_X4
X_15401_ _05692_ _05693_ VDD VSS INV_X1
X_15402_ net526 _05693_ _05694_ VDD VSS NAND2_X2
X_15403_ _05571_ _05694_ _05690_ _05695_ VDD VSS AND3_X4
X_15404_ _05695_ _05696_ VDD VSS BUF_X8
X_15405_ net156 samples_imag\[4\]\[0\] _05697_ VDD VSS NAND2_X4
X_15406_ _05692_ _05698_ VDD VSS BUF_X4
X_15407_ _05690_ _05699_ VDD VSS INV_X2
X_15408_ _05699_ _05694_ _05700_ VDD VSS NAND2_X2
X_15409_ _05700_ _05701_ VDD VSS BUF_X4
X_15410_ _05697_ _05698_ _05442_ net530 _05701_ _00389_ VDD
+ VSS OAI221_X2
X_15411_ samples_imag\[4\]\[10\] net156 _05702_ VDD VSS NAND2_X4
X_15412_ _05702_ _05698_ _05465_ _05445_ _05701_ _00390_ VDD
+ VSS OAI221_X2
X_15413_ samples_imag\[4\]\[11\] _05696_ _05703_ VDD VSS NAND2_X4
X_15414_ _05703_ _05698_ _05472_ net528 _05701_ _00391_ VDD
+ VSS OAI221_X2
X_15415_ samples_imag\[4\]\[12\] _05696_ _05704_ VDD VSS NAND2_X4
X_15416_ _05704_ _05698_ _05482_ net529 _05701_ _00392_ VDD
+ VSS OAI221_X2
X_15417_ samples_imag\[4\]\[13\] _05696_ _05705_ VDD VSS NAND2_X2
X_15418_ _05705_ _05698_ _05490_ _05486_ _05701_ _00393_ VDD
+ VSS OAI221_X1
X_15419_ net156 samples_imag\[4\]\[14\] _05706_ VDD VSS NAND2_X4
X_15420_ _05706_ _05698_ _05500_ _05493_ _05701_ _00394_ VDD
+ VSS OAI221_X2
X_15421_ _05503_ _05699_ _05707_ VDD VSS NAND2_X1
X_15422_ _05672_ samples_imag\[4\]\[15\] _05690_ _05708_ VDD
+ VSS NAND3_X1
X_15423_ _05707_ _05708_ _05709_ VDD VSS NAND2_X1
X_15424_ _05501_ _05709_ _05694_ _00395_ VDD VSS MUX2_X1
X_15425_ net156 samples_imag\[4\]\[1\] _05710_ VDD VSS NAND2_X4
X_15426_ _05710_ _05692_ _05511_ net531 _05701_ _00396_ VDD
+ VSS OAI221_X2
X_15427_ _05676_ samples_imag\[4\]\[2\] _05690_ _05711_ VDD
+ VSS NAND3_X1
X_15428_ _05711_ _05515_ _05690_ _05712_ VDD VSS OAI21_X1
X_15429_ _05513_ _05712_ _05694_ _00397_ VDD VSS MUX2_X1
X_15430_ _05676_ samples_imag\[4\]\[3\] _05690_ _05713_ VDD
+ VSS NAND3_X1
X_15431_ _05713_ _05690_ _05520_ _05714_ VDD VSS OAI21_X1
X_15432_ _05524_ _05714_ _05694_ _00398_ VDD VSS MUX2_X1
X_15433_ _05696_ samples_imag\[4\]\[4\] _05715_ VDD VSS NAND2_X4
X_15434_ _05715_ _05692_ _05532_ _05527_ _05701_ _00399_ VDD
+ VSS OAI221_X2
X_15435_ net156 samples_imag\[4\]\[5\] _05716_ VDD VSS NAND2_X4
X_15436_ _05716_ _05692_ _05539_ _05535_ _05701_ _00400_ VDD
+ VSS OAI221_X2
X_15437_ _05696_ samples_imag\[4\]\[6\] _05717_ VDD VSS NAND2_X4
X_15438_ _05717_ _05692_ _05546_ _05542_ _05701_ _00401_ VDD
+ VSS OAI221_X2
X_15439_ _05695_ samples_imag\[4\]\[7\] _05718_ VDD VSS NAND2_X1
X_15440_ _05718_ _05692_ _05554_ _05549_ _05700_ _00402_ VDD
+ VSS OAI221_X1
X_15441_ _05695_ samples_imag\[4\]\[8\] _05719_ VDD VSS NAND2_X1
X_15442_ _05719_ _05692_ _05561_ _05557_ _05700_ _00403_ VDD
+ VSS OAI221_X1
X_15443_ _05695_ samples_imag\[4\]\[9\] _05720_ VDD VSS NAND2_X1
X_15444_ _05720_ _05692_ _05569_ _05565_ _05700_ _00404_ VDD
+ VSS OAI221_X1
X_15445_ _05572_ _05345_ _05686_ _05721_ VDD VSS NAND3_X1
X_15446_ _05575_ _05688_ _05722_ VDD VSS NAND2_X1
X_15447_ _05721_ _05722_ net497 _05723_ VDD VSS MUX2_X2
X_15448_ _04794_ _04790_ _05724_ VDD VSS NAND2_X1
X_15449_ _04791_ _05724_ _05725_ VDD VSS NOR2_X2
X_15450_ net526 _05725_ _05726_ VDD VSS NAND2_X2
X_15451_ _05571_ _05726_ _05723_ _05727_ VDD VSS AND3_X4
X_15452_ _05727_ _05728_ VDD VSS BUF_X8
X_15453_ net158 samples_imag\[5\]\[0\] _05729_ VDD VSS NAND2_X4
X_15454_ _04791_ _05724_ _05730_ VDD VSS OR2_X1
X_15455_ _05730_ _05731_ VDD VSS BUF_X4
X_15456_ _05731_ _05732_ VDD VSS BUF_X4
X_15457_ _05723_ _05733_ VDD VSS INV_X2
X_15458_ _05733_ _05726_ _05734_ VDD VSS NAND2_X2
X_15459_ _05734_ _05735_ VDD VSS BUF_X4
X_15460_ _05729_ _05732_ _05442_ net530 _05735_ _00405_ VDD
+ VSS OAI221_X2
X_15461_ samples_imag\[5\]\[10\] net158 _05736_ VDD VSS NAND2_X4
X_15462_ _05736_ _05732_ _05465_ _05445_ _05735_ _00406_ VDD
+ VSS OAI221_X2
X_15463_ samples_imag\[5\]\[11\] _05728_ _05737_ VDD VSS NAND2_X4
X_15464_ _05737_ _05732_ _05472_ net528 _05735_ _00407_ VDD
+ VSS OAI221_X2
X_15465_ samples_imag\[5\]\[12\] _05728_ _05738_ VDD VSS NAND2_X4
X_15466_ _05738_ _05732_ _05482_ net529 _05735_ _00408_ VDD
+ VSS OAI221_X2
X_15467_ _05728_ samples_imag\[5\]\[13\] _05739_ VDD VSS NAND2_X4
X_15468_ _05739_ _05732_ _05490_ _05486_ _05735_ _00409_ VDD
+ VSS OAI221_X2
X_15469_ samples_imag\[5\]\[14\] net158 _05740_ VDD VSS NAND2_X2
X_15470_ _05740_ _05732_ _05500_ _05493_ _05735_ _00410_ VDD
+ VSS OAI221_X1
X_15471_ _05503_ _05733_ _05741_ VDD VSS NAND2_X1
X_15472_ _05672_ samples_imag\[5\]\[15\] _05723_ _05742_ VDD
+ VSS NAND3_X1
X_15473_ _05741_ _05742_ _05743_ VDD VSS NAND2_X1
X_15474_ _05501_ _05743_ _05726_ _00411_ VDD VSS MUX2_X1
X_15475_ samples_imag\[5\]\[1\] net158 _05744_ VDD VSS NAND2_X2
X_15476_ _05744_ _05731_ _05511_ net531 _05735_ _00412_ VDD
+ VSS OAI221_X1
X_15477_ _05676_ samples_imag\[5\]\[2\] _05723_ _05745_ VDD
+ VSS NAND3_X1
X_15478_ _05745_ _05515_ net527 _05746_ VDD VSS OAI21_X1
X_15479_ _05513_ _05746_ _05726_ _00413_ VDD VSS MUX2_X1
X_15480_ _05676_ _05723_ samples_imag\[5\]\[3\] _05747_ VDD
+ VSS NAND3_X1
X_15481_ _05747_ _05723_ _05520_ _05748_ VDD VSS OAI21_X1
X_15482_ _05524_ _05748_ _05726_ _00414_ VDD VSS MUX2_X1
X_15483_ samples_imag\[5\]\[4\] _05728_ _05749_ VDD VSS NAND2_X4
X_15484_ _05749_ _05731_ _05532_ _05527_ _05735_ _00415_ VDD
+ VSS OAI221_X2
X_15485_ net158 samples_imag\[5\]\[5\] _05750_ VDD VSS NAND2_X4
X_15486_ _05750_ _05731_ _05539_ _05535_ _05735_ _00416_ VDD
+ VSS OAI221_X2
X_15487_ _05728_ samples_imag\[5\]\[6\] _05751_ VDD VSS NAND2_X4
X_15488_ _05751_ _05731_ _05546_ _05542_ _05735_ _00417_ VDD
+ VSS OAI221_X2
X_15489_ _05727_ samples_imag\[5\]\[7\] _05752_ VDD VSS NAND2_X1
X_15490_ _05752_ _05731_ _05554_ _05549_ _05734_ _00418_ VDD
+ VSS OAI221_X1
X_15491_ _05727_ samples_imag\[5\]\[8\] _05753_ VDD VSS NAND2_X1
X_15492_ _05753_ _05731_ _05561_ _05557_ _05734_ _00419_ VDD
+ VSS OAI221_X1
X_15493_ _05727_ samples_imag\[5\]\[9\] _05754_ VDD VSS NAND2_X1
X_15494_ _05754_ _05731_ _05569_ _05565_ _05734_ _00420_ VDD
+ VSS OAI221_X1
X_15495_ _05345_ _05346_ _05755_ VDD VSS NOR2_X1
X_15496_ _05344_ _05755_ _05756_ VDD VSS NAND2_X1
X_15497_ _05348_ _05574_ _05688_ _05757_ VDD VSS NAND3_X1
X_15498_ _05756_ _05757_ _05429_ _05758_ VDD VSS MUX2_X2
X_15499_ _04794_ _04791_ _05296_ _05759_ VDD VSS AND3_X1
X_15500_ _05759_ net153 _05760_ VDD VSS NAND2_X2
X_15501_ _05758_ _05571_ _05760_ _05761_ VDD VSS AND3_X4
X_15502_ _05761_ _05762_ VDD VSS BUF_X16
X_15503_ samples_imag\[6\]\[0\] net131 _05763_ VDD VSS NAND2_X4
X_15504_ _04794_ _04791_ _05296_ _05764_ VDD VSS NAND3_X4
X_15505_ _05764_ _05765_ VDD VSS BUF_X4
X_15506_ _05758_ _05766_ VDD VSS INV_X2
X_15507_ _05766_ _05760_ _05767_ VDD VSS NAND2_X2
X_15508_ _05767_ _05768_ VDD VSS BUF_X4
X_15509_ _05763_ _05765_ _05442_ _05431_ _05768_ _00421_ VDD
+ VSS OAI221_X2
X_15510_ net131 samples_imag\[6\]\[10\] _05769_ VDD VSS NAND2_X4
X_15511_ _05769_ _05765_ _05465_ _05445_ _05768_ _00422_ VDD
+ VSS OAI221_X2
X_15512_ net131 samples_imag\[6\]\[11\] _05770_ VDD VSS NAND2_X4
X_15513_ _05770_ _05765_ _05472_ net528 _05768_ _00423_ VDD
+ VSS OAI221_X2
X_15514_ net131 samples_imag\[6\]\[12\] _05771_ VDD VSS NAND2_X4
X_15515_ _05771_ _05765_ _05482_ _05475_ _05768_ _00424_ VDD
+ VSS OAI221_X2
X_15516_ net131 samples_imag\[6\]\[13\] _05772_ VDD VSS NAND2_X4
X_15517_ _05772_ _05765_ _05490_ _05486_ _05768_ _00425_ VDD
+ VSS OAI221_X2
X_15518_ _05762_ samples_imag\[6\]\[14\] _05773_ VDD VSS NAND2_X4
X_15519_ _05773_ _05765_ _05500_ _05493_ _05768_ _00426_ VDD
+ VSS OAI221_X2
X_15520_ _05503_ _05766_ _05774_ VDD VSS NAND2_X1
X_15521_ _05672_ samples_imag\[6\]\[15\] _05758_ _05775_ VDD
+ VSS NAND3_X1
X_15522_ _05774_ _05775_ _05776_ VDD VSS NAND2_X1
X_15523_ _05501_ _05776_ _05760_ _00427_ VDD VSS MUX2_X1
X_15524_ _05762_ samples_imag\[6\]\[1\] _05777_ VDD VSS NAND2_X4
X_15525_ _05777_ _05764_ _05511_ net531 _05768_ _00428_ VDD
+ VSS OAI221_X2
X_15526_ _05676_ _05758_ samples_imag\[6\]\[2\] _05778_ VDD
+ VSS NAND3_X1
X_15527_ _05778_ _05758_ _05515_ _05779_ VDD VSS OAI21_X1
X_15528_ _05513_ _05779_ _05760_ _00429_ VDD VSS MUX2_X1
X_15529_ _05524_ _05759_ _05761_ samples_imag\[6\]\[3\] _05780_
+ VDD VSS AOI22_X1
X_15530_ _05780_ _05768_ _05520_ _00430_ VDD VSS OAI21_X1
X_15531_ _05762_ samples_imag\[6\]\[4\] _05781_ VDD VSS NAND2_X4
X_15532_ _05781_ _05764_ _05532_ _05527_ _05768_ _00431_ VDD
+ VSS OAI221_X2
X_15533_ _05762_ samples_imag\[6\]\[5\] _05782_ VDD VSS NAND2_X4
X_15534_ _05782_ _05764_ _05539_ _05535_ _05768_ _00432_ VDD
+ VSS OAI221_X2
X_15535_ _05762_ samples_imag\[6\]\[6\] _05783_ VDD VSS NAND2_X4
X_15536_ _05783_ _05764_ _05546_ _05542_ _05767_ _00433_ VDD
+ VSS OAI221_X2
X_15537_ _05761_ samples_imag\[6\]\[7\] _05784_ VDD VSS NAND2_X1
X_15538_ _05784_ _05764_ _05554_ _05549_ _05767_ _00434_ VDD
+ VSS OAI221_X1
X_15539_ _05761_ samples_imag\[6\]\[8\] _05785_ VDD VSS NAND2_X1
X_15540_ _05785_ _05764_ _05561_ _05557_ _05767_ _00435_ VDD
+ VSS OAI221_X1
X_15541_ _05761_ samples_imag\[6\]\[9\] _05786_ VDD VSS NAND2_X1
X_15542_ _05786_ _05764_ _05569_ _05565_ _05767_ _00436_ VDD
+ VSS OAI221_X1
X_15543_ _05572_ _05755_ _05787_ VDD VSS NAND2_X1
X_15544_ _05652_ _05688_ _05788_ VDD VSS NAND2_X1
X_15545_ _05787_ _05788_ net497 _05789_ VDD VSS MUX2_X1
X_15546_ _05342_ _04791_ _04790_ _04794_ _05790_ VDD VSS NAND4_X4
X_15547_ _00842_ _05790_ _05789_ _05791_ VDD VSS AND3_X4
X_15548_ _05791_ _05792_ VDD VSS BUF_X8
X_15549_ samples_imag\[7\]\[0\] net154 _05793_ VDD VSS NAND2_X1
X_15550_ _04794_ _04791_ _04790_ _05794_ VDD VSS NAND3_X4
X_15551_ _05794_ _05795_ VDD VSS BUF_X4
X_15552_ _05789_ _05796_ VDD VSS BUF_X8
X_15553_ _05796_ _05797_ VDD VSS INV_X8
X_15554_ _05797_ _05790_ _05798_ VDD VSS NAND2_X4
X_15555_ _05798_ _05799_ VDD VSS BUF_X8
X_15556_ _05793_ _05795_ _05442_ net530 net152 _00437_ VDD
+ VSS OAI221_X2
X_15557_ samples_imag\[7\]\[10\] net154 _05800_ VDD VSS NAND2_X2
X_15558_ _05800_ _05795_ _05465_ _05445_ _05799_ _00438_ VDD
+ VSS OAI221_X2
X_15559_ samples_imag\[7\]\[11\] _05792_ _05801_ VDD VSS NAND2_X2
X_15560_ _05801_ _05795_ _05472_ net528 _05799_ _00439_ VDD
+ VSS OAI221_X2
X_15561_ samples_imag\[7\]\[12\] _05792_ _05802_ VDD VSS NAND2_X2
X_15562_ _05802_ _05795_ _05482_ _05475_ _05799_ _00440_ VDD
+ VSS OAI221_X2
X_15563_ samples_imag\[7\]\[13\] net154 _05803_ VDD VSS NAND2_X2
X_15564_ _05803_ _05795_ _05490_ _05486_ _05799_ _00441_ VDD
+ VSS OAI221_X2
X_15565_ samples_imag\[7\]\[14\] net154 _05804_ VDD VSS NAND2_X2
X_15566_ _05804_ _05795_ _05500_ _05799_ _05493_ _00442_ VDD
+ VSS OAI221_X2
X_15567_ _05503_ _05797_ _05805_ VDD VSS NAND2_X2
X_15568_ _05672_ samples_imag\[7\]\[15\] net143 _05806_ VDD
+ VSS NAND3_X1
X_15569_ _05805_ _05806_ _05807_ VDD VSS NAND2_X1
X_15570_ _05501_ _05807_ _05790_ _00443_ VDD VSS MUX2_X1
X_15571_ net154 samples_imag\[7\]\[1\] _05808_ VDD VSS NAND2_X1
X_15572_ _05808_ _05794_ _05511_ net152 net531 _00444_ VDD
+ VSS OAI221_X2
X_15573_ _05676_ samples_imag\[7\]\[2\] _05796_ _05809_ VDD
+ VSS NAND3_X4
X_15574_ _05809_ net143 _05515_ _05810_ VDD VSS OAI21_X2
X_15575_ _05513_ _05810_ _05790_ _00445_ VDD VSS MUX2_X1
X_15576_ _05676_ samples_imag\[7\]\[3\] _05796_ _05811_ VDD
+ VSS NAND3_X4
X_15577_ _05811_ net143 _05520_ _05812_ VDD VSS OAI21_X2
X_15578_ _05524_ _05812_ _05790_ _00446_ VDD VSS MUX2_X1
X_15579_ _05796_ samples_imag\[7\]\[4\] _05676_ _05813_ VDD
+ VSS NAND3_X4
X_15580_ _05813_ net143 _05527_ _05814_ VDD VSS OAI21_X2
X_15581_ _05601_ _05814_ _05790_ _00447_ VDD VSS MUX2_X1
X_15582_ _05796_ samples_imag\[7\]\[5\] _05676_ _05815_ VDD
+ VSS NAND3_X4
X_15583_ _05815_ net143 _05535_ _05816_ VDD VSS OAI21_X2
X_15584_ _05604_ _05816_ _05790_ _00448_ VDD VSS MUX2_X1
X_15585_ samples_imag\[7\]\[6\] _05792_ _05817_ VDD VSS NAND2_X2
X_15586_ _05817_ _05794_ _05546_ _05542_ net152 _00449_ VDD
+ VSS OAI221_X2
X_15587_ samples_imag\[7\]\[7\] _05792_ _05818_ VDD VSS NAND2_X2
X_15588_ _05818_ _05794_ _05554_ _05549_ net152 _00450_ VDD
+ VSS OAI221_X2
X_15589_ _05792_ samples_imag\[7\]\[8\] _05819_ VDD VSS NAND2_X2
X_15590_ _05819_ _05794_ _05561_ _05557_ net152 _00451_ VDD
+ VSS OAI221_X2
X_15591_ samples_imag\[7\]\[9\] _05791_ _05820_ VDD VSS NAND2_X1
X_15592_ _05820_ _05794_ _05569_ _05798_ _05565_ _00452_ VDD
+ VSS OAI221_X1
X_15593_ _08651_ _05821_ VDD VSS INV_X1
X_15594_ _08652_ _05822_ VDD VSS BUF_X2
X_15595_ _08662_ _05823_ VDD VSS INV_X1
X_15596_ _08666_ _05824_ VDD VSS INV_X1
X_15597_ _08672_ _05825_ VDD VSS INV_X1
X_15598_ _08676_ _05826_ VDD VSS INV_X1
X_15599_ _08682_ _05827_ VDD VSS INV_X1
X_15600_ _08686_ _05828_ VDD VSS INV_X1
X_15601_ _08692_ _05829_ VDD VSS INV_X1
X_15602_ _08696_ _05830_ VDD VSS INV_X1
X_15603_ _08701_ _05831_ VDD VSS INV_X1
X_15604_ _08711_ _05832_ VDD VSS INV_X1
X_15605_ _08712_ _05833_ VDD VSS INV_X2
X_15606_ _05832_ _07360_ _05833_ _05834_ VDD VSS OAI21_X2
Xclone58 _05929_ net58 VDD VSS BUF_X4
X_15608_ _08706_ net448 _05834_ _05836_ VDD VSS AOI21_X4
Xclone57 _00001_ net57 VDD VSS BUF_X2
X_15610_ _08702_ _05838_ VDD VSS INV_X2
X_15611_ _05831_ _05836_ _05838_ _05839_ VDD VSS OAI21_X1
X_15612_ _08697_ _05839_ _05840_ VDD VSS NAND2_X1
X_15613_ _05829_ _05830_ _05840_ _05841_ VDD VSS AOI21_X2
X_15614_ _08687_ _08691_ _05841_ _05842_ VDD VSS OAI21_X2
X_15615_ _05827_ _05828_ _05842_ _05843_ VDD VSS AOI21_X2
X_15616_ _08677_ _08681_ _05843_ _05844_ VDD VSS OAI21_X2
X_15617_ _05825_ _05826_ _05844_ _05845_ VDD VSS AOI21_X2
X_15618_ _08667_ _08671_ _05845_ _05846_ VDD VSS OAI21_X2
X_15619_ _05823_ _05824_ _05846_ _05847_ VDD VSS AOI21_X1
X_15620_ _08657_ _08661_ _05847_ _05848_ VDD VSS OAI21_X1
X_15621_ _05848_ _05849_ VDD VSS INV_X2
X_15622_ _05822_ _08656_ _05849_ _05850_ VDD VSS OAI21_X4
X_15623_ _05821_ _05850_ _05851_ VDD VSS NAND2_X1
X_15624_ _08635_ _05851_ _08647_ _05852_ VDD VSS AOI21_X2
X_15625_ temp_real\[0\] _08642_ _05853_ VDD VSS XNOR2_X1
X_15626_ _05853_ _05852_ _05854_ VDD VSS XNOR2_X2
X_15627_ temp_real\[0\] _08645_ _05854_ _05855_ VDD VSS NAND3_X2
X_15628_ _05855_ _05302_ _05856_ VDD VSS AND2_X4
Xclone98 _05932_ net98 VDD VSS BUF_X8
X_15630_ _05856_ _05858_ VDD VSS INV_X2
X_15631_ _05858_ _05855_ _05341_ _05859_ VDD VSS OAI21_X4
X_15632_ _05859_ _05298_ _05860_ VDD VSS AND2_X4
Xclone94 _05347_ _05356_ net453 net94 VDD VSS MUX2_X2
X_15634_ _05860_ _05862_ VDD VSS INV_X1
X_15635_ _08648_ _05863_ VDD VSS INV_X1
X_15636_ _08658_ _05864_ VDD VSS INV_X1
X_15637_ _08668_ _05865_ VDD VSS INV_X1
X_15638_ _08678_ _05866_ VDD VSS INV_X1
X_15639_ _08688_ _05867_ VDD VSS INV_X1
X_15640_ _08698_ _05868_ VDD VSS INV_X1
X_15641_ _08708_ _05869_ VDD VSS INV_X1
X_15642_ _08713_ net481 _05833_ _05870_ VDD VSS AOI21_X4
X_15643_ _05869_ _05870_ net474 _05871_ VDD VSS OAI21_X4
X_15644_ _08703_ _05838_ _05871_ _05872_ VDD VSS AOI21_X4
X_15645_ _05868_ _05872_ _08697_ _05873_ VDD VSS OAI21_X4
X_15646_ _08693_ _05873_ _05829_ _05874_ VDD VSS AOI21_X4
X_15647_ _05867_ _08687_ _05874_ _05875_ VDD VSS OAI21_X4
X_15648_ _08683_ _05875_ _05827_ _05876_ VDD VSS AOI21_X4
X_15649_ _05866_ _08677_ _05876_ _05877_ VDD VSS OAI21_X4
X_15650_ _08673_ _05877_ _05825_ _05878_ VDD VSS AOI21_X4
X_15651_ _05865_ _05878_ _08667_ _05879_ VDD VSS OAI21_X4
X_15652_ _08663_ _05879_ _05823_ _05880_ VDD VSS AOI21_X4
X_15653_ _05864_ _05880_ _08657_ _05881_ VDD VSS OAI21_X4
X_15654_ _05822_ _05882_ VDD VSS INV_X1
X_15655_ _08653_ _05881_ _05882_ _05883_ VDD VSS AOI21_X1
X_15656_ _05863_ _05883_ _08636_ _05884_ VDD VSS OAI21_X2
X_15657_ _07355_ _08642_ _05885_ VDD VSS XNOR2_X1
X_15658_ _05885_ _05884_ _05886_ VDD VSS XNOR2_X2
X_15659_ temp_real\[0\] _08644_ _05887_ VDD VSS AND2_X1
X_15660_ _05869_ net474 _07358_ _05888_ VDD VSS OAI21_X2
X_15661_ _08703_ _05888_ _05838_ _05889_ VDD VSS AOI21_X2
X_15662_ _05868_ _05889_ _08697_ _05890_ VDD VSS OAI21_X2
X_15663_ _08693_ _05890_ _05829_ _05891_ VDD VSS AOI21_X4
X_15664_ _05867_ _05891_ _08687_ _05892_ VDD VSS OAI21_X4
X_15665_ _08683_ _05892_ _05827_ _05893_ VDD VSS AOI21_X4
X_15666_ _05866_ _05893_ _08677_ _05894_ VDD VSS OAI21_X4
X_15667_ _08673_ _05894_ _05825_ _05895_ VDD VSS AOI21_X4
X_15668_ _05865_ _05895_ _08667_ _05896_ VDD VSS OAI21_X2
X_15669_ _08663_ _05823_ _05896_ _05897_ VDD VSS AOI21_X4
X_15670_ _05864_ _05897_ _08657_ _05898_ VDD VSS OAI21_X2
X_15671_ _08653_ _05882_ _05898_ _05899_ VDD VSS AOI21_X2
X_15672_ _08636_ _05899_ _05900_ VDD VSS XOR2_X2
X_15673_ _05881_ _05822_ _05901_ VDD VSS XNOR2_X2
X_15674_ _08662_ _05879_ _05902_ VDD VSS XNOR2_X2
X_15675_ _08657_ _05903_ VDD VSS INV_X1
X_15676_ _05903_ _05897_ _05904_ VDD VSS XNOR2_X2
X_15677_ _08667_ _05905_ VDD VSS INV_X1
X_15678_ _05895_ _05905_ _05906_ VDD VSS XNOR2_X2
X_15679_ _08672_ net454 _05907_ VDD VSS XNOR2_X2
X_15680_ _08677_ _05908_ VDD VSS INV_X1
X_15681_ _05908_ net449 _05909_ VDD VSS XNOR2_X2
X_15682_ _08692_ _05873_ _05910_ VDD VSS XNOR2_X2
X_15683_ _08687_ _05911_ VDD VSS INV_X1
X_15684_ _05911_ net450 _05912_ VDD VSS XNOR2_X2
X_15685_ net447 net457 _05913_ VDD VSS XNOR2_X1
X_15686_ _08639_ _05914_ VDD VSS INV_X2
X_15687_ _07359_ _05914_ _05915_ VDD VSS NOR2_X1
X_15688_ _08697_ _05916_ VDD VSS INV_X1
X_15689_ _05916_ net451 _05917_ VDD VSS XNOR2_X2
X_15690_ net444 net455 _05918_ VDD VSS XNOR2_X2
X_15691_ _05917_ _05918_ _05919_ VDD VSS NOR2_X2
X_15692_ _05913_ _05915_ _05919_ _05920_ VDD VSS NAND3_X1
X_15693_ _08682_ _05875_ _05921_ VDD VSS XNOR2_X2
X_15694_ _05910_ _05912_ _05921_ _05920_ _05922_ VDD VSS OR4_X2
X_15695_ _05922_ _05907_ _05909_ _05906_ _05923_ VDD VSS OR4_X4
X_15696_ _05923_ _05902_ _05904_ _05901_ _05924_ VDD VSS OR4_X4
X_15697_ _05886_ _05887_ _05924_ _05900_ _05925_ VDD VSS OAI211_X4
X_15698_ _05302_ _05925_ _05926_ VDD VSS AND2_X4
Xclone59 _00873_ net59 VDD VSS BUF_X8
X_15700_ _05925_ _05341_ _05928_ VDD VSS NOR2_X4
X_15701_ _05928_ _05926_ _05929_ VDD VSS NOR2_X4
X_15702_ _05347_ _05356_ net453 _05930_ VDD VSS MUX2_X2
Xclone97 _05930_ net97 VDD VSS BUF_X8
X_15704_ _05423_ _05862_ _05930_ _05932_ VDD VSS AND3_X4
X_15705_ _05932_ _05933_ VDD VSS BUF_X8
X_15706_ samples_real\[0\]\[0\] net98 _05934_ VDD VSS NAND2_X1
X_15707_ net443 _05935_ VDD VSS BUF_X8
X_15708_ _05929_ _05936_ VDD VSS BUF_X16
X_15709_ _05936_ _05937_ VDD VSS BUF_X32
X_15710_ _05914_ _05935_ net491 net70 _05938_ VDD VSS AOI22_X4
X_15711_ net70 _05494_ _05939_ VDD VSS NAND2_X1
X_15712_ _05930_ _05940_ VDD VSS BUF_X4
X_15713_ _05938_ _05939_ net97 _05941_ VDD VSS MUX2_X1
X_15714_ _05860_ _05942_ VDD VSS CLKBUF_X3
X_15715_ _05914_ net478 _05943_ VDD VSS NAND2_X4
X_15716_ _05934_ _05941_ _05942_ _05552_ _05943_ _00453_ VDD
+ VSS OAI221_X1
X_15717_ samples_real\[0\]\[10\] net98 _05944_ VDD VSS NAND2_X1
X_15718_ net456 _05935_ net491 net71 _05945_ VDD VSS AOI22_X4
X_15719_ net71 _05494_ _05946_ VDD VSS NAND2_X1
X_15720_ _05945_ _05946_ _05940_ _05947_ VDD VSS MUX2_X1
X_15721_ _05858_ _05948_ VDD VSS CLKBUF_X3
X_15722_ _08671_ _05949_ VDD VSS INV_X1
X_15723_ _08681_ _05950_ VDD VSS INV_X1
X_15724_ _08691_ _05951_ VDD VSS INV_X1
X_15725_ net446 _05952_ VDD VSS INV_X1
X_15726_ _05952_ _07361_ _05953_ VDD VSS NOR2_X2
X_15727_ net444 _08706_ _05953_ _05954_ VDD VSS OAI21_X1
X_15728_ _05916_ _05831_ _05954_ _05955_ VDD VSS AOI21_X1
X_15729_ _08692_ _08696_ _05955_ _05956_ VDD VSS OAI21_X1
X_15730_ _05911_ _05951_ _05956_ _05957_ VDD VSS AOI21_X1
X_15731_ _08682_ _08686_ _05957_ _05958_ VDD VSS OAI21_X1
X_15732_ _05908_ _05950_ _05958_ _05959_ VDD VSS AOI21_X1
X_15733_ _08672_ _08676_ _05959_ _05960_ VDD VSS OAI21_X1
X_15734_ _05905_ _05949_ _05960_ _05961_ VDD VSS AND3_X1
X_15735_ _05905_ _05949_ _05960_ _05962_ VDD VSS AOI21_X1
X_15736_ _05948_ _05961_ _05962_ _05963_ VDD VSS OR3_X1
X_15737_ _05963_ _05964_ VDD VSS CLKBUF_X3
X_15738_ _05944_ _05947_ _05942_ _05552_ _05964_ _00454_ VDD
+ VSS OAI221_X1
X_15739_ samples_real\[0\]\[11\] net98 _05965_ VDD VSS NAND2_X1
X_15740_ _05902_ _05935_ _05937_ net72 _05966_ VDD VSS AOI22_X4
X_15741_ _05433_ _05967_ VDD VSS CLKBUF_X3
X_15742_ net72 _05967_ _05968_ VDD VSS NAND2_X1
X_15743_ _05966_ _05968_ _05940_ _05969_ VDD VSS MUX2_X1
X_15744_ _05823_ _05824_ _05846_ _05970_ VDD VSS AND3_X1
X_15745_ _05847_ _05948_ _05970_ _05971_ VDD VSS OR3_X1
X_15746_ _05971_ _05972_ VDD VSS BUF_X4
X_15747_ _05965_ _05942_ _05969_ _05552_ _05972_ _00455_ VDD
+ VSS OAI221_X1
X_15748_ samples_real\[0\]\[12\] _05933_ _05973_ VDD VSS NAND2_X1
X_15749_ _05904_ _05935_ _05937_ net73 _05974_ VDD VSS AOI22_X4
X_15750_ net73 _05967_ _05975_ VDD VSS NAND2_X1
X_15751_ _05974_ _05975_ _05940_ _05976_ VDD VSS MUX2_X1
X_15752_ _08661_ _05977_ VDD VSS INV_X1
X_15753_ _08662_ _08666_ _05962_ _05978_ VDD VSS OAI21_X1
X_15754_ _05903_ _05977_ _05978_ _05979_ VDD VSS AND3_X1
X_15755_ _05903_ _05977_ _05978_ _05980_ VDD VSS AOI21_X1
X_15756_ _05948_ _05979_ _05980_ _05981_ VDD VSS OR3_X1
X_15757_ _05981_ _05982_ VDD VSS CLKBUF_X3
X_15758_ _05973_ _05976_ _05942_ _05552_ _05982_ _00456_ VDD
+ VSS OAI221_X1
X_15759_ samples_real\[0\]\[13\] _05933_ _05983_ VDD VSS NAND2_X1
X_15760_ net464 _05935_ net491 net74 _05984_ VDD VSS AOI22_X4
X_15761_ net74 _05967_ _05985_ VDD VSS NAND2_X1
X_15762_ _05984_ _05985_ net97 _05986_ VDD VSS MUX2_X1
X_15763_ _05822_ _08656_ _05849_ _05987_ VDD VSS OR3_X2
X_15764_ _05850_ net478 _05987_ _05988_ VDD VSS NAND3_X4
X_15765_ _05983_ _05986_ _05942_ _05552_ _05988_ _00457_ VDD
+ VSS OAI221_X1
X_15766_ samples_real\[0\]\[14\] _05933_ _05989_ VDD VSS NAND2_X1
X_15767_ net459 _05935_ net491 net75 _05990_ VDD VSS AOI22_X4
X_15768_ net75 _05967_ _05991_ VDD VSS NAND2_X1
X_15769_ _05990_ _05991_ _05940_ _05992_ VDD VSS MUX2_X1
X_15770_ _05822_ _08656_ _05980_ _05993_ VDD VSS OAI21_X1
X_15771_ _05821_ _05993_ _05994_ VDD VSS NAND2_X1
X_15772_ _08647_ _05994_ _05995_ VDD VSS XOR2_X2
X_15773_ net478 _05995_ _05996_ VDD VSS NAND2_X4
X_15774_ _05989_ _05992_ _05942_ _05552_ _05996_ _00458_ VDD
+ VSS OAI221_X1
X_15775_ net76 _05997_ VDD VSS INV_X1
X_15776_ net463 _05926_ _05936_ _05997_ _05998_ VDD VSS AOI22_X4
X_15777_ net97 _05998_ _05999_ VDD VSS NOR2_X4
X_15778_ net76 _05434_ _05423_ samples_real\[0\]\[15\] _06000_
+ VDD VSS AOI22_X1
X_15779_ _05999_ _06000_ net97 _06001_ VDD VSS AOI21_X2
X_15780_ _05358_ _05854_ _06002_ VDD VSS OR2_X2
X_15781_ _06001_ _06002_ _05860_ _00459_ VDD VSS MUX2_X1
X_15782_ samples_real\[0\]\[1\] _05933_ _06003_ VDD VSS NAND2_X1
X_15783_ _07359_ _05935_ _05937_ net77 _06004_ VDD VSS AOI22_X4
X_15784_ net77 _05967_ _06005_ VDD VSS NAND2_X1
X_15785_ _06004_ _06005_ _05940_ _06006_ VDD VSS MUX2_X1
X_15786_ _07362_ net478 _06007_ VDD VSS NAND2_X4
X_15787_ _06003_ _06006_ _05942_ _05552_ _06007_ _00460_ VDD
+ VSS OAI221_X1
X_15788_ _05952_ _07361_ _06008_ VDD VSS AND2_X1
X_15789_ _05948_ _05953_ _06008_ _06009_ VDD VSS NOR3_X4
X_15790_ _05942_ _06009_ _06010_ VDD VSS NAND2_X1
X_15791_ _05913_ _06011_ VDD VSS INV_X1
X_15792_ _06011_ _05935_ _05937_ net78 _06012_ VDD VSS AOI22_X4
X_15793_ net78 _05434_ _05423_ samples_real\[0\]\[2\] _06013_
+ VDD VSS AOI22_X1
X_15794_ _06012_ _06013_ net97 _06014_ VDD VSS MUX2_X1
X_15795_ _06010_ _06014_ _05942_ _00461_ VDD VSS OAI21_X2
X_15796_ _05933_ samples_real\[0\]\[3\] _06015_ VDD VSS NAND2_X4
X_15797_ _05918_ _05935_ net491 net79 _06016_ VDD VSS AOI22_X4
X_15798_ net79 _05967_ _06017_ VDD VSS NAND2_X1
X_15799_ _06016_ _06017_ _05930_ _06018_ VDD VSS MUX2_X1
X_15800_ net445 _05836_ _06019_ VDD VSS XNOR2_X2
X_15801_ net478 _06019_ _06020_ VDD VSS NAND2_X4
X_15802_ _06015_ _06018_ _05942_ _05440_ _06020_ _00462_ VDD
+ VSS OAI221_X2
X_15803_ net98 samples_real\[0\]\[4\] _06021_ VDD VSS NAND2_X4
X_15804_ _05917_ _05935_ _05937_ net80 _06022_ VDD VSS AOI22_X4
X_15805_ net80 _05967_ _06023_ VDD VSS NAND2_X1
X_15806_ _06022_ _06023_ net94 _06024_ VDD VSS MUX2_X1
X_15807_ _05916_ _05831_ _05954_ _06025_ VDD VSS AND3_X1
X_15808_ _05948_ _05955_ _06025_ _06026_ VDD VSS OR3_X1
X_15809_ _06026_ _06027_ VDD VSS CLKBUF_X3
X_15810_ _06021_ _06024_ net470 _05440_ _06027_ _00463_ VDD
+ VSS OAI221_X2
X_15811_ net98 samples_real\[0\]\[5\] _06028_ VDD VSS NAND2_X4
X_15812_ _05910_ net443 net58 net81 _06029_ VDD VSS AOI22_X4
X_15813_ net81 _05967_ _06030_ VDD VSS NAND2_X1
X_15814_ _06029_ _06030_ net94 _06031_ VDD VSS MUX2_X1
X_15815_ _05829_ _05830_ _05840_ _06032_ VDD VSS AND3_X1
X_15816_ _05841_ _05948_ _06032_ _06033_ VDD VSS OR3_X1
X_15817_ _06033_ _06034_ VDD VSS BUF_X4
X_15818_ _06028_ _06031_ net470 _05440_ _06034_ _00464_ VDD
+ VSS OAI221_X2
X_15819_ _05932_ samples_real\[0\]\[6\] _06035_ VDD VSS NAND2_X4
X_15820_ _05912_ net443 net58 net82 _06036_ VDD VSS AOI22_X4
X_15821_ net82 _05967_ _06037_ VDD VSS NAND2_X1
X_15822_ _06036_ _06037_ net94 _06038_ VDD VSS MUX2_X1
X_15823_ _05911_ _05951_ _05956_ _06039_ VDD VSS AND3_X1
X_15824_ _05948_ _05957_ _06039_ _06040_ VDD VSS OR3_X1
X_15825_ _06040_ _06041_ VDD VSS BUF_X4
X_15826_ _06035_ _06038_ _05860_ _05440_ _06041_ _00465_ VDD
+ VSS OAI221_X2
X_15827_ _05932_ samples_real\[0\]\[7\] _06042_ VDD VSS NAND2_X4
X_15828_ net462 net443 net58 net83 _06043_ VDD VSS AOI22_X4
X_15829_ net83 _05967_ _06044_ VDD VSS NAND2_X1
X_15830_ _06043_ _06044_ net94 _06045_ VDD VSS MUX2_X1
X_15831_ _05827_ _05828_ _05842_ _06046_ VDD VSS AND3_X1
X_15832_ _05843_ _05948_ _06046_ _06047_ VDD VSS OR3_X1
X_15833_ _06047_ _06048_ VDD VSS BUF_X4
X_15834_ _06042_ _06045_ _05860_ _05440_ _06048_ _00466_ VDD
+ VSS OAI221_X2
X_15835_ samples_real\[0\]\[8\] _05932_ _06049_ VDD VSS NAND2_X1
X_15836_ _05909_ net460 net58 net84 _06050_ VDD VSS AOI22_X4
X_15837_ net84 _05433_ _06051_ VDD VSS NAND2_X1
X_15838_ _06050_ _06051_ net461 _06052_ VDD VSS MUX2_X1
X_15839_ _05908_ _05950_ _05958_ _06053_ VDD VSS AND3_X1
X_15840_ _05948_ _05959_ _06053_ _06054_ VDD VSS OR3_X1
X_15841_ _06054_ _06055_ VDD VSS BUF_X4
X_15842_ _06049_ _06052_ net470 _05440_ _06055_ _00467_ VDD
+ VSS OAI221_X1
X_15843_ samples_real\[0\]\[9\] _05932_ _06056_ VDD VSS NAND2_X1
X_15844_ _05907_ _05926_ net58 net85 _06057_ VDD VSS AOI22_X4
X_15845_ net85 _05433_ _06058_ VDD VSS NAND2_X1
X_15846_ _06057_ _06058_ net461 _06059_ VDD VSS MUX2_X1
X_15847_ _05825_ _05826_ _05844_ _06060_ VDD VSS AND3_X1
X_15848_ _05845_ _05948_ _06060_ _06061_ VDD VSS OR3_X1
X_15849_ _06061_ _06062_ VDD VSS BUF_X4
X_15850_ _06056_ _06059_ net470 _05440_ _06062_ _00468_ VDD
+ VSS OAI221_X1
X_15851_ _05573_ _05576_ _05936_ _06063_ VDD VSS MUX2_X2
X_15852_ _04790_ _05297_ _05859_ _06064_ VDD VSS NAND3_X4
X_15853_ _06063_ _05571_ _06064_ _06065_ VDD VSS AND3_X4
X_15854_ _06065_ _06066_ VDD VSS BUF_X8
X_15855_ samples_real\[1\]\[0\] net482 _06067_ VDD VSS NAND2_X4
X_15856_ _06063_ _06068_ VDD VSS INV_X4
X_15857_ _06068_ _06064_ _06069_ VDD VSS NAND2_X4
X_15858_ _06069_ _06070_ VDD VSS BUF_X8
X_15859_ _05582_ _06071_ VDD VSS CLKBUF_X3
X_15860_ _06067_ _06070_ _05938_ _06071_ _05943_ _00469_ VDD
+ VSS OAI221_X2
X_15861_ samples_real\[1\]\[10\] _06066_ _06072_ VDD VSS NAND2_X4
X_15862_ _06072_ _06070_ _05945_ _06071_ _05964_ _00470_ VDD
+ VSS OAI221_X2
X_15863_ samples_real\[1\]\[11\] _06066_ _06073_ VDD VSS NAND2_X2
X_15864_ _06073_ _06070_ _05966_ _06071_ _05972_ _00471_ VDD
+ VSS OAI221_X1
X_15865_ _06066_ samples_real\[1\]\[12\] _06074_ VDD VSS NAND2_X4
X_15866_ _06074_ _06070_ _05974_ _06071_ _05982_ _00472_ VDD
+ VSS OAI221_X2
X_15867_ net482 samples_real\[1\]\[13\] _06075_ VDD VSS NAND2_X4
X_15868_ _06075_ _06070_ _05984_ _06071_ _05988_ _00473_ VDD
+ VSS OAI221_X2
X_15869_ samples_real\[1\]\[14\] net482 _06076_ VDD VSS NAND2_X4
X_15870_ _06076_ _06070_ _05990_ _06071_ _05996_ _00474_ VDD
+ VSS OAI221_X2
X_15871_ _05998_ _06068_ _06077_ VDD VSS NAND2_X4
X_15872_ _06063_ samples_real\[1\]\[15\] _05672_ _06078_ VDD
+ VSS NAND3_X2
X_15873_ _06077_ _06078_ _06079_ VDD VSS NAND2_X2
X_15874_ _06002_ _06079_ _06064_ _00475_ VDD VSS MUX2_X1
X_15875_ net482 samples_real\[1\]\[1\] _06080_ VDD VSS NAND2_X4
X_15876_ _06080_ _06070_ _06004_ _06071_ _06007_ _00476_ VDD
+ VSS OAI221_X2
X_15877_ _06063_ _00855_ samples_real\[1\]\[2\] _06081_ VDD
+ VSS NAND3_X2
X_15878_ _06081_ _06012_ _06063_ _06082_ VDD VSS OAI21_X2
X_15879_ _06009_ _06082_ _06064_ _00477_ VDD VSS MUX2_X1
X_15880_ net482 samples_real\[1\]\[3\] _06083_ VDD VSS NAND2_X4
X_15881_ _06083_ _06070_ _06016_ _06071_ _06020_ _00478_ VDD
+ VSS OAI221_X2
X_15882_ _06066_ samples_real\[1\]\[4\] _06084_ VDD VSS NAND2_X4
X_15883_ _06084_ _06070_ _06022_ _06071_ _06027_ _00479_ VDD
+ VSS OAI221_X2
X_15884_ _06066_ samples_real\[1\]\[5\] _06085_ VDD VSS NAND2_X4
X_15885_ _06085_ _06070_ _06029_ _06071_ _06034_ _00480_ VDD
+ VSS OAI221_X2
X_15886_ net486 samples_real\[1\]\[6\] _06086_ VDD VSS NAND2_X4
X_15887_ _06086_ _06069_ _06036_ _05583_ _06041_ _00481_ VDD
+ VSS OAI221_X2
X_15888_ _06065_ samples_real\[1\]\[7\] _06087_ VDD VSS NAND2_X2
X_15889_ _06087_ _06069_ _06043_ _05583_ _06048_ _00482_ VDD
+ VSS OAI221_X1
X_15890_ net486 samples_real\[1\]\[8\] _06088_ VDD VSS NAND2_X4
X_15891_ _06088_ _06069_ _06050_ _05583_ _06055_ _00483_ VDD
+ VSS OAI221_X2
X_15892_ net486 samples_real\[1\]\[9\] _06089_ VDD VSS NAND2_X4
X_15893_ _06089_ _06069_ _06057_ _05583_ _06062_ _00484_ VDD
+ VSS OAI221_X2
X_15894_ _05614_ _05615_ _05936_ _06090_ VDD VSS MUX2_X2
X_15895_ _05620_ _05859_ _06091_ VDD VSS NAND2_X2
X_15896_ _06090_ _05571_ _06091_ _06092_ VDD VSS AND3_X4
X_15897_ _06092_ _06093_ VDD VSS BUF_X8
X_15898_ samples_real\[2\]\[0\] net483 _06094_ VDD VSS NAND2_X4
X_15899_ _06090_ _06095_ VDD VSS INV_X4
X_15900_ _06095_ _06091_ _06096_ VDD VSS NAND2_X4
X_15901_ _06096_ _06097_ VDD VSS BUF_X4
X_15902_ _05626_ _06098_ VDD VSS BUF_X2
X_15903_ _06094_ _06097_ _05938_ _06098_ _05943_ _00485_ VDD
+ VSS OAI221_X2
X_15904_ samples_real\[2\]\[10\] net483 _06099_ VDD VSS NAND2_X4
X_15905_ _06099_ _06097_ _05945_ _06098_ _05964_ _00486_ VDD
+ VSS OAI221_X2
X_15906_ samples_real\[2\]\[11\] _06093_ _06100_ VDD VSS NAND2_X4
X_15907_ _06100_ _06097_ _05966_ _06098_ _05972_ _00487_ VDD
+ VSS OAI221_X2
X_15908_ samples_real\[2\]\[12\] _06093_ _06101_ VDD VSS NAND2_X2
X_15909_ _06101_ _06097_ _05974_ _06098_ _05982_ _00488_ VDD
+ VSS OAI221_X1
X_15910_ samples_real\[2\]\[13\] _06093_ _06102_ VDD VSS NAND2_X2
X_15911_ _06102_ _06097_ _05984_ _06098_ _05988_ _00489_ VDD
+ VSS OAI221_X1
X_15912_ samples_real\[2\]\[14\] _06093_ _06103_ VDD VSS NAND2_X4
X_15913_ _06103_ _06097_ _05990_ _06098_ _05996_ _00490_ VDD
+ VSS OAI221_X2
X_15914_ _05998_ _06095_ _06104_ VDD VSS NAND2_X2
X_15915_ _06090_ samples_real\[2\]\[15\] _05672_ _06105_ VDD
+ VSS NAND3_X2
X_15916_ _06104_ _06105_ _06106_ VDD VSS NAND2_X1
X_15917_ _06002_ _06106_ _06091_ _00491_ VDD VSS MUX2_X1
X_15918_ samples_real\[2\]\[1\] _06093_ _06107_ VDD VSS NAND2_X1
X_15919_ _06107_ _06097_ _06004_ _06098_ _06007_ _00492_ VDD
+ VSS OAI221_X1
X_15920_ _06090_ samples_real\[2\]\[2\] _00855_ _06108_ VDD
+ VSS NAND3_X2
X_15921_ _06108_ _06012_ _06090_ _06109_ VDD VSS OAI21_X2
X_15922_ _06009_ _06109_ _06091_ _00493_ VDD VSS MUX2_X1
X_15923_ samples_real\[2\]\[3\] net483 _06110_ VDD VSS NAND2_X2
X_15924_ _06110_ _06097_ _06016_ _06098_ _06020_ _00494_ VDD
+ VSS OAI221_X1
X_15925_ net483 samples_real\[2\]\[4\] _06111_ VDD VSS NAND2_X4
X_15926_ _06111_ _06097_ _06022_ _06098_ _06027_ _00495_ VDD
+ VSS OAI221_X2
X_15927_ samples_real\[2\]\[5\] net483 _06112_ VDD VSS NAND2_X4
X_15928_ _06112_ _06097_ _06029_ _06098_ _06034_ _00496_ VDD
+ VSS OAI221_X2
X_15929_ _06092_ samples_real\[2\]\[6\] _06113_ VDD VSS NAND2_X4
X_15930_ _06113_ _06096_ _06036_ _05627_ _06041_ _00497_ VDD
+ VSS OAI221_X2
X_15931_ net524 samples_real\[2\]\[7\] _06114_ VDD VSS NAND2_X4
X_15932_ _06114_ _06096_ _06043_ _05627_ _06048_ _00498_ VDD
+ VSS OAI221_X2
X_15933_ net524 samples_real\[2\]\[8\] _06115_ VDD VSS NAND2_X4
X_15934_ _06115_ _06096_ _06050_ _05627_ _06055_ _00499_ VDD
+ VSS OAI221_X2
X_15935_ _06092_ samples_real\[2\]\[9\] _06116_ VDD VSS NAND2_X2
X_15936_ _06116_ _06096_ _06057_ _05627_ _06062_ _00500_ VDD
+ VSS OAI221_X1
X_15937_ _05651_ _05653_ _05936_ _06117_ VDD VSS MUX2_X2
X_15938_ _05655_ _05859_ _06118_ VDD VSS NAND2_X2
X_15939_ _06118_ _05571_ _06117_ _06119_ VDD VSS AND3_X4
X_15940_ _06119_ _06120_ VDD VSS BUF_X16
X_15941_ samples_real\[3\]\[0\] net93 _06121_ VDD VSS NAND2_X4
X_15942_ _06117_ _06122_ VDD VSS INV_X4
X_15943_ _06122_ _06118_ _06123_ VDD VSS NAND2_X2
X_15944_ _06123_ _06124_ VDD VSS BUF_X8
X_15945_ _05661_ _06125_ VDD VSS CLKBUF_X3
X_15946_ _06121_ _06124_ _05938_ _06125_ _05943_ _00501_ VDD
+ VSS OAI221_X2
X_15947_ net93 samples_real\[3\]\[10\] _06126_ VDD VSS NAND2_X4
X_15948_ _06126_ _06124_ _05945_ _06125_ _05964_ _00502_ VDD
+ VSS OAI221_X2
X_15949_ net93 samples_real\[3\]\[11\] _06127_ VDD VSS NAND2_X4
X_15950_ _06127_ _06124_ _05966_ _06125_ _05972_ _00503_ VDD
+ VSS OAI221_X2
X_15951_ net93 samples_real\[3\]\[12\] _06128_ VDD VSS NAND2_X4
X_15952_ _06128_ _06124_ _05974_ _06125_ _05982_ _00504_ VDD
+ VSS OAI221_X2
X_15953_ samples_real\[3\]\[13\] net93 _06129_ VDD VSS NAND2_X4
X_15954_ _06129_ _06124_ _05984_ _06125_ _05988_ _00505_ VDD
+ VSS OAI221_X2
X_15955_ _06120_ samples_real\[3\]\[14\] _06130_ VDD VSS NAND2_X4
X_15956_ _06130_ _06124_ _05990_ _06125_ _05996_ _00506_ VDD
+ VSS OAI221_X2
X_15957_ _05998_ _06122_ _06131_ VDD VSS NAND2_X2
X_15958_ _06117_ samples_real\[3\]\[15\] _05672_ _06132_ VDD
+ VSS NAND3_X2
X_15959_ _06131_ _06132_ _06133_ VDD VSS NAND2_X1
X_15960_ _06002_ _06133_ _06118_ _00507_ VDD VSS MUX2_X1
X_15961_ _06120_ samples_real\[3\]\[1\] _06134_ VDD VSS NAND2_X4
X_15962_ _06134_ _06124_ _06004_ _06125_ _06007_ _00508_ VDD
+ VSS OAI221_X2
X_15963_ _06117_ samples_real\[3\]\[2\] _00855_ _06135_ VDD
+ VSS NAND3_X2
X_15964_ _06135_ _06012_ _06117_ _06136_ VDD VSS OAI21_X2
X_15965_ _06009_ _06136_ _06118_ _00509_ VDD VSS MUX2_X1
X_15966_ _06120_ samples_real\[3\]\[3\] _06137_ VDD VSS NAND2_X4
X_15967_ _06137_ _06124_ _06016_ _06125_ _06020_ _00510_ VDD
+ VSS OAI221_X2
X_15968_ samples_real\[3\]\[4\] _06120_ _06138_ VDD VSS NAND2_X4
X_15969_ _06138_ _06124_ _06022_ _06125_ _06027_ _00511_ VDD
+ VSS OAI221_X2
X_15970_ samples_real\[3\]\[5\] _06120_ _06139_ VDD VSS NAND2_X4
X_15971_ _06139_ _06124_ _06029_ _06125_ _06034_ _00512_ VDD
+ VSS OAI221_X2
X_15972_ _06119_ samples_real\[3\]\[6\] _06140_ VDD VSS NAND2_X4
X_15973_ _06140_ _06123_ _06036_ _05662_ _06041_ _00513_ VDD
+ VSS OAI221_X2
X_15974_ _06119_ samples_real\[3\]\[7\] _06141_ VDD VSS NAND2_X2
X_15975_ _06141_ _06123_ _06043_ _05662_ _06048_ _00514_ VDD
+ VSS OAI221_X1
X_15976_ _06119_ samples_real\[3\]\[8\] _06142_ VDD VSS NAND2_X4
X_15977_ _06142_ _06123_ _06050_ _05662_ _06055_ _00515_ VDD
+ VSS OAI221_X2
X_15978_ _06119_ samples_real\[3\]\[9\] _06143_ VDD VSS NAND2_X4
X_15979_ _06143_ _06123_ _06057_ _05662_ _06062_ _00516_ VDD
+ VSS OAI221_X2
X_15980_ _05687_ _05689_ net453 _06144_ VDD VSS MUX2_X2
X_15981_ _05693_ _05859_ _06145_ VDD VSS NAND2_X2
X_15982_ _06144_ _06145_ _05571_ _06146_ VDD VSS AND3_X4
X_15983_ _06146_ _06147_ VDD VSS BUF_X16
X_15984_ net101 samples_real\[4\]\[0\] _06148_ VDD VSS NAND2_X4
X_15985_ _06144_ _06149_ VDD VSS INV_X4
X_15986_ _06149_ _06145_ _06150_ VDD VSS NAND2_X4
X_15987_ _06150_ _06151_ VDD VSS BUF_X4
X_15988_ _05692_ _06152_ VDD VSS BUF_X2
X_15989_ _06148_ _06151_ _05938_ _06152_ _05943_ _00517_ VDD
+ VSS OAI221_X2
X_15990_ net101 samples_real\[4\]\[10\] _06153_ VDD VSS NAND2_X4
X_15991_ _06153_ _06151_ _05945_ _06152_ _05964_ _00518_ VDD
+ VSS OAI221_X2
X_15992_ samples_real\[4\]\[11\] _06147_ _06154_ VDD VSS NAND2_X4
X_15993_ _06154_ _06151_ _05966_ _06152_ _05972_ _00519_ VDD
+ VSS OAI221_X2
X_15994_ samples_real\[4\]\[12\] _06147_ _06155_ VDD VSS NAND2_X4
X_15995_ _06155_ _06151_ _05974_ _06152_ _05982_ _00520_ VDD
+ VSS OAI221_X2
X_15996_ samples_real\[4\]\[13\] net101 _06156_ VDD VSS NAND2_X2
X_15997_ _06156_ _06151_ _05984_ _06152_ _05988_ _00521_ VDD
+ VSS OAI221_X1
X_15998_ _06147_ samples_real\[4\]\[14\] _06157_ VDD VSS NAND2_X4
X_15999_ _06157_ _06151_ _05990_ _06152_ _05996_ _00522_ VDD
+ VSS OAI221_X2
X_16000_ _05998_ _06149_ _06158_ VDD VSS NAND2_X2
X_16001_ _05672_ samples_real\[4\]\[15\] _06144_ _06159_ VDD
+ VSS NAND3_X1
X_16002_ _06158_ _06159_ _06160_ VDD VSS NAND2_X1
X_16003_ _06002_ _06160_ _06145_ _00523_ VDD VSS MUX2_X1
X_16004_ _06147_ samples_real\[4\]\[1\] _06161_ VDD VSS NAND2_X4
X_16005_ _06161_ _06151_ _06004_ _06152_ _06007_ _00524_ VDD
+ VSS OAI221_X2
X_16006_ _06144_ samples_real\[4\]\[2\] _00855_ _06162_ VDD
+ VSS NAND3_X2
X_16007_ _06162_ _06012_ net517 _06163_ VDD VSS OAI21_X2
X_16008_ _06009_ _06163_ _06145_ _00525_ VDD VSS MUX2_X1
X_16009_ net101 samples_real\[4\]\[3\] _06164_ VDD VSS NAND2_X4
X_16010_ _06164_ _06151_ _06016_ _06152_ _06020_ _00526_ VDD
+ VSS OAI221_X2
X_16011_ net101 samples_real\[4\]\[4\] _06165_ VDD VSS NAND2_X4
X_16012_ _06165_ _06151_ _06022_ _06152_ _06027_ _00527_ VDD
+ VSS OAI221_X2
X_16013_ _06147_ samples_real\[4\]\[5\] _06166_ VDD VSS NAND2_X4
X_16014_ _06166_ _06151_ _06029_ _06152_ _06034_ _00528_ VDD
+ VSS OAI221_X2
X_16015_ _06146_ samples_real\[4\]\[6\] _06167_ VDD VSS NAND2_X2
X_16016_ _06167_ _06150_ _06036_ _05698_ _06041_ _00529_ VDD
+ VSS OAI221_X1
X_16017_ _06146_ samples_real\[4\]\[7\] _06168_ VDD VSS NAND2_X2
X_16018_ _06168_ _06150_ _06043_ _05698_ _06048_ _00530_ VDD
+ VSS OAI221_X1
X_16019_ _06146_ samples_real\[4\]\[8\] _06169_ VDD VSS NAND2_X2
X_16020_ _06169_ _06150_ _06050_ _05698_ _06055_ _00531_ VDD
+ VSS OAI221_X1
X_16021_ _06146_ samples_real\[4\]\[9\] _06170_ VDD VSS NAND2_X4
X_16022_ _06170_ _06150_ _06057_ _05698_ _06062_ _00532_ VDD
+ VSS OAI221_X2
X_16023_ _05721_ _05722_ net453 _06171_ VDD VSS MUX2_X2
X_16024_ _05725_ _05859_ _06172_ VDD VSS NAND2_X2
X_16025_ _00842_ _06172_ _06171_ _06173_ VDD VSS AND3_X4
X_16026_ _06173_ _06174_ VDD VSS BUF_X16
X_16027_ net104 samples_real\[5\]\[0\] _06175_ VDD VSS NAND2_X4
X_16028_ _06171_ _06176_ VDD VSS INV_X4
X_16029_ _06176_ _06172_ _06177_ VDD VSS NAND2_X4
X_16030_ _06177_ _06178_ VDD VSS BUF_X8
X_16031_ _05731_ _06179_ VDD VSS CLKBUF_X3
X_16032_ _06175_ _06178_ _05938_ _06179_ _05943_ _00533_ VDD
+ VSS OAI221_X2
X_16033_ net104 samples_real\[5\]\[10\] _06180_ VDD VSS NAND2_X4
X_16034_ _06180_ _06178_ _05945_ _06179_ _05964_ _00534_ VDD
+ VSS OAI221_X2
X_16035_ samples_real\[5\]\[11\] _06174_ _06181_ VDD VSS NAND2_X4
X_16036_ _06181_ _06178_ _05966_ _06179_ _05972_ _00535_ VDD
+ VSS OAI221_X2
X_16037_ samples_real\[5\]\[12\] _06174_ _06182_ VDD VSS NAND2_X4
X_16038_ _06182_ _06178_ _05974_ _06179_ _05982_ _00536_ VDD
+ VSS OAI221_X2
X_16039_ net104 samples_real\[5\]\[13\] _06183_ VDD VSS NAND2_X4
X_16040_ _06183_ _06178_ _05984_ _06179_ _05988_ _00537_ VDD
+ VSS OAI221_X2
X_16041_ samples_real\[5\]\[14\] _06174_ _06184_ VDD VSS NAND2_X4
X_16042_ _06184_ _06178_ _05990_ _06179_ _05996_ _00538_ VDD
+ VSS OAI221_X2
X_16043_ _05998_ _06176_ _06185_ VDD VSS NAND2_X2
X_16044_ _05672_ samples_real\[5\]\[15\] _06171_ _06186_ VDD
+ VSS NAND3_X1
X_16045_ _06185_ _06186_ _06187_ VDD VSS NAND2_X1
X_16046_ _06002_ _06187_ _06172_ _00539_ VDD VSS MUX2_X1
X_16047_ _06174_ samples_real\[5\]\[1\] _06188_ VDD VSS NAND2_X4
X_16048_ _06188_ _06178_ _06004_ _06179_ _06007_ _00540_ VDD
+ VSS OAI221_X2
X_16049_ _00855_ samples_real\[5\]\[2\] net487 _06189_ VDD
+ VSS NAND3_X4
X_16050_ _06189_ _06012_ net518 _06190_ VDD VSS OAI21_X2
X_16051_ _06009_ _06190_ _06172_ _00541_ VDD VSS MUX2_X1
X_16052_ net104 samples_real\[5\]\[3\] _06191_ VDD VSS NAND2_X4
X_16053_ _06191_ _06178_ _06016_ _06179_ _06020_ _00542_ VDD
+ VSS OAI221_X2
X_16054_ net104 samples_real\[5\]\[4\] _06192_ VDD VSS NAND2_X4
X_16055_ _06192_ _06178_ _06022_ _06179_ _06027_ _00543_ VDD
+ VSS OAI221_X2
X_16056_ _06174_ samples_real\[5\]\[5\] _06193_ VDD VSS NAND2_X4
X_16057_ _06193_ _06178_ _06029_ _06179_ _06034_ _00544_ VDD
+ VSS OAI221_X2
X_16058_ _06173_ samples_real\[5\]\[6\] _06194_ VDD VSS NAND2_X2
X_16059_ _06194_ _06177_ _06036_ _05732_ _06041_ _00545_ VDD
+ VSS OAI221_X1
X_16060_ _06173_ samples_real\[5\]\[7\] _06195_ VDD VSS NAND2_X2
X_16061_ _06195_ _06177_ _06043_ _05732_ _06048_ _00546_ VDD
+ VSS OAI221_X1
X_16062_ _06173_ samples_real\[5\]\[8\] _06196_ VDD VSS NAND2_X2
X_16063_ _06196_ _06177_ _06050_ _05732_ _06055_ _00547_ VDD
+ VSS OAI221_X1
X_16064_ _06173_ samples_real\[5\]\[9\] _06197_ VDD VSS NAND2_X2
X_16065_ _06197_ _06177_ _06057_ _05732_ _06062_ _00548_ VDD
+ VSS OAI221_X1
X_16066_ _05756_ _05757_ net453 _06198_ VDD VSS MUX2_X2
X_16067_ _05759_ _05859_ _06199_ VDD VSS NAND2_X2
X_16068_ _00842_ _06199_ _06198_ _06200_ VDD VSS AND3_X4
X_16069_ _06200_ _06201_ VDD VSS BUF_X8
X_16070_ net107 samples_real\[6\]\[0\] _06202_ VDD VSS NAND2_X4
X_16071_ _06198_ _06203_ VDD VSS INV_X4
X_16072_ _06203_ _06199_ _06204_ VDD VSS NAND2_X4
X_16073_ _06204_ _06205_ VDD VSS BUF_X8
X_16074_ _05764_ _06206_ VDD VSS CLKBUF_X3
X_16075_ _06202_ _06205_ _05938_ _06206_ _05943_ _00549_ VDD
+ VSS OAI221_X2
X_16076_ net107 samples_real\[6\]\[10\] _06207_ VDD VSS NAND2_X4
X_16077_ _06207_ _06205_ _05945_ _06206_ _05964_ _00550_ VDD
+ VSS OAI221_X2
X_16078_ _06201_ samples_real\[6\]\[11\] _06208_ VDD VSS NAND2_X4
X_16079_ _06208_ _06205_ _05966_ _06206_ _05972_ _00551_ VDD
+ VSS OAI221_X2
X_16080_ _06201_ samples_real\[6\]\[12\] _06209_ VDD VSS NAND2_X4
X_16081_ _06209_ _06205_ _05974_ _06206_ _05982_ _00552_ VDD
+ VSS OAI221_X2
X_16082_ net107 samples_real\[6\]\[13\] _06210_ VDD VSS NAND2_X4
X_16083_ _06210_ _06205_ _05984_ _06206_ _05988_ _00553_ VDD
+ VSS OAI221_X2
X_16084_ _06201_ samples_real\[6\]\[14\] _06211_ VDD VSS NAND2_X4
X_16085_ _06211_ _06205_ _05990_ _06206_ _05996_ _00554_ VDD
+ VSS OAI221_X2
X_16086_ _05998_ _06203_ _06212_ VDD VSS NAND2_X2
X_16087_ _05596_ samples_real\[6\]\[15\] _06198_ _06213_ VDD
+ VSS NAND3_X1
X_16088_ _06212_ _06213_ _06214_ VDD VSS NAND2_X1
X_16089_ _06002_ _06214_ _06199_ _00555_ VDD VSS MUX2_X1
X_16090_ _06201_ samples_real\[6\]\[1\] _06215_ VDD VSS NAND2_X4
X_16091_ _06215_ _06205_ _06004_ _06206_ _06007_ _00556_ VDD
+ VSS OAI221_X2
X_16092_ _00855_ samples_real\[6\]\[2\] _06198_ _06216_ VDD
+ VSS NAND3_X1
X_16093_ _06216_ _06012_ net514 _06217_ VDD VSS OAI21_X2
X_16094_ _06009_ _06217_ _06199_ _00557_ VDD VSS MUX2_X1
X_16095_ net107 samples_real\[6\]\[3\] _06218_ VDD VSS NAND2_X4
X_16096_ _06218_ _06205_ _06016_ _06206_ _06020_ _00558_ VDD
+ VSS OAI221_X2
X_16097_ net107 samples_real\[6\]\[4\] _06219_ VDD VSS NAND2_X4
X_16098_ _06219_ _06205_ _06022_ _06206_ _06027_ _00559_ VDD
+ VSS OAI221_X2
X_16099_ _06201_ samples_real\[6\]\[5\] _06220_ VDD VSS NAND2_X4
X_16100_ _06220_ _06205_ _06029_ _06206_ _06034_ _00560_ VDD
+ VSS OAI221_X1
X_16101_ _06200_ samples_real\[6\]\[6\] _06221_ VDD VSS NAND2_X4
X_16102_ _06221_ _06204_ _06036_ _05765_ _06041_ _00561_ VDD
+ VSS OAI221_X2
X_16103_ _06200_ samples_real\[6\]\[7\] _06222_ VDD VSS NAND2_X4
X_16104_ _06222_ _06204_ _06043_ _05765_ _06048_ _00562_ VDD
+ VSS OAI221_X2
X_16105_ _06200_ samples_real\[6\]\[8\] _06223_ VDD VSS NAND2_X2
X_16106_ _06223_ _06204_ _06050_ _05765_ _06055_ _00563_ VDD
+ VSS OAI221_X1
X_16107_ _06200_ samples_real\[6\]\[9\] _06224_ VDD VSS NAND2_X2
X_16108_ _06224_ _06204_ _06057_ _05765_ _06062_ _00564_ VDD
+ VSS OAI221_X1
X_16109_ _05787_ _05788_ net453 _06225_ VDD VSS MUX2_X2
X_16110_ _04794_ _04791_ _04790_ _05859_ _06226_ VDD VSS NAND4_X4
X_16111_ _00842_ _06226_ _06225_ _06227_ VDD VSS AND3_X4
X_16112_ _06227_ _06228_ VDD VSS BUF_X16
X_16113_ _06228_ samples_real\[7\]\[0\] _06229_ VDD VSS NAND2_X4
X_16114_ _06225_ _06230_ VDD VSS INV_X4
X_16115_ _06230_ _06226_ _06231_ VDD VSS NAND2_X4
X_16116_ _06231_ _06232_ VDD VSS BUF_X8
X_16117_ _05794_ _06233_ VDD VSS CLKBUF_X3
X_16118_ _06229_ _06232_ _05938_ _06233_ _05943_ _00565_ VDD
+ VSS OAI221_X2
X_16119_ _06228_ samples_real\[7\]\[10\] _06234_ VDD VSS NAND2_X4
X_16120_ _06234_ _06232_ _05945_ _06233_ _05964_ _00566_ VDD
+ VSS OAI221_X2
X_16121_ _06228_ samples_real\[7\]\[11\] _06235_ VDD VSS NAND2_X4
X_16122_ _06235_ _06232_ _05966_ _06233_ _05972_ _00567_ VDD
+ VSS OAI221_X2
X_16123_ net516 samples_real\[7\]\[12\] _06236_ VDD VSS NAND2_X4
X_16124_ _06236_ _06232_ _05974_ _06233_ _05982_ _00568_ VDD
+ VSS OAI221_X2
X_16125_ _06228_ samples_real\[7\]\[13\] _06237_ VDD VSS NAND2_X4
X_16126_ _06237_ _06232_ _05984_ _06233_ _05988_ _00569_ VDD
+ VSS OAI221_X2
X_16127_ net516 samples_real\[7\]\[14\] _06238_ VDD VSS NAND2_X4
X_16128_ _06238_ _06232_ _05990_ _06233_ _05996_ _00570_ VDD
+ VSS OAI221_X2
X_16129_ _05998_ _06230_ _06239_ VDD VSS NAND2_X2
X_16130_ _05596_ samples_real\[7\]\[15\] _06225_ _06240_ VDD
+ VSS NAND3_X1
X_16131_ _06239_ _06240_ _06241_ VDD VSS NAND2_X1
X_16132_ _06002_ _06241_ _06226_ _00571_ VDD VSS MUX2_X1
X_16133_ net516 samples_real\[7\]\[1\] _06242_ VDD VSS NAND2_X4
X_16134_ _06242_ _06232_ _06004_ _06233_ _06007_ _00572_ VDD
+ VSS OAI221_X2
X_16135_ _00855_ _06225_ samples_real\[7\]\[2\] _06243_ VDD
+ VSS NAND3_X2
X_16136_ _06243_ _06012_ net515 _06244_ VDD VSS OAI21_X2
X_16137_ _06009_ _06244_ _06226_ _00573_ VDD VSS MUX2_X1
X_16138_ samples_real\[7\]\[3\] net516 _06245_ VDD VSS NAND2_X4
X_16139_ _06245_ _06232_ _06016_ _06233_ _06020_ _00574_ VDD
+ VSS OAI221_X1
X_16140_ net516 samples_real\[7\]\[4\] _06246_ VDD VSS NAND2_X4
X_16141_ _06246_ _06232_ _06022_ _06233_ _06027_ _00575_ VDD
+ VSS OAI221_X2
X_16142_ samples_real\[7\]\[5\] _06228_ _06247_ VDD VSS NAND2_X4
X_16143_ _06247_ _06232_ _06029_ _06233_ _06034_ _00576_ VDD
+ VSS OAI221_X2
X_16144_ _06227_ samples_real\[7\]\[6\] _06248_ VDD VSS NAND2_X4
X_16145_ _06248_ _06231_ _06036_ _05795_ _06041_ _00577_ VDD
+ VSS OAI221_X2
X_16146_ _06227_ samples_real\[7\]\[7\] _06249_ VDD VSS NAND2_X2
X_16147_ _06249_ _06231_ _06043_ _05795_ _06048_ _00578_ VDD
+ VSS OAI221_X1
X_16148_ _06227_ samples_real\[7\]\[8\] _06250_ VDD VSS NAND2_X2
X_16149_ _06250_ _06231_ _06050_ _05795_ _06055_ _00579_ VDD
+ VSS OAI221_X1
X_16150_ _06227_ samples_real\[7\]\[9\] _06251_ VDD VSS NAND2_X2
X_16151_ _06251_ _06231_ _06057_ _05795_ _06062_ _00580_ VDD
+ VSS OAI221_X1
X_16152_ _04839_ _04925_ _06252_ VDD VSS XNOR2_X1
X_16153_ _04990_ _06252_ _06253_ VDD VSS XNOR2_X1
X_16154_ _04823_ _06253_ _06254_ VDD VSS NOR2_X1
X_16155_ _04894_ _04944_ _06255_ VDD VSS XNOR2_X1
X_16156_ _04882_ _06255_ _06256_ VDD VSS XNOR2_X1
X_16157_ _04808_ _06256_ _06257_ VDD VSS NOR2_X1
X_16158_ _06254_ _06257_ _06258_ VDD VSS XNOR2_X1
X_16159_ samples_imag\[0\]\[15\] samples_imag\[2\]\[15\] _04875_
+ _06259_ VDD VSS MUX2_X1
X_16160_ samples_imag\[1\]\[15\] samples_imag\[3\]\[15\] _04875_
+ _06260_ VDD VSS MUX2_X1
X_16161_ _06259_ _06260_ _04867_ _06261_ VDD VSS MUX2_X1
X_16162_ samples_imag\[4\]\[15\] samples_imag\[6\]\[15\] _04875_
+ _06262_ VDD VSS MUX2_X1
X_16163_ samples_imag\[5\]\[15\] samples_imag\[7\]\[15\] _04875_
+ _06263_ VDD VSS MUX2_X1
X_16164_ _06262_ _06263_ _04867_ _06264_ VDD VSS MUX2_X1
X_16165_ _06261_ _06264_ _04893_ _06265_ VDD VSS MUX2_X1
X_16166_ _00022_ _06265_ _06266_ VDD VSS NAND2_X1
X_16167_ _07702_ _06266_ _06267_ VDD VSS XOR2_X1
X_16168_ _04981_ _05117_ _06268_ VDD VSS NAND2_X1
X_16169_ _04865_ _05001_ _06269_ VDD VSS OR2_X1
X_16170_ _06268_ _06269_ _06270_ VDD VSS XNOR2_X1
X_16171_ _06267_ _06270_ _06271_ VDD VSS XNOR2_X1
X_16172_ _07401_ _07559_ _06272_ VDD VSS XNOR2_X1
X_16173_ _07377_ _07410_ _06273_ VDD VSS XNOR2_X2
X_16174_ _06272_ _06273_ _06274_ VDD VSS XNOR2_X2
X_16175_ _06271_ _06274_ _06275_ VDD VSS XNOR2_X2
X_16176_ _06258_ _06275_ _06276_ VDD VSS XNOR2_X2
X_16177_ _09471_ _09511_ _09540_ _09558_ _06277_ VDD VSS NAND4_X1
X_16178_ _09528_ _09565_ _09485_ _09499_ _06278_ VDD VSS NAND4_X1
X_16179_ _06277_ _06278_ _06279_ VDD VSS NOR2_X1
X_16180_ _09571_ _06280_ VDD VSS INV_X1
X_16181_ _07911_ _06281_ VDD VSS INV_X1
X_16182_ _06281_ _09572_ _09574_ _09576_ _06282_ VDD VSS NAND4_X1
X_16183_ _09582_ _07653_ _09583_ _06283_ VDD VSS AOI21_X1
X_16184_ _06280_ _06282_ _06283_ _06284_ VDD VSS OAI21_X2
X_16185_ _09484_ _06285_ VDD VSS INV_X1
X_16186_ _09510_ _06286_ VDD VSS INV_X1
X_16187_ _09511_ _06287_ VDD VSS INV_X1
X_16188_ _09539_ _06288_ VDD VSS INV_X1
X_16189_ _09557_ _09558_ _09564_ _06289_ VDD VSS AOI21_X1
X_16190_ _09540_ _06290_ VDD VSS INV_X1
X_16191_ _06288_ _06289_ _06290_ _06291_ VDD VSS OAI21_X1
X_16192_ _09527_ _06291_ _09528_ _06292_ VDD VSS AOI21_X1
X_16193_ _06286_ _06287_ _06292_ _06293_ VDD VSS OAI21_X1
X_16194_ _09498_ _06293_ _09499_ _06294_ VDD VSS AOI21_X1
X_16195_ _09485_ _06295_ VDD VSS INV_X1
X_16196_ _06285_ _06294_ _06295_ _06296_ VDD VSS OAI21_X1
X_16197_ _09470_ _06279_ _06284_ _06296_ _09471_ _06297_ VDD
+ VSS AOI221_X2
X_16198_ _04992_ _05010_ _06298_ VDD VSS NOR2_X1
X_16199_ _00034_ _06299_ VDD VSS INV_X1
X_16200_ _06299_ _04822_ _06300_ VDD VSS NAND2_X1
X_16201_ _06298_ _06300_ _06301_ VDD VSS XOR2_X2
X_16202_ _00046_ _05055_ _06302_ VDD VSS NAND2_X1
X_16203_ _09411_ _07479_ _06303_ VDD VSS XOR2_X1
X_16204_ _09409_ _09399_ _06304_ VDD VSS XNOR2_X1
X_16205_ _06303_ _06304_ _06305_ VDD VSS XNOR2_X1
X_16206_ _07429_ _07488_ _06306_ VDD VSS XNOR2_X1
X_16207_ _07402_ _09396_ _06307_ VDD VSS XNOR2_X1
X_16208_ _06306_ _06307_ _06308_ VDD VSS XNOR2_X1
X_16209_ _06305_ _06308_ _06309_ VDD VSS XNOR2_X1
X_16210_ _07395_ _07375_ _06310_ VDD VSS XOR2_X1
X_16211_ _07469_ _07536_ _06311_ VDD VSS XNOR2_X1
X_16212_ _06310_ _06311_ _06312_ VDD VSS XNOR2_X1
X_16213_ _07420_ _07433_ _06313_ VDD VSS XNOR2_X1
X_16214_ _07384_ _07407_ _06314_ VDD VSS XNOR2_X1
X_16215_ _06313_ _06314_ _06315_ VDD VSS XNOR2_X1
X_16216_ _06312_ _06315_ _06316_ VDD VSS XNOR2_X1
X_16217_ _06309_ _06316_ _06317_ VDD VSS XNOR2_X1
X_16218_ _07437_ _09392_ _06318_ VDD VSS XOR2_X1
X_16219_ _07399_ _07389_ _06319_ VDD VSS XNOR2_X1
X_16220_ _06318_ _06319_ _06320_ VDD VSS XNOR2_X1
X_16221_ _07460_ _09408_ _06321_ VDD VSS XNOR2_X1
X_16222_ _09386_ _09389_ _06322_ VDD VSS XNOR2_X1
X_16223_ _06321_ _06322_ _06323_ VDD VSS XNOR2_X1
X_16224_ _06320_ _06323_ _06324_ VDD VSS XNOR2_X1
X_16225_ _07629_ _07586_ _06325_ VDD VSS XNOR2_X2
X_16226_ _07474_ _07483_ _06326_ VDD VSS XNOR2_X1
X_16227_ _06326_ _06325_ _06327_ VDD VSS XNOR2_X1
X_16228_ _06327_ _06324_ _06328_ VDD VSS XNOR2_X1
X_16229_ _06328_ _06317_ _06329_ VDD VSS XNOR2_X1
X_16230_ _00045_ _00046_ _06330_ VDD VSS XOR2_X2
X_16231_ _07527_ _09446_ _06331_ VDD VSS XNOR2_X1
X_16232_ _07539_ _09417_ _06332_ VDD VSS XNOR2_X1
X_16233_ _06331_ _06332_ _06333_ VDD VSS XNOR2_X1
X_16234_ _06330_ _06333_ _06334_ VDD VSS XNOR2_X1
X_16235_ _06334_ _06329_ _06335_ VDD VSS XNOR2_X1
X_16236_ _06335_ _06302_ _06336_ VDD VSS XNOR2_X1
X_16237_ _06336_ _06301_ _06337_ VDD VSS XNOR2_X1
X_16238_ _06337_ _06297_ _06338_ VDD VSS XNOR2_X1
X_16239_ _06338_ _06276_ _06339_ VDD VSS XNOR2_X2
X_16240_ temp_imag\[0\] _06339_ _04778_ _00584_ VDD VSS MUX2_X1
X_16241_ _07984_ _07986_ _06340_ VDD VSS XNOR2_X1
X_16242_ _08332_ _08256_ _06341_ VDD VSS XNOR2_X1
X_16243_ _06340_ _06341_ _06342_ VDD VSS XNOR2_X1
X_16244_ _08135_ _07985_ _06343_ VDD VSS XNOR2_X1
X_16245_ _08105_ _08004_ _06344_ VDD VSS XNOR2_X1
X_16246_ _06343_ _06344_ _06345_ VDD VSS XNOR2_X1
X_16247_ _06342_ _06345_ _06346_ VDD VSS XNOR2_X1
X_16248_ samples_real\[0\]\[15\] samples_real\[2\]\[15\] net52
+ _06347_ VDD VSS MUX2_X1
X_16249_ samples_real\[1\]\[15\] samples_real\[3\]\[15\] net52
+ _06348_ VDD VSS MUX2_X1
X_16250_ _06347_ _06348_ _04851_ _06349_ VDD VSS MUX2_X1
X_16251_ samples_real\[4\]\[15\] samples_real\[6\]\[15\] net52
+ _06350_ VDD VSS MUX2_X1
X_16252_ samples_real\[5\]\[15\] samples_real\[7\]\[15\] net52
+ _06351_ VDD VSS MUX2_X1
X_16253_ _06350_ _06351_ _04830_ _06352_ VDD VSS MUX2_X1
X_16254_ _06349_ _06352_ _04847_ _06353_ VDD VSS MUX2_X1
X_16255_ _00022_ _06353_ _06354_ VDD VSS NAND2_X1
X_16256_ _08019_ _06354_ _06355_ VDD VSS XOR2_X1
X_16257_ _05125_ _05117_ _06356_ VDD VSS NAND2_X1
X_16258_ _00021_ _06357_ VDD VSS INV_X1
X_16259_ _06357_ _05010_ _06358_ VDD VSS OR2_X1
X_16260_ _06356_ _06358_ _06359_ VDD VSS XNOR2_X1
X_16261_ _06355_ _06359_ _06360_ VDD VSS XNOR2_X1
X_16262_ _00046_ _04822_ _06361_ VDD VSS NAND2_X1
X_16263_ _06299_ _05055_ _06362_ VDD VSS NAND2_X1
X_16264_ _06361_ _06362_ _06363_ VDD VSS XOR2_X1
X_16265_ _00024_ _05121_ _06364_ VDD VSS NAND2_X1
X_16266_ _07994_ _06364_ _06365_ VDD VSS XNOR2_X1
X_16267_ _06363_ _06365_ _06366_ VDD VSS XNOR2_X1
X_16268_ _06360_ _06366_ _06367_ VDD VSS XNOR2_X1
X_16269_ _06346_ _06367_ _06368_ VDD VSS XNOR2_X1
X_16270_ _08214_ _09597_ _06369_ VDD VSS XNOR2_X2
X_16271_ _07974_ _08152_ _06370_ VDD VSS XNOR2_X1
X_16272_ _06369_ _06370_ _06371_ VDD VSS XNOR2_X2
X_16273_ _08026_ _08088_ _06372_ VDD VSS XNOR2_X1
X_16274_ _07992_ _08015_ _06373_ VDD VSS XNOR2_X1
X_16275_ _06372_ _06373_ _06374_ VDD VSS XNOR2_X1
X_16276_ _06371_ _06374_ _06375_ VDD VSS XNOR2_X2
X_16277_ _07942_ _07960_ _06376_ VDD VSS XOR2_X1
X_16278_ _08092_ _09615_ _06377_ VDD VSS XNOR2_X1
X_16279_ _06376_ _06377_ _06378_ VDD VSS XNOR2_X1
X_16280_ _08063_ _07934_ _06379_ VDD VSS XNOR2_X1
X_16281_ _06330_ _06379_ _06380_ VDD VSS XNOR2_X1
X_16282_ _06378_ _06380_ _06381_ VDD VSS XNOR2_X1
X_16283_ _06375_ _06381_ _06382_ VDD VSS XNOR2_X2
X_16284_ _06382_ _07953_ _06383_ VDD VSS XNOR2_X2
X_16285_ _04839_ _05046_ _06384_ VDD VSS XNOR2_X1
X_16286_ _04895_ _06384_ _06385_ VDD VSS NOR2_X1
X_16287_ _06385_ _06383_ _06386_ VDD VSS XNOR2_X1
X_16288_ _08002_ _07997_ _06387_ VDD VSS XNOR2_X1
X_16289_ _07946_ _09594_ _06388_ VDD VSS XNOR2_X1
X_16290_ _06387_ _06388_ _06389_ VDD VSS XNOR2_X1
X_16291_ _09591_ _08029_ _06390_ VDD VSS XNOR2_X1
X_16292_ _07937_ _08069_ _06391_ VDD VSS XNOR2_X1
X_16293_ _06390_ _06391_ _06392_ VDD VSS XNOR2_X1
X_16294_ _06389_ _06392_ _06393_ VDD VSS XNOR2_X1
X_16295_ _07979_ _07982_ _06394_ VDD VSS XOR2_X2
X_16296_ _09584_ _07917_ _06395_ VDD VSS XNOR2_X1
X_16297_ _06394_ _06395_ _06396_ VDD VSS XNOR2_X1
X_16298_ _07918_ _07926_ _06397_ VDD VSS XNOR2_X1
X_16299_ _07922_ _09587_ _06398_ VDD VSS XNOR2_X1
X_16300_ _06397_ _06398_ _06399_ VDD VSS XNOR2_X1
X_16301_ _06396_ _06399_ _06400_ VDD VSS XNOR2_X1
X_16302_ _06393_ _06400_ _06401_ VDD VSS XNOR2_X1
X_16303_ _08126_ _08127_ _06402_ VDD VSS XNOR2_X1
X_16304_ _06401_ _06402_ _06403_ VDD VSS XNOR2_X1
X_16305_ _06386_ _06403_ _06404_ VDD VSS XNOR2_X1
X_16306_ _06404_ _06368_ _06405_ VDD VSS XNOR2_X1
X_16307_ _09647_ _06406_ VDD VSS INV_X1
X_16308_ _09662_ _06407_ VDD VSS INV_X1
X_16309_ _09689_ _06408_ VDD VSS INV_X1
X_16310_ _09702_ _06409_ VDD VSS INV_X1
X_16311_ _09718_ _06410_ VDD VSS INV_X1
X_16312_ _08547_ _09747_ _09745_ _09750_ _06411_ VDD VSS NAND4_X1
X_16313_ _06411_ _08424_ _08552_ _06412_ VDD VSS NOR3_X1
X_16314_ _09736_ _09744_ _06412_ _06413_ VDD VSS OAI21_X1
X_16315_ _06413_ _06414_ VDD VSS INV_X1
X_16316_ _09729_ _09735_ _06414_ _06415_ VDD VSS OAI21_X1
X_16317_ _09728_ _06416_ VDD VSS INV_X1
X_16318_ _06410_ _06415_ _06416_ _06417_ VDD VSS AOI21_X1
X_16319_ _09703_ _09717_ _06417_ _06418_ VDD VSS OAI21_X1
X_16320_ _06408_ _06409_ _06418_ _06419_ VDD VSS AOI21_X1
X_16321_ _09673_ _09688_ _06419_ _06420_ VDD VSS OAI21_X1
X_16322_ _09672_ _06421_ VDD VSS INV_X1
X_16323_ _06407_ _06420_ _06421_ _06422_ VDD VSS AOI21_X1
X_16324_ _09648_ _09661_ _06422_ _06423_ VDD VSS OAI21_X1
X_16325_ _06406_ _06423_ _06424_ VDD VSS NAND2_X1
X_16326_ _09631_ _06424_ _09632_ _06425_ VDD VSS AOI21_X2
X_16327_ _06405_ _06425_ _06426_ VDD VSS XNOR2_X2
X_16328_ temp_real\[0\] _06426_ _04778_ _00585_ VDD VSS MUX2_X1
X_16329_ _00006_ _00019_ _00048_ VDD VSS NOR2_X1
X_16330_ _00048_ _00047_ VDD VSS INV_X1
X_16331_ _00006_ _06427_ VDD VSS INV_X1
X_16332_ _06427_ _00019_ _00049_ VDD VSS NAND2_X1
X_16333_ _06427_ _00008_ _00050_ VDD VSS NOR2_X1
X_16334_ net86 _00853_ _06428_ VDD VSS NAND2_X1
X_16335_ sample_count\[2\] bit_rev_idx\[0\] _06428_ _06429_
+ VDD VSS MUX2_X1
X_16336_ _00856_ _06429_ _00051_ VDD VSS AND2_X1
X_16337_ sample_count\[1\] bit_rev_idx\[1\] _06428_ _06430_
+ VDD VSS MUX2_X1
X_16338_ _00856_ _06430_ _00052_ VDD VSS AND2_X1
X_16339_ sample_count\[0\] bit_rev_idx\[2\] _06428_ _06431_
+ VDD VSS MUX2_X1
X_16340_ _00856_ _06431_ _00053_ VDD VSS AND2_X1
X_16341_ _04769_ _00858_ _00860_ _06432_ VDD VSS OAI21_X1
X_16342_ net88 _00041_ _06432_ _06433_ VDD VSS MUX2_X1
X_16343_ _00856_ _06433_ _00054_ VDD VSS AND2_X1
X_16344_ _05264_ _04776_ _06434_ VDD VSS NAND2_X1
X_16345_ _00031_ _00851_ _06435_ VDD VSS NOR2_X1
X_16346_ _04771_ _09382_ _00020_ _06436_ VDD VSS NOR3_X2
X_16347_ _04771_ _00853_ _06437_ VDD VSS NAND2_X1
X_16348_ _00031_ _06438_ VDD VSS INV_X1
X_16349_ _06437_ _06438_ _00853_ _06439_ VDD VSS OAI21_X2
X_16350_ _06435_ _06436_ _06439_ _06440_ VDD VSS NOR3_X4
X_16351_ _05264_ _06434_ _06440_ _06441_ VDD VSS MUX2_X1
X_16352_ _00845_ _06441_ _00055_ VDD VSS NOR2_X1
X_16353_ _09358_ _04776_ _06440_ _06442_ VDD VSS NAND3_X1
X_16354_ butterfly_count\[1\] _06443_ VDD VSS INV_X1
X_16355_ _06442_ _06440_ _06443_ _06444_ VDD VSS OAI21_X1
X_16356_ _00856_ _06444_ _00056_ VDD VSS AND2_X1
X_16357_ _09359_ _04776_ _06445_ VDD VSS NAND2_X1
X_16358_ _01169_ _06445_ _06440_ _06446_ VDD VSS MUX2_X1
X_16359_ _00845_ _06446_ _00057_ VDD VSS NOR2_X1
X_16360_ _00857_ _06447_ VDD VSS BUF_X4
X_16361_ _06447_ _06448_ VDD VSS CLKBUF_X3
X_16362_ _06448_ samples_imag\[0\]\[0\] _06449_ VDD VSS NAND2_X1
X_16363_ _00859_ net89 _06450_ VDD VSS NAND2_X1
X_16364_ _00845_ _06449_ _06450_ _00061_ VDD VSS AOI21_X1
X_16365_ _06448_ samples_imag\[6\]\[4\] _06451_ VDD VSS NAND2_X1
X_16366_ _00859_ net90 _06452_ VDD VSS NAND2_X1
X_16367_ _00845_ _06451_ _06452_ _00062_ VDD VSS AOI21_X1
X_16368_ _06448_ samples_imag\[6\]\[5\] _06453_ VDD VSS NAND2_X1
X_16369_ _00859_ net91 _06454_ VDD VSS NAND2_X1
X_16370_ _00845_ _06453_ _06454_ _00063_ VDD VSS AOI21_X1
X_16371_ _00844_ _06455_ VDD VSS CLKBUF_X3
X_16372_ _06448_ samples_imag\[6\]\[6\] _06456_ VDD VSS NAND2_X1
X_16373_ _00859_ net92 _06457_ VDD VSS NAND2_X1
X_16374_ _06455_ _06456_ _06457_ _00064_ VDD VSS AOI21_X1
X_16375_ _06448_ samples_imag\[6\]\[7\] _06458_ VDD VSS NAND2_X1
X_16376_ _00859_ net95 _06459_ VDD VSS NAND2_X1
X_16377_ _06455_ _06458_ _06459_ _00065_ VDD VSS AOI21_X1
X_16378_ _06448_ samples_imag\[6\]\[8\] _06460_ VDD VSS NAND2_X1
X_16379_ _00859_ net96 _06461_ VDD VSS NAND2_X1
X_16380_ _06455_ _06460_ _06461_ _00066_ VDD VSS AOI21_X1
X_16381_ _06448_ samples_imag\[6\]\[9\] _06462_ VDD VSS NAND2_X1
X_16382_ _00859_ net99 _06463_ VDD VSS NAND2_X1
X_16383_ _06455_ _06462_ _06463_ _00067_ VDD VSS AOI21_X1
X_16384_ _06448_ samples_imag\[6\]\[10\] _06464_ VDD VSS NAND2_X1
X_16385_ _00859_ net100 _06465_ VDD VSS NAND2_X1
X_16386_ _06455_ _06464_ _06465_ _00068_ VDD VSS AOI21_X1
X_16387_ _06448_ samples_imag\[6\]\[11\] _06466_ VDD VSS NAND2_X1
X_16388_ _00859_ net102 _06467_ VDD VSS NAND2_X1
X_16389_ _06455_ _06466_ _06467_ _00069_ VDD VSS AOI21_X1
X_16390_ _06448_ samples_imag\[6\]\[12\] _06468_ VDD VSS NAND2_X1
X_16391_ _00858_ _06469_ VDD VSS CLKBUF_X3
X_16392_ _06469_ _06470_ VDD VSS CLKBUF_X3
X_16393_ _06470_ net103 _06471_ VDD VSS NAND2_X1
X_16394_ _06455_ _06468_ _06471_ _00070_ VDD VSS AOI21_X1
X_16395_ _06447_ _06472_ VDD VSS CLKBUF_X3
X_16396_ _06472_ samples_imag\[6\]\[13\] _06473_ VDD VSS NAND2_X1
X_16397_ _06470_ net105 _06474_ VDD VSS NAND2_X1
X_16398_ _06455_ _06473_ _06474_ _00071_ VDD VSS AOI21_X1
X_16399_ _06472_ samples_imag\[0\]\[10\] _06475_ VDD VSS NAND2_X1
X_16400_ _06470_ net106 _06476_ VDD VSS NAND2_X1
X_16401_ _06455_ _06475_ _06476_ _00072_ VDD VSS AOI21_X1
X_16402_ _06472_ samples_imag\[6\]\[14\] _06477_ VDD VSS NAND2_X1
X_16403_ _06470_ net108 _06478_ VDD VSS NAND2_X1
X_16404_ _06455_ _06477_ _06478_ _00073_ VDD VSS AOI21_X1
X_16405_ _00844_ _06479_ VDD VSS CLKBUF_X3
X_16406_ _06472_ samples_imag\[6\]\[15\] _06480_ VDD VSS NAND2_X1
X_16407_ _06470_ net109 _06481_ VDD VSS NAND2_X1
X_16408_ _06479_ _06480_ _06481_ _00074_ VDD VSS AOI21_X1
X_16409_ _06472_ samples_imag\[7\]\[0\] _06482_ VDD VSS NAND2_X1
X_16410_ _06470_ net110 _06483_ VDD VSS NAND2_X1
X_16411_ _06479_ _06482_ _06483_ _00075_ VDD VSS AOI21_X1
X_16412_ _06472_ samples_imag\[7\]\[1\] _06484_ VDD VSS NAND2_X1
X_16413_ _06470_ net111 _06485_ VDD VSS NAND2_X1
X_16414_ _06479_ _06484_ _06485_ _00076_ VDD VSS AOI21_X1
X_16415_ _06472_ samples_imag\[7\]\[2\] _06486_ VDD VSS NAND2_X1
X_16416_ _06470_ net112 _06487_ VDD VSS NAND2_X1
X_16417_ _06479_ _06486_ _06487_ _00077_ VDD VSS AOI21_X1
X_16418_ _06472_ samples_imag\[7\]\[3\] _06488_ VDD VSS NAND2_X1
X_16419_ _06470_ net113 _06489_ VDD VSS NAND2_X1
X_16420_ _06479_ _06488_ _06489_ _00078_ VDD VSS AOI21_X1
X_16421_ _06472_ samples_imag\[7\]\[4\] _06490_ VDD VSS NAND2_X1
X_16422_ _06470_ net114 _06491_ VDD VSS NAND2_X1
X_16423_ _06479_ _06490_ _06491_ _00079_ VDD VSS AOI21_X1
X_16424_ _06472_ samples_imag\[7\]\[5\] _06492_ VDD VSS NAND2_X1
X_16425_ _06469_ _06493_ VDD VSS CLKBUF_X3
X_16426_ _06493_ net115 _06494_ VDD VSS NAND2_X1
X_16427_ _06479_ _06492_ _06494_ _00080_ VDD VSS AOI21_X1
X_16428_ _06447_ _06495_ VDD VSS CLKBUF_X3
X_16429_ _06495_ samples_imag\[7\]\[6\] _06496_ VDD VSS NAND2_X1
X_16430_ _06493_ net116 _06497_ VDD VSS NAND2_X1
X_16431_ _06479_ _06496_ _06497_ _00081_ VDD VSS AOI21_X1
X_16432_ _06495_ samples_imag\[7\]\[7\] _06498_ VDD VSS NAND2_X1
X_16433_ _06493_ net117 _06499_ VDD VSS NAND2_X1
X_16434_ _06479_ _06498_ _06499_ _00082_ VDD VSS AOI21_X1
X_16435_ _06495_ samples_imag\[0\]\[11\] _06500_ VDD VSS NAND2_X1
X_16436_ _06493_ net118 _06501_ VDD VSS NAND2_X1
X_16437_ _06479_ _06500_ _06501_ _00083_ VDD VSS AOI21_X1
X_16438_ _00843_ _06502_ VDD VSS BUF_X4
X_16439_ _06502_ _06503_ VDD VSS CLKBUF_X3
X_16440_ _06495_ samples_imag\[7\]\[8\] _06504_ VDD VSS NAND2_X1
X_16441_ _06493_ net119 _06505_ VDD VSS NAND2_X1
X_16442_ _06503_ _06504_ _06505_ _00084_ VDD VSS AOI21_X1
X_16443_ _06495_ samples_imag\[7\]\[9\] _06506_ VDD VSS NAND2_X1
X_16444_ _06493_ net120 _06507_ VDD VSS NAND2_X1
X_16445_ _06503_ _06506_ _06507_ _00085_ VDD VSS AOI21_X1
X_16446_ _06495_ samples_imag\[7\]\[10\] _06508_ VDD VSS NAND2_X1
X_16447_ _06493_ net121 _06509_ VDD VSS NAND2_X1
X_16448_ _06503_ _06508_ _06509_ _00086_ VDD VSS AOI21_X1
X_16449_ _06495_ samples_imag\[7\]\[11\] _06510_ VDD VSS NAND2_X1
X_16450_ _06493_ net122 _06511_ VDD VSS NAND2_X1
X_16451_ _06503_ _06510_ _06511_ _00087_ VDD VSS AOI21_X1
X_16452_ _06495_ samples_imag\[7\]\[12\] _06512_ VDD VSS NAND2_X1
X_16453_ _06493_ net123 _06513_ VDD VSS NAND2_X1
X_16454_ _06503_ _06512_ _06513_ _00088_ VDD VSS AOI21_X1
X_16455_ _06495_ samples_imag\[7\]\[13\] _06514_ VDD VSS NAND2_X1
X_16456_ _06493_ net124 _06515_ VDD VSS NAND2_X1
X_16457_ _06503_ _06514_ _06515_ _00089_ VDD VSS AOI21_X1
X_16458_ _06495_ samples_imag\[7\]\[14\] _06516_ VDD VSS NAND2_X1
X_16459_ _00858_ _06517_ VDD VSS CLKBUF_X3
X_16460_ _06517_ _06518_ VDD VSS CLKBUF_X3
X_16461_ _06518_ net126 _06519_ VDD VSS NAND2_X1
X_16462_ _06503_ _06516_ _06519_ _00090_ VDD VSS AOI21_X1
X_16463_ _00857_ _06520_ VDD VSS BUF_X4
X_16464_ _06520_ _06521_ VDD VSS CLKBUF_X3
X_16465_ _06521_ samples_imag\[7\]\[15\] _06522_ VDD VSS NAND2_X1
X_16466_ _06518_ net127 _06523_ VDD VSS NAND2_X1
X_16467_ _06503_ _06522_ _06523_ _00091_ VDD VSS AOI21_X1
X_16468_ _06521_ samples_imag\[0\]\[12\] _06524_ VDD VSS NAND2_X1
X_16469_ _06518_ net128 _06525_ VDD VSS NAND2_X1
X_16470_ _06503_ _06524_ _06525_ _00092_ VDD VSS AOI21_X1
X_16471_ _06521_ samples_imag\[0\]\[13\] _06526_ VDD VSS NAND2_X1
X_16472_ _06518_ net134 _06527_ VDD VSS NAND2_X1
X_16473_ _06503_ _06526_ _06527_ _00093_ VDD VSS AOI21_X1
X_16474_ _06502_ _06528_ VDD VSS CLKBUF_X3
X_16475_ _06521_ samples_imag\[0\]\[14\] _06529_ VDD VSS NAND2_X1
X_16476_ _06518_ net135 _06530_ VDD VSS NAND2_X1
X_16477_ _06528_ _06529_ _06530_ _00094_ VDD VSS AOI21_X1
X_16478_ _06521_ samples_imag\[0\]\[15\] _06531_ VDD VSS NAND2_X1
X_16479_ _06518_ net136 _06532_ VDD VSS NAND2_X1
X_16480_ _06528_ _06531_ _06532_ _00095_ VDD VSS AOI21_X1
X_16481_ _06521_ samples_imag\[1\]\[0\] _06533_ VDD VSS NAND2_X1
X_16482_ _06518_ net141 _06534_ VDD VSS NAND2_X1
X_16483_ _06528_ _06533_ _06534_ _00096_ VDD VSS AOI21_X1
X_16484_ _06521_ samples_imag\[1\]\[1\] _06535_ VDD VSS NAND2_X1
X_16485_ _06518_ net142 _06536_ VDD VSS NAND2_X1
X_16486_ _06528_ _06535_ _06536_ _00097_ VDD VSS AOI21_X1
X_16487_ _06521_ samples_imag\[1\]\[2\] _06537_ VDD VSS NAND2_X1
X_16488_ _06518_ net145 _06538_ VDD VSS NAND2_X1
X_16489_ _06528_ _06537_ _06538_ _00098_ VDD VSS AOI21_X1
X_16490_ _06521_ samples_imag\[1\]\[3\] _06539_ VDD VSS NAND2_X1
X_16491_ _06518_ net146 _06540_ VDD VSS NAND2_X1
X_16492_ _06528_ _06539_ _06540_ _00099_ VDD VSS AOI21_X1
X_16493_ _06521_ samples_imag\[0\]\[1\] _06541_ VDD VSS NAND2_X1
X_16494_ _06517_ _06542_ VDD VSS CLKBUF_X3
X_16495_ _06542_ net147 _06543_ VDD VSS NAND2_X1
X_16496_ _06528_ _06541_ _06543_ _00100_ VDD VSS AOI21_X1
X_16497_ _06520_ _06544_ VDD VSS BUF_X2
X_16498_ _06544_ samples_imag\[1\]\[4\] _06545_ VDD VSS NAND2_X1
X_16499_ _06542_ net148 _06546_ VDD VSS NAND2_X1
X_16500_ _06528_ _06545_ _06546_ _00101_ VDD VSS AOI21_X1
X_16501_ _06544_ samples_imag\[1\]\[5\] _06547_ VDD VSS NAND2_X1
X_16502_ _06542_ net150 _06548_ VDD VSS NAND2_X1
X_16503_ _06528_ _06547_ _06548_ _00102_ VDD VSS AOI21_X1
X_16504_ _06544_ samples_imag\[1\]\[6\] _06549_ VDD VSS NAND2_X1
X_16505_ _06542_ net155 _06550_ VDD VSS NAND2_X1
X_16506_ _06528_ _06549_ _06550_ _00103_ VDD VSS AOI21_X1
X_16507_ _06502_ _06551_ VDD VSS CLKBUF_X3
X_16508_ _06544_ samples_imag\[1\]\[7\] _06552_ VDD VSS NAND2_X1
X_16509_ _06542_ net157 _06553_ VDD VSS NAND2_X1
X_16510_ _06551_ _06552_ _06553_ _00104_ VDD VSS AOI21_X1
X_16511_ _06544_ samples_imag\[1\]\[8\] _06554_ VDD VSS NAND2_X1
X_16512_ _06542_ net159 _06555_ VDD VSS NAND2_X1
X_16513_ _06551_ _06554_ _06555_ _00105_ VDD VSS AOI21_X1
X_16514_ _06544_ samples_imag\[1\]\[9\] _06556_ VDD VSS NAND2_X1
X_16515_ _06542_ net160 _06557_ VDD VSS NAND2_X1
X_16516_ _06551_ _06556_ _06557_ _00106_ VDD VSS AOI21_X1
X_16517_ _06544_ samples_imag\[1\]\[10\] _06558_ VDD VSS NAND2_X1
X_16518_ _06542_ net161 _06559_ VDD VSS NAND2_X1
X_16519_ _06551_ _06558_ _06559_ _00107_ VDD VSS AOI21_X1
X_16520_ _06544_ samples_imag\[1\]\[11\] _06560_ VDD VSS NAND2_X1
X_16521_ _06542_ net162 _06561_ VDD VSS NAND2_X1
X_16522_ _06551_ _06560_ _06561_ _00108_ VDD VSS AOI21_X1
X_16523_ _06544_ samples_imag\[1\]\[12\] _06562_ VDD VSS NAND2_X1
X_16524_ _06542_ net163 _06563_ VDD VSS NAND2_X1
X_16525_ _06551_ _06562_ _06563_ _00109_ VDD VSS AOI21_X1
X_16526_ _06544_ samples_imag\[1\]\[13\] _06564_ VDD VSS NAND2_X1
X_16527_ _06517_ _06565_ VDD VSS CLKBUF_X3
X_16528_ _06565_ net164 _06566_ VDD VSS NAND2_X1
X_16529_ _06551_ _06564_ _06566_ _00110_ VDD VSS AOI21_X1
X_16530_ _06520_ _06567_ VDD VSS CLKBUF_X3
X_16531_ _06567_ samples_imag\[0\]\[2\] _06568_ VDD VSS NAND2_X1
X_16532_ _06565_ net165 _06569_ VDD VSS NAND2_X1
X_16533_ _06551_ _06568_ _06569_ _00111_ VDD VSS AOI21_X1
X_16534_ _06567_ samples_imag\[1\]\[14\] _06570_ VDD VSS NAND2_X1
X_16535_ _06565_ net166 _06571_ VDD VSS NAND2_X1
X_16536_ _06551_ _06570_ _06571_ _00112_ VDD VSS AOI21_X1
X_16537_ _06567_ samples_imag\[1\]\[15\] _06572_ VDD VSS NAND2_X1
X_16538_ _06565_ net167 _06573_ VDD VSS NAND2_X1
X_16539_ _06551_ _06572_ _06573_ _00113_ VDD VSS AOI21_X1
X_16540_ _06502_ _06574_ VDD VSS CLKBUF_X3
X_16541_ _06567_ samples_imag\[2\]\[0\] _06575_ VDD VSS NAND2_X1
X_16542_ _06565_ net168 _06576_ VDD VSS NAND2_X1
X_16543_ _06574_ _06575_ _06576_ _00114_ VDD VSS AOI21_X1
X_16544_ _06567_ samples_imag\[2\]\[1\] _06577_ VDD VSS NAND2_X1
X_16545_ _06565_ net169 _06578_ VDD VSS NAND2_X1
X_16546_ _06574_ _06577_ _06578_ _00115_ VDD VSS AOI21_X1
X_16547_ _06567_ samples_imag\[2\]\[2\] _06579_ VDD VSS NAND2_X1
X_16548_ _06565_ net170 _06580_ VDD VSS NAND2_X1
X_16549_ _06574_ _06579_ _06580_ _00116_ VDD VSS AOI21_X1
X_16550_ _06567_ samples_imag\[2\]\[3\] _06581_ VDD VSS NAND2_X1
X_16551_ _06565_ net171 _06582_ VDD VSS NAND2_X1
X_16552_ _06574_ _06581_ _06582_ _00117_ VDD VSS AOI21_X1
X_16553_ _06567_ samples_imag\[2\]\[4\] _06583_ VDD VSS NAND2_X1
X_16554_ _06565_ net172 _06584_ VDD VSS NAND2_X1
X_16555_ _06574_ _06583_ _06584_ _00118_ VDD VSS AOI21_X1
X_16556_ _06567_ samples_imag\[2\]\[5\] _06585_ VDD VSS NAND2_X1
X_16557_ _06565_ net173 _06586_ VDD VSS NAND2_X1
X_16558_ _06574_ _06585_ _06586_ _00119_ VDD VSS AOI21_X1
X_16559_ _06567_ samples_imag\[2\]\[6\] _06587_ VDD VSS NAND2_X1
X_16560_ _06517_ _06588_ VDD VSS CLKBUF_X3
X_16561_ _06588_ net174 _06589_ VDD VSS NAND2_X1
X_16562_ _06574_ _06587_ _06589_ _00120_ VDD VSS AOI21_X1
X_16563_ _06520_ _06590_ VDD VSS CLKBUF_X3
X_16564_ _06590_ samples_imag\[2\]\[7\] _06591_ VDD VSS NAND2_X1
X_16565_ _06588_ net175 _06592_ VDD VSS NAND2_X1
X_16566_ _06574_ _06591_ _06592_ _00121_ VDD VSS AOI21_X1
X_16567_ _06590_ samples_imag\[0\]\[3\] _06593_ VDD VSS NAND2_X1
X_16568_ _06588_ net176 _06594_ VDD VSS NAND2_X1
X_16569_ _06574_ _06593_ _06594_ _00122_ VDD VSS AOI21_X1
X_16570_ _06590_ samples_imag\[2\]\[8\] _06595_ VDD VSS NAND2_X1
X_16571_ _06588_ net177 _06596_ VDD VSS NAND2_X1
X_16572_ _06574_ _06595_ _06596_ _00123_ VDD VSS AOI21_X1
X_16573_ _06502_ _06597_ VDD VSS CLKBUF_X3
X_16574_ _06590_ samples_imag\[2\]\[9\] _06598_ VDD VSS NAND2_X1
X_16575_ _06588_ net178 _06599_ VDD VSS NAND2_X1
X_16576_ _06597_ _06598_ _06599_ _00124_ VDD VSS AOI21_X1
X_16577_ _06590_ samples_imag\[2\]\[10\] _06600_ VDD VSS NAND2_X1
X_16578_ _06588_ net179 _06601_ VDD VSS NAND2_X1
X_16579_ _06597_ _06600_ _06601_ _00125_ VDD VSS AOI21_X1
X_16580_ _06590_ samples_imag\[2\]\[11\] _06602_ VDD VSS NAND2_X1
X_16581_ _06588_ net180 _06603_ VDD VSS NAND2_X1
X_16582_ _06597_ _06602_ _06603_ _00126_ VDD VSS AOI21_X1
X_16583_ _06590_ samples_imag\[2\]\[12\] _06604_ VDD VSS NAND2_X1
X_16584_ _06588_ net181 _06605_ VDD VSS NAND2_X1
X_16585_ _06597_ _06604_ _06605_ _00127_ VDD VSS AOI21_X1
X_16586_ _06590_ samples_imag\[2\]\[13\] _06606_ VDD VSS NAND2_X1
X_16587_ _06588_ net182 _06607_ VDD VSS NAND2_X1
X_16588_ _06597_ _06606_ _06607_ _00128_ VDD VSS AOI21_X1
X_16589_ _06590_ samples_imag\[2\]\[14\] _06608_ VDD VSS NAND2_X1
X_16590_ _06588_ net183 _06609_ VDD VSS NAND2_X1
X_16591_ _06597_ _06608_ _06609_ _00129_ VDD VSS AOI21_X1
X_16592_ _06590_ samples_imag\[2\]\[15\] _06610_ VDD VSS NAND2_X1
X_16593_ _06517_ _06611_ VDD VSS CLKBUF_X3
X_16594_ _06611_ net184 _06612_ VDD VSS NAND2_X1
X_16595_ _06597_ _06610_ _06612_ _00130_ VDD VSS AOI21_X1
X_16596_ _06520_ _06613_ VDD VSS BUF_X2
X_16597_ _06613_ samples_imag\[3\]\[0\] _06614_ VDD VSS NAND2_X1
X_16598_ _06611_ net185 _06615_ VDD VSS NAND2_X1
X_16599_ _06597_ _06614_ _06615_ _00131_ VDD VSS AOI21_X1
X_16600_ _06613_ samples_imag\[3\]\[1\] _06616_ VDD VSS NAND2_X1
X_16601_ _06611_ net186 _06617_ VDD VSS NAND2_X1
X_16602_ _06597_ _06616_ _06617_ _00132_ VDD VSS AOI21_X1
X_16603_ _06613_ samples_imag\[0\]\[4\] _06618_ VDD VSS NAND2_X1
X_16604_ _06611_ net187 _06619_ VDD VSS NAND2_X1
X_16605_ _06597_ _06618_ _06619_ _00133_ VDD VSS AOI21_X1
X_16606_ _06502_ _06620_ VDD VSS CLKBUF_X3
X_16607_ _06613_ samples_imag\[3\]\[2\] _06621_ VDD VSS NAND2_X1
X_16608_ _06611_ net188 _06622_ VDD VSS NAND2_X1
X_16609_ _06620_ _06621_ _06622_ _00134_ VDD VSS AOI21_X1
X_16610_ _06613_ samples_imag\[3\]\[3\] _06623_ VDD VSS NAND2_X1
X_16611_ _06611_ net189 _06624_ VDD VSS NAND2_X1
X_16612_ _06620_ _06623_ _06624_ _00135_ VDD VSS AOI21_X1
X_16613_ _06613_ samples_imag\[3\]\[4\] _06625_ VDD VSS NAND2_X1
X_16614_ _06611_ net190 _06626_ VDD VSS NAND2_X1
X_16615_ _06620_ _06625_ _06626_ _00136_ VDD VSS AOI21_X1
X_16616_ _06613_ samples_imag\[3\]\[5\] _06627_ VDD VSS NAND2_X1
X_16617_ _06611_ net191 _06628_ VDD VSS NAND2_X1
X_16618_ _06620_ _06627_ _06628_ _00137_ VDD VSS AOI21_X1
X_16619_ _06613_ samples_imag\[3\]\[6\] _06629_ VDD VSS NAND2_X1
X_16620_ _06611_ net192 _06630_ VDD VSS NAND2_X1
X_16621_ _06620_ _06629_ _06630_ _00138_ VDD VSS AOI21_X1
X_16622_ _06613_ samples_imag\[3\]\[7\] _06631_ VDD VSS NAND2_X1
X_16623_ _06611_ net193 _06632_ VDD VSS NAND2_X1
X_16624_ _06620_ _06631_ _06632_ _00139_ VDD VSS AOI21_X1
X_16625_ _06613_ samples_imag\[3\]\[8\] _06633_ VDD VSS NAND2_X1
X_16626_ _06517_ _06634_ VDD VSS CLKBUF_X3
X_16627_ _06634_ net194 _06635_ VDD VSS NAND2_X1
X_16628_ _06620_ _06633_ _06635_ _00140_ VDD VSS AOI21_X1
X_16629_ _06520_ _06636_ VDD VSS BUF_X2
X_16630_ _06636_ samples_imag\[3\]\[9\] _06637_ VDD VSS NAND2_X1
X_16631_ _06634_ net195 _06638_ VDD VSS NAND2_X1
X_16632_ _06620_ _06637_ _06638_ _00141_ VDD VSS AOI21_X1
X_16633_ _06636_ samples_imag\[3\]\[10\] _06639_ VDD VSS NAND2_X1
X_16634_ _06634_ net196 _06640_ VDD VSS NAND2_X1
X_16635_ _06620_ _06639_ _06640_ _00142_ VDD VSS AOI21_X1
X_16636_ _06636_ samples_imag\[3\]\[11\] _06641_ VDD VSS NAND2_X1
X_16637_ _06634_ net197 _06642_ VDD VSS NAND2_X1
X_16638_ _06620_ _06641_ _06642_ _00143_ VDD VSS AOI21_X1
X_16639_ _06502_ _06643_ VDD VSS CLKBUF_X3
X_16640_ _06636_ samples_imag\[0\]\[5\] _06644_ VDD VSS NAND2_X1
X_16641_ _06634_ net198 _06645_ VDD VSS NAND2_X1
X_16642_ _06643_ _06644_ _06645_ _00144_ VDD VSS AOI21_X1
X_16643_ _06636_ samples_imag\[3\]\[12\] _06646_ VDD VSS NAND2_X1
X_16644_ _06634_ net199 _06647_ VDD VSS NAND2_X1
X_16645_ _06643_ _06646_ _06647_ _00145_ VDD VSS AOI21_X1
X_16646_ _06636_ samples_imag\[3\]\[13\] _06648_ VDD VSS NAND2_X1
X_16647_ _06634_ net200 _06649_ VDD VSS NAND2_X1
X_16648_ _06643_ _06648_ _06649_ _00146_ VDD VSS AOI21_X1
X_16649_ _06636_ samples_imag\[3\]\[14\] _06650_ VDD VSS NAND2_X1
X_16650_ _06634_ net201 _06651_ VDD VSS NAND2_X1
X_16651_ _06643_ _06650_ _06651_ _00147_ VDD VSS AOI21_X1
X_16652_ _06636_ samples_imag\[3\]\[15\] _06652_ VDD VSS NAND2_X1
X_16653_ _06634_ net202 _06653_ VDD VSS NAND2_X1
X_16654_ _06643_ _06652_ _06653_ _00148_ VDD VSS AOI21_X1
X_16655_ _06636_ samples_imag\[4\]\[0\] _06654_ VDD VSS NAND2_X1
X_16656_ _06634_ net203 _06655_ VDD VSS NAND2_X1
X_16657_ _06643_ _06654_ _06655_ _00149_ VDD VSS AOI21_X1
X_16658_ _06636_ samples_imag\[4\]\[1\] _06656_ VDD VSS NAND2_X1
X_16659_ _06517_ _06657_ VDD VSS CLKBUF_X3
X_16660_ _06657_ net204 _06658_ VDD VSS NAND2_X1
X_16661_ _06643_ _06656_ _06658_ _00150_ VDD VSS AOI21_X1
X_16662_ _06520_ _06659_ VDD VSS BUF_X2
X_16663_ _06659_ samples_imag\[4\]\[2\] _06660_ VDD VSS NAND2_X1
X_16664_ _06657_ net205 _06661_ VDD VSS NAND2_X1
X_16665_ _06643_ _06660_ _06661_ _00151_ VDD VSS AOI21_X1
X_16666_ _06659_ samples_imag\[4\]\[3\] _06662_ VDD VSS NAND2_X1
X_16667_ _06657_ net206 _06663_ VDD VSS NAND2_X1
X_16668_ _06643_ _06662_ _06663_ _00152_ VDD VSS AOI21_X1
X_16669_ _06659_ samples_imag\[4\]\[4\] _06664_ VDD VSS NAND2_X1
X_16670_ _06657_ net207 _06665_ VDD VSS NAND2_X1
X_16671_ _06643_ _06664_ _06665_ _00153_ VDD VSS AOI21_X1
X_16672_ _06502_ _06666_ VDD VSS CLKBUF_X3
X_16673_ _06659_ samples_imag\[4\]\[5\] _06667_ VDD VSS NAND2_X1
X_16674_ _06657_ net208 _06668_ VDD VSS NAND2_X1
X_16675_ _06666_ _06667_ _06668_ _00154_ VDD VSS AOI21_X1
X_16676_ _06659_ samples_imag\[0\]\[6\] _06669_ VDD VSS NAND2_X1
X_16677_ _06657_ net209 _06670_ VDD VSS NAND2_X1
X_16678_ _06666_ _06669_ _06670_ _00155_ VDD VSS AOI21_X1
X_16679_ _06659_ samples_imag\[4\]\[6\] _06671_ VDD VSS NAND2_X1
X_16680_ _06657_ net210 _06672_ VDD VSS NAND2_X1
X_16681_ _06666_ _06671_ _06672_ _00156_ VDD VSS AOI21_X1
X_16682_ _06659_ samples_imag\[4\]\[7\] _06673_ VDD VSS NAND2_X1
X_16683_ _06657_ net211 _06674_ VDD VSS NAND2_X1
X_16684_ _06666_ _06673_ _06674_ _00157_ VDD VSS AOI21_X1
X_16685_ _06659_ samples_imag\[4\]\[8\] _06675_ VDD VSS NAND2_X1
X_16686_ _06657_ net212 _06676_ VDD VSS NAND2_X1
X_16687_ _06666_ _06675_ _06676_ _00158_ VDD VSS AOI21_X1
X_16688_ _06659_ samples_imag\[4\]\[9\] _06677_ VDD VSS NAND2_X1
X_16689_ _06657_ net213 _06678_ VDD VSS NAND2_X1
X_16690_ _06666_ _06677_ _06678_ _00159_ VDD VSS AOI21_X1
X_16691_ _06659_ samples_imag\[4\]\[10\] _06679_ VDD VSS NAND2_X1
X_16692_ _06517_ _06680_ VDD VSS CLKBUF_X3
X_16693_ _06680_ net214 _06681_ VDD VSS NAND2_X1
X_16694_ _06666_ _06679_ _06681_ _00160_ VDD VSS AOI21_X1
X_16695_ _06520_ _06682_ VDD VSS BUF_X2
X_16696_ _06682_ samples_imag\[4\]\[11\] _06683_ VDD VSS NAND2_X1
X_16697_ _06680_ net215 _06684_ VDD VSS NAND2_X1
X_16698_ _06666_ _06683_ _06684_ _00161_ VDD VSS AOI21_X1
X_16699_ _06682_ samples_imag\[4\]\[12\] _06685_ VDD VSS NAND2_X1
X_16700_ _06680_ net216 _06686_ VDD VSS NAND2_X1
X_16701_ _06666_ _06685_ _06686_ _00162_ VDD VSS AOI21_X1
X_16702_ _06682_ samples_imag\[4\]\[13\] _06687_ VDD VSS NAND2_X1
X_16703_ _06680_ net217 _06688_ VDD VSS NAND2_X1
X_16704_ _06666_ _06687_ _06688_ _00163_ VDD VSS AOI21_X1
X_16705_ _06502_ _06689_ VDD VSS CLKBUF_X3
X_16706_ _06682_ samples_imag\[4\]\[14\] _06690_ VDD VSS NAND2_X1
X_16707_ _06680_ net218 _06691_ VDD VSS NAND2_X1
X_16708_ _06689_ _06690_ _06691_ _00164_ VDD VSS AOI21_X1
X_16709_ _06682_ samples_imag\[4\]\[15\] _06692_ VDD VSS NAND2_X1
X_16710_ _06680_ net219 _06693_ VDD VSS NAND2_X1
X_16711_ _06689_ _06692_ _06693_ _00165_ VDD VSS AOI21_X1
X_16712_ _06682_ samples_imag\[0\]\[7\] _06694_ VDD VSS NAND2_X1
X_16713_ _06680_ net220 _06695_ VDD VSS NAND2_X1
X_16714_ _06689_ _06694_ _06695_ _00166_ VDD VSS AOI21_X1
X_16715_ _06682_ samples_imag\[5\]\[0\] _06696_ VDD VSS NAND2_X1
X_16716_ _06680_ net221 _06697_ VDD VSS NAND2_X1
X_16717_ _06689_ _06696_ _06697_ _00167_ VDD VSS AOI21_X1
X_16718_ _06682_ samples_imag\[5\]\[1\] _06698_ VDD VSS NAND2_X1
X_16719_ _06680_ net222 _06699_ VDD VSS NAND2_X1
X_16720_ _06689_ _06698_ _06699_ _00168_ VDD VSS AOI21_X1
X_16721_ _06682_ samples_imag\[5\]\[2\] _06700_ VDD VSS NAND2_X1
X_16722_ _06680_ net223 _06701_ VDD VSS NAND2_X1
X_16723_ _06689_ _06700_ _06701_ _00169_ VDD VSS AOI21_X1
X_16724_ _06682_ samples_imag\[5\]\[3\] _06702_ VDD VSS NAND2_X1
X_16725_ _06517_ _06703_ VDD VSS BUF_X2
X_16726_ _06703_ net224 _06704_ VDD VSS NAND2_X1
X_16727_ _06689_ _06702_ _06704_ _00170_ VDD VSS AOI21_X1
X_16728_ _06520_ _06705_ VDD VSS BUF_X2
X_16729_ _06705_ samples_imag\[5\]\[4\] _06706_ VDD VSS NAND2_X1
X_16730_ _06703_ net225 _06707_ VDD VSS NAND2_X1
X_16731_ _06689_ _06706_ _06707_ _00171_ VDD VSS AOI21_X1
X_16732_ _06705_ samples_imag\[5\]\[5\] _06708_ VDD VSS NAND2_X1
X_16733_ _06703_ net226 _06709_ VDD VSS NAND2_X1
X_16734_ _06689_ _06708_ _06709_ _00172_ VDD VSS AOI21_X1
X_16735_ _06705_ samples_imag\[5\]\[6\] _06710_ VDD VSS NAND2_X1
X_16736_ _06703_ net227 _06711_ VDD VSS NAND2_X1
X_16737_ _06689_ _06710_ _06711_ _00173_ VDD VSS AOI21_X1
X_16738_ _06502_ _06712_ VDD VSS BUF_X2
X_16739_ _06705_ samples_imag\[5\]\[7\] _06713_ VDD VSS NAND2_X1
X_16740_ _06703_ net228 _06714_ VDD VSS NAND2_X1
X_16741_ _06712_ _06713_ _06714_ _00174_ VDD VSS AOI21_X1
X_16742_ _06705_ samples_imag\[5\]\[8\] _06715_ VDD VSS NAND2_X1
X_16743_ _06703_ net229 _06716_ VDD VSS NAND2_X1
X_16744_ _06712_ _06715_ _06716_ _00175_ VDD VSS AOI21_X1
X_16745_ _06705_ samples_imag\[5\]\[9\] _06717_ VDD VSS NAND2_X1
X_16746_ _06703_ net230 _06718_ VDD VSS NAND2_X1
X_16747_ _06712_ _06717_ _06718_ _00176_ VDD VSS AOI21_X1
X_16748_ _06705_ samples_imag\[0\]\[8\] _06719_ VDD VSS NAND2_X1
X_16749_ _06703_ net231 _06720_ VDD VSS NAND2_X1
X_16750_ _06712_ _06719_ _06720_ _00177_ VDD VSS AOI21_X1
X_16751_ _06705_ samples_imag\[5\]\[10\] _06721_ VDD VSS NAND2_X1
X_16752_ _06703_ net232 _06722_ VDD VSS NAND2_X1
X_16753_ _06712_ _06721_ _06722_ _00178_ VDD VSS AOI21_X1
X_16754_ _06705_ samples_imag\[5\]\[11\] _06723_ VDD VSS NAND2_X1
X_16755_ _06703_ net233 _06724_ VDD VSS NAND2_X1
X_16756_ _06712_ _06723_ _06724_ _00179_ VDD VSS AOI21_X1
X_16757_ _06705_ samples_imag\[5\]\[12\] _06725_ VDD VSS NAND2_X1
X_16758_ _06517_ _06726_ VDD VSS CLKBUF_X3
X_16759_ _06726_ net234 _06727_ VDD VSS NAND2_X1
X_16760_ _06712_ _06725_ _06727_ _00180_ VDD VSS AOI21_X1
X_16761_ _06520_ _06728_ VDD VSS BUF_X4
X_16762_ _06728_ samples_imag\[5\]\[13\] _06729_ VDD VSS NAND2_X1
X_16763_ _06726_ net235 _06730_ VDD VSS NAND2_X1
X_16764_ _06712_ _06729_ _06730_ _00181_ VDD VSS AOI21_X1
X_16765_ _06728_ samples_imag\[5\]\[14\] _06731_ VDD VSS NAND2_X1
X_16766_ _06726_ net236 _06732_ VDD VSS NAND2_X1
X_16767_ _06712_ _06731_ _06732_ _00182_ VDD VSS AOI21_X1
X_16768_ _06728_ samples_imag\[5\]\[15\] _06733_ VDD VSS NAND2_X1
X_16769_ _06726_ net237 _06734_ VDD VSS NAND2_X1
X_16770_ _06712_ _06733_ _06734_ _00183_ VDD VSS AOI21_X1
X_16771_ _00843_ _06735_ VDD VSS CLKBUF_X3
X_16772_ _06735_ _06736_ VDD VSS BUF_X4
X_16773_ _06728_ samples_imag\[6\]\[0\] _06737_ VDD VSS NAND2_X1
X_16774_ _06726_ net238 _06738_ VDD VSS NAND2_X1
X_16775_ _06736_ _06737_ _06738_ _00184_ VDD VSS AOI21_X1
X_16776_ _06728_ samples_imag\[6\]\[1\] _06739_ VDD VSS NAND2_X1
X_16777_ _06726_ net239 _06740_ VDD VSS NAND2_X1
X_16778_ _06736_ _06739_ _06740_ _00185_ VDD VSS AOI21_X1
X_16779_ _06728_ samples_imag\[6\]\[2\] _06741_ VDD VSS NAND2_X1
X_16780_ _06726_ net240 _06742_ VDD VSS NAND2_X1
X_16781_ _06736_ _06741_ _06742_ _00186_ VDD VSS AOI21_X1
X_16782_ _06728_ samples_imag\[6\]\[3\] _06743_ VDD VSS NAND2_X1
X_16783_ _06726_ net241 _06744_ VDD VSS NAND2_X1
X_16784_ _06736_ _06743_ _06744_ _00187_ VDD VSS AOI21_X1
X_16785_ _06728_ samples_imag\[0\]\[9\] _06745_ VDD VSS NAND2_X1
X_16786_ _06726_ net242 _06746_ VDD VSS NAND2_X1
X_16787_ _06736_ _06745_ _06746_ _00188_ VDD VSS AOI21_X1
X_16788_ _06728_ samples_real\[0\]\[0\] _06747_ VDD VSS NAND2_X1
X_16789_ _06726_ net243 _06748_ VDD VSS NAND2_X1
X_16790_ _06736_ _06747_ _06748_ _00189_ VDD VSS AOI21_X1
X_16791_ _06728_ samples_real\[6\]\[4\] _06749_ VDD VSS NAND2_X1
X_16792_ _00858_ _06750_ VDD VSS CLKBUF_X3
X_16793_ _06750_ _06751_ VDD VSS CLKBUF_X3
X_16794_ _06751_ net244 _06752_ VDD VSS NAND2_X1
X_16795_ _06736_ _06749_ _06752_ _00190_ VDD VSS AOI21_X1
X_16796_ _00857_ _06753_ VDD VSS CLKBUF_X3
X_16797_ _06753_ _06754_ VDD VSS BUF_X2
X_16798_ _06754_ samples_real\[6\]\[5\] _06755_ VDD VSS NAND2_X1
X_16799_ _06751_ net245 _06756_ VDD VSS NAND2_X1
X_16800_ _06736_ _06755_ _06756_ _00191_ VDD VSS AOI21_X1
X_16801_ _06754_ samples_real\[6\]\[6\] _06757_ VDD VSS NAND2_X1
X_16802_ _06751_ net246 _06758_ VDD VSS NAND2_X1
X_16803_ _06736_ _06757_ _06758_ _00192_ VDD VSS AOI21_X1
X_16804_ _06754_ samples_real\[6\]\[7\] _06759_ VDD VSS NAND2_X1
X_16805_ _06751_ net247 _06760_ VDD VSS NAND2_X1
X_16806_ _06736_ _06759_ _06760_ _00193_ VDD VSS AOI21_X1
X_16807_ _06735_ _06761_ VDD VSS CLKBUF_X3
X_16808_ _06754_ samples_real\[6\]\[8\] _06762_ VDD VSS NAND2_X1
X_16809_ _06751_ net248 _06763_ VDD VSS NAND2_X1
X_16810_ _06761_ _06762_ _06763_ _00194_ VDD VSS AOI21_X1
X_16811_ _06754_ samples_real\[6\]\[9\] _06764_ VDD VSS NAND2_X1
X_16812_ _06751_ net249 _06765_ VDD VSS NAND2_X1
X_16813_ _06761_ _06764_ _06765_ _00195_ VDD VSS AOI21_X1
X_16814_ _06754_ samples_real\[6\]\[10\] _06766_ VDD VSS NAND2_X1
X_16815_ _06751_ net250 _06767_ VDD VSS NAND2_X1
X_16816_ _06761_ _06766_ _06767_ _00196_ VDD VSS AOI21_X1
X_16817_ _06754_ samples_real\[6\]\[11\] _06768_ VDD VSS NAND2_X1
X_16818_ _06751_ net251 _06769_ VDD VSS NAND2_X1
X_16819_ _06761_ _06768_ _06769_ _00197_ VDD VSS AOI21_X1
X_16820_ _06754_ samples_real\[6\]\[12\] _06770_ VDD VSS NAND2_X1
X_16821_ _06751_ net252 _06771_ VDD VSS NAND2_X1
X_16822_ _06761_ _06770_ _06771_ _00198_ VDD VSS AOI21_X1
X_16823_ _06754_ samples_real\[6\]\[13\] _06772_ VDD VSS NAND2_X1
X_16824_ _06751_ net253 _06773_ VDD VSS NAND2_X1
X_16825_ _06761_ _06772_ _06773_ _00199_ VDD VSS AOI21_X1
X_16826_ _06754_ samples_real\[0\]\[10\] _06774_ VDD VSS NAND2_X1
X_16827_ _06750_ _06775_ VDD VSS CLKBUF_X3
X_16828_ _06775_ net254 _06776_ VDD VSS NAND2_X1
X_16829_ _06761_ _06774_ _06776_ _00200_ VDD VSS AOI21_X1
X_16830_ _06753_ _06777_ VDD VSS BUF_X2
X_16831_ _06777_ samples_real\[6\]\[14\] _06778_ VDD VSS NAND2_X1
X_16832_ _06775_ net255 _06779_ VDD VSS NAND2_X1
X_16833_ _06761_ _06778_ _06779_ _00201_ VDD VSS AOI21_X1
X_16834_ _06777_ samples_real\[6\]\[15\] _06780_ VDD VSS NAND2_X1
X_16835_ _06775_ net256 _06781_ VDD VSS NAND2_X1
X_16836_ _06761_ _06780_ _06781_ _00202_ VDD VSS AOI21_X1
X_16837_ _06777_ samples_real\[7\]\[0\] _06782_ VDD VSS NAND2_X1
X_16838_ _06775_ net257 _06783_ VDD VSS NAND2_X1
X_16839_ _06761_ _06782_ _06783_ _00203_ VDD VSS AOI21_X1
X_16840_ _06735_ _06784_ VDD VSS CLKBUF_X3
X_16841_ _06777_ samples_real\[7\]\[1\] _06785_ VDD VSS NAND2_X1
X_16842_ _06775_ net258 _06786_ VDD VSS NAND2_X1
X_16843_ _06784_ _06785_ _06786_ _00204_ VDD VSS AOI21_X1
X_16844_ _06777_ samples_real\[7\]\[2\] _06787_ VDD VSS NAND2_X1
X_16845_ _06775_ net259 _06788_ VDD VSS NAND2_X1
X_16846_ _06784_ _06787_ _06788_ _00205_ VDD VSS AOI21_X1
X_16847_ _06777_ samples_real\[7\]\[3\] _06789_ VDD VSS NAND2_X1
X_16848_ _06775_ net260 _06790_ VDD VSS NAND2_X1
X_16849_ _06784_ _06789_ _06790_ _00206_ VDD VSS AOI21_X1
X_16850_ _06777_ samples_real\[7\]\[4\] _06791_ VDD VSS NAND2_X1
X_16851_ _06775_ net261 _06792_ VDD VSS NAND2_X1
X_16852_ _06784_ _06791_ _06792_ _00207_ VDD VSS AOI21_X1
X_16853_ _06777_ samples_real\[7\]\[5\] _06793_ VDD VSS NAND2_X1
X_16854_ _06775_ net262 _06794_ VDD VSS NAND2_X1
X_16855_ _06784_ _06793_ _06794_ _00208_ VDD VSS AOI21_X1
X_16856_ _06777_ samples_real\[7\]\[6\] _06795_ VDD VSS NAND2_X1
X_16857_ _06775_ net263 _06796_ VDD VSS NAND2_X1
X_16858_ _06784_ _06795_ _06796_ _00209_ VDD VSS AOI21_X1
X_16859_ _06777_ samples_real\[7\]\[7\] _06797_ VDD VSS NAND2_X1
X_16860_ _06750_ _06798_ VDD VSS CLKBUF_X3
X_16861_ _06798_ net264 _06799_ VDD VSS NAND2_X1
X_16862_ _06784_ _06797_ _06799_ _00210_ VDD VSS AOI21_X1
X_16863_ _06753_ _06800_ VDD VSS BUF_X2
X_16864_ _06800_ samples_real\[0\]\[11\] _06801_ VDD VSS NAND2_X1
X_16865_ _06798_ net265 _06802_ VDD VSS NAND2_X1
X_16866_ _06784_ _06801_ _06802_ _00211_ VDD VSS AOI21_X1
X_16867_ _06800_ samples_real\[7\]\[8\] _06803_ VDD VSS NAND2_X1
X_16868_ _06798_ net266 _06804_ VDD VSS NAND2_X1
X_16869_ _06784_ _06803_ _06804_ _00212_ VDD VSS AOI21_X1
X_16870_ _06800_ samples_real\[7\]\[9\] _06805_ VDD VSS NAND2_X1
X_16871_ _06798_ net267 _06806_ VDD VSS NAND2_X1
X_16872_ _06784_ _06805_ _06806_ _00213_ VDD VSS AOI21_X1
X_16873_ _06735_ _06807_ VDD VSS CLKBUF_X3
X_16874_ _06800_ samples_real\[7\]\[10\] _06808_ VDD VSS NAND2_X1
X_16875_ _06798_ net268 _06809_ VDD VSS NAND2_X1
X_16876_ _06807_ _06808_ _06809_ _00214_ VDD VSS AOI21_X1
X_16877_ _06800_ samples_real\[7\]\[11\] _06810_ VDD VSS NAND2_X1
X_16878_ _06798_ net269 _06811_ VDD VSS NAND2_X1
X_16879_ _06807_ _06810_ _06811_ _00215_ VDD VSS AOI21_X1
X_16880_ _06800_ samples_real\[7\]\[12\] _06812_ VDD VSS NAND2_X1
X_16881_ _06798_ net270 _00586_ VDD VSS NAND2_X1
X_16882_ _06807_ _06812_ _00586_ _00216_ VDD VSS AOI21_X1
X_16883_ _06800_ samples_real\[7\]\[13\] _00587_ VDD VSS NAND2_X1
X_16884_ _06798_ net271 _00588_ VDD VSS NAND2_X1
X_16885_ _06807_ _00587_ _00588_ _00217_ VDD VSS AOI21_X1
X_16886_ _06800_ samples_real\[7\]\[14\] _00589_ VDD VSS NAND2_X1
X_16887_ _06798_ net272 _00590_ VDD VSS NAND2_X1
X_16888_ _06807_ _00589_ _00590_ _00218_ VDD VSS AOI21_X1
X_16889_ _06800_ samples_real\[7\]\[15\] _00591_ VDD VSS NAND2_X1
X_16890_ _06798_ net273 _00592_ VDD VSS NAND2_X1
X_16891_ _06807_ _00591_ _00592_ _00219_ VDD VSS AOI21_X1
X_16892_ _06800_ samples_real\[0\]\[12\] _00593_ VDD VSS NAND2_X1
X_16893_ _06750_ _00594_ VDD VSS CLKBUF_X3
X_16894_ _00594_ net274 _00595_ VDD VSS NAND2_X1
X_16895_ _06807_ _00593_ _00595_ _00220_ VDD VSS AOI21_X1
X_16896_ _06753_ _00596_ VDD VSS BUF_X2
X_16897_ _00596_ samples_real\[0\]\[13\] _00597_ VDD VSS NAND2_X1
X_16898_ _00594_ net275 _00598_ VDD VSS NAND2_X1
X_16899_ _06807_ _00597_ _00598_ _00221_ VDD VSS AOI21_X1
X_16900_ _00596_ samples_real\[0\]\[14\] _00599_ VDD VSS NAND2_X1
X_16901_ _00594_ net276 _00600_ VDD VSS NAND2_X1
X_16902_ _06807_ _00599_ _00600_ _00222_ VDD VSS AOI21_X1
X_16903_ _00596_ samples_real\[0\]\[15\] _00601_ VDD VSS NAND2_X1
X_16904_ _00594_ net277 _00602_ VDD VSS NAND2_X1
X_16905_ _06807_ _00601_ _00602_ _00223_ VDD VSS AOI21_X1
X_16906_ _06735_ _00603_ VDD VSS CLKBUF_X3
X_16907_ _00596_ samples_real\[1\]\[0\] _00604_ VDD VSS NAND2_X1
X_16908_ _00594_ net278 _00605_ VDD VSS NAND2_X1
X_16909_ _00603_ _00604_ _00605_ _00224_ VDD VSS AOI21_X1
X_16910_ _00596_ samples_real\[1\]\[1\] _00606_ VDD VSS NAND2_X1
X_16911_ _00594_ net279 _00607_ VDD VSS NAND2_X1
X_16912_ _00603_ _00606_ _00607_ _00225_ VDD VSS AOI21_X1
X_16913_ _00596_ samples_real\[1\]\[2\] _00608_ VDD VSS NAND2_X1
X_16914_ _00594_ net280 _00609_ VDD VSS NAND2_X1
X_16915_ _00603_ _00608_ _00609_ _00226_ VDD VSS AOI21_X1
X_16916_ _00596_ samples_real\[1\]\[3\] _00610_ VDD VSS NAND2_X1
X_16917_ _00594_ net281 _00611_ VDD VSS NAND2_X1
X_16918_ _00603_ _00610_ _00611_ _00227_ VDD VSS AOI21_X1
X_16919_ _00596_ samples_real\[0\]\[1\] _00612_ VDD VSS NAND2_X1
X_16920_ _00594_ net282 _00613_ VDD VSS NAND2_X1
X_16921_ _00603_ _00612_ _00613_ _00228_ VDD VSS AOI21_X1
X_16922_ _00596_ samples_real\[1\]\[4\] _00614_ VDD VSS NAND2_X1
X_16923_ _00594_ net283 _00615_ VDD VSS NAND2_X1
X_16924_ _00603_ _00614_ _00615_ _00229_ VDD VSS AOI21_X1
X_16925_ _00596_ samples_real\[1\]\[5\] _00616_ VDD VSS NAND2_X1
X_16926_ _06750_ _00617_ VDD VSS CLKBUF_X3
X_16927_ _00617_ net284 _00618_ VDD VSS NAND2_X1
X_16928_ _00603_ _00616_ _00618_ _00230_ VDD VSS AOI21_X1
X_16929_ _06753_ _00619_ VDD VSS CLKBUF_X3
X_16930_ _00619_ samples_real\[1\]\[6\] _00620_ VDD VSS NAND2_X1
X_16931_ _00617_ net285 _00621_ VDD VSS NAND2_X1
X_16932_ _00603_ _00620_ _00621_ _00231_ VDD VSS AOI21_X1
X_16933_ _00619_ samples_real\[1\]\[7\] _00622_ VDD VSS NAND2_X1
X_16934_ _00617_ net286 _00623_ VDD VSS NAND2_X1
X_16935_ _00603_ _00622_ _00623_ _00232_ VDD VSS AOI21_X1
X_16936_ _00619_ samples_real\[1\]\[8\] _00624_ VDD VSS NAND2_X1
X_16937_ _00617_ net287 _00625_ VDD VSS NAND2_X1
X_16938_ _00603_ _00624_ _00625_ _00233_ VDD VSS AOI21_X1
X_16939_ _06735_ _00626_ VDD VSS CLKBUF_X3
X_16940_ _00619_ samples_real\[1\]\[9\] _00627_ VDD VSS NAND2_X1
X_16941_ _00617_ net288 _00628_ VDD VSS NAND2_X1
X_16942_ _00626_ _00627_ _00628_ _00234_ VDD VSS AOI21_X1
X_16943_ _00619_ samples_real\[1\]\[10\] _00629_ VDD VSS NAND2_X1
X_16944_ _00617_ net289 _00630_ VDD VSS NAND2_X1
X_16945_ _00626_ _00629_ _00630_ _00235_ VDD VSS AOI21_X1
X_16946_ _00619_ samples_real\[1\]\[11\] _00631_ VDD VSS NAND2_X1
X_16947_ _00617_ net290 _00632_ VDD VSS NAND2_X1
X_16948_ _00626_ _00631_ _00632_ _00236_ VDD VSS AOI21_X1
X_16949_ _00619_ samples_real\[1\]\[12\] _00633_ VDD VSS NAND2_X1
X_16950_ _00617_ net291 _00634_ VDD VSS NAND2_X1
X_16951_ _00626_ _00633_ _00634_ _00237_ VDD VSS AOI21_X1
X_16952_ _00619_ samples_real\[1\]\[13\] _00635_ VDD VSS NAND2_X1
X_16953_ _00617_ net292 _00636_ VDD VSS NAND2_X1
X_16954_ _00626_ _00635_ _00636_ _00238_ VDD VSS AOI21_X1
X_16955_ _00619_ samples_real\[0\]\[2\] _00637_ VDD VSS NAND2_X1
X_16956_ _00617_ net293 _00638_ VDD VSS NAND2_X1
X_16957_ _00626_ _00637_ _00638_ _00239_ VDD VSS AOI21_X1
X_16958_ _00619_ samples_real\[1\]\[14\] _00639_ VDD VSS NAND2_X1
X_16959_ _06750_ _00640_ VDD VSS CLKBUF_X3
X_16960_ _00640_ net294 _00641_ VDD VSS NAND2_X1
X_16961_ _00626_ _00639_ _00641_ _00240_ VDD VSS AOI21_X1
X_16962_ _06753_ _00642_ VDD VSS CLKBUF_X3
X_16963_ _00642_ samples_real\[1\]\[15\] _00643_ VDD VSS NAND2_X1
X_16964_ _00640_ net295 _00644_ VDD VSS NAND2_X1
X_16965_ _00626_ _00643_ _00644_ _00241_ VDD VSS AOI21_X1
X_16966_ _00642_ samples_real\[2\]\[0\] _00645_ VDD VSS NAND2_X1
X_16967_ _00640_ net296 _00646_ VDD VSS NAND2_X1
X_16968_ _00626_ _00645_ _00646_ _00242_ VDD VSS AOI21_X1
X_16969_ _00642_ samples_real\[2\]\[1\] _00647_ VDD VSS NAND2_X1
X_16970_ _00640_ net297 _00648_ VDD VSS NAND2_X1
X_16971_ _00626_ _00647_ _00648_ _00243_ VDD VSS AOI21_X1
X_16972_ _06735_ _00649_ VDD VSS CLKBUF_X3
X_16973_ _00642_ samples_real\[2\]\[2\] _00650_ VDD VSS NAND2_X1
X_16974_ _00640_ net298 _00651_ VDD VSS NAND2_X1
X_16975_ _00649_ _00650_ _00651_ _00244_ VDD VSS AOI21_X1
X_16976_ _00642_ samples_real\[2\]\[3\] _00652_ VDD VSS NAND2_X1
X_16977_ _00640_ net299 _00653_ VDD VSS NAND2_X1
X_16978_ _00649_ _00652_ _00653_ _00245_ VDD VSS AOI21_X1
X_16979_ _00642_ samples_real\[2\]\[4\] _00654_ VDD VSS NAND2_X1
X_16980_ _00640_ net300 _00655_ VDD VSS NAND2_X1
X_16981_ _00649_ _00654_ _00655_ _00246_ VDD VSS AOI21_X1
X_16982_ _00642_ samples_real\[2\]\[5\] _00656_ VDD VSS NAND2_X1
X_16983_ _00640_ net301 _00657_ VDD VSS NAND2_X1
X_16984_ _00649_ _00656_ _00657_ _00247_ VDD VSS AOI21_X1
X_16985_ _00642_ samples_real\[2\]\[6\] _00658_ VDD VSS NAND2_X1
X_16986_ _00640_ net302 _00659_ VDD VSS NAND2_X1
X_16987_ _00649_ _00658_ _00659_ _00248_ VDD VSS AOI21_X1
X_16988_ _00642_ samples_real\[2\]\[7\] _00660_ VDD VSS NAND2_X1
X_16989_ _00640_ net303 _00661_ VDD VSS NAND2_X1
X_16990_ _00649_ _00660_ _00661_ _00249_ VDD VSS AOI21_X1
X_16991_ _00642_ samples_real\[0\]\[3\] _00662_ VDD VSS NAND2_X1
X_16992_ _06750_ _00663_ VDD VSS CLKBUF_X3
X_16993_ _00663_ net304 _00664_ VDD VSS NAND2_X1
X_16994_ _00649_ _00662_ _00664_ _00250_ VDD VSS AOI21_X1
X_16995_ _06753_ _00665_ VDD VSS CLKBUF_X3
X_16996_ _00665_ samples_real\[2\]\[8\] _00666_ VDD VSS NAND2_X1
X_16997_ _00663_ net305 _00667_ VDD VSS NAND2_X1
X_16998_ _00649_ _00666_ _00667_ _00251_ VDD VSS AOI21_X1
X_16999_ _00665_ samples_real\[2\]\[9\] _00668_ VDD VSS NAND2_X1
X_17000_ _00663_ net306 _00669_ VDD VSS NAND2_X1
X_17001_ _00649_ _00668_ _00669_ _00252_ VDD VSS AOI21_X1
X_17002_ _00665_ samples_real\[2\]\[10\] _00670_ VDD VSS NAND2_X1
X_17003_ _00663_ net307 _00671_ VDD VSS NAND2_X1
X_17004_ _00649_ _00670_ _00671_ _00253_ VDD VSS AOI21_X1
X_17005_ _06735_ _00672_ VDD VSS CLKBUF_X3
X_17006_ _00665_ samples_real\[2\]\[11\] _00673_ VDD VSS NAND2_X1
X_17007_ _00663_ net308 _00674_ VDD VSS NAND2_X1
X_17008_ _00672_ _00673_ _00674_ _00254_ VDD VSS AOI21_X1
X_17009_ _00665_ samples_real\[2\]\[12\] _00675_ VDD VSS NAND2_X1
X_17010_ _00663_ net309 _00676_ VDD VSS NAND2_X1
X_17011_ _00672_ _00675_ _00676_ _00255_ VDD VSS AOI21_X1
X_17012_ _00665_ samples_real\[2\]\[13\] _00677_ VDD VSS NAND2_X1
X_17013_ _00663_ net310 _00678_ VDD VSS NAND2_X1
X_17014_ _00672_ _00677_ _00678_ _00256_ VDD VSS AOI21_X1
X_17015_ _00665_ samples_real\[2\]\[14\] _00679_ VDD VSS NAND2_X1
X_17016_ _00663_ net311 _00680_ VDD VSS NAND2_X1
X_17017_ _00672_ _00679_ _00680_ _00257_ VDD VSS AOI21_X1
X_17018_ _00665_ samples_real\[2\]\[15\] _00681_ VDD VSS NAND2_X1
X_17019_ _00663_ net312 _00682_ VDD VSS NAND2_X1
X_17020_ _00672_ _00681_ _00682_ _00258_ VDD VSS AOI21_X1
X_17021_ _00665_ samples_real\[3\]\[0\] _00683_ VDD VSS NAND2_X1
X_17022_ _00663_ net313 _00684_ VDD VSS NAND2_X1
X_17023_ _00672_ _00683_ _00684_ _00259_ VDD VSS AOI21_X1
X_17024_ _00665_ samples_real\[3\]\[1\] _00685_ VDD VSS NAND2_X1
X_17025_ _06750_ _00686_ VDD VSS CLKBUF_X3
X_17026_ _00686_ net314 _00687_ VDD VSS NAND2_X1
X_17027_ _00672_ _00685_ _00687_ _00260_ VDD VSS AOI21_X1
X_17028_ _06753_ _00688_ VDD VSS BUF_X2
X_17029_ _00688_ samples_real\[0\]\[4\] _00689_ VDD VSS NAND2_X1
X_17030_ _00686_ net315 _00690_ VDD VSS NAND2_X1
X_17031_ _00672_ _00689_ _00690_ _00261_ VDD VSS AOI21_X1
X_17032_ _00688_ samples_real\[3\]\[2\] _00691_ VDD VSS NAND2_X1
X_17033_ _00686_ net316 _00692_ VDD VSS NAND2_X1
X_17034_ _00672_ _00691_ _00692_ _00262_ VDD VSS AOI21_X1
X_17035_ _00688_ samples_real\[3\]\[3\] _00693_ VDD VSS NAND2_X1
X_17036_ _00686_ net317 _00694_ VDD VSS NAND2_X1
X_17037_ _00672_ _00693_ _00694_ _00263_ VDD VSS AOI21_X1
X_17038_ _06735_ _00695_ VDD VSS CLKBUF_X3
X_17039_ _00688_ samples_real\[3\]\[4\] _00696_ VDD VSS NAND2_X1
X_17040_ _00686_ net318 _00697_ VDD VSS NAND2_X1
X_17041_ _00695_ _00696_ _00697_ _00264_ VDD VSS AOI21_X1
X_17042_ _00688_ samples_real\[3\]\[5\] _00698_ VDD VSS NAND2_X1
X_17043_ _00686_ net319 _00699_ VDD VSS NAND2_X1
X_17044_ _00695_ _00698_ _00699_ _00265_ VDD VSS AOI21_X1
X_17045_ _00688_ samples_real\[3\]\[6\] _00700_ VDD VSS NAND2_X1
X_17046_ _00686_ net320 _00701_ VDD VSS NAND2_X1
X_17047_ _00695_ _00700_ _00701_ _00266_ VDD VSS AOI21_X1
X_17048_ _00688_ samples_real\[3\]\[7\] _00702_ VDD VSS NAND2_X1
X_17049_ _00686_ net321 _00703_ VDD VSS NAND2_X1
X_17050_ _00695_ _00702_ _00703_ _00267_ VDD VSS AOI21_X1
X_17051_ _00688_ samples_real\[3\]\[8\] _00704_ VDD VSS NAND2_X1
X_17052_ _00686_ net322 _00705_ VDD VSS NAND2_X1
X_17053_ _00695_ _00704_ _00705_ _00268_ VDD VSS AOI21_X1
X_17054_ _00688_ samples_real\[3\]\[9\] _00706_ VDD VSS NAND2_X1
X_17055_ _00686_ net323 _00707_ VDD VSS NAND2_X1
X_17056_ _00695_ _00706_ _00707_ _00269_ VDD VSS AOI21_X1
X_17057_ _00688_ samples_real\[3\]\[10\] _00708_ VDD VSS NAND2_X1
X_17058_ _06750_ _00709_ VDD VSS CLKBUF_X3
X_17059_ _00709_ net324 _00710_ VDD VSS NAND2_X1
X_17060_ _00695_ _00708_ _00710_ _00270_ VDD VSS AOI21_X1
X_17061_ _06753_ _00711_ VDD VSS BUF_X2
X_17062_ _00711_ samples_real\[3\]\[11\] _00712_ VDD VSS NAND2_X1
X_17063_ _00709_ net325 _00713_ VDD VSS NAND2_X1
X_17064_ _00695_ _00712_ _00713_ _00271_ VDD VSS AOI21_X1
X_17065_ _00711_ samples_real\[0\]\[5\] _00714_ VDD VSS NAND2_X1
X_17066_ _00709_ net326 _00715_ VDD VSS NAND2_X1
X_17067_ _00695_ _00714_ _00715_ _00272_ VDD VSS AOI21_X1
X_17068_ _00711_ samples_real\[3\]\[12\] _00716_ VDD VSS NAND2_X1
X_17069_ _00709_ net327 _00717_ VDD VSS NAND2_X1
X_17070_ _00695_ _00716_ _00717_ _00273_ VDD VSS AOI21_X1
X_17071_ _06735_ _00718_ VDD VSS CLKBUF_X3
X_17072_ _00711_ samples_real\[3\]\[13\] _00719_ VDD VSS NAND2_X1
X_17073_ _00709_ net328 _00720_ VDD VSS NAND2_X1
X_17074_ _00718_ _00719_ _00720_ _00274_ VDD VSS AOI21_X1
X_17075_ _00711_ samples_real\[3\]\[14\] _00721_ VDD VSS NAND2_X1
X_17076_ _00709_ net329 _00722_ VDD VSS NAND2_X1
X_17077_ _00718_ _00721_ _00722_ _00275_ VDD VSS AOI21_X1
X_17078_ _00711_ samples_real\[3\]\[15\] _00723_ VDD VSS NAND2_X1
X_17079_ _00709_ net330 _00724_ VDD VSS NAND2_X1
X_17080_ _00718_ _00723_ _00724_ _00276_ VDD VSS AOI21_X1
X_17081_ _00711_ samples_real\[4\]\[0\] _00725_ VDD VSS NAND2_X1
X_17082_ _00709_ net331 _00726_ VDD VSS NAND2_X1
X_17083_ _00718_ _00725_ _00726_ _00277_ VDD VSS AOI21_X1
X_17084_ _00711_ samples_real\[4\]\[1\] _00727_ VDD VSS NAND2_X1
X_17085_ _00709_ net332 _00728_ VDD VSS NAND2_X1
X_17086_ _00718_ _00727_ _00728_ _00278_ VDD VSS AOI21_X1
X_17087_ _00711_ samples_real\[4\]\[2\] _00729_ VDD VSS NAND2_X1
X_17088_ _00709_ net333 _00730_ VDD VSS NAND2_X1
X_17089_ _00718_ _00729_ _00730_ _00279_ VDD VSS AOI21_X1
X_17090_ _00711_ samples_real\[4\]\[3\] _00731_ VDD VSS NAND2_X1
X_17091_ _06750_ _00732_ VDD VSS CLKBUF_X3
X_17092_ _00732_ net334 _00733_ VDD VSS NAND2_X1
X_17093_ _00718_ _00731_ _00733_ _00280_ VDD VSS AOI21_X1
X_17094_ _06753_ _00734_ VDD VSS BUF_X2
X_17095_ _00734_ samples_real\[4\]\[4\] _00735_ VDD VSS NAND2_X1
X_17096_ _00732_ net335 _00736_ VDD VSS NAND2_X1
X_17097_ _00718_ _00735_ _00736_ _00281_ VDD VSS AOI21_X1
X_17098_ _00734_ samples_real\[4\]\[5\] _00737_ VDD VSS NAND2_X1
X_17099_ _00732_ net336 _00738_ VDD VSS NAND2_X1
X_17100_ _00718_ _00737_ _00738_ _00282_ VDD VSS AOI21_X1
X_17101_ _00734_ samples_real\[0\]\[6\] _00739_ VDD VSS NAND2_X1
X_17102_ _00732_ net337 _00740_ VDD VSS NAND2_X1
X_17103_ _00718_ _00739_ _00740_ _00283_ VDD VSS AOI21_X1
X_17104_ _00843_ _00741_ VDD VSS CLKBUF_X3
X_17105_ _00734_ samples_real\[4\]\[6\] _00742_ VDD VSS NAND2_X1
X_17106_ _00732_ net338 _00743_ VDD VSS NAND2_X1
X_17107_ _00741_ _00742_ _00743_ _00284_ VDD VSS AOI21_X1
X_17108_ _00734_ samples_real\[4\]\[7\] _00744_ VDD VSS NAND2_X1
X_17109_ _00732_ net339 _00745_ VDD VSS NAND2_X1
X_17110_ _00741_ _00744_ _00745_ _00285_ VDD VSS AOI21_X1
X_17111_ _00734_ samples_real\[4\]\[8\] _00746_ VDD VSS NAND2_X1
X_17112_ _00732_ net340 _00747_ VDD VSS NAND2_X1
X_17113_ _00741_ _00746_ _00747_ _00286_ VDD VSS AOI21_X1
X_17114_ _00734_ samples_real\[4\]\[9\] _00748_ VDD VSS NAND2_X1
X_17115_ _00732_ net341 _00749_ VDD VSS NAND2_X1
X_17116_ _00741_ _00748_ _00749_ _00287_ VDD VSS AOI21_X1
X_17117_ _00734_ samples_real\[4\]\[10\] _00750_ VDD VSS NAND2_X1
X_17118_ _00732_ net342 _00751_ VDD VSS NAND2_X1
X_17119_ _00741_ _00750_ _00751_ _00288_ VDD VSS AOI21_X1
X_17120_ _00734_ samples_real\[4\]\[11\] _00752_ VDD VSS NAND2_X1
X_17121_ _00732_ net343 _00753_ VDD VSS NAND2_X1
X_17122_ _00741_ _00752_ _00753_ _00289_ VDD VSS AOI21_X1
X_17123_ _00734_ samples_real\[4\]\[12\] _00754_ VDD VSS NAND2_X1
X_17124_ _00858_ _00755_ VDD VSS CLKBUF_X3
X_17125_ _00755_ net344 _00756_ VDD VSS NAND2_X1
X_17126_ _00741_ _00754_ _00756_ _00290_ VDD VSS AOI21_X1
X_17127_ _00857_ _00757_ VDD VSS CLKBUF_X3
X_17128_ _00757_ samples_real\[4\]\[13\] _00758_ VDD VSS NAND2_X1
X_17129_ _00755_ net345 _00759_ VDD VSS NAND2_X1
X_17130_ _00741_ _00758_ _00759_ _00291_ VDD VSS AOI21_X1
X_17131_ _00757_ samples_real\[4\]\[14\] _00760_ VDD VSS NAND2_X1
X_17132_ _00755_ net346 _00761_ VDD VSS NAND2_X1
X_17133_ _00741_ _00760_ _00761_ _00292_ VDD VSS AOI21_X1
X_17134_ _00757_ samples_real\[4\]\[15\] _00762_ VDD VSS NAND2_X1
X_17135_ _00755_ net347 _00763_ VDD VSS NAND2_X1
X_17136_ _00741_ _00762_ _00763_ _00293_ VDD VSS AOI21_X1
X_17137_ _00843_ _00764_ VDD VSS CLKBUF_X3
X_17138_ _00757_ samples_real\[0\]\[7\] _00765_ VDD VSS NAND2_X1
X_17139_ _00755_ net348 _00766_ VDD VSS NAND2_X1
X_17140_ _00764_ _00765_ _00766_ _00294_ VDD VSS AOI21_X1
X_17141_ _00757_ samples_real\[5\]\[0\] _00767_ VDD VSS NAND2_X1
X_17142_ _00755_ net349 _00768_ VDD VSS NAND2_X1
X_17143_ _00764_ _00767_ _00768_ _00295_ VDD VSS AOI21_X1
X_17144_ _00757_ samples_real\[5\]\[1\] _00769_ VDD VSS NAND2_X1
X_17145_ _00755_ net350 _00770_ VDD VSS NAND2_X1
X_17146_ _00764_ _00769_ _00770_ _00296_ VDD VSS AOI21_X1
X_17147_ _00757_ samples_real\[5\]\[2\] _00771_ VDD VSS NAND2_X1
X_17148_ _00755_ net351 _00772_ VDD VSS NAND2_X1
X_17149_ _00764_ _00771_ _00772_ _00297_ VDD VSS AOI21_X1
X_17150_ _00757_ samples_real\[5\]\[3\] _00773_ VDD VSS NAND2_X1
X_17151_ _00755_ net352 _00774_ VDD VSS NAND2_X1
X_17152_ _00764_ _00773_ _00774_ _00298_ VDD VSS AOI21_X1
X_17153_ _00757_ samples_real\[5\]\[4\] _00775_ VDD VSS NAND2_X1
X_17154_ _00755_ net353 _00776_ VDD VSS NAND2_X1
X_17155_ _00764_ _00775_ _00776_ _00299_ VDD VSS AOI21_X1
X_17156_ _00757_ samples_real\[5\]\[5\] _00777_ VDD VSS NAND2_X1
X_17157_ _00858_ _00778_ VDD VSS CLKBUF_X3
X_17158_ _00778_ net354 _00779_ VDD VSS NAND2_X1
X_17159_ _00764_ _00777_ _00779_ _00300_ VDD VSS AOI21_X1
X_17160_ _00857_ _00780_ VDD VSS CLKBUF_X3
X_17161_ _00780_ samples_real\[5\]\[6\] _00781_ VDD VSS NAND2_X1
X_17162_ _00778_ net355 _00782_ VDD VSS NAND2_X1
X_17163_ _00764_ _00781_ _00782_ _00301_ VDD VSS AOI21_X1
X_17164_ _00780_ samples_real\[5\]\[7\] _00783_ VDD VSS NAND2_X1
X_17165_ _00778_ net356 _00784_ VDD VSS NAND2_X1
X_17166_ _00764_ _00783_ _00784_ _00302_ VDD VSS AOI21_X1
X_17167_ _00780_ samples_real\[5\]\[8\] _00785_ VDD VSS NAND2_X1
X_17168_ _00778_ net357 _00786_ VDD VSS NAND2_X1
X_17169_ _00764_ _00785_ _00786_ _00303_ VDD VSS AOI21_X1
X_17170_ _00843_ _00787_ VDD VSS BUF_X4
X_17171_ _00780_ samples_real\[5\]\[9\] _00788_ VDD VSS NAND2_X1
X_17172_ _00778_ net358 _00789_ VDD VSS NAND2_X1
X_17173_ _00787_ _00788_ _00789_ _00304_ VDD VSS AOI21_X1
X_17174_ _00780_ samples_real\[0\]\[8\] _00790_ VDD VSS NAND2_X1
X_17175_ _00778_ net359 _00791_ VDD VSS NAND2_X1
X_17176_ _00787_ _00790_ _00791_ _00305_ VDD VSS AOI21_X1
X_17177_ _00780_ samples_real\[5\]\[10\] _00792_ VDD VSS NAND2_X1
X_17178_ _00778_ net360 _00793_ VDD VSS NAND2_X1
X_17179_ _00787_ _00792_ _00793_ _00306_ VDD VSS AOI21_X1
X_17180_ _00780_ samples_real\[5\]\[11\] _00794_ VDD VSS NAND2_X1
X_17181_ _00778_ net361 _00795_ VDD VSS NAND2_X1
X_17182_ _00787_ _00794_ _00795_ _00307_ VDD VSS AOI21_X1
X_17183_ _00780_ samples_real\[5\]\[12\] _00796_ VDD VSS NAND2_X1
X_17184_ _00778_ net362 _00797_ VDD VSS NAND2_X1
X_17185_ _00787_ _00796_ _00797_ _00308_ VDD VSS AOI21_X1
X_17186_ _00780_ samples_real\[5\]\[13\] _00798_ VDD VSS NAND2_X1
X_17187_ _00778_ net363 _00799_ VDD VSS NAND2_X1
X_17188_ _00787_ _00798_ _00799_ _00309_ VDD VSS AOI21_X1
X_17189_ _00780_ samples_real\[5\]\[14\] _00800_ VDD VSS NAND2_X1
X_17190_ _06469_ net364 _00801_ VDD VSS NAND2_X1
X_17191_ _00787_ _00800_ _00801_ _00310_ VDD VSS AOI21_X1
X_17192_ _06447_ samples_real\[5\]\[15\] _00802_ VDD VSS NAND2_X1
X_17193_ _06469_ net365 _00803_ VDD VSS NAND2_X1
X_17194_ _00787_ _00802_ _00803_ _00311_ VDD VSS AOI21_X1
X_17195_ _06447_ samples_real\[6\]\[0\] _00804_ VDD VSS NAND2_X1
X_17196_ _06469_ net366 _00805_ VDD VSS NAND2_X1
X_17197_ _00787_ _00804_ _00805_ _00312_ VDD VSS AOI21_X1
X_17198_ _06447_ samples_real\[6\]\[1\] _00806_ VDD VSS NAND2_X1
X_17199_ _06469_ net367 _00807_ VDD VSS NAND2_X1
X_17200_ _00787_ _00806_ _00807_ _00313_ VDD VSS AOI21_X1
X_17201_ _06447_ samples_real\[6\]\[2\] _00808_ VDD VSS NAND2_X1
X_17202_ _06469_ net368 _00809_ VDD VSS NAND2_X1
X_17203_ _00844_ _00808_ _00809_ _00314_ VDD VSS AOI21_X1
X_17204_ _06447_ samples_real\[6\]\[3\] _00810_ VDD VSS NAND2_X1
X_17205_ _06469_ net369 _00811_ VDD VSS NAND2_X1
X_17206_ _00844_ _00810_ _00811_ _00315_ VDD VSS AOI21_X1
X_17207_ _06447_ samples_real\[0\]\[9\] _00812_ VDD VSS NAND2_X1
X_17208_ _06469_ net370 _00813_ VDD VSS NAND2_X1
X_17209_ _00844_ _00812_ _00813_ _00316_ VDD VSS AOI21_X1
X_17210_ _00862_ _06437_ _00814_ VDD VSS NAND2_X1
X_17211_ _05300_ _00814_ _00815_ VDD VSS NOR2_X1
X_17212_ _00815_ _09382_ _04771_ _00816_ VDD VSS OAI21_X1
X_17213_ net371 _00816_ _00817_ VDD VSS NAND2_X1
X_17214_ _00844_ _00815_ _00020_ _00818_ VDD VSS AOI21_X1
X_17215_ _00817_ _00818_ _00317_ VDD VSS NAND2_X1
X_17216_ _00856_ _06447_ net372 _00819_ VDD VSS OAI21_X1
X_17217_ net87 _06469_ _00820_ VDD VSS NAND2_X1
X_17218_ _00820_ net372 net87 _00821_ VDD VSS OAI21_X1
X_17219_ _00819_ _00821_ _00860_ _00318_ VDD VSS AOI21_X1
X_17220_ _00814_ _05352_ _00020_ _00822_ VDD VSS AOI21_X1
X_17221_ _00852_ _00822_ _00823_ VDD VSS NAND2_X2
X_17222_ _04770_ _00853_ _00824_ VDD VSS NAND2_X1
X_17223_ sample_count\[0\] _00823_ _00824_ _00825_ VDD VSS
+ OR3_X1
X_17224_ sample_count\[0\] _00823_ _00826_ VDD VSS NAND2_X1
X_17225_ _00844_ _00825_ _00826_ _00322_ VDD VSS AOI21_X1
X_17226_ _04770_ _00853_ _09379_ _00827_ VDD VSS NAND3_X1
X_17227_ _00823_ _00827_ _00828_ VDD VSS NOR2_X1
X_17228_ _00828_ _00823_ sample_count\[1\] _00829_ VDD VSS
+ AOI21_X1
X_17229_ _00845_ _00829_ _00323_ VDD VSS NOR2_X1
X_17230_ _00853_ _09383_ _00830_ VDD VSS NAND2_X1
X_17231_ _00830_ _05350_ _00823_ _00831_ VDD VSS MUX2_X1
X_17232_ _00845_ _00831_ _00324_ VDD VSS NOR2_X1
X_17233_ _00851_ _04776_ _00832_ VDD VSS NAND2_X1
X_17234_ _04798_ _00846_ _06440_ _00832_ _00833_ VDD VSS NAND4_X1
X_17235_ _06440_ _00832_ _00834_ VDD VSS NAND2_X1
X_17236_ _00849_ _00834_ _00835_ VDD VSS NAND2_X1
X_17237_ _00844_ _00833_ _00835_ _00581_ VDD VSS AOI21_X1
X_17238_ _00850_ _00834_ _00836_ VDD VSS NAND2_X1
X_17239_ _00846_ _09364_ _00837_ VDD VSS NAND2_X1
X_17240_ _00836_ _00837_ _00834_ _00838_ VDD VSS OAI21_X1
X_17241_ _00856_ _00838_ _00582_ VDD VSS AND2_X1
X_17242_ _00848_ _00834_ _00839_ VDD VSS NAND2_X1
X_17243_ _04775_ _09343_ _00834_ _00840_ VDD VSS OR3_X1
X_17244_ _00844_ _00839_ _00840_ _00583_ VDD VSS AOI21_X1
X_17245_ _07347_ _07348_ _07349_ _07350_ _07351_ VDD VSS FA_X1
X_17246_ temp_imag\[0\] _07348_ _07352_ _07353_ _07354_ VDD
+ VSS FA_X1
X_17247_ _07355_ _07356_ _07357_ _07358_ _07359_ VDD VSS FA_X1
X_17248_ temp_real\[0\] _07356_ _07360_ _07361_ _07362_ VDD
+ VSS FA_X1
X_17249_ _07363_ _00043_ _07364_ _07365_ _07366_ VDD VSS FA_X1
X_17250_ _07367_ _07368_ _07369_ _07370_ _07371_ VDD VSS FA_X1
X_17251_ _07372_ _07373_ _07374_ _07375_ _07376_ VDD VSS FA_X1
X_17252_ _07377_ _07373_ _07378_ _07379_ _07380_ VDD VSS FA_X1
X_17253_ _07381_ _07383_ _07382_ _07384_ _07385_ VDD VSS FA_X1
X_17254_ _07386_ _07388_ _07387_ _07389_ _07390_ VDD VSS FA_X1
X_17255_ _07391_ _07392_ _07393_ _07394_ _07395_ VDD VSS FA_X1
X_17256_ _07396_ _07397_ _07398_ _07399_ _07400_ VDD VSS FA_X1
X_17257_ _07392_ _07393_ _07401_ _07402_ _07403_ VDD VSS FA_X1
X_17258_ _07404_ _07405_ _07406_ _07407_ _07408_ VDD VSS FA_X1
X_17259_ _07409_ _07410_ _07411_ _07412_ _07413_ VDD VSS FA_X1
X_17260_ _07414_ _07413_ _07415_ _07416_ _07417_ VDD VSS FA_X1
X_17261_ _07418_ _07419_ _07403_ _07420_ _07421_ VDD VSS FA_X1
X_17262_ _07422_ _07423_ _07397_ _07424_ _07425_ VDD VSS FA_X1
X_17263_ _07426_ _07427_ _07428_ _07429_ _07430_ VDD VSS FA_X1
X_17264_ _07394_ _07431_ _07432_ _07433_ _07434_ VDD VSS FA_X1
X_17265_ _07430_ _07436_ _07435_ _07437_ _07438_ VDD VSS FA_X1
X_17266_ _07439_ _07440_ _07417_ _07441_ _07442_ VDD VSS FA_X1
X_17267_ _07443_ _07374_ _07381_ _07415_ _07444_ VDD VSS FA_X1
X_17268_ _07445_ _07446_ _07395_ _07447_ _07448_ VDD VSS FA_X1
X_17269_ _07382_ _07383_ _07449_ _07446_ _07450_ VDD VSS FA_X1
X_17270_ _07397_ _07398_ _07451_ _07452_ _07453_ VDD VSS FA_X1
X_17271_ _07454_ _07448_ _07455_ _07456_ _07457_ VDD VSS FA_X1
X_17272_ _07434_ _07458_ _07459_ _07460_ _07461_ VDD VSS FA_X1
X_17273_ _07462_ _07463_ _07464_ _07458_ _07465_ VDD VSS FA_X1
X_17274_ _07466_ _07467_ _07468_ _07469_ _07470_ VDD VSS FA_X1
X_17275_ _07471_ _07472_ _07473_ _07474_ _07475_ VDD VSS FA_X1
X_17276_ _07476_ _07477_ _07478_ _07479_ _07480_ VDD VSS FA_X1
X_17277_ _07481_ _07475_ _07482_ _07483_ _07484_ VDD VSS FA_X1
X_17278_ _07472_ _07485_ _07473_ _07482_ _07486_ VDD VSS FA_X1
X_17279_ _07470_ _07487_ _07438_ _07488_ _07489_ VDD VSS FA_X1
X_17280_ _07490_ _07491_ _07492_ _07487_ _07493_ VDD VSS FA_X1
X_17281_ _07494_ _07495_ _07496_ _07491_ _07497_ VDD VSS FA_X1
X_17282_ _07498_ _07499_ _07500_ _07501_ _07502_ VDD VSS FA_X1
X_17283_ _07450_ _07503_ _07453_ _07455_ _07504_ VDD VSS FA_X1
X_17284_ _07409_ _07410_ _07383_ _07503_ _07505_ VDD VSS FA_X1
X_17285_ _07423_ _07397_ _07398_ _07506_ _07507_ VDD VSS FA_X1
X_17286_ _07508_ _07504_ _07509_ _07510_ _07511_ VDD VSS FA_X1
X_17287_ _07465_ _07512_ _07513_ _07514_ _07515_ VDD VSS FA_X1
X_17288_ _07516_ _07517_ _07518_ _07512_ _07519_ VDD VSS FA_X1
X_17289_ _07520_ _07521_ _07522_ _07523_ _07524_ VDD VSS FA_X1
X_17290_ _07480_ _07525_ _07526_ _07527_ _07528_ VDD VSS FA_X1
X_17291_ _07529_ _07486_ _07530_ _07531_ _07532_ VDD VSS FA_X1
X_17292_ _07533_ _07485_ _07473_ _07530_ _07534_ VDD VSS FA_X1
X_17293_ _07523_ _07528_ _07535_ _07536_ _07537_ VDD VSS FA_X1
X_17294_ _07537_ _07538_ _07489_ _07539_ _07540_ VDD VSS FA_X1
X_17295_ _07493_ _07541_ _07524_ _07538_ _07542_ VDD VSS FA_X1
X_17296_ _07543_ _07544_ _07511_ _07545_ _07546_ VDD VSS FA_X1
X_17297_ _07377_ _07443_ _07378_ _07547_ _07548_ VDD VSS FA_X1
X_17298_ _07505_ _07549_ _07507_ _07509_ _07550_ VDD VSS FA_X1
X_17299_ _07374_ _07410_ _07381_ _07549_ _07551_ VDD VSS FA_X1
X_17300_ _07383_ _07449_ _07552_ _07553_ _07554_ VDD VSS FA_X1
X_17301_ _07555_ _07550_ _07556_ _07557_ _07558_ VDD VSS FA_X1
X_17302_ _07559_ _07519_ _07560_ _07561_ _07562_ VDD VSS FA_X1
X_17303_ _07553_ _07563_ _07564_ _07560_ _07565_ VDD VSS FA_X1
X_17304_ _07566_ _07567_ _07568_ _07569_ _07570_ VDD VSS FA_X1
X_17305_ _07571_ _07572_ _07573_ _07535_ _07574_ VDD VSS FA_X1
X_17306_ _07472_ _07534_ _07575_ _07576_ _07577_ VDD VSS FA_X1
X_17307_ _07533_ _07485_ _07578_ _07575_ _07579_ VDD VSS FA_X1
X_17308_ _07569_ _07574_ _07580_ _07581_ _07582_ VDD VSS FA_X1
X_17309_ _07584_ _07583_ _07585_ _07586_ _07587_ VDD VSS FA_X1
X_17310_ _07542_ _07589_ _07582_ _07588_ _07590_ VDD VSS FA_X1
X_17311_ _07591_ _07592_ _07570_ _07589_ _07593_ VDD VSS FA_X1
X_17312_ _07594_ _07595_ _07558_ _07596_ _07597_ VDD VSS FA_X1
X_17313_ _07551_ _07598_ _07554_ _07556_ _07599_ VDD VSS FA_X1
X_17314_ _07373_ _07381_ _07411_ _07598_ _07600_ VDD VSS FA_X1
X_17315_ _07410_ _07383_ _07449_ _07601_ _07602_ VDD VSS FA_X1
X_17316_ _07603_ _07565_ _07604_ _07605_ _07606_ VDD VSS FA_X1
X_17317_ _07601_ _07607_ _07608_ _07604_ _07609_ VDD VSS FA_X1
X_17318_ _07610_ _07606_ _07611_ _07612_ _07613_ VDD VSS FA_X1
X_17319_ _07614_ _07615_ _07616_ _07580_ _07617_ VDD VSS FA_X1
X_17320_ _07473_ _07579_ _07618_ _07619_ _07620_ VDD VSS FA_X1
X_17321_ _07621_ _07533_ _07578_ _07618_ _07622_ VDD VSS FA_X1
X_17322_ _07623_ _07617_ _07624_ _07625_ _07626_ VDD VSS FA_X1
X_17323_ _07628_ _07627_ _07587_ _07629_ _07630_ VDD VSS FA_X1
X_17324_ _07631_ _07632_ _07633_ _07627_ _07634_ VDD VSS FA_X1
X_17325_ _07593_ _07636_ _07626_ _07635_ _07637_ VDD VSS FA_X1
X_17326_ _07638_ _07639_ _07640_ _07636_ _07641_ VDD VSS FA_X1
X_17327_ _07642_ _07643_ _07644_ _07645_ _07646_ VDD VSS FA_X1
X_17328_ _07600_ _07647_ _07602_ _07648_ _07649_ VDD VSS FA_X1
X_17329_ _07377_ _07443_ _07411_ _07647_ _07650_ VDD VSS FA_X1
X_17330_ _07410_ _07381_ _07383_ _07651_ _07652_ VDD VSS FA_X1
X_17331_ _07653_ _07609_ _07654_ _07611_ _07655_ VDD VSS FA_X1
X_17332_ _07651_ _07656_ _07657_ _07654_ _07658_ VDD VSS FA_X1
X_17333_ _07659_ _07660_ _07661_ _07662_ _07663_ VDD VSS FA_X1
X_17334_ _07664_ _07665_ _07666_ _07624_ _07667_ VDD VSS FA_X1
X_17335_ _07485_ _07622_ _07668_ _07669_ _07670_ VDD VSS FA_X1
X_17336_ _07671_ _07621_ _07578_ _07668_ _07672_ VDD VSS FA_X1
X_17337_ _07673_ _07674_ _07675_ _07676_ _07677_ VDD VSS FA_X1
X_17338_ _07634_ _07678_ _07679_ _07680_ _07681_ VDD VSS FA_X1
X_17339_ _07682_ _07683_ _07684_ _07678_ _07685_ VDD VSS FA_X1
X_17340_ _07641_ _07687_ _07688_ _07686_ _07689_ VDD VSS FA_X1
X_17341_ _07690_ _07691_ _07663_ _07687_ _07692_ VDD VSS FA_X1
X_17342_ _07693_ _07694_ _07695_ _07691_ _07696_ VDD VSS FA_X1
X_17343_ _07650_ _07697_ _07652_ _07698_ _07699_ VDD VSS FA_X1
X_17344_ _07701_ _07702_ _07498_ _07700_ _07703_ VDD VSS FA_X1
X_17345_ _07410_ _07381_ _07411_ _07704_ _07705_ VDD VSS FA_X1
X_17346_ _07704_ _07706_ _07707_ _07708_ _07709_ VDD VSS FA_X1
X_17347_ _07710_ _07711_ _07712_ _07713_ _07714_ VDD VSS FA_X1
X_17348_ _07533_ _07672_ _07715_ _07716_ _07717_ VDD VSS FA_X1
X_17349_ _07671_ _07718_ _07621_ _07715_ _07719_ VDD VSS FA_X1
X_17350_ _07720_ _07721_ _07722_ _07723_ _07724_ VDD VSS FA_X1
X_17351_ _07685_ _07725_ _07726_ _07727_ _07728_ VDD VSS FA_X1
X_17352_ _07729_ _07730_ _07731_ _07725_ _07732_ VDD VSS FA_X1
X_17353_ _07692_ _07734_ _07735_ _07733_ _07736_ VDD VSS FA_X1
X_17354_ _07737_ _07738_ _07739_ _07740_ _07741_ VDD VSS FA_X1
X_17355_ _07703_ _07742_ _07743_ _07744_ _07745_ VDD VSS FA_X1
X_17356_ _07443_ _07381_ _07411_ _07747_ _07748_ VDD VSS FA_X1
X_17357_ _07747_ _07749_ _07750_ _07751_ _07752_ VDD VSS FA_X1
X_17358_ _07753_ _07754_ _07755_ _07756_ _07757_ VDD VSS FA_X1
X_17359_ _07578_ _07719_ _07758_ _07759_ _07760_ VDD VSS FA_X1
X_17360_ _07559_ _07671_ _07718_ _07758_ _07761_ VDD VSS FA_X1
X_17361_ _07762_ _07763_ _07764_ _07765_ _07766_ VDD VSS FA_X1
X_17362_ _07732_ _07767_ _07768_ _07769_ _07770_ VDD VSS FA_X1
X_17363_ _07771_ _07772_ _07773_ _07767_ _07774_ VDD VSS FA_X1
X_17364_ _07776_ _07777_ _07778_ _07775_ _07779_ VDD VSS FA_X1
X_17365_ _07780_ _07781_ _07782_ _07783_ _07784_ VDD VSS FA_X1
X_17366_ _07702_ _07498_ _07500_ _07785_ _07786_ VDD VSS FA_X1
X_17367_ _07787_ _07788_ _07789_ _07790_ _07791_ VDD VSS FA_X1
X_17368_ _07792_ _07793_ _07794_ _07795_ _07796_ VDD VSS FA_X1
X_17369_ _07621_ _07761_ _07797_ _07798_ _07799_ VDD VSS FA_X1
X_17370_ _07559_ _07603_ _07718_ _07797_ _07800_ VDD VSS FA_X1
X_17371_ _07801_ _07802_ _07803_ _07804_ _07805_ VDD VSS FA_X1
X_17372_ _07774_ _07806_ _07807_ _07808_ _07809_ VDD VSS FA_X1
X_17373_ _07810_ _07811_ _07812_ _07806_ _07813_ VDD VSS FA_X1
X_17374_ _07815_ _07816_ _07817_ _07814_ _07818_ VDD VSS FA_X1
X_17375_ _07819_ _07820_ _07821_ _07822_ _07823_ VDD VSS FA_X1
X_17376_ _07824_ _07825_ _07826_ _07827_ _07828_ VDD VSS FA_X1
X_17377_ _07671_ _07800_ _07829_ _07830_ _07831_ VDD VSS FA_X1
X_17378_ _07559_ _07603_ _07653_ _07829_ _07832_ VDD VSS FA_X1
X_17379_ _07833_ _07834_ _07835_ _07836_ _07837_ VDD VSS FA_X1
X_17380_ _07813_ _07838_ _07839_ _07840_ _07841_ VDD VSS FA_X1
X_17381_ _07842_ _07843_ _07844_ _07838_ _07845_ VDD VSS FA_X1
X_17382_ _07823_ _07846_ _07847_ _07843_ _07848_ VDD VSS FA_X1
X_17383_ _07849_ _07850_ _07851_ _07846_ _07852_ VDD VSS FA_X1
X_17384_ _07702_ _07498_ _07853_ _07854_ _07855_ VDD VSS FA_X1
X_17385_ _07742_ _07856_ _07857_ _07858_ _07859_ VDD VSS FA_X1
X_17386_ _07845_ _07860_ _07861_ _07862_ _07863_ VDD VSS FA_X1
X_17387_ _07848_ _07864_ _07865_ _07860_ _07866_ VDD VSS FA_X1
X_17388_ _07852_ _07867_ _07868_ _07864_ _07869_ VDD VSS FA_X1
X_17389_ _07870_ _07871_ _07872_ _07867_ _07873_ VDD VSS FA_X1
X_17390_ _07718_ _07874_ _07832_ _07875_ _07876_ VDD VSS FA_X1
X_17391_ _07877_ _07878_ _07879_ _07880_ _07881_ VDD VSS FA_X1
X_17392_ _07866_ _07882_ _07883_ _07884_ _07885_ VDD VSS FA_X1
X_17393_ _07869_ _07886_ _07887_ _07882_ _07888_ VDD VSS FA_X1
X_17394_ _07873_ _07889_ _07890_ _07886_ _07891_ VDD VSS FA_X1
X_17395_ _07892_ _07893_ _07894_ _07889_ _07895_ VDD VSS FA_X1
X_17396_ _07896_ _07891_ _07897_ _07898_ _07899_ VDD VSS FA_X1
X_17397_ _07895_ _07900_ _07901_ _07897_ _07902_ VDD VSS FA_X1
X_17398_ _07904_ _07905_ _07906_ _07903_ _07907_ VDD VSS FA_X1
X_17399_ _07907_ _07908_ _07909_ _07910_ _07911_ VDD VSS FA_X1
X_17400_ _07914_ _07915_ _07916_ _07917_ _07918_ VDD VSS FA_X1
X_17401_ _07919_ _07920_ _07921_ _07922_ _07923_ VDD VSS FA_X1
X_17402_ _07918_ _07924_ _07925_ _07926_ _07927_ VDD VSS FA_X1
X_17403_ _07928_ _07929_ _07930_ _07931_ _07932_ VDD VSS FA_X1
X_17404_ _07934_ _07935_ _07936_ _07937_ _07938_ VDD VSS FA_X1
X_17405_ _07939_ _07940_ _07941_ _07942_ _07943_ VDD VSS FA_X1
X_17406_ _07923_ _07944_ _07945_ _07946_ _07947_ VDD VSS FA_X1
X_17407_ _07948_ _07949_ _07950_ _07951_ _07952_ VDD VSS FA_X1
X_17408_ _07953_ _07928_ _07929_ _07954_ _07955_ VDD VSS FA_X1
X_17409_ _07957_ _07958_ _07959_ _07960_ _07961_ VDD VSS FA_X1
X_17410_ _07962_ _07963_ _07964_ _07965_ _07966_ VDD VSS FA_X1
X_17411_ _07940_ _07967_ _07968_ _07969_ _07970_ VDD VSS FA_X1
X_17412_ _07971_ _07973_ _07972_ _07974_ _07975_ VDD VSS FA_X1
X_17413_ _07976_ _07978_ _07977_ _07979_ _07980_ VDD VSS FA_X1
X_17414_ _07969_ _07980_ _07981_ _07982_ _07983_ VDD VSS FA_X1
X_17415_ _07984_ _07985_ _07986_ _07987_ _07988_ VDD VSS FA_X1
X_17416_ _07989_ _07990_ _07991_ _07992_ _07993_ VDD VSS FA_X1
X_17417_ _07994_ _07995_ _07996_ _07997_ _07998_ VDD VSS FA_X1
X_17418_ _07999_ _08000_ _08001_ _08002_ _08003_ VDD VSS FA_X1
X_17419_ _08004_ _08005_ _08006_ _08007_ _08008_ VDD VSS FA_X1
X_17420_ _08009_ _07988_ _08010_ _08011_ _08012_ VDD VSS FA_X1
X_17421_ _08014_ _08013_ _07993_ _08015_ _08016_ VDD VSS FA_X1
X_17422_ _07990_ _08017_ _07991_ _08013_ _08018_ VDD VSS FA_X1
X_17423_ _08019_ _08020_ _08021_ _08022_ _08023_ VDD VSS FA_X1
X_17424_ _08025_ _08024_ _08016_ _08026_ _08027_ VDD VSS FA_X1
X_17425_ _07947_ _07975_ _08028_ _08029_ _08030_ VDD VSS FA_X1
X_17426_ _08031_ _08032_ _08033_ _08028_ _08034_ VDD VSS FA_X1
X_17427_ _08035_ _08036_ _08037_ _08038_ _08039_ VDD VSS FA_X1
X_17428_ _07953_ _08040_ _07928_ _08041_ _08042_ VDD VSS FA_X1
X_17429_ _08044_ _08045_ _08046_ _08047_ _08048_ VDD VSS FA_X1
X_17430_ _08049_ _08050_ _08051_ _08052_ _08053_ VDD VSS FA_X1
X_17431_ _07967_ _08054_ _08055_ _08009_ _08056_ VDD VSS FA_X1
X_17432_ _08057_ _08048_ _08058_ _08059_ _08060_ VDD VSS FA_X1
X_17433_ _08027_ _08062_ _08003_ _08063_ _08064_ VDD VSS FA_X1
X_17434_ _07984_ _08065_ _08066_ _08067_ _08068_ VDD VSS FA_X1
X_17435_ _08069_ _08008_ _08070_ _08071_ _08072_ VDD VSS FA_X1
X_17436_ _08018_ _08073_ _08074_ _08024_ _08075_ VDD VSS FA_X1
X_17437_ _08017_ _07977_ _07991_ _08073_ _08076_ VDD VSS FA_X1
X_17438_ _08077_ _08078_ _08079_ _08080_ _08081_ VDD VSS FA_X1
X_17439_ _08075_ _08082_ _08083_ _08084_ _08085_ VDD VSS FA_X1
X_17440_ _08086_ _08087_ _08064_ _08088_ _08089_ VDD VSS FA_X1
X_17441_ _08091_ _08090_ _08030_ _08092_ _08093_ VDD VSS FA_X1
X_17442_ _08034_ _08094_ _08060_ _08090_ _08095_ VDD VSS FA_X1
X_17443_ _08096_ _08097_ _08098_ _08094_ _08099_ VDD VSS FA_X1
X_17444_ _08100_ _08101_ _08102_ _08103_ _08104_ VDD VSS FA_X1
X_17445_ _08105_ _08040_ _07953_ _08106_ _08107_ VDD VSS FA_X1
X_17446_ _08109_ _08110_ _08056_ _08058_ _08111_ VDD VSS FA_X1
X_17447_ _08112_ _08113_ _08114_ _08115_ _08116_ VDD VSS FA_X1
X_17448_ _08117_ _08118_ _08119_ _08120_ _08121_ VDD VSS FA_X1
X_17449_ _08123_ _08124_ _08085_ _08087_ _08125_ VDD VSS FA_X1
X_17450_ _08126_ _08127_ _08004_ _08128_ _08129_ VDD VSS FA_X1
X_17451_ _08076_ _08130_ _08131_ _08082_ _08132_ VDD VSS FA_X1
X_17452_ _08133_ _08017_ _07977_ _08130_ _08134_ VDD VSS FA_X1
X_17453_ _08135_ _08136_ _08137_ _08138_ _08139_ VDD VSS FA_X1
X_17454_ _08140_ _08132_ _08141_ _08142_ _08143_ VDD VSS FA_X1
X_17455_ _08144_ _08145_ _08146_ _08147_ _08148_ VDD VSS FA_X1
X_17456_ _08150_ _08149_ _08151_ _08152_ _08153_ VDD VSS FA_X1
X_17457_ _08095_ _08155_ _08148_ _08154_ _08156_ VDD VSS FA_X1
X_17458_ _08099_ _08157_ _08121_ _08155_ _08158_ VDD VSS FA_X1
X_17459_ _08159_ _08160_ _08161_ _08157_ _08162_ VDD VSS FA_X1
X_17460_ _08163_ _08164_ _08165_ _08166_ _08167_ VDD VSS FA_X1
X_17461_ _08105_ _08168_ _08040_ _08169_ _08170_ VDD VSS FA_X1
X_17462_ _08171_ _08172_ _08173_ _08122_ _08174_ VDD VSS FA_X1
X_17463_ _08176_ _08177_ _08178_ _08175_ _08179_ VDD VSS FA_X1
X_17464_ _08180_ _08181_ _08182_ _08183_ _08184_ VDD VSS FA_X1
X_17465_ _08186_ _08187_ _08143_ _08188_ _08189_ VDD VSS FA_X1
X_17466_ _08190_ _08191_ _08065_ _08192_ _08193_ VDD VSS FA_X1
X_17467_ _08134_ _08194_ _08195_ _08141_ _08196_ VDD VSS FA_X1
X_17468_ _07941_ _08133_ _07977_ _08194_ _08197_ VDD VSS FA_X1
X_17469_ _08198_ _08199_ _08200_ _08201_ _08202_ VDD VSS FA_X1
X_17470_ _08196_ _08203_ _08204_ _08205_ _08206_ VDD VSS FA_X1
X_17471_ _08207_ _08208_ _08209_ _08210_ _08211_ VDD VSS FA_X1
X_17472_ _08213_ _08212_ _08153_ _08214_ _08215_ VDD VSS FA_X1
X_17473_ _08216_ _08217_ _08218_ _08212_ _08219_ VDD VSS FA_X1
X_17474_ _08158_ _08221_ _08211_ _08220_ _08222_ VDD VSS FA_X1
X_17475_ _08162_ _08223_ _08184_ _08221_ _08224_ VDD VSS FA_X1
X_17476_ _08225_ _08226_ _08227_ _08228_ _08229_ VDD VSS FA_X1
X_17477_ _08168_ _08230_ _08105_ _08231_ _08232_ VDD VSS FA_X1
X_17478_ _08234_ _08235_ _08236_ _08185_ _08237_ VDD VSS FA_X1
X_17479_ _08238_ _08239_ _08240_ _08241_ _08242_ VDD VSS FA_X1
X_17480_ _08243_ _08237_ _08244_ _08245_ _08246_ VDD VSS FA_X1
X_17481_ _08248_ _08249_ _08206_ _08250_ _08251_ VDD VSS FA_X1
X_17482_ _08197_ _08252_ _08253_ _08203_ _08254_ VDD VSS FA_X1
X_17483_ _07941_ _07968_ _08133_ _08252_ _08255_ VDD VSS FA_X1
X_17484_ _08256_ _08257_ _08258_ _08259_ _08260_ VDD VSS FA_X1
X_17485_ _08261_ _08262_ _08259_ _08263_ _08264_ VDD VSS FA_X1
X_17486_ _08245_ _08265_ _08266_ _08267_ _08268_ VDD VSS FA_X1
X_17487_ _08219_ _08269_ _08270_ _08271_ _08272_ VDD VSS FA_X1
X_17488_ _08273_ _08274_ _08275_ _08269_ _08276_ VDD VSS FA_X1
X_17489_ _08224_ _08278_ _08279_ _08277_ _08280_ VDD VSS FA_X1
X_17490_ _08281_ _08282_ _08283_ _08278_ _08284_ VDD VSS FA_X1
X_17491_ _08285_ _07921_ _08233_ _08286_ _08287_ VDD VSS FA_X1
X_17492_ _08288_ _08286_ _08289_ _08290_ _08291_ VDD VSS FA_X1
X_17493_ _08292_ _08293_ _08294_ _08295_ _08296_ VDD VSS FA_X1
X_17494_ _08255_ _08298_ _08299_ _08300_ _08301_ VDD VSS FA_X1
X_17495_ _08055_ _07941_ _07968_ _08298_ _08302_ VDD VSS FA_X1
X_17496_ _08303_ _08304_ _08305_ _08306_ _08307_ VDD VSS FA_X1
X_17497_ _08308_ _08309_ _08306_ _08310_ _08311_ VDD VSS FA_X1
X_17498_ _08295_ _08312_ _08313_ _08314_ _08315_ VDD VSS FA_X1
X_17499_ _08276_ _08316_ _08317_ _08318_ _08319_ VDD VSS FA_X1
X_17500_ _08320_ _08321_ _08322_ _08316_ _08323_ VDD VSS FA_X1
X_17501_ _08284_ _08325_ _08326_ _08324_ _08327_ VDD VSS FA_X1
X_17502_ _08328_ _08329_ _08330_ _08325_ _08331_ VDD VSS FA_X1
X_17503_ _08332_ _08333_ _08230_ _08334_ _08335_ VDD VSS FA_X1
X_17504_ _08337_ _08338_ _08339_ _08340_ _08341_ VDD VSS FA_X1
X_17505_ _08342_ _08343_ _08344_ _08345_ _08346_ VDD VSS FA_X1
X_17506_ _08302_ _08348_ _08349_ _08350_ _08351_ VDD VSS FA_X1
X_17507_ _08352_ _08055_ _07968_ _08348_ _08353_ VDD VSS FA_X1
X_17508_ _08133_ _08354_ _08355_ _08356_ _08357_ VDD VSS FA_X1
X_17509_ _08358_ _08359_ _08360_ _08361_ _08362_ VDD VSS FA_X1
X_17510_ _08345_ _08363_ _08364_ _08365_ _08366_ VDD VSS FA_X1
X_17511_ _08323_ _08367_ _08368_ _08369_ _08370_ VDD VSS FA_X1
X_17512_ _08371_ _08372_ _08373_ _08367_ _08374_ VDD VSS FA_X1
X_17513_ _08331_ _08376_ _08377_ _08375_ _08378_ VDD VSS FA_X1
X_17514_ _08379_ _08380_ _08381_ _08376_ _08382_ VDD VSS FA_X1
X_17515_ _08383_ _08384_ _08385_ _08386_ _08387_ VDD VSS FA_X1
X_17516_ _08353_ _08389_ _08390_ _08391_ _08392_ VDD VSS FA_X1
X_17517_ _08352_ _08055_ _08234_ _08389_ _08393_ VDD VSS FA_X1
X_17518_ _08005_ _08394_ _08395_ _08396_ _08397_ VDD VSS FA_X1
X_17519_ _08398_ _08399_ _08396_ _08400_ _08401_ VDD VSS FA_X1
X_17520_ _08402_ _08403_ _08404_ _08405_ _08406_ VDD VSS FA_X1
X_17521_ _08374_ _08408_ _08409_ _08410_ _08411_ VDD VSS FA_X1
X_17522_ _08412_ _08413_ _08414_ _08408_ _08415_ VDD VSS FA_X1
X_17523_ _08382_ _08417_ _08418_ _08416_ _08419_ VDD VSS FA_X1
X_17524_ _08420_ _08421_ _08422_ _08417_ _08423_ VDD VSS FA_X1
X_17525_ _08333_ _08424_ _08332_ _08388_ _08425_ VDD VSS FA_X1
X_17526_ _08415_ _08427_ _08428_ _08429_ _08430_ VDD VSS FA_X1
X_17527_ _08431_ _08432_ _08433_ _08427_ _08434_ VDD VSS FA_X1
X_17528_ _08435_ _08436_ _08437_ _08432_ _08438_ VDD VSS FA_X1
X_17529_ _08440_ _08441_ _08442_ _08439_ _08443_ VDD VSS FA_X1
X_17530_ _08444_ _08445_ _08397_ _08399_ _08446_ VDD VSS FA_X1
X_17531_ _08066_ _08448_ _08449_ _08450_ _08451_ VDD VSS FA_X1
X_17532_ _08452_ _08453_ _08454_ _08455_ _08456_ VDD VSS FA_X1
X_17533_ _08434_ _08457_ _08458_ _08459_ _08460_ VDD VSS FA_X1
X_17534_ _08438_ _08461_ _08462_ _08457_ _08463_ VDD VSS FA_X1
X_17535_ _08464_ _08465_ _08466_ _08461_ _08467_ VDD VSS FA_X1
X_17536_ _08469_ _08470_ _08471_ _08468_ _08472_ VDD VSS FA_X1
X_17537_ _08473_ _08474_ _08475_ _08476_ _08477_ VDD VSS FA_X1
X_17538_ _08463_ _08478_ _08479_ _08480_ _08481_ VDD VSS FA_X1
X_17539_ _08467_ _08482_ _08483_ _08478_ _08484_ VDD VSS FA_X1
X_17540_ _08485_ _08486_ _08487_ _08482_ _08488_ VDD VSS FA_X1
X_17541_ _08489_ _08490_ _08491_ _08486_ _08492_ VDD VSS FA_X1
X_17542_ _08234_ _08493_ _08494_ _08495_ _08496_ VDD VSS FA_X1
X_17543_ _08497_ _08496_ _08498_ _08499_ _08500_ VDD VSS FA_X1
X_17544_ _08484_ _08503_ _08504_ _08505_ _08506_ VDD VSS FA_X1
X_17545_ _08488_ _08507_ _08499_ _08503_ _08508_ VDD VSS FA_X1
X_17546_ _08510_ _08511_ _08512_ _08509_ _08513_ VDD VSS FA_X1
X_17547_ _08190_ _08515_ _08516_ _08502_ _08517_ VDD VSS FA_X1
X_17548_ _08518_ _08517_ _08519_ _08520_ _08521_ VDD VSS FA_X1
X_17549_ _08055_ _08525_ _08526_ _08527_ _08528_ VDD VSS FA_X1
X_17550_ _08508_ _08529_ _08527_ _08530_ _08531_ VDD VSS FA_X1
X_17551_ _08532_ _08533_ _08528_ _08529_ _08534_ VDD VSS FA_X1
X_17552_ _08536_ _08537_ _08538_ _08519_ _08539_ VDD VSS FA_X1
X_17553_ _08424_ _08540_ _08541_ _08542_ _08543_ VDD VSS FA_X1
X_17554_ _08534_ _08544_ _08545_ _08546_ _08547_ VDD VSS FA_X1
X_17555_ _08548_ _08549_ _08550_ _08551_ _08552_ VDD VSS FA_X1
X_17556_ _08553_ _07347_ _08554_ _08555_ VDD VSS HA_X1
X_17557_ temp_imag\[0\] _08557_ _07352_ _08558_ VDD VSS HA_X1
X_17558_ temp_imag\[0\] _08559_ _08556_ _08560_ VDD VSS HA_X1
X_17559_ _08561_ _08562_ _08563_ _08564_ VDD VSS HA_X1
X_17560_ _07347_ _08553_ _08565_ _08566_ VDD VSS HA_X1
X_17561_ temp_imag\[0\] _08553_ _08567_ _08568_ VDD VSS HA_X1
X_17562_ _07347_ _08569_ _08570_ _08571_ VDD VSS HA_X1
X_17563_ temp_imag\[0\] _08569_ _08572_ _08573_ VDD VSS HA_X1
X_17564_ _07347_ _08574_ _08575_ _08576_ VDD VSS HA_X1
X_17565_ temp_imag\[0\] _08574_ _08577_ _08578_ VDD VSS HA_X1
X_17566_ _07347_ _08579_ _08580_ _08581_ VDD VSS HA_X1
X_17567_ temp_imag\[0\] _08579_ _08582_ _08583_ VDD VSS HA_X1
X_17568_ _07347_ _08584_ _08585_ _08586_ VDD VSS HA_X1
X_17569_ temp_imag\[0\] _08584_ _08587_ _08588_ VDD VSS HA_X1
X_17570_ _07347_ _08589_ _08590_ _08591_ VDD VSS HA_X1
X_17571_ temp_imag\[0\] _08589_ _08592_ _08593_ VDD VSS HA_X1
X_17572_ _07347_ _08594_ _08595_ _08596_ VDD VSS HA_X1
X_17573_ temp_imag\[0\] _08594_ _08597_ _08598_ VDD VSS HA_X1
X_17574_ _07347_ _08599_ _08600_ _08601_ VDD VSS HA_X1
X_17575_ temp_imag\[0\] _08599_ _08602_ _08603_ VDD VSS HA_X1
X_17576_ _07347_ _08604_ _08605_ _08606_ VDD VSS HA_X1
X_17577_ temp_imag\[0\] _08604_ _08607_ _08608_ VDD VSS HA_X1
X_17578_ _07347_ _08609_ _08610_ _08611_ VDD VSS HA_X1
X_17579_ temp_imag\[0\] _08609_ _08612_ _08613_ VDD VSS HA_X1
X_17580_ _07347_ _08614_ _08615_ _08616_ VDD VSS HA_X1
X_17581_ temp_imag\[0\] _08614_ _08617_ _08618_ VDD VSS HA_X1
X_17582_ _07347_ _08619_ _08620_ _08621_ VDD VSS HA_X1
X_17583_ temp_imag\[0\] net522 _08622_ _08623_ VDD VSS HA_X1
X_17584_ _07347_ _08624_ _08625_ _08626_ VDD VSS HA_X1
X_17585_ temp_imag\[0\] _08624_ _08627_ _08628_ VDD VSS HA_X1
X_17586_ _07347_ _08629_ _08630_ _08631_ VDD VSS HA_X1
X_17587_ temp_imag\[0\] net521 _08632_ _08633_ VDD VSS HA_X1
X_17588_ _08634_ _07355_ _08635_ _08636_ VDD VSS HA_X1
X_17589_ temp_real\[0\] _08638_ _07360_ _08639_ VDD VSS HA_X1
X_17590_ temp_real\[0\] _08640_ _08637_ _08641_ VDD VSS HA_X1
X_17591_ _08642_ _08643_ _08644_ _08645_ VDD VSS HA_X1
X_17592_ _07355_ _08634_ _08646_ _08647_ VDD VSS HA_X1
X_17593_ temp_real\[0\] _08634_ _08648_ _08649_ VDD VSS HA_X1
X_17594_ _07355_ _08650_ _08651_ _08652_ VDD VSS HA_X1
X_17595_ temp_real\[0\] _08650_ _08653_ _08654_ VDD VSS HA_X1
X_17596_ _07355_ _08655_ _08656_ _08657_ VDD VSS HA_X1
X_17597_ temp_real\[0\] _08655_ _08658_ _08659_ VDD VSS HA_X1
X_17598_ _07355_ _08660_ _08661_ _08662_ VDD VSS HA_X1
X_17599_ temp_real\[0\] _08660_ _08663_ _08664_ VDD VSS HA_X1
X_17600_ _07355_ _08665_ _08666_ _08667_ VDD VSS HA_X1
X_17601_ temp_real\[0\] _08665_ _08668_ _08669_ VDD VSS HA_X1
X_17602_ _07355_ _08670_ _08671_ _08672_ VDD VSS HA_X1
X_17603_ temp_real\[0\] _08670_ _08673_ _08674_ VDD VSS HA_X1
X_17604_ _07355_ _08675_ _08676_ _08677_ VDD VSS HA_X1
X_17605_ temp_real\[0\] _08675_ _08678_ _08679_ VDD VSS HA_X1
X_17606_ _07355_ _08680_ _08681_ _08682_ VDD VSS HA_X1
X_17607_ temp_real\[0\] _08680_ _08683_ _08684_ VDD VSS HA_X1
X_17608_ _07355_ _08685_ _08686_ _08687_ VDD VSS HA_X1
X_17609_ temp_real\[0\] _08685_ _08688_ _08689_ VDD VSS HA_X1
X_17610_ _07355_ _08690_ _08691_ _08692_ VDD VSS HA_X1
X_17611_ temp_real\[0\] _08690_ _08693_ _08694_ VDD VSS HA_X1
X_17612_ _07355_ _08695_ _08696_ _08697_ VDD VSS HA_X1
X_17613_ temp_real\[0\] _08695_ _08698_ _08699_ VDD VSS HA_X1
X_17614_ _07355_ _08700_ _08701_ _08702_ VDD VSS HA_X1
X_17615_ temp_real\[0\] _08700_ _08703_ _08704_ VDD VSS HA_X1
X_17616_ _07355_ _08705_ _08706_ _08707_ VDD VSS HA_X1
X_17617_ temp_real\[0\] _08705_ _08708_ _08709_ VDD VSS HA_X1
X_17618_ _07355_ _08710_ _08711_ _08712_ VDD VSS HA_X1
X_17619_ temp_real\[0\] _08710_ _08713_ _08714_ VDD VSS HA_X1
X_17620_ _08715_ net398 _08716_ _08717_ VDD VSS HA_X1
X_17621_ _07367_ _08718_ _08719_ _08720_ VDD VSS HA_X1
X_17622_ _08721_ _08722_ _08723_ _08724_ VDD VSS HA_X1
X_17623_ _07367_ _08725_ _08726_ _08727_ VDD VSS HA_X1
X_17624_ _08715_ net384 _08728_ _08729_ VDD VSS HA_X1
X_17625_ _08730_ _08731_ _08732_ _08733_ VDD VSS HA_X1
X_17626_ _08721_ _08734_ _08735_ _08736_ VDD VSS HA_X1
X_17627_ _07367_ _08737_ _08738_ _08739_ VDD VSS HA_X1
X_17628_ _08715_ _08740_ _08741_ _08742_ VDD VSS HA_X1
X_17629_ _08743_ _08744_ _08745_ _08746_ VDD VSS HA_X1
X_17630_ _08730_ _08747_ _08748_ _08749_ VDD VSS HA_X1
X_17631_ _08721_ _08750_ _08751_ _08752_ VDD VSS HA_X1
X_17632_ _07367_ _08753_ _08754_ _08755_ VDD VSS HA_X1
X_17633_ _08715_ net385 _08756_ _08757_ VDD VSS HA_X1
X_17634_ _07367_ _08758_ _08759_ _08760_ VDD VSS HA_X1
X_17635_ _08715_ _08761_ _08762_ _08763_ VDD VSS HA_X1
X_17636_ _08764_ _08765_ _08766_ _08767_ VDD VSS HA_X1
X_17637_ _08743_ _08768_ _08769_ _08770_ VDD VSS HA_X1
X_17638_ _08730_ _08771_ _08772_ _08773_ VDD VSS HA_X1
X_17639_ _08721_ _08774_ _08775_ _08776_ VDD VSS HA_X1
X_17640_ _08777_ _08778_ _08779_ _08780_ VDD VSS HA_X1
X_17641_ _08764_ _08781_ _08782_ _08783_ VDD VSS HA_X1
X_17642_ _08743_ _08784_ _08785_ _08786_ VDD VSS HA_X1
X_17643_ _08730_ _08787_ _08788_ _08789_ VDD VSS HA_X1
X_17644_ _08721_ _08790_ _08791_ _08792_ VDD VSS HA_X1
X_17645_ _07367_ _08793_ _08794_ _08795_ VDD VSS HA_X1
X_17646_ _08715_ net386 _08796_ _08797_ VDD VSS HA_X1
X_17647_ _08777_ _08798_ _08799_ _08800_ VDD VSS HA_X1
X_17648_ _08764_ _08801_ _08802_ _08803_ VDD VSS HA_X1
X_17649_ _08743_ _08804_ _08805_ _08806_ VDD VSS HA_X1
X_17650_ _08730_ _08807_ _08808_ _08809_ VDD VSS HA_X1
X_17651_ _08721_ _08810_ _08811_ _08812_ VDD VSS HA_X1
X_17652_ _07367_ _08813_ _08814_ _08815_ VDD VSS HA_X1
X_17653_ _08715_ _08816_ _08817_ _08818_ VDD VSS HA_X1
X_17654_ _08819_ _08820_ _08821_ _08822_ VDD VSS HA_X1
X_17655_ _08777_ _08823_ _08824_ _08825_ VDD VSS HA_X1
X_17656_ _08764_ _08826_ _08827_ _08828_ VDD VSS HA_X1
X_17657_ _08743_ _08829_ _08830_ _08831_ VDD VSS HA_X1
X_17658_ _08721_ _08832_ _08833_ _08834_ VDD VSS HA_X1
X_17659_ _07367_ _08835_ _08836_ _08837_ VDD VSS HA_X1
X_17660_ _08715_ net387 _08838_ _08839_ VDD VSS HA_X1
X_17661_ _08764_ _08840_ _08841_ _08842_ VDD VSS HA_X1
X_17662_ _08743_ _08843_ _08844_ _08845_ VDD VSS HA_X1
X_17663_ _08721_ _08846_ _08847_ _08848_ VDD VSS HA_X1
X_17664_ _08777_ _08849_ _08850_ _08851_ VDD VSS HA_X1
X_17665_ _07367_ _08852_ _08853_ _08854_ VDD VSS HA_X1
X_17666_ _08715_ _08855_ _08856_ _08857_ VDD VSS HA_X1
X_17667_ _08730_ _08858_ _08859_ _08860_ VDD VSS HA_X1
X_17668_ _08721_ _08861_ _08862_ _08863_ VDD VSS HA_X1
X_17669_ _07367_ _08864_ _08865_ _08866_ VDD VSS HA_X1
X_17670_ _08715_ net388 _08867_ _08868_ VDD VSS HA_X1
X_17671_ _08777_ _08869_ _08870_ _08871_ VDD VSS HA_X1
X_17672_ _08764_ _08872_ _08873_ _08874_ VDD VSS HA_X1
X_17673_ _08743_ _08875_ _08876_ _08877_ VDD VSS HA_X1
X_17674_ _08730_ _08878_ _08879_ _08880_ VDD VSS HA_X1
X_17675_ _08730_ _08881_ _08882_ _08883_ VDD VSS HA_X1
X_17676_ _08721_ _08884_ _08885_ _08886_ VDD VSS HA_X1
X_17677_ _07367_ _08887_ _08888_ _08889_ VDD VSS HA_X1
X_17678_ _08715_ _08890_ _08891_ _08892_ VDD VSS HA_X1
X_17679_ _08777_ _08893_ _08894_ _08895_ VDD VSS HA_X1
X_17680_ _08764_ _08896_ _08897_ _08898_ VDD VSS HA_X1
X_17681_ _08743_ _08899_ _08900_ _08901_ VDD VSS HA_X1
X_17682_ _08721_ _08902_ _08903_ _08904_ VDD VSS HA_X1
X_17683_ _07367_ _08905_ _08906_ _08907_ VDD VSS HA_X1
X_17684_ _08743_ _08908_ _08909_ _08910_ VDD VSS HA_X1
X_17685_ _08730_ _08911_ _08912_ _08913_ VDD VSS HA_X1
X_17686_ _08715_ net389 _08914_ _08915_ VDD VSS HA_X1
X_17687_ _08777_ _08916_ _08917_ _08918_ VDD VSS HA_X1
X_17688_ _08764_ _08919_ _08920_ _08921_ VDD VSS HA_X1
X_17689_ _08777_ _08922_ _08923_ _08924_ VDD VSS HA_X1
X_17690_ _08764_ _08925_ _08926_ _08927_ VDD VSS HA_X1
X_17691_ _08743_ _08928_ _08929_ _08930_ VDD VSS HA_X1
X_17692_ _08730_ _08931_ _08932_ _08933_ VDD VSS HA_X1
X_17693_ _08721_ _08934_ _08935_ _08936_ VDD VSS HA_X1
X_17694_ _07367_ _08937_ _08938_ _08939_ VDD VSS HA_X1
X_17695_ _08715_ _08940_ _08941_ _08942_ VDD VSS HA_X1
X_17696_ _08777_ _08943_ _08944_ _08945_ VDD VSS HA_X1
X_17697_ _08764_ _08946_ _08947_ _08948_ VDD VSS HA_X1
X_17698_ _08743_ _08949_ _08950_ _08951_ VDD VSS HA_X1
X_17699_ _08730_ _08952_ _08953_ _08954_ VDD VSS HA_X1
X_17700_ _08721_ _08955_ _08956_ _08957_ VDD VSS HA_X1
X_17701_ _07367_ _08958_ _08959_ _08960_ VDD VSS HA_X1
X_17702_ _08715_ net390 _08961_ _08962_ VDD VSS HA_X1
X_17703_ _08777_ _08963_ _08964_ _08965_ VDD VSS HA_X1
X_17704_ _08764_ _08966_ _08967_ _08968_ VDD VSS HA_X1
X_17705_ _08743_ _08969_ _08970_ _08971_ VDD VSS HA_X1
X_17706_ _08730_ _08972_ _08973_ _08974_ VDD VSS HA_X1
X_17707_ _08721_ _08975_ _08976_ _08977_ VDD VSS HA_X1
X_17708_ _07367_ _08978_ _08979_ _08980_ VDD VSS HA_X1
X_17709_ _08715_ _08981_ _08982_ _08983_ VDD VSS HA_X1
X_17710_ _08715_ net391 _08984_ _08985_ VDD VSS HA_X1
X_17711_ _08721_ _08986_ _08987_ _08988_ VDD VSS HA_X1
X_17712_ _07367_ _08989_ _08990_ _08991_ VDD VSS HA_X1
X_17713_ _08743_ _08992_ _08993_ _08994_ VDD VSS HA_X1
X_17714_ _08730_ _08995_ _08996_ _08997_ VDD VSS HA_X1
X_17715_ _08777_ _08998_ _08999_ _09000_ VDD VSS HA_X1
X_17716_ _08764_ _09001_ _09002_ _09003_ VDD VSS HA_X1
X_17717_ _07367_ _09004_ _09005_ _09006_ VDD VSS HA_X1
X_17718_ net42 _09007_ _09008_ _09009_ VDD VSS HA_X1
X_17719_ _08777_ _09010_ _09011_ _09012_ VDD VSS HA_X1
X_17720_ _08764_ _09013_ _09014_ _09015_ VDD VSS HA_X1
X_17721_ _08743_ _09016_ _09017_ _09018_ VDD VSS HA_X1
X_17722_ _08730_ _09019_ _09020_ _09021_ VDD VSS HA_X1
X_17723_ _08721_ _09022_ _09023_ _09024_ VDD VSS HA_X1
X_17724_ net42 net392 _09025_ _09026_ VDD VSS HA_X1
X_17725_ _08721_ _09027_ _09028_ _09029_ VDD VSS HA_X1
X_17726_ _07367_ _09030_ _09031_ _09032_ VDD VSS HA_X1
X_17727_ _08777_ _09033_ _09034_ _09035_ VDD VSS HA_X1
X_17728_ _08764_ _09036_ _09037_ _09038_ VDD VSS HA_X1
X_17729_ _08743_ _09039_ _09040_ _09041_ VDD VSS HA_X1
X_17730_ _08730_ _09042_ _09043_ _09044_ VDD VSS HA_X1
X_17731_ _08730_ _09045_ _09046_ _09047_ VDD VSS HA_X1
X_17732_ _08721_ _09048_ _09049_ _09050_ VDD VSS HA_X1
X_17733_ _07367_ _09051_ _09052_ _09053_ VDD VSS HA_X1
X_17734_ net42 _09054_ _09055_ _09056_ VDD VSS HA_X1
X_17735_ _08777_ _09057_ _09058_ _09059_ VDD VSS HA_X1
X_17736_ _08764_ _09060_ _09061_ _09062_ VDD VSS HA_X1
X_17737_ _08743_ _09063_ _09064_ _09065_ VDD VSS HA_X1
X_17738_ _08743_ _09066_ _09067_ _09068_ VDD VSS HA_X1
X_17739_ _08730_ _09069_ _09070_ _09071_ VDD VSS HA_X1
X_17740_ _08721_ _09072_ _09073_ _09074_ VDD VSS HA_X1
X_17741_ _09075_ _07367_ _09076_ _09077_ VDD VSS HA_X1
X_17742_ net42 net393 _09078_ _09079_ VDD VSS HA_X1
X_17743_ _08777_ _09080_ _09081_ _09082_ VDD VSS HA_X1
X_17744_ _08764_ _09083_ _09084_ _09085_ VDD VSS HA_X1
X_17745_ _08764_ _09086_ _09087_ _09088_ VDD VSS HA_X1
X_17746_ _08743_ _09089_ _09090_ _09091_ VDD VSS HA_X1
X_17747_ _08730_ _09092_ _09093_ _09094_ VDD VSS HA_X1
X_17748_ _08721_ _09095_ _09096_ _09097_ VDD VSS HA_X1
X_17749_ _09098_ _07367_ _09099_ _09100_ VDD VSS HA_X1
X_17750_ _09101_ net42 _09102_ _09103_ VDD VSS HA_X1
X_17751_ _08777_ _09104_ _09105_ _09106_ VDD VSS HA_X1
X_17752_ _08777_ _09107_ _09108_ _09109_ VDD VSS HA_X1
X_17753_ _08764_ _09110_ _09111_ _09112_ VDD VSS HA_X1
X_17754_ _08743_ _09113_ _09114_ _09115_ VDD VSS HA_X1
X_17755_ _08730_ _09116_ _09117_ _09118_ VDD VSS HA_X1
X_17756_ _08721_ _09119_ _09120_ _09121_ VDD VSS HA_X1
X_17757_ _07367_ _09122_ _09123_ _09124_ VDD VSS HA_X1
X_17758_ net42 net394 _09125_ _09126_ VDD VSS HA_X1
X_17759_ _08777_ _09127_ _09128_ _09129_ VDD VSS HA_X1
X_17760_ _08764_ _09130_ _09131_ _09132_ VDD VSS HA_X1
X_17761_ _08743_ _09133_ _09134_ _09135_ VDD VSS HA_X1
X_17762_ _08730_ _09136_ _09137_ _09138_ VDD VSS HA_X1
X_17763_ _08721_ _09139_ _09140_ _09141_ VDD VSS HA_X1
X_17764_ _07367_ _09142_ _09143_ _09144_ VDD VSS HA_X1
X_17765_ net42 _09145_ _09146_ _09147_ VDD VSS HA_X1
X_17766_ net42 net395 _09148_ _09149_ VDD VSS HA_X1
X_17767_ _08777_ _09150_ _09151_ _09152_ VDD VSS HA_X1
X_17768_ _08764_ _09153_ _09154_ _09155_ VDD VSS HA_X1
X_17769_ _08743_ _09156_ _09157_ _09158_ VDD VSS HA_X1
X_17770_ _08730_ _09159_ _09160_ _09161_ VDD VSS HA_X1
X_17771_ _08721_ _09162_ _09163_ _09164_ VDD VSS HA_X1
X_17772_ _07367_ _09165_ _09166_ _09167_ VDD VSS HA_X1
X_17773_ _07367_ _09168_ _09169_ _09170_ VDD VSS HA_X1
X_17774_ net42 _09171_ _09172_ _09173_ VDD VSS HA_X1
X_17775_ _08764_ _09174_ _09175_ _09176_ VDD VSS HA_X1
X_17776_ _08743_ _09177_ _09178_ _09179_ VDD VSS HA_X1
X_17777_ _08730_ _09180_ _09181_ _09182_ VDD VSS HA_X1
X_17778_ _08721_ _09183_ _09184_ _09185_ VDD VSS HA_X1
X_17779_ _08819_ _09186_ _09187_ _09188_ VDD VSS HA_X1
X_17780_ _08777_ _09189_ _09190_ _09191_ VDD VSS HA_X1
X_17781_ _08721_ _09192_ _09193_ _09194_ VDD VSS HA_X1
X_17782_ _07367_ _09195_ _09196_ _09197_ VDD VSS HA_X1
X_17783_ net42 net396 _09198_ _09199_ VDD VSS HA_X1
X_17784_ _08819_ _09200_ _09201_ _09202_ VDD VSS HA_X1
X_17785_ _08777_ _09203_ _09204_ _09205_ VDD VSS HA_X1
X_17786_ _08764_ _09206_ _09207_ _09208_ VDD VSS HA_X1
X_17787_ _08743_ _09209_ _09210_ _09211_ VDD VSS HA_X1
X_17788_ _08730_ _09212_ _09213_ _09214_ VDD VSS HA_X1
X_17789_ _08730_ _09215_ _09216_ _09217_ VDD VSS HA_X1
X_17790_ _08721_ _09218_ _09219_ _09220_ VDD VSS HA_X1
X_17791_ _07367_ _09221_ _09222_ _09223_ VDD VSS HA_X1
X_17792_ net42 _09224_ _09225_ _09226_ VDD VSS HA_X1
X_17793_ _08819_ _09227_ _09228_ _09229_ VDD VSS HA_X1
X_17794_ _08777_ _09230_ _09231_ _09232_ VDD VSS HA_X1
X_17795_ _08764_ _09233_ _09234_ _09235_ VDD VSS HA_X1
X_17796_ _08743_ _09236_ _09237_ _09238_ VDD VSS HA_X1
X_17797_ net42 net397 _09239_ _09240_ VDD VSS HA_X1
X_17798_ _08721_ _09241_ _09242_ _09243_ VDD VSS HA_X1
X_17799_ _07367_ _09244_ _09245_ _09246_ VDD VSS HA_X1
X_17800_ _08743_ _09247_ _09248_ _09249_ VDD VSS HA_X1
X_17801_ _08730_ _09250_ _09251_ _09252_ VDD VSS HA_X1
X_17802_ _08777_ _09253_ _09254_ _09255_ VDD VSS HA_X1
X_17803_ _08764_ _09256_ _09257_ _09258_ VDD VSS HA_X1
X_17804_ _08819_ _09259_ _09260_ _09261_ VDD VSS HA_X1
X_17805_ _07367_ _09262_ _09263_ _09264_ VDD VSS HA_X1
X_17806_ butterfly_count\[2\] net42 _09265_ _09266_ VDD VSS
+ HA_X1
X_17807_ _08764_ _09267_ _09268_ _09269_ VDD VSS HA_X1
X_17808_ _08743_ _09270_ _09271_ _09272_ VDD VSS HA_X1
X_17809_ _08730_ _09273_ _09274_ _09275_ VDD VSS HA_X1
X_17810_ _08721_ _09276_ _09277_ _09278_ VDD VSS HA_X1
X_17811_ _08819_ _09279_ _09280_ _09281_ VDD VSS HA_X1
X_17812_ _08777_ _09282_ _09283_ _09284_ VDD VSS HA_X1
X_17813_ _09285_ _09286_ _09287_ _09288_ VDD VSS HA_X1
X_17814_ butterfly_count\[1\] net42 _09289_ _09290_ VDD VSS
+ HA_X1
X_17815_ _08721_ _09291_ _09292_ _09293_ VDD VSS HA_X1
X_17816_ _07367_ _09294_ _09295_ _09296_ VDD VSS HA_X1
X_17817_ _08777_ _09297_ _09298_ _09299_ VDD VSS HA_X1
X_17818_ _08764_ _09300_ _09301_ _09302_ VDD VSS HA_X1
X_17819_ _08743_ _09303_ _09304_ _09305_ VDD VSS HA_X1
X_17820_ _08730_ _09306_ _09307_ _09308_ VDD VSS HA_X1
X_17821_ _09309_ _09310_ _09311_ _09312_ VDD VSS HA_X1
X_17822_ _09313_ _09314_ _09315_ _09316_ VDD VSS HA_X1
X_17823_ _09318_ _09317_ _09319_ _09320_ VDD VSS HA_X1
X_17824_ _09321_ _09322_ _09323_ _09324_ VDD VSS HA_X1
X_17825_ _09325_ _09326_ _09327_ _09328_ VDD VSS HA_X1
X_17826_ _09329_ _09330_ _09331_ _09332_ VDD VSS HA_X1
X_17827_ _07367_ _07368_ _09333_ _09334_ VDD VSS HA_X1
X_17828_ _09335_ _09286_ _09336_ _09337_ VDD VSS HA_X1
X_17829_ butterfly_count\[0\] net42 _09338_ _09339_ VDD VSS
+ HA_X1
X_17830_ _09340_ _09341_ _09342_ _09343_ VDD VSS HA_X1
X_17831_ _09340_ _09341_ _09325_ _09344_ VDD VSS HA_X1
X_17832_ stage\[2\] _09341_ _09345_ _09346_ VDD VSS HA_X1
X_17833_ _09341_ stage\[2\] _09309_ _09347_ VDD VSS HA_X1
X_17834_ butterfly_in_group\[0\] _09348_ _09349_ _00042_ VDD
+ VSS HA_X1
X_17835_ butterfly_in_group\[1\] _09350_ _09351_ _09352_ VDD
+ VSS HA_X1
X_17836_ _09352_ _09353_ _09354_ _09355_ VDD VSS HA_X1
X_17837_ _09355_ _09349_ _09356_ _00043_ VDD VSS HA_X1
X_17838_ _09286_ _00042_ _07364_ _00044_ VDD VSS HA_X1
X_17839_ _09335_ _09285_ _09357_ _09358_ VDD VSS HA_X1
X_17840_ butterfly_count\[0\] butterfly_count\[1\] _09359_
+ _09360_ VDD VSS HA_X1
X_17841_ _09361_ _09362_ _09363_ _09364_ VDD VSS HA_X1
X_17842_ _09361_ _09362_ _09365_ _09366_ VDD VSS HA_X1
X_17843_ _09361_ stage\[1\] _09367_ _09368_ VDD VSS HA_X1
X_17844_ stage\[0\] _09362_ _09369_ _09370_ VDD VSS HA_X1
X_17845_ stage\[0\] _09362_ _09371_ _09372_ VDD VSS HA_X1
X_17846_ stage\[0\] stage\[1\] _09341_ _09373_ VDD VSS HA_X1
X_17847_ stage\[0\] stage\[1\] _09374_ _09375_ VDD VSS HA_X1
X_17848_ _09376_ _09377_ _09378_ _09379_ VDD VSS HA_X1
X_17849_ sample_count\[0\] sample_count\[1\] _09380_ _09381_
+ VDD VSS HA_X1
X_17850_ sample_count\[2\] _09380_ _09382_ _09383_ VDD VSS
+ HA_X1
X_17851_ _09384_ _09385_ _09386_ _09387_ VDD VSS HA_X1
X_17852_ _09388_ _09387_ _09389_ _07404_ VDD VSS HA_X1
X_17853_ _09390_ _07449_ _09391_ _09392_ VDD VSS HA_X1
X_17854_ _07380_ _07481_ _07405_ _07439_ VDD VSS HA_X1
X_17855_ _09384_ _07377_ _07414_ _09393_ VDD VSS HA_X1
X_17856_ _09394_ _09395_ _09396_ _07431_ VDD VSS HA_X1
X_17857_ _09397_ _09398_ _07432_ _07463_ VDD VSS HA_X1
X_17858_ _07603_ _07671_ _09399_ _07459_ VDD VSS HA_X1
X_17859_ _09393_ _07529_ _07440_ _09400_ VDD VSS HA_X1
X_17860_ _07444_ _09401_ _07454_ _09402_ VDD VSS HA_X1
X_17861_ _09404_ _09405_ _07464_ _07516_ VDD VSS HA_X1
X_17862_ _07653_ _07718_ _09406_ _07513_ VDD VSS HA_X1
X_17863_ _07621_ _07533_ _09407_ _09408_ VDD VSS HA_X1
X_17864_ _07485_ _07578_ _09409_ _09410_ VDD VSS HA_X1
X_17865_ _09407_ _09410_ _09411_ _09412_ VDD VSS HA_X1
X_17866_ _07671_ _07578_ _09414_ _09415_ VDD VSS HA_X1
X_17867_ _09408_ _09414_ _09413_ _09416_ VDD VSS HA_X1
X_17868_ _07484_ _07531_ _09417_ _09418_ VDD VSS HA_X1
X_17869_ _09420_ _07547_ _07508_ _09421_ VDD VSS HA_X1
X_17870_ _09384_ _07472_ _09403_ _09422_ VDD VSS HA_X1
X_17871_ _09423_ _09424_ _07518_ _07563_ VDD VSS HA_X1
X_17872_ _09425_ _09416_ _09419_ _09426_ VDD VSS HA_X1
X_17873_ _07718_ _07621_ _09427_ _09428_ VDD VSS HA_X1
X_17874_ _09427_ _09415_ _09425_ _09429_ VDD VSS HA_X1
X_17875_ _07532_ _07576_ _09430_ _09431_ VDD VSS HA_X1
X_17876_ _09421_ _09422_ _07544_ _07594_ VDD VSS HA_X1
X_17877_ _07548_ _09433_ _07555_ _09434_ VDD VSS HA_X1
X_17878_ _09435_ _09436_ _07564_ _07607_ VDD VSS HA_X1
X_17879_ _09437_ _09429_ _09432_ _09438_ VDD VSS HA_X1
X_17880_ _07559_ _07671_ _09439_ _09440_ VDD VSS HA_X1
X_17881_ _09439_ _09428_ _09437_ _09441_ VDD VSS HA_X1
X_17882_ _07577_ _07619_ _09442_ _09443_ VDD VSS HA_X1
X_17883_ _09445_ _09430_ _09446_ _07585_ VDD VSS HA_X1
X_17884_ _07473_ _09434_ _07595_ _07642_ VDD VSS HA_X1
X_17885_ _09384_ _07372_ _09433_ _09447_ VDD VSS HA_X1
X_17886_ _07599_ _07648_ _07610_ _07644_ VDD VSS HA_X1
X_17887_ _09448_ _09449_ _07608_ _07656_ VDD VSS HA_X1
X_17888_ _09450_ _09441_ _09444_ _09451_ VDD VSS HA_X1
X_17889_ _07603_ _07718_ _09452_ _09453_ VDD VSS HA_X1
X_17890_ _09452_ _09440_ _09450_ _09454_ VDD VSS HA_X1
X_17891_ _07620_ _07669_ _09455_ _09456_ VDD VSS HA_X1
X_17892_ _09458_ _09442_ _07628_ _07633_ VDD VSS HA_X1
X_17893_ _07485_ _09447_ _07643_ _09459_ VDD VSS HA_X1
X_17894_ _07649_ _07698_ _09460_ _09461_ VDD VSS HA_X1
X_17895_ _09463_ _09464_ _07657_ _07706_ VDD VSS HA_X1
X_17896_ _07670_ _07716_ _09466_ _09467_ VDD VSS HA_X1
X_17897_ _09468_ _09454_ _09457_ _09469_ VDD VSS HA_X1
X_17898_ _07676_ _09455_ _07679_ _07684_ VDD VSS HA_X1
X_17899_ _07630_ _07680_ _09470_ _09471_ VDD VSS HA_X1
X_17900_ _07699_ _09472_ _09473_ _09474_ VDD VSS HA_X1
X_17901_ _07378_ _07533_ _09462_ _09475_ VDD VSS HA_X1
X_17902_ _07658_ _07708_ _09465_ _09476_ VDD VSS HA_X1
X_17903_ _09477_ _09478_ _07707_ _07749_ VDD VSS HA_X1
X_17904_ _09467_ _09469_ _07675_ _07721_ VDD VSS HA_X1
X_17905_ _07717_ _07759_ _09480_ _09481_ VDD VSS HA_X1
X_17906_ _09482_ _09453_ _09468_ _09483_ VDD VSS HA_X1
X_17907_ _07723_ _09466_ _07726_ _07731_ VDD VSS HA_X1
X_17908_ _07681_ _07727_ _09484_ _09485_ VDD VSS HA_X1
X_17909_ _09474_ _09475_ _07738_ _07780_ VDD VSS HA_X1
X_17910_ _07372_ _07378_ _07746_ _09486_ VDD VSS HA_X1
X_17911_ _09487_ _09488_ _09489_ _09490_ VDD VSS HA_X1
X_17912_ _07709_ _07751_ _09479_ _09491_ VDD VSS HA_X1
X_17913_ _09492_ _09493_ _07750_ _07788_ VDD VSS HA_X1
X_17914_ _09481_ _09483_ _07722_ _07763_ VDD VSS HA_X1
X_17915_ _07760_ _07798_ _09495_ _09496_ VDD VSS HA_X1
X_17916_ _07559_ _07653_ _09482_ _09497_ VDD VSS HA_X1
X_17917_ _07765_ _09480_ _07768_ _07773_ VDD VSS HA_X1
X_17918_ _07728_ _07769_ _09498_ _09499_ VDD VSS HA_X1
X_17919_ _07578_ _09490_ _07781_ _07819_ VDD VSS HA_X1
X_17920_ _07748_ _09486_ _09488_ _09500_ VDD VSS HA_X1
X_17921_ _09500_ _09501_ _09502_ _09503_ VDD VSS HA_X1
X_17922_ _07752_ _07790_ _09494_ _09504_ VDD VSS HA_X1
X_17923_ _09505_ _09506_ _07789_ _07825_ VDD VSS HA_X1
X_17924_ _09496_ _09497_ _07764_ _07802_ VDD VSS HA_X1
X_17925_ _07603_ _07653_ _07874_ _07912_ VDD VSS HA_X1
X_17926_ _07799_ _07830_ _09508_ _09509_ VDD VSS HA_X1
X_17927_ _07804_ _09495_ _07807_ _07812_ VDD VSS HA_X1
X_17928_ _07770_ _07808_ _09510_ _09511_ VDD VSS HA_X1
X_17929_ _07621_ _09503_ _07820_ _07849_ VDD VSS HA_X1
X_17930_ _07378_ _09512_ _09501_ _09513_ VDD VSS HA_X1
X_17931_ _07791_ _07827_ _09507_ _09514_ VDD VSS HA_X1
X_17932_ _09515_ _09516_ _07826_ _09517_ VDD VSS HA_X1
X_17933_ _09514_ _09518_ _09519_ _07851_ VDD VSS HA_X1
X_17934_ _07603_ _09509_ _07803_ _09520_ VDD VSS HA_X1
X_17935_ _07559_ _07912_ _09521_ _09522_ VDD VSS HA_X1
X_17936_ _07874_ _07832_ _07896_ _07901_ VDD VSS HA_X1
X_17937_ _07831_ _07875_ _09523_ _09524_ VDD VSS HA_X1
X_17938_ _09526_ _09508_ _07839_ _07844_ VDD VSS HA_X1
X_17939_ _07809_ _07840_ _09527_ _09528_ VDD VSS HA_X1
X_17940_ _07671_ _09513_ _07850_ _07870_ VDD VSS HA_X1
X_17941_ _07828_ _09529_ _09518_ _09530_ VDD VSS HA_X1
X_17942_ _09532_ _09533_ _09531_ _09534_ VDD VSS HA_X1
X_17943_ _09530_ _09535_ _09536_ _07872_ VDD VSS HA_X1
X_17944_ _07653_ _09524_ _09525_ _09537_ VDD VSS HA_X1
X_17945_ _09536_ _09537_ _09538_ _07868_ VDD VSS HA_X1
X_17946_ _09538_ _09523_ _07861_ _07865_ VDD VSS HA_X1
X_17947_ _07841_ _07862_ _09539_ _09540_ VDD VSS HA_X1
X_17948_ _07718_ _09541_ _07871_ _07892_ VDD VSS HA_X1
X_17949_ _09542_ _09543_ _09535_ _09544_ VDD VSS HA_X1
X_17950_ _09545_ _09534_ _09543_ _09546_ VDD VSS HA_X1
X_17951_ _09547_ _09548_ _09545_ _09549_ VDD VSS HA_X1
X_17952_ _09544_ _09550_ _09551_ _07894_ VDD VSS HA_X1
X_17953_ _09521_ _07876_ _09552_ _09553_ VDD VSS HA_X1
X_17954_ _09551_ _09553_ _09554_ _09555_ VDD VSS HA_X1
X_17955_ _09554_ _09552_ _07883_ _09556_ VDD VSS HA_X1
X_17956_ _07863_ _07884_ _09557_ _09558_ VDD VSS HA_X1
X_17957_ _07559_ _09486_ _07893_ _09559_ VDD VSS HA_X1
X_17958_ _09546_ _09560_ _09550_ _09561_ VDD VSS HA_X1
X_17959_ _07885_ _09563_ _09564_ _09565_ VDD VSS HA_X1
X_17960_ _07888_ _07898_ _09563_ _09566_ VDD VSS HA_X1
X_17961_ _09567_ _09549_ _09560_ _09568_ VDD VSS HA_X1
X_17962_ _07378_ _07603_ _09562_ _09569_ VDD VSS HA_X1
X_17963_ _09566_ _09570_ _09571_ _09572_ VDD VSS HA_X1
X_17964_ _07899_ _09573_ _09570_ _09574_ VDD VSS HA_X1
X_17965_ _07902_ _09575_ _09573_ _09576_ VDD VSS HA_X1
X_17966_ _09568_ _09569_ _07913_ _09577_ VDD VSS HA_X1
X_17967_ _09578_ _09579_ _09567_ _09580_ VDD VSS HA_X1
X_17968_ _09577_ _09581_ _09582_ _09583_ VDD VSS HA_X1
X_17969_ _08019_ _08336_ _09584_ _07919_ VDD VSS HA_X1
X_17970_ _07929_ _07930_ _09585_ _08112_ VDD VSS HA_X1
X_17971_ _07914_ _07915_ _08051_ _09586_ VDD VSS HA_X1
X_17972_ _08043_ _07933_ _09587_ _07924_ VDD VSS HA_X1
X_17973_ _08077_ _08426_ _07920_ _09588_ VDD VSS HA_X1
X_17974_ _08108_ _07956_ _07925_ _07948_ VDD VSS HA_X1
X_17975_ _07928_ _07929_ _09589_ _08176_ VDD VSS HA_X1
X_17976_ _07933_ _07914_ _08114_ _09590_ VDD VSS HA_X1
X_17977_ _07927_ _07951_ _09591_ _07945_ VDD VSS HA_X1
X_17978_ _09592_ _09593_ _09594_ _07934_ VDD VSS HA_X1
X_17979_ _07916_ _09592_ _07936_ _07962_ VDD VSS HA_X1
X_17980_ _07953_ _07928_ _09595_ _08238_ VDD VSS HA_X1
X_17981_ _07956_ _07933_ _08178_ _09596_ VDD VSS HA_X1
X_17982_ _08352_ _08054_ _08069_ _08173_ VDD VSS HA_X1
X_17983_ _08173_ _07943_ _09597_ _07959_ VDD VSS HA_X1
X_17984_ _09588_ _08233_ _07944_ _08031_ VDD VSS HA_X1
X_17985_ _07921_ _08043_ _07949_ _08035_ VDD VSS HA_X1
X_17986_ _07952_ _08038_ _07971_ _08033_ VDD VSS HA_X1
X_17987_ _07915_ _07916_ _07964_ _08049_ VDD VSS HA_X1
X_17988_ _07953_ _08040_ _09598_ _08288_ VDD VSS HA_X1
X_17989_ _07956_ _08043_ _08240_ _09599_ VDD VSS HA_X1
X_17990_ _08234_ _07970_ _09600_ _08046_ VDD VSS HA_X1
X_17991_ _08285_ _08135_ _08032_ _08096_ VDD VSS HA_X1
X_17992_ _08108_ _08233_ _08036_ _08100_ VDD VSS HA_X1
X_17993_ _08039_ _08103_ _08061_ _08098_ VDD VSS HA_X1
X_17994_ _08105_ _08040_ _09602_ _08337_ VDD VSS HA_X1
X_17995_ _08108_ _08043_ _08289_ _09603_ VDD VSS HA_X1
X_17996_ _08071_ _09604_ _09601_ _09605_ VDD VSS HA_X1
X_17997_ _08336_ _08198_ _08097_ _08159_ VDD VSS HA_X1
X_17998_ _08285_ _07921_ _08101_ _08163_ VDD VSS HA_X1
X_17999_ _08104_ _08166_ _08117_ _08161_ VDD VSS HA_X1
X_18000_ _08105_ _08168_ _09607_ _08383_ VDD VSS HA_X1
X_18001_ _08108_ _07921_ _08339_ _09608_ VDD VSS HA_X1
X_18002_ _09609_ _09610_ _09606_ _09611_ VDD VSS HA_X1
X_18003_ _09612_ _08068_ _09609_ _09613_ VDD VSS HA_X1
X_18004_ _08147_ _08084_ _09615_ _08151_ VDD VSS HA_X1
X_18005_ _08426_ _08256_ _08160_ _09616_ VDD VSS HA_X1
X_18006_ _08336_ _08233_ _08164_ _08225_ VDD VSS HA_X1
X_18007_ _08167_ _08228_ _08180_ _09617_ VDD VSS HA_X1
X_18008_ _08168_ _08230_ _09618_ _09619_ VDD VSS HA_X1
X_18009_ _07921_ _08233_ _08385_ _09620_ VDD VSS HA_X1
X_18010_ _09621_ _09613_ _09614_ _09622_ VDD VSS HA_X1
X_18011_ _09623_ _08129_ _09621_ _09624_ VDD VSS HA_X1
X_18012_ _08210_ _08142_ _08213_ _08218_ VDD VSS HA_X1
X_18013_ _09616_ _09617_ _08223_ _08281_ VDD VSS HA_X1
X_18014_ _08285_ _08426_ _08226_ _09626_ VDD VSS HA_X1
X_18015_ _08229_ _09627_ _08247_ _09628_ VDD VSS HA_X1
X_18016_ _09629_ _09624_ _09625_ _09630_ VDD VSS HA_X1
X_18017_ _08267_ _08205_ _08270_ _08275_ VDD VSS HA_X1
X_18018_ _08215_ _08271_ _09631_ _09632_ VDD VSS HA_X1
X_18019_ _08303_ _09628_ _08282_ _08328_ VDD VSS HA_X1
X_18020_ _09626_ _09633_ _09627_ _09634_ VDD VSS HA_X1
X_18021_ _09634_ _09635_ _08297_ _09636_ VDD VSS HA_X1
X_18022_ _09637_ _09638_ _08244_ _08293_ VDD VSS HA_X1
X_18023_ _08332_ _08333_ _09639_ _09640_ VDD VSS HA_X1
X_18024_ _08285_ _08336_ _09641_ _09642_ VDD VSS HA_X1
X_18025_ _09643_ _09630_ _08266_ _08312_ VDD VSS HA_X1
X_18026_ _09644_ _08193_ _09629_ _09645_ VDD VSS HA_X1
X_18027_ _08314_ _09646_ _08317_ _08322_ VDD VSS HA_X1
X_18028_ _08272_ _08318_ _09647_ _09648_ VDD VSS HA_X1
X_18029_ _07985_ _09636_ _08329_ _08379_ VDD VSS HA_X1
X_18030_ _08336_ _08287_ _09635_ _09649_ VDD VSS HA_X1
X_18031_ _09649_ _09650_ _08347_ _09651_ VDD VSS HA_X1
X_18032_ _09652_ _09653_ _08294_ _08343_ VDD VSS HA_X1
X_18033_ _08333_ _08424_ _09654_ _08522_ VDD VSS HA_X1
X_18034_ _08336_ _08426_ _09655_ _09656_ VDD VSS HA_X1
X_18035_ _09657_ _09645_ _08313_ _08363_ VDD VSS HA_X1
X_18036_ _08352_ _08234_ _08447_ _09658_ VDD VSS HA_X1
X_18037_ _07967_ _08234_ _09644_ _09659_ VDD VSS HA_X1
X_18038_ _08365_ _09660_ _08368_ _08373_ VDD VSS HA_X1
X_18039_ _08319_ _08369_ _09661_ _09662_ VDD VSS HA_X1
X_18040_ _08005_ _09651_ _08380_ _08420_ VDD VSS HA_X1
X_18041_ _08426_ _09663_ _09650_ _09664_ VDD VSS HA_X1
X_18042_ _09665_ _09666_ _08344_ _09667_ VDD VSS HA_X1
X_18043_ _09668_ _09669_ _08407_ _08422_ VDD VSS HA_X1
X_18044_ _09670_ _09659_ _08364_ _08403_ VDD VSS HA_X1
X_18045_ _08405_ _09671_ _08409_ _08414_ VDD VSS HA_X1
X_18046_ _08370_ _08410_ _09672_ _09673_ VDD VSS HA_X1
X_18047_ _08066_ _09664_ _08421_ _08440_ VDD VSS HA_X1
X_18048_ _09674_ _09675_ _09676_ _09677_ VDD VSS HA_X1
X_18049_ _09619_ _08338_ _09678_ _09679_ VDD VSS HA_X1
X_18050_ _09680_ _09681_ _09682_ _08442_ VDD VSS HA_X1
X_18051_ _08054_ _09683_ _08404_ _09684_ VDD VSS HA_X1
X_18052_ _09685_ _09684_ _09686_ _08437_ VDD VSS HA_X1
X_18053_ _09686_ _09687_ _08428_ _08433_ VDD VSS HA_X1
X_18054_ _08411_ _08429_ _09688_ _09689_ VDD VSS HA_X1
X_18055_ _08127_ _09690_ _08441_ _08469_ VDD VSS HA_X1
X_18056_ _09691_ _09692_ _09693_ _09694_ VDD VSS HA_X1
X_18057_ _09641_ _09663_ _09695_ _09696_ VDD VSS HA_X1
X_18058_ _09697_ _09698_ _09699_ _08471_ VDD VSS HA_X1
X_18059_ _09700_ _08456_ _09701_ _08466_ VDD VSS HA_X1
X_18060_ _09701_ _08455_ _08458_ _08462_ VDD VSS HA_X1
X_18061_ _08430_ _08459_ _09702_ _09703_ VDD VSS HA_X1
X_18062_ _08426_ _08190_ _08470_ _09704_ VDD VSS HA_X1
X_18063_ _09705_ _09696_ _09698_ _09706_ VDD VSS HA_X1
X_18064_ _09640_ _09655_ _09705_ _09707_ VDD VSS HA_X1
X_18065_ _09706_ _09707_ _08473_ _09708_ VDD VSS HA_X1
X_18066_ _09658_ _09709_ _08453_ _09710_ VDD VSS HA_X1
X_18067_ _09710_ _08495_ _09711_ _09712_ VDD VSS HA_X1
X_18068_ _09713_ _09712_ _09714_ _09715_ VDD VSS HA_X1
X_18069_ _09714_ _09711_ _08479_ _09716_ VDD VSS HA_X1
X_18070_ _08460_ _08480_ _09717_ _09718_ VDD VSS HA_X1
X_18071_ _08522_ _09719_ _08501_ _09720_ VDD VSS HA_X1
X_18072_ _08426_ _08536_ _09721_ _09722_ VDD VSS HA_X1
X_18073_ _08496_ _08498_ _09723_ _09724_ VDD VSS HA_X1
X_18074_ _08497_ _09724_ _09725_ _09726_ VDD VSS HA_X1
X_18075_ _09725_ _09723_ _08504_ _09727_ VDD VSS HA_X1
X_18076_ _08481_ _08505_ _09728_ _09729_ VDD VSS HA_X1
X_18077_ _09730_ _09731_ _08514_ _09732_ VDD VSS HA_X1
X_18078_ _08523_ _08524_ _08526_ _09733_ VDD VSS HA_X1
X_18079_ _08522_ _09733_ _08525_ _09734_ VDD VSS HA_X1
X_18080_ _08506_ _08530_ _09735_ _09736_ VDD VSS HA_X1
X_18081_ _09737_ _08521_ _08535_ _08548_ VDD VSS HA_X1
X_18082_ _08540_ _08541_ _09738_ _09739_ VDD VSS HA_X1
X_18083_ _08424_ _09739_ _09740_ _09741_ VDD VSS HA_X1
X_18084_ _09740_ _09738_ _08545_ _09742_ VDD VSS HA_X1
X_18085_ _08531_ _08546_ _09744_ _09745_ VDD VSS HA_X1
X_18086_ _08518_ _09746_ _09743_ _09747_ VDD VSS HA_X1
X_18087_ _09748_ _09749_ _08541_ _09750_ VDD VSS HA_X1
X_18088_ _00016_ clknet_leaf_36_clk _00003_ _07340_ VDD VSS
+ DFF_X1
X_18089_ _00017_ clknet_leaf_2_clk _00004_ _07341_ VDD VSS
+ DFF_X2
X_18090_ _00018_ clknet_leaf_37_clk _00005_ _07342_ VDD VSS
+ DFF_X1
X_18091_ _00013_ clknet_leaf_74_clk _00000_ _07343_ VDD VSS
+ DFF_X1
X_18092_ _00014_ clknet_leaf_79_clk _00001_ _07344_ VDD VSS
+ DFF_X2
X_18093_ _00015_ clknet_leaf_74_clk _00002_ _07339_ VDD VSS
+ DFF_X1
X_18094_ _00047_ clknet_leaf_66_clk _00046_ _07345_ VDD VSS
+ DFF_X1
X_18095_ _00006_ clknet_leaf_66_clk _00021_ _00032_ VDD VSS
+ DFF_X1
X_18096_ _00048_ clknet_leaf_65_clk _00022_ _00037_ VDD VSS
+ DFF_X1
X_18097_ _00008_ clknet_leaf_67_clk _00024_ _00033_ VDD VSS
+ DFF_X1
X_18098_ _00007_ clknet_leaf_67_clk _00023_ _00035_ VDD VSS
+ DFF_X1
X_18099_ _00049_ clknet_leaf_67_clk _00025_ _00036_ VDD VSS
+ DFF_X1
X_18100_ _00050_ clknet_leaf_67_clk _00045_ _00034_ VDD VSS
+ DFF_X1
Xclkbuf_leaf_0_clk clknet_3_0__leaf_clk clknet_leaf_0_clk
+ VDD VSS CLKBUF_X3
X_17620__319 net398 VDD VSS LOGIC1_X1
Xbit_rev_idx\[0\]$_SDFFE_PN0P_ _00051_ clknet_leaf_2_clk bit_rev_idx\[0\]
+ _00039_ VDD VSS DFF_X1
Xbit_rev_idx\[1\]$_SDFFE_PN0P_ _00052_ clknet_leaf_2_clk bit_rev_idx\[1\]
+ _00027_ VDD VSS DFF_X2
Xbit_rev_idx\[2\]$_SDFFE_PN0P_ _00053_ clknet_leaf_2_clk bit_rev_idx\[2\]
+ _00029_ VDD VSS DFF_X1
Xbusy$_SDFFE_PN0P_ _00054_ clknet_leaf_79_clk net88 _07338_
+ VDD VSS DFF_X2
Xbutterfly_count\[0\]$_SDFFE_PN0P_ _00055_ clknet_leaf_78_clk
+ butterfly_count\[0\] _09335_ VDD VSS DFF_X2
Xbutterfly_count\[1\]$_SDFFE_PN0P_ _00056_ clknet_leaf_78_clk
+ butterfly_count\[1\] _09285_ VDD VSS DFF_X2
Xbutterfly_count\[2\]$_SDFFE_PN0P_ _00057_ clknet_leaf_77_clk
+ butterfly_count\[2\] _00040_ VDD VSS DFF_X1
Xbutterfly_in_group\[0\]$_DFFE_PP_ _00058_ clknet_leaf_77_clk
+ butterfly_in_group\[0\] _07337_ VDD VSS DFF_X1
Xbutterfly_in_group\[1\]$_DFFE_PP_ _00059_ clknet_leaf_77_clk
+ butterfly_in_group\[1\] _07336_ VDD VSS DFF_X2
Xbutterfly_in_group\[2\]$_DFFE_PP_ _00060_ clknet_leaf_77_clk
+ butterfly_in_group\[2\] _07335_ VDD VSS DFF_X1
Xdata_out_imag\[0\]$_SDFFE_PN0P_ _00061_ clknet_3_0__leaf_clk
+ net89 _07334_ VDD VSS DFF_X1
Xdata_out_imag\[100\]$_SDFFE_PN0P_ _00062_ clknet_leaf_0_clk
+ net90 _07333_ VDD VSS DFF_X1
Xdata_out_imag\[101\]$_SDFFE_PN0P_ _00063_ clknet_leaf_0_clk
+ net91 _07332_ VDD VSS DFF_X2
Xdata_out_imag\[102\]$_SDFFE_PN0P_ _00064_ clknet_leaf_81_clk
+ net92 _07331_ VDD VSS DFF_X1
Xdata_out_imag\[103\]$_SDFFE_PN0P_ _00065_ clknet_leaf_82_clk
+ net95 _07330_ VDD VSS DFF_X1
Xdata_out_imag\[104\]$_SDFFE_PN0P_ _00066_ clknet_leaf_0_clk
+ net96 _07329_ VDD VSS DFF_X1
Xdata_out_imag\[105\]$_SDFFE_PN0P_ _00067_ clknet_leaf_0_clk
+ net99 _07328_ VDD VSS DFF_X1
Xdata_out_imag\[106\]$_SDFFE_PN0P_ _00068_ clknet_leaf_81_clk
+ net100 _07327_ VDD VSS DFF_X1
Xdata_out_imag\[107\]$_SDFFE_PN0P_ _00069_ clknet_leaf_81_clk
+ net102 _07326_ VDD VSS DFF_X1
Xdata_out_imag\[108\]$_SDFFE_PN0P_ _00070_ clknet_leaf_80_clk
+ net103 _07325_ VDD VSS DFF_X1
Xdata_out_imag\[109\]$_SDFFE_PN0P_ _00071_ clknet_leaf_81_clk
+ net105 _07324_ VDD VSS DFF_X1
Xdata_out_imag\[10\]$_SDFFE_PN0P_ _00072_ clknet_leaf_0_clk
+ net106 _07323_ VDD VSS DFF_X1
Xdata_out_imag\[110\]$_SDFFE_PN0P_ _00073_ clknet_leaf_80_clk
+ net108 _07322_ VDD VSS DFF_X1
Xdata_out_imag\[111\]$_SDFFE_PN0P_ _00074_ clknet_leaf_1_clk
+ net109 _07321_ VDD VSS DFF_X2
Xdata_out_imag\[112\]$_SDFFE_PN0P_ _00075_ clknet_leaf_80_clk
+ net110 _07320_ VDD VSS DFF_X1
Xdata_out_imag\[113\]$_SDFFE_PN0P_ _00076_ clknet_leaf_81_clk
+ net111 _07319_ VDD VSS DFF_X1
Xdata_out_imag\[114\]$_SDFFE_PN0P_ _00077_ clknet_leaf_1_clk
+ net112 _07318_ VDD VSS DFF_X2
Xdata_out_imag\[115\]$_SDFFE_PN0P_ _00078_ clknet_leaf_1_clk
+ net113 _07317_ VDD VSS DFF_X2
Xdata_out_imag\[116\]$_SDFFE_PN0P_ _00079_ clknet_leaf_0_clk
+ net114 _07316_ VDD VSS DFF_X2
Xdata_out_imag\[117\]$_SDFFE_PN0P_ _00080_ clknet_leaf_0_clk
+ net115 _07315_ VDD VSS DFF_X2
Xdata_out_imag\[118\]$_SDFFE_PN0P_ _00081_ clknet_leaf_81_clk
+ net116 _07314_ VDD VSS DFF_X1
Xdata_out_imag\[119\]$_SDFFE_PN0P_ _00082_ clknet_leaf_80_clk
+ net117 _07313_ VDD VSS DFF_X1
Xdata_out_imag\[11\]$_SDFFE_PN0P_ _00083_ clknet_leaf_80_clk
+ net118 _07312_ VDD VSS DFF_X1
Xdata_out_imag\[120\]$_SDFFE_PN0P_ _00084_ clknet_leaf_80_clk
+ net119 _07311_ VDD VSS DFF_X1
Xdata_out_imag\[121\]$_SDFFE_PN0P_ _00085_ clknet_leaf_81_clk
+ net120 _07310_ VDD VSS DFF_X1
Xdata_out_imag\[122\]$_SDFFE_PN0P_ _00086_ clknet_leaf_8_clk
+ net121 _07309_ VDD VSS DFF_X1
Xdata_out_imag\[123\]$_SDFFE_PN0P_ _00087_ clknet_leaf_80_clk
+ net122 _07308_ VDD VSS DFF_X1
Xdata_out_imag\[124\]$_SDFFE_PN0P_ _00088_ clknet_leaf_8_clk
+ net123 _07307_ VDD VSS DFF_X1
Xdata_out_imag\[125\]$_SDFFE_PN0P_ _00089_ clknet_leaf_9_clk
+ net124 _07306_ VDD VSS DFF_X1
Xdata_out_imag\[126\]$_SDFFE_PN0P_ _00090_ clknet_leaf_19_clk
+ net126 _07305_ VDD VSS DFF_X1
Xdata_out_imag\[127\]$_SDFFE_PN0P_ _00091_ clknet_leaf_19_clk
+ net127 _07304_ VDD VSS DFF_X1
Xdata_out_imag\[12\]$_SDFFE_PN0P_ _00092_ clknet_leaf_19_clk
+ net128 _07303_ VDD VSS DFF_X1
Xdata_out_imag\[13\]$_SDFFE_PN0P_ _00093_ clknet_leaf_20_clk
+ net134 _07302_ VDD VSS DFF_X1
Xdata_out_imag\[14\]$_SDFFE_PN0P_ _00094_ clknet_leaf_27_clk
+ net135 _07301_ VDD VSS DFF_X1
Xdata_out_imag\[15\]$_SDFFE_PN0P_ _00095_ clknet_leaf_30_clk
+ net136 _07300_ VDD VSS DFF_X1
Xdata_out_imag\[16\]$_SDFFE_PN0P_ _00096_ clknet_leaf_31_clk
+ net141 _07299_ VDD VSS DFF_X1
Xdata_out_imag\[17\]$_SDFFE_PN0P_ _00097_ clknet_leaf_29_clk
+ net142 _07298_ VDD VSS DFF_X1
Xdata_out_imag\[18\]$_SDFFE_PN0P_ _00098_ clknet_leaf_31_clk
+ net145 _07297_ VDD VSS DFF_X1
Xdata_out_imag\[19\]$_SDFFE_PN0P_ _00099_ clknet_leaf_30_clk
+ net146 _07296_ VDD VSS DFF_X1
Xdata_out_imag\[1\]$_SDFFE_PN0P_ _00100_ clknet_leaf_29_clk
+ net147 _07295_ VDD VSS DFF_X1
Xdata_out_imag\[20\]$_SDFFE_PN0P_ _00101_ clknet_leaf_28_clk
+ net148 _07294_ VDD VSS DFF_X1
Xdata_out_imag\[21\]$_SDFFE_PN0P_ _00102_ clknet_leaf_28_clk
+ net150 _07293_ VDD VSS DFF_X1
Xdata_out_imag\[22\]$_SDFFE_PN0P_ _00103_ clknet_leaf_27_clk
+ net155 _07292_ VDD VSS DFF_X1
Xdata_out_imag\[23\]$_SDFFE_PN0P_ _00104_ clknet_leaf_22_clk
+ net157 _07291_ VDD VSS DFF_X1
Xdata_out_imag\[24\]$_SDFFE_PN0P_ _00105_ clknet_leaf_20_clk
+ net159 _07290_ VDD VSS DFF_X1
Xdata_out_imag\[25\]$_SDFFE_PN0P_ _00106_ clknet_leaf_21_clk
+ net160 _07289_ VDD VSS DFF_X1
Xdata_out_imag\[26\]$_SDFFE_PN0P_ _00107_ clknet_leaf_20_clk
+ net161 _07288_ VDD VSS DFF_X1
Xdata_out_imag\[27\]$_SDFFE_PN0P_ _00108_ clknet_leaf_20_clk
+ net162 _07287_ VDD VSS DFF_X1
Xdata_out_imag\[28\]$_SDFFE_PN0P_ _00109_ clknet_leaf_20_clk
+ net163 _07286_ VDD VSS DFF_X1
Xdata_out_imag\[29\]$_SDFFE_PN0P_ _00110_ clknet_leaf_21_clk
+ net164 _07285_ VDD VSS DFF_X1
Xdata_out_imag\[2\]$_SDFFE_PN0P_ _00111_ clknet_leaf_31_clk
+ net165 _07284_ VDD VSS DFF_X1
Xdata_out_imag\[30\]$_SDFFE_PN0P_ _00112_ clknet_leaf_27_clk
+ net166 _07283_ VDD VSS DFF_X1
Xdata_out_imag\[31\]$_SDFFE_PN0P_ _00113_ clknet_leaf_31_clk
+ net167 _07282_ VDD VSS DFF_X1
Xdata_out_imag\[32\]$_SDFFE_PN0P_ _00114_ clknet_leaf_28_clk
+ net168 _07281_ VDD VSS DFF_X1
Xdata_out_imag\[33\]$_SDFFE_PN0P_ _00115_ clknet_leaf_28_clk
+ net169 _07280_ VDD VSS DFF_X1
Xdata_out_imag\[34\]$_SDFFE_PN0P_ _00116_ clknet_leaf_31_clk
+ net170 _07279_ VDD VSS DFF_X1
Xdata_out_imag\[35\]$_SDFFE_PN0P_ _00117_ clknet_leaf_31_clk
+ net171 _07278_ VDD VSS DFF_X1
Xdata_out_imag\[36\]$_SDFFE_PN0P_ _00118_ clknet_leaf_29_clk
+ net172 _07277_ VDD VSS DFF_X1
Xdata_out_imag\[37\]$_SDFFE_PN0P_ _00119_ clknet_leaf_28_clk
+ net173 _07276_ VDD VSS DFF_X1
Xdata_out_imag\[38\]$_SDFFE_PN0P_ _00120_ clknet_leaf_27_clk
+ net174 _07275_ VDD VSS DFF_X1
Xdata_out_imag\[39\]$_SDFFE_PN0P_ _00121_ clknet_leaf_21_clk
+ net175 _07274_ VDD VSS DFF_X1
Xdata_out_imag\[3\]$_SDFFE_PN0P_ _00122_ clknet_leaf_28_clk
+ net176 _07273_ VDD VSS DFF_X1
Xdata_out_imag\[40\]$_SDFFE_PN0P_ _00123_ clknet_leaf_21_clk
+ net177 _07272_ VDD VSS DFF_X1
Xdata_out_imag\[41\]$_SDFFE_PN0P_ _00124_ clknet_leaf_21_clk
+ net178 _07271_ VDD VSS DFF_X1
Xdata_out_imag\[42\]$_SDFFE_PN0P_ _00125_ clknet_leaf_21_clk
+ net179 _07270_ VDD VSS DFF_X1
Xdata_out_imag\[43\]$_SDFFE_PN0P_ _00126_ clknet_leaf_20_clk
+ net180 _07269_ VDD VSS DFF_X1
Xdata_out_imag\[44\]$_SDFFE_PN0P_ _00127_ clknet_leaf_20_clk
+ net181 _07268_ VDD VSS DFF_X1
Xdata_out_imag\[45\]$_SDFFE_PN0P_ _00128_ clknet_leaf_21_clk
+ net182 _07267_ VDD VSS DFF_X1
Xdata_out_imag\[46\]$_SDFFE_PN0P_ _00129_ clknet_leaf_27_clk
+ net183 _07266_ VDD VSS DFF_X1
Xdata_out_imag\[47\]$_SDFFE_PN0P_ _00130_ clknet_leaf_30_clk
+ net184 _07265_ VDD VSS DFF_X1
Xdata_out_imag\[48\]$_SDFFE_PN0P_ _00131_ clknet_leaf_30_clk
+ net185 _07264_ VDD VSS DFF_X1
Xdata_out_imag\[49\]$_SDFFE_PN0P_ _00132_ clknet_leaf_29_clk
+ net186 _07263_ VDD VSS DFF_X1
Xdata_out_imag\[4\]$_SDFFE_PN0P_ _00133_ clknet_leaf_28_clk
+ net187 _07262_ VDD VSS DFF_X1
Xdata_out_imag\[50\]$_SDFFE_PN0P_ _00134_ clknet_leaf_30_clk
+ net188 _07261_ VDD VSS DFF_X1
Xdata_out_imag\[51\]$_SDFFE_PN0P_ _00135_ clknet_leaf_29_clk
+ net189 _07260_ VDD VSS DFF_X1
Xdata_out_imag\[52\]$_SDFFE_PN0P_ _00136_ clknet_leaf_26_clk
+ net190 _07259_ VDD VSS DFF_X1
Xdata_out_imag\[53\]$_SDFFE_PN0P_ _00137_ clknet_leaf_29_clk
+ net191 _07258_ VDD VSS DFF_X1
Xdata_out_imag\[54\]$_SDFFE_PN0P_ _00138_ clknet_leaf_22_clk
+ net192 _07257_ VDD VSS DFF_X1
Xdata_out_imag\[55\]$_SDFFE_PN0P_ _00139_ clknet_leaf_22_clk
+ net193 _07256_ VDD VSS DFF_X1
Xdata_out_imag\[56\]$_SDFFE_PN0P_ _00140_ clknet_leaf_18_clk
+ net194 _07255_ VDD VSS DFF_X1
Xdata_out_imag\[57\]$_SDFFE_PN0P_ _00141_ clknet_leaf_19_clk
+ net195 _07254_ VDD VSS DFF_X1
Xdata_out_imag\[58\]$_SDFFE_PN0P_ _00142_ clknet_leaf_18_clk
+ net196 _07253_ VDD VSS DFF_X1
Xdata_out_imag\[59\]$_SDFFE_PN0P_ _00143_ clknet_leaf_18_clk
+ net197 _07252_ VDD VSS DFF_X1
Xdata_out_imag\[5\]$_SDFFE_PN0P_ _00144_ clknet_leaf_17_clk
+ net198 _07251_ VDD VSS DFF_X1
Xdata_out_imag\[60\]$_SDFFE_PN0P_ _00145_ clknet_leaf_17_clk
+ net199 _07250_ VDD VSS DFF_X1
Xdata_out_imag\[61\]$_SDFFE_PN0P_ _00146_ clknet_leaf_17_clk
+ net200 _07249_ VDD VSS DFF_X1
Xdata_out_imag\[62\]$_SDFFE_PN0P_ _00147_ clknet_leaf_17_clk
+ net201 _07248_ VDD VSS DFF_X1
Xdata_out_imag\[63\]$_SDFFE_PN0P_ _00148_ clknet_leaf_18_clk
+ net202 _07247_ VDD VSS DFF_X1
Xdata_out_imag\[64\]$_SDFFE_PN0P_ _00149_ clknet_leaf_18_clk
+ net203 _07246_ VDD VSS DFF_X1
Xdata_out_imag\[65\]$_SDFFE_PN0P_ _00150_ clknet_leaf_11_clk
+ net204 _07245_ VDD VSS DFF_X1
Xdata_out_imag\[66\]$_SDFFE_PN0P_ _00151_ clknet_leaf_10_clk
+ net205 _07244_ VDD VSS DFF_X1
Xdata_out_imag\[67\]$_SDFFE_PN0P_ _00152_ clknet_leaf_10_clk
+ net206 _07243_ VDD VSS DFF_X1
Xdata_out_imag\[68\]$_SDFFE_PN0P_ _00153_ clknet_leaf_9_clk
+ net207 _07242_ VDD VSS DFF_X1
Xdata_out_imag\[69\]$_SDFFE_PN0P_ _00154_ clknet_leaf_9_clk
+ net208 _07241_ VDD VSS DFF_X1
Xdata_out_imag\[6\]$_SDFFE_PN0P_ _00155_ clknet_leaf_9_clk
+ net209 _07240_ VDD VSS DFF_X1
Xdata_out_imag\[70\]$_SDFFE_PN0P_ _00156_ clknet_leaf_9_clk
+ net210 _07239_ VDD VSS DFF_X1
Xdata_out_imag\[71\]$_SDFFE_PN0P_ _00157_ clknet_leaf_9_clk
+ net211 _07238_ VDD VSS DFF_X1
Xdata_out_imag\[72\]$_SDFFE_PN0P_ _00158_ clknet_leaf_9_clk
+ net212 _07237_ VDD VSS DFF_X1
Xdata_out_imag\[73\]$_SDFFE_PN0P_ _00159_ clknet_leaf_9_clk
+ net213 _07236_ VDD VSS DFF_X1
Xdata_out_imag\[74\]$_SDFFE_PN0P_ _00160_ clknet_leaf_10_clk
+ net214 _07235_ VDD VSS DFF_X1
Xdata_out_imag\[75\]$_SDFFE_PN0P_ _00161_ clknet_leaf_10_clk
+ net215 _07234_ VDD VSS DFF_X1
Xdata_out_imag\[76\]$_SDFFE_PN0P_ _00162_ clknet_leaf_10_clk
+ net216 _07233_ VDD VSS DFF_X1
Xdata_out_imag\[77\]$_SDFFE_PN0P_ _00163_ clknet_leaf_10_clk
+ net217 _07232_ VDD VSS DFF_X1
Xdata_out_imag\[78\]$_SDFFE_PN0P_ _00164_ clknet_leaf_11_clk
+ net218 _07231_ VDD VSS DFF_X1
Xdata_out_imag\[79\]$_SDFFE_PN0P_ _00165_ clknet_leaf_11_clk
+ net219 _07230_ VDD VSS DFF_X1
Xdata_out_imag\[7\]$_SDFFE_PN0P_ _00166_ clknet_leaf_11_clk
+ net220 _07229_ VDD VSS DFF_X1
Xdata_out_imag\[80\]$_SDFFE_PN0P_ _00167_ clknet_leaf_12_clk
+ net221 _07228_ VDD VSS DFF_X1
Xdata_out_imag\[81\]$_SDFFE_PN0P_ _00168_ clknet_leaf_11_clk
+ net222 _07227_ VDD VSS DFF_X1
Xdata_out_imag\[82\]$_SDFFE_PN0P_ _00169_ clknet_leaf_11_clk
+ net223 _07226_ VDD VSS DFF_X1
Xdata_out_imag\[83\]$_SDFFE_PN0P_ _00170_ clknet_leaf_11_clk
+ net224 _07225_ VDD VSS DFF_X1
Xdata_out_imag\[84\]$_SDFFE_PN0P_ _00171_ clknet_leaf_16_clk
+ net225 _07224_ VDD VSS DFF_X1
Xdata_out_imag\[85\]$_SDFFE_PN0P_ _00172_ clknet_leaf_11_clk
+ net226 _07223_ VDD VSS DFF_X1
Xdata_out_imag\[86\]$_SDFFE_PN0P_ _00173_ clknet_leaf_12_clk
+ net227 _07222_ VDD VSS DFF_X1
Xdata_out_imag\[87\]$_SDFFE_PN0P_ _00174_ clknet_leaf_16_clk
+ net228 _07221_ VDD VSS DFF_X1
Xdata_out_imag\[88\]$_SDFFE_PN0P_ _00175_ clknet_leaf_17_clk
+ net229 _07220_ VDD VSS DFF_X1
Xdata_out_imag\[89\]$_SDFFE_PN0P_ _00176_ clknet_leaf_16_clk
+ net230 _07219_ VDD VSS DFF_X1
Xdata_out_imag\[8\]$_SDFFE_PN0P_ _00177_ clknet_leaf_17_clk
+ net231 _07218_ VDD VSS DFF_X1
Xdata_out_imag\[90\]$_SDFFE_PN0P_ _00178_ clknet_leaf_16_clk
+ net232 _07217_ VDD VSS DFF_X1
Xdata_out_imag\[91\]$_SDFFE_PN0P_ _00179_ clknet_leaf_17_clk
+ net233 _07216_ VDD VSS DFF_X1
Xdata_out_imag\[92\]$_SDFFE_PN0P_ _00180_ clknet_leaf_16_clk
+ net234 _07215_ VDD VSS DFF_X1
Xdata_out_imag\[93\]$_SDFFE_PN0P_ _00181_ clknet_leaf_18_clk
+ net235 _07214_ VDD VSS DFF_X1
Xdata_out_imag\[94\]$_SDFFE_PN0P_ _00182_ clknet_leaf_17_clk
+ net236 _07213_ VDD VSS DFF_X1
Xdata_out_imag\[95\]$_SDFFE_PN0P_ _00183_ clknet_leaf_16_clk
+ net237 _07212_ VDD VSS DFF_X1
Xdata_out_imag\[96\]$_SDFFE_PN0P_ _00184_ clknet_leaf_27_clk
+ net238 _07211_ VDD VSS DFF_X1
Xdata_out_imag\[97\]$_SDFFE_PN0P_ _00185_ clknet_leaf_12_clk
+ net239 _07210_ VDD VSS DFF_X1
Xdata_out_imag\[98\]$_SDFFE_PN0P_ _00186_ clknet_leaf_16_clk
+ net240 _07209_ VDD VSS DFF_X1
Xdata_out_imag\[99\]$_SDFFE_PN0P_ _00187_ clknet_leaf_12_clk
+ net241 _07208_ VDD VSS DFF_X1
Xdata_out_imag\[9\]$_SDFFE_PN0P_ _00188_ clknet_leaf_27_clk
+ net242 _07207_ VDD VSS DFF_X1
Xdata_out_real\[0\]$_SDFFE_PN0P_ _00189_ clknet_leaf_32_clk
+ net243 _07206_ VDD VSS DFF_X1
Xdata_out_real\[100\]$_SDFFE_PN0P_ _00190_ clknet_leaf_62_clk
+ net244 _07205_ VDD VSS DFF_X1
Xdata_out_real\[101\]$_SDFFE_PN0P_ _00191_ clknet_leaf_62_clk
+ net245 _07204_ VDD VSS DFF_X1
Xdata_out_real\[102\]$_SDFFE_PN0P_ _00192_ clknet_leaf_62_clk
+ net246 _07203_ VDD VSS DFF_X1
Xdata_out_real\[103\]$_SDFFE_PN0P_ _00193_ clknet_leaf_61_clk
+ net247 _07202_ VDD VSS DFF_X1
Xdata_out_real\[104\]$_SDFFE_PN0P_ _00194_ clknet_leaf_61_clk
+ net248 _07201_ VDD VSS DFF_X1
Xdata_out_real\[105\]$_SDFFE_PN0P_ _00195_ clknet_leaf_62_clk
+ net249 _07200_ VDD VSS DFF_X1
Xdata_out_real\[106\]$_SDFFE_PN0P_ _00196_ clknet_leaf_61_clk
+ net250 _07199_ VDD VSS DFF_X1
Xdata_out_real\[107\]$_SDFFE_PN0P_ _00197_ clknet_leaf_57_clk
+ net251 _07198_ VDD VSS DFF_X1
Xdata_out_real\[108\]$_SDFFE_PN0P_ _00198_ clknet_leaf_61_clk
+ net252 _07197_ VDD VSS DFF_X1
Xdata_out_real\[109\]$_SDFFE_PN0P_ _00199_ clknet_leaf_61_clk
+ net253 _07196_ VDD VSS DFF_X1
Xdata_out_real\[10\]$_SDFFE_PN0P_ _00200_ clknet_leaf_57_clk
+ net254 _07195_ VDD VSS DFF_X1
Xdata_out_real\[110\]$_SDFFE_PN0P_ _00201_ clknet_leaf_58_clk
+ net255 _07194_ VDD VSS DFF_X1
Xdata_out_real\[111\]$_SDFFE_PN0P_ _00202_ clknet_leaf_58_clk
+ net256 _07193_ VDD VSS DFF_X1
Xdata_out_real\[112\]$_SDFFE_PN0P_ _00203_ clknet_leaf_59_clk
+ net257 _07192_ VDD VSS DFF_X1
Xdata_out_real\[113\]$_SDFFE_PN0P_ _00204_ clknet_leaf_59_clk
+ net258 _07191_ VDD VSS DFF_X1
Xdata_out_real\[114\]$_SDFFE_PN0P_ _00205_ clknet_leaf_58_clk
+ net259 _07190_ VDD VSS DFF_X1
Xdata_out_real\[115\]$_SDFFE_PN0P_ _00206_ clknet_leaf_59_clk
+ net260 _07189_ VDD VSS DFF_X1
Xdata_out_real\[116\]$_SDFFE_PN0P_ _00207_ clknet_leaf_58_clk
+ net261 _07188_ VDD VSS DFF_X1
Xdata_out_real\[117\]$_SDFFE_PN0P_ _00208_ clknet_leaf_59_clk
+ net262 _07187_ VDD VSS DFF_X1
Xdata_out_real\[118\]$_SDFFE_PN0P_ _00209_ clknet_leaf_58_clk
+ net263 _07186_ VDD VSS DFF_X1
Xdata_out_real\[119\]$_SDFFE_PN0P_ _00210_ clknet_leaf_58_clk
+ net264 _07185_ VDD VSS DFF_X1
Xdata_out_real\[11\]$_SDFFE_PN0P_ _00211_ clknet_leaf_56_clk
+ net265 _07184_ VDD VSS DFF_X1
Xdata_out_real\[120\]$_SDFFE_PN0P_ _00212_ clknet_leaf_56_clk
+ net266 _07183_ VDD VSS DFF_X1
Xdata_out_real\[121\]$_SDFFE_PN0P_ _00213_ clknet_leaf_56_clk
+ net267 _07182_ VDD VSS DFF_X1
Xdata_out_real\[122\]$_SDFFE_PN0P_ _00214_ clknet_leaf_55_clk
+ net268 _07181_ VDD VSS DFF_X1
Xdata_out_real\[123\]$_SDFFE_PN0P_ _00215_ clknet_leaf_55_clk
+ net269 _07180_ VDD VSS DFF_X1
Xdata_out_real\[124\]$_SDFFE_PN0P_ _00216_ clknet_leaf_56_clk
+ net270 _07179_ VDD VSS DFF_X1
Xdata_out_real\[125\]$_SDFFE_PN0P_ _00217_ clknet_leaf_55_clk
+ net271 _07178_ VDD VSS DFF_X1
Xdata_out_real\[126\]$_SDFFE_PN0P_ _00218_ clknet_leaf_56_clk
+ net272 _07177_ VDD VSS DFF_X1
Xdata_out_real\[127\]$_SDFFE_PN0P_ _00219_ clknet_leaf_55_clk
+ net273 _07176_ VDD VSS DFF_X1
Xdata_out_real\[12\]$_SDFFE_PN0P_ _00220_ clknet_leaf_55_clk
+ net274 _07175_ VDD VSS DFF_X1
Xdata_out_real\[13\]$_SDFFE_PN0P_ _00221_ clknet_leaf_55_clk
+ net275 _07174_ VDD VSS DFF_X1
Xdata_out_real\[14\]$_SDFFE_PN0P_ _00222_ clknet_leaf_54_clk
+ net276 _07173_ VDD VSS DFF_X1
Xdata_out_real\[15\]$_SDFFE_PN0P_ _00223_ clknet_leaf_54_clk
+ net277 _07172_ VDD VSS DFF_X1
Xdata_out_real\[16\]$_SDFFE_PN0P_ _00224_ clknet_leaf_50_clk
+ net278 _07171_ VDD VSS DFF_X1
Xdata_out_real\[17\]$_SDFFE_PN0P_ _00225_ clknet_leaf_50_clk
+ net279 _07170_ VDD VSS DFF_X1
Xdata_out_real\[18\]$_SDFFE_PN0P_ _00226_ clknet_leaf_50_clk
+ net280 _07169_ VDD VSS DFF_X1
Xdata_out_real\[19\]$_SDFFE_PN0P_ _00227_ clknet_leaf_50_clk
+ net281 _07168_ VDD VSS DFF_X1
Xdata_out_real\[1\]$_SDFFE_PN0P_ _00228_ clknet_leaf_49_clk
+ net282 _07167_ VDD VSS DFF_X1
Xdata_out_real\[20\]$_SDFFE_PN0P_ _00229_ clknet_leaf_49_clk
+ net283 _07166_ VDD VSS DFF_X1
Xdata_out_real\[21\]$_SDFFE_PN0P_ _00230_ clknet_leaf_48_clk
+ net284 _07165_ VDD VSS DFF_X1
Xdata_out_real\[22\]$_SDFFE_PN0P_ _00231_ clknet_leaf_44_clk
+ net285 _07164_ VDD VSS DFF_X1
Xdata_out_real\[23\]$_SDFFE_PN0P_ _00232_ clknet_leaf_45_clk
+ net286 _07163_ VDD VSS DFF_X1
Xdata_out_real\[24\]$_SDFFE_PN0P_ _00233_ clknet_leaf_45_clk
+ net287 _07162_ VDD VSS DFF_X1
Xdata_out_real\[25\]$_SDFFE_PN0P_ _00234_ clknet_leaf_32_clk
+ net288 _07161_ VDD VSS DFF_X1
Xdata_out_real\[26\]$_SDFFE_PN0P_ _00235_ clknet_leaf_46_clk
+ net289 _07160_ VDD VSS DFF_X1
Xdata_out_real\[27\]$_SDFFE_PN0P_ _00236_ clknet_leaf_49_clk
+ net290 _07159_ VDD VSS DFF_X1
Xdata_out_real\[28\]$_SDFFE_PN0P_ _00237_ clknet_leaf_48_clk
+ net291 _07158_ VDD VSS DFF_X1
Xdata_out_real\[29\]$_SDFFE_PN0P_ _00238_ clknet_leaf_48_clk
+ net292 _07157_ VDD VSS DFF_X1
Xdata_out_real\[2\]$_SDFFE_PN0P_ _00239_ clknet_leaf_32_clk
+ net293 _07156_ VDD VSS DFF_X1
Xdata_out_real\[30\]$_SDFFE_PN0P_ _00240_ clknet_leaf_49_clk
+ net294 _07155_ VDD VSS DFF_X1
Xdata_out_real\[31\]$_SDFFE_PN0P_ _00241_ clknet_leaf_31_clk
+ net295 _07154_ VDD VSS DFF_X1
Xdata_out_real\[32\]$_SDFFE_PN0P_ _00242_ clknet_leaf_46_clk
+ net296 _07153_ VDD VSS DFF_X1
Xdata_out_real\[33\]$_SDFFE_PN0P_ _00243_ clknet_leaf_48_clk
+ net297 _07152_ VDD VSS DFF_X1
Xdata_out_real\[34\]$_SDFFE_PN0P_ _00244_ clknet_leaf_32_clk
+ net298 _07151_ VDD VSS DFF_X1
Xdata_out_real\[35\]$_SDFFE_PN0P_ _00245_ clknet_leaf_47_clk
+ net299 _07150_ VDD VSS DFF_X1
Xdata_out_real\[36\]$_SDFFE_PN0P_ _00246_ clknet_leaf_46_clk
+ net300 _07149_ VDD VSS DFF_X1
Xdata_out_real\[37\]$_SDFFE_PN0P_ _00247_ clknet_leaf_47_clk
+ net301 _07148_ VDD VSS DFF_X1
Xdata_out_real\[38\]$_SDFFE_PN0P_ _00248_ clknet_leaf_32_clk
+ net302 _07147_ VDD VSS DFF_X1
Xdata_out_real\[39\]$_SDFFE_PN0P_ _00249_ clknet_leaf_46_clk
+ net303 _07146_ VDD VSS DFF_X1
Xdata_out_real\[3\]$_SDFFE_PN0P_ _00250_ clknet_leaf_47_clk
+ net304 _07145_ VDD VSS DFF_X1
Xdata_out_real\[40\]$_SDFFE_PN0P_ _00251_ clknet_leaf_45_clk
+ net305 _07144_ VDD VSS DFF_X1
Xdata_out_real\[41\]$_SDFFE_PN0P_ _00252_ clknet_leaf_44_clk
+ net306 _07143_ VDD VSS DFF_X1
Xdata_out_real\[42\]$_SDFFE_PN0P_ _00253_ clknet_leaf_46_clk
+ net307 _07142_ VDD VSS DFF_X1
Xdata_out_real\[43\]$_SDFFE_PN0P_ _00254_ clknet_leaf_55_clk
+ net308 _07141_ VDD VSS DFF_X1
Xdata_out_real\[44\]$_SDFFE_PN0P_ _00255_ clknet_leaf_49_clk
+ net309 _07140_ VDD VSS DFF_X1
Xdata_out_real\[45\]$_SDFFE_PN0P_ _00256_ clknet_leaf_49_clk
+ net310 _07139_ VDD VSS DFF_X1
Xdata_out_real\[46\]$_SDFFE_PN0P_ _00257_ clknet_leaf_49_clk
+ net311 _07138_ VDD VSS DFF_X1
Xdata_out_real\[47\]$_SDFFE_PN0P_ _00258_ clknet_leaf_32_clk
+ net312 _07137_ VDD VSS DFF_X1
Xdata_out_real\[48\]$_SDFFE_PN0P_ _00259_ clknet_leaf_47_clk
+ net313 _07136_ VDD VSS DFF_X1
Xdata_out_real\[49\]$_SDFFE_PN0P_ _00260_ clknet_leaf_48_clk
+ net314 _07135_ VDD VSS DFF_X1
Xdata_out_real\[4\]$_SDFFE_PN0P_ _00261_ clknet_leaf_46_clk
+ net315 _07134_ VDD VSS DFF_X1
Xdata_out_real\[50\]$_SDFFE_PN0P_ _00262_ clknet_leaf_45_clk
+ net316 _07133_ VDD VSS DFF_X1
Xdata_out_real\[51\]$_SDFFE_PN0P_ _00263_ clknet_leaf_48_clk
+ net317 _07132_ VDD VSS DFF_X1
Xdata_out_real\[52\]$_SDFFE_PN0P_ _00264_ clknet_leaf_46_clk
+ net318 _07131_ VDD VSS DFF_X1
Xdata_out_real\[53\]$_SDFFE_PN0P_ _00265_ clknet_leaf_48_clk
+ net319 _07130_ VDD VSS DFF_X1
Xdata_out_real\[54\]$_SDFFE_PN0P_ _00266_ clknet_leaf_45_clk
+ net320 _07129_ VDD VSS DFF_X1
Xdata_out_real\[55\]$_SDFFE_PN0P_ _00267_ clknet_leaf_45_clk
+ net321 _07128_ VDD VSS DFF_X1
Xdata_out_real\[56\]$_SDFFE_PN0P_ _00268_ clknet_leaf_45_clk
+ net322 _07127_ VDD VSS DFF_X1
Xdata_out_real\[57\]$_SDFFE_PN0P_ _00269_ clknet_leaf_45_clk
+ net323 _07126_ VDD VSS DFF_X1
Xdata_out_real\[58\]$_SDFFE_PN0P_ _00270_ clknet_leaf_59_clk
+ net324 _07125_ VDD VSS DFF_X1
Xdata_out_real\[59\]$_SDFFE_PN0P_ _00271_ clknet_leaf_56_clk
+ net325 _07124_ VDD VSS DFF_X1
Xdata_out_real\[5\]$_SDFFE_PN0P_ _00272_ clknet_leaf_59_clk
+ net326 _07123_ VDD VSS DFF_X1
Xdata_out_real\[60\]$_SDFFE_PN0P_ _00273_ clknet_leaf_59_clk
+ net327 _07122_ VDD VSS DFF_X1
Xdata_out_real\[61\]$_SDFFE_PN0P_ _00274_ clknet_leaf_60_clk
+ net328 _07121_ VDD VSS DFF_X1
Xdata_out_real\[62\]$_SDFFE_PN0P_ _00275_ clknet_leaf_56_clk
+ net329 _07120_ VDD VSS DFF_X1
Xdata_out_real\[63\]$_SDFFE_PN0P_ _00276_ clknet_leaf_57_clk
+ net330 _07119_ VDD VSS DFF_X1
Xdata_out_real\[64\]$_SDFFE_PN0P_ _00277_ clknet_leaf_59_clk
+ net331 _07118_ VDD VSS DFF_X1
Xdata_out_real\[65\]$_SDFFE_PN0P_ _00278_ clknet_leaf_56_clk
+ net332 _07117_ VDD VSS DFF_X1
Xdata_out_real\[66\]$_SDFFE_PN0P_ _00279_ clknet_leaf_60_clk
+ net333 _07116_ VDD VSS DFF_X1
Xdata_out_real\[67\]$_SDFFE_PN0P_ _00280_ clknet_leaf_57_clk
+ net334 _07115_ VDD VSS DFF_X1
Xdata_out_real\[68\]$_SDFFE_PN0P_ _00281_ clknet_leaf_60_clk
+ net335 _07114_ VDD VSS DFF_X1
Xdata_out_real\[69\]$_SDFFE_PN0P_ _00282_ clknet_leaf_58_clk
+ net336 _07113_ VDD VSS DFF_X1
Xdata_out_real\[6\]$_SDFFE_PN0P_ _00283_ clknet_leaf_60_clk
+ net337 _07112_ VDD VSS DFF_X1
Xdata_out_real\[70\]$_SDFFE_PN0P_ _00284_ clknet_leaf_57_clk
+ net338 _07111_ VDD VSS DFF_X1
Xdata_out_real\[71\]$_SDFFE_PN0P_ _00285_ clknet_leaf_54_clk
+ net339 _07110_ VDD VSS DFF_X1
Xdata_out_real\[72\]$_SDFFE_PN0P_ _00286_ clknet_leaf_60_clk
+ net340 _07109_ VDD VSS DFF_X1
Xdata_out_real\[73\]$_SDFFE_PN0P_ _00287_ clknet_leaf_54_clk
+ net341 _07108_ VDD VSS DFF_X1
Xdata_out_real\[74\]$_SDFFE_PN0P_ _00288_ clknet_leaf_57_clk
+ net342 _07107_ VDD VSS DFF_X1
Xdata_out_real\[75\]$_SDFFE_PN0P_ _00289_ clknet_leaf_60_clk
+ net343 _07106_ VDD VSS DFF_X1
Xdata_out_real\[76\]$_SDFFE_PN0P_ _00290_ clknet_leaf_57_clk
+ net344 _07105_ VDD VSS DFF_X1
Xdata_out_real\[77\]$_SDFFE_PN0P_ _00291_ clknet_leaf_54_clk
+ net345 _07104_ VDD VSS DFF_X1
Xdata_out_real\[78\]$_SDFFE_PN0P_ _00292_ clknet_leaf_60_clk
+ net346 _07103_ VDD VSS DFF_X1
Xdata_out_real\[79\]$_SDFFE_PN0P_ _00293_ clknet_leaf_61_clk
+ net347 _07102_ VDD VSS DFF_X1
Xdata_out_real\[7\]$_SDFFE_PN0P_ _00294_ clknet_leaf_61_clk
+ net348 _07101_ VDD VSS DFF_X1
Xdata_out_real\[80\]$_SDFFE_PN0P_ _00295_ clknet_leaf_53_clk
+ net349 _07100_ VDD VSS DFF_X1
Xdata_out_real\[81\]$_SDFFE_PN0P_ _00296_ clknet_leaf_63_clk
+ net350 _07099_ VDD VSS DFF_X1
Xdata_out_real\[82\]$_SDFFE_PN0P_ _00297_ clknet_leaf_62_clk
+ net351 _07098_ VDD VSS DFF_X1
Xdata_out_real\[83\]$_SDFFE_PN0P_ _00298_ clknet_leaf_54_clk
+ net352 _07097_ VDD VSS DFF_X1
Xdata_out_real\[84\]$_SDFFE_PN0P_ _00299_ clknet_leaf_54_clk
+ net353 _07096_ VDD VSS DFF_X1
Xdata_out_real\[85\]$_SDFFE_PN0P_ _00300_ clknet_leaf_62_clk
+ net354 _07095_ VDD VSS DFF_X1
Xdata_out_real\[86\]$_SDFFE_PN0P_ _00301_ clknet_leaf_63_clk
+ net355 _07094_ VDD VSS DFF_X1
Xdata_out_real\[87\]$_SDFFE_PN0P_ _00302_ clknet_leaf_63_clk
+ net356 _07093_ VDD VSS DFF_X1
Xdata_out_real\[88\]$_SDFFE_PN0P_ _00303_ clknet_leaf_66_clk
+ net357 _07092_ VDD VSS DFF_X1
Xdata_out_real\[89\]$_SDFFE_PN0P_ _00304_ clknet_leaf_67_clk
+ net358 _07091_ VDD VSS DFF_X2
Xdata_out_real\[8\]$_SDFFE_PN0P_ _00305_ clknet_leaf_68_clk
+ net359 _07090_ VDD VSS DFF_X2
Xdata_out_real\[90\]$_SDFFE_PN0P_ _00306_ clknet_leaf_67_clk
+ net360 _07089_ VDD VSS DFF_X2
Xdata_out_real\[91\]$_SDFFE_PN0P_ _00307_ clknet_leaf_65_clk
+ net361 _07088_ VDD VSS DFF_X1
Xdata_out_real\[92\]$_SDFFE_PN0P_ _00308_ clknet_leaf_65_clk
+ net362 _07087_ VDD VSS DFF_X2
Xdata_out_real\[93\]$_SDFFE_PN0P_ _00309_ clknet_leaf_68_clk
+ net363 _07086_ VDD VSS DFF_X2
Xdata_out_real\[94\]$_SDFFE_PN0P_ _00310_ clknet_leaf_76_clk
+ net364 _07085_ VDD VSS DFF_X2
Xdata_out_real\[95\]$_SDFFE_PN0P_ _00311_ clknet_leaf_74_clk
+ net365 _07084_ VDD VSS DFF_X2
Xdata_out_real\[96\]$_SDFFE_PN0P_ _00312_ clknet_leaf_76_clk
+ net366 _07083_ VDD VSS DFF_X2
Xdata_out_real\[97\]$_SDFFE_PN0P_ _00313_ clknet_leaf_76_clk
+ net367 _07082_ VDD VSS DFF_X2
Xdata_out_real\[98\]$_SDFFE_PN0P_ _00314_ clknet_leaf_75_clk
+ net368 _07081_ VDD VSS DFF_X2
Xdata_out_real\[99\]$_SDFFE_PN0P_ _00315_ clknet_leaf_76_clk
+ net369 _07080_ VDD VSS DFF_X2
Xdata_out_real\[9\]$_SDFFE_PN0P_ _00316_ clknet_leaf_79_clk
+ net370 _07079_ VDD VSS DFF_X2
Xdata_ready$_SDFFE_PN1P_ _00317_ clknet_leaf_79_clk net371
+ _07078_ VDD VSS DFF_X2
Xdata_valid_out$_SDFFE_PN0P_ _00318_ clknet_leaf_1_clk net372
+ _07077_ VDD VSS DFF_X2
Xgroup\[0\]$_DFFE_PP_ _00319_ clknet_leaf_77_clk group\[0\]
+ _07076_ VDD VSS DFF_X1
Xgroup\[1\]$_DFFE_PP_ _00320_ clknet_leaf_77_clk group\[1\]
+ _07075_ VDD VSS DFF_X1
Xgroup\[2\]$_DFFE_PP_ _00321_ clknet_leaf_77_clk group\[2\]
+ _07074_ VDD VSS DFF_X1
Xidx1\[0\]$_DFFE_PP_ _00013_ clknet_leaf_74_clk idx1\[0\]
+ _00038_ VDD VSS DFF_X1
Xidx1\[1\]$_DFFE_PP_ _00014_ clknet_leaf_79_clk idx1\[1\]
+ _00026_ VDD VSS DFF_X1
Xidx1\[2\]$_DFFE_PP_ _00015_ clknet_leaf_74_clk idx1\[2\]
+ _00028_ VDD VSS DFF_X1
Xidx2\[0\]$_DFFE_PP_ _00016_ clknet_leaf_36_clk idx2\[0\]
+ _00030_ VDD VSS DFF_X1
Xidx2\[1\]$_DFFE_PP_ _00017_ clknet_leaf_37_clk idx2\[1\]
+ _07073_ VDD VSS DFF_X2
Xidx2\[2\]$_DFFE_PP_ _00018_ clknet_leaf_37_clk idx2\[2\]
+ _07072_ VDD VSS DFF_X1
Xsample_count\[0\]$_SDFFE_PN0P_ _00322_ clknet_leaf_2_clk
+ sample_count\[0\] _09376_ VDD VSS DFF_X1
Xsample_count\[1\]$_SDFFE_PN0P_ _00323_ clknet_leaf_2_clk
+ sample_count\[1\] _09377_ VDD VSS DFF_X1
Xsample_count\[2\]$_SDFFE_PN0P_ _00324_ clknet_leaf_2_clk
+ sample_count\[2\] _07071_ VDD VSS DFF_X1
Xsamples_imag\[0\]\[0\]$_DFFE_PP_ _00325_ clknet_leaf_3_clk
+ samples_imag\[0\]\[0\] _07070_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[10\]$_DFFE_PP_ _00326_ clknet_leaf_6_clk
+ samples_imag\[0\]\[10\] _07069_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[11\]$_DFFE_PP_ _00327_ clknet_leaf_7_clk
+ samples_imag\[0\]\[11\] _07068_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[12\]$_DFFE_PP_ _00328_ clknet_leaf_6_clk
+ samples_imag\[0\]\[12\] _07067_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[13\]$_DFFE_PP_ _00329_ clknet_leaf_6_clk
+ samples_imag\[0\]\[13\] _07066_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[14\]$_DFFE_PP_ _00330_ clknet_leaf_4_clk
+ samples_imag\[0\]\[14\] _07065_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[15\]$_DFFE_PP_ _00331_ clknet_leaf_3_clk
+ samples_imag\[0\]\[15\] _07064_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[1\]$_DFFE_PP_ _00332_ clknet_leaf_4_clk
+ samples_imag\[0\]\[1\] _07063_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[2\]$_DFFE_PP_ _00333_ clknet_leaf_37_clk
+ samples_imag\[0\]\[2\] _07062_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[3\]$_DFFE_PP_ _00334_ clknet_leaf_3_clk
+ samples_imag\[0\]\[3\] _07061_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[4\]$_DFFE_PP_ _00335_ clknet_leaf_4_clk
+ samples_imag\[0\]\[4\] _07060_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[5\]$_DFFE_PP_ _00336_ clknet_leaf_4_clk
+ samples_imag\[0\]\[5\] _07059_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[6\]$_DFFE_PP_ _00337_ clknet_leaf_5_clk
+ samples_imag\[0\]\[6\] _07058_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[7\]$_DFFE_PP_ _00338_ clknet_leaf_5_clk
+ samples_imag\[0\]\[7\] _07057_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[8\]$_DFFE_PP_ _00339_ clknet_leaf_5_clk
+ samples_imag\[0\]\[8\] _07056_ VDD VSS DFF_X2
Xsamples_imag\[0\]\[9\]$_DFFE_PP_ _00340_ clknet_leaf_6_clk
+ samples_imag\[0\]\[9\] _07055_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[0\]$_DFFE_PP_ _00341_ clknet_leaf_30_clk
+ samples_imag\[1\]\[0\] _07054_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[10\]$_DFFE_PP_ _00342_ clknet_leaf_19_clk
+ samples_imag\[1\]\[10\] _07053_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[11\]$_DFFE_PP_ _00343_ clknet_leaf_19_clk
+ samples_imag\[1\]\[11\] _07052_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[12\]$_DFFE_PP_ _00344_ clknet_leaf_23_clk
+ samples_imag\[1\]\[12\] _07051_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[13\]$_DFFE_PP_ _00345_ clknet_leaf_23_clk
+ samples_imag\[1\]\[13\] _07050_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[14\]$_DFFE_PP_ _00346_ clknet_leaf_26_clk
+ samples_imag\[1\]\[14\] _07049_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[15\]$_DFFE_PP_ _00347_ clknet_leaf_33_clk
+ samples_imag\[1\]\[15\] _07048_ VDD VSS DFF_X2
Xsamples_imag\[1\]\[1\]$_DFFE_PP_ _00348_ clknet_leaf_25_clk
+ samples_imag\[1\]\[1\] _07047_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[2\]$_DFFE_PP_ _00349_ clknet_leaf_33_clk
+ samples_imag\[1\]\[2\] _07046_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[3\]$_DFFE_PP_ _00350_ clknet_leaf_34_clk
+ samples_imag\[1\]\[3\] _07045_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[4\]$_DFFE_PP_ _00351_ clknet_leaf_34_clk
+ samples_imag\[1\]\[4\] _07044_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[5\]$_DFFE_PP_ _00352_ clknet_leaf_25_clk
+ samples_imag\[1\]\[5\] _07043_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[6\]$_DFFE_PP_ _00353_ clknet_leaf_25_clk
+ samples_imag\[1\]\[6\] _07042_ VDD VSS DFF_X2
Xsamples_imag\[1\]\[7\]$_DFFE_PP_ _00354_ clknet_leaf_22_clk
+ samples_imag\[1\]\[7\] _07041_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[8\]$_DFFE_PP_ _00355_ clknet_leaf_23_clk
+ samples_imag\[1\]\[8\] _07040_ VDD VSS DFF_X1
Xsamples_imag\[1\]\[9\]$_DFFE_PP_ _00356_ clknet_leaf_23_clk
+ samples_imag\[1\]\[9\] _07039_ VDD VSS DFF_X1
Xsamples_imag\[2\]\[0\]$_DFFE_PP_ _00357_ clknet_leaf_26_clk
+ samples_imag\[2\]\[0\] _07038_ VDD VSS DFF_X2
Xsamples_imag\[2\]\[10\]$_DFFE_PP_ _00358_ clknet_leaf_23_clk
+ samples_imag\[2\]\[10\] _07037_ VDD VSS DFF_X1
Xsamples_imag\[2\]\[11\]$_DFFE_PP_ _00359_ clknet_leaf_23_clk
+ samples_imag\[2\]\[11\] _07036_ VDD VSS DFF_X1
Xsamples_imag\[2\]\[12\]$_DFFE_PP_ _00360_ clknet_leaf_23_clk
+ samples_imag\[2\]\[12\] _07035_ VDD VSS DFF_X1
Xsamples_imag\[2\]\[13\]$_DFFE_PP_ _00361_ clknet_leaf_22_clk
+ samples_imag\[2\]\[13\] _07034_ VDD VSS DFF_X1
Xsamples_imag\[2\]\[14\]$_DFFE_PP_ _00362_ clknet_leaf_22_clk
+ samples_imag\[2\]\[14\] _07033_ VDD VSS DFF_X2
Xsamples_imag\[2\]\[15\]$_DFFE_PP_ _00363_ clknet_leaf_34_clk
+ samples_imag\[2\]\[15\] _07032_ VDD VSS DFF_X2
Xsamples_imag\[2\]\[1\]$_DFFE_PP_ _00364_ clknet_leaf_26_clk
+ samples_imag\[2\]\[1\] _07031_ VDD VSS DFF_X2
Xsamples_imag\[2\]\[2\]$_DFFE_PP_ _00365_ clknet_leaf_34_clk
+ samples_imag\[2\]\[2\] _07030_ VDD VSS DFF_X2
Xsamples_imag\[2\]\[3\]$_DFFE_PP_ _00366_ clknet_leaf_34_clk
+ samples_imag\[2\]\[3\] _07029_ VDD VSS DFF_X2
Xsamples_imag\[2\]\[4\]$_DFFE_PP_ _00367_ clknet_leaf_34_clk
+ samples_imag\[2\]\[4\] _07028_ VDD VSS DFF_X2
Xsamples_imag\[2\]\[5\]$_DFFE_PP_ _00368_ clknet_leaf_26_clk
+ samples_imag\[2\]\[5\] _07027_ VDD VSS DFF_X1
Xsamples_imag\[2\]\[6\]$_DFFE_PP_ _00369_ clknet_leaf_25_clk
+ samples_imag\[2\]\[6\] _07026_ VDD VSS DFF_X2
Xsamples_imag\[2\]\[7\]$_DFFE_PP_ _00370_ clknet_leaf_22_clk
+ samples_imag\[2\]\[7\] _07025_ VDD VSS DFF_X2
Xsamples_imag\[2\]\[8\]$_DFFE_PP_ _00371_ clknet_leaf_24_clk
+ samples_imag\[2\]\[8\] _07024_ VDD VSS DFF_X1
Xsamples_imag\[2\]\[9\]$_DFFE_PP_ _00372_ clknet_leaf_24_clk
+ samples_imag\[2\]\[9\] _07023_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[0\]$_DFFE_PP_ _00373_ clknet_leaf_30_clk
+ samples_imag\[3\]\[0\] _07022_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[10\]$_DFFE_PP_ _00374_ clknet_leaf_23_clk
+ samples_imag\[3\]\[10\] _07021_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[11\]$_DFFE_PP_ _00375_ clknet_leaf_18_clk
+ samples_imag\[3\]\[11\] _07020_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[12\]$_DFFE_PP_ _00376_ clknet_leaf_15_clk
+ samples_imag\[3\]\[12\] _07019_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[13\]$_DFFE_PP_ _00377_ clknet_leaf_15_clk
+ samples_imag\[3\]\[13\] _07018_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[14\]$_DFFE_PP_ _00378_ clknet_leaf_18_clk
+ samples_imag\[3\]\[14\] _07017_ VDD VSS DFF_X2
Xsamples_imag\[3\]\[15\]$_DFFE_PP_ _00379_ clknet_leaf_33_clk
+ samples_imag\[3\]\[15\] _07016_ VDD VSS DFF_X2
Xsamples_imag\[3\]\[1\]$_DFFE_PP_ _00380_ clknet_leaf_26_clk
+ samples_imag\[3\]\[1\] _07015_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[2\]$_DFFE_PP_ _00381_ clknet_leaf_33_clk
+ samples_imag\[3\]\[2\] _07014_ VDD VSS DFF_X2
Xsamples_imag\[3\]\[3\]$_DFFE_PP_ _00382_ clknet_leaf_34_clk
+ samples_imag\[3\]\[3\] _07013_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[4\]$_DFFE_PP_ _00383_ clknet_leaf_25_clk
+ samples_imag\[3\]\[4\] _07012_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[5\]$_DFFE_PP_ _00384_ clknet_leaf_26_clk
+ samples_imag\[3\]\[5\] _07011_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[6\]$_DFFE_PP_ _00385_ clknet_leaf_25_clk
+ samples_imag\[3\]\[6\] _07010_ VDD VSS DFF_X2
Xsamples_imag\[3\]\[7\]$_DFFE_PP_ _00386_ clknet_leaf_24_clk
+ samples_imag\[3\]\[7\] _07009_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[8\]$_DFFE_PP_ _00387_ clknet_leaf_24_clk
+ samples_imag\[3\]\[8\] _07008_ VDD VSS DFF_X1
Xsamples_imag\[3\]\[9\]$_DFFE_PP_ _00388_ clknet_leaf_24_clk
+ samples_imag\[3\]\[9\] _07007_ VDD VSS DFF_X1
Xsamples_imag\[4\]\[0\]$_DFFE_PP_ _00389_ clknet_leaf_15_clk
+ samples_imag\[4\]\[0\] _07006_ VDD VSS DFF_X2
Xsamples_imag\[4\]\[10\]$_DFFE_PP_ _00390_ clknet_leaf_13_clk
+ samples_imag\[4\]\[10\] _07005_ VDD VSS DFF_X1
Xsamples_imag\[4\]\[11\]$_DFFE_PP_ _00391_ clknet_leaf_13_clk
+ samples_imag\[4\]\[11\] _07004_ VDD VSS DFF_X1
Xsamples_imag\[4\]\[12\]$_DFFE_PP_ _00392_ clknet_leaf_13_clk
+ samples_imag\[4\]\[12\] _07003_ VDD VSS DFF_X1
Xsamples_imag\[4\]\[13\]$_DFFE_PP_ _00393_ clknet_leaf_12_clk
+ samples_imag\[4\]\[13\] _07002_ VDD VSS DFF_X1
Xsamples_imag\[4\]\[14\]$_DFFE_PP_ _00394_ clknet_leaf_15_clk
+ samples_imag\[4\]\[14\] _07001_ VDD VSS DFF_X2
Xsamples_imag\[4\]\[15\]$_DFFE_PP_ _00395_ clknet_leaf_35_clk
+ samples_imag\[4\]\[15\] _07000_ VDD VSS DFF_X2
Xsamples_imag\[4\]\[1\]$_DFFE_PP_ _00396_ clknet_leaf_15_clk
+ samples_imag\[4\]\[1\] _06999_ VDD VSS DFF_X2
Xsamples_imag\[4\]\[2\]$_DFFE_PP_ _00397_ clknet_leaf_35_clk
+ samples_imag\[4\]\[2\] _06998_ VDD VSS DFF_X2
Xsamples_imag\[4\]\[3\]$_DFFE_PP_ _00398_ clknet_leaf_35_clk
+ samples_imag\[4\]\[3\] _06997_ VDD VSS DFF_X2
Xsamples_imag\[4\]\[4\]$_DFFE_PP_ _00399_ clknet_leaf_13_clk
+ samples_imag\[4\]\[4\] _06996_ VDD VSS DFF_X2
Xsamples_imag\[4\]\[5\]$_DFFE_PP_ _00400_ clknet_leaf_13_clk
+ samples_imag\[4\]\[5\] _06995_ VDD VSS DFF_X2
Xsamples_imag\[4\]\[6\]$_DFFE_PP_ _00401_ clknet_leaf_13_clk
+ samples_imag\[4\]\[6\] _06994_ VDD VSS DFF_X1
Xsamples_imag\[4\]\[7\]$_DFFE_PP_ _00402_ clknet_leaf_5_clk
+ samples_imag\[4\]\[7\] _06993_ VDD VSS DFF_X1
Xsamples_imag\[4\]\[8\]$_DFFE_PP_ _00403_ clknet_leaf_5_clk
+ samples_imag\[4\]\[8\] _06992_ VDD VSS DFF_X1
Xsamples_imag\[4\]\[9\]$_DFFE_PP_ _00404_ clknet_leaf_5_clk
+ samples_imag\[4\]\[9\] _06991_ VDD VSS DFF_X1
Xsamples_imag\[5\]\[0\]$_DFFE_PP_ _00405_ clknet_leaf_14_clk
+ samples_imag\[5\]\[0\] _06990_ VDD VSS DFF_X2
Xsamples_imag\[5\]\[10\]$_DFFE_PP_ _00406_ clknet_leaf_14_clk
+ samples_imag\[5\]\[10\] _06989_ VDD VSS DFF_X1
Xsamples_imag\[5\]\[11\]$_DFFE_PP_ _00407_ clknet_leaf_15_clk
+ samples_imag\[5\]\[11\] _06988_ VDD VSS DFF_X1
Xsamples_imag\[5\]\[12\]$_DFFE_PP_ _00408_ clknet_leaf_16_clk
+ samples_imag\[5\]\[12\] _06987_ VDD VSS DFF_X1
Xsamples_imag\[5\]\[13\]$_DFFE_PP_ _00409_ clknet_leaf_15_clk
+ samples_imag\[5\]\[13\] _06986_ VDD VSS DFF_X1
Xsamples_imag\[5\]\[14\]$_DFFE_PP_ _00410_ clknet_leaf_15_clk
+ samples_imag\[5\]\[14\] _06985_ VDD VSS DFF_X1
Xsamples_imag\[5\]\[15\]$_DFFE_PP_ _00411_ clknet_leaf_35_clk
+ samples_imag\[5\]\[15\] _06984_ VDD VSS DFF_X1
Xsamples_imag\[5\]\[1\]$_DFFE_PP_ _00412_ clknet_leaf_12_clk
+ samples_imag\[5\]\[1\] _06983_ VDD VSS DFF_X1
Xsamples_imag\[5\]\[2\]$_DFFE_PP_ _00413_ clknet_leaf_35_clk
+ samples_imag\[5\]\[2\] _06982_ VDD VSS DFF_X2
Xsamples_imag\[5\]\[3\]$_DFFE_PP_ _00414_ clknet_leaf_35_clk
+ samples_imag\[5\]\[3\] _06981_ VDD VSS DFF_X2
Xsamples_imag\[5\]\[4\]$_DFFE_PP_ _00415_ clknet_leaf_14_clk
+ samples_imag\[5\]\[4\] _06980_ VDD VSS DFF_X2
Xsamples_imag\[5\]\[5\]$_DFFE_PP_ _00416_ clknet_leaf_14_clk
+ samples_imag\[5\]\[5\] _06979_ VDD VSS DFF_X2
Xsamples_imag\[5\]\[6\]$_DFFE_PP_ _00417_ clknet_leaf_12_clk
+ samples_imag\[5\]\[6\] _06978_ VDD VSS DFF_X1
Xsamples_imag\[5\]\[7\]$_DFFE_PP_ _00418_ clknet_leaf_14_clk
+ samples_imag\[5\]\[7\] _06977_ VDD VSS DFF_X2
Xsamples_imag\[5\]\[8\]$_DFFE_PP_ _00419_ clknet_leaf_14_clk
+ samples_imag\[5\]\[8\] _06976_ VDD VSS DFF_X2
Xsamples_imag\[5\]\[9\]$_DFFE_PP_ _00420_ clknet_leaf_14_clk
+ samples_imag\[5\]\[9\] _06975_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[0\]$_DFFE_PP_ _00421_ clknet_leaf_5_clk
+ samples_imag\[6\]\[0\] _06974_ VDD VSS DFF_X1
Xsamples_imag\[6\]\[10\]$_DFFE_PP_ _00422_ clknet_leaf_82_clk
+ samples_imag\[6\]\[10\] _06973_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[11\]$_DFFE_PP_ _00423_ clknet_leaf_7_clk
+ samples_imag\[6\]\[11\] _06972_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[12\]$_DFFE_PP_ _00424_ clknet_leaf_8_clk
+ samples_imag\[6\]\[12\] _06971_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[13\]$_DFFE_PP_ _00425_ clknet_leaf_7_clk
+ samples_imag\[6\]\[13\] _06970_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[14\]$_DFFE_PP_ _00426_ clknet_leaf_7_clk
+ samples_imag\[6\]\[14\] _06969_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[15\]$_DFFE_PP_ _00427_ clknet_leaf_36_clk
+ samples_imag\[6\]\[15\] _06968_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[1\]$_DFFE_PP_ _00428_ clknet_leaf_6_clk
+ samples_imag\[6\]\[1\] _06967_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[2\]$_DFFE_PP_ _00429_ clknet_leaf_36_clk
+ samples_imag\[6\]\[2\] _06966_ VDD VSS DFF_X1
Xsamples_imag\[6\]\[3\]$_DFFE_PP_ _00430_ clknet_leaf_4_clk
+ samples_imag\[6\]\[3\] _06965_ VDD VSS DFF_X1
Xsamples_imag\[6\]\[4\]$_DFFE_PP_ _00431_ clknet_leaf_3_clk
+ samples_imag\[6\]\[4\] _06964_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[5\]$_DFFE_PP_ _00432_ clknet_leaf_3_clk
+ samples_imag\[6\]\[5\] _06963_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[6\]$_DFFE_PP_ _00433_ clknet_leaf_82_clk
+ samples_imag\[6\]\[6\] _06962_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[7\]$_DFFE_PP_ _00434_ clknet_leaf_82_clk
+ samples_imag\[6\]\[7\] _06961_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[8\]$_DFFE_PP_ _00435_ clknet_leaf_82_clk
+ samples_imag\[6\]\[8\] _06960_ VDD VSS DFF_X2
Xsamples_imag\[6\]\[9\]$_DFFE_PP_ _00436_ clknet_leaf_82_clk
+ samples_imag\[6\]\[9\] _06959_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[0\]$_DFFE_PP_ _00437_ clknet_leaf_7_clk
+ samples_imag\[7\]\[0\] _06958_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[10\]$_DFFE_PP_ _00438_ clknet_leaf_7_clk
+ samples_imag\[7\]\[10\] _06957_ VDD VSS DFF_X1
Xsamples_imag\[7\]\[11\]$_DFFE_PP_ _00439_ clknet_leaf_8_clk
+ samples_imag\[7\]\[11\] _06956_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[12\]$_DFFE_PP_ _00440_ clknet_leaf_8_clk
+ samples_imag\[7\]\[12\] _06955_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[13\]$_DFFE_PP_ _00441_ clknet_leaf_8_clk
+ samples_imag\[7\]\[13\] _06954_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[14\]$_DFFE_PP_ _00442_ clknet_leaf_10_clk
+ samples_imag\[7\]\[14\] _06953_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[15\]$_DFFE_PP_ _00443_ clknet_leaf_36_clk
+ samples_imag\[7\]\[15\] _06952_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[1\]$_DFFE_PP_ _00444_ clknet_leaf_7_clk
+ samples_imag\[7\]\[1\] _06951_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[2\]$_DFFE_PP_ _00445_ clknet_leaf_36_clk
+ samples_imag\[7\]\[2\] _06950_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[3\]$_DFFE_PP_ _00446_ clknet_leaf_4_clk
+ samples_imag\[7\]\[3\] _06949_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[4\]$_DFFE_PP_ _00447_ clknet_leaf_4_clk
+ samples_imag\[7\]\[4\] _06948_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[5\]$_DFFE_PP_ _00448_ clknet_leaf_4_clk
+ samples_imag\[7\]\[5\] _06947_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[6\]$_DFFE_PP_ _00449_ clknet_leaf_8_clk
+ samples_imag\[7\]\[6\] _06946_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[7\]$_DFFE_PP_ _00450_ clknet_leaf_82_clk
+ samples_imag\[7\]\[7\] _06945_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[8\]$_DFFE_PP_ _00451_ clknet_leaf_82_clk
+ samples_imag\[7\]\[8\] _06944_ VDD VSS DFF_X2
Xsamples_imag\[7\]\[9\]$_DFFE_PP_ _00452_ clknet_leaf_6_clk
+ samples_imag\[7\]\[9\] _06943_ VDD VSS DFF_X2
Xsamples_real\[0\]\[0\]$_DFFE_PP_ _00453_ clknet_leaf_40_clk
+ samples_real\[0\]\[0\] _06942_ VDD VSS DFF_X1
Xsamples_real\[0\]\[10\]$_DFFE_PP_ _00454_ clknet_leaf_72_clk
+ samples_real\[0\]\[10\] _06941_ VDD VSS DFF_X2
Xsamples_real\[0\]\[11\]$_DFFE_PP_ _00455_ clknet_leaf_71_clk
+ samples_real\[0\]\[11\] _06940_ VDD VSS DFF_X2
Xsamples_real\[0\]\[12\]$_DFFE_PP_ _00456_ clknet_leaf_70_clk
+ samples_real\[0\]\[12\] _06939_ VDD VSS DFF_X2
Xsamples_real\[0\]\[13\]$_DFFE_PP_ _00457_ clknet_leaf_69_clk
+ samples_real\[0\]\[13\] _06938_ VDD VSS DFF_X2
Xsamples_real\[0\]\[14\]$_DFFE_PP_ _00458_ clknet_leaf_70_clk
+ samples_real\[0\]\[14\] _06937_ VDD VSS DFF_X2
Xsamples_real\[0\]\[15\]$_DFFE_PP_ _00459_ clknet_leaf_37_clk
+ samples_real\[0\]\[15\] _06936_ VDD VSS DFF_X2
Xsamples_real\[0\]\[1\]$_DFFE_PP_ _00460_ clknet_leaf_71_clk
+ samples_real\[0\]\[1\] _06935_ VDD VSS DFF_X2
Xsamples_real\[0\]\[2\]$_DFFE_PP_ _00461_ clknet_leaf_38_clk
+ samples_real\[0\]\[2\] _06934_ VDD VSS DFF_X2
Xsamples_real\[0\]\[3\]$_DFFE_PP_ _00462_ clknet_leaf_72_clk
+ samples_real\[0\]\[3\] _06933_ VDD VSS DFF_X2
Xsamples_real\[0\]\[4\]$_DFFE_PP_ _00463_ clknet_leaf_38_clk
+ samples_real\[0\]\[4\] _06932_ VDD VSS DFF_X2
Xsamples_real\[0\]\[5\]$_DFFE_PP_ _00464_ clknet_leaf_73_clk
+ samples_real\[0\]\[5\] _06931_ VDD VSS DFF_X2
Xsamples_real\[0\]\[6\]$_DFFE_PP_ _00465_ clknet_leaf_38_clk
+ samples_real\[0\]\[6\] _06930_ VDD VSS DFF_X2
Xsamples_real\[0\]\[7\]$_DFFE_PP_ _00466_ clknet_leaf_38_clk
+ samples_real\[0\]\[7\] _06929_ VDD VSS DFF_X2
Xsamples_real\[0\]\[8\]$_DFFE_PP_ _00467_ clknet_leaf_73_clk
+ samples_real\[0\]\[8\] _06928_ VDD VSS DFF_X2
Xsamples_real\[0\]\[9\]$_DFFE_PP_ _00468_ clknet_leaf_37_clk
+ samples_real\[0\]\[9\] _06927_ VDD VSS DFF_X2
Xsamples_real\[1\]\[0\]$_DFFE_PP_ _00469_ clknet_leaf_50_clk
+ samples_real\[1\]\[0\] _06926_ VDD VSS DFF_X1
Xsamples_real\[1\]\[10\]$_DFFE_PP_ _00470_ clknet_leaf_43_clk
+ samples_real\[1\]\[10\] _06925_ VDD VSS DFF_X1
Xsamples_real\[1\]\[11\]$_DFFE_PP_ _00471_ clknet_leaf_51_clk
+ samples_real\[1\]\[11\] _06924_ VDD VSS DFF_X1
Xsamples_real\[1\]\[12\]$_DFFE_PP_ _00472_ clknet_leaf_50_clk
+ samples_real\[1\]\[12\] _06923_ VDD VSS DFF_X1
Xsamples_real\[1\]\[13\]$_DFFE_PP_ _00473_ clknet_leaf_52_clk
+ samples_real\[1\]\[13\] _06922_ VDD VSS DFF_X2
Xsamples_real\[1\]\[14\]$_DFFE_PP_ _00474_ clknet_leaf_52_clk
+ samples_real\[1\]\[14\] _06921_ VDD VSS DFF_X1
Xsamples_real\[1\]\[15\]$_DFFE_PP_ _00475_ clknet_leaf_33_clk
+ samples_real\[1\]\[15\] _06920_ VDD VSS DFF_X1
Xsamples_real\[1\]\[1\]$_DFFE_PP_ _00476_ clknet_leaf_51_clk
+ samples_real\[1\]\[1\] _06919_ VDD VSS DFF_X1
Xsamples_real\[1\]\[2\]$_DFFE_PP_ _00477_ clknet_leaf_42_clk
+ samples_real\[1\]\[2\] _06918_ VDD VSS DFF_X2
Xsamples_real\[1\]\[3\]$_DFFE_PP_ _00478_ clknet_leaf_51_clk
+ samples_real\[1\]\[3\] _06917_ VDD VSS DFF_X1
Xsamples_real\[1\]\[4\]$_DFFE_PP_ _00479_ clknet_leaf_47_clk
+ samples_real\[1\]\[4\] _06916_ VDD VSS DFF_X1
Xsamples_real\[1\]\[5\]$_DFFE_PP_ _00480_ clknet_leaf_50_clk
+ samples_real\[1\]\[5\] _06915_ VDD VSS DFF_X1
Xsamples_real\[1\]\[6\]$_DFFE_PP_ _00481_ clknet_leaf_44_clk
+ samples_real\[1\]\[6\] _06914_ VDD VSS DFF_X1
Xsamples_real\[1\]\[7\]$_DFFE_PP_ _00482_ clknet_leaf_42_clk
+ samples_real\[1\]\[7\] _06913_ VDD VSS DFF_X1
Xsamples_real\[1\]\[8\]$_DFFE_PP_ _00483_ clknet_leaf_44_clk
+ samples_real\[1\]\[8\] _06912_ VDD VSS DFF_X1
Xsamples_real\[1\]\[9\]$_DFFE_PP_ _00484_ clknet_leaf_44_clk
+ samples_real\[1\]\[9\] _06911_ VDD VSS DFF_X1
Xsamples_real\[2\]\[0\]$_DFFE_PP_ _00485_ clknet_leaf_41_clk
+ samples_real\[2\]\[0\] _06910_ VDD VSS DFF_X1
Xsamples_real\[2\]\[10\]$_DFFE_PP_ _00486_ clknet_leaf_41_clk
+ samples_real\[2\]\[10\] _06909_ VDD VSS DFF_X1
Xsamples_real\[2\]\[11\]$_DFFE_PP_ _00487_ clknet_leaf_52_clk
+ samples_real\[2\]\[11\] _06908_ VDD VSS DFF_X1
Xsamples_real\[2\]\[12\]$_DFFE_PP_ _00488_ clknet_leaf_52_clk
+ samples_real\[2\]\[12\] _06907_ VDD VSS DFF_X1
Xsamples_real\[2\]\[13\]$_DFFE_PP_ _00489_ clknet_leaf_52_clk
+ samples_real\[2\]\[13\] _06906_ VDD VSS DFF_X1
Xsamples_real\[2\]\[14\]$_DFFE_PP_ _00490_ clknet_leaf_52_clk
+ samples_real\[2\]\[14\] _06905_ VDD VSS DFF_X1
Xsamples_real\[2\]\[15\]$_DFFE_PP_ _00491_ clknet_leaf_32_clk
+ samples_real\[2\]\[15\] _06904_ VDD VSS DFF_X1
Xsamples_real\[2\]\[1\]$_DFFE_PP_ _00492_ clknet_leaf_51_clk
+ samples_real\[2\]\[1\] _06903_ VDD VSS DFF_X1
Xsamples_real\[2\]\[2\]$_DFFE_PP_ _00493_ clknet_leaf_42_clk
+ samples_real\[2\]\[2\] _06902_ VDD VSS DFF_X1
Xsamples_real\[2\]\[3\]$_DFFE_PP_ _00494_ clknet_leaf_41_clk
+ samples_real\[2\]\[3\] _06901_ VDD VSS DFF_X1
Xsamples_real\[2\]\[4\]$_DFFE_PP_ _00495_ clknet_leaf_41_clk
+ samples_real\[2\]\[4\] _06900_ VDD VSS DFF_X1
Xsamples_real\[2\]\[5\]$_DFFE_PP_ _00496_ clknet_leaf_41_clk
+ samples_real\[2\]\[5\] _06899_ VDD VSS DFF_X1
Xsamples_real\[2\]\[6\]$_DFFE_PP_ _00497_ clknet_leaf_33_clk
+ samples_real\[2\]\[6\] _06898_ VDD VSS DFF_X1
Xsamples_real\[2\]\[7\]$_DFFE_PP_ _00498_ clknet_leaf_43_clk
+ samples_real\[2\]\[7\] _06897_ VDD VSS DFF_X1
Xsamples_real\[2\]\[8\]$_DFFE_PP_ _00499_ clknet_leaf_43_clk
+ samples_real\[2\]\[8\] _06896_ VDD VSS DFF_X2
Xsamples_real\[2\]\[9\]$_DFFE_PP_ _00500_ clknet_leaf_44_clk
+ samples_real\[2\]\[9\] _06895_ VDD VSS DFF_X1
Xsamples_real\[3\]\[0\]$_DFFE_PP_ _00501_ clknet_leaf_47_clk
+ samples_real\[3\]\[0\] _06894_ VDD VSS DFF_X1
Xsamples_real\[3\]\[10\]$_DFFE_PP_ _00502_ clknet_leaf_43_clk
+ samples_real\[3\]\[10\] _06893_ VDD VSS DFF_X2
Xsamples_real\[3\]\[11\]$_DFFE_PP_ _00503_ clknet_leaf_53_clk
+ samples_real\[3\]\[11\] _06892_ VDD VSS DFF_X2
Xsamples_real\[3\]\[12\]$_DFFE_PP_ _00504_ clknet_leaf_53_clk
+ samples_real\[3\]\[12\] _06891_ VDD VSS DFF_X2
Xsamples_real\[3\]\[13\]$_DFFE_PP_ _00505_ clknet_leaf_53_clk
+ samples_real\[3\]\[13\] _06890_ VDD VSS DFF_X1
Xsamples_real\[3\]\[14\]$_DFFE_PP_ _00506_ clknet_leaf_53_clk
+ samples_real\[3\]\[14\] _06889_ VDD VSS DFF_X2
Xsamples_real\[3\]\[15\]$_DFFE_PP_ _00507_ clknet_leaf_42_clk
+ samples_real\[3\]\[15\] _06888_ VDD VSS DFF_X2
Xsamples_real\[3\]\[1\]$_DFFE_PP_ _00508_ clknet_leaf_51_clk
+ samples_real\[3\]\[1\] _06887_ VDD VSS DFF_X1
Xsamples_real\[3\]\[2\]$_DFFE_PP_ _00509_ clknet_leaf_42_clk
+ samples_real\[3\]\[2\] _06886_ VDD VSS DFF_X1
Xsamples_real\[3\]\[3\]$_DFFE_PP_ _00510_ clknet_leaf_51_clk
+ samples_real\[3\]\[3\] _06885_ VDD VSS DFF_X1
Xsamples_real\[3\]\[4\]$_DFFE_PP_ _00511_ clknet_leaf_41_clk
+ samples_real\[3\]\[4\] _06884_ VDD VSS DFF_X1
Xsamples_real\[3\]\[5\]$_DFFE_PP_ _00512_ clknet_leaf_51_clk
+ samples_real\[3\]\[5\] _06883_ VDD VSS DFF_X1
Xsamples_real\[3\]\[6\]$_DFFE_PP_ _00513_ clknet_leaf_43_clk
+ samples_real\[3\]\[6\] _06882_ VDD VSS DFF_X1
Xsamples_real\[3\]\[7\]$_DFFE_PP_ _00514_ clknet_leaf_43_clk
+ samples_real\[3\]\[7\] _06881_ VDD VSS DFF_X1
Xsamples_real\[3\]\[8\]$_DFFE_PP_ _00515_ clknet_leaf_43_clk
+ samples_real\[3\]\[8\] _06880_ VDD VSS DFF_X1
Xsamples_real\[3\]\[9\]$_DFFE_PP_ _00516_ clknet_leaf_44_clk
+ samples_real\[3\]\[9\] _06879_ VDD VSS DFF_X1
Xsamples_real\[4\]\[0\]$_DFFE_PP_ _00517_ clknet_leaf_53_clk
+ samples_real\[4\]\[0\] _06878_ VDD VSS DFF_X2
Xsamples_real\[4\]\[10\]$_DFFE_PP_ _00518_ clknet_leaf_53_clk
+ samples_real\[4\]\[10\] _06877_ VDD VSS DFF_X2
Xsamples_real\[4\]\[11\]$_DFFE_PP_ _00519_ clknet_leaf_63_clk
+ samples_real\[4\]\[11\] _06876_ VDD VSS DFF_X1
Xsamples_real\[4\]\[12\]$_DFFE_PP_ _00520_ clknet_leaf_63_clk
+ samples_real\[4\]\[12\] _06875_ VDD VSS DFF_X1
Xsamples_real\[4\]\[13\]$_DFFE_PP_ _00521_ clknet_leaf_52_clk
+ samples_real\[4\]\[13\] _06874_ VDD VSS DFF_X1
Xsamples_real\[4\]\[14\]$_DFFE_PP_ _00522_ clknet_leaf_63_clk
+ samples_real\[4\]\[14\] _06873_ VDD VSS DFF_X1
Xsamples_real\[4\]\[15\]$_DFFE_PP_ _00523_ clknet_leaf_39_clk
+ samples_real\[4\]\[15\] _06872_ VDD VSS DFF_X2
Xsamples_real\[4\]\[1\]$_DFFE_PP_ _00524_ clknet_leaf_64_clk
+ samples_real\[4\]\[1\] _06871_ VDD VSS DFF_X2
Xsamples_real\[4\]\[2\]$_DFFE_PP_ _00525_ clknet_leaf_39_clk
+ samples_real\[4\]\[2\] _06870_ VDD VSS DFF_X2
Xsamples_real\[4\]\[3\]$_DFFE_PP_ _00526_ clknet_leaf_52_clk
+ samples_real\[4\]\[3\] _06869_ VDD VSS DFF_X2
Xsamples_real\[4\]\[4\]$_DFFE_PP_ _00527_ clknet_leaf_64_clk
+ samples_real\[4\]\[4\] _06868_ VDD VSS DFF_X2
Xsamples_real\[4\]\[5\]$_DFFE_PP_ _00528_ clknet_leaf_63_clk
+ samples_real\[4\]\[5\] _06867_ VDD VSS DFF_X1
Xsamples_real\[4\]\[6\]$_DFFE_PP_ _00529_ clknet_leaf_41_clk
+ samples_real\[4\]\[6\] _06866_ VDD VSS DFF_X2
Xsamples_real\[4\]\[7\]$_DFFE_PP_ _00530_ clknet_leaf_40_clk
+ samples_real\[4\]\[7\] _06865_ VDD VSS DFF_X2
Xsamples_real\[4\]\[8\]$_DFFE_PP_ _00531_ clknet_leaf_39_clk
+ samples_real\[4\]\[8\] _06864_ VDD VSS DFF_X2
Xsamples_real\[4\]\[9\]$_DFFE_PP_ _00532_ clknet_leaf_40_clk
+ samples_real\[4\]\[9\] _06863_ VDD VSS DFF_X2
Xsamples_real\[5\]\[0\]$_DFFE_PP_ _00533_ clknet_leaf_70_clk
+ samples_real\[5\]\[0\] _06862_ VDD VSS DFF_X2
Xsamples_real\[5\]\[10\]$_DFFE_PP_ _00534_ clknet_leaf_69_clk
+ samples_real\[5\]\[10\] _06861_ VDD VSS DFF_X2
Xsamples_real\[5\]\[11\]$_DFFE_PP_ _00535_ clknet_leaf_65_clk
+ samples_real\[5\]\[11\] _06860_ VDD VSS DFF_X1
Xsamples_real\[5\]\[12\]$_DFFE_PP_ _00536_ clknet_leaf_65_clk
+ samples_real\[5\]\[12\] _06859_ VDD VSS DFF_X1
Xsamples_real\[5\]\[13\]$_DFFE_PP_ _00537_ clknet_leaf_69_clk
+ samples_real\[5\]\[13\] _06858_ VDD VSS DFF_X2
Xsamples_real\[5\]\[14\]$_DFFE_PP_ _00538_ clknet_leaf_69_clk
+ samples_real\[5\]\[14\] _06857_ VDD VSS DFF_X1
Xsamples_real\[5\]\[15\]$_DFFE_PP_ _00539_ clknet_leaf_38_clk
+ samples_real\[5\]\[15\] _06856_ VDD VSS DFF_X2
Xsamples_real\[5\]\[1\]$_DFFE_PP_ _00540_ clknet_leaf_65_clk
+ samples_real\[5\]\[1\] _06855_ VDD VSS DFF_X2
Xsamples_real\[5\]\[2\]$_DFFE_PP_ _00541_ clknet_leaf_39_clk
+ samples_real\[5\]\[2\] _06854_ VDD VSS DFF_X2
Xsamples_real\[5\]\[3\]$_DFFE_PP_ _00542_ clknet_leaf_70_clk
+ samples_real\[5\]\[3\] _06853_ VDD VSS DFF_X2
Xsamples_real\[5\]\[4\]$_DFFE_PP_ _00543_ clknet_leaf_70_clk
+ samples_real\[5\]\[4\] _06852_ VDD VSS DFF_X2
Xsamples_real\[5\]\[5\]$_DFFE_PP_ _00544_ clknet_leaf_65_clk
+ samples_real\[5\]\[5\] _06851_ VDD VSS DFF_X1
Xsamples_real\[5\]\[6\]$_DFFE_PP_ _00545_ clknet_leaf_71_clk
+ samples_real\[5\]\[6\] _06850_ VDD VSS DFF_X2
Xsamples_real\[5\]\[7\]$_DFFE_PP_ _00546_ clknet_leaf_70_clk
+ samples_real\[5\]\[7\] _06849_ VDD VSS DFF_X2
Xsamples_real\[5\]\[8\]$_DFFE_PP_ _00547_ clknet_leaf_40_clk
+ samples_real\[5\]\[8\] _06848_ VDD VSS DFF_X2
Xsamples_real\[5\]\[9\]$_DFFE_PP_ _00548_ clknet_leaf_72_clk
+ samples_real\[5\]\[9\] _06847_ VDD VSS DFF_X2
Xsamples_real\[6\]\[0\]$_DFFE_PP_ _00549_ clknet_leaf_68_clk
+ samples_real\[6\]\[0\] _06846_ VDD VSS DFF_X2
Xsamples_real\[6\]\[10\]$_DFFE_PP_ _00550_ clknet_leaf_69_clk
+ samples_real\[6\]\[10\] _06845_ VDD VSS DFF_X2
Xsamples_real\[6\]\[11\]$_DFFE_PP_ _00551_ clknet_leaf_67_clk
+ samples_real\[6\]\[11\] _06844_ VDD VSS DFF_X2
Xsamples_real\[6\]\[12\]$_DFFE_PP_ _00552_ clknet_leaf_68_clk
+ samples_real\[6\]\[12\] _06843_ VDD VSS DFF_X2
Xsamples_real\[6\]\[13\]$_DFFE_PP_ _00553_ clknet_leaf_69_clk
+ samples_real\[6\]\[13\] _06842_ VDD VSS DFF_X2
Xsamples_real\[6\]\[14\]$_DFFE_PP_ _00554_ clknet_leaf_69_clk
+ samples_real\[6\]\[14\] _06841_ VDD VSS DFF_X2
Xsamples_real\[6\]\[15\]$_DFFE_PP_ _00555_ clknet_leaf_38_clk
+ samples_real\[6\]\[15\] _06840_ VDD VSS DFF_X2
Xsamples_real\[6\]\[1\]$_DFFE_PP_ _00556_ clknet_leaf_68_clk
+ samples_real\[6\]\[1\] _06839_ VDD VSS DFF_X2
Xsamples_real\[6\]\[2\]$_DFFE_PP_ _00557_ clknet_leaf_38_clk
+ samples_real\[6\]\[2\] _06838_ VDD VSS DFF_X2
Xsamples_real\[6\]\[3\]$_DFFE_PP_ _00558_ clknet_leaf_68_clk
+ samples_real\[6\]\[3\] _06837_ VDD VSS DFF_X2
Xsamples_real\[6\]\[4\]$_DFFE_PP_ _00559_ clknet_leaf_69_clk
+ samples_real\[6\]\[4\] _06836_ VDD VSS DFF_X2
Xsamples_real\[6\]\[5\]$_DFFE_PP_ _00560_ clknet_leaf_68_clk
+ samples_real\[6\]\[5\] _06835_ VDD VSS DFF_X2
Xsamples_real\[6\]\[6\]$_DFFE_PP_ _00561_ clknet_leaf_73_clk
+ samples_real\[6\]\[6\] _06834_ VDD VSS DFF_X2
Xsamples_real\[6\]\[7\]$_DFFE_PP_ _00562_ clknet_leaf_73_clk
+ samples_real\[6\]\[7\] _06833_ VDD VSS DFF_X2
Xsamples_real\[6\]\[8\]$_DFFE_PP_ _00563_ clknet_leaf_72_clk
+ samples_real\[6\]\[8\] _06832_ VDD VSS DFF_X2
Xsamples_real\[6\]\[9\]$_DFFE_PP_ _00564_ clknet_leaf_72_clk
+ samples_real\[6\]\[9\] _06831_ VDD VSS DFF_X2
Xsamples_real\[7\]\[0\]$_DFFE_PP_ _00565_ clknet_leaf_70_clk
+ samples_real\[7\]\[0\] _06830_ VDD VSS DFF_X2
Xsamples_real\[7\]\[10\]$_DFFE_PP_ _00566_ clknet_leaf_71_clk
+ samples_real\[7\]\[10\] _06829_ VDD VSS DFF_X2
Xsamples_real\[7\]\[11\]$_DFFE_PP_ _00567_ clknet_leaf_66_clk
+ samples_real\[7\]\[11\] _06828_ VDD VSS DFF_X2
Xsamples_real\[7\]\[12\]$_DFFE_PP_ _00568_ clknet_leaf_66_clk
+ samples_real\[7\]\[12\] _06827_ VDD VSS DFF_X2
Xsamples_real\[7\]\[13\]$_DFFE_PP_ _00569_ clknet_leaf_71_clk
+ samples_real\[7\]\[13\] _06826_ VDD VSS DFF_X2
Xsamples_real\[7\]\[14\]$_DFFE_PP_ _00570_ clknet_leaf_64_clk
+ samples_real\[7\]\[14\] _06825_ VDD VSS DFF_X2
Xsamples_real\[7\]\[15\]$_DFFE_PP_ _00571_ clknet_leaf_39_clk
+ samples_real\[7\]\[15\] _06824_ VDD VSS DFF_X2
Xsamples_real\[7\]\[1\]$_DFFE_PP_ _00572_ clknet_leaf_64_clk
+ samples_real\[7\]\[1\] _06823_ VDD VSS DFF_X2
Xsamples_real\[7\]\[2\]$_DFFE_PP_ _00573_ clknet_leaf_39_clk
+ samples_real\[7\]\[2\] _06822_ VDD VSS DFF_X2
Xsamples_real\[7\]\[3\]$_DFFE_PP_ _00574_ clknet_leaf_64_clk
+ samples_real\[7\]\[3\] _06821_ VDD VSS DFF_X1
Xsamples_real\[7\]\[4\]$_DFFE_PP_ _00575_ clknet_leaf_64_clk
+ samples_real\[7\]\[4\] _06820_ VDD VSS DFF_X1
Xsamples_real\[7\]\[5\]$_DFFE_PP_ _00576_ clknet_leaf_66_clk
+ samples_real\[7\]\[5\] _06819_ VDD VSS DFF_X1
Xsamples_real\[7\]\[6\]$_DFFE_PP_ _00577_ clknet_leaf_71_clk
+ samples_real\[7\]\[6\] _06818_ VDD VSS DFF_X2
Xsamples_real\[7\]\[7\]$_DFFE_PP_ _00578_ clknet_leaf_71_clk
+ samples_real\[7\]\[7\] _06817_ VDD VSS DFF_X2
Xsamples_real\[7\]\[8\]$_DFFE_PP_ _00579_ clknet_leaf_40_clk
+ samples_real\[7\]\[8\] _06816_ VDD VSS DFF_X2
Xsamples_real\[7\]\[9\]$_DFFE_PP_ _00580_ clknet_leaf_72_clk
+ samples_real\[7\]\[9\] _06815_ VDD VSS DFF_X2
Xstage\[0\]$_SDFFE_PN0P_ _00581_ clknet_leaf_78_clk stage\[0\]
+ _09361_ VDD VSS DFF_X2
Xstage\[1\]$_SDFFE_PN0P_ _00582_ clknet_leaf_78_clk stage\[1\]
+ _09362_ VDD VSS DFF_X2
Xstage\[2\]$_SDFFE_PN0P_ _00583_ clknet_leaf_78_clk stage\[2\]
+ _09340_ VDD VSS DFF_X2
Xstate\[0\]$_DFF_P_ _00010_ clknet_leaf_1_clk state\[0\] _07346_
+ VDD VSS DFF_X1
Xstate\[1\]$_DFF_P_ _00011_ clknet_leaf_79_clk state\[1\]
+ _00031_ VDD VSS DFF_X1
Xstate\[2\]$_DFF_P_ _00012_ clknet_leaf_79_clk state\[2\]
+ _00020_ VDD VSS DFF_X1
Xstate\[3\]$_DFF_P_ _00009_ clknet_leaf_79_clk state\[3\]
+ _00041_ VDD VSS DFF_X1
Xtemp_imag\[0\]$_DFFE_PP_ _00584_ clknet_leaf_1_clk temp_imag\[0\]
+ _07347_ VDD VSS DFF_X2
Xtemp_real\[0\]$_DFFE_PP_ _00585_ clknet_leaf_75_clk temp_real\[0\]
+ _07355_ VDD VSS DFF_X2
Xtwiddle_idx\[0\]$_DFFE_PP_ _00006_ clknet_leaf_75_clk twiddle_idx\[0\]
+ _06814_ VDD VSS DFF_X1
Xtwiddle_idx\[1\]$_DFFE_PP_ _00019_ clknet_leaf_75_clk twiddle_idx\[1\]
+ _06813_ VDD VSS DFF_X1
Xclone1 _03748_ _03723_ _03736_ _03680_ net1 VDD VSS NOR4_X4
Xclone2 _02196_ _02259_ _02232_ net2 VDD VSS NAND3_X4
Xclone14 _03990_ net14 VDD VSS BUF_X4
Xclone15 _02116_ _02097_ _02120_ net15 VDD VSS NOR3_X4
Xclone17 _02278_ net17 VDD VSS BUF_X4
Xclone18 _02641_ net18 VDD VSS BUF_X4
Xclone19 _02334_ net19 VDD VSS BUF_X2
Xclone20 net21 _03501_ net20 VDD VSS NAND2_X2
Xclone21 net403 _03412_ _03473_ net21 VDD VSS AND3_X1
Xclone23 _03789_ net23 VDD VSS BUF_X4
Xclone24 _04723_ net24 VDD VSS BUF_X4
Xclone25 _01300_ net25 VDD VSS BUF_X4
Xclone26 _04356_ net26 VDD VSS BUF_X4
Xclone27 _02697_ _02685_ net380 _02731_ net27 VDD VSS NAND4_X4
Xclone28 _02016_ net28 VDD VSS BUF_X4
Xclone29 _02132_ net29 VDD VSS BUF_X4
Xclone31 _09309_ net31 VDD VSS BUF_X2
Xclone32 _03351_ net32 VDD VSS BUF_X4
Xclone34 net411 net34 VDD VSS BUF_X8
Xclone35 _02523_ net35 VDD VSS BUF_X4
Xclone36 _01308_ net36 VDD VSS BUF_X4
Xclone37 net429 _04521_ net37 VDD VSS NAND2_X4
Xclone38 _03502_ net38 VDD VSS BUF_X4
Xclone39 _03112_ net39 VDD VSS BUF_X4
Xclone40 _04134_ net40 VDD VSS BUF_X4
Xclone41 _03051_ net41 VDD VSS BUF_X4
Xclone42 _01082_ _01081_ net42 VDD VSS NAND2_X4
Xsplit43 _08828_ net43 VDD VSS BUF_X1
Xclone44 _04724_ net44 VDD VSS BUF_X4
Xclone51 _00004_ net51 VDD VSS BUF_X4
Xclone53 _04869_ net53 VDD VSS BUF_X4
Xsplit61 _00001_ net61 VDD VSS BUF_X1
Xclone93 _06119_ net93 VDD VSS BUF_X16
Xclone101 _06146_ net101 VDD VSS BUF_X8
Xclone104 _06173_ net104 VDD VSS BUF_X16
Xclone107 _06200_ net107 VDD VSS BUF_X16
Xclone130 net458 net130 VDD VSS BUF_X16
Xclone131 _05761_ net131 VDD VSS BUF_X16
Xclone138 _05358_ _05341_ _05418_ net138 VDD VSS MUX2_X2
Xclone139 _05421_ net139 VDD VSS BUF_X4
Xclone140 _05424_ net140 VDD VSS BUF_X4
Xclone143 _05789_ net143 VDD VSS BUF_X2
Xclone144 net534 net144 VDD VSS BUF_X4
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Right_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Right_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Right_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Right_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Right_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Right_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Right_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Right_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Right_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Right_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Right_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Right_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Right_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Right_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Right_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Right_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Right_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Right_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Right_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Right_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Right_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Right_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Right_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Right_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Right_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Right_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Right_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Right_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Right_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Right_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Right_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Right_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Right_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Right_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Right_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Right_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Right_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Right_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Right_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Right_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Right_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Right_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Right_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Right_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Right_89 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Right_90 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Right_91 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Right_92 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Right_93 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Right_94 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Right_95 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Right_96 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Right_97 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Right_98 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Right_99 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Right_100 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Right_101 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Right_102 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Right_103 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Right_104 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Right_105 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Right_106 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Right_107 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Right_108 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Right_109 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Right_110 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Right_111 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Right_112 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Right_113 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Right_114 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Right_115 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Right_116 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Right_117 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Right_118 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Right_119 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Right_120 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Right_121 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Right_122 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Right_123 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Right_124 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Right_125 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Right_126 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Right_127 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Right_128 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Right_129 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Right_130 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Right_131 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Right_132 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_133 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_134 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_135 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_136 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_137 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_138 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_139 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_140 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_141 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_142 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_143 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_144 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_145 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_146 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_147 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_148 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_149 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_150 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_151 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_152 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_153 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_154 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_155 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_156 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_157 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_158 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_159 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_160 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_161 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_162 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_163 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_164 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_165 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_166 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_167 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_168 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_169 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_170 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_171 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_172 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_173 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_174 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_175 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_176 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_177 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Left_178 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Left_179 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Left_180 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Left_181 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Left_182 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Left_183 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Left_184 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Left_185 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Left_186 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Left_187 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Left_188 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Left_189 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Left_190 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Left_191 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Left_192 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Left_193 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Left_194 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Left_195 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Left_196 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Left_197 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Left_198 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Left_199 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Left_200 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Left_201 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Left_202 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Left_203 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Left_204 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Left_205 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Left_206 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Left_207 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Left_208 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Left_209 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Left_210 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Left_211 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Left_212 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Left_213 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Left_214 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Left_215 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Left_216 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Left_217 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Left_218 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Left_219 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Left_220 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Left_221 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Left_222 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Left_223 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Left_224 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Left_225 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Left_226 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Left_227 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Left_228 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Left_229 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Left_230 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Left_231 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Left_232 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Left_233 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Left_234 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Left_235 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Left_236 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Left_237 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Left_238 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Left_239 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Left_240 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Left_241 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Left_242 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Left_243 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Left_244 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Left_245 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Left_246 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Left_247 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Left_248 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Left_249 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Left_250 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Left_251 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Left_252 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Left_253 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Left_254 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Left_255 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Left_256 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Left_257 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Left_258 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Left_259 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Left_260 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Left_261 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Left_262 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Left_263 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Left_264 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Left_265 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_266 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_2_267 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_4_268 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_6_269 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_8_270 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_10_271 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_12_272 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_14_273 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_16_274 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_18_275 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_20_276 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_22_277 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_24_278 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_26_279 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_28_280 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_30_281 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_32_282 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_34_283 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_36_284 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_38_285 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_40_286 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_42_287 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_44_288 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_46_289 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_48_290 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_50_291 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_52_292 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_54_293 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_56_294 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_58_295 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_60_296 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_62_297 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_64_298 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_66_299 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_68_300 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_70_301 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_72_302 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_74_303 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_76_304 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_78_305 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_80_306 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_82_307 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_84_308 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_86_309 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_88_310 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_90_311 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_92_312 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_94_313 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_96_314 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_98_315 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_100_316 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_102_317 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_104_318 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_106_319 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_108_320 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_110_321 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_112_322 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_114_323 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_116_324 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_118_325 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_120_326 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_122_327 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_124_328 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_126_329 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_128_330 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_130_331 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_132_332 VDD VSS TAPCELL_X1
Xinput1 data_in_imag[0] net45 VDD VSS BUF_X2
Xinput2 data_in_imag[10] net46 VDD VSS CLKBUF_X2
Xinput3 data_in_imag[11] net47 VDD VSS CLKBUF_X2
Xinput4 data_in_imag[12] net48 VDD VSS CLKBUF_X2
Xinput5 data_in_imag[13] net49 VDD VSS CLKBUF_X2
Xinput6 data_in_imag[14] net50 VDD VSS BUF_X2
Xinput7 data_in_imag[15] net54 VDD VSS BUF_X1
Xinput8 data_in_imag[1] net55 VDD VSS BUF_X2
Xinput9 data_in_imag[2] net62 VDD VSS BUF_X2
Xinput10 data_in_imag[3] net63 VDD VSS BUF_X2
Xinput11 data_in_imag[4] net64 VDD VSS BUF_X2
Xinput12 data_in_imag[5] net65 VDD VSS BUF_X2
Xinput13 data_in_imag[6] net66 VDD VSS BUF_X2
Xinput14 data_in_imag[7] net67 VDD VSS BUF_X2
Xinput15 data_in_imag[8] net68 VDD VSS BUF_X2
Xinput16 data_in_imag[9] net69 VDD VSS CLKBUF_X2
Xinput17 data_in_real[0] net70 VDD VSS BUF_X2
Xinput18 data_in_real[10] net71 VDD VSS BUF_X2
Xinput19 data_in_real[11] net72 VDD VSS BUF_X2
Xinput20 data_in_real[12] net73 VDD VSS BUF_X2
Xinput21 data_in_real[13] net74 VDD VSS BUF_X2
Xinput22 data_in_real[14] net75 VDD VSS BUF_X2
Xinput23 data_in_real[15] net76 VDD VSS CLKBUF_X2
Xinput24 data_in_real[1] net77 VDD VSS BUF_X2
Xinput25 data_in_real[2] net78 VDD VSS BUF_X2
Xinput26 data_in_real[3] net79 VDD VSS BUF_X2
Xinput27 data_in_real[4] net80 VDD VSS BUF_X2
Xinput28 data_in_real[5] net81 VDD VSS BUF_X2
Xinput29 data_in_real[6] net82 VDD VSS BUF_X2
Xinput30 data_in_real[7] net83 VDD VSS BUF_X2
Xinput31 data_in_real[8] net84 VDD VSS BUF_X2
Xinput32 data_in_real[9] net85 VDD VSS BUF_X2
Xinput33 data_valid_in net86 VDD VSS BUF_X2
Xinput34 start net87 VDD VSS BUF_X2
Xoutput35 net88 busy VDD VSS BUF_X1
Xoutput36 net89 data_out_imag[0] VDD VSS BUF_X1
Xoutput37 net90 data_out_imag[100] VDD VSS BUF_X1
Xoutput38 net91 data_out_imag[101] VDD VSS BUF_X1
Xoutput39 net92 data_out_imag[102] VDD VSS BUF_X1
Xoutput40 net95 data_out_imag[103] VDD VSS BUF_X1
Xoutput41 net96 data_out_imag[104] VDD VSS BUF_X1
Xoutput42 net99 data_out_imag[105] VDD VSS BUF_X1
Xoutput43 net100 data_out_imag[106] VDD VSS BUF_X1
Xoutput44 net102 data_out_imag[107] VDD VSS BUF_X1
Xoutput45 net103 data_out_imag[108] VDD VSS BUF_X1
Xoutput46 net105 data_out_imag[109] VDD VSS BUF_X1
Xoutput47 net106 data_out_imag[10] VDD VSS BUF_X1
Xoutput48 net108 data_out_imag[110] VDD VSS BUF_X1
Xoutput49 net109 data_out_imag[111] VDD VSS BUF_X1
Xoutput50 net110 data_out_imag[112] VDD VSS BUF_X1
Xoutput51 net111 data_out_imag[113] VDD VSS BUF_X1
Xoutput52 net112 data_out_imag[114] VDD VSS BUF_X1
Xoutput53 net113 data_out_imag[115] VDD VSS BUF_X1
Xoutput54 net114 data_out_imag[116] VDD VSS BUF_X1
Xoutput55 net115 data_out_imag[117] VDD VSS BUF_X1
Xoutput56 net116 data_out_imag[118] VDD VSS BUF_X1
Xoutput57 net117 data_out_imag[119] VDD VSS BUF_X1
Xoutput58 net118 data_out_imag[11] VDD VSS BUF_X1
Xoutput59 net119 data_out_imag[120] VDD VSS BUF_X1
Xoutput60 net120 data_out_imag[121] VDD VSS BUF_X1
Xoutput61 net121 data_out_imag[122] VDD VSS BUF_X1
Xoutput62 net122 data_out_imag[123] VDD VSS BUF_X1
Xoutput63 net123 data_out_imag[124] VDD VSS BUF_X1
Xoutput64 net124 data_out_imag[125] VDD VSS BUF_X1
Xoutput65 net126 data_out_imag[126] VDD VSS BUF_X1
Xoutput66 net127 data_out_imag[127] VDD VSS BUF_X1
Xoutput67 net128 data_out_imag[12] VDD VSS BUF_X1
Xoutput68 net134 data_out_imag[13] VDD VSS BUF_X1
Xoutput69 net135 data_out_imag[14] VDD VSS BUF_X1
Xoutput70 net136 data_out_imag[15] VDD VSS BUF_X1
Xoutput71 net141 data_out_imag[16] VDD VSS BUF_X1
Xoutput72 net142 data_out_imag[17] VDD VSS BUF_X1
Xoutput73 net145 data_out_imag[18] VDD VSS BUF_X1
Xoutput74 net146 data_out_imag[19] VDD VSS BUF_X1
Xoutput75 net147 data_out_imag[1] VDD VSS BUF_X1
Xoutput76 net148 data_out_imag[20] VDD VSS BUF_X1
Xoutput77 net150 data_out_imag[21] VDD VSS BUF_X1
Xoutput78 net155 data_out_imag[22] VDD VSS BUF_X1
Xoutput79 net157 data_out_imag[23] VDD VSS BUF_X1
Xoutput80 net159 data_out_imag[24] VDD VSS BUF_X1
Xoutput81 net160 data_out_imag[25] VDD VSS BUF_X1
Xoutput82 net161 data_out_imag[26] VDD VSS BUF_X1
Xoutput83 net162 data_out_imag[27] VDD VSS BUF_X1
Xoutput84 net163 data_out_imag[28] VDD VSS BUF_X1
Xoutput85 net164 data_out_imag[29] VDD VSS BUF_X1
Xoutput86 net165 data_out_imag[2] VDD VSS BUF_X1
Xoutput87 net166 data_out_imag[30] VDD VSS BUF_X1
Xoutput88 net167 data_out_imag[31] VDD VSS BUF_X1
Xoutput89 net168 data_out_imag[32] VDD VSS BUF_X1
Xoutput90 net169 data_out_imag[33] VDD VSS BUF_X1
Xoutput91 net170 data_out_imag[34] VDD VSS BUF_X1
Xoutput92 net171 data_out_imag[35] VDD VSS BUF_X1
Xoutput93 net172 data_out_imag[36] VDD VSS BUF_X1
Xoutput94 net173 data_out_imag[37] VDD VSS BUF_X1
Xoutput95 net174 data_out_imag[38] VDD VSS BUF_X1
Xoutput96 net175 data_out_imag[39] VDD VSS BUF_X1
Xoutput97 net176 data_out_imag[3] VDD VSS BUF_X1
Xoutput98 net177 data_out_imag[40] VDD VSS BUF_X1
Xoutput99 net178 data_out_imag[41] VDD VSS BUF_X1
Xoutput100 net179 data_out_imag[42] VDD VSS BUF_X1
Xoutput101 net180 data_out_imag[43] VDD VSS BUF_X1
Xoutput102 net181 data_out_imag[44] VDD VSS BUF_X1
Xoutput103 net182 data_out_imag[45] VDD VSS BUF_X1
Xoutput104 net183 data_out_imag[46] VDD VSS BUF_X1
Xoutput105 net184 data_out_imag[47] VDD VSS BUF_X1
Xoutput106 net185 data_out_imag[48] VDD VSS BUF_X1
Xoutput107 net186 data_out_imag[49] VDD VSS BUF_X1
Xoutput108 net187 data_out_imag[4] VDD VSS BUF_X1
Xoutput109 net188 data_out_imag[50] VDD VSS BUF_X1
Xoutput110 net189 data_out_imag[51] VDD VSS BUF_X1
Xoutput111 net190 data_out_imag[52] VDD VSS BUF_X1
Xoutput112 net191 data_out_imag[53] VDD VSS BUF_X1
Xoutput113 net192 data_out_imag[54] VDD VSS BUF_X1
Xoutput114 net193 data_out_imag[55] VDD VSS BUF_X1
Xoutput115 net194 data_out_imag[56] VDD VSS BUF_X1
Xoutput116 net195 data_out_imag[57] VDD VSS BUF_X1
Xoutput117 net196 data_out_imag[58] VDD VSS BUF_X1
Xoutput118 net197 data_out_imag[59] VDD VSS BUF_X1
Xoutput119 net198 data_out_imag[5] VDD VSS BUF_X1
Xoutput120 net199 data_out_imag[60] VDD VSS BUF_X1
Xoutput121 net200 data_out_imag[61] VDD VSS BUF_X1
Xoutput122 net201 data_out_imag[62] VDD VSS BUF_X1
Xoutput123 net202 data_out_imag[63] VDD VSS BUF_X1
Xoutput124 net203 data_out_imag[64] VDD VSS BUF_X1
Xoutput125 net204 data_out_imag[65] VDD VSS BUF_X1
Xoutput126 net205 data_out_imag[66] VDD VSS BUF_X1
Xoutput127 net206 data_out_imag[67] VDD VSS BUF_X1
Xoutput128 net207 data_out_imag[68] VDD VSS BUF_X1
Xoutput129 net208 data_out_imag[69] VDD VSS BUF_X1
Xoutput130 net209 data_out_imag[6] VDD VSS BUF_X1
Xoutput131 net210 data_out_imag[70] VDD VSS BUF_X1
Xoutput132 net211 data_out_imag[71] VDD VSS BUF_X1
Xoutput133 net212 data_out_imag[72] VDD VSS BUF_X1
Xoutput134 net213 data_out_imag[73] VDD VSS BUF_X1
Xoutput135 net214 data_out_imag[74] VDD VSS BUF_X1
Xoutput136 net215 data_out_imag[75] VDD VSS BUF_X1
Xoutput137 net216 data_out_imag[76] VDD VSS BUF_X1
Xoutput138 net217 data_out_imag[77] VDD VSS BUF_X1
Xoutput139 net218 data_out_imag[78] VDD VSS BUF_X1
Xoutput140 net219 data_out_imag[79] VDD VSS BUF_X1
Xoutput141 net220 data_out_imag[7] VDD VSS BUF_X1
Xoutput142 net221 data_out_imag[80] VDD VSS BUF_X1
Xoutput143 net222 data_out_imag[81] VDD VSS BUF_X1
Xoutput144 net223 data_out_imag[82] VDD VSS BUF_X1
Xoutput145 net224 data_out_imag[83] VDD VSS BUF_X1
Xoutput146 net225 data_out_imag[84] VDD VSS BUF_X1
Xoutput147 net226 data_out_imag[85] VDD VSS BUF_X1
Xoutput148 net227 data_out_imag[86] VDD VSS BUF_X1
Xoutput149 net228 data_out_imag[87] VDD VSS BUF_X1
Xoutput150 net229 data_out_imag[88] VDD VSS BUF_X1
Xoutput151 net230 data_out_imag[89] VDD VSS BUF_X1
Xoutput152 net231 data_out_imag[8] VDD VSS BUF_X1
Xoutput153 net232 data_out_imag[90] VDD VSS BUF_X1
Xoutput154 net233 data_out_imag[91] VDD VSS BUF_X1
Xoutput155 net234 data_out_imag[92] VDD VSS BUF_X1
Xoutput156 net235 data_out_imag[93] VDD VSS BUF_X1
Xoutput157 net236 data_out_imag[94] VDD VSS BUF_X1
Xoutput158 net237 data_out_imag[95] VDD VSS BUF_X1
Xoutput159 net238 data_out_imag[96] VDD VSS BUF_X1
Xoutput160 net239 data_out_imag[97] VDD VSS BUF_X1
Xoutput161 net240 data_out_imag[98] VDD VSS BUF_X1
Xoutput162 net241 data_out_imag[99] VDD VSS BUF_X1
Xoutput163 net242 data_out_imag[9] VDD VSS BUF_X1
Xoutput164 net243 data_out_real[0] VDD VSS BUF_X1
Xoutput165 net244 data_out_real[100] VDD VSS BUF_X1
Xoutput166 net245 data_out_real[101] VDD VSS BUF_X1
Xoutput167 net246 data_out_real[102] VDD VSS BUF_X1
Xoutput168 net247 data_out_real[103] VDD VSS BUF_X1
Xoutput169 net248 data_out_real[104] VDD VSS BUF_X1
Xoutput170 net249 data_out_real[105] VDD VSS BUF_X1
Xoutput171 net250 data_out_real[106] VDD VSS BUF_X1
Xoutput172 net251 data_out_real[107] VDD VSS BUF_X1
Xoutput173 net252 data_out_real[108] VDD VSS BUF_X1
Xoutput174 net253 data_out_real[109] VDD VSS BUF_X1
Xoutput175 net254 data_out_real[10] VDD VSS BUF_X1
Xoutput176 net255 data_out_real[110] VDD VSS BUF_X1
Xoutput177 net256 data_out_real[111] VDD VSS BUF_X1
Xoutput178 net257 data_out_real[112] VDD VSS BUF_X1
Xoutput179 net258 data_out_real[113] VDD VSS BUF_X1
Xoutput180 net259 data_out_real[114] VDD VSS BUF_X1
Xoutput181 net260 data_out_real[115] VDD VSS BUF_X1
Xoutput182 net261 data_out_real[116] VDD VSS BUF_X1
Xoutput183 net262 data_out_real[117] VDD VSS BUF_X1
Xoutput184 net263 data_out_real[118] VDD VSS BUF_X1
Xoutput185 net264 data_out_real[119] VDD VSS BUF_X1
Xoutput186 net265 data_out_real[11] VDD VSS BUF_X1
Xoutput187 net266 data_out_real[120] VDD VSS BUF_X1
Xoutput188 net267 data_out_real[121] VDD VSS BUF_X1
Xoutput189 net268 data_out_real[122] VDD VSS BUF_X1
Xoutput190 net269 data_out_real[123] VDD VSS BUF_X1
Xoutput191 net270 data_out_real[124] VDD VSS BUF_X1
Xoutput192 net271 data_out_real[125] VDD VSS BUF_X1
Xoutput193 net272 data_out_real[126] VDD VSS BUF_X1
Xoutput194 net273 data_out_real[127] VDD VSS BUF_X1
Xoutput195 net274 data_out_real[12] VDD VSS BUF_X1
Xoutput196 net275 data_out_real[13] VDD VSS BUF_X1
Xoutput197 net276 data_out_real[14] VDD VSS BUF_X1
Xoutput198 net277 data_out_real[15] VDD VSS BUF_X1
Xoutput199 net278 data_out_real[16] VDD VSS BUF_X1
Xoutput200 net279 data_out_real[17] VDD VSS BUF_X1
Xoutput201 net280 data_out_real[18] VDD VSS BUF_X1
Xoutput202 net281 data_out_real[19] VDD VSS BUF_X1
Xoutput203 net282 data_out_real[1] VDD VSS BUF_X1
Xoutput204 net283 data_out_real[20] VDD VSS BUF_X1
Xoutput205 net284 data_out_real[21] VDD VSS BUF_X1
Xoutput206 net285 data_out_real[22] VDD VSS BUF_X1
Xoutput207 net286 data_out_real[23] VDD VSS BUF_X1
Xoutput208 net287 data_out_real[24] VDD VSS BUF_X1
Xoutput209 net288 data_out_real[25] VDD VSS BUF_X1
Xoutput210 net289 data_out_real[26] VDD VSS BUF_X1
Xoutput211 net290 data_out_real[27] VDD VSS BUF_X1
Xoutput212 net291 data_out_real[28] VDD VSS BUF_X1
Xoutput213 net292 data_out_real[29] VDD VSS BUF_X1
Xoutput214 net293 data_out_real[2] VDD VSS BUF_X1
Xoutput215 net294 data_out_real[30] VDD VSS BUF_X1
Xoutput216 net295 data_out_real[31] VDD VSS BUF_X1
Xoutput217 net296 data_out_real[32] VDD VSS BUF_X1
Xoutput218 net297 data_out_real[33] VDD VSS BUF_X1
Xoutput219 net298 data_out_real[34] VDD VSS BUF_X1
Xoutput220 net299 data_out_real[35] VDD VSS BUF_X1
Xoutput221 net300 data_out_real[36] VDD VSS BUF_X1
Xoutput222 net301 data_out_real[37] VDD VSS BUF_X1
Xoutput223 net302 data_out_real[38] VDD VSS BUF_X1
Xoutput224 net303 data_out_real[39] VDD VSS BUF_X1
Xoutput225 net304 data_out_real[3] VDD VSS BUF_X1
Xoutput226 net305 data_out_real[40] VDD VSS BUF_X1
Xoutput227 net306 data_out_real[41] VDD VSS BUF_X1
Xoutput228 net307 data_out_real[42] VDD VSS BUF_X1
Xoutput229 net308 data_out_real[43] VDD VSS BUF_X1
Xoutput230 net309 data_out_real[44] VDD VSS BUF_X1
Xoutput231 net310 data_out_real[45] VDD VSS BUF_X1
Xoutput232 net311 data_out_real[46] VDD VSS BUF_X1
Xoutput233 net312 data_out_real[47] VDD VSS BUF_X1
Xoutput234 net313 data_out_real[48] VDD VSS BUF_X1
Xoutput235 net314 data_out_real[49] VDD VSS BUF_X1
Xoutput236 net315 data_out_real[4] VDD VSS BUF_X1
Xoutput237 net316 data_out_real[50] VDD VSS BUF_X1
Xoutput238 net317 data_out_real[51] VDD VSS BUF_X1
Xoutput239 net318 data_out_real[52] VDD VSS BUF_X1
Xoutput240 net319 data_out_real[53] VDD VSS BUF_X1
Xoutput241 net320 data_out_real[54] VDD VSS BUF_X1
Xoutput242 net321 data_out_real[55] VDD VSS BUF_X1
Xoutput243 net322 data_out_real[56] VDD VSS BUF_X1
Xoutput244 net323 data_out_real[57] VDD VSS BUF_X1
Xoutput245 net324 data_out_real[58] VDD VSS BUF_X1
Xoutput246 net325 data_out_real[59] VDD VSS BUF_X1
Xoutput247 net326 data_out_real[5] VDD VSS BUF_X1
Xoutput248 net327 data_out_real[60] VDD VSS BUF_X1
Xoutput249 net328 data_out_real[61] VDD VSS BUF_X1
Xoutput250 net329 data_out_real[62] VDD VSS BUF_X1
Xoutput251 net330 data_out_real[63] VDD VSS BUF_X1
Xoutput252 net331 data_out_real[64] VDD VSS BUF_X1
Xoutput253 net332 data_out_real[65] VDD VSS BUF_X1
Xoutput254 net333 data_out_real[66] VDD VSS BUF_X1
Xoutput255 net334 data_out_real[67] VDD VSS BUF_X1
Xoutput256 net335 data_out_real[68] VDD VSS BUF_X1
Xoutput257 net336 data_out_real[69] VDD VSS BUF_X1
Xoutput258 net337 data_out_real[6] VDD VSS BUF_X1
Xoutput259 net338 data_out_real[70] VDD VSS BUF_X1
Xoutput260 net339 data_out_real[71] VDD VSS BUF_X1
Xoutput261 net340 data_out_real[72] VDD VSS BUF_X1
Xoutput262 net341 data_out_real[73] VDD VSS BUF_X1
Xoutput263 net342 data_out_real[74] VDD VSS BUF_X1
Xoutput264 net343 data_out_real[75] VDD VSS BUF_X1
Xoutput265 net344 data_out_real[76] VDD VSS BUF_X1
Xoutput266 net345 data_out_real[77] VDD VSS BUF_X1
Xoutput267 net346 data_out_real[78] VDD VSS BUF_X1
Xoutput268 net347 data_out_real[79] VDD VSS BUF_X1
Xoutput269 net348 data_out_real[7] VDD VSS BUF_X1
Xoutput270 net349 data_out_real[80] VDD VSS BUF_X1
Xoutput271 net350 data_out_real[81] VDD VSS BUF_X1
Xoutput272 net351 data_out_real[82] VDD VSS BUF_X1
Xoutput273 net352 data_out_real[83] VDD VSS BUF_X1
Xoutput274 net353 data_out_real[84] VDD VSS BUF_X1
Xoutput275 net354 data_out_real[85] VDD VSS BUF_X1
Xoutput276 net355 data_out_real[86] VDD VSS BUF_X1
Xoutput277 net356 data_out_real[87] VDD VSS BUF_X1
Xoutput278 net357 data_out_real[88] VDD VSS BUF_X1
Xoutput279 net358 data_out_real[89] VDD VSS BUF_X1
Xoutput280 net359 data_out_real[8] VDD VSS BUF_X1
Xoutput281 net360 data_out_real[90] VDD VSS BUF_X1
Xoutput282 net361 data_out_real[91] VDD VSS BUF_X1
Xoutput283 net362 data_out_real[92] VDD VSS BUF_X1
Xoutput284 net363 data_out_real[93] VDD VSS BUF_X1
Xoutput285 net364 data_out_real[94] VDD VSS BUF_X1
Xoutput286 net365 data_out_real[95] VDD VSS BUF_X1
Xoutput287 net366 data_out_real[96] VDD VSS BUF_X1
Xoutput288 net367 data_out_real[97] VDD VSS BUF_X1
Xoutput289 net368 data_out_real[98] VDD VSS BUF_X1
Xoutput290 net369 data_out_real[99] VDD VSS BUF_X1
Xoutput291 net370 data_out_real[9] VDD VSS BUF_X1
Xoutput292 net371 data_ready VDD VSS BUF_X1
Xoutput293 net372 data_valid_out VDD VSS BUF_X1
Xmax_cap294 _04439_ net373 VDD VSS BUF_X2
Xmax_cap295 _04410_ net374 VDD VSS BUF_X2
Xmax_cap296 _04046_ net375 VDD VSS BUF_X2
Xwire297 _03637_ net376 VDD VSS CLKBUF_X3
Xmax_cap298 _03341_ net377 VDD VSS CLKBUF_X2
Xmax_cap299 _02987_ net378 VDD VSS BUF_X2
Xmax_cap300 net380 net379 VDD VSS BUF_X1
Xmax_cap301 _02709_ net380 VDD VSS BUF_X1
Xmax_cap302 net382 net381 VDD VSS BUF_X2
Xmax_cap303 _02004_ net382 VDD VSS BUF_X2
Xmax_cap304 _01108_ net383 VDD VSS BUF_X4
X_17624__305 net384 VDD VSS LOGIC0_X1
X_17633__306 net385 VDD VSS LOGIC0_X1
X_17646__307 net386 VDD VSS LOGIC0_X1
X_17660__308 net387 VDD VSS LOGIC0_X1
X_17670__309 net388 VDD VSS LOGIC0_X1
X_17686__310 net389 VDD VSS LOGIC0_X1
X_17702__311 net390 VDD VSS LOGIC0_X1
X_17710__312 net391 VDD VSS LOGIC0_X1
X_17724__313 net392 VDD VSS LOGIC0_X1
X_17742__314 net393 VDD VSS LOGIC0_X1
X_17758__315 net394 VDD VSS LOGIC0_X1
X_17766__316 net395 VDD VSS LOGIC0_X1
X_17783__317 net396 VDD VSS LOGIC0_X1
X_17797__318 net397 VDD VSS LOGIC0_X1
Xclkbuf_leaf_1_clk clknet_3_0__leaf_clk clknet_leaf_1_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_2_clk clknet_3_0__leaf_clk clknet_leaf_2_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_3_clk clknet_3_1__leaf_clk clknet_leaf_3_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_4_clk clknet_3_1__leaf_clk clknet_leaf_4_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_5_clk clknet_3_1__leaf_clk clknet_leaf_5_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_6_clk clknet_3_1__leaf_clk clknet_leaf_6_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_7_clk clknet_3_1__leaf_clk clknet_leaf_7_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_8_clk clknet_3_0__leaf_clk clknet_leaf_8_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_9_clk clknet_3_1__leaf_clk clknet_leaf_9_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_10_clk clknet_3_1__leaf_clk clknet_leaf_10_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_11_clk clknet_3_1__leaf_clk clknet_leaf_11_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_12_clk clknet_3_1__leaf_clk clknet_leaf_12_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_13_clk clknet_3_1__leaf_clk clknet_leaf_13_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_14_clk clknet_3_2__leaf_clk clknet_leaf_14_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_15_clk clknet_3_2__leaf_clk clknet_leaf_15_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_16_clk clknet_3_2__leaf_clk clknet_leaf_16_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_17_clk clknet_3_2__leaf_clk clknet_leaf_17_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_18_clk clknet_3_3__leaf_clk clknet_leaf_18_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_19_clk clknet_3_3__leaf_clk clknet_leaf_19_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_20_clk clknet_3_3__leaf_clk clknet_leaf_20_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_21_clk clknet_3_3__leaf_clk clknet_leaf_21_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_22_clk clknet_3_3__leaf_clk clknet_leaf_22_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_23_clk clknet_3_2__leaf_clk clknet_leaf_23_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_24_clk clknet_3_2__leaf_clk clknet_leaf_24_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_25_clk clknet_3_3__leaf_clk clknet_leaf_25_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_26_clk clknet_3_3__leaf_clk clknet_leaf_26_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_27_clk clknet_3_3__leaf_clk clknet_leaf_27_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_28_clk clknet_3_3__leaf_clk clknet_leaf_28_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_29_clk clknet_3_3__leaf_clk clknet_leaf_29_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_30_clk clknet_3_3__leaf_clk clknet_leaf_30_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_31_clk clknet_3_3__leaf_clk clknet_leaf_31_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_32_clk clknet_3_7__leaf_clk clknet_leaf_32_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_33_clk clknet_3_3__leaf_clk clknet_leaf_33_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_34_clk clknet_3_2__leaf_clk clknet_leaf_34_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_35_clk clknet_3_2__leaf_clk clknet_leaf_35_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_36_clk clknet_3_2__leaf_clk clknet_leaf_36_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_37_clk clknet_3_1__leaf_clk clknet_leaf_37_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_38_clk clknet_3_5__leaf_clk clknet_leaf_38_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_39_clk clknet_3_5__leaf_clk clknet_leaf_39_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_40_clk clknet_3_5__leaf_clk clknet_leaf_40_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_41_clk clknet_3_7__leaf_clk clknet_leaf_41_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_42_clk clknet_3_7__leaf_clk clknet_leaf_42_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_43_clk clknet_3_7__leaf_clk clknet_leaf_43_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_44_clk clknet_3_7__leaf_clk clknet_leaf_44_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_45_clk clknet_3_7__leaf_clk clknet_leaf_45_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_46_clk clknet_3_7__leaf_clk clknet_leaf_46_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_47_clk clknet_3_7__leaf_clk clknet_leaf_47_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_48_clk clknet_3_7__leaf_clk clknet_leaf_48_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_49_clk clknet_3_7__leaf_clk clknet_leaf_49_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_50_clk clknet_3_7__leaf_clk clknet_leaf_50_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_51_clk clknet_3_7__leaf_clk clknet_leaf_51_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_52_clk clknet_3_6__leaf_clk clknet_leaf_52_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_53_clk clknet_3_6__leaf_clk clknet_leaf_53_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_54_clk clknet_3_6__leaf_clk clknet_leaf_54_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_55_clk clknet_3_6__leaf_clk clknet_leaf_55_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_56_clk clknet_3_6__leaf_clk clknet_leaf_56_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_57_clk clknet_3_6__leaf_clk clknet_leaf_57_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_58_clk clknet_3_6__leaf_clk clknet_leaf_58_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_59_clk clknet_3_6__leaf_clk clknet_leaf_59_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_60_clk clknet_3_6__leaf_clk clknet_leaf_60_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_61_clk clknet_3_6__leaf_clk clknet_leaf_61_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_62_clk clknet_3_6__leaf_clk clknet_leaf_62_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_63_clk clknet_3_6__leaf_clk clknet_leaf_63_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_64_clk clknet_3_6__leaf_clk clknet_leaf_64_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_65_clk clknet_3_5__leaf_clk clknet_leaf_65_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_66_clk clknet_3_5__leaf_clk clknet_leaf_66_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_67_clk clknet_3_5__leaf_clk clknet_leaf_67_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_68_clk clknet_3_5__leaf_clk clknet_leaf_68_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_69_clk clknet_3_5__leaf_clk clknet_leaf_69_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_70_clk clknet_3_5__leaf_clk clknet_leaf_70_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_71_clk clknet_3_5__leaf_clk clknet_leaf_71_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_72_clk clknet_3_4__leaf_clk clknet_leaf_72_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_73_clk clknet_3_4__leaf_clk clknet_leaf_73_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_74_clk clknet_3_4__leaf_clk clknet_leaf_74_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_75_clk clknet_3_4__leaf_clk clknet_leaf_75_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_76_clk clknet_3_4__leaf_clk clknet_leaf_76_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_77_clk clknet_3_4__leaf_clk clknet_leaf_77_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_78_clk clknet_3_4__leaf_clk clknet_leaf_78_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_79_clk clknet_3_4__leaf_clk clknet_leaf_79_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_80_clk clknet_3_0__leaf_clk clknet_leaf_80_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_81_clk clknet_3_0__leaf_clk clknet_leaf_81_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_82_clk clknet_3_0__leaf_clk clknet_leaf_82_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_3_0__f_clk clknet_0_clk clknet_3_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_1__f_clk clknet_0_clk clknet_3_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_2__f_clk clknet_0_clk clknet_3_2__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_3__f_clk clknet_0_clk clknet_3_3__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_4__f_clk clknet_0_clk clknet_3_4__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_5__f_clk clknet_0_clk clknet_3_5__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_6__f_clk clknet_0_clk clknet_3_6__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_7__f_clk clknet_0_clk clknet_3_7__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_3_0__leaf_clk _unconnected_0 VDD VSS INV_X4
Xclkload1 clknet_3_1__leaf_clk _unconnected_1 VDD VSS INV_X2
Xclkload2 clknet_3_2__leaf_clk _unconnected_2 VDD VSS INV_X4
Xclkload3 clknet_3_4__leaf_clk _unconnected_3 VDD VSS INV_X4
Xclkload4 clknet_3_5__leaf_clk _unconnected_4 VDD VSS INV_X2
Xclkload5 clknet_3_7__leaf_clk _unconnected_5 VDD VSS CLKBUF_X3
Xclkload6 clknet_leaf_0_clk _unconnected_6 VDD VSS CLKBUF_X1
Xclkload7 clknet_leaf_1_clk _unconnected_7 VDD VSS INV_X1
Xclkload8 clknet_leaf_2_clk _unconnected_8 VDD VSS CLKBUF_X1
Xclkload9 clknet_leaf_8_clk _unconnected_9 VDD VSS CLKBUF_X1
Xclkload10 clknet_leaf_80_clk _unconnected_10 VDD VSS CLKBUF_X1
Xclkload11 clknet_leaf_81_clk _unconnected_11 VDD VSS CLKBUF_X1
Xclkload12 clknet_leaf_3_clk _unconnected_12 VDD VSS INV_X2
Xclkload13 clknet_leaf_4_clk _unconnected_13 VDD VSS CLKBUF_X1
Xclkload14 clknet_leaf_5_clk _unconnected_14 VDD VSS CLKBUF_X1
Xclkload15 clknet_leaf_6_clk _unconnected_15 VDD VSS INV_X1
Xclkload16 clknet_leaf_7_clk _unconnected_16 VDD VSS CLKBUF_X1
Xclkload17 clknet_leaf_10_clk _unconnected_17 VDD VSS CLKBUF_X1
Xclkload18 clknet_leaf_12_clk _unconnected_18 VDD VSS CLKBUF_X1
Xclkload19 clknet_leaf_13_clk _unconnected_19 VDD VSS INV_X1
Xclkload20 clknet_leaf_37_clk _unconnected_20 VDD VSS INV_X1
Xclkload21 clknet_leaf_14_clk _unconnected_21 VDD VSS CLKBUF_X1
Xclkload22 clknet_leaf_15_clk _unconnected_22 VDD VSS CLKBUF_X1
Xclkload23 clknet_leaf_24_clk _unconnected_23 VDD VSS INV_X2
Xclkload24 clknet_leaf_34_clk _unconnected_24 VDD VSS CLKBUF_X1
Xclkload25 clknet_leaf_35_clk _unconnected_25 VDD VSS INV_X1
Xclkload26 clknet_leaf_36_clk _unconnected_26 VDD VSS INV_X1
Xclkload27 clknet_leaf_19_clk _unconnected_27 VDD VSS INV_X1
Xclkload28 clknet_leaf_20_clk _unconnected_28 VDD VSS CLKBUF_X1
Xclkload29 clknet_leaf_21_clk _unconnected_29 VDD VSS CLKBUF_X1
Xclkload30 clknet_leaf_22_clk _unconnected_30 VDD VSS CLKBUF_X1
Xclkload31 clknet_leaf_25_clk _unconnected_31 VDD VSS INV_X1
Xclkload32 clknet_leaf_26_clk _unconnected_32 VDD VSS CLKBUF_X1
Xclkload33 clknet_leaf_27_clk _unconnected_33 VDD VSS CLKBUF_X1
Xclkload34 clknet_leaf_28_clk _unconnected_34 VDD VSS CLKBUF_X1
Xclkload35 clknet_leaf_29_clk _unconnected_35 VDD VSS INV_X1
Xclkload36 clknet_leaf_30_clk _unconnected_36 VDD VSS CLKBUF_X1
Xclkload37 clknet_leaf_31_clk _unconnected_37 VDD VSS CLKBUF_X1
Xclkload38 clknet_leaf_33_clk _unconnected_38 VDD VSS INV_X1
Xclkload39 clknet_leaf_72_clk _unconnected_39 VDD VSS INV_X1
Xclkload40 clknet_leaf_73_clk _unconnected_40 VDD VSS INV_X2
Xclkload41 clknet_leaf_74_clk _unconnected_41 VDD VSS INV_X2
Xclkload42 clknet_leaf_75_clk _unconnected_42 VDD VSS INV_X2
Xclkload43 clknet_leaf_76_clk _unconnected_43 VDD VSS INV_X2
Xclkload44 clknet_leaf_77_clk _unconnected_44 VDD VSS CLKBUF_X1
Xclkload45 clknet_leaf_78_clk _unconnected_45 VDD VSS INV_X2
Xclkload46 clknet_leaf_38_clk _unconnected_46 VDD VSS CLKBUF_X1
Xclkload47 clknet_leaf_39_clk _unconnected_47 VDD VSS INV_X1
Xclkload48 clknet_leaf_40_clk _unconnected_48 VDD VSS INV_X2
Xclkload49 clknet_leaf_65_clk _unconnected_49 VDD VSS CLKBUF_X1
Xclkload50 clknet_leaf_66_clk _unconnected_50 VDD VSS INV_X1
Xclkload51 clknet_leaf_67_clk _unconnected_51 VDD VSS CLKBUF_X1
Xclkload52 clknet_leaf_68_clk _unconnected_52 VDD VSS CLKBUF_X1
Xclkload53 clknet_leaf_70_clk _unconnected_53 VDD VSS CLKBUF_X1
Xclkload54 clknet_leaf_71_clk _unconnected_54 VDD VSS CLKBUF_X1
Xclkload55 clknet_leaf_52_clk _unconnected_55 VDD VSS CLKBUF_X1
Xclkload56 clknet_leaf_53_clk _unconnected_56 VDD VSS CLKBUF_X1
Xclkload57 clknet_leaf_54_clk _unconnected_57 VDD VSS CLKBUF_X1
Xclkload58 clknet_leaf_55_clk _unconnected_58 VDD VSS CLKBUF_X1
Xclkload59 clknet_leaf_57_clk _unconnected_59 VDD VSS CLKBUF_X1
Xclkload60 clknet_leaf_58_clk _unconnected_60 VDD VSS CLKBUF_X1
Xclkload61 clknet_leaf_60_clk _unconnected_61 VDD VSS CLKBUF_X1
Xclkload62 clknet_leaf_61_clk _unconnected_62 VDD VSS CLKBUF_X1
Xclkload63 clknet_leaf_62_clk _unconnected_63 VDD VSS INV_X1
Xclkload64 clknet_leaf_63_clk _unconnected_64 VDD VSS CLKBUF_X1
Xclkload65 clknet_leaf_64_clk _unconnected_65 VDD VSS INV_X1
Xclkload66 clknet_leaf_32_clk _unconnected_66 VDD VSS CLKBUF_X1
Xclkload67 clknet_leaf_41_clk _unconnected_67 VDD VSS CLKBUF_X1
Xclkload68 clknet_leaf_42_clk _unconnected_68 VDD VSS INV_X2
Xclkload69 clknet_leaf_43_clk _unconnected_69 VDD VSS CLKBUF_X1
Xclkload70 clknet_leaf_44_clk _unconnected_70 VDD VSS CLKBUF_X1
Xclkload71 clknet_leaf_46_clk _unconnected_71 VDD VSS CLKBUF_X1
Xclkload72 clknet_leaf_47_clk _unconnected_72 VDD VSS INV_X1
Xclkload73 clknet_leaf_48_clk _unconnected_73 VDD VSS CLKBUF_X1
Xclkload74 clknet_leaf_49_clk _unconnected_74 VDD VSS CLKBUF_X1
Xclkload75 clknet_leaf_50_clk _unconnected_75 VDD VSS CLKBUF_X1
Xclkload76 clknet_leaf_51_clk _unconnected_76 VDD VSS CLKBUF_X1
Xrebuffer1 _04356_ net399 VDD VSS BUF_X1
Xrebuffer2 net399 net400 VDD VSS BUF_X1
Xrebuffer3 net399 net401 VDD VSS BUF_X1
Xclone43 net403 _03412_ _03473_ net402 VDD VSS NAND3_X2
Xclone45 _03351_ _03430_ _03432_ _03445_ net403 VDD VSS OAI22_X2
Xrebuffer46 _04247_ net404 VDD VSS BUF_X1
Xrebuffer47 _04248_ net405 VDD VSS BUF_X1
Xrebuffer48 _04248_ net406 VDD VSS BUF_X1
Xrebuffer49 _04096_ net407 VDD VSS BUF_X1
Xclone50 _04070_ net408 VDD VSS BUF_X4
Xrebuffer51 _09264_ net409 VDD VSS BUF_X1
Xrebuffer52 _04567_ net410 VDD VSS BUF_X1
Xrebuffer53 _04567_ net411 VDD VSS BUF_X1
Xrebuffer54 net414 net412 VDD VSS BUF_X1
Xrebuffer55 _04566_ net413 VDD VSS BUF_X1
Xrebuffer57 net416 net415 VDD VSS BUF_X1
Xrebuffer58 net417 net416 VDD VSS BUF_X1
Xrebuffer59 net418 net417 VDD VSS BUF_X1
Xrebuffer60 net419 net418 VDD VSS BUF_X1
Xrebuffer61 net420 net419 VDD VSS BUF_X1
Xrebuffer62 net421 net420 VDD VSS BUF_X1
Xrebuffer63 net422 net421 VDD VSS BUF_X1
Xrebuffer64 _04565_ net422 VDD VSS BUF_X4
Xrebuffer65 _04568_ net423 VDD VSS BUF_X1
Xclone66 _03053_ net424 VDD VSS BUF_X4
Xclone67 _02927_ net425 VDD VSS BUF_X8
Xrebuffer71 _04568_ net429 VDD VSS BUF_X1
Xrebuffer86 _08702_ net444 VDD VSS BUF_X1
Xrebuffer87 _08702_ net445 VDD VSS BUF_X1
Xrebuffer88 _08707_ net446 VDD VSS BUF_X1
Xrebuffer89 _08707_ net447 VDD VSS BUF_X1
Xrebuffer90 net474 net448 VDD VSS BUF_X1
Xrebuffer91 _05893_ net449 VDD VSS BUF_X1
Xrebuffer92 _05891_ net450 VDD VSS BUF_X1
Xrebuffer93 _05889_ net451 VDD VSS BUF_X2
Xrebuffer94 _00001_ net452 VDD VSS BUF_X2
Xrebuffer95 net485 net453 VDD VSS BUF_X16
Xrebuffer96 _05877_ net454 VDD VSS BUF_X1
Xrebuffer97 _05871_ net455 VDD VSS BUF_X1
Xrebuffer98 _05906_ net456 VDD VSS BUF_X1
Xrebuffer99 _07358_ net457 VDD VSS BUF_X1
Xrebuffer100 _00873_ net458 VDD VSS BUF_X16
Xrebuffer101 _05900_ net459 VDD VSS BUF_X1
Xrebuffer116 _08707_ net474 VDD VSS BUF_X2
Xrebuffer117 net458 net475 VDD VSS BUF_X1
Xrebuffer118 net130 net476 VDD VSS BUF_X1
Xrebuffer119 net130 net477 VDD VSS BUF_X1
Xrebuffer120 _05856_ net478 VDD VSS BUF_X1
Xrebuffer123 _08637_ net481 VDD VSS BUF_X4
Xclone124 _06065_ net482 VDD VSS BUF_X16
Xclone126 _06092_ net483 VDD VSS BUF_X8
Xclone141 _05936_ net491 VDD VSS BUF_X16
Xrebuffer143 _08626_ net493 VDD VSS BUF_X2
Xrebuffer144 net493 net494 VDD VSS BUF_X1
Xrebuffer145 _08626_ net495 VDD VSS BUF_X1
Xrebuffer146 _05418_ net496 VDD VSS BUF_X1
Xrebuffer147 _05419_ net497 VDD VSS BUF_X4
Xrebuffer148 _05394_ net498 VDD VSS BUF_X1
Xrebuffer149 _05390_ net499 VDD VSS BUF_X4
Xrebuffer150 _07350_ net500 VDD VSS BUF_X1
Xrebuffer151 _05382_ net501 VDD VSS BUF_X1
Xrebuffer152 _05388_ net502 VDD VSS BUF_X1
Xrebuffer153 _05375_ net503 VDD VSS BUF_X1
Xrebuffer154 _05392_ net504 VDD VSS BUF_X4
Xrebuffer155 net508 net505 VDD VSS BUF_X1
Xrebuffer156 _05373_ net506 VDD VSS BUF_X1
Xrebuffer157 _05386_ net507 VDD VSS BUF_X1
Xrebuffer158 _05384_ net508 VDD VSS BUF_X2
Xrebuffer159 _05377_ net509 VDD VSS BUF_X4
Xrebuffer160 _05371_ net510 VDD VSS BUF_X1
Xrebuffer162 _05414_ net512 VDD VSS BUF_X1
Xrebuffer164 _06198_ net514 VDD VSS BUF_X1
Xrebuffer165 _06225_ net515 VDD VSS BUF_X2
Xclone166 _06227_ net516 VDD VSS BUF_X16
Xrebuffer167 _06144_ net517 VDD VSS BUF_X2
Xrebuffer168 net487 net518 VDD VSS BUF_X2
Xrebuffer129 _05338_ net520 VDD VSS BUF_X1
Xmax_cap1 _04046_ net426 VDD VSS BUF_X2
Xclone47 _03504_ _03505_ net428 VDD VSS NOR2_X2
Xrebuffer73 _04882_ net437 VDD VSS BUF_X4
Xrebuffer74 _04962_ net438 VDD VSS BUF_X1
Xrebuffer79 _05926_ net443 VDD VSS BUF_X2
Xrebuffer80 net443 net460 VDD VSS BUF_X1
Xrebuffer81 _05930_ net461 VDD VSS BUF_X4
Xrebuffer82 _05921_ net462 VDD VSS BUF_X1
Xrebuffer83 _05886_ net463 VDD VSS BUF_X1
Xrebuffer84 _05901_ net464 VDD VSS BUF_X1
Xclone106 _05859_ _05298_ net470 VDD VSS AND2_X2
Xrebuffer113 _05929_ net485 VDD VSS BUF_X8
Xrebuffer114 _06065_ net486 VDD VSS BUF_X8
Xrebuffer115 _06171_ net487 VDD VSS BUF_X4
Xrebuffer121 net534 net488 VDD VSS BUF_X4
Xrebuffer122 _05367_ net489 VDD VSS BUF_X1
Xrebuffer126 _00931_ net511 VDD VSS BUF_X16
Xrebuffer127 _05577_ net513 VDD VSS BUF_X4
Xrebuffer130 _08629_ net521 VDD VSS BUF_X1
Xrebuffer131 _08619_ net522 VDD VSS BUF_X1
Xrebuffer133 _06092_ net524 VDD VSS BUF_X8
Xrebuffer135 _05342_ net526 VDD VSS BUF_X4
Xrebuffer136 _05723_ net527 VDD VSS BUF_X1
Xrebuffer137 _05468_ net528 VDD VSS BUF_X4
Xrebuffer138 _05475_ net529 VDD VSS BUF_X2
Xrebuffer139 _05431_ net530 VDD VSS BUF_X4
Xrebuffer140 _05508_ net531 VDD VSS BUF_X8
Xrebuffer163 _05577_ net534 VDD VSS BUF_X4
.ENDS parameterized_fft
