* cell mesh_router
* pin north_in_data[27]
* pin north_in_data[24]
* pin north_in_data[26]
* pin north_in_data[25]
* pin east_in_data[7]
* pin north_in_data[7]
* pin east_in_data[6]
* pin local_out_data[27]
* pin local_out_data[26]
* pin north_in_data[6]
* pin east_in_data[3]
* pin north_in_data[3]
* pin local_out_data[3]
* pin north_in_data[2]
* pin east_in_data[2]
* pin north_in_data[5]
* pin east_in_data[5]
* pin local_out_data[2]
* pin east_in_data[4]
* pin north_in_data[4]
* pin north_in_data[8]
* pin east_in_data[8]
* pin local_out_data[4]
* pin north_in_data[9]
* pin east_in_data[9]
* pin east_in_data[23]
* pin north_in_data[23]
* pin north_in_data[22]
* pin east_in_data[22]
* pin south_in_data[22]
* pin north_in_data[21]
* pin east_in_data[21]
* pin south_in_data[21]
* pin north_in_data[20]
* pin east_in_data[20]
* pin south_in_data[20]
* pin north_in_data[1]
* pin north_in_data[19]
* pin south_in_data[1]
* pin south_in_data[19]
* pin east_in_data[1]
* pin east_in_data[19]
* pin east_in_data[0]
* pin east_in_data[18]
* pin north_in_data[18]
* pin north_in_data[0]
* pin east_in_data[17]
* pin north_in_data[17]
* pin north_in_data[12]
* pin south_in_data[25]
* pin east_in_data[24]
* pin north_in_data[28]
* pin east_in_data[26]
* pin east_in_data[25]
* pin north_in_data[13]
* pin north_in_data[15]
* pin north_in_data[11]
* pin north_in_data[16]
* pin north_in_data[30]
* pin north_in_data[31]
* pin east_in_data[27]
* pin north_in_data[10]
* pin east_in_data[13]
* pin north_in_data[14]
* pin east_in_ready
* pin east_in_valid
* pin north_in_data[29]
* pin east_in_data[16]
* pin south_in_data[26]
* pin east_in_data[15]
* pin east_in_data[14]
* pin east_in_data[28]
* pin east_in_data[29]
* pin south_in_data[23]
* pin north_in_valid
* pin east_in_data[10]
* pin east_in_data[31]
* pin east_in_data[30]
* pin east_in_data[11]
* pin east_in_data[12]
* pin local_out_data[16]
* pin local_out_data[18]
* pin local_out_data[20]
* pin local_out_data[21]
* pin local_out_data[22]
* pin local_out_data[1]
* pin local_out_data[10]
* pin south_in_data[24]
* pin south_out_valid
* pin local_out_data[23]
* pin local_out_data[17]
* pin south_in_data[27]
* pin south_in_data[3]
* pin south_in_data[18]
* pin south_in_data[16]
* pin south_in_data[2]
* pin south_in_data[4]
* pin local_out_data[15]
* pin south_in_data[15]
* pin south_in_ready
* pin south_in_valid
* pin south_in_data[29]
* pin south_in_data[28]
* pin local_out_data[14]
* pin south_in_data[17]
* pin south_in_data[14]
* pin east_out_ready
* pin north_in_ready
* pin west_out_valid
* pin local_out_valid
* pin west_out_ready
* pin south_in_data[30]
* pin east_out_valid
* pin south_out_ready
* pin south_in_data[10]
* pin south_in_data[31]
* pin south_in_data[13]
* pin local_out_data[13]
* pin local_out_data[12]
* pin south_in_data[6]
* pin south_in_data[0]
* pin south_in_data[11]
* pin south_in_data[12]
* pin local_out_data[7]
* pin south_in_data[7]
* pin south_in_data[5]
* pin local_out_data[25]
* pin local_out_data[0]
* pin local_out_data[11]
* pin local_out_data[6]
* pin north_out_valid
* pin east_out_data[10]
* pin local_out_data[8]
* pin local_out_data[29]
* pin local_out_data[31]
* pin local_out_data[5]
* pin local_out_data[24]
* pin north_out_ready
* pin clk
* pin east_out_data[17]
* pin south_out_data[12]
* pin east_out_data[11]
* pin west_out_data[0]
* pin south_out_data[11]
* pin east_out_data[12]
* pin west_out_data[12]
* pin south_out_data[17]
* pin north_out_data[29]
* pin south_out_data[7]
* pin west_out_data[7]
* pin east_out_data[7]
* pin south_out_data[10]
* pin west_out_data[11]
* pin north_out_data[11]
* pin west_out_data[6]
* pin south_out_data[6]
* pin west_in_data[29]
* pin east_out_data[6]
* pin north_out_data[31]
* pin west_in_data[31]
* pin south_out_data[5]
* pin local_in_data[12]
* pin local_in_data[11]
* pin west_out_data[17]
* pin north_out_data[12]
* pin north_out_data[0]
* pin west_out_data[10]
* pin west_out_data[5]
* pin east_out_data[5]
* pin north_out_data[7]
* pin north_out_data[6]
* pin east_out_data[14]
* pin south_out_data[14]
* pin west_in_data[28]
* pin local_out_data[28]
* pin west_out_data[3]
* pin south_out_data[26]
* pin south_out_data[18]
* pin local_in_data[14]
* pin west_out_data[14]
* pin north_out_data[14]
* pin south_out_data[3]
* pin local_out_data[30]
* pin south_out_data[27]
* pin west_out_data[27]
* pin north_out_data[28]
* pin west_out_data[24]
* pin south_out_data[13]
* pin south_out_data[16]
* pin west_out_data[16]
* pin east_out_data[18]
* pin west_out_data[13]
* pin west_out_data[18]
* pin west_in_data[30]
* pin south_out_data[24]
* pin west_out_data[4]
* pin east_out_data[24]
* pin east_out_data[4]
* pin south_out_data[4]
* pin east_out_data[3]
* pin south_out_data[2]
* pin south_out_data[15]
* pin east_out_data[16]
* pin east_out_data[13]
* pin east_out_data[15]
* pin east_out_data[27]
* pin north_out_data[30]
* pin west_out_data[2]
* pin east_out_data[2]
* pin west_out_data[15]
* pin local_out_ready
* pin local_in_data[28]
* pin north_out_data[17]
* pin north_out_data[10]
* pin north_out_data[15]
* pin local_in_data[15]
* pin south_out_data[25]
* pin east_out_data[26]
* pin east_out_data[25]
* pin local_in_data[30]
* pin local_in_data[29]
* pin west_out_data[26]
* pin west_out_data[25]
* pin north_out_data[13]
* pin north_out_data[18]
* pin west_in_data[15]
* pin local_in_data[10]
* pin north_out_data[16]
* pin west_in_ready
* pin west_in_valid
* pin west_in_data[13]
* pin local_in_data[16]
* pin local_in_data[13]
* pin west_in_data[24]
* pin west_in_data[27]
* pin local_in_data[31]
* pin rst_n
* pin local_in_data[18]
* pin local_in_data[17]
* pin west_in_data[12]
* pin local_in_valid
* pin local_in_ready
* pin west_in_data[14]
* pin west_in_data[10]
* pin west_in_data[11]
* pin west_in_data[26]
* pin west_in_data[25]
* pin west_in_data[16]
* pin south_out_data[30]
* pin south_out_data[28]
* pin west_out_data[30]
* pin east_out_data[29]
* pin west_out_data[28]
* pin east_out_data[31]
* pin south_out_data[29]
* pin east_out_data[28]
* pin east_out_data[30]
* pin west_out_data[31]
* pin west_out_data[29]
* pin south_out_data[31]
* pin local_in_data[20]
* pin east_out_data[9]
* pin east_out_data[21]
* pin north_out_data[21]
* pin north_out_data[27]
* pin east_out_data[8]
* pin south_out_data[8]
* pin west_out_data[8]
* pin west_out_data[23]
* pin local_out_data[9]
* pin west_in_data[22]
* pin local_in_data[22]
* pin north_out_data[19]
* pin south_out_data[0]
* pin west_out_data[19]
* pin west_in_data[1]
* pin south_out_data[1]
* pin east_out_data[1]
* pin west_out_data[1]
* pin local_out_data[19]
* pin west_in_data[19]
* pin south_out_data[20]
* pin local_in_data[19]
* pin north_out_data[26]
* pin west_out_data[20]
* pin west_out_data[21]
* pin south_out_data[21]
* pin local_in_data[21]
* pin west_out_data[22]
* pin north_out_data[5]
* pin north_out_data[4]
* pin local_in_data[8]
* pin east_out_data[22]
* pin south_out_data[9]
* pin north_out_data[8]
* pin south_out_data[23]
* pin north_out_data[22]
* pin east_out_data[23]
* pin north_out_data[9]
* pin west_in_data[7]
* pin local_in_data[26]
* pin local_in_data[24]
* pin north_out_data[24]
* pin west_in_data[6]
* pin west_in_data[3]
* pin west_in_data[5]
* pin west_in_data[4]
* pin west_in_data[9]
* pin south_out_data[22]
* pin south_in_data[9]
* pin south_out_data[19]
* pin east_out_data[0]
* pin local_in_data[0]
* pin west_in_data[0]
* pin local_in_data[1]
* pin north_out_data[1]
* pin local_in_data[6]
* pin north_out_data[25]
* pin local_in_data[27]
* pin east_out_data[20]
* pin north_out_data[20]
* pin west_in_data[2]
* pin local_in_data[3]
* pin west_in_data[20]
* pin local_in_data[5]
* pin north_out_data[2]
* pin west_out_data[9]
* pin local_in_data[2]
* pin west_in_data[21]
* pin local_in_data[4]
* pin west_in_data[8]
* pin local_in_data[9]
* pin local_in_data[23]
* pin west_in_data[23]
* pin north_out_data[23]
* pin south_in_data[8]
* pin local_in_data[7]
* pin local_in_data[25]
* pin north_out_data[3]
* pin east_out_data[19]
* pin west_in_data[18]
* pin west_in_data[17]
* pin NWELL
* pin PWELL,gf180mcu_gnd
.SUBCKT mesh_router 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23
+ 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48
+ 121 122 123 124 125 126 152 153 154 155 167 168 169 203 204 205 212 213 214
+ 241 250 281 286 293 294 315 324 350 360 361 392 393 395 396 442 443 444 445
+ 446 461 462 487 488 520 521 560 561 573 574 620 743 757 758 759 760 808 809
+ 810 830 886 887 888 941 942 943 944 986 1012 1041 1042 1155 1180 1199 1200
+ 1201 1224 1225 1226 1227 1260 1261 1283 1284 1318 1352 1353 1354 1355 1356
+ 1357 1373 1394 1395 1396 1397 1398 1399 1400 1401 1421 1422 1423 1424 1471
+ 1472 1473 1492 1493 1494 1495 1496 1497 1499 1535 1536 1537 1538 1539 1540
+ 1557 1558 1559 1560 1607 1608 1634 1635 1636 1637 1667 1668 1669 1670 1693
+ 1694 1695 1696 1697 1698 1735 1736 1737 1738 1739 1740 1755 1756 1757 1758
+ 1759 1760 1761 1762 1791 1793 1794 1795 1816 1817 1818 1819 1847 1862 1863
+ 1886 1887 1888 1889 1906 1907 1908 1909 1910 1911 1912 1951 1952 1953 1954
+ 1955 1968 1969 1996 1997 1998 2009 2010 2011 2012 2030 2031 2032 2038 2039
+ 2062 2063 2064 2070 2071 2087 2123 2124 2125 2126 2127 2128 2152 2153 2154
+ 2155 2156 2157 2182 2184 2186 2187 2188 2190 2191 2192 2193 2194 2195 2196
+ 2198 2200 2201 2202 2203 2204 2205 2206 2208 2209 2211 2214 2215 2216 2217
+ 2219 2220 2221 2222 2224 2225 2226 2227 2229 2230 2231 2232 2233 2235 2236
+ 2237 2238 2239 2241 2242 2245 2246 2247 2249 2251 2254 2255 2256 2257 2260
+ 2261 2262 2264 2266 2269 2270 2271 2274 2276 2277 2278 2279 2280 2284 2286
+ 2287 2288 2289 2292 2293 2294 2295 2296 2297 2298 2304 2305
* net 1 north_in_data[27]
* net 2 north_in_data[24]
* net 3 north_in_data[26]
* net 4 north_in_data[25]
* net 5 east_in_data[7]
* net 6 north_in_data[7]
* net 7 east_in_data[6]
* net 8 local_out_data[27]
* net 9 local_out_data[26]
* net 10 north_in_data[6]
* net 11 east_in_data[3]
* net 12 north_in_data[3]
* net 13 local_out_data[3]
* net 14 north_in_data[2]
* net 15 east_in_data[2]
* net 16 north_in_data[5]
* net 17 east_in_data[5]
* net 18 local_out_data[2]
* net 19 east_in_data[4]
* net 20 north_in_data[4]
* net 21 north_in_data[8]
* net 22 east_in_data[8]
* net 23 local_out_data[4]
* net 24 north_in_data[9]
* net 25 east_in_data[9]
* net 26 east_in_data[23]
* net 27 north_in_data[23]
* net 28 north_in_data[22]
* net 29 east_in_data[22]
* net 30 south_in_data[22]
* net 31 north_in_data[21]
* net 32 east_in_data[21]
* net 33 south_in_data[21]
* net 34 north_in_data[20]
* net 35 east_in_data[20]
* net 36 south_in_data[20]
* net 37 north_in_data[1]
* net 38 north_in_data[19]
* net 39 south_in_data[1]
* net 40 south_in_data[19]
* net 41 east_in_data[1]
* net 42 east_in_data[19]
* net 43 east_in_data[0]
* net 44 east_in_data[18]
* net 45 north_in_data[18]
* net 46 north_in_data[0]
* net 47 east_in_data[17]
* net 48 north_in_data[17]
* net 121 north_in_data[12]
* net 122 south_in_data[25]
* net 123 east_in_data[24]
* net 124 north_in_data[28]
* net 125 east_in_data[26]
* net 126 east_in_data[25]
* net 152 north_in_data[13]
* net 153 north_in_data[15]
* net 154 north_in_data[11]
* net 155 north_in_data[16]
* net 167 north_in_data[30]
* net 168 north_in_data[31]
* net 169 east_in_data[27]
* net 203 north_in_data[10]
* net 204 east_in_data[13]
* net 205 north_in_data[14]
* net 212 east_in_ready
* net 213 east_in_valid
* net 214 north_in_data[29]
* net 241 east_in_data[16]
* net 250 south_in_data[26]
* net 281 east_in_data[15]
* net 286 east_in_data[14]
* net 293 east_in_data[28]
* net 294 east_in_data[29]
* net 315 south_in_data[23]
* net 324 north_in_valid
* net 350 east_in_data[10]
* net 360 east_in_data[31]
* net 361 east_in_data[30]
* net 392 east_in_data[11]
* net 393 east_in_data[12]
* net 395 local_out_data[16]
* net 396 local_out_data[18]
* net 442 local_out_data[20]
* net 443 local_out_data[21]
* net 444 local_out_data[22]
* net 445 local_out_data[1]
* net 446 local_out_data[10]
* net 461 south_in_data[24]
* net 462 south_out_valid
* net 487 local_out_data[23]
* net 488 local_out_data[17]
* net 520 south_in_data[27]
* net 521 south_in_data[3]
* net 560 south_in_data[18]
* net 561 south_in_data[16]
* net 573 south_in_data[2]
* net 574 south_in_data[4]
* net 620 local_out_data[15]
* net 743 south_in_data[15]
* net 757 south_in_ready
* net 758 south_in_valid
* net 759 south_in_data[29]
* net 760 south_in_data[28]
* net 808 local_out_data[14]
* net 809 south_in_data[17]
* net 810 south_in_data[14]
* net 830 east_out_ready
* net 886 north_in_ready
* net 887 west_out_valid
* net 888 local_out_valid
* net 941 west_out_ready
* net 942 south_in_data[30]
* net 943 east_out_valid
* net 944 south_out_ready
* net 986 south_in_data[10]
* net 1012 south_in_data[31]
* net 1041 south_in_data[13]
* net 1042 local_out_data[13]
* net 1155 local_out_data[12]
* net 1180 south_in_data[6]
* net 1199 south_in_data[0]
* net 1200 south_in_data[11]
* net 1201 south_in_data[12]
* net 1224 local_out_data[7]
* net 1225 south_in_data[7]
* net 1226 south_in_data[5]
* net 1227 local_out_data[25]
* net 1260 local_out_data[0]
* net 1261 local_out_data[11]
* net 1283 local_out_data[6]
* net 1284 north_out_valid
* net 1318 east_out_data[10]
* net 1352 local_out_data[8]
* net 1353 local_out_data[29]
* net 1354 local_out_data[31]
* net 1355 local_out_data[5]
* net 1356 local_out_data[24]
* net 1357 north_out_ready
* net 1373 clk
* net 1394 east_out_data[17]
* net 1395 south_out_data[12]
* net 1396 east_out_data[11]
* net 1397 west_out_data[0]
* net 1398 south_out_data[11]
* net 1399 east_out_data[12]
* net 1400 west_out_data[12]
* net 1401 south_out_data[17]
* net 1421 north_out_data[29]
* net 1422 south_out_data[7]
* net 1423 west_out_data[7]
* net 1424 east_out_data[7]
* net 1471 south_out_data[10]
* net 1472 west_out_data[11]
* net 1473 north_out_data[11]
* net 1492 west_out_data[6]
* net 1493 south_out_data[6]
* net 1494 west_in_data[29]
* net 1495 east_out_data[6]
* net 1496 north_out_data[31]
* net 1497 west_in_data[31]
* net 1499 south_out_data[5]
* net 1535 local_in_data[12]
* net 1536 local_in_data[11]
* net 1537 west_out_data[17]
* net 1538 north_out_data[12]
* net 1539 north_out_data[0]
* net 1540 west_out_data[10]
* net 1557 west_out_data[5]
* net 1558 east_out_data[5]
* net 1559 north_out_data[7]
* net 1560 north_out_data[6]
* net 1607 east_out_data[14]
* net 1608 south_out_data[14]
* net 1634 west_in_data[28]
* net 1635 local_out_data[28]
* net 1636 west_out_data[3]
* net 1637 south_out_data[26]
* net 1667 south_out_data[18]
* net 1668 local_in_data[14]
* net 1669 west_out_data[14]
* net 1670 north_out_data[14]
* net 1693 south_out_data[3]
* net 1694 local_out_data[30]
* net 1695 south_out_data[27]
* net 1696 west_out_data[27]
* net 1697 north_out_data[28]
* net 1698 west_out_data[24]
* net 1735 south_out_data[13]
* net 1736 south_out_data[16]
* net 1737 west_out_data[16]
* net 1738 east_out_data[18]
* net 1739 west_out_data[13]
* net 1740 west_out_data[18]
* net 1755 west_in_data[30]
* net 1756 south_out_data[24]
* net 1757 west_out_data[4]
* net 1758 east_out_data[24]
* net 1759 east_out_data[4]
* net 1760 south_out_data[4]
* net 1761 east_out_data[3]
* net 1762 south_out_data[2]
* net 1791 south_out_data[15]
* net 1793 east_out_data[16]
* net 1794 east_out_data[13]
* net 1795 east_out_data[15]
* net 1816 east_out_data[27]
* net 1817 north_out_data[30]
* net 1818 west_out_data[2]
* net 1819 east_out_data[2]
* net 1847 west_out_data[15]
* net 1862 local_out_ready
* net 1863 local_in_data[28]
* net 1886 north_out_data[17]
* net 1887 north_out_data[10]
* net 1888 north_out_data[15]
* net 1889 local_in_data[15]
* net 1906 south_out_data[25]
* net 1907 east_out_data[26]
* net 1908 east_out_data[25]
* net 1909 local_in_data[30]
* net 1910 local_in_data[29]
* net 1911 west_out_data[26]
* net 1912 west_out_data[25]
* net 1951 north_out_data[13]
* net 1952 north_out_data[18]
* net 1953 west_in_data[15]
* net 1954 local_in_data[10]
* net 1955 north_out_data[16]
* net 1968 west_in_ready
* net 1969 west_in_valid
* net 1996 west_in_data[13]
* net 1997 local_in_data[16]
* net 1998 local_in_data[13]
* net 2009 west_in_data[24]
* net 2010 west_in_data[27]
* net 2011 local_in_data[31]
* net 2012 rst_n
* net 2030 local_in_data[18]
* net 2031 local_in_data[17]
* net 2032 west_in_data[12]
* net 2038 local_in_valid
* net 2039 local_in_ready
* net 2062 west_in_data[14]
* net 2063 west_in_data[10]
* net 2064 west_in_data[11]
* net 2070 west_in_data[26]
* net 2071 west_in_data[25]
* net 2087 west_in_data[16]
* net 2123 south_out_data[30]
* net 2124 south_out_data[28]
* net 2125 west_out_data[30]
* net 2126 east_out_data[29]
* net 2127 west_out_data[28]
* net 2128 east_out_data[31]
* net 2152 south_out_data[29]
* net 2153 east_out_data[28]
* net 2154 east_out_data[30]
* net 2155 west_out_data[31]
* net 2156 west_out_data[29]
* net 2157 south_out_data[31]
* net 2182 local_in_data[20]
* net 2184 east_out_data[9]
* net 2186 east_out_data[21]
* net 2187 north_out_data[21]
* net 2188 north_out_data[27]
* net 2190 east_out_data[8]
* net 2191 south_out_data[8]
* net 2192 west_out_data[8]
* net 2193 west_out_data[23]
* net 2194 local_out_data[9]
* net 2195 west_in_data[22]
* net 2196 local_in_data[22]
* net 2198 north_out_data[19]
* net 2200 south_out_data[0]
* net 2201 west_out_data[19]
* net 2202 west_in_data[1]
* net 2203 south_out_data[1]
* net 2204 east_out_data[1]
* net 2205 west_out_data[1]
* net 2206 local_out_data[19]
* net 2208 west_in_data[19]
* net 2209 south_out_data[20]
* net 2211 local_in_data[19]
* net 2214 north_out_data[26]
* net 2215 west_out_data[20]
* net 2216 west_out_data[21]
* net 2217 south_out_data[21]
* net 2219 local_in_data[21]
* net 2220 west_out_data[22]
* net 2221 north_out_data[5]
* net 2222 north_out_data[4]
* net 2224 local_in_data[8]
* net 2225 east_out_data[22]
* net 2226 south_out_data[9]
* net 2227 north_out_data[8]
* net 2229 south_out_data[23]
* net 2230 north_out_data[22]
* net 2231 east_out_data[23]
* net 2232 north_out_data[9]
* net 2233 west_in_data[7]
* net 2235 local_in_data[26]
* net 2236 local_in_data[24]
* net 2237 north_out_data[24]
* net 2238 west_in_data[6]
* net 2239 west_in_data[3]
* net 2241 west_in_data[5]
* net 2242 west_in_data[4]
* net 2245 west_in_data[9]
* net 2246 south_out_data[22]
* net 2247 south_in_data[9]
* net 2249 south_out_data[19]
* net 2251 east_out_data[0]
* net 2254 local_in_data[0]
* net 2255 west_in_data[0]
* net 2256 local_in_data[1]
* net 2257 north_out_data[1]
* net 2260 local_in_data[6]
* net 2261 north_out_data[25]
* net 2262 local_in_data[27]
* net 2264 east_out_data[20]
* net 2266 north_out_data[20]
* net 2269 west_in_data[2]
* net 2270 local_in_data[3]
* net 2271 west_in_data[20]
* net 2274 local_in_data[5]
* net 2276 north_out_data[2]
* net 2277 west_out_data[9]
* net 2278 local_in_data[2]
* net 2279 west_in_data[21]
* net 2280 local_in_data[4]
* net 2284 west_in_data[8]
* net 2286 local_in_data[9]
* net 2287 local_in_data[23]
* net 2288 west_in_data[23]
* net 2289 north_out_data[23]
* net 2292 south_in_data[8]
* net 2293 local_in_data[7]
* net 2294 local_in_data[25]
* net 2295 north_out_data[3]
* net 2296 east_out_data[19]
* net 2297 west_in_data[18]
* net 2298 west_in_data[17]
* net 2304 NWELL
* net 2305 PWELL,gf180mcu_gnd
* cell instance $4 r0 *1 1644.16,5.04
X$4 2305 49 1 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $8 m0 *1 1662.08,25.2
X$8 2305 77 2 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $12 r0 *1 1656.48,5.04
X$12 2305 78 3 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $16 r0 *1 1668.8,5.04
X$16 2305 50 4 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $19 r0 *1 1683.36,15.12
X$19 2305 59 5 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $24 r0 *1 1698.48,25.2
X$24 2305 82 6 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $28 m0 *1 1685.04,25.2
X$28 2305 80 7 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $31 r0 *1 1685.6,25.2
X$31 60 2304 2305 8 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $35 r0 *1 1697.36,5.04
X$35 61 2304 2305 9 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $40 m0 *1 1706.32,25.2
X$40 2305 83 10 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $43 m0 *1 1718.64,25.2
X$43 2305 84 11 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $48 r0 *1 1721.44,15.12
X$48 2305 58 12 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $53 r0 *1 1725.36,25.2
X$53 86 2304 2305 13 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $58 m0 *1 1737.68,35.28
X$58 2305 107 14 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $62 m0 *1 1735.44,25.2
X$62 2305 87 15 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $66 r0 *1 1743.28,25.2
X$66 2305 88 16 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $70 m0 *1 1747.76,25.2
X$70 2305 90 17 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $73 r0 *1 1748.32,15.12
X$73 63 2304 2305 18 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $78 r0 *1 1756.72,25.2
X$78 2305 89 19 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $82 m0 *1 1760.08,25.2
X$82 2305 91 20 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $86 m0 *1 1763.44,15.12
X$86 2305 57 21 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $90 m0 *1 1778,25.2
X$90 2305 94 22 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $93 r0 *1 1774.08,15.12
X$93 93 2304 2305 23 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $98 r0 *1 1782.48,15.12
X$98 2305 56 24 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $101 r0 *1 1809.36,15.12
X$101 2305 98 25 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $106 m0 *1 1798.72,25.2
X$106 2305 96 26 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $110 r0 *1 1802.64,25.2
X$110 2305 65 27 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $114 r0 *1 1815.52,25.2
X$114 2305 52 28 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $118 m0 *1 1816.08,25.2
X$118 2305 99 29 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $122 r0 *1 1831.2,25.2
X$122 2305 101 30 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $126 m0 *1 1828.4,25.2
X$126 2305 100 31 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $130 m0 *1 1840.72,25.2
X$130 2305 102 32 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $134 r0 *1 1843.52,25.2
X$134 2305 103 33 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $137 r0 *1 1855.84,25.2
X$137 2305 97 34 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $142 m0 *1 1853.6,25.2
X$142 2305 95 35 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $146 m0 *1 1865.92,25.2
X$146 2305 92 36 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $150 r0 *1 1881.04,5.04
X$150 2305 55 37 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $154 r0 *1 1869.28,25.2
X$154 2305 69 38 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $158 m0 *1 1881.6,25.2
X$158 2305 85 39 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $162 r0 *1 1896.16,25.2
X$162 2305 79 40 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $166 m0 *1 1888.88,35.28
X$166 2305 108 41 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $170 r0 *1 1882.72,25.2
X$170 2305 81 42 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $176 m0 *1 1918.56,25.2
X$176 2305 74 43 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $180 r0 *1 1908.48,25.2
X$180 2305 76 44 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $183 r0 *1 1918.56,15.12
X$183 2305 73 45 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $188 r0 *1 1939.84,5.04
X$188 2305 53 46 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $192 r0 *1 1930.88,15.12
X$192 2305 75 47 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $196 m0 *1 1939.28,15.12
X$196 2305 72 48 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $198 m0 *1 1650.32,15.12
X$198 2305 49 119 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $201 m0 *1 1679.44,15.12
X$201 2305 50 110 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $207 r0 *1 1681.12,5.04
X$207 2305 59 51 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $209 m0 *1 1685.04,1678.32
X$209 2305 2304 253 51 254 255 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $215 r0 *1 1817.2,5.04
X$215 2305 52 67 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $217 r0 *1 1910.72,5.04
X$217 2305 53 117 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $225 r0 *1 1896.16,5.04
X$225 2305 79 54 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $228 m0 *1 1872.08,1678.32
X$228 2305 2304 268 54 264 345 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $233 m0 *1 1864.24,15.12
X$233 2305 55 166 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $236 r0 *1 1780.8,5.04
X$236 2305 56 228 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $241 r0 *1 1766.24,5.04
X$241 2305 57 225 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $246 r0 *1 1721.44,5.04
X$246 2305 58 111 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $254 r0 *1 1676.08,1718.64
X$254 2305 513 596 60 512 427 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $258 m0 *1 1673.84,1718.64
X$258 2305 477 541 61 453 427 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $274 m0 *1 1713.04,15.12
X$274 2305 84 62 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $276 r0 *1 1716.96,1678.32
X$276 2305 2304 300 62 254 256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $286 r0 *1 1742.16,1718.64
X$286 2305 518 908 63 459 427 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $289 r0 *1 1751.68,5.04
X$289 2305 89 64 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $291 r0 *1 1756.16,1678.32
X$291 2305 2304 301 64 254 302 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $296 r0 *1 1799.84,5.04
X$296 2305 65 66 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $309 r0 *1 1799.28,1648.08
X$309 2305 2304 188 66 136 189 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $314 r0 *1 1811.6,1638
X$314 2305 2304 134 67 136 135 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $316 m0 *1 1847.44,15.12
X$316 2305 95 68 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $318 r0 *1 1853.6,1668.24
X$318 2305 2304 266 68 230 267 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $323 r0 *1 1866.48,5.04
X$323 2305 69 165 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $328 m0 *1 1893.36,15.12
X$328 2305 108 70 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $333 m0 *1 1889.44,1668.24
X$333 2305 2304 244 70 230 236 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $341 r0 *1 1904,15.12
X$341 2305 76 71 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $343 m0 *1 1908.48,1708.56
X$343 2305 2304 388 71 271 436 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $346 r0 *1 1925.28,5.04
X$346 2305 72 106 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $351 m0 *1 1904,25.2
X$351 2305 73 194 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $356 m0 *1 1910.16,15.12
X$356 2305 74 270 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $363 m0 *1 1924.72,15.12
X$363 2305 75 118 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $370 r0 *1 1657.04,15.12
X$370 2305 77 109 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $374 m0 *1 1664.88,15.12
X$374 2305 78 131 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $382 r0 *1 1698.48,15.12
X$382 2305 80 290 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $389 m0 *1 1878.8,15.12
X$389 2305 81 209 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $392 m0 *1 1698.48,15.12
X$392 2305 82 104 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $397 r0 *1 1706.32,5.04
X$397 2305 83 132 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $406 r0 *1 1880.48,15.12
X$406 2305 85 346 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $412 r0 *1 1722.56,1718.64
X$412 2305 478 605 86 456 427 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $416 r0 *1 1733.76,15.12
X$416 2305 87 120 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $423 r0 *1 1737.12,5.04
X$423 2305 88 184 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $430 m0 *1 1746.64,15.12
X$430 2305 90 223 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $435 r0 *1 1756.72,15.12
X$435 2305 91 163 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $440 r0 *1 1858.64,15.12
X$440 2305 92 321 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $446 m0 *1 1766.24,1728.72
X$446 2305 479 607 93 519 427 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $450 m0 *1 1775.76,15.12
X$450 2305 94 227 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $459 r0 *1 1794.8,15.12
X$459 2305 96 113 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $466 r0 *1 1851.36,5.04
X$466 2305 97 190 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $471 m0 *1 1800.4,15.12
X$471 2305 98 262 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $474 m0 *1 1814.96,15.12
X$474 2305 99 114 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $479 r0 *1 1822.24,15.12
X$479 2305 100 115 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $484 m0 *1 1830.64,15.12
X$484 2305 101 105 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $490 r0 *1 1832.32,5.04
X$490 2305 102 138 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $495 r0 *1 1836.8,15.12
X$495 2305 103 116 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $501 m0 *1 1694.56,1658.16
X$501 2305 2304 180 104 182 181 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $504 r0 *1 1837.92,1688.4
X$504 2305 2304 343 105 264 344 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $507 m0 *1 1929.76,1658.16
X$507 2305 2304 197 106 146 198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $510 m0 *1 1732.08,15.12
X$510 2305 107 112 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $521 m0 *1 1653.68,1638
X$521 2305 2304 161 109 136 130 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $526 m0 *1 1675.52,1658.16
X$526 2305 2304 178 110 136 179 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $531 m0 *1 1727.04,1668.24
X$531 2305 2304 222 111 182 257 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $534 r0 *1 1735.44,1648.08
X$534 2305 2304 211 112 182 133 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $538 m0 *1 1798.72,1668.24
X$538 2305 2304 229 113 230 261 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $544 m0 *1 1815.52,1668.24
X$544 2305 2304 231 114 230 232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $547 r0 *1 1827.84,1638
X$547 2305 2304 164 115 136 139 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $552 r0 *1 1836.8,1678.32
X$552 2305 2304 307 116 264 308 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $557 r0 *1 1909.6,1648.08
X$557 2305 2304 195 117 146 196 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $567 m0 *1 1928.08,1678.32
X$567 2305 2304 289 118 271 272 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $581 m0 *1 1649.76,1658.16
X$581 2305 2304 175 119 136 176 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $588 m0 *1 1735.44,1678.32
X$588 2305 2304 291 120 254 258 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $591 m0 *1 3543.12,1638
X$591 2305 121 145 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $594 m0 *1 10.64,1638
X$594 2305 157 122 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $597 r0 *1 14.56,1627.92
X$597 2305 128 123 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $600 m0 *1 31.36,1648.08
X$600 2305 124 158 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $603 r0 *1 6.16,1638
X$603 2305 127 125 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $606 m0 *1 4.48,1648.08
X$606 2305 156 126 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $608 m0 *1 16.8,1648.08
X$608 2305 127 353 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $611 m0 *1 26.88,1638
X$611 2305 128 319 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $614 r0 *1 1377.04,1648.08
X$614 2305 173 172 129 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $616 m0 *1 1379.28,1648.08
X$616 2305 2304 129 158 182 173 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $626 m0 *1 1659.84,1728.72
X$626 2304 475 130 2305 588 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $628 m0 *1 1655.92,1718.64
X$628 2305 2304 338 425 130 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $630 m0 *1 1645.28,1728.72
X$630 176 2304 422 473 2305 130 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $632 m0 *1 1650.88,1698.48
X$632 2305 2304 130 332 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $634 r0 *1 1650.88,1718.64
X$634 130 2304 176 422 2305 423 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $637 r0 *1 1649.76,1708.56
X$637 130 2305 176 422 2304 424 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $639 r0 *1 1645.28,1638
X$639 2305 130 174 161 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $646 m0 *1 1666,1658.16
X$646 2305 2304 177 131 136 221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $657 m0 *1 1708,1658.16
X$657 2305 2304 210 132 182 183 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $669 m0 *1 1739.92,1708.56
X$669 2304 340 133 2305 375 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $672 m0 *1 1734.88,1708.56
X$672 2305 2304 374 413 133 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $675 m0 *1 1728.72,1658.16
X$675 2305 133 174 211 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $679 m0 *1 1807.68,1648.08
X$679 2305 135 137 134 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $683 m0 *1 1822.24,1708.56
X$683 2304 340 135 2305 913 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $689 m0 *1 1817.2,1708.56
X$689 2305 2304 374 407 135 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $700 r0 *1 1839.6,1658.16
X$700 2305 220 136 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $708 r0 *1 1856.4,1658.16
X$708 2305 2304 246 190 136 191 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $711 m0 *1 1863.68,1638
X$711 2305 2304 140 166 136 141 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $715 r0 *1 1863.68,1648.08
X$715 2305 2304 192 165 136 193 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $733 r0 *1 1901.2,1668.24
X$733 2305 269 137 237 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $735 r0 *1 1925.28,1658.16
X$735 2305 198 137 197 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $737 r0 *1 1794.24,1668.24
X$737 2305 261 137 229 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $740 m0 *1 1800.4,1658.16
X$740 2305 189 137 188 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $742 r0 *1 1772.96,1668.24
X$742 2305 260 137 249 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $747 r0 *1 1767.36,1658.16
X$747 2305 226 137 187 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $749 r0 *1 1812.16,1668.24
X$749 2305 232 137 231 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $752 m0 *1 1757.28,1668.24
X$752 2305 186 137 224 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $755 r0 *1 1929.2,1678.32
X$755 2305 272 137 289 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $757 m0 *1 1824.48,1648.08
X$757 2305 139 137 164 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $760 m0 *1 1872.64,1668.24
X$760 2305 235 137 234 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $763 r0 *1 1872.64,1668.24
X$763 2305 236 137 244 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $765 m0 *1 1849.12,1668.24
X$765 2305 191 137 246 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $768 m0 *1 1832.32,1668.24
X$768 2305 233 137 248 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $771 r0 *1 1860.88,1638
X$771 2305 141 137 140 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $773 m0 *1 1904.56,1658.16
X$773 2305 196 137 195 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $775 r0 *1 1860.32,1688.4
X$775 2305 298 137 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $777 m0 *1 1859.2,1658.16
X$777 2305 193 137 192 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $785 r0 *1 1831.2,1658.16
X$785 2305 2304 248 138 230 233 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $793 m0 *1 1828.96,1708.56
X$793 2304 340 139 2305 385 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $799 m0 *1 1834,1708.56
X$799 2305 2304 374 405 139 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $808 r0 *1 1880.48,1708.56
X$808 2305 2304 374 401 141 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $810 m0 *1 1879.36,1738.8
X$810 2304 547 141 2305 548 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $816 r0 *1 2060.8,1648.08
X$816 2305 2304 199 142 146 143 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $818 m0 *1 3549.84,1648.08
X$818 2305 154 142 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $822 m0 *1 2056.32,1658.16
X$822 2305 143 144 199 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $824 r0 *1 2065.84,1748.88
X$824 2305 2304 439 738 143 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $827 r0 *1 2059.12,1748.88
X$827 2304 387 143 2305 678 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $843 m0 *1 2080.4,1678.32
X$843 2305 275 144 287 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $845 m0 *1 2105.6,1678.32
X$845 2305 239 144 276 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $847 m0 *1 2126.88,1708.56
X$847 2305 390 144 349 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $850 r0 *1 2069.2,1648.08
X$850 2305 200 144 162 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $852 m0 *1 2086.56,1648.08
X$852 2305 148 144 147 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $854 r0 *1 2058.56,1668.24
X$854 2305 238 144 243 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $856 m0 *1 2126.32,1688.4
X$856 2305 279 144 314 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $859 m0 *1 2089.36,1658.16
X$859 2305 151 144 201 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $861 m0 *1 2103.36,1688.4
X$861 2305 313 144 320 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $864 r0 *1 2077.6,1678.32
X$864 2305 274 144 273 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $867 r0 *1 2060.24,1698.48
X$867 2305 144 2325 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $870 r0 *1 2059.68,1708.56
X$870 2305 298 144 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $872 m0 *1 2128,1678.32
X$872 2305 280 144 278 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $875 m0 *1 2075.92,1648.08
X$875 2305 2304 162 145 146 200 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $889 r0 *1 1900.64,1658.16
X$889 2305 220 146 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $891 r0 *1 2095.52,1648.08
X$891 2305 2304 201 150 146 151 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $894 r0 *1 2086,1668.24
X$894 2305 2304 273 240 146 274 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $897 m0 *1 2065.28,1668.24
X$897 2305 2304 243 202 146 238 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $900 r0 *1 2095.52,1668.24
X$900 2305 2304 287 160 146 275 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $903 r0 *1 2086,1648.08
X$903 2305 2304 147 149 146 148 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $907 m0 *1 1906.8,1668.24
X$907 2305 2304 237 194 146 269 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $916 m0 *1 2093.28,1738.8
X$916 2304 547 148 2305 557 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $918 m0 *1 2086,1728.72
X$918 2305 2304 439 496 148 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $926 r0 *1 3551.52,1638
X$926 2305 153 149 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $930 m0 *1 3564.4,1648.08
X$930 2305 155 150 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $938 m0 *1 2098.88,1738.8
X$938 2304 547 151 2305 558 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $940 r0 *1 2086.56,1718.64
X$940 2305 2304 439 438 151 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $943 r0 *1 3549.84,1648.08
X$943 2305 152 160 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $953 r0 *1 16.8,1648.08
X$953 2305 156 207 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $958 r0 *1 18.48,1638
X$958 2305 157 159 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $969 r0 *1 1518.72,1708.56
X$969 2305 2304 420 159 264 421 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $990 r0 *1 1756.16,1658.16
X$990 2305 2304 224 163 182 186 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1009 r0 *1 16.8,1658.16
X$1009 2305 167 171 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1011 r0 *1 2.24,1658.16
X$1011 2305 168 206 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1015 r0 *1 4.48,1648.08
X$1015 2305 170 169 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $1017 m0 *1 8.4,1658.16
X$1017 2305 170 328 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $1023 r0 *1 1379.84,1658.16
X$1023 2305 2304 208 171 182 219 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1036 m0 *1 1379.84,1718.64
X$1036 2305 419 172 418 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1039 r0 *1 1382.64,1698.48
X$1039 2305 325 172 356 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1041 r0 *1 1388.24,1688.4
X$1041 2305 296 172 295 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1044 r0 *1 1388.24,1658.16
X$1044 2305 219 172 208 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1047 m0 *1 1433.6,1728.72
X$1047 2305 172 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $1049 m0 *1 1433.6,1718.64
X$1049 2305 298 172 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1053 m0 *1 1365.84,1668.24
X$1053 2305 217 172 215 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1055 m0 *1 1370.32,1678.32
X$1055 2305 218 172 251 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1057 m0 *1 1518.16,1698.48
X$1057 2305 327 172 326 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $1059 m0 *1 1515.92,1718.64
X$1059 2305 421 172 420 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $1065 m0 *1 1387.12,1758.96
X$1065 2305 173 2304 700 745 701 296 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1067 r0 *1 1431.92,1728.72
X$1067 2305 474 173 217 219 218 2304 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $1070 m0 *1 1440.32,1758.96
X$1070 2305 2304 583 706 173 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1074 m0 *1 1442.56,1708.56
X$1074 218 173 217 219 2304 2305 362 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1085 r0 *1 1727.6,1678.32
X$1085 2305 258 174 291 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1087 m0 *1 1727.6,1688.4
X$1087 2305 292 174 323 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1089 m0 *1 1711.36,1698.48
X$1089 2305 256 174 300 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1091 r0 *1 1678.88,1678.32
X$1091 2305 255 174 253 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1094 m0 *1 1690.08,1688.4
X$1094 2305 299 174 322 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1097 m0 *1 1735.44,1668.24
X$1097 2305 185 174 247 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1101 r0 *1 1669.92,1658.16
X$1101 2305 179 174 178 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1104 r0 *1 1632.4,1678.32
X$1104 2305 174 2327 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1107 m0 *1 1689.52,1668.24
X$1107 2305 181 174 180 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1109 r0 *1 1709.12,1658.16
X$1109 2305 183 174 210 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1112 r0 *1 1718.08,1668.24
X$1112 2305 257 174 222 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1115 r0 *1 1632.4,1688.4
X$1115 2305 298 174 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1118 r0 *1 1643.6,1668.24
X$1118 2305 176 245 175 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $1128 r0 *1 1676.08,1698.48
X$1128 2305 2304 338 359 176 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1132 m0 *1 1642.48,1708.56
X$1132 366 358 176 404 362 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1136 m0 *1 1636.32,1769.04
X$1136 2305 176 2304 700 844 701 330 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1138 r0 *1 1649.76,1748.88
X$1138 2304 176 422 2305 655 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1143 r0 *1 1639.12,1748.88
X$1143 2305 2304 653 176 651 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1148 m0 *1 1667.12,1668.24
X$1148 2305 221 245 177 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1163 r0 *1 1648.64,1698.48
X$1163 332 2305 179 221 2304 366 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1166 m0 *1 1638.56,1748.88
X$1166 2305 2304 583 692 179 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1168 r0 *1 1645.28,1738.8
X$1168 338 179 474 473 2305 2304 845 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1170 r0 *1 1673.84,1738.8
X$1170 387 2304 179 591 2305 589 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1172 m0 *1 1659.28,1738.8
X$1172 2305 2304 179 537 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1179 r0 *1 1715.84,1698.48
X$1179 2304 340 181 2305 339 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1182 m0 *1 1700.72,1708.56
X$1182 2305 2304 338 337 181 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1193 r0 *1 1564.08,1658.16
X$1193 2305 220 182 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1200 r0 *1 1374.24,1668.24
X$1200 2305 2304 251 216 182 218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1202 r0 *1 1370.88,1658.16
X$1202 2305 2304 215 206 182 217 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1209 r0 *1 1743.84,1658.16
X$1209 2305 2304 247 184 182 185 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1218 m0 *1 1715.84,1708.56
X$1218 2304 340 183 2305 411 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1220 r0 *1 1710.24,1698.48
X$1220 2305 2304 338 373 183 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1227 r0 *1 1741.04,1698.48
X$1227 2304 340 185 2305 377 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1230 r0 *1 1747.76,1698.48
X$1230 2305 2304 338 415 185 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1236 m0 *1 1764.56,1708.56
X$1236 2305 2304 374 416 186 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1241 m0 *1 1758.96,1708.56
X$1241 2304 340 186 2305 380 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1247 m0 *1 1774.08,1668.24
X$1247 2305 2304 187 225 220 226 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1258 m0 *1 1808.8,1708.56
X$1258 2305 2304 374 410 189 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1261 r0 *1 1804.32,1708.56
X$1261 2304 340 189 2305 431 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1268 m0 *1 1864.24,1708.56
X$1268 2305 2304 374 403 191 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1270 r0 *1 1858.64,1738.8
X$1270 2304 547 191 2305 611 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1279 m0 *1 1869.84,1738.8
X$1279 2304 547 193 2305 612 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1281 m0 *1 1872.08,1708.56
X$1281 2305 2304 374 450 193 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1291 m0 *1 1912.96,1748.88
X$1291 2304 387 196 2305 676 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1294 m0 *1 1918,1748.88
X$1294 2305 2304 439 627 196 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1300 r0 *1 1937.6,1738.8
X$1300 2304 547 198 2305 614 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1302 m0 *1 1935.92,1738.8
X$1302 2305 2304 439 552 198 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1314 r0 *1 2073.12,1748.88
X$1314 2305 2304 439 804 200 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1317 r0 *1 2079.84,1758.96
X$1317 2304 547 200 2305 805 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1324 m0 *1 3553.2,1658.16
X$1324 2305 203 202 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1330 r0 *1 3564.4,1658.16
X$1330 2305 204 242 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1334 r0 *1 3549.84,1658.16
X$1334 2305 205 240 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1344 m0 *1 1573.04,1678.32
X$1344 2305 2304 288 207 230 252 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1354 r0 *1 1878.24,1658.16
X$1354 2305 2304 234 209 230 235 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1365 r0 *1 16.8,1668.24
X$1365 282 2304 2305 212 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1368 r0 *1 25.2,1668.24
X$1368 2305 213 284 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $1371 m0 *1 16.8,1668.24
X$1371 2305 214 216 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1389 m0 *1 1378.72,1769.04
X$1389 2305 217 2304 700 831 701 419 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1391 m0 *1 1445.36,1769.04
X$1391 2305 2304 583 834 217 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1398 r0 *1 1390.48,1758.96
X$1398 2305 218 2304 700 762 701 325 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1403 r0 *1 1444.24,1748.88
X$1403 2305 2304 583 643 218 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1416 r0 *1 1433.6,1769.04
X$1416 2305 2304 583 876 219 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1418 m0 *1 1387.68,1769.04
X$1418 2305 219 2304 700 832 701 464 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1436 r0 *1 1552.88,1708.56
X$1436 351 364 363 2305 2304 220 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $1438 m0 *1 1786.4,1668.24
X$1438 2305 2304 249 228 220 260 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1451 m0 *1 1685.6,1738.8
X$1451 387 2304 221 591 2305 572 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1453 m0 *1 1695.12,1708.56
X$1453 2305 2304 374 408 221 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1456 m0 *1 1643.6,1698.48
X$1456 2305 2304 332 358 221 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1458 m0 *1 1649.2,1718.64
X$1458 2305 2304 221 422 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $1462 m0 *1 1649.2,1738.8
X$1462 338 221 474 473 2305 2304 536 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1475 r0 *1 1744.4,1678.32
X$1475 2305 2304 323 223 254 292 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1487 r0 *1 1776.32,1698.48
X$1487 2305 2304 338 417 226 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1490 r0 *1 1781.92,1698.48
X$1490 2304 340 226 2305 341 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1498 r0 *1 1775.76,1678.32
X$1498 2305 2304 303 227 263 259 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1517 r0 *1 1631.84,1698.48
X$1517 2305 263 230 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1519 r0 *1 1574.72,1698.48
X$1519 2305 2304 365 353 230 329 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1521 r0 *1 1590.96,1688.4
X$1521 2305 2304 331 319 230 297 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1523 r0 *1 1575.84,1688.4
X$1523 2305 2304 357 328 230 330 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1540 r0 *1 1817.2,1718.64
X$1540 2305 511 369 232 426 452 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1542 r0 *1 1827.84,1758.96
X$1542 2305 2304 717 781 232 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1544 r0 *1 1827.84,1748.88
X$1544 2305 2304 755 667 590 232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1553 m0 *1 1835.12,1718.64
X$1553 2305 510 369 233 426 386 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1555 m0 *1 1834,1748.88
X$1555 2305 2304 693 631 590 233 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1557 r0 *1 1832.88,1738.8
X$1557 2305 2304 481 610 233 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1571 r0 *1 1874.88,1718.64
X$1571 2305 672 369 235 426 435 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1573 r0 *1 1869.28,1748.88
X$1573 2305 2304 670 671 590 235 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1576 r0 *1 1877.68,1748.88
X$1576 2305 2304 712 786 235 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1581 m0 *1 1888.32,1718.64
X$1581 2305 503 369 236 426 400 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1583 r0 *1 1882.72,1748.88
X$1583 2305 2304 690 674 590 236 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1585 r0 *1 1886.64,1758.96
X$1585 2305 2304 717 916 236 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1594 m0 *1 2064.16,1748.88
X$1594 2304 387 238 2305 616 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1599 m0 *1 2071.44,1748.88
X$1599 2305 2304 439 617 238 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1607 r0 *1 2106.16,1789.2
X$1607 2305 2304 1045 1047 724 239 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1609 r0 *1 2074.24,1779.12
X$1609 2305 992 535 239 556 739 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1612 r0 *1 2110.64,1668.24
X$1612 2305 2304 276 242 271 239 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1614 r0 *1 2045.68,1769.04
X$1614 2305 2304 717 863 239 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1621 m0 *1 3549.84,1668.24
X$1621 2305 241 283 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1643 r0 *1 1546.72,1728.72
X$1643 2305 526 528 245 504 2304 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1645 m0 *1 1607.2,1688.4
X$1645 2305 298 245 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1650 m0 *1 1572.48,1698.48
X$1650 2305 330 245 357 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $1652 m0 *1 1570.8,1708.56
X$1652 2305 329 245 365 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $1655 r0 *1 1569.68,1678.32
X$1655 2305 252 245 288 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $1658 m0 *1 1607.2,1698.48
X$1658 2305 245 2330 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1663 r0 *1 1591.52,1698.48
X$1663 2305 297 245 331 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $1682 m0 *1 16.8,1688.4
X$1682 2305 250 352 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1697 m0 *1 1673.84,1748.88
X$1697 2305 2304 694 589 590 252 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1699 r0 *1 1681.12,1758.96
X$1699 2305 2304 717 823 252 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1701 r0 *1 1578.64,1718.64
X$1701 470 2305 252 329 2304 468 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1703 r0 *1 1606.64,1728.72
X$1703 252 2304 329 650 2305 470 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $1707 m0 *1 1611.68,1758.96
X$1707 712 2304 252 381 2305 713 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1709 r0 *1 1588.72,1718.64
X$1709 2305 505 470 2304 252 329 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1712 m0 *1 1577.52,1738.8
X$1712 2305 2304 529 252 467 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1714 r0 *1 1578.08,1738.8
X$1714 252 2305 467 630 2304 585 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1727 m0 *1 1388.24,1688.4
X$1727 2305 2304 295 316 254 296 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1735 m0 *1 1564.08,1688.4
X$1735 2305 263 254 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1738 r0 *1 1696.8,1678.32
X$1738 2305 2304 322 290 254 299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1740 r0 *1 1391.04,1718.64
X$1740 2305 2304 463 447 254 464 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1743 r0 *1 1379.84,1718.64
X$1743 2305 2304 418 489 254 419 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1746 m0 *1 1386,1698.48
X$1746 2305 2304 356 318 254 325 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1751 m0 *1 1682.24,1748.88
X$1751 2305 2304 592 593 594 255 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1754 r0 *1 1696.8,1708.56
X$1754 2305 428 378 255 429 371 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1757 r0 *1 1690.64,1738.8
X$1757 2305 2304 481 598 255 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1762 m0 *1 1719.76,1738.8
X$1762 2305 2304 481 604 256 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1764 r0 *1 1716.96,1738.8
X$1764 2305 2304 603 636 594 256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1766 m0 *1 1719.76,1718.64
X$1766 2305 456 378 256 429 457 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1772 m0 *1 1725.36,1708.56
X$1772 2305 2304 374 412 257 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1774 r0 *1 1716.96,1708.56
X$1774 2304 340 257 2305 455 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1778 m0 *1 1739.92,1718.64
X$1778 2305 459 369 258 429 458 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1780 m0 *1 1739.36,1758.96
X$1780 2305 2304 712 720 258 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1783 r0 *1 1738.8,1738.8
X$1783 2305 2304 606 637 594 258 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1789 r0 *1 1774.64,1708.56
X$1789 2305 382 378 259 429 414 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1792 r0 *1 1782.48,1738.8
X$1792 2305 2304 608 634 594 259 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1794 m0 *1 1781.92,1748.88
X$1794 2305 2304 481 911 259 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1797 m0 *1 1771.84,1688.4
X$1797 2305 259 265 303 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1802 r0 *1 1782.48,1718.64
X$1802 2305 2304 338 430 260 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1804 m0 *1 1790.32,1728.72
X$1804 2304 475 260 2305 480 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1814 m0 *1 1800.4,1718.64
X$1814 2305 517 369 261 426 383 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1817 r0 *1 1803.2,1758.96
X$1817 2305 2304 717 780 261 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1819 r0 *1 1817.2,1748.88
X$1819 2305 2304 666 695 590 261 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1824 r0 *1 1806.56,1678.32
X$1824 2305 2304 305 262 263 304 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1833 m0 *1 1898.4,1688.4
X$1833 2305 263 271 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1840 m0 *1 1556.24,1698.48
X$1840 284 282 363 2305 2304 263 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $1856 m0 *1 1850.8,1748.88
X$1856 2305 726 264 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1858 r0 *1 1520.96,1688.4
X$1858 2305 2304 326 352 264 327 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1861 m0 *1 1884.96,1698.48
X$1861 2305 2304 311 346 264 347 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1863 m0 *1 1515.36,1728.72
X$1863 2305 2304 465 491 264 524 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1865 m0 *1 1855.28,1688.4
X$1865 2305 2304 309 321 264 310 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1867 r0 *1 1818.32,1688.4
X$1867 2305 2304 342 355 264 306 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1870 m0 *1 1515.36,1738.8
X$1870 2305 2304 523 562 264 538 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1881 r0 *1 1855.28,1678.32
X$1881 2305 310 265 309 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1884 m0 *1 1753.92,1688.4
X$1884 2305 302 265 301 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1887 m0 *1 1832.32,1688.4
X$1887 2305 308 265 307 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1890 r0 *1 1876,1678.32
X$1890 2305 347 265 311 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1892 m0 *1 1863.68,1688.4
X$1892 2305 298 265 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1897 m0 *1 1807.68,1698.48
X$1897 2305 306 265 342 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1899 m0 *1 1803.76,1688.4
X$1899 2305 304 265 305 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1902 m0 *1 1832.88,1698.48
X$1902 2305 344 265 343 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1904 r0 *1 1872.08,1698.48
X$1904 2305 345 265 268 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1906 m0 *1 1863.68,1698.48
X$1906 2305 265 2324 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1909 r0 *1 1909.04,1688.4
X$1909 2305 348 265 312 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1913 m0 *1 1848.56,1678.32
X$1913 2305 267 265 266 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1915 r0 *1 1904.56,1708.56
X$1915 2305 436 265 388 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1922 m0 *1 1855.28,1718.64
X$1922 2305 433 369 267 426 434 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1924 m0 *1 1863.68,1758.96
X$1924 2305 2304 717 751 267 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1930 m0 *1 1855.28,1758.96
X$1930 2305 2304 754 669 590 267 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1940 m0 *1 1921.92,1738.8
X$1940 2304 547 269 2305 551 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1942 r0 *1 1921.36,1728.72
X$1942 2305 2304 439 484 269 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1947 r0 *1 1914.64,1678.32
X$1947 2305 2304 312 270 271 348 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1961 m0 *1 2109.52,1708.56
X$1961 2305 2304 399 397 271 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1968 r0 *1 2112.88,1678.32
X$1968 2305 2304 320 277 271 313 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1972 r0 *1 2133.6,1678.32
X$1972 2305 2304 314 285 271 279 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1974 r0 *1 2134.16,1668.24
X$1974 2305 2304 278 283 271 280 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1976 r0 *1 2133.04,1698.48
X$1976 2305 2304 349 354 271 390 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1979 m0 *1 2144.8,1708.56
X$1979 2305 2304 391 398 271 441 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1986 m0 *1 1943.76,1758.96
X$1986 2305 2304 717 792 272 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1988 r0 *1 1932,1728.72
X$1988 2305 567 535 272 426 500 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1991 r0 *1 1940.4,1758.96
X$1991 2305 2304 747 728 724 272 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2002 r0 *1 2095.52,1758.96
X$2002 2304 547 274 2305 806 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2004 r0 *1 2089.36,1748.88
X$2004 2305 2304 439 741 274 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2014 m0 *1 2099.44,1758.96
X$2014 2304 547 275 2305 742 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2016 m0 *1 2090.48,1748.88
X$2016 2305 2304 439 618 275 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2023 m0 *1 3552.08,1678.32
X$2023 2305 281 277 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2033 r0 *1 2074.24,1769.04
X$2033 2305 869 535 279 556 740 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2036 m0 *1 2050.16,1769.04
X$2036 2305 2304 640 802 279 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2038 m0 *1 2110.08,1809.36
X$2038 2305 2304 1153 1159 724 279 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2048 m0 *1 1971.76,1769.04
X$2048 2305 2304 712 794 280 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2054 r0 *1 2074.24,1728.72
X$2054 2305 564 535 280 556 497 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2056 m0 *1 2110.08,1769.04
X$2056 2305 2304 868 813 724 280 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2062 m0 *1 1559.6,1708.56
X$2062 2305 527 282 2304 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $2076 m0 *1 1554,1728.72
X$2076 2305 2304 504 466 485 284 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2078 r0 *1 3549.84,1678.32
X$2078 2305 286 285 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2110 r0 *1 1741.04,1708.56
X$2110 2305 376 378 292 429 379 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2113 r0 *1 1752.8,1748.88
X$2113 2305 2304 662 696 594 292 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2115 m0 *1 1746.08,1758.96
X$2115 2305 2304 640 829 292 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2119 m0 *1 2.24,1688.4
X$2119 2305 293 316 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2121 r0 *1 16.8,1688.4
X$2121 2305 294 318 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2133 r0 *1 1411.76,1748.88
X$2133 2305 2304 640 642 296 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2136 m0 *1 1397.76,1748.88
X$2136 2305 641 296 419 464 325 2304 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $2140 m0 *1 1403.92,1728.72
X$2140 325 296 419 464 2304 2305 467 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2151 m0 *1 1691.2,1748.88
X$2151 2305 2304 481 597 297 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2153 m0 *1 1701.84,1748.88
X$2153 2305 2304 659 635 590 297 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2155 r0 *1 1602.16,1718.64
X$2155 2305 2304 297 470 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $2157 m0 *1 1597.12,1738.8
X$2157 527 297 330 532 2305 2304 1016 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2159 r0 *1 1590.4,1738.8
X$2159 330 2304 532 586 2305 297 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $2164 m0 *1 1583.12,1738.8
X$2164 628 297 330 532 2304 2305 570 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2181 r0 *1 2059.68,1869.84
X$2181 2305 298 1743 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2183 m0 *1 2060.8,1879.92
X$2183 2305 298 1259 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2186 r0 *1 1436.4,1859.76
X$2186 2305 298 1617 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2188 m0 *1 1436.4,1869.84
X$2188 2305 298 1228 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2194 r0 *1 1743.84,1809.36
X$2194 2305 1373 298 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2201 r0 *1 1434.72,1718.64
X$2201 2305 298 451 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2204 m0 *1 1597.12,1910.16
X$2204 2305 298 1918 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2207 m0 *1 1870.4,1910.16
X$2207 2305 298 1660 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2209 m0 *1 2060.24,1708.56
X$2209 2305 298 389 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2212 m0 *1 1870.96,1920.24
X$2212 2305 298 2025 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2214 r0 *1 1613.92,1910.16
X$2214 2305 298 1976 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2218 r0 *1 1696.8,1738.8
X$2218 2305 2304 599 600 594 299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2221 r0 *1 1705.2,1738.8
X$2221 2305 2304 481 601 299 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2225 m0 *1 1696.8,1718.64
X$2225 2305 515 378 299 429 372 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2236 r0 *1 1762.32,1718.64
X$2236 2305 519 378 302 429 460 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2238 r0 *1 1764.56,1758.96
X$2238 2305 2304 712 778 302 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2240 r0 *1 1764.56,1748.88
X$2240 2305 2304 663 697 594 302 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2250 r0 *1 1793.68,1718.64
X$2250 2305 1632 378 304 429 454 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2255 m0 *1 1797.04,1748.88
X$2255 2305 2304 609 633 594 304 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2257 r0 *1 1804.32,1748.88
X$2257 2305 2304 640 1301 304 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2265 r0 *1 1813.28,1789.2
X$2265 2305 306 1020 2304 1028 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2267 r0 *1 1808.8,1758.96
X$2267 2305 2304 825 666 657 306 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2269 r0 *1 1816.08,1799.28
X$2269 2305 306 1144 2304 1179 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2271 r0 *1 1803.2,1728.72
X$2271 2305 2304 516 306 539 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2274 r0 *1 1798.72,1779.12
X$2274 2305 967 1065 1009 912 902 306 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $2290 r0 *1 1835.68,1789.2
X$2290 2305 1019 1030 1062 1061 1021 308 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $2293 m0 *1 1843.52,1799.28
X$2293 2305 308 1020 2304 1031 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2296 r0 *1 1840.16,1748.88
X$2296 2305 2304 668 693 657 308 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2298 r0 *1 1853.6,1769.04
X$2298 2305 308 731 2304 857 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2300 m0 *1 1849.68,1728.72
X$2300 2305 2304 508 308 482 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2316 r0 *1 1860.88,1758.96
X$2316 2305 2304 785 754 657 310 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2319 r0 *1 1868.72,1809.36
X$2319 2305 310 1144 2304 1221 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2321 m0 *1 1861.44,1809.36
X$2321 2305 310 1020 2304 1148 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2325 r0 *1 1854.72,1779.12
X$2325 2305 967 1176 1006 969 902 310 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $2327 r0 *1 1863.12,1718.64
X$2327 2305 2304 506 310 482 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2339 m0 *1 2071.44,1738.8
X$2339 2305 565 535 313 556 555 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2344 m0 *1 2104.48,1789.2
X$2344 2305 2304 1039 991 724 313 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2346 r0 *1 2050.72,1769.04
X$2346 2305 2304 640 797 313 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2353 m0 *1 3566.64,1698.48
X$2353 2305 317 315 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $2360 r0 *1 3552.08,1688.4
X$2360 2305 317 355 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $2389 m0 *1 14.56,1698.48
X$2389 2305 324 351 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $2401 m0 *1 1410.64,1758.96
X$2401 2305 2304 640 702 325 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2414 m0 *1 1678.32,1758.96
X$2414 2305 2304 715 540 657 327 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2417 m0 *1 1551.2,1789.2
X$2417 2305 2304 950 1048 327 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2423 m0 *1 1700.16,1779.12
X$2423 2305 327 731 2304 939 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2425 m0 *1 1557.92,1789.2
X$2425 950 2305 421 327 2304 951 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2428 r0 *1 1541.12,1728.72
X$2428 2305 2304 327 501 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $2442 m0 *1 1686.72,1758.96
X$2442 2305 2304 712 718 329 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2444 m0 *1 1677.2,1738.8
X$2444 2305 2304 540 572 590 329 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2446 m0 *1 1674.4,1708.56
X$2446 2305 453 369 329 426 409 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2452 r0 *1 1598.24,1728.72
X$2452 2305 2304 329 532 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2465 r0 *1 1672.16,1708.56
X$2465 2305 512 369 330 426 334 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2467 m0 *1 1575.84,1728.72
X$2467 2305 530 505 468 330 467 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2471 r0 *1 1593.2,1728.72
X$2471 2305 2304 330 531 532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2502 r0 *1 1818.88,1708.56
X$2502 335 333 384 452 407 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2504 m0 *1 1878.8,1718.64
X$2504 432 333 384 435 450 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2507 r0 *1 1823.36,1728.72
X$2507 2305 481 333 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2509 r0 *1 1860.88,1708.56
X$2509 432 333 384 434 403 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2511 r0 *1 1809.36,1708.56
X$2511 335 333 384 383 410 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2514 r0 *1 1683.36,1698.48
X$2514 335 333 336 409 408 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2517 m0 *1 1934.8,1728.72
X$2517 432 333 384 500 552 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2519 r0 *1 1924.16,1718.64
X$2519 432 333 384 483 484 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2521 m0 *1 1679.44,1698.48
X$2521 335 333 336 334 359 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2524 r0 *1 1849.12,1708.56
X$2524 432 333 384 386 405 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2526 r0 *1 1885.52,1708.56
X$2526 432 333 384 400 401 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2543 m0 *1 1705.76,1708.56
X$2543 335 370 336 372 373 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2545 r0 *1 1731.52,1708.56
X$2545 335 370 336 458 413 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2547 m0 *1 1785.28,1708.56
X$2547 2305 2304 381 335 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2549 r0 *1 1762.32,1708.56
X$2549 335 370 336 460 416 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2551 m0 *1 1744.96,1708.56
X$2551 335 370 336 379 415 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2555 r0 *1 1722,1708.56
X$2555 335 370 336 457 412 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2559 r0 *1 1700.72,1698.48
X$2559 335 370 336 371 337 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2573 m0 *1 1769.04,1718.64
X$2573 2305 454 381 370 336 430 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2576 r0 *1 1733.2,1698.48
X$2576 2305 2304 367 336 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2585 m0 *1 1772.96,1708.56
X$2585 381 370 336 414 417 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $2606 m0 *1 1641.36,1718.64
X$2606 2305 2304 387 338 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2613 r0 *1 1637.44,1738.8
X$2613 2305 2304 338 583 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2626 r0 *1 1682.8,1738.8
X$2626 2304 591 339 2305 593 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2628 r0 *1 1718.08,1809.36
X$2628 775 909 339 776 2305 2304 1187 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2630 r0 *1 1687.84,1799.28
X$2630 906 602 339 937 2305 2304 1171 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2632 m0 *1 1713.04,1809.36
X$2632 905 915 959 339 2305 2304 1173 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2655 m0 *1 1821.12,1718.64
X$2655 2305 2304 475 340 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $2663 r0 *1 1777.44,1738.8
X$2663 2304 591 341 2305 634 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2665 r0 *1 1784.16,1799.28
X$2665 906 602 341 937 2305 2304 1248 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2667 r0 *1 1785.28,1809.36
X$2667 775 909 341 776 2305 2304 1222 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2670 m0 *1 1778,1809.36
X$2670 955 580 1139 341 2305 2304 1247 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2683 m0 *1 1831.76,1738.8
X$2683 2305 2304 344 546 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2687 m0 *1 1833.44,1758.96
X$2687 2305 2304 725 755 657 344 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2689 r0 *1 1823.36,1769.04
X$2689 2305 967 856 855 914 902 344 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $2695 m0 *1 1868.72,1758.96
X$2695 2305 2304 727 670 657 345 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2697 r0 *1 1877.12,1829.52
X$2697 2305 2304 345 1456 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2701 r0 *1 1876,1769.04
X$2701 2305 345 731 2304 858 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2709 r0 *1 1891.68,1738.8
X$2709 2305 2304 347 613 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2711 m0 *1 1886.64,1758.96
X$2711 2305 2304 750 690 657 347 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2713 m0 *1 1882.16,1769.04
X$2713 2305 967 917 788 859 902 347 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $2723 r0 *1 1916.32,1748.88
X$2723 2305 677 535 348 689 556 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2725 r0 *1 1920.24,1809.36
X$2725 2305 2304 1218 1219 724 348 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2727 m0 *1 1912.4,1789.2
X$2727 2305 2304 717 971 348 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2734 m0 *1 3541.44,1708.56
X$2734 2305 350 398 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2738 m0 *1 1541.68,1748.88
X$2738 2304 645 2305 580 351 581 583 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2752 r0 *1 3549.84,1698.48
X$2752 2305 393 354 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2774 r0 *1 2.24,1708.56
X$2774 2305 360 489 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2777 r0 *1 24.08,1708.56
X$2777 2305 361 447 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2781 m0 *1 1654.24,1708.56
X$2781 2305 367 424 366 362 2304 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $2792 m0 *1 1476.16,1769.04
X$2792 767 704 363 2305 2304 726 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $2794 m0 *1 1535.52,1890
X$2794 2305 2304 363 526 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $2796 r0 *1 1548.96,1920.24
X$2796 363 1919 2013 2305 2304 2036 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $2799 r0 *1 1539.44,1910.16
X$2799 1641 1289 363 2305 2304 2015 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $2803 m0 *1 18.48,1920.24
X$2803 2305 2033 363 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $2812 r0 *1 1635.2,1708.56
X$2812 2305 387 364 2304 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $2817 m0 *1 1632.96,1758.96
X$2817 364 714 652 404 2304 2305 753 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2819 r0 *1 10.64,1779.12
X$2819 364 2304 2305 886 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2821 r0 *1 1547.28,1779.12
X$2821 2305 1000 880 580 364 2304 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $2838 r0 *1 1731.52,1779.12
X$2838 2305 2304 367 915 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $2840 r0 *1 1733.76,1758.96
X$2840 367 2304 2305 733 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $2842 m0 *1 1711.92,1738.8
X$2842 2305 2304 367 602 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2846 r0 *1 1664.32,1708.56
X$2846 2305 2304 367 368 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2848 r0 *1 1739.36,1779.12
X$2848 367 2304 2305 970 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $2850 m0 *1 1741.6,1779.12
X$2850 2305 2304 367 909 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $2852 r0 *1 1746.08,1779.12
X$2852 2305 2304 367 963 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $2873 r0 *1 1995.84,1799.28
X$2873 906 368 805 1082 2305 2304 1101 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2876 r0 *1 1996.96,1789.2
X$2876 906 368 742 937 2305 2304 1034 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2878 r0 *1 1903.44,1779.12
X$2878 901 368 676 789 2305 2304 936 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2880 m0 *1 1911.84,1809.36
X$2880 1056 368 676 1082 2305 2304 1276 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2882 r0 *1 1911.84,1779.12
X$2882 901 368 551 789 2305 2304 918 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2884 m0 *1 1854.16,1789.2
X$2884 901 368 611 789 2305 2304 969 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2888 r0 *1 1881.6,1769.04
X$2888 901 368 548 789 2305 2304 859 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2890 m0 *1 1798.72,1779.12
X$2890 901 368 431 789 2305 2304 912 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2892 m0 *1 1822.8,1779.12
X$2892 901 368 913 789 2305 2304 914 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2894 r0 *1 1658.72,1708.56
X$2894 2305 368 425 2304 406 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2917 r0 *1 1790.32,1698.48
X$2917 2305 378 369 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $2923 m0 *1 1914.64,1728.72
X$2923 2305 499 369 436 426 483 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2940 r0 *1 1762.88,1738.8
X$2940 2305 481 370 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2951 r0 *1 1445.92,1758.96
X$2951 2305 706 2304 817 665 370 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2954 m0 *1 1445.36,1758.96
X$2954 2305 643 2304 748 665 370 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2975 r0 *1 1870.4,1708.56
X$2975 2305 2304 387 374 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2993 r0 *1 1748.32,1789.2
X$2993 1018 737 375 1059 2305 2304 1122 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2995 m0 *1 1737.68,1789.2
X$2995 905 915 959 375 2305 2304 1010 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2997 m0 *1 1736.56,1769.04
X$2997 775 733 375 776 2305 2304 828 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2999 m0 *1 1738.24,1738.8
X$2999 2304 542 375 2305 637 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3004 r0 *1 1732.08,1829.52
X$3004 2305 1419 1445 1360 376 550 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3009 m0 *1 1737.12,1819.44
X$3009 775 909 377 776 2305 2304 1244 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3012 m0 *1 1746.64,1819.44
X$3012 1056 963 377 1082 2305 2304 1245 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3015 r0 *1 1736,1819.44
X$3015 905 915 959 377 2305 2304 1346 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3017 m0 *1 1749.44,1748.88
X$3017 2304 591 377 2305 696 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3040 m0 *1 1610.56,1708.56
X$3040 2305 402 378 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $3042 m0 *1 1620.08,1718.64
X$3042 2305 378 535 2304 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $3045 r0 *1 1618.4,1718.64
X$3045 2305 2304 471 470 378 406 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3052 m0 *1 1764,1748.88
X$3052 2304 591 380 2305 697 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3054 m0 *1 1779.12,1799.28
X$3054 1018 737 380 1059 2305 2304 1124 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3056 m0 *1 1761.76,1789.2
X$3056 905 915 959 380 2305 2304 964 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3059 m0 *1 1766.8,1779.12
X$3059 775 909 380 776 2305 2304 940 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3069 r0 *1 1772.96,1748.88
X$3069 2305 381 665 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3072 m0 *1 1605.52,1708.56
X$3072 2304 527 381 2305 402 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3075 m0 *1 1801.52,1738.8
X$3075 2305 381 432 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3079 r0 *1 1605.52,1748.88
X$3079 2305 641 381 586 650 2304 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $3083 r0 *1 1568.56,1748.88
X$3083 2305 2304 647 646 381 649 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3087 r0 *1 1775.76,1839.6
X$3087 2305 1586 1661 1491 382 550 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3115 r0 *1 1942.64,1738.8
X$3115 2305 2304 602 384 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3117 m0 *1 2076.48,1728.72
X$3117 432 485 384 555 496 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3120 r0 *1 2077.04,1718.64
X$3120 432 485 384 497 438 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3125 m0 *1 1821.68,1748.88
X$3125 2304 542 385 2305 631 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3127 r0 *1 1820.56,1789.2
X$3127 1027 970 1024 385 2305 2304 1063 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3129 m0 *1 1827.28,1789.2
X$3129 906 602 385 937 2305 2304 1061 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3133 m0 *1 1817.76,1769.04
X$3133 775 733 385 776 2305 2304 822 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3154 r0 *1 2059.68,1738.8
X$3154 2305 2304 387 439 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3160 m0 *1 1846.32,1738.8
X$3160 2305 475 387 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3166 m0 *1 1774.08,1758.96
X$3166 724 723 387 2305 2304 700 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $3174 m0 *1 2060.24,1718.64
X$3174 2305 389 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3176 r0 *1 2126.88,1789.2
X$3176 2305 1033 389 1044 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3178 m0 *1 2106.72,1758.96
X$3178 2305 625 389 681 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3181 m0 *1 2125.76,1758.96
X$3181 2305 730 389 683 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3184 r0 *1 2102.8,1708.56
X$3184 2305 440 389 399 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3187 m0 *1 2128.56,1789.2
X$3187 2305 924 389 990 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3189 r0 *1 2144.8,1769.04
X$3189 2305 800 389 867 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3191 r0 *1 2144.8,1748.88
X$3191 2305 684 389 686 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3197 m0 *1 2125.76,1769.04
X$3197 2305 729 389 807 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3199 r0 *1 2142.56,1708.56
X$3199 2305 441 389 391 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3210 r0 *1 2074.24,1799.28
X$3210 2305 1160 535 390 556 803 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3214 r0 *1 2047.36,1779.12
X$3214 2305 2304 717 923 390 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3216 r0 *1 2097.2,1809.36
X$3216 2305 2304 1196 1202 724 390 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3221 m0 *1 3556,1708.56
X$3221 2305 392 397 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3227 r0 *1 2095.52,1728.72
X$3227 2305 566 680 394 564 486 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3229 m0 *1 3570.56,1708.56
X$3229 394 2304 2305 395 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3234 m0 *1 3570.56,1718.64
X$3234 448 2304 2305 396 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3294 m0 *1 1715.28,1819.44
X$3294 775 909 411 776 2305 2304 1296 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3298 r0 *1 1696.8,1799.28
X$3298 906 602 411 937 2305 2304 1279 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3300 m0 *1 1696.8,1748.88
X$3300 2304 591 411 2305 600 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3302 r0 *1 1711.36,1819.44
X$3302 905 915 959 411 2305 2304 1295 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3334 m0 *1 1404.48,1769.04
X$3334 2305 2304 640 875 419 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3346 m0 *1 1599.36,1829.52
X$3346 2305 1368 1333 1290 421 765 1239 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $3348 m0 *1 1546.16,1829.52
X$3348 2305 2304 421 1234 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $3350 r0 *1 1638,1779.12
X$3350 2305 967 953 1003 938 902 421 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $3355 r0 *1 1672.16,1748.88
X$3355 2305 2304 656 694 657 421 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3360 m0 *1 1640.8,1758.96
X$3360 2305 654 653 714 422 897 2304 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $3365 r0 *1 1646.96,1728.72
X$3365 2305 584 423 473 537 474 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $3405 r0 *1 1629.6,1718.64
X$3405 2305 472 426 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3418 r0 *1 1873.76,1728.72
X$3418 2305 550 427 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $3420 m0 *1 1888.88,1728.72
X$3420 2305 549 502 495 503 427 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3423 m0 *1 1830.08,1728.72
X$3423 2305 545 509 437 511 427 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3429 m0 *1 1859.76,1728.72
X$3429 2305 506 673 449 433 427 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3436 r0 *1 1843.52,1718.64
X$3436 2305 508 507 494 510 427 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3438 m0 *1 1804.88,1728.72
X$3438 2305 516 514 492 517 427 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3447 m0 *1 1629.04,1829.52
X$3447 2305 1335 1509 1262 428 550 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3479 r0 *1 1896.16,1728.72
X$3479 2305 476 429 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3481 m0 *1 1951.6,1738.8
X$3481 2304 554 429 2305 566 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3483 m0 *1 1943.2,1738.8
X$3483 2304 615 429 2305 553 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3491 r0 *1 1810.48,1748.88
X$3491 2304 542 431 2305 695 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3493 r0 *1 1799.28,1789.2
X$3493 1027 970 1024 431 2305 2304 1081 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3495 r0 *1 1803.76,1799.28
X$3495 1056 909 431 1082 2305 2304 1178 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3516 m0 *1 2079.28,1758.96
X$3516 2305 739 432 485 737 618 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3524 r0 *1 2084.88,1758.96
X$3524 432 485 737 740 741 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3539 r0 *1 1921.36,1758.96
X$3539 2305 2304 717 790 436 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3541 m0 *1 1914.08,1758.96
X$3541 2305 2304 749 675 590 436 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3547 m0 *1 3553.76,1718.64
X$3547 437 2304 2305 444 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3581 m0 *1 2069.2,1799.28
X$3581 2305 1268 535 440 556 925 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3583 r0 *1 2107.84,1819.44
X$3583 2305 2304 1316 1267 724 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3585 m0 *1 2047.36,1779.12
X$3585 2305 2304 640 979 440 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3594 m0 *1 2059.12,1779.12
X$3594 2305 929 535 441 556 870 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3596 m0 *1 1974,1779.12
X$3596 2305 2304 712 975 441 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3599 m0 *1 2106.72,1819.44
X$3599 2305 2304 1265 1266 724 441 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3603 r0 *1 3562.16,1718.64
X$3603 449 2304 2305 442 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3606 r0 *1 3545.36,1718.64
X$3606 494 2304 2305 443 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3611 r0 *1 3553.76,1718.64
X$3611 495 2304 2305 445 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3614 m0 *1 3570.56,1728.72
X$3614 493 2304 2305 446 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3624 m0 *1 1944.32,1728.72
X$3624 2305 553 498 448 499 486 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3646 m0 *1 1543.92,1738.8
X$3646 2305 526 475 451 525 2304 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3648 r0 *1 1510.88,1738.8
X$3648 2305 579 451 523 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3650 r0 *1 1509.76,1758.96
X$3650 2305 526 534 451 707 2304 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $3652 m0 *1 1379.84,1728.72
X$3652 2305 464 451 463 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3654 m0 *1 1367.52,1748.88
X$3654 2305 639 451 638 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3657 r0 *1 1351.84,1758.96
X$3657 2305 761 451 698 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3659 m0 *1 1350.16,1738.8
X$3659 2305 522 451 626 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $3664 r0 *1 1434.72,1708.56
X$3664 2305 451 2328 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $3666 r0 *1 1512.56,1728.72
X$3666 2305 524 451 465 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $3669 m0 *1 1351.84,1769.04
X$3669 2305 766 451 872 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3671 r0 *1 1346.8,1789.2
X$3671 2305 945 451 1046 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3673 m0 *1 1377.6,1738.8
X$3673 2305 578 451 577 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3690 r0 *1 1714.16,1779.12
X$3690 905 915 959 455 2305 2304 960 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3692 m0 *1 1715.28,1769.04
X$3692 775 733 455 776 2305 2304 851 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3694 r0 *1 1711.92,1738.8
X$3694 2304 591 455 2305 636 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3696 r0 *1 1713.04,1799.28
X$3696 906 602 455 937 2305 2304 1118 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3721 m0 *1 25.2,1728.72
X$3721 2305 461 491 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3724 m0 *1 16.8,1728.72
X$3724 490 2304 2305 462 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3741 r0 *1 1406.72,1758.96
X$3741 2305 2304 640 763 464 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3747 m0 *1 1562.96,1738.8
X$3747 2305 2304 647 466 568 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3760 r0 *1 1587.6,1728.72
X$3760 2305 2304 469 470 531 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3762 r0 *1 1584.8,1738.8
X$3762 2305 2304 630 586 469 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3771 r0 *1 1577.52,1728.72
X$3771 2304 570 2305 569 470 629 531 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $3780 r0 *1 1608.88,1839.6
X$3780 2305 1681 1358 1437 1487 471 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $3784 m0 *1 1627.92,1728.72
X$3784 2305 472 476 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3786 m0 *1 1627.92,1738.8
X$3786 2305 472 556 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $3789 m0 *1 1613.36,1738.8
X$3789 2304 534 533 2305 472 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3799 r0 *1 1652.56,1738.8
X$3799 2305 2304 474 587 473 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3812 r0 *1 1658.72,1738.8
X$3812 537 2304 474 588 2305 654 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3826 r0 *1 1850.8,1738.8
X$3826 2305 2304 475 547 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3848 m0 *1 1616.16,1839.6
X$3848 2305 1437 1238 1369 1287 476 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3851 m0 *1 1826.72,1738.8
X$3851 2304 546 476 2305 545 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3853 m0 *1 1743.28,1728.72
X$3853 2304 571 476 2305 518 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3857 m0 *1 1878.8,1849.68
X$3857 2304 1456 476 2305 1547 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3860 m0 *1 1815.52,1849.68
X$3860 2304 1450 476 2305 1549 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3862 r0 *1 1767.36,1728.72
X$3862 2304 543 476 2305 479 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3865 m0 *1 1669.92,1728.72
X$3865 2304 501 476 2305 477 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3867 r0 *1 1777.44,1849.68
X$3867 2304 1515 476 2305 1586 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3871 m0 *1 1887.76,1738.8
X$3871 2304 613 476 2305 549 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3876 r0 *1 1719.76,1728.72
X$3876 2305 2304 478 522 539 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3888 r0 *1 1811.04,1809.36
X$3888 1018 737 480 1059 2305 2304 1251 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3890 m0 *1 1809.36,1819.44
X$3890 775 909 480 776 2305 2304 1250 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3892 m0 *1 1786.96,1748.88
X$3892 2304 591 480 2305 633 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3894 m0 *1 1816.64,1819.44
X$3894 905 915 959 480 2305 2304 1417 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3915 r0 *1 1681.12,1728.72
X$3915 2305 527 481 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3917 r0 *1 1808.8,1728.72
X$3917 2305 481 485 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3920 m0 *1 1806,1748.88
X$3920 2305 481 640 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3931 r0 *1 2085.44,1819.44
X$3931 2305 2304 1315 1036 482 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3933 r0 *1 2083.2,1789.2
X$3933 2305 2304 926 1033 482 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3936 r0 *1 2088.8,1789.2
X$3936 2305 2304 1096 924 482 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3939 r0 *1 2082.64,1809.36
X$3939 2305 2304 1194 1038 482 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3942 r0 *1 1928.64,1809.36
X$3942 2305 2304 1256 1086 482 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3946 m0 *1 2098.88,1748.88
X$3946 2305 2304 679 625 482 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3948 m0 *1 1968.4,1758.96
X$3948 2305 2304 746 729 482 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3950 r0 *1 2098.32,1779.12
X$3950 2305 2304 928 800 482 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3952 r0 *1 1841.28,1728.72
X$3952 2305 544 482 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3971 r0 *1 2059.68,1758.96
X$3971 2305 870 665 485 737 617 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3973 m0 *1 2059.12,1758.96
X$3973 2305 925 665 485 737 738 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3975 m0 *1 2060.8,1769.04
X$3975 2305 803 665 485 737 804 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3977 m0 *1 1925.28,1748.88
X$3977 665 485 580 689 627 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3980 m0 *1 1622.32,1758.96
X$3980 665 485 580 1214 692 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3993 m0 *1 2084.88,1829.52
X$3993 2305 1315 1405 1320 1268 486 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3995 m0 *1 2089.36,1799.28
X$3995 2305 1096 1468 1094 992 486 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3997 r0 *1 1875.44,1849.68
X$3997 2305 1547 1691 1938 672 486 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $3999 m0 *1 2085.44,1819.44
X$3999 2305 1194 1466 1154 1160 486 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $4001 r0 *1 2095.52,1738.8
X$4001 2305 679 687 624 565 486 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $4003 r0 *1 1968.96,1738.8
X$4003 2305 746 688 563 567 486 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $4005 m0 *1 1900.64,1738.8
X$4005 2305 550 486 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $4012 m0 *1 2081.52,1779.12
X$4012 2305 926 927 493 929 486 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $4015 r0 *1 2097.2,1769.04
X$4015 2305 928 1158 812 869 486 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $4018 r0 *1 3570.56,1718.64
X$4018 492 2304 2305 487 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4021 m0 *1 3556,1738.8
X$4021 563 2304 2305 488 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4029 m0 *1 1581.44,1758.96
X$4029 2305 752 711 490 753 2304 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $4066 r0 *1 1944.88,1869.84
X$4066 2305 1664 498 1532 1458 1665 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $4086 m0 *1 1651.44,1839.6
X$4086 2305 1370 2304 1120 1438 1184 501 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4088 r0 *1 1650.32,1839.6
X$4088 2305 501 2304 1073 1413 1120 1079 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4091 r0 *1 1522.64,1748.88
X$4091 579 2304 501 644 2305 524 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $4093 m0 *1 1526.56,1829.52
X$4093 501 1234 524 2305 2304 1182 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $4096 r0 *1 1557.36,1819.44
X$4096 524 2305 538 501 2304 1185 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $4098 r0 *1 1522.64,1819.44
X$4098 524 2304 538 501 2305 1233 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4105 m0 *1 1883.84,1900.08
X$4105 2305 1936 502 1532 1692 1940 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $4124 r0 *1 1842.4,1869.84
X$4124 2305 1780 507 1652 1692 1782 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $4132 m0 *1 1821.68,1900.08
X$4132 2305 1985 509 1652 1692 1931 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $4148 r0 *1 1675.52,1728.72
X$4148 2305 2304 513 538 539 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4153 m0 *1 1804.32,1900.08
X$4153 2305 1928 514 1652 1692 1929 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $4158 r0 *1 1676.08,1829.52
X$4158 2305 1371 1653 1359 515 550 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $4175 m0 *1 2.24,1738.8
X$4175 2305 520 562 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4178 r0 *1 16.8,1738.8
X$4178 2305 621 521 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $4185 r0 *1 1722.56,1748.88
X$4185 2305 2304 660 603 664 522 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4188 r0 *1 1353.52,1738.8
X$4188 2305 2304 626 622 576 522 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4190 m0 *1 1702.4,1799.28
X$4190 2305 1019 1022 1074 1118 1021 522 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $4193 r0 *1 1723.68,1789.2
X$4193 2305 522 1020 2304 962 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4196 m0 *1 1729.84,1769.04
X$4196 2305 522 731 2304 853 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4208 m0 *1 1684.48,1789.2
X$4208 2305 1019 1172 1057 1007 1021 524 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $4211 r0 *1 1601.04,1829.52
X$4211 2305 1368 1487 1290 524 765 1369 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $4213 r0 *1 1696.8,1748.88
X$4213 2305 2304 658 659 657 524 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4220 m0 *1 1569.68,1789.2
X$4220 2305 2304 524 950 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4222 r0 *1 1701.84,1758.96
X$4222 2305 524 731 2304 774 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4226 r0 *1 1545.04,1738.8
X$4226 2305 2304 525 582 581 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4238 r0 *1 1520.4,1869.84
X$4238 2305 526 1363 1617 1678 2304 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $4245 r0 *1 1546.72,1890
X$4245 2305 526 1869 1918 1868 2304 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $4265 m0 *1 1679.44,1779.12
X$4265 2305 527 717 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4269 r0 *1 1611.68,1769.04
X$4269 527 2304 710 641 2305 841 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4271 r0 *1 1621.2,1758.96
X$4271 527 2304 840 641 2305 821 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4274 m0 *1 1568,1758.96
X$4274 2304 648 527 701 2305 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $4276 r0 *1 1578.08,1748.88
X$4276 2305 527 712 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4278 r0 *1 1563.52,1738.8
X$4278 2305 528 527 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4281 m0 *1 1622.32,1779.12
X$4281 527 2304 771 641 2305 1002 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4286 m0 *1 1569.12,1748.88
X$4286 2304 2305 648 594 528 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $4291 r0 *1 1599.36,1789.2
X$4291 2305 2304 529 1017 1016 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4294 m0 *1 1568,1738.8
X$4294 2305 691 2304 530 568 569 529 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4297 m0 *1 1598.24,1799.28
X$4297 710 2304 529 1016 2305 1107 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4303 r0 *1 1566.32,1819.44
X$4303 2305 1622 2304 1435 1329 898 530 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4306 m0 *1 1578.64,1779.12
X$4306 899 839 530 900 2304 2305 752 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $4329 m0 *1 1521.52,1769.04
X$4329 2305 2304 533 703 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $4331 r0 *1 1513.68,1769.04
X$4331 2305 893 2304 835 836 533 646 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4333 r0 *1 1528.8,1819.44
X$4333 2305 1127 533 644 1182 2304 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $4335 m0 *1 1604.4,1738.8
X$4335 2304 2305 533 544 534 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $4340 r0 *1 1595.44,1819.44
X$4340 2305 1290 1291 1289 533 534 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $4347 m0 *1 1524.88,1799.28
X$4347 2304 2305 1014 664 534 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $4349 m0 *1 1552.88,1809.36
X$4349 2305 2304 534 1134 1127 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4352 r0 *1 1541.12,1799.28
X$4352 2305 2304 534 1131 1015 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4355 m0 *1 1498.56,1769.04
X$4355 2305 534 704 2304 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $4359 r0 *1 1543.36,1819.44
X$4359 2304 534 1127 2305 1183 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4365 m0 *1 1513.12,1769.04
X$4365 2305 2304 707 836 534 767 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4391 r0 *1 1616.72,1809.36
X$4391 2305 1000 556 1238 1287 535 2304 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $4401 r0 *1 1668.8,1819.44
X$4401 955 2304 1139 536 2305 1440 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4403 m0 *1 1694,1779.12
X$4403 732 2304 536 734 2305 850 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4406 m0 *1 1662.08,1819.44
X$4406 1018 2304 536 1059 2305 1241 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4431 r0 *1 1547.28,1789.2
X$4431 1048 951 538 1068 949 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $4433 m0 *1 1526,1748.88
X$4433 2305 579 538 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4438 r0 *1 1634.08,1789.2
X$4438 2305 967 1071 1050 1051 902 538 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $4440 r0 *1 1530.48,1799.28
X$4440 2305 2304 1163 538 1015 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4442 r0 *1 1631.28,1769.04
X$4442 2305 2304 843 538 842 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4445 r0 *1 1660.96,1799.28
X$4445 2305 1019 1140 1170 1108 1021 538 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $4447 m0 *1 1667.12,1809.36
X$4447 2305 538 1020 2304 1169 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4461 r0 *1 1670.48,1829.52
X$4461 2305 2304 1371 1288 539 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4464 r0 *1 1783.04,1728.72
X$4464 2305 544 539 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $4469 r0 *1 1726.48,1829.52
X$4469 2305 2304 1419 1231 539 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4472 r0 *1 1413.44,1779.12
X$4472 2305 765 934 935 764 539 945 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $4474 m0 *1 1411.76,1779.12
X$4474 2305 765 933 877 833 539 946 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $4476 m0 *1 1421.28,1769.04
X$4476 2305 765 818 748 819 539 766 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $4478 m0 *1 1623.44,1829.52
X$4478 2305 2304 1335 1208 539 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4480 r0 *1 1421.84,1758.96
X$4480 2305 765 1205 817 705 539 761 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $4487 r0 *1 1678.32,1879.92
X$4487 2305 1504 541 1652 1692 1828 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $4500 m0 *1 1827.84,1748.88
X$4500 2304 542 913 2305 667 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4503 m0 *1 1727.6,1748.88
X$4503 2304 542 588 2305 635 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4505 r0 *1 1854.16,1748.88
X$4505 2304 542 611 2305 669 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4509 r0 *1 1911.28,1748.88
X$4509 2304 542 551 2305 675 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4511 m0 *1 1870.4,1748.88
X$4511 2304 542 612 2305 671 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4514 m0 *1 1880.48,1748.88
X$4514 2304 542 548 2305 674 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4517 m0 *1 1938.72,1758.96
X$4517 2304 542 614 2305 728 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4519 r0 *1 1757.28,1738.8
X$4519 591 2304 2305 542 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $4529 r0 *1 1767.92,1799.28
X$4529 2305 543 2304 1073 1077 1120 1079 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4531 m0 *1 1776.88,1789.2
X$4531 2305 2304 543 965 957 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4534 r0 *1 1761.2,1748.88
X$4534 2305 2304 639 543 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4549 m0 *1 1827.84,1829.52
X$4549 2305 546 2304 1073 1350 1120 1079 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4551 r0 *1 1830.08,1819.44
X$4551 2305 2304 546 1281 957 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4587 r0 *1 1877.68,1789.2
X$4587 1018 737 548 1059 2305 2304 1117 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4589 m0 *1 1883.28,1789.2
X$4589 1027 970 1024 548 2305 2304 1004 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4612 r0 *1 1798.16,1849.68
X$4612 2305 1549 1723 2052 1632 550 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $4616 m0 *1 1918,1819.44
X$4616 2305 550 1307 1319 1256 677 2304 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $4622 r0 *1 1599.92,1839.6
X$4622 2304 2305 1368 550 765 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $4628 m0 *1 1924.16,1799.28
X$4628 1027 970 1024 551 2305 2304 1106 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4630 r0 *1 1920.8,1789.2
X$4630 1018 580 551 1059 2305 2304 1088 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4644 m0 *1 1947.68,1819.44
X$4644 2305 2304 554 1272 957 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4646 m0 *1 1938.72,1819.44
X$4646 2305 554 2304 1073 1275 1120 1079 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4648 m0 *1 1965.04,1758.96
X$4648 2305 2304 730 554 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4679 m0 *1 1630.72,1819.44
X$4679 1336 2304 2305 1240 556 1214 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $4690 m0 *1 1996.96,1799.28
X$4690 1056 963 557 1082 2305 2304 1164 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4693 m0 *1 1968.96,1799.28
X$4693 1027 970 1024 557 2305 2304 1162 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4696 r0 *1 2002,1758.96
X$4696 732 733 557 734 2305 2304 796 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4698 m0 *1 2099.44,1789.2
X$4698 2304 723 557 2305 991 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4708 r0 *1 1948.8,1809.36
X$4708 1018 580 558 1059 2305 2304 1188 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4711 m0 *1 1964.48,1809.36
X$4711 1027 970 1024 558 2305 2304 1149 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4713 r0 *1 1977.92,1769.04
X$4713 732 733 558 734 2305 2304 862 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4715 m0 *1 2105.04,1769.04
X$4715 2304 723 558 2305 813 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4720 m0 *1 3564.4,1738.8
X$4720 2305 561 559 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4723 r0 *1 2133.04,1748.88
X$4723 2305 2304 683 559 619 730 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4726 r0 *1 3564.4,1738.8
X$4726 2305 560 623 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4776 r0 *1 1744.96,1799.28
X$4776 2305 571 2304 1073 1175 1120 1079 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4778 r0 *1 1748.32,1738.8
X$4778 2305 2304 578 571 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4780 m0 *1 1748.32,1789.2
X$4780 2305 2304 571 1121 957 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4788 r0 *1 2.24,1738.8
X$4788 2305 573 575 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4791 m0 *1 2.24,1748.88
X$4791 2305 574 685 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4795 r0 *1 1378.16,1738.8
X$4795 2305 2304 577 575 576 578 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4810 m0 *1 1462.72,1748.88
X$4810 2305 726 576 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4812 r0 *1 1370.32,1748.88
X$4812 2305 2304 638 685 576 639 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4816 r0 *1 1460.48,1809.36
X$4816 2305 2304 1181 1207 576 1208 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4818 m0 *1 1353.52,1789.2
X$4818 2305 2304 1046 988 576 945 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4821 r0 *1 1355.2,1769.04
X$4821 2305 2304 872 815 576 766 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4825 m0 *1 1355.76,1758.96
X$4825 2305 2304 698 699 576 761 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4827 r0 *1 1366.96,1789.2
X$4827 2305 2304 1013 1043 576 946 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4829 m0 *1 1422.4,1819.44
X$4829 2305 2304 1232 1204 576 1288 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4831 m0 *1 1401.68,1819.44
X$4831 2305 2304 1230 1229 576 1231 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4848 r0 *1 1740.48,1748.88
X$4848 2305 2304 661 606 657 578 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4850 r0 *1 1752.24,1758.96
X$4850 2305 578 731 2304 777 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4879 m0 *1 1546.16,1769.04
X$4879 583 768 580 769 2305 2304 582 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4881 m0 *1 1869.84,1819.44
X$4881 955 580 1139 612 2305 2304 1453 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4886 m0 *1 1938.16,1748.88
X$4886 2305 602 580 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4889 m0 *1 1626.8,1748.88
X$4889 2305 595 651 632 580 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4910 r0 *1 1542.24,1748.88
X$4910 2305 2304 583 645 646 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4915 m0 *1 1630.16,1799.28
X$4915 583 2304 651 1018 2305 1112 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4923 m0 *1 1636.88,1799.28
X$4923 583 2304 651 955 2305 1168 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4931 r0 *1 1543.92,1769.04
X$4931 2305 768 584 628 891 587 837 629 2304 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4934 r0 *1 1656.48,1769.04
X$4934 2305 2304 584 848 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4936 r0 *1 1627.92,1738.8
X$4936 632 2305 2304 587 584 2313 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $4939 m0 *1 1654.8,1769.04
X$4939 2305 846 714 773 584 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4944 m0 *1 1562.96,1769.04
X$4944 709 2305 2304 585 770 2309 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $4946 r0 *1 1580.32,1758.96
X$4946 2305 2304 585 772 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4948 r0 *1 1570.8,1769.04
X$4948 2305 771 899 585 839 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4960 r0 *1 1616.16,1779.12
X$4960 2305 1002 959 586 650 2304 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $4962 m0 *1 1621.76,1769.04
X$4962 2305 821 789 586 650 2304 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $4966 m0 *1 1607.76,1779.12
X$4966 2305 841 937 586 650 2304 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $4968 m0 *1 1603.84,1769.04
X$4968 2305 854 586 650 840 641 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $4970 m0 *1 1599.36,1789.2
X$4970 2305 974 586 650 710 641 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $4972 r0 *1 1598.24,1779.12
X$4972 2305 1001 586 650 771 641 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $4975 r0 *1 1583.12,1769.04
X$4975 2304 641 586 2305 839 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4989 m0 *1 1669.92,1769.04
X$4989 849 2305 2304 587 848 2307 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $4992 m0 *1 1666.56,1769.04
X$4992 2305 2304 587 773 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5010 r0 *1 1685.6,1779.12
X$5010 906 602 588 937 2305 2304 1007 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5012 m0 *1 1722.56,1769.04
X$5012 775 733 588 776 2305 2304 824 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5014 r0 *1 1733.2,1789.2
X$5014 905 970 1024 588 2305 2304 1115 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5033 r0 *1 1790.88,1738.8
X$5033 2305 594 590 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $5073 m0 *1 1710.8,1748.88
X$5073 2305 2304 595 591 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $5081 m0 *1 1655.92,1829.52
X$5081 2305 2304 1292 592 664 1208 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5097 r0 *1 1787.52,1748.88
X$5097 2305 594 724 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $5111 r0 *1 1711.92,1748.88
X$5111 2305 2304 595 723 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5116 m0 *1 1679.44,1890
X$5116 2305 1434 596 1652 1692 1831 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $5121 r0 *1 1686.16,1789.2
X$5121 2304 973 2305 974 1057 597 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5124 r0 *1 1687.84,1758.96
X$5124 2304 716 2305 719 756 597 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5128 m0 *1 1674.4,1789.2
X$5128 2304 956 2305 597 1055 958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5134 r0 *1 1687.84,1809.36
X$5134 2304 973 2305 974 1217 598 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5137 r0 *1 1704.64,1809.36
X$5137 2304 827 2305 719 1242 598 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5141 r0 *1 1718.64,1819.44
X$5141 2304 1011 2305 598 1345 1001 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5146 r0 *1 1687.28,1839.6
X$5146 2305 2304 1511 599 664 1288 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5152 r0 *1 1687.84,1819.44
X$5152 2304 973 2305 974 1341 601 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5155 m0 *1 1708,1839.6
X$5155 2304 1011 2305 601 1372 1001 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5157 r0 *1 1705.2,1839.6
X$5157 2304 827 2305 719 1552 601 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5176 r0 *1 1946.56,1779.12
X$5176 906 602 614 937 2305 2304 921 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5182 m0 *1 1948.8,1758.96
X$5182 2305 602 737 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $5196 r0 *1 1704.64,1789.2
X$5196 2304 973 2305 974 1074 604 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5198 r0 *1 1714.72,1789.2
X$5198 2304 1011 2305 604 1060 1001 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5200 r0 *1 1716.96,1758.96
X$5200 2304 827 2305 719 884 604 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5205 m0 *1 1710.8,1900.08
X$5205 2305 1772 605 1652 1692 1925 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $5213 r0 *1 1762.32,1879.92
X$5213 2305 1836 607 1652 1645 1837 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $5219 r0 *1 1788.08,1849.68
X$5219 2305 2304 1588 608 664 1299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5224 r0 *1 1822.8,1849.68
X$5224 2305 2304 1589 609 664 1517 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5232 r0 *1 1843.52,1758.96
X$5232 2304 716 2305 782 783 610 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5235 m0 *1 1835.12,1799.28
X$5235 2304 956 2305 610 1029 958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5237 r0 *1 1827.84,1789.2
X$5237 2304 973 2305 974 1062 610 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5242 r0 *1 1845.76,1799.28
X$5242 1027 970 1024 611 2305 2304 1145 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5246 m0 *1 1846.32,1809.36
X$5246 1056 963 611 1082 2305 2304 1282 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5253 r0 *1 1864.8,1819.44
X$5253 1056 909 612 1082 2305 2304 1351 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5258 r0 *1 1867.6,1769.04
X$5258 732 733 612 734 2305 2304 882 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5267 r0 *1 1883.28,1799.28
X$5267 2305 613 2304 1073 1116 1120 1079 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $5269 r0 *1 1896.72,1789.2
X$5269 2305 2304 613 1113 957 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5274 r0 *1 1945.44,1769.04
X$5274 732 733 614 734 2305 2304 879 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5278 r0 *1 1946,1789.2
X$5278 1027 970 1024 614 2305 2304 1053 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5285 r0 *1 1941.52,1799.28
X$5285 2305 2304 615 1091 957 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5287 r0 *1 1932.56,1799.28
X$5287 2305 615 2304 1073 1109 1120 1079 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $5289 r0 *1 1936.48,1748.88
X$5289 2305 2304 684 615 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5298 m0 *1 2078.72,1819.44
X$5298 2304 723 616 2305 1266 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5301 r0 *1 1984.64,1819.44
X$5301 955 963 1139 616 2305 2304 1310 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5303 r0 *1 1976.8,1819.44
X$5303 1056 909 616 1082 2305 2304 1340 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5305 m0 *1 1985.2,1779.12
X$5305 732 915 616 734 2305 2304 976 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5319 m0 *1 2144.24,1819.44
X$5319 2305 2304 1264 1263 619 1036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5321 r0 *1 2143.68,1789.2
X$5321 2305 2304 1044 985 619 1033 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5323 r0 *1 2111.76,1758.96
X$5323 2305 2304 726 619 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5325 r0 *1 2113.44,1748.88
X$5325 2305 2304 681 682 619 625 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5328 m0 *1 2149.84,1809.36
X$5328 2305 2304 1157 1156 619 1038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5330 r0 *1 2131.36,1809.36
X$5330 2305 2304 1197 1198 619 1086 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5332 r0 *1 2134.72,1779.12
X$5332 2305 2304 990 987 619 924 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5334 m0 *1 2151.52,1769.04
X$5334 2305 2304 867 744 619 800 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5336 m0 *1 2151.52,1748.88
X$5336 2305 2304 686 623 619 684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5338 r0 *1 2132.48,1758.96
X$5338 2305 2304 807 811 619 729 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5341 r0 *1 3556,1738.8
X$5341 624 2304 2305 620 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5345 m0 *1 16.8,1738.8
X$5345 2305 621 622 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $5373 r0 *1 2017.68,1758.96
X$5373 2305 625 731 2304 799 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $5375 m0 *1 2061.36,1799.28
X$5375 2305 625 1020 2304 1097 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $5377 r0 *1 2021.04,1799.28
X$5377 2305 625 1144 2304 1150 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $5379 m0 *1 2110.64,1799.28
X$5379 2305 2304 1095 1039 791 625 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5401 m0 *1 16.8,1789.2
X$5401 2305 941 628 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $5404 m0 *1 1568.56,1879.92
X$5404 2305 629 2304 1705 1803 1770 628 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $5406 m0 *1 1538.88,1869.84
X$5406 2305 2304 1642 629 1572 628 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5410 m0 *1 1510.88,1779.12
X$5410 2305 835 894 628 891 892 837 629 2304 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5426 r0 *1 16.8,1789.2
X$5426 2305 944 629 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $5470 m0 *1 1764,1758.96
X$5470 2305 2304 722 663 664 639 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5472 r0 *1 1775.2,1758.96
X$5472 2305 639 731 2304 779 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $5496 r0 *1 1565.76,1769.04
X$5496 2305 2304 640 900 838 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5524 m0 *1 1416.24,1758.96
X$5524 2304 642 2305 703 705 704 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5533 r0 *1 1538.32,1809.36
X$5533 2305 1144 644 1182 1183 1066 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $5535 m0 *1 1538.88,1819.44
X$5535 2305 1220 644 1182 1183 1103 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $5539 r0 *1 1523.76,1809.36
X$5539 2304 1127 644 2305 1129 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5541 m0 *1 1534.4,1809.36
X$5541 2305 1138 644 1182 1183 1067 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $5543 m0 *1 1520.4,1819.44
X$5543 2305 894 1233 644 1234 1127 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $5554 m0 *1 1562.96,1890
X$5554 2304 2305 1870 1855 1823 646 1895 1871 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $5557 m0 *1 1555.12,1859.76
X$5557 2305 2304 1679 1619 1291 646 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5560 m0 *1 2.24,1900.08
X$5560 2305 1862 646 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $5571 r0 *1 1572.48,1758.96
X$5571 648 771 710 840 2304 2305 649 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $5573 m0 *1 1556.24,1758.96
X$5573 2305 648 838 709 708 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5606 r0 *1 1635.76,1748.88
X$5606 2305 2304 651 652 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5620 m0 *1 1660.96,1799.28
X$5620 1056 655 654 1082 2305 2304 1170 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5622 m0 *1 1649.2,1789.2
X$5622 2304 655 654 2305 954 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5635 r0 *1 1667.12,1920.24
X$5635 2305 2304 2043 1239 2019 656 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5658 r0 *1 1896.16,1748.88
X$5658 2305 664 657 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $5667 m0 *1 1688.4,1920.24
X$5667 2305 2304 2020 1369 2019 658 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5676 r0 *1 1718.64,1900.08
X$5676 2305 2304 1980 1772 1568 660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5680 m0 *1 1736,1910.16
X$5680 2305 2304 1981 1877 1568 661 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5685 r0 *1 1755.6,1839.6
X$5685 2305 2304 1447 662 664 1231 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5714 m0 *1 1916.32,1829.52
X$5714 2305 664 791 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $5716 m0 *1 1546.16,1779.12
X$5716 2305 2304 664 842 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5735 r0 *1 1558.48,1758.96
X$5735 2305 2304 665 708 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5742 r0 *1 1438.64,1769.04
X$5742 2305 876 2304 935 665 712 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $5744 r0 *1 1445.92,1769.04
X$5744 2305 834 2304 877 665 712 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $5758 m0 *1 1837.92,1930.32
X$5758 2305 2304 2097 1780 2019 668 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5777 r0 *1 1855.28,1900.08
X$5777 2305 1932 673 1532 1692 1987 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $5793 m0 *1 1912.4,1819.44
X$5793 2304 723 676 2305 1219 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5795 m0 *1 1887.2,1819.44
X$5795 905 909 676 959 2305 2304 1306 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5808 m0 *1 2072,1819.44
X$5808 2304 723 678 2305 1267 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5810 r0 *1 2004.8,1819.44
X$5810 955 963 1139 678 2305 2304 1330 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5812 r0 *1 1997.52,1819.44
X$5812 1056 963 678 1059 2305 2304 1332 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5814 m0 *1 2003.68,1779.12
X$5814 732 915 678 734 2305 2304 994 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5821 m0 *1 2088.8,1869.84
X$5821 2305 1731 680 1532 1458 1734 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $5827 m0 *1 3564.4,1758.96
X$5827 2305 743 682 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $5837 m0 *1 1931.44,1769.04
X$5837 2305 2304 861 749 791 684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5839 m0 *1 1916.32,1779.12
X$5839 2305 967 920 919 918 902 684 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $5858 r0 *1 2095.52,1869.84
X$5858 2305 1843 687 1532 1458 1787 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $5864 r0 *1 1966.16,1849.68
X$5864 2305 1595 688 1532 1458 1596 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $5876 r0 *1 1561.84,1779.12
X$5876 2305 2304 691 952 770 895 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5903 r0 *1 11.76,1758.96
X$5903 2305 760 699 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $5932 r0 *1 1414,1758.96
X$5932 2304 702 2305 703 819 704 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5940 m0 *1 1515.36,1789.2
X$5940 2304 703 1102 2305 893 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5943 r0 *1 1517.6,1789.2
X$5943 2305 1014 1015 948 703 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5948 m0 *1 1410.08,1769.04
X$5948 2304 763 2305 703 764 704 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5950 r0 *1 1411.2,1769.04
X$5950 2304 875 2305 703 833 704 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5961 r0 *1 26.32,1758.96
X$5961 704 2304 2305 757 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5984 m0 *1 1581.44,1799.28
X$5984 2305 2304 710 1069 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5988 r0 *1 1574.72,1779.12
X$5988 2305 710 2319 772 839 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5995 r0 *1 1576.96,1819.44
X$5995 1331 2304 1644 1166 2305 711 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6015 m0 *1 1567.44,1779.12
X$6015 712 896 899 770 2305 2304 898 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6024 m0 *1 1616.16,1819.44
X$6024 2305 713 2304 1334 1238 1239 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6035 r0 *1 1679.44,1920.24
X$6035 2305 2304 2044 1504 2019 715 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6047 m0 *1 1948.8,1769.04
X$6047 2304 716 2305 782 878 792 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6049 r0 *1 2019.36,1769.04
X$6049 2304 716 2305 782 864 863 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6051 r0 *1 2024.4,1758.96
X$6051 2304 716 2305 782 814 802 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6053 r0 *1 1687.84,1769.04
X$6053 2304 716 2305 719 883 718 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6057 m0 *1 1963.92,1769.04
X$6057 2304 716 2305 782 820 794 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6059 r0 *1 1744.4,1758.96
X$6059 2304 716 2305 719 721 720 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6062 r0 *1 2009.84,1758.96
X$6062 2304 716 2305 782 735 797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6064 r0 *1 1901.76,1769.04
X$6064 2305 860 716 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $6066 m0 *1 1867.6,1769.04
X$6066 2304 716 2305 782 787 786 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6100 m0 *1 1769.04,1839.6
X$6100 2304 1151 2305 718 1441 1152 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6103 r0 *1 1751.68,1829.52
X$6103 2304 1025 2305 1026 1414 718 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6117 r0 *1 1793.12,1769.04
X$6117 2305 854 719 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $6119 m0 *1 1787.52,1829.52
X$6119 2304 827 2305 719 1420 911 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6121 r0 *1 1746.64,1839.6
X$6121 2304 827 2305 719 1514 829 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6129 m0 *1 1767.92,1769.04
X$6129 2304 827 2305 719 885 778 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6133 m0 *1 1803.76,1839.6
X$6133 2304 827 2305 719 1490 1301 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6142 r0 *1 1740.48,1789.2
X$6142 2304 1011 2305 720 1023 958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6145 r0 *1 1755.6,1789.2
X$6145 2304 1025 2305 1026 1075 720 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6149 m0 *1 1743.84,1769.04
X$6149 2305 907 828 721 777 826 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6152 r0 *1 1760.08,1900.08
X$6152 2305 2304 1982 1836 1568 722 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6177 r0 *1 2101.12,1789.2
X$6177 2304 723 742 2305 1047 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6179 r0 *1 2089.36,1809.36
X$6179 2304 723 805 2305 1202 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6183 m0 *1 1710.8,1779.12
X$6183 905 906 901 723 2304 2305 769 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $6188 m0 *1 2104.48,1809.36
X$6188 2304 723 806 2305 1159 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6220 m0 *1 1825.04,1930.32
X$6220 2305 2304 2096 1985 2019 725 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6238 m0 *1 1844.08,1849.68
X$6238 2305 2304 1548 1452 726 1517 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6244 m0 *1 1786.96,1859.76
X$6244 2305 2304 1688 1587 726 1299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6249 r0 *1 1863.12,1920.24
X$6249 2305 2304 2055 1633 2019 727 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6258 m0 *1 1968.4,1779.12
X$6258 2305 729 731 2304 922 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6260 m0 *1 1956.08,1789.2
X$6260 2305 1019 1342 996 921 1021 729 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $6264 r0 *1 1964.48,1758.96
X$6264 2305 2304 793 747 791 729 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6266 r0 *1 1977.36,1789.2
X$6266 2305 729 1020 2304 1052 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6277 r0 *1 2116.8,1769.04
X$6277 2305 2304 866 868 791 730 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6279 r0 *1 1984.64,1758.96
X$6279 2305 730 731 2304 795 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6302 m0 *1 1915.2,1769.04
X$6302 2305 2304 860 731 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $6332 m0 *1 1996.4,1779.12
X$6332 732 915 805 734 2305 2304 932 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6335 m0 *1 2002.56,1769.04
X$6335 732 733 806 734 2305 2304 816 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6337 r0 *1 2003.68,1769.04
X$6337 732 733 742 734 2305 2304 871 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6339 m0 *1 1679.44,1769.04
X$6339 2305 2304 849 732 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $6385 m0 *1 1907.36,1769.04
X$6385 2305 2304 789 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $6390 m0 *1 2009.84,1769.04
X$6390 2305 798 796 735 799 784 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6411 m0 *1 1622.32,1799.28
X$6411 2305 2304 1138 736 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6413 r0 *1 2038.96,1758.96
X$6413 2305 800 736 2304 801 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6415 r0 *1 1663.2,1779.12
X$6415 2304 736 2305 854 1003 823 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6417 m0 *1 2001.44,1789.2
X$6417 2305 1033 736 2304 977 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6420 r0 *1 1788.64,1779.12
X$6420 2304 736 2305 854 1009 780 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6422 r0 *1 2034.48,1789.2
X$6422 2305 1036 736 2304 982 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6424 r0 *1 1625.68,1789.2
X$6424 2304 736 2305 1017 1050 1049 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6426 m0 *1 1825.04,1769.04
X$6426 2304 736 2305 854 855 781 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6428 m0 *1 2042.32,1789.2
X$6428 2305 1038 736 2304 984 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6430 m0 *1 1854.72,1779.12
X$6430 2304 736 2305 854 1006 751 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6432 m0 *1 2041.76,1779.12
X$6432 2305 924 736 2304 930 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6465 r0 *1 1834.56,1809.36
X$6465 1018 737 913 1059 2305 2304 1302 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6482 m0 *1 2005.36,1799.28
X$6482 955 963 1139 742 2305 2304 1092 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6490 r0 *1 3549.84,1758.96
X$6490 2305 810 744 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $6495 m0 *1 1380.4,1779.12
X$6495 2305 890 2304 931 745 842 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6516 m0 *1 1884.96,1930.32
X$6516 2305 2304 2092 1936 2019 750 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6523 r0 *1 1855.28,1799.28
X$6523 2304 956 2305 751 1146 958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6525 m0 *1 1853.6,1809.36
X$6525 2304 1141 2305 1035 1147 751 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6547 m0 *1 1690.64,1769.04
X$6547 2305 904 824 756 774 826 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6552 m0 *1 26.32,1769.04
X$6552 2305 758 767 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $6555 m0 *1 2.24,1769.04
X$6555 2305 759 815 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $6566 r0 *1 1418.48,1789.2
X$6566 2305 1127 761 946 945 766 2304 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $6570 m0 *1 1374.8,1779.12
X$6570 2305 2304 890 761 842 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6572 m0 *1 1431.36,1789.2
X$6572 766 761 946 945 2304 2305 949 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $6576 r0 *1 1379.84,1769.04
X$6576 2305 873 2304 874 762 842 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6600 m0 *1 1585.92,1829.52
X$6600 2305 1291 1289 2304 765 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $6614 r0 *1 1374.24,1769.04
X$6614 2305 2304 873 766 842 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6636 m0 *1 1572.48,1769.04
X$6636 2305 2304 839 770 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6638 m0 *1 1578.64,1769.04
X$6638 2305 840 2315 772 770 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $6645 r0 *1 1609.44,1789.2
X$6645 2305 2304 771 1070 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6656 r0 *1 1661.52,1769.04
X$6656 2305 847 2317 773 848 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $6690 r0 *1 1810.48,1769.04
X$6690 901 2304 2305 775 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $6722 r0 *1 1816.64,1769.04
X$6722 789 2304 2305 776 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $6729 m0 *1 1769.04,1789.2
X$6729 2304 1011 2305 778 1064 1001 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6733 m0 *1 1763.44,1799.28
X$6733 2304 1025 2305 1026 1123 778 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6735 r0 *1 1765.68,1769.04
X$6735 2305 910 940 885 779 826 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6742 r0 *1 1795.92,1799.28
X$6742 2304 1141 2305 1035 1080 780 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6744 m0 *1 1802.64,1789.2
X$6744 2304 956 2305 780 966 958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6759 r0 *1 1826.72,1809.36
X$6759 2304 956 2305 781 1253 958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6763 r0 *1 1835.12,1819.44
X$6763 2304 1025 2305 1026 1303 781 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6773 m0 *1 1923.04,1769.04
X$6773 2305 2304 854 782 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6777 m0 *1 2024.4,1779.12
X$6777 2304 902 2305 782 993 923 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6781 r0 *1 2020.48,1779.12
X$6781 2304 902 2305 782 980 979 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6787 r0 *1 1981.28,1779.12
X$6787 2304 902 2305 782 995 975 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6793 m0 *1 1841.84,1769.04
X$6793 2305 1005 822 783 857 784 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6808 r0 *1 1924.72,1779.12
X$6808 2305 967 784 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $6810 m0 *1 2024.4,1789.2
X$6810 2305 981 994 980 982 784 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6813 r0 *1 2027.2,1769.04
X$6813 2305 865 871 864 930 784 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6815 m0 *1 2030,1769.04
X$6815 2305 1037 816 814 801 784 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6818 r0 *1 2029.44,1779.12
X$6818 2305 983 932 993 984 784 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6820 r0 *1 1954.96,1769.04
X$6820 2305 1343 879 878 922 784 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6822 r0 *1 1989.12,1779.12
X$6822 2305 1312 976 995 977 784 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6824 m0 *1 1976.8,1769.04
X$6824 2305 978 862 820 795 784 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6826 m0 *1 1867.04,1779.12
X$6826 2305 1305 882 787 858 784 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $6830 m0 *1 1855.84,1930.32
X$6830 2305 2304 2099 1932 2019 785 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6837 r0 *1 1868.72,1839.6
X$6837 2304 1151 2305 786 1454 1152 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6840 r0 *1 1869.28,1829.52
X$6840 2304 1141 2305 1026 1378 786 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6845 m0 *1 1884.96,1779.12
X$6845 2304 827 2305 854 788 916 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6871 m0 *1 1641.92,1789.2
X$6871 901 2304 954 789 2305 1051 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6874 m0 *1 1646.4,1779.12
X$6874 901 2304 845 789 2305 938 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6880 m0 *1 1925.84,1789.2
X$6880 2304 956 2305 790 1058 958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6882 r0 *1 1928.08,1789.2
X$6882 2304 1025 2305 1026 1110 790 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6885 r0 *1 1919.12,1769.04
X$6885 2304 827 2305 854 919 790 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6902 m0 *1 1932.56,1829.52
X$6902 2305 2304 1308 1218 791 1086 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6908 m0 *1 2107.28,1829.52
X$6908 2305 2304 1321 1316 791 1036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6910 r0 *1 2116.24,1819.44
X$6910 2305 2304 1317 1265 791 1033 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6913 r0 *1 2114.56,1789.2
X$6913 2305 2304 1040 1045 791 924 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6915 m0 *1 2115.12,1819.44
X$6915 2305 2304 1258 1196 791 1038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6917 r0 *1 2111.2,1809.36
X$6917 2305 2304 1195 1153 791 800 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6919 m0 *1 1939.28,1789.2
X$6919 2304 956 2305 792 999 958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6923 m0 *1 1947.12,1789.2
X$6923 2304 973 2305 974 996 792 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6928 r0 *1 1965.04,1869.84
X$6928 2305 2304 1802 1595 1392 793 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6936 r0 *1 1957.76,1819.44
X$6936 2304 1025 2305 1026 1274 794 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6938 r0 *1 1965.6,1809.36
X$6938 2304 1151 2305 794 1273 1152 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6947 r0 *1 2009.28,1799.28
X$6947 2304 1141 2305 1035 1165 797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6950 r0 *1 2048.48,1799.28
X$6950 2304 1151 2305 797 1098 1152 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6955 r0 *1 2055.76,1879.92
X$6955 2305 1854 1785 1382 798 1844 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $6976 m0 *1 2043.44,1819.44
X$6976 2305 800 1144 2304 1270 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6978 r0 *1 2063.04,1809.36
X$6978 2305 800 1020 2304 1192 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6994 r0 *1 2049.6,1809.36
X$6994 2304 1151 2305 802 1191 1152 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6996 r0 *1 2023.28,1819.44
X$6996 2304 1141 2305 1035 1271 802 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7013 r0 *1 2005.36,1809.36
X$7013 955 963 1139 805 2305 2304 1206 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7024 r0 *1 1998.08,1809.36
X$7024 1056 963 806 1082 2305 2304 1211 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7026 m0 *1 1995.84,1809.36
X$7026 1027 963 1139 806 2305 2304 1269 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7034 m0 *1 3556.56,1769.04
X$7034 812 2304 2305 808 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7037 r0 *1 3564.4,1758.96
X$7037 2305 809 811 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $7074 r0 *1 1366.4,1829.52
X$7074 2305 1365 1402 1240 818 1366 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7103 r0 *1 1661.52,1809.36
X$7103 2304 956 2305 823 1215 958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7106 r0 *1 1680,1819.44
X$7106 2304 1141 2305 1035 1278 823 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7113 m0 *1 1797.04,1930.32
X$7113 2305 2304 2049 1928 2019 825 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7131 r0 *1 1795.36,1839.6
X$7131 2305 967 826 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $7134 m0 *1 1705.76,1819.44
X$7134 2304 1187 1243 1242 1280 826 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $7141 r0 *1 1718.64,1769.04
X$7141 2305 852 851 884 853 826 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $7143 r0 *1 1696.8,1769.04
X$7143 2305 903 850 883 939 826 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $7145 m0 *1 1741.04,1849.68
X$7145 2304 1244 1629 1514 1556 826 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $7147 r0 *1 1812.16,1839.6
X$7147 2304 1250 1750 1490 1489 826 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $7150 r0 *1 1785.28,1829.52
X$7150 2305 1722 1222 1420 1300 826 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $7152 m0 *1 1715.28,1849.68
X$7152 2304 1296 1553 1552 1554 826 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $7183 r0 *1 1899.52,1839.6
X$7183 2305 860 827 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $7191 m0 *1 1904,1789.2
X$7191 2304 827 2305 854 972 971 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7208 m0 *1 1735.44,1839.6
X$7208 2304 1011 2305 829 1444 1001 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7212 m0 *1 1747.76,1829.52
X$7212 2304 1141 2305 1035 1297 829 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7214 r0 *1 2.24,1769.04
X$7214 2305 830 891 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $7217 m0 *1 1377.04,1789.2
X$7217 2305 997 2304 1126 831 842 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7220 m0 *1 1384.32,1789.2
X$7220 2305 947 2304 998 832 842 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7235 r0 *1 1554,1829.52
X$7235 2305 2304 837 952 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7238 m0 *1 12.32,1839.6
X$7238 2305 1357 837 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $7241 r0 *1 1533.84,1839.6
X$7241 2304 1482 2305 1431 1433 1432 837 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $7246 m0 *1 1564.08,1779.12
X$7246 2305 2304 838 896 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7262 m0 *1 1625.12,1789.2
X$7262 2305 2304 840 1049 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7280 r0 *1 1636.88,1769.04
X$7280 2305 843 2304 881 844 842 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7284 r0 *1 1380.96,1779.12
X$7284 2305 2304 947 945 842 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $7289 r0 *1 1374.24,1779.12
X$7289 2305 2304 997 946 842 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $7303 r0 *1 1662.64,1819.44
X$7303 1018 2304 845 1059 2305 1293 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7305 m0 *1 1644.72,1819.44
X$7305 955 2304 1139 845 2305 1337 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7313 m0 *1 1774.08,1779.12
X$7313 846 2304 2305 905 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $7315 m0 *1 1658.72,1789.2
X$7315 2305 2304 846 955 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7317 r0 *1 1779.68,1779.12
X$7317 846 2304 2305 1027 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $7321 r0 *1 1677.76,1779.12
X$7321 2305 2304 847 906 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $7323 r0 *1 1667.12,1789.2
X$7323 2305 2304 847 1018 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $7326 r0 *1 1674.96,1789.2
X$7326 2305 2304 847 1056 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7339 r0 *1 1673.28,1769.04
X$7339 2305 2304 849 901 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $7350 m0 *1 1711.36,1879.92
X$7350 2305 1834 1765 1583 852 1773 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7383 r0 *1 1828.96,1900.08
X$7383 2305 1967 2283 1713 856 1986 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7408 m0 *1 1901.76,1779.12
X$7408 2305 860 902 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $7411 m0 *1 1628.48,1809.36
X$7411 2305 1138 860 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $7415 r0 *1 1913.52,1799.28
X$7415 2305 1086 860 2304 1087 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7418 m0 *1 1734.88,1849.68
X$7418 2305 1231 860 2304 1556 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7420 m0 *1 1796.48,1829.52
X$7420 2305 1299 860 2304 1300 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7422 m0 *1 1724.8,1849.68
X$7422 2305 1288 860 2304 1554 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7424 r0 *1 1703.52,1819.44
X$7424 2305 1208 860 2304 1280 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7426 m0 *1 1820.56,1849.68
X$7426 2305 1517 860 2304 1489 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7429 r0 *1 1930.88,1869.84
X$7429 2305 2304 1804 1664 1392 861 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7439 r0 *1 2028.32,1799.28
X$7439 2304 1151 2305 863 1093 1152 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7441 r0 *1 2021.04,1789.2
X$7441 2304 973 2305 1035 1100 863 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7449 r0 *1 2034.48,1859.76
X$7449 2305 1746 1673 1382 865 1666 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7454 m0 *1 2115.68,1879.92
X$7454 2305 2304 1799 1731 1392 866 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7486 r0 *1 1370.32,1839.6
X$7486 2305 2304 1480 1429 1568 874 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7511 r0 *1 2.24,1779.12
X$7511 880 2304 2305 888 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7518 m0 *1 1674.4,1920.24
X$7518 2305 2304 2018 1434 2019 881 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7537 m0 *1 2.24,1779.12
X$7537 889 2304 2305 887 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7542 m0 *1 1580.32,1809.36
X$7542 2305 889 1186 1112 1167 1136 2304 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $7552 m0 *1 1541.12,1779.12
X$7552 2305 2304 891 895 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7557 r0 *1 1515.36,1779.12
X$7557 948 2305 2304 894 892 2312 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $7560 m0 *1 1517.04,1809.36
X$7560 2305 2304 1129 892 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7562 r0 *1 1512,1799.28
X$7562 2305 1067 2318 1128 892 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $7573 m0 *1 1513.68,1809.36
X$7573 2305 2304 894 1128 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7575 m0 *1 1522.08,1809.36
X$7575 2305 1103 1130 894 1129 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $7582 m0 *1 1538.32,1839.6
X$7582 2305 2304 895 1482 1239 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7587 r0 *1 1562.4,1869.84
X$7587 2305 2304 1769 952 1705 895 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7595 m0 *1 1551.76,1829.52
X$7595 2305 1210 897 1328 1329 1327 2304 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $7612 r0 *1 1579.76,1809.36
X$7612 2304 1069 2305 900 1236 1186 1213 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $7614 m0 *1 1577.52,1819.44
X$7614 2304 1070 2305 900 1236 1212 1235 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $7681 m0 *1 1676.64,1869.84
X$7681 2305 1752 1646 1713 903 1708 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7687 m0 *1 1636.32,1879.92
X$7687 2305 1807 1808 1713 904 1714 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7752 m0 *1 1733.2,1890
X$7752 2305 1901 1848 1583 907 1835 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7756 r0 *1 1737.12,1900.08
X$7756 2305 1877 908 1652 1692 1926 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7787 m0 *1 1762.32,1879.92
X$7787 2305 1904 1796 1583 910 1775 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7796 m0 *1 1781.36,1839.6
X$7796 2304 1151 2305 911 1516 1152 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7798 m0 *1 1784.72,1819.44
X$7798 2304 973 2305 974 1249 911 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7805 m0 *1 1823.36,1809.36
X$7805 1027 970 1024 913 2305 2304 1252 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7849 m0 *1 1876,1799.28
X$7849 2304 1025 2305 1026 1083 916 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7851 r0 *1 1884.96,1789.2
X$7851 2304 956 2305 916 1084 958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7853 r0 *1 1896.16,1900.08
X$7853 2305 1939 1963 1713 917 1937 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7861 m0 *1 1942.64,1869.84
X$7861 2305 1748 1797 1382 920 1594 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7876 m0 *1 2017.68,1819.44
X$7876 2304 1141 2305 1035 1189 923 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7878 r0 *1 2041.76,1809.36
X$7878 2304 1151 2305 923 1190 1152 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7886 m0 *1 2021.04,1799.28
X$7886 2305 1019 1527 1100 1034 1021 924 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $7892 m0 *1 2048.48,1799.28
X$7892 2305 924 1020 2304 1099 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7904 m0 *1 2092.16,1849.68
X$7904 2305 1530 2304 1458 927 1240 1531 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $7919 r0 *1 1370.32,1859.76
X$7919 2305 2304 1640 1639 1568 931 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7928 m0 *1 1368.64,1829.52
X$7928 2305 1362 1285 1240 933 1286 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7934 m0 *1 1370.88,1869.84
X$7934 2305 1745 1699 1240 934 1704 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $7942 m0 *1 1903.44,1799.28
X$7942 2305 1085 936 972 967 1087 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $7974 r0 *1 1964.48,1799.28
X$7974 2305 2304 937 1059 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7976 m0 *1 1980.16,1799.28
X$7976 2305 937 1082 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $7998 m0 *1 2.24,1789.2
X$7998 2305 942 988 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8001 r0 *1 25.2,1779.12
X$8001 989 2304 2305 943 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8023 m0 *1 1363.04,1799.28
X$8023 2305 946 1228 1013 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $8044 r0 *1 1662.08,1789.2
X$8044 2305 2304 950 1054 957 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8050 r0 *1 1559.6,1809.36
X$8050 2305 1184 1185 951 1134 1133 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $8052 m0 *1 1559.6,1809.36
X$8052 2305 1137 1185 951 1134 1132 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $8064 m0 *1 1635.76,1900.08
X$8064 2305 1962 1923 1713 953 1922 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $8069 r0 *1 1643.6,1799.28
X$8069 955 2304 1139 954 2305 1072 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8112 r0 *1 1900.08,1809.36
X$8112 2305 1220 956 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8121 r0 *1 1627.92,1799.28
X$8121 2304 956 2305 1017 1111 1070 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8154 r0 *1 1830.64,1839.6
X$8154 2305 2304 1450 1451 957 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8158 m0 *1 1653.12,1819.44
X$8158 2305 2304 1234 1338 957 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8163 m0 *1 1862,1849.68
X$8163 2305 1370 2304 1120 1518 957 1456 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $8165 m0 *1 1678.88,1839.6
X$8165 2305 1184 957 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8185 m0 *1 1861.44,1799.28
X$8185 2305 1001 958 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8219 r0 *1 1868.72,1789.2
X$8219 959 2304 2305 1024 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $8228 r0 *1 1879.92,1819.44
X$8228 2305 2304 959 1139 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $8233 m0 *1 1714.16,1789.2
X$8233 2305 1008 960 1060 962 961 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8254 m0 *1 1853.04,1829.52
X$8254 2305 1304 961 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $8256 m0 *1 1668.24,1799.28
X$8256 2305 1114 1115 1055 1054 961 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8259 r0 *1 1766.8,1789.2
X$8259 2305 1078 964 1064 965 961 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8261 m0 *1 1739.92,1799.28
X$8261 2305 1119 1010 1023 1121 961 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8263 r0 *1 1849.68,1809.36
X$8263 2305 1223 1145 1146 1148 961 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8265 m0 *1 1802.64,1799.28
X$8265 2305 1125 1081 966 1028 961 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8267 m0 *1 1826.16,1819.44
X$8267 2305 1254 1252 1253 1281 961 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8270 r0 *1 1644.16,1819.44
X$8270 2305 1647 1337 1215 1338 961 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8272 m0 *1 1643.04,1809.36
X$8272 2305 1277 1072 1111 1169 961 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8274 m0 *1 1834.56,1789.2
X$8274 2305 968 1063 1029 1031 961 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8332 m0 *1 1639.68,1849.68
X$8332 2304 2305 1375 967 1508 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $8339 r0 *1 1845.76,1890
X$8339 2305 1896 2183 1832 968 1781 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $8385 r0 *1 1905.12,1819.44
X$8385 2304 1141 2305 1035 1347 971 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8387 r0 *1 1896.16,1819.44
X$8387 2304 1011 2305 1001 1255 971 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8421 m0 *1 1995.84,1829.52
X$8421 2305 1033 973 2304 1313 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8424 m0 *1 1952.72,1819.44
X$8424 2305 1144 973 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8428 m0 *1 2035.04,1829.52
X$8428 2305 1036 973 2304 1326 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8445 r0 *1 1925.28,1829.52
X$8445 2305 974 1035 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8447 m0 *1 1945.44,1829.52
X$8447 2305 974 1026 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8462 r0 *1 1968.96,1829.52
X$8462 2304 1025 2305 1026 1410 975 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8465 r0 *1 1980.72,1829.52
X$8465 2304 1151 2305 975 1309 1152 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8474 m0 *1 2059.12,1869.84
X$8474 2305 1744 1733 1382 978 1732 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $8486 r0 *1 2017.12,1839.6
X$8486 2304 1151 2305 979 1481 1152 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8488 r0 *1 2017.68,1829.52
X$8488 2304 1141 2305 1035 1314 979 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8494 r0 *1 2063.04,1829.52
X$8494 2305 1479 1404 1382 981 1383 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $8499 m0 *1 2038.96,1839.6
X$8499 2305 1381 1403 1382 983 1463 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $8506 m0 *1 3549.84,1789.2
X$8506 2305 986 985 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8512 m0 *1 3564.4,1789.2
X$8512 2305 1041 987 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8525 r0 *1 1573.04,1799.28
X$8525 2305 989 1212 1168 1104 1135 2304 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $8558 r0 *1 1377.04,1869.84
X$8558 2305 2304 1800 1567 1568 998 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8565 r0 *1 1959.44,1789.2
X$8565 2305 1032 1053 999 1052 1090 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8611 m0 *1 1889.44,1839.6
X$8611 2305 1001 1152 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8618 m0 *1 1811.6,1839.6
X$8618 2304 1011 2305 1301 1418 1001 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8629 m0 *1 1883.84,1799.28
X$8629 2305 1174 1004 1084 1113 1090 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $8637 r0 *1 1848.56,1879.92
X$8637 2305 1860 1859 1713 1005 1781 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $8651 r0 *1 1709.12,1879.92
X$8651 2305 1833 1822 1656 1008 1773 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $8684 r0 *1 1896.16,1829.52
X$8684 2305 1220 1011 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8687 m0 *1 1989.12,1829.52
X$8687 2305 1033 1011 2304 1311 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8693 r0 *1 2025.52,1829.52
X$8693 2305 1036 1011 2304 1380 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8698 r0 *1 2.24,1789.2
X$8698 2305 1012 1043 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8705 m0 *1 1513.68,1799.28
X$8705 1014 1103 1066 1067 2304 2305 1102 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8771 r0 *1 2017.68,1809.36
X$8771 2305 1019 1325 1189 1101 1021 1038 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $8775 m0 *1 1682.8,1829.52
X$8775 2305 1019 1442 1341 1279 1021 1288 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $8777 r0 *1 1764.56,1819.44
X$8777 2305 1298 1019 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $8783 r0 *1 1786.4,1819.44
X$8783 2305 1019 1349 1249 1248 1025 1299 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $8786 m0 *1 1681.68,1819.44
X$8786 2305 1019 1216 1217 1171 1021 1208 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $8803 r0 *1 1882.16,1809.36
X$8803 2305 2304 1220 1020 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8814 r0 *1 2057.44,1809.36
X$8814 2305 1038 1020 2304 1203 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8840 r0 *1 1976.8,1809.36
X$8840 2305 1144 1021 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $8849 r0 *1 1912.96,1819.44
X$8849 2305 1143 1486 1347 1276 1021 1086 2304 gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $8856 r0 *1 1711.92,1869.84
X$8856 2305 1022 1741 1512 1812 1773 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $8902 m0 *1 1807.68,1829.52
X$8902 2304 1025 2305 1026 1376 1301 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8906 m0 *1 1960,1829.52
X$8906 2305 1144 1025 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8986 m0 *1 1840.16,1879.92
X$8986 2305 1030 1840 1715 1861 1781 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $8993 r0 *1 1962.8,1839.6
X$8993 2305 1483 1544 1460 1032 1461 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9057 r0 *1 2133.6,1819.44
X$9057 2305 1036 1259 1264 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $9067 m0 *1 2054.08,1859.76
X$9067 2305 1625 1600 1382 1037 1529 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9077 r0 *1 2142.56,1809.36
X$9077 2305 1038 1259 1157 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $9091 r0 *1 2116.24,1869.84
X$9091 2305 2304 1798 1729 1392 1040 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9097 m0 *1 3545.36,1799.28
X$9097 1094 2304 2305 1042 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9196 m0 *1 1931.44,1799.28
X$9196 2305 1105 1106 1058 1091 1090 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9251 m0 *1 1806.56,1920.24
X$9251 2305 2037 2177 1713 1065 1984 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9254 r0 *1 1556.24,1809.36
X$9254 2305 2304 1066 1132 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9258 r0 *1 1512,1809.36
X$9258 2305 1066 2320 1128 1129 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $9269 r0 *1 1551.2,1799.28
X$9269 1130 2305 1131 1068 2304 1166 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $9282 m0 *1 1635.2,1869.84
X$9282 2305 1710 1749 1713 1071 1712 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9303 m0 *1 1648.64,1829.52
X$9303 2305 2304 1234 1339 1073 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9307 r0 *1 1821.68,1839.6
X$9307 2305 1450 2304 1073 1377 1120 1079 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $9310 m0 *1 1608.88,1809.36
X$9310 2305 1137 1073 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $9318 r0 *1 1876.56,1839.6
X$9318 2305 2304 1456 1488 1073 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9322 r0 *1 1753.92,1799.28
X$9322 2304 1175 2305 1122 1076 1075 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9328 r0 *1 1733.76,1890
X$9328 2305 1965 1903 1512 1076 1835 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9331 m0 *1 1771.28,1799.28
X$9331 2304 1077 2305 1124 1177 1123 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9336 m0 *1 1754.48,1890
X$9336 2305 1905 1766 1656 1078 1775 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9360 m0 *1 1597.12,1849.68
X$9360 2305 1507 1079 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $9365 r0 *1 1594.88,1809.36
X$9365 2305 2304 1079 1213 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9372 m0 *1 1763.44,1839.6
X$9372 2305 2304 1079 1298 1375 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9375 m0 *1 1798.16,1809.36
X$9375 2305 1142 1178 1080 1179 1143 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9409 r0 *1 1875.44,1799.28
X$9409 2304 1116 2305 1117 1457 1083 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9414 r0 *1 1904,1849.68
X$9414 2305 1085 2179 1382 1690 1523 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9424 m0 *1 2124.64,1819.44
X$9424 2305 1086 1259 1197 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $9429 m0 *1 1909.04,1829.52
X$9429 2305 1086 1220 2304 1348 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9438 r0 *1 1924.72,1799.28
X$9438 2304 1109 2305 1088 1089 1110 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9443 m0 *1 1944.88,1859.76
X$9443 2305 1631 1728 1386 1089 1594 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9460 m0 *1 1881.04,1829.52
X$9460 2305 1304 1090 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $9462 m0 *1 1985.2,1839.6
X$9462 2304 1310 1411 1309 1311 1090 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $9466 m0 *1 1967.28,1819.44
X$9466 2305 1623 1149 1273 1272 1090 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9469 m0 *1 2031.12,1809.36
X$9469 2305 1209 1092 1093 1099 1090 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9471 r0 *1 2056.32,1799.28
X$9471 2305 1257 1162 1098 1097 1090 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9473 m0 *1 2052.96,1819.44
X$9473 2305 1193 1269 1191 1192 1090 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9477 m0 *1 2018.24,1839.6
X$9477 2305 1407 1330 1481 1380 1090 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9480 r0 *1 2047.92,1819.44
X$9480 2304 1206 1323 1190 1203 1090 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $9498 m0 *1 2103.92,1879.92
X$9498 2305 2304 1786 1843 1392 1095 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9533 m0 *1 1565.2,1819.44
X$9533 2305 2304 1103 1133 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9544 r0 *1 1566.88,1799.28
X$9544 2305 2304 1104 1133 1131 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $9551 r0 *1 1937.6,1859.76
X$9551 2305 1685 1683 1460 1105 1594 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9559 r0 *1 1605.52,1799.28
X$9559 2305 1137 1107 2304 1108 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9586 r0 *1 1658.72,1879.92
X$9586 2305 1899 1853 1832 1114 1714 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9606 r0 *1 1732.64,1879.92
X$9606 2305 1902 1829 1656 1119 1835 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9641 m0 *1 1760.08,1849.68
X$9641 2305 1375 1120 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $9662 m0 *1 1798.16,1910.16
X$9662 2305 2008 2082 1832 1125 1984 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9666 m0 *1 1372,1839.6
X$9666 2305 2304 1361 1364 1568 1126 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9696 r0 *1 1529.36,1809.36
X$9696 2305 1210 1183 1182 1130 2304 1163 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $9700 r0 *1 1561.28,1799.28
X$9700 2305 2304 1167 1132 1131 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $9725 r0 *1 1573.04,1879.92
X$9725 1706 2304 1771 1856 2305 1135 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9728 m0 *1 1583.68,1900.08
X$9728 1706 2304 1771 1959 2305 1136 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9768 r0 *1 1660.4,1869.84
X$9768 2305 1140 1751 1715 1809 1712 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9788 r0 *1 1934.24,1809.36
X$9788 2305 1144 1141 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $9806 r0 *1 1800.4,1910.16
X$9806 2305 1983 2083 1715 1142 1984 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $9828 m0 *1 1766.24,1829.52
X$9828 2305 1298 1143 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $9831 r0 *1 1748.88,1819.44
X$9831 2304 1297 1446 1245 1246 1143 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $9833 r0 *1 1991.36,1829.52
X$9833 2304 1340 1409 1410 1313 1143 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $9835 m0 *1 2009.84,1809.36
X$9835 2305 1161 1165 1164 1150 1143 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9837 m0 *1 2025.52,1819.44
X$9837 2305 1324 1271 1211 1270 1143 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9840 m0 *1 1848,1819.44
X$9840 2305 1966 1147 1282 1221 1143 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9843 m0 *1 1867.6,1839.6
X$9843 2305 1455 1351 1378 1488 1143 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9845 m0 *1 1664.32,1829.52
X$9845 2305 1294 1293 1278 1339 1143 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9847 m0 *1 2017.12,1829.52
X$9847 2305 1406 1314 1332 1326 1143 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $9870 m0 *1 1753.92,1819.44
X$9870 2305 1231 1144 2304 1246 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9904 m0 *1 1904,1839.6
X$9904 2305 1220 1151 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $9953 m0 *1 3549.28,1809.36
X$9953 1154 2304 2305 1155 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9959 r0 *1 3549.84,1809.36
X$9959 2305 1201 1156 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $9970 r0 *1 2104.48,1849.68
X$9970 2305 1599 2304 1458 1158 1532 1603 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $9981 m0 *1 2078.16,1890
X$9981 2305 1891 1789 1386 1161 1844 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10025 m0 *1 1657.6,1869.84
X$10025 2305 1172 1811 1715 1649 1714 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10030 m0 *1 1713.6,1829.52
X$10030 2304 1173 1415 1345 1344 1304 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $10035 r0 *1 1873.76,1900.08
X$10035 2305 1935 2085 1832 1174 1937 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10046 m0 *1 1853.04,1910.16
X$10046 2305 1933 2002 1713 1176 1934 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10052 r0 *1 1761.76,1869.84
X$10052 2305 1815 1700 1512 1177 1775 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10063 m0 *1 2.24,1819.44
X$10063 2305 1180 1204 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $10066 m0 *1 1457.68,1819.44
X$10066 2305 1208 1228 1181 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $10095 r0 *1 1764.56,1839.6
X$10095 2305 1370 2304 1375 1551 1184 1515 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $10109 r0 *1 1949.92,1819.44
X$10109 2304 1275 2305 1188 1322 1274 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10119 m0 *1 2061.92,1849.68
X$10119 2305 1620 1606 1460 1193 1529 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10124 m0 *1 2106.72,1859.76
X$10124 2305 2304 1615 1599 1392 1195 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10135 m0 *1 3564.4,1819.44
X$10135 2305 1199 1198 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $10143 m0 *1 3549.84,1819.44
X$10143 2305 1200 1263 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $10162 m0 *1 1365.84,1859.76
X$10162 2305 1566 1564 1240 1205 1569 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10173 r0 *1 18.48,1819.44
X$10173 2305 1225 1207 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $10188 m0 *1 1708,1829.52
X$10188 2305 1208 1220 2304 1344 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10195 r0 *1 2039.52,1869.84
X$10195 2305 1784 1792 1460 1209 1666 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10223 m0 *1 1674.4,1849.68
X$10223 2305 1216 1498 1512 1580 1510 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10257 m0 *1 1743.28,1839.6
X$10257 2305 1231 1220 2304 1374 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10261 m0 *1 1715.84,1839.6
X$10261 2305 1288 1220 2304 1443 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10275 r0 *1 1853.6,1910.16
X$10275 2305 2005 2024 1832 1223 1934 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10278 m0 *1 16.8,1819.44
X$10278 1262 2304 2305 1224 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10284 r0 *1 2.24,1819.44
X$10284 2305 1226 1229 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $10287 m0 *1 16.8,1829.52
X$10287 1237 2304 2305 1227 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10297 r0 *1 1334.48,1859.76
X$10297 2305 1639 1228 1565 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $10299 m0 *1 1319.36,1849.68
X$10299 2305 1364 1228 1426 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $10302 m0 *1 1336.16,1849.68
X$10302 2305 1429 1228 1501 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $10305 r0 *1 1436.4,1869.84
X$10305 2305 1228 2331 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $10310 r0 *1 1398.88,1819.44
X$10310 2305 1231 1228 1230 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $10313 r0 *1 1420.16,1819.44
X$10313 2305 1288 1228 1232 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $10354 m0 *1 1582,1839.6
X$10354 2305 2304 1370 1235 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10362 m0 *1 1574.72,1839.6
X$10362 1367 2305 1236 1412 2304 1331 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $10364 m0 *1 1569.68,1839.6
X$10364 2305 2304 1363 1236 1436 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10371 r0 *1 1613.36,1819.44
X$10371 2305 1624 1237 1334 1333 1336 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10378 m0 *1 1606.08,1839.6
X$10378 2305 2304 1291 1289 1238 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $10393 r0 *1 1635.76,1900.08
X$10393 2305 1709 2304 1962 1711 1239 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10397 m0 *1 1537.76,1849.68
X$10397 2305 1504 1239 1430 2304 1433 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $10399 m0 *1 1532.16,1930.32
X$10399 2305 2304 2041 2067 1973 1239 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10401 r0 *1 1529.36,1920.24
X$10401 2305 1239 1918 2041 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $10403 r0 *1 1666,1910.16
X$10403 2305 1813 2304 1977 1774 1239 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10406 m0 *1 1645.28,1910.16
X$10406 2305 1830 2304 1975 1875 1239 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10409 m0 *1 1548.4,1859.76
X$10409 1239 2305 1505 1643 2304 1571 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $10425 r0 *1 1611.12,1859.76
X$10425 2305 2304 1708 1681 1240 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10427 m0 *1 2092.16,1839.6
X$10427 2305 1465 2304 1458 1405 1240 1387 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $10429 m0 *1 1617.28,1859.76
X$10429 2305 2304 1857 1624 1240 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10432 m0 *1 1423.52,1829.52
X$10432 2305 1287 1240 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $10435 m0 *1 1928.64,1839.6
X$10435 2305 1519 2304 1458 1307 1240 1520 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $10446 m0 *1 1660.4,1839.6
X$10446 2304 1413 2305 1241 1439 1414 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10453 r0 *1 1700.72,1849.68
X$10453 2305 1753 1561 1583 1243 1510 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10463 m0 *1 1779.12,1849.68
X$10463 2304 1551 2305 1247 1659 1516 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10471 r0 *1 1812.72,1829.52
X$10471 2304 1377 2305 1251 1448 1376 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10478 r0 *1 1825.6,1910.16
X$10478 2305 2007 2142 1832 1254 1986 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10482 m0 *1 1898.4,1829.52
X$10482 2304 1306 1591 1255 1304 1348 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $10486 r0 *1 2060.8,1890
X$10486 2305 1892 1850 1460 1257 1844 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10491 m0 *1 2116.24,1839.6
X$10491 2305 2304 1390 1391 1392 1258 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10504 m0 *1 2050.72,1879.92
X$10504 2305 1259 2322 2304 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $10506 r0 *1 2123.52,1839.6
X$10506 2305 1387 1259 1469 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $10509 m0 *1 2135.84,1859.76
X$10509 2305 1603 1259 1674 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $10511 m0 *1 2135.84,1869.84
X$10511 2305 1531 1259 1742 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $10516 r0 *1 2140.32,1839.6
X$10516 2305 1467 1259 1470 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $10520 m0 *1 2091.04,1900.08
X$10520 2305 1843 1259 1948 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $10523 m0 *1 3562.16,1829.52
X$10523 1319 2304 2305 1260 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10526 m0 *1 3553.76,1829.52
X$10526 1320 2304 2305 1261 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10588 r0 *1 1641.36,1879.92
X$10588 2305 1874 1890 1832 1277 1712 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10609 r0 *1 2.24,1829.52
X$10609 1359 2304 2305 1283 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10613 r0 *1 27.44,1829.52
X$10613 1327 2304 2305 1284 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10618 r0 *1 36.4,1829.52
X$10618 1285 2304 2305 1354 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10621 m0 *1 1380.4,1839.6
X$10621 2305 2304 1408 1286 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10639 r0 *1 1363.04,1859.76
X$10639 2305 1287 2304 1566 1639 1363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10641 r0 *1 1786.96,1869.84
X$10641 2305 1777 2304 1645 1661 1287 1776 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $10643 r0 *1 1808.8,1869.84
X$10643 2305 1725 2304 1645 1723 1287 1779 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $10646 r0 *1 1369.76,1869.84
X$10646 2305 1287 2304 1745 1567 1363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10648 m0 *1 1643.04,1859.76
X$10648 2305 1577 2304 1645 1509 1287 1578 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $10652 r0 *1 1804.88,1859.76
X$10652 2305 1662 1287 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $10655 m0 *1 1366.96,1849.68
X$10655 2305 1287 2304 1365 1429 1363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10657 m0 *1 1364.16,1839.6
X$10657 2305 1287 2304 1362 1364 1363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10690 m0 *1 1552.32,1849.68
X$10690 2305 1375 1572 1433 1289 1505 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $10694 r0 *1 2.24,1910.16
X$10694 1289 2304 2305 1968 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10697 r0 *1 1571.92,1839.6
X$10697 1289 2305 1436 1485 2304 1484 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $10700 r0 *1 1421.84,1839.6
X$10700 2305 1363 1289 2304 gf180mcu_fd_sc_mcu9t5v0__clkinv_16
* cell instance $10705 r0 *1 1598.24,1869.84
X$10705 2305 1645 1707 1706 1291 1289 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $10719 m0 *1 1565.2,1859.76
X$10719 1506 2305 2304 1621 1291 1436 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $10722 r0 *1 1551.76,1849.68
X$10722 2305 1291 1433 1572 1505 2304 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $10728 r0 *1 1645.28,1849.68
X$10728 2305 2304 1626 1577 1568 1292 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10737 m0 *1 1664.32,1900.08
X$10737 2305 1977 1914 1715 1294 1922 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10740 r0 *1 1713.04,1839.6
X$10740 2304 1295 1627 1372 1443 1304 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $10756 m0 *1 1796.48,1849.68
X$10756 2305 2304 1299 1515 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10759 r0 *1 1788.08,1859.76
X$10759 2305 1299 1660 1688 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $10776 m0 *1 1836.8,1829.52
X$10776 2304 1350 2305 1302 1416 1303 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10794 r0 *1 1737.12,1839.6
X$10794 2304 1346 1555 1444 1374 1304 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $10799 m0 *1 1819.44,1839.6
X$10799 2304 1417 1449 1418 1451 1304 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $10801 m0 *1 1751.12,1849.68
X$10801 2304 2305 1375 1304 1370 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $10808 m0 *1 1880.48,1879.92
X$10808 2305 1783 1841 1713 1305 1726 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10817 r0 *1 1927.52,1849.68
X$10817 2305 2304 1522 1519 1392 1308 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10828 m0 *1 2000.88,1849.68
X$10828 2305 1597 1612 1382 1312 1524 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10839 r0 *1 2113.44,1849.68
X$10839 2305 2304 1605 1530 1392 1317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10843 m0 *1 3562.16,1839.6
X$10843 1384 2304 2305 1318 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10854 m0 *1 2107.84,1839.6
X$10854 2305 2304 1389 1465 1392 1321 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10864 r0 *1 2077.04,1879.92
X$10864 2305 1880 1851 1386 1322 1732 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10868 r0 *1 2064.72,1839.6
X$10868 2305 1478 1611 1460 1323 1463 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10875 m0 *1 2078.72,1859.76
X$10875 2305 1676 1616 1386 1324 1529 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10881 r0 *1 2036.16,1839.6
X$10881 2305 1325 1477 1386 1545 1463 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10897 r0 *1 1564.08,1839.6
X$10897 1434 1505 1433 1484 2304 2305 1328 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $10949 m0 *1 1962.8,1849.68
X$10949 2305 1342 1543 1386 1682 1461 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10954 m0 *1 1962.24,1839.6
X$10954 2305 1628 1379 1382 1343 1461 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10980 r0 *1 1790.32,1879.92
X$10980 2305 1349 2080 1512 1778 1838 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $10993 r0 *1 2.24,1849.68
X$10993 1491 2304 2305 1352 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10995 r0 *1 19.04,1829.52
X$10995 1402 2304 2305 1353 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11001 m0 *1 34.72,1839.6
X$11001 1360 2304 2305 1355 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11004 m0 *1 2.24,1839.6
X$11004 1358 2304 2305 1356 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11027 m0 *1 1356.32,1849.68
X$11027 2305 2304 1541 1408 1503 1361 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $11046 r0 *1 1576.4,1859.76
X$11046 2304 1506 1363 1727 2305 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $11051 r0 *1 1528.8,1859.76
X$11051 2305 2304 1678 1677 1363 1641 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11058 r0 *1 1369.2,1849.68
X$11058 2305 1505 1567 1364 1639 1429 2304 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $11061 r0 *1 1327.76,1839.6
X$11061 2305 2304 1426 1500 1427 1364 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11069 r0 *1 1378.72,1839.6
X$11069 2305 2304 1428 1366 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11074 r0 *1 1572.48,1849.68
X$11074 2305 1367 1571 1573 1370 2304 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $11076 r0 *1 1578.64,1839.6
X$11076 2305 2304 1367 1485 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11084 m0 *1 1601.6,1879.92
X$11084 2304 2305 1707 1368 1706 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $11103 r0 *1 1530.48,1839.6
X$11103 2305 2304 1369 1430 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11105 r0 *1 1662.64,1859.76
X$11105 2305 1648 2304 1649 1526 1369 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11107 m0 *1 1518.16,1920.24
X$11107 2305 2304 2014 2035 1973 1369 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11109 r0 *1 1514.24,1910.16
X$11109 2305 1369 1918 2014 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $11111 m0 *1 1655.36,1890
X$11111 2305 1830 2304 1899 1875 1369 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11114 r0 *1 1536.64,1879.92
X$11114 2305 1768 1867 1369 2304 1572 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $11116 m0 *1 1537.76,1879.92
X$11116 2305 1801 1369 2304 1434 1768 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $11119 r0 *1 1644.16,1869.84
X$11119 2305 1709 2304 1807 1711 1369 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11127 m0 *1 1580.88,1849.68
X$11127 1506 1370 1507 1508 2304 2305 1619 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $11134 m0 *1 1765.12,1859.76
X$11134 2304 1370 1375 2305 1585 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11157 m0 *1 1603.28,1859.76
X$11157 2304 1507 1375 2305 1680 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11161 r0 *1 1639.68,1849.68
X$11161 2304 1508 1375 2305 1576 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11183 m0 *1 3570.56,1839.6
X$11183 1379 2304 2305 1401 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11187 m0 *1 2036.72,1849.68
X$11187 2305 1592 2304 1381 1528 1391 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11211 r0 *1 1909.04,1869.84
X$11211 2305 1718 1382 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $11221 r0 *1 2086,1829.52
X$11221 2305 2304 1387 1383 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $11223 m0 *1 2057.44,1839.6
X$11223 2305 1464 1388 1460 1407 1383 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11225 m0 *1 2074.8,1839.6
X$11225 2305 1675 1393 1386 1406 1383 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11230 r0 *1 1998.08,1839.6
X$11230 2305 1462 1384 1460 1411 1524 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11237 r0 *1 1923.04,1839.6
X$11237 2305 1486 1385 1386 1546 1523 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11240 r0 *1 3570.56,1829.52
X$11240 1385 2304 2305 1397 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11258 m0 *1 2031.12,1869.84
X$11258 2305 1527 1730 1386 1747 1666 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11260 r0 *1 2006.48,1849.68
X$11260 2305 1598 1613 1386 1409 1524 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11264 m0 *1 1926.4,1879.92
X$11264 2305 1813 1386 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $11280 r0 *1 2112.88,1839.6
X$11280 2305 2304 1533 1387 1521 1389 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $11283 m0 *1 2130.24,1849.68
X$11283 2305 2304 1469 1542 1534 1387 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11290 r0 *1 3562.16,1829.52
X$11290 1388 2304 2305 1396 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11296 m0 *1 2110.08,1849.68
X$11296 2305 2304 1604 1467 1521 1390 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $11306 r0 *1 2109.52,1900.08
X$11306 2305 1391 1743 1992 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $11308 r0 *1 2095.52,1839.6
X$11308 2305 1391 2304 1458 1466 1532 1467 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $11312 m0 *1 2116.8,1910.16
X$11312 2305 2304 1992 1993 1946 1391 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11314 m0 *1 2046.8,1849.68
X$11314 2305 1459 2304 1478 1525 1391 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11317 m0 *1 2027.2,1849.68
X$11317 2305 1512 2304 1545 1526 1391 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11332 m0 *1 1921.92,1869.84
X$11332 2305 1727 1392 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $11348 r0 *1 3562.16,1839.6
X$11348 1393 2304 2305 1472 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11351 r0 *1 3537.52,1839.6
X$11351 1544 2304 2305 1394 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11353 m0 *1 3553.76,1839.6
X$11353 1403 2304 2305 1395 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11362 r0 *1 3553.76,1829.52
X$11362 1404 2304 2305 1398 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11366 r0 *1 3558.8,1849.68
X$11366 1611 2304 2305 1399 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11371 r0 *1 3545.92,1839.6
X$11371 1477 2304 2305 1400 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11402 r0 *1 1362.48,1879.92
X$11402 2305 1824 1767 1408 1703 1428 2304 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $11407 r0 *1 1344,1910.16
X$11407 2305 1408 1617 1999 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $11409 m0 *1 1347.36,1910.16
X$11409 2305 2304 1999 1970 1917 1408 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11424 r0 *1 1547.28,1839.6
X$11424 1431 1433 1434 1412 1505 2304 2305 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $11439 m0 *1 1695.68,1849.68
X$11439 2305 1513 1475 1656 1415 1510 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11444 m0 *1 1828.96,1910.16
X$11444 2305 1930 2023 1715 1416 1986 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11459 r0 *1 33.6,1849.68
X$11459 1502 2304 2305 1421 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11462 m0 *1 19.04,1859.76
X$11462 1561 2304 2305 1422 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11465 r0 *1 2.24,1839.6
X$11465 1498 2304 2305 1423 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11468 r0 *1 38.64,1839.6
X$11468 1475 2304 2305 1424 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11486 m0 *1 8.4,1849.68
X$11486 1425 2304 2305 1492 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11501 r0 *1 1678.32,1849.68
X$11501 2305 1442 1425 1512 1651 1582 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11522 m0 *1 1337.28,1859.76
X$11522 2305 2304 1565 1638 1427 1639 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11524 r0 *1 1648.64,1920.24
X$11524 2305 2304 2042 2017 1427 1577 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11526 m0 *1 1715.28,1930.32
X$11526 2305 2304 2045 1979 1427 1772 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11528 m0 *1 1549.52,1920.24
X$11528 2305 2015 1427 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $11532 m0 *1 1746.08,1940.4
X$11532 2305 2304 2094 2078 1427 1720 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11534 r0 *1 1752.8,1930.32
X$11534 2305 2304 2048 2021 1427 1836 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11537 m0 *1 1727.6,1940.4
X$11537 2305 2304 2077 2091 1427 1877 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11539 r0 *1 1696.8,1910.16
X$11539 2305 2304 2003 1978 1427 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11542 r0 *1 1338.96,1839.6
X$11542 2305 2304 1501 1474 1427 1429 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11544 m0 *1 1330,1869.84
X$11544 2305 2304 1701 1702 1427 1567 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11550 r0 *1 1340.08,1890
X$11550 2305 1428 1617 1864 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $11552 m0 *1 1344.56,1900.08
X$11552 2305 2304 1864 1865 1917 1428 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11556 r0 *1 1359.68,1839.6
X$11556 2305 2304 1502 1428 1503 1480 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $11568 m0 *1 1530.48,1849.68
X$11568 2305 2304 1430 1431 1504 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11580 m0 *1 1538.88,1859.76
X$11580 2305 2304 1618 1570 1432 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11610 m0 *1 1643.04,1890
X$11610 2305 1830 2304 1874 1875 1434 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11615 m0 *1 1523.2,1910.16
X$11615 2305 2304 1972 1971 1973 1434 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11617 r0 *1 1538.88,1890
X$11617 2305 2304 1867 1434 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11620 m0 *1 1662.08,1879.92
X$11620 2305 1648 2304 1809 1526 1434 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11622 m0 *1 1533.28,1859.76
X$11622 2305 2304 1618 1434 1505 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $11628 r0 *1 1636.88,1869.84
X$11628 2305 1709 2304 1710 1711 1434 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11632 r0 *1 1573.04,1869.84
X$11632 1706 1825 1805 1705 2305 2304 1435 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $11642 r0 *1 1667.68,1839.6
X$11642 2304 1438 2305 1440 1550 1441 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11646 r0 *1 1660.4,1900.08
X$11646 2305 2001 1964 1715 1439 1873 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11663 r0 *1 1740.48,1869.84
X$11663 2305 1720 2304 1645 1445 1652 1721 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $11666 r0 *1 1743.28,1859.76
X$11666 2305 1658 1686 1512 1446 1584 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11668 m0 *1 1752.24,1910.16
X$11668 2305 2304 2006 1720 1568 1447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11673 m0 *1 1820,1890
X$11673 2305 1898 1897 1512 1448 1814 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11676 r0 *1 1816.64,1879.92
X$11676 2305 1839 2113 1656 1449 1814 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11685 m0 *1 1831.2,1849.68
X$11685 2305 2304 1517 1450 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11697 m0 *1 1870.4,3573.36
X$11697 2305 2210 1452 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $11709 m0 *1 1870.96,1849.68
X$11709 2304 1518 2305 1453 1893 1454 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11715 r0 *1 1873.76,1869.84
X$11715 2305 1590 1810 1715 1455 1726 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11727 r0 *1 1871.52,1920.24
X$11727 2305 2093 2056 1715 1457 1937 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11746 r0 *1 2100.56,1859.76
X$11746 2305 1729 2304 1458 1468 1532 1602 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $11749 r0 *1 1911.28,1859.76
X$11749 2305 1645 1458 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $11768 r0 *1 2059.12,1849.68
X$11768 2305 1459 2304 1620 1525 1599 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11771 r0 *1 1887.2,1859.76
X$11771 2305 2304 1716 1459 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11773 r0 *1 2057.44,1839.6
X$11773 2305 1459 2304 1464 1525 1465 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11775 r0 *1 2048.48,1879.92
X$11775 2305 1459 2304 1852 1525 1731 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11777 m0 *1 2053.52,1890
X$11777 2305 1459 2304 1892 1525 1843 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11780 m0 *1 2035.04,1879.92
X$11780 2305 1459 2304 1784 1525 1729 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11782 m0 *1 1928.64,1859.76
X$11782 2305 1459 2304 1685 1525 1664 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11785 m0 *1 1876.56,1890
X$11785 2305 1459 2304 1894 1875 1633 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11788 r0 *1 1955.52,1839.6
X$11788 2305 1459 2304 1483 1525 1595 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11790 r0 *1 1868.72,1890
X$11790 2305 1459 2304 1935 1875 1936 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11804 m0 *1 2060.8,1890
X$11804 2305 1852 1885 1460 1623 1732 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11811 m0 *1 1900.08,1859.76
X$11811 2305 1591 1689 1460 1687 1523 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $11816 m0 *1 1899.52,1879.92
X$11816 2305 1716 1460 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $11823 m0 *1 1977.92,1859.76
X$11823 2305 2304 1596 1461 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $11826 r0 *1 1992.48,1849.68
X$11826 2305 1656 2304 1462 1525 1530 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11832 r0 *1 2088.24,1839.6
X$11832 2305 2304 1467 1463 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $11847 m0 *1 2107.84,1930.32
X$11847 2305 2304 2059 2086 1946 1465 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11850 r0 *1 2100.56,1920.24
X$11850 2305 1465 1743 2059 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $11852 m0 *1 2071.44,1859.76
X$11852 2305 1593 2304 1675 1601 1465 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11854 m0 *1 2054.64,1849.68
X$11854 2305 1592 2304 1479 1528 1465 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11866 m0 *1 2147.6,1849.68
X$11866 2305 2304 1470 1476 1534 1467 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11877 r0 *1 3538.64,1849.68
X$11877 1612 2304 2305 1471 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11882 m0 *1 3562.16,1859.76
X$11882 1533 2304 2305 1473 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11885 r0 *1 12.32,1839.6
X$11885 2305 1494 1474 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $11895 m0 *1 3564.4,1849.68
X$11895 2305 1535 1476 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $11957 r0 *1 2.24,1859.76
X$11957 1671 2304 2305 1493 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11962 r0 *1 20.16,1869.84
X$11962 1684 2304 2305 1495 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11965 m0 *1 39.76,1849.68
X$11965 1541 2304 2305 1496 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11968 m0 *1 25.2,1849.68
X$11968 2305 1497 1500 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $11975 m0 *1 16.8,1849.68
X$11975 1562 2304 2305 1499 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12003 r0 *1 1629.04,1849.68
X$12003 2305 2304 1563 1578 1503 1626 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12005 m0 *1 1667.12,1859.76
X$12005 2305 2304 1610 1650 1503 1579 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12008 r0 *1 1738.8,1910.16
X$12008 2305 2304 2108 1721 1503 2006 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12010 r0 *1 1749.44,1910.16
X$12010 2305 2304 2047 1837 1503 1982 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12012 r0 *1 1716.4,1910.16
X$12012 2305 2304 2170 1925 1503 1980 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12017 m0 *1 1736,1920.24
X$12017 2305 2304 2046 1926 1503 1981 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12019 m0 *1 1366.4,1879.92
X$12019 2305 2304 1764 1767 1503 1800 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12021 m0 *1 1626.8,1920.24
X$12021 2305 2016 1503 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12024 m0 *1 1352.96,1869.84
X$12024 2305 2304 1763 1703 1503 1640 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12038 r0 *1 1681.12,1869.84
X$12038 2305 1709 2304 1752 1711 1504 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12040 m0 *1 1512.56,1930.32
X$12040 2305 1504 1918 2040 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $12042 r0 *1 1517.04,1920.24
X$12042 2305 2304 2040 2066 1973 1504 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12045 r0 *1 1533.28,1879.92
X$12045 2305 2304 1504 1768 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12050 m0 *1 1653.12,1900.08
X$12050 2305 1830 2304 2000 1875 1504 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12052 m0 *1 1669.92,1910.16
X$12052 2305 1813 2304 2001 1774 1504 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12070 r0 *1 1565.2,1849.68
X$12070 2305 2304 1573 1505 1572 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $12085 m0 *1 1584.24,1859.76
X$12085 2305 1507 2314 1574 1573 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12094 r0 *1 1593.76,1849.68
X$12094 2305 1508 2316 1574 1575 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12099 r0 *1 1663.76,1849.68
X$12099 2305 2304 1578 1510 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $12109 m0 *1 1677.76,1859.76
X$12109 2305 2304 1579 1581 1568 1511 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12132 m0 *1 1915.2,1849.68
X$12132 2305 1512 2304 1546 1526 1519 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12134 m0 *1 1923.6,1890
X$12134 2305 1813 1512 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $12145 m0 *1 1694,1869.84
X$12145 2305 1716 2304 1513 1719 1577 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12168 r0 *1 1845.2,1849.68
X$12168 2305 1517 1660 1548 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12183 r0 *1 1901.76,1920.24
X$12183 2305 1519 2025 2058 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12186 m0 *1 1917.44,1859.76
X$12186 2305 1656 2304 1687 1525 1519 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12189 r0 *1 1904,1859.76
X$12189 2305 1583 2304 1690 1528 1519 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12191 m0 *1 1897.28,1930.32
X$12191 2305 2304 2058 2057 1946 1519 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12200 m0 *1 1919.68,1910.16
X$12200 2305 2304 1941 1942 1534 1520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12202 m0 *1 1922.48,1849.68
X$12202 2305 2304 1614 1520 1521 1522 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12205 m0 *1 1901.76,1900.08
X$12205 2305 1520 2025 1941 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12209 m0 *1 1933.12,1849.68
X$12209 2305 2304 1520 1523 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $12222 r0 *1 2118.48,1879.92
X$12222 2305 2304 1956 1602 1521 1798 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12226 m0 *1 1905.12,1910.16
X$12226 2305 2016 1521 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12228 m0 *1 2116.24,1869.84
X$12228 2305 2304 1788 1531 1521 1605 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12230 m0 *1 2115.12,1859.76
X$12230 2305 2304 1609 1603 1521 1615 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12233 r0 *1 2107.84,1879.92
X$12233 2305 2304 1849 1787 1521 1786 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12235 r0 *1 2112.32,1890
X$12235 2305 2304 1884 1734 1521 1799 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12237 m0 *1 1957.2,1890
X$12237 2305 2304 1957 1665 1521 1804 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12240 m0 *1 1979.6,1890
X$12240 2305 2304 1842 1596 1521 1802 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12253 m0 *1 2018.24,1849.68
X$12253 2305 2304 1531 1524 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $12281 m0 *1 1905.12,1890
X$12281 2305 1719 1525 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12298 r0 *1 1669.36,1849.68
X$12298 2305 1648 2304 1580 1526 1577 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12300 r0 *1 1834,1879.92
X$12300 2305 1648 2304 1861 1526 1780 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12303 m0 *1 1818.32,1869.84
X$12303 2305 1774 1526 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12307 m0 *1 2023.84,1869.84
X$12307 2305 1648 2304 1747 1526 1729 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12310 m0 *1 1704.08,1879.92
X$12310 2305 1648 2304 1812 1526 1772 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12312 r0 *1 1676.08,1859.76
X$12312 2305 1648 2304 1651 1526 1581 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12314 m0 *1 1963.36,1859.76
X$12314 2305 1648 2304 1682 1526 1595 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12332 r0 *1 2051.84,1849.68
X$12332 2305 1592 2304 1625 1528 1599 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12338 m0 *1 2051.84,1869.84
X$12338 2305 1592 2304 1744 1528 1731 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12340 m0 *1 2043.44,1879.92
X$12340 2305 1592 2304 1854 1528 1843 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12342 r0 *1 2031.12,1869.84
X$12342 2305 1592 2304 1746 1528 1729 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12346 m0 *1 1995.84,1859.76
X$12346 2305 1583 2304 1597 1528 1530 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12348 r0 *1 1958.88,1849.68
X$12348 2305 1592 2304 1628 1528 1595 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12350 r0 *1 1930.32,1859.76
X$12350 2305 1592 2304 1748 1528 1664 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12352 m0 *1 1887.2,1869.84
X$12352 2305 1717 1528 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12359 r0 *1 2098.88,1849.68
X$12359 2305 2304 1603 1529 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $12375 m0 *1 2005.92,1859.76
X$12375 2305 1648 2304 1598 1601 1530 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12377 r0 *1 2106.16,1910.16
X$12377 2305 1530 1743 2026 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12380 m0 *1 2115.68,1920.24
X$12380 2305 2304 2026 2034 1946 1530 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12395 r0 *1 2143.68,1869.84
X$12395 2305 2304 1742 1790 1534 1531 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12414 r0 *1 1877.12,1859.76
X$12414 2305 1633 2304 1692 1691 1532 1663 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $12423 r0 *1 1840.72,1859.76
X$12423 2305 1662 1532 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $12443 r0 *1 2143.68,1859.76
X$12443 2305 2304 1674 1672 1534 1603 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12446 r0 *1 1902.32,1910.16
X$12446 2305 2036 1534 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12450 r0 *1 2148.72,1900.08
X$12450 2305 2304 1994 1995 1534 1734 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12452 m0 *1 1979.04,1910.16
X$12452 2305 2304 1947 1991 1534 1596 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12454 m0 *1 2159.36,1890
X$12454 2305 2304 1846 1883 1534 1602 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12456 m0 *1 2142.56,1890
X$12456 2305 2304 1845 1882 1534 1787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12458 r0 *1 1954.96,1900.08
X$12458 2305 2304 1989 1990 1534 1665 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12467 m0 *1 3541.44,1849.68
X$12467 2305 1536 1542 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12469 m0 *1 3556,1849.68
X$12469 1543 2304 2305 1537 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12473 m0 *1 3536.96,1859.76
X$12473 1604 2304 2305 1538 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12476 m0 *1 3564.4,1869.84
X$12476 1614 2304 2305 1539 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12479 r0 *1 3550.4,1849.68
X$12479 1613 2304 2305 1540 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12519 m0 *1 1652.56,1910.16
X$12519 2305 2000 1915 1832 1550 1873 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $12531 m0 *1 1702.96,1859.76
X$12531 2305 1655 1671 1583 1553 1582 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $12542 m0 *1 1737.68,1859.76
X$12542 2305 1754 1630 1656 1555 1584 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $12549 m0 *1 26.88,1869.84
X$12549 1686 2304 2305 1557 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12552 m0 *1 16.8,1869.84
X$12552 1630 2304 2305 1558 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12555 m0 *1 2.24,1859.76
X$12555 1563 2304 2305 1559 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12558 m0 *1 35.84,1859.76
X$12558 1610 2304 2305 1560 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12567 r0 *1 1733.76,1849.68
X$12567 2305 1657 1562 1583 1629 1584 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $12576 r0 *1 2.24,1879.92
X$12576 1564 2304 2305 1635 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12587 r0 *1 1326.08,1869.84
X$12587 2305 1567 1617 1701 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12607 r0 *1 1606.64,1900.08
X$12607 2305 1727 1568 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12623 m0 *1 1367.52,1869.84
X$12623 2305 2304 1703 1569 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12627 r0 *1 1538.32,1859.76
X$12627 2304 1642 1677 1571 1570 1679 2305 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $12632 m0 *1 1574.72,1859.76
X$12632 1621 2305 2304 1571 1575 2306 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12635 m0 *1 1577.52,1849.68
X$12635 2305 2304 1571 1574 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12648 m0 *1 1547.28,1869.84
X$12648 2304 1572 1801 2305 1643 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12655 m0 *1 1597.12,1859.76
X$12655 2305 2304 1573 1575 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12675 r0 *1 1642.48,1859.76
X$12675 2305 1576 1717 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12687 r0 *1 1696.8,1869.84
X$12687 2305 1718 2304 1753 1717 1577 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12692 m0 *1 1649.76,1930.32
X$12692 2305 1577 1918 2042 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12702 r0 *1 1643.6,1940.4
X$12702 2305 1578 1918 2088 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12704 m0 *1 1653.68,1950.48
X$12704 2305 2304 2088 2102 1917 1578 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12716 m0 *1 1697.92,1910.16
X$12716 2305 1581 1976 2003 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12718 r0 *1 1704.08,1869.84
X$12718 2305 1718 2304 1655 1717 1581 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12721 r0 *1 1685.6,1859.76
X$12721 2305 1581 2304 1645 1653 1652 1650 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $12726 m0 *1 1701.28,1869.84
X$12726 2305 1716 2304 1654 1719 1581 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12730 r0 *1 1700.16,1859.76
X$12730 2305 1654 1684 1656 1627 1582 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $12732 m0 *1 1691.76,1859.76
X$12732 2305 2304 1650 1582 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $12751 r0 *1 1792.56,1890
X$12751 2305 1900 2050 1583 1722 1838 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $12754 m0 *1 1817.2,1879.92
X$12754 2305 1724 2054 1583 1750 1814 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $12761 r0 *1 1904.56,1879.92
X$12761 2305 1718 1583 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $12774 m0 *1 1750,1869.84
X$12774 2305 2304 1721 1584 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $12779 r0 *1 1767.36,1859.76
X$12779 2305 1585 1719 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12794 m0 *1 1811.04,3563.28
X$12794 2305 2291 1587 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $12807 m0 *1 1780.24,1920.24
X$12807 2305 2304 2022 1777 1727 1588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12810 r0 *1 1817.76,1920.24
X$12810 2305 2304 2053 1725 1727 1589 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12813 m0 *1 1873.2,1859.76
X$12813 2305 1593 2304 1590 1601 1633 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12834 m0 *1 1878.24,1869.84
X$12834 2305 1592 2304 1783 1711 1633 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12840 r0 *1 1910.72,1890
X$12840 2305 2304 1718 1592 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12844 m0 *1 1874.88,1900.08
X$12844 2305 1592 2304 1939 1711 1936 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12855 m0 *1 1882.72,1940.4
X$12855 2305 1593 2304 2093 1601 1936 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12860 r0 *1 1821.68,1900.08
X$12860 2305 1593 2304 1930 1774 1985 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12863 m0 *1 2079.84,1900.08
X$12863 2305 1593 2304 1891 1601 1843 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12865 r0 *1 2078.16,1890
X$12865 2305 1593 2304 1880 1601 1731 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12867 r0 *1 1802.64,1900.08
X$12867 2305 1593 2304 1983 1774 1928 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12870 r0 *1 2075.36,1859.76
X$12870 2305 1593 2304 1676 1601 1599 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12875 m0 *1 1843.52,1920.24
X$12875 2305 1593 2304 2004 1601 1932 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12877 r0 *1 1774.64,1900.08
X$12877 2305 2304 1927 1593 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12880 m0 *1 1936.48,1859.76
X$12880 2305 1593 2304 1631 1601 1664 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12886 r0 *1 1954.96,1859.76
X$12886 2305 2304 1665 1594 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $12901 r0 *1 1934.24,1890
X$12901 2305 2304 1944 1945 1946 1595 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12904 m0 *1 1931.44,1900.08
X$12904 2305 1595 1660 1944 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12909 r0 *1 1971.76,1900.08
X$12909 2305 1596 1743 1947 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12931 r0 *1 2131.36,1910.16
X$12931 2305 2304 2027 2028 1946 1599 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12933 m0 *1 2125.76,1920.24
X$12933 2305 1599 1743 2027 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $12943 r0 *1 3562.16,1869.84
X$12943 1600 2304 2305 1608 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12962 m0 *1 1788.08,1879.92
X$12962 2305 1648 2304 1778 1601 1777 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12964 r0 *1 1788.08,1900.08
X$12964 2305 1774 1601 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12981 r0 *1 2069.76,1849.68
X$12981 2305 2304 1602 1666 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $12985 r0 *1 2155.44,1879.92
X$12985 2305 1602 1743 1846 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13010 m0 *1 3553.76,1859.76
X$13010 1606 2304 2305 1607 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13019 r0 *1 3570.56,1859.76
X$13019 1609 2304 2305 1670 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13052 m0 *1 3556,1869.84
X$13052 1616 2304 2305 1669 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13064 m0 *1 1436.4,1859.76
X$13064 2305 1617 2329 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $13070 r0 *1 1359.68,1890
X$13070 2305 1767 1617 1866 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13073 m0 *1 1341.2,1890
X$13073 2305 1703 1617 1820 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13097 r0 *1 1579.2,1879.92
X$13097 1825 1826 1622 1806 2304 2305 1644 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $13100 m0 *1 1563.52,1879.92
X$13100 2305 2304 1622 1823 1769 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13102 m0 *1 1616.72,1890
X$13102 2305 1622 1827 1858 1831 1824 2304 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $13149 r0 *1 1873.76,1950.48
X$13149 2305 2304 2118 2129 1973 1633 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13154 m0 *1 1869.84,1960.56
X$13154 2305 1633 2025 2118 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13158 r0 *1 24.08,1859.76
X$13158 2305 1634 1638 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $13163 m0 *1 37.52,1869.84
X$13163 1741 2304 2305 1636 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13166 r0 *1 10.64,1859.76
X$13166 1646 2304 2305 1637 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13189 m0 *1 20.72,1910.16
X$13189 2305 1969 1641 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $13220 r0 *1 1855.84,1859.76
X$13220 2305 1645 1692 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $13230 r0 *1 1643.04,1900.08
X$13230 2305 1975 1913 1832 1647 1922 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $13252 r0 *1 1930.32,1879.92
X$13252 2305 1813 1648 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $13271 m0 *1 1672.16,1940.4
X$13271 2305 2304 2072 2074 1917 1650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13273 r0 *1 1667.68,1940.4
X$13273 2305 1650 1918 2072 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13288 r0 *1 1819.44,1859.76
X$13288 2305 1662 1652 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $13328 m0 *1 1832.88,1869.84
X$13328 2305 1716 1656 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $13340 m0 *1 1778,1890
X$13340 2305 1878 2135 1656 1659 1838 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $13350 r0 *1 1733.2,1869.84
X$13350 2305 1718 2304 1657 1717 1720 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13353 m0 *1 1742.72,1869.84
X$13353 2305 1813 2304 1658 1774 1720 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13376 r0 *1 1781.92,1960.56
X$13376 2305 1929 1660 2166 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13379 m0 *1 1948.24,1910.16
X$13379 2305 1665 1660 1989 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13381 r0 *1 1748.32,1950.48
X$13381 2305 1837 1660 2133 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13383 r0 *1 1783.6,1920.24
X$13383 2305 1777 1660 2069 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13388 m0 *1 1770.16,1950.48
X$13388 2305 1776 1660 2109 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13391 r0 *1 1923.04,1900.08
X$13391 2305 1664 1660 1988 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13394 m0 *1 1800.4,1950.48
X$13394 2305 1928 1660 2134 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13397 m0 *1 1862.56,1980.72
X$13397 2305 1663 1660 2171 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13399 r0 *1 1729.28,1930.32
X$13399 2305 1720 1660 2094 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13402 r0 *1 1807.68,1960.56
X$13402 2305 1779 1660 2111 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13404 m0 *1 1870.4,1900.08
X$13404 2305 2304 1660 2321 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $13407 r0 *1 1806.56,1930.32
X$13407 2305 1725 1660 2068 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13409 r0 *1 1860.32,1970.64
X$13409 2305 1940 1660 2147 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $13421 m0 *1 1607.76,1869.84
X$13421 2304 1707 1706 1662 2305 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $13432 r0 *1 1861.44,1930.32
X$13432 2305 2304 2146 1663 2075 2055 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $13434 r0 *1 1868.16,1869.84
X$13434 2305 2304 1663 1726 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $13438 r0 *1 1864.24,1980.72
X$13438 2305 2304 2171 2175 2106 1663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13447 r0 *1 1921.92,1910.16
X$13447 2305 2304 1988 1943 1946 1664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13473 m0 *1 3545.36,1879.92
X$13473 1797 2304 2305 1667 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13476 r0 *1 3552.08,1859.76
X$13476 2305 1668 1672 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $13494 r0 *1 3562.16,1879.92
X$13494 1673 2304 2305 1735 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13518 r0 *1 1616.16,1859.76
X$13518 2305 1680 1774 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $13530 m0 *1 3530.8,1869.84
X$13530 1683 2304 2305 1738 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13574 r0 *1 1919.12,3553.2
X$13574 1689 2304 2305 2251 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13612 r0 *1 11.76,1869.84
X$13612 1765 2304 2305 1693 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13614 m0 *1 8.4,1869.84
X$13614 1699 2304 2305 1694 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13618 m0 *1 2.24,1879.92
X$13618 1749 2304 2305 1695 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13620 r0 *1 36.96,1869.84
X$13620 1751 2304 2305 1696 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13624 m0 *1 33.6,1879.92
X$13624 1763 2304 2305 1697 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13627 r0 *1 25.2,1879.92
X$13627 1811 2304 2305 1698 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13636 r0 *1 51.52,1869.84
X$13636 1700 2304 2305 1757 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13642 m0 *1 18.48,1879.92
X$13642 2305 1755 1702 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $13651 r0 *1 1345.12,1879.92
X$13651 2305 2304 1820 1821 1917 1703 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13656 m0 *1 1377.04,1879.92
X$13656 2305 2304 1767 1704 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13664 m0 *1 1597.12,1900.08
X$13664 1921 2305 2304 1920 1705 2308 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13666 m0 *1 1574.16,1900.08
X$13666 1958 2305 2304 1870 1705 2310 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13671 r0 *1 1597.68,1879.92
X$13671 2305 2304 1826 1705 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $13683 m0 *1 1582.56,1879.92
X$13683 2305 2304 1706 1806 1771 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13687 m0 *1 1548.96,1900.08
X$13687 2305 2304 1868 1895 1706 1919 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13689 r0 *1 1550.64,1910.16
X$13689 2305 1706 2013 2304 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $13691 m0 *1 1573.6,1910.16
X$13691 2304 1974 1706 2016 2305 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $13693 r0 *1 1560.72,1900.08
X$13693 2305 1869 1706 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $13702 r0 *1 1604.96,1890
X$13702 2305 1872 1707 1961 1770 2304 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $13704 m0 *1 1598.24,1890
X$13704 2305 2304 1707 1871 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13717 m0 *1 1624.56,1900.08
X$13717 1708 2304 1922 1873 2305 1961 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13719 r0 *1 1625.68,1890
X$13719 1708 2304 1831 1873 2305 1960 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13722 r0 *1 1654.8,1869.84
X$13722 2305 2304 1708 1714 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $13725 r0 *1 1696.8,1960.56
X$13725 2305 2304 2160 2161 2106 1708 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13727 m0 *1 1688.4,1960.56
X$13727 2305 1708 1976 2160 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $13729 r0 *1 1685.04,1930.32
X$13729 2305 2304 2089 1708 2075 2020 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $13731 r0 *1 1621.2,1900.08
X$13731 1708 2305 1922 1873 2304 1827 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13751 r0 *1 1841.28,1879.92
X$13751 2305 1709 2304 1860 1711 1780 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13753 r0 *1 1685.04,1900.08
X$13753 2305 2304 1924 1709 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13755 m0 *1 1710.8,1890
X$13755 2305 1709 2304 1834 1717 1772 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13757 r0 *1 1726.48,1890
X$13757 2305 1709 2304 1901 1717 1877 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13759 r0 *1 1791.44,1910.16
X$13759 2305 1709 2304 2037 1711 1928 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13761 m0 *1 1818.88,1910.16
X$13761 2305 1709 2304 1967 1711 1985 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13764 r0 *1 1848,1900.08
X$13764 2305 1709 2304 1933 1711 1932 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13791 m0 *1 1854.16,1869.84
X$13791 2305 1717 1711 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $13797 r0 *1 1634.08,1879.92
X$13797 1714 2304 1712 1828 2305 1770 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13800 m0 *1 1662.64,1890
X$13800 2305 2304 1831 1712 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $13834 r0 *1 1868.16,1879.92
X$13834 2305 1718 1713 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $13854 r0 *1 1627.36,1879.92
X$13854 1714 2305 1857 1828 2304 1858 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13873 m0 *1 1859.2,1879.92
X$13873 2305 1813 1715 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $13877 m0 *1 1850.8,1900.08
X$13877 2305 2004 2116 1715 1966 1934 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $13897 r0 *1 1816.64,1890
X$13897 2305 1716 2304 1839 1719 1725 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13900 r0 *1 1696.8,1890
X$13900 2305 1876 1716 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $13906 r0 *1 1778,1890
X$13906 2305 1716 2304 1878 1719 1777 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13909 m0 *1 1883.84,1890
X$13909 2305 1716 1832 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $13911 m0 *1 1735.44,1869.84
X$13911 2305 1716 2304 1754 1719 1720 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13914 r0 *1 1752.24,1890
X$13914 2305 1716 2304 1905 1719 1836 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13928 r0 *1 1785.28,1890
X$13928 2305 1718 2304 1900 1717 1777 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13932 r0 *1 1817.76,1869.84
X$13932 2305 1718 2304 1724 1717 1725 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13940 r0 *1 1761.76,1890
X$13940 2305 1718 2304 1904 1717 1836 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13960 m0 *1 1688.96,1900.08
X$13960 2305 1924 1718 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $13991 m0 *1 1703.52,1890
X$13991 2305 1830 2304 1833 1719 1772 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13993 m0 *1 1725.92,1890
X$13993 2305 1830 2304 1902 1719 1877 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13998 r0 *1 1896.16,1890
X$13998 2305 1719 1875 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $14024 r0 *1 1742.72,1960.56
X$14024 2305 2304 2163 2165 1917 1721 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14027 m0 *1 1732.64,1960.56
X$14027 2305 1721 1976 2163 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $14040 m0 *1 1812.72,1890
X$14040 2305 1813 2304 1898 1774 1725 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $14048 m0 *1 1805.44,1930.32
X$14048 2305 2304 2068 2051 2015 1725 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14056 r0 *1 1876,1890
X$14056 2305 1894 1879 1832 1893 1726 2304 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $14073 r0 *1 1877.12,1930.32
X$14073 2305 1727 2019 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $14080 r0 *1 3553.76,1869.84
X$14080 1728 2304 2305 1740 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14094 m0 *1 2129.68,1900.08
X$14094 2305 2304 1881 1950 1946 1729 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14097 r0 *1 2122.96,1890
X$14097 2305 1729 1743 1881 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $14103 r0 *1 3570.56,1869.84
X$14103 1730 2304 2305 1739 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14115 r0 *1 2129.68,1920.24
X$14115 2305 2304 2060 2061 1946 1731 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14118 m0 *1 2123.52,1930.32
X$14118 2305 1731 1743 2060 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $14125 m0 *1 2095.52,1879.92
X$14125 2305 2304 1734 1732 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $14134 m0 *1 3553.76,1879.92
X$14134 1733 2304 2305 1736 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14145 m0 *1 2142.56,1910.16
X$14145 2305 1734 1743 1994 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $14152 r0 *1 3553.76,1879.92
X$14152 1851 2304 2305 1737 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14182 r0 *1 2060.8,1859.76
X$14182 2305 2304 1743 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $14187 r0 *1 2138.64,1879.92
X$14187 2305 1787 1743 1845 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $14236 m0 *1 2.24,1890
X$14236 1808 2304 2305 1756 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14241 m0 *1 38.08,1900.08
X$14241 1853 2304 2305 1758 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14244 m0 *1 33.6,1890
X$14244 1766 2304 2305 1759 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14247 m0 *1 42,1879.92
X$14247 1796 2304 2305 1760 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14250 r0 *1 44.24,1879.92
X$14250 1822 2304 2305 1761 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14253 m0 *1 25.2,1890
X$14253 1848 2304 2305 1762 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14262 r0 *1 48.16,1890
X$14262 1764 2304 2305 1817 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14320 m0 *1 1361.36,1900.08
X$14320 2305 2304 1866 1916 1917 1767 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14334 r0 *1 1599.92,1890
X$14334 2304 1872 1770 2305 1826 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14341 m0 *1 1606.64,1900.08
X$14341 2305 1870 1960 1770 1922 1872 2304 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $14347 m0 *1 1577.52,1879.92
X$14347 2305 2304 1771 1805 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14351 r0 *1 1575.28,1900.08
X$14351 2305 1974 1771 1958 1871 2304 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $14365 r0 *1 1716.4,1920.24
X$14365 2305 1772 1976 2045 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $14370 r0 *1 1720.32,1890
X$14370 2305 2304 1925 1773 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $14400 r0 *1 1755.04,1879.92
X$14400 2305 1813 2304 1815 1774 1836 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $14403 m0 *1 1739.36,1900.08
X$14403 2305 1813 2304 1965 1774 1877 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $14408 m0 *1 1772.4,1890
X$14408 2305 2304 1837 1775 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $14420 m0 *1 1796.48,1890
X$14420 2305 2304 1776 1838 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $14423 m0 *1 1776.32,1930.32
X$14423 2305 2304 2176 1776 2016 2022 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $14428 r0 *1 1774.64,1950.48
X$14428 2305 2304 2109 2110 2036 1776 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14437 m0 *1 1786.96,1930.32
X$14437 2305 2304 2069 2079 2015 1777 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14452 m0 *1 1811.6,1960.56
X$14452 2305 2304 2111 2132 2036 1779 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14455 r0 *1 1811.04,1879.92
X$14455 2305 2304 1779 1814 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $14459 m0 *1 1813.84,1930.32
X$14459 2305 2304 2178 1779 2016 2053 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $14469 m0 *1 1840.72,1960.56
X$14469 2305 2304 2115 2114 1973 1780 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14472 m0 *1 1843.52,1890
X$14472 2305 1830 2304 1896 1875 1780 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $14478 r0 *1 1841.84,1950.48
X$14478 2305 1780 2025 2115 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $14484 m0 *1 1850.8,1890
X$14484 2305 2304 1782 1781 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $14496 r0 *1 1835.68,1930.32
X$14496 2305 2304 2185 1782 2075 2097 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $14499 r0 *1 1847.44,1970.64
X$14499 2305 2304 2143 2144 2106 1782 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14501 m0 *1 1841.84,1970.64
X$14501 2305 1782 2025 2143 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $14510 m0 *1 3562.16,1879.92
X$14510 1785 2304 2305 1791 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14522 r0 *1 2102.24,1879.92
X$14522 2305 2304 1787 1844 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $14531 r0 *1 3530.8,1890
X$14531 1788 2304 2305 1887 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14538 r0 *1 3556,1890
X$14538 1789 2304 2305 1847 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14553 m0 *1 3562.72,1900.08
X$14553 2305 1954 1790 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $14560 m0 *1 3570.56,1879.92
X$14560 1792 2304 2305 1794 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14563 r0 *1 3547.6,1890
X$14563 1885 2304 2305 1793 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14568 m0 *1 3536.96,1890
X$14568 1850 2304 2305 1795 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14600 r0 *1 1569.68,1879.92
X$14600 2305 2304 1803 1855 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14638 r0 *1 1896.16,3553.2
X$14638 1810 2304 2305 2201 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14672 m0 *1 1771.84,1910.16
X$14672 2305 1927 1813 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $14693 m0 *1 42,1890
X$14693 1890 2304 2305 1816 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14700 r0 *1 42,1900.08
X$14700 1903 2304 2305 1818 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14702 r0 *1 52.64,1879.92
X$14702 1829 2304 2305 1819 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14709 m0 *1 10.64,1890
X$14709 2305 1863 1821 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $14725 m0 *1 1610,1890
X$14725 2305 2304 1824 1872 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $14735 m0 *1 1575.28,1890
X$14735 1856 2305 2304 1870 1826 1825 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $14743 r0 *1 1589.28,1900.08
X$14743 1959 2305 2304 1920 1826 2311 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $14754 r0 *1 1676.08,1960.56
X$14754 2305 1828 1976 2105 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $14756 m0 *1 1636.32,1910.16
X$14756 2305 2304 1828 1873 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $14758 r0 *1 1673.84,1930.32
X$14758 2305 2304 2073 1828 2075 2044 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $14761 m0 *1 1680,1950.48
X$14761 2305 2304 2105 2131 2106 1828 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14787 r0 *1 1846.32,1910.16
X$14787 2305 1830 2304 2005 1875 1932 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $14790 r0 *1 1818.32,1910.16
X$14790 2305 1830 2304 2007 1875 1985 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $14793 m0 *1 1788.08,1910.16
X$14793 2305 1830 2304 2008 1875 1928 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $14795 r0 *1 1668.24,1890
X$14795 2305 2304 1876 1830 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $14811 r0 *1 1676.08,1970.64
X$14811 2305 1831 1976 2137 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $14816 m0 *1 1667.68,1930.32
X$14816 2305 2304 2104 1831 2075 2018 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $14818 m0 *1 1685.04,1980.72
X$14818 2305 2304 2137 2138 2106 1831 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14858 m0 *1 1746.64,1900.08
X$14858 2305 2304 1926 1835 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $14870 m0 *1 1753.92,1930.32
X$14870 2305 1836 2025 2048 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $14884 m0 *1 1749.44,1960.56
X$14884 2305 2304 2133 2139 1917 1837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14904 r0 *1 1853.6,3543.12
X$14904 1840 2304 2305 2216 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14909 r0 *1 1921.92,3563.28
X$14909 1841 2304 2305 2249 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14914 m0 *1 3536.96,1900.08
X$14914 1842 2304 2305 1886 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14923 r0 *1 2097.76,1890
X$14923 2305 2304 1948 1949 1946 1843 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14950 m0 *1 3562.16,1890
X$14950 1849 2304 2305 1888 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15005 r0 *1 1584.24,1890
X$15005 1869 2304 1856 1871 2305 1876 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $15014 r0 *1 1627.92,1900.08
X$15014 2305 2304 1857 1922 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $15017 r0 *1 1667.68,1960.56
X$15017 2305 2304 2159 2103 2106 1857 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15020 m0 *1 1668.8,1960.56
X$15020 2305 1857 1976 2159 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15022 r0 *1 1663.2,1930.32
X$15022 2305 2304 2212 1857 2075 2043 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $15034 m0 *1 1856.96,3553.2
X$15034 1859 2304 2305 2217 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15066 r0 *1 16.8,1890
X$15066 2305 1910 1865 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15072 r0 *1 1524.88,1900.08
X$15072 2305 1867 1918 1972 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15084 m0 *1 1588.72,1910.16
X$15084 1869 2304 1959 1871 2305 1927 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $15086 r0 *1 1598.8,1900.08
X$15086 1869 2304 1921 1871 2305 1924 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $15096 m0 *1 1592.64,1900.08
X$15096 2305 2304 1870 1920 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15172 m0 *1 1725.36,1930.32
X$15172 2305 1877 1976 2077 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15186 r0 *1 1886.64,3563.28
X$15186 1879 2304 2305 2296 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15195 r0 *1 3564.4,1890
X$15195 2305 1889 1882 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15199 r0 *1 3552.08,1910.16
X$15199 2305 1998 1883 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15206 m0 *1 3545.36,1900.08
X$15206 1884 2304 2305 1955 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15265 r0 *1 1843.52,3563.28
X$15265 1897 2304 2305 2277 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15300 r0 *1 33.6,1910.16
X$15300 1923 2304 2305 1906 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15303 m0 *1 46.48,1900.08
X$15303 1915 2304 2305 1907 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15305 r0 *1 33.6,1900.08
X$15305 1913 2304 2305 1908 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15309 m0 *1 23.52,1900.08
X$15309 2305 1909 1916 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15314 m0 *1 2.24,1910.16
X$15314 1964 2304 2305 1911 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15317 m0 *1 10.64,1910.16
X$15317 1914 2304 2305 1912 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15347 m0 *1 1715.28,1940.4
X$15347 2305 2304 2090 2076 1917 1925 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15352 r0 *1 1733.76,1960.56
X$15352 2305 2304 2107 2164 1917 1926 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15359 m0 *1 1581.44,1920.24
X$15359 2305 2036 1917 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15384 r0 *1 1592.64,1910.16
X$15384 2305 1918 2323 2304 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $15395 m0 *1 2.24,1930.32
X$15395 2305 2038 1919 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $15440 r0 *1 1698.48,1930.32
X$15440 2305 1925 1976 2090 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15446 r0 *1 1728.16,1950.48
X$15446 2305 1926 1976 2107 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15471 r0 *1 1799.28,1950.48
X$15471 2305 2304 2134 2081 1973 1928 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15478 m0 *1 1823.92,1920.24
X$15478 2305 2304 1929 1984 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $15481 r0 *1 1800.4,1940.4
X$15481 2305 2304 2136 1929 2075 2049 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $15485 m0 *1 1798.72,1970.64
X$15485 2305 2304 2166 2140 2106 1929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15496 r0 *1 1823.36,1930.32
X$15496 2305 2304 2169 1931 2075 2096 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $15498 m0 *1 1827.28,1980.72
X$15498 2305 2304 2168 2141 2106 1931 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15500 m0 *1 1832.32,1920.24
X$15500 2305 2304 1931 1986 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $15502 r0 *1 1828.4,1970.64
X$15502 2305 1931 2025 2168 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15509 m0 *1 1855.84,1940.4
X$15509 2305 2304 2101 2100 1973 1932 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15511 r0 *1 1849.12,1940.4
X$15511 2305 1932 2025 2101 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15524 m0 *1 1865.36,1920.24
X$15524 2305 2304 1987 1934 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $15538 r0 *1 1870.4,1940.4
X$15538 2305 2304 2084 2095 1973 1936 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15540 m0 *1 1868.16,1950.48
X$15540 2305 1936 2025 2084 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15550 r0 *1 1896.16,1910.16
X$15550 2305 2304 1940 1937 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $15556 m0 *1 1883.84,3533.04
X$15556 1938 2304 2305 2206 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15566 m0 *1 1872.08,1940.4
X$15566 2305 2304 2117 1940 2075 2092 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $15568 m0 *1 1865.36,1970.64
X$15568 2305 2304 2147 2162 2106 1940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15582 r0 *1 1902.32,3563.28
X$15582 2305 2252 1942 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $15595 r0 *1 1912.4,3573.36
X$15595 2305 2250 1943 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $15608 r0 *1 1926.96,3573.36
X$15608 2305 2303 1945 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $15625 m0 *1 1905.68,1930.32
X$15625 2305 2015 1946 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15638 r0 *1 3548.16,1900.08
X$15638 2305 1953 1949 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15643 m0 *1 3549.84,1910.16
X$15643 2305 1996 1950 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15648 m0 *1 3554.32,1900.08
X$15648 1956 2304 2305 1951 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15653 r0 *1 3531.92,1900.08
X$15653 1957 2304 2305 1952 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15694 r0 *1 1899.52,3543.12
X$15694 1963 2304 2305 2203 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15726 m0 *1 3.92,1920.24
X$15726 2305 2011 1970 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15731 r0 *1 10.64,1910.16
X$15731 2305 2010 1971 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15754 m0 *1 1824.48,1960.56
X$15754 2305 2304 2130 2112 1973 1985 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15756 m0 *1 1850.8,1920.24
X$15756 2305 2015 1973 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15787 m0 *1 1616.72,1920.24
X$15787 2305 2304 1976 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $15803 r0 *1 1700.72,3573.36
X$15803 2305 2268 1978 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $15816 r0 *1 1715.84,3563.28
X$15816 2305 2272 1979 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $15858 r0 *1 1807.68,1950.48
X$15858 2305 1985 2025 2130 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15873 r0 *1 1846.32,1930.32
X$15873 2305 2304 2098 1987 2075 2099 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $15877 m0 *1 1849.12,1960.56
X$15877 2305 1987 2025 2167 2304 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15880 r0 *1 1860.88,1960.56
X$15880 2305 2304 2167 2145 2106 1987 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15889 m0 *1 3549.84,1930.32
X$15889 2305 2065 1990 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $15894 m0 *1 3564.4,1920.24
X$15894 2305 2029 1991 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $15903 r0 *1 3542.56,1920.24
X$15903 2305 2032 1993 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15911 m0 *1 3549.84,1920.24
X$15911 2305 1997 1995 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15932 r0 *1 1872.64,3543.12
X$15932 2002 2304 2305 2209 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15970 m0 *1 16.8,1930.32
X$15970 2305 2009 2035 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $15977 r0 *1 11.2,1920.24
X$15977 2305 2033 2012 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $15984 r0 *1 2.8,1920.24
X$15984 2013 2304 2305 2039 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16011 m0 *1 1869.84,1930.32
X$16011 2305 2016 2075 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $16018 m0 *1 1649.76,3573.36
X$16018 2305 2258 2017 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16063 r0 *1 1758.96,3573.36
X$16063 2305 2282 2021 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16083 r0 *1 1840.16,3543.12
X$16083 2023 2304 2305 2220 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16107 m0 *1 1862,3573.36
X$16107 2024 2304 2305 2264 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16136 r0 *1 1870.96,1910.16
X$16136 2305 2025 2326 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $16149 r0 *1 3549.84,1930.32
X$16149 2305 2062 2028 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $16156 r0 *1 3566.64,1910.16
X$16156 2305 2029 2031 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $16159 m0 *1 3566.64,1930.32
X$16159 2305 2065 2030 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $16168 r0 *1 3557.12,1920.24
X$16168 2305 2063 2034 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $16193 r0 *1 1681.12,1950.48
X$16193 2305 2036 2106 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $16219 m0 *1 1736,3553.2
X$16219 2046 2304 2305 2276 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16222 m0 *1 1748.88,3553.2
X$16222 2047 2304 2305 2222 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16246 r0 *1 1794.24,3553.2
X$16246 2050 2304 2305 2191 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16253 r0 *1 1818.88,3573.36
X$16253 2305 2302 2051 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16268 r0 *1 1814.4,3543.12
X$16268 2052 2304 2305 2194 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16276 r0 *1 1821.12,3533.04
X$16276 2054 2304 2305 2226 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16285 r0 *1 1882.72,3533.04
X$16285 2056 2304 2305 2205 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16298 r0 *1 1896.16,3573.36
X$16298 2305 2253 2057 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16322 m0 *1 3535.28,1930.32
X$16322 2305 2087 2061 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $16330 m0 *1 3552.08,1940.4
X$16330 2305 2064 2086 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $16337 r0 *1 16.8,1940.4
X$16337 2305 2070 2066 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $16342 r0 *1 11.76,1930.32
X$16342 2305 2071 2067 2304 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $16361 r0 *1 1678.88,3553.2
X$16361 2073 2304 2305 2214 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16363 r0 *1 1666.56,3573.36
X$16363 2305 2234 2074 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16391 r0 *1 1715.28,3573.36
X$16391 2305 2189 2076 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16406 m0 *1 1748.32,3573.36
X$16406 2305 2281 2078 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16420 r0 *1 1779.12,3573.36
X$16420 2305 2243 2079 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16430 m0 *1 1796.48,3553.2
X$16430 2080 2304 2305 2192 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16443 r0 *1 1804.32,3573.36
X$16443 2305 2244 2081 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16461 r0 *1 1803.2,3553.2
X$16461 2082 2304 2305 2231 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16472 r0 *1 1803.2,3543.12
X$16472 2083 2304 2305 2193 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16501 m0 *1 1891.12,3553.2
X$16501 2085 2304 2305 2204 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16528 m0 *1 1693.44,3563.28
X$16528 2089 2304 2305 2237 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16540 r0 *1 1729.84,3573.36
X$16540 2305 2301 2091 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16559 r0 *1 1870.4,3563.28
X$16559 2305 2199 2095 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16581 m0 *1 1859.2,3563.28
X$16581 2098 2304 2305 2266 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16593 m0 *1 1844.64,3563.28
X$16593 2305 2213 2100 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16600 r0 *1 1647.52,3573.36
X$16600 2305 2299 2102 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16604 m0 *1 1665.44,3563.28
X$16604 2305 2259 2103 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16617 r0 *1 1668.8,3553.2
X$16617 2104 2304 2305 2188 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16651 r0 *1 1740.48,3553.2
X$16651 2108 2304 2305 2221 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16655 m0 *1 1770.72,3573.36
X$16655 2305 2228 2110 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16662 m0 *1 1827.28,3573.36
X$16662 2305 2223 2112 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16674 m0 *1 1827.84,3543.12
X$16674 2113 2304 2305 2184 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16682 r0 *1 1859.2,3573.36
X$16682 2305 2267 2114 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16701 m0 *1 1855.84,3543.12
X$16701 2116 2304 2305 2215 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16708 r0 *1 1882.72,3553.2
X$16708 2117 2304 2305 2257 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16712 m0 *1 3556,1960.56
X$16712 2119 2123 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16714 m0 *1 3553.2,1960.56
X$16714 2305 2304 2119 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16716 m0 *1 3563.28,1950.48
X$16716 2305 2304 2120 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16718 m0 *1 3565.52,1950.48
X$16718 2120 2127 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16720 r0 *1 3563.28,1950.48
X$16720 2305 2304 2121 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16722 r0 *1 3565.52,1950.48
X$16722 2121 2124 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16724 m0 *1 3569.44,1960.56
X$16724 2122 2126 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16726 m0 *1 3567.2,1960.56
X$16726 2305 2304 2122 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16733 m0 *1 3564.96,1970.64
X$16733 2149 2125 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16740 r0 *1 3565.52,1960.56
X$16740 2150 2128 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16744 r0 *1 1877.68,3573.36
X$16744 2305 2180 2129 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16752 r0 *1 1681.12,3573.36
X$16752 2305 2300 2131 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16758 m0 *1 1812.72,3573.36
X$16758 2305 2285 2132 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16773 m0 *1 1785.28,3553.2
X$16773 2135 2304 2305 2190 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16781 m0 *1 1785.84,3573.36
X$16781 2136 2304 2305 2289 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16785 m0 *1 1678.32,3573.36
X$16785 2305 2263 2138 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16788 r0 *1 1744.4,3573.36
X$16788 2305 2240 2139 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16793 r0 *1 1804.32,3563.28
X$16793 2305 2290 2140 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16809 r0 *1 1844.64,3573.36
X$16809 2305 2197 2141 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16829 m0 *1 1826.72,3553.2
X$16829 2142 2304 2305 2225 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16836 m0 *1 1844.64,3573.36
X$16836 2305 2218 2144 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16841 r0 *1 1854.72,3563.28
X$16841 2305 2181 2145 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16855 r0 *1 1864.24,3543.12
X$16855 2146 2304 2305 2198 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16870 r0 *1 3556,1980.72
X$16870 2305 2304 2148 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16872 m0 *1 3555.44,1980.72
X$16872 2148 2155 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16875 m0 *1 3562.72,1970.64
X$16875 2305 2304 2149 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16878 r0 *1 3563.28,1960.56
X$16878 2305 2304 2150 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16880 m0 *1 3569.44,1980.72
X$16880 2151 2157 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16882 m0 *1 3567.2,1980.72
X$16882 2305 2304 2151 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16885 m0 *1 3556,1990.8
X$16885 2172 2152 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16888 m0 *1 3565.52,1990.8
X$16888 2174 2153 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16891 r0 *1 3569.44,1980.72
X$16891 2173 2154 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16895 r0 *1 3569.44,1970.64
X$16895 2158 2156 2304 2305 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $16903 r0 *1 3564.4,1970.64
X$16903 2305 2304 2158 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16915 m0 *1 1698.48,3573.36
X$16915 2305 2265 2161 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16921 m0 *1 1897.28,3573.36
X$16921 2305 2248 2162 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16931 m0 *1 1733.76,3573.36
X$16931 2305 2273 2164 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16936 r0 *1 1747.76,3563.28
X$16936 2305 2275 2165 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $16955 m0 *1 1804.88,3553.2
X$16955 2169 2304 2305 2230 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16959 m0 *1 1713.04,3573.36
X$16959 2170 2304 2305 2295 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16964 m0 *1 3553.76,1990.8
X$16964 2305 2304 2172 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16969 r0 *1 3565.52,1980.72
X$16969 2305 2304 2173 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16972 r0 *1 3566.08,1990.8
X$16972 2305 2304 2174 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $16976 m0 *1 1870.4,3563.28
X$16976 2305 2207 2175 2304 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $17002 m0 *1 1776.88,3553.2
X$17002 2176 2304 2305 2227 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $17011 m0 *1 1814.4,3553.2
X$17011 2177 2304 2305 2229 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $17018 m0 *1 1813.28,3543.12
X$17018 2178 2304 2305 2232 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $17031 m0 *1 1918,3553.2
X$17031 2179 2304 2305 2200 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $17045 m0 *1 1883.84,3543.12
X$17045 2305 2180 2208 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17049 m0 *1 1870.4,3543.12
X$17049 2305 2181 2182 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17059 r0 *1 1841.28,3533.04
X$17059 2183 2304 2305 2186 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $17067 m0 *1 1844.64,3543.12
X$17067 2185 2304 2305 2187 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $17081 r0 *1 1720.32,3553.2
X$17081 2305 2189 2270 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17102 r0 *1 1827.84,3553.2
X$17102 2305 2223 2195 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17106 r0 *1 1827.84,3543.12
X$17106 2305 2197 2196 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17118 m0 *1 1899.52,3553.2
X$17118 2305 2199 2202 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17143 m0 *1 1872.64,3553.2
X$17143 2305 2207 2211 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17154 r0 *1 1870.4,3553.2
X$17154 2305 2210 2247 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17163 m0 *1 1670.48,3553.2
X$17163 2212 2304 2305 2261 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $17167 r0 *1 1856.96,3553.2
X$17167 2305 2213 2271 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17183 m0 *1 1844.64,3553.2
X$17183 2305 2218 2219 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17207 r0 *1 1775.2,3553.2
X$17207 2305 2228 2224 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17240 r0 *1 1652,3563.28
X$17240 2305 2258 2233 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17245 r0 *1 1668.8,3563.28
X$17245 2305 2234 2260 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17249 r0 *1 1681.12,3563.28
X$17249 2305 2300 2235 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17253 m0 *1 1701.84,3563.28
X$17253 2305 2265 2236 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17260 r0 *1 1703.52,3563.28
X$17260 2305 2268 2238 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17264 m0 *1 1722,3563.28
X$17264 2305 2272 2239 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17269 r0 *1 1751.12,3553.2
X$17269 2305 2240 2280 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17273 m0 *1 1750,3563.28
X$17273 2305 2281 2241 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17277 m0 *1 1762.32,3563.28
X$17277 2305 2282 2242 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17280 r0 *1 1769.6,3563.28
X$17280 2305 2243 2284 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17283 m0 *1 1781.92,3563.28
X$17283 2305 2244 2288 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17289 r0 *1 1811.6,3553.2
X$17289 2305 2302 2245 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17293 m0 *1 1829.52,3563.28
X$17293 2283 2304 2305 2246 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $17301 m0 *1 1897.28,3563.28
X$17301 2305 2248 2256 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17308 m0 *1 1918,3573.36
X$17308 2305 2250 2297 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17315 m0 *1 1919.12,3563.28
X$17315 2305 2252 2254 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17322 r0 *1 1904.56,3553.2
X$17322 2305 2253 2255 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17347 m0 *1 1666,3573.36
X$17347 2305 2259 2294 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17356 m0 *1 1680,3563.28
X$17356 2305 2263 2262 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17376 r0 *1 1844.64,3553.2
X$17376 2305 2267 2279 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17384 m0 *1 1721.44,3573.36
X$17384 2305 2301 2269 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17398 m0 *1 1737.68,3563.28
X$17398 2305 2273 2278 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17403 r0 *1 1735.44,3563.28
X$17403 2305 2275 2274 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17441 r0 *1 1831.2,3563.28
X$17441 2305 2285 2286 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17449 r0 *1 1781.92,3563.28
X$17449 2305 2290 2287 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17464 r0 *1 1818.88,3563.28
X$17464 2305 2291 2292 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17473 r0 *1 1635.2,3573.36
X$17473 2305 2299 2293 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $17489 m0 *1 1930.32,3573.36
X$17489 2305 2303 2298 2304 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
.ENDS mesh_router

* cell gf180mcu_fd_sc_mcu9t5v0__mux4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin S1
* pin I0
* pin I2
* pin S0
* pin I3
* pin I1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux4_2 1 6 7 11 12 13 14 16 18
* net 1 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* net 7 S1
* net 11 I0
* net 12 I2
* net 13 S0
* net 14 I3
* net 16 I1
* net 18 NWELL,VDD
* device instance $1 r0 *1 0.97,3.62 pmos_5p0
M$1 3 12 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.6848P AD=0.5504P PS=3.63U PD=2.14U
* device instance $2 r0 *1 2.33,3.62 pmos_5p0
M$2 4 13 3 18 pmos_5p0 L=0.5U W=1.28U AS=0.5504P AD=0.4544P PS=2.14U PD=1.99U
* device instance $3 r0 *1 3.54,3.62 pmos_5p0
M$3 5 17 4 18 pmos_5p0 L=0.5U W=1.28U AS=0.4544P AD=0.4032P PS=1.99U PD=1.91U
* device instance $4 r0 *1 4.67,3.62 pmos_5p0
M$4 18 14 5 18 pmos_5p0 L=0.5U W=1.28U AS=0.4032P AD=0.6432P PS=1.91U PD=2.4U
* device instance $5 r0 *1 6.13,3.62 pmos_5p0
M$5 6 2 18 18 pmos_5p0 L=0.5U W=2.56U AS=0.976P AD=0.896P PS=4.2U PD=5.24U
* device instance $7 r0 *1 9.555,3.62 pmos_5p0
M$7 2 15 4 18 pmos_5p0 L=0.5U W=1.28U AS=0.7616P AD=0.4672P PS=3.75U PD=2.01U
* device instance $8 r0 *1 10.785,3.62 pmos_5p0
M$8 8 7 2 18 pmos_5p0 L=0.5U W=1.28U AS=0.4672P AD=0.5632P PS=2.01U PD=3.44U
* device instance $9 r0 *1 12.605,3.62 pmos_5p0
M$9 18 7 15 18 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3712P PS=3.44U PD=1.86U
* device instance $10 r0 *1 13.685,3.62 pmos_5p0
M$10 9 16 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.3712P AD=0.3776P PS=1.86U PD=1.87U
* device instance $11 r0 *1 14.775,3.62 pmos_5p0
M$11 8 17 9 18 pmos_5p0 L=0.5U W=1.28U AS=0.3776P AD=0.3328P PS=1.87U PD=1.8U
* device instance $12 r0 *1 15.795,3.62 pmos_5p0
M$12 10 13 8 18 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.416P PS=1.8U PD=1.93U
* device instance $13 r0 *1 16.945,3.62 pmos_5p0
M$13 18 11 10 18 pmos_5p0 L=0.5U W=1.28U AS=0.416P AD=0.3968P PS=1.93U PD=1.9U
* device instance $14 r0 *1 18.065,3.62 pmos_5p0
M$14 17 13 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.3968P AD=0.5632P PS=1.9U PD=3.44U
* device instance $15 r0 *1 12.515,1.18 nmos_5p0
M$15 1 7 15 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.208P PS=2.48U PD=1.32U
* device instance $16 r0 *1 13.635,1.18 nmos_5p0
M$16 9 16 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $17 r0 *1 14.755,1.18 nmos_5p0
M$17 8 13 9 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $18 r0 *1 15.875,1.18 nmos_5p0
M$18 10 17 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $19 r0 *1 16.995,1.18 nmos_5p0
M$19 1 11 10 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $20 r0 *1 18.115,1.18 nmos_5p0
M$20 17 13 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
* device instance $21 r0 *1 0.92,1.18 nmos_5p0
M$21 3 12 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.48P PS=2.48U PD=2U
* device instance $22 r0 *1 2.72,1.18 nmos_5p0
M$22 4 17 3 1 nmos_5p0 L=0.6U W=0.8U AS=0.48P AD=0.208P PS=2U PD=1.32U
* device instance $23 r0 *1 3.84,1.18 nmos_5p0
M$23 5 13 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $24 r0 *1 4.96,1.18 nmos_5p0
M$24 1 14 5 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $25 r0 *1 6.08,1.18 nmos_5p0
M$25 6 2 1 1 nmos_5p0 L=0.6U W=1.6U AS=0.416P AD=0.56P PS=2.64U PD=3.8U
* device instance $27 r0 *1 9.555,1.18 nmos_5p0
M$27 2 7 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.544P AD=0.208P PS=2.96U PD=1.32U
* device instance $28 r0 *1 10.675,1.18 nmos_5p0
M$28 8 15 2 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux4_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_16 1 2 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7031P PS=21.69U PD=19.78U
* device instance $9 r0 *1 10.01,3.78 pmos_5p0
M$9 4 3 5 5 pmos_5p0 L=0.5U W=29.28U AS=9.2415P AD=9.3147P PS=39.38U PD=41.29U
* device instance $25 r0 *1 0.92,1.3 nmos_5p0
M$25 3 2 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.7295P AD=1.5184P PS=11.34U PD=10U
* device instance $33 r0 *1 10.06,1.265 nmos_5p0
M$33 4 3 1 1 nmos_5p0 L=0.6U W=12.8U AS=3.3895P AD=3.472P PS=21.3U PD=22.28U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_12 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=21.96U AS=7.0455P AD=7.0455P PS=31.49U PD=31.49U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=8.76U AS=2.409P AD=2.409P PS=16.09U PD=16.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_12

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 A3
* device instance $1 r0 *1 0.92,3.872 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.93765P PS=6.72U PD=4.43U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 11 5 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 4 6 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 6 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 9 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 7 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $11 r0 *1 3.16,1.005 nmos_5p0
M$11 4 7 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2342P PS=3.68U PD=5.83U
* device instance $12 r0 *1 4.28,1.005 nmos_5p0
M$12 8 5 4 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 4 6 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A3
* pin ZN
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_4 1 2 4 5 11 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A3
* net 5 ZN
* net 11 A2
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.87,3.965 pmos_5p0
M$1 5 11 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.8542P AD=1.5914P PS=9.84U PD=8.02U
* device instance $2 r0 *1 1.89,3.965 pmos_5p0
M$2 12 4 5 12 pmos_5p0 L=0.5U W=5.84U AS=1.6644P AD=1.6644P PS=8.12U PD=8.12U
* device instance $9 r0 *1 9.33,3.965 pmos_5p0
M$9 5 2 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.7374P AD=2.0002P PS=8.22U PD=10.04U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 6 11 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2772P PS=3.52U PD=1.74U
* device instance $14 r0 *1 1.94,1.005 nmos_5p0
M$14 1 4 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $15 r0 *1 3.06,1.005 nmos_5p0
M$15 7 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2772P PS=1.84U PD=1.74U
* device instance $16 r0 *1 4.08,1.005 nmos_5p0
M$16 3 11 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $17 r0 *1 5.2,1.005 nmos_5p0
M$17 9 11 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2772P PS=1.84U PD=1.74U
* device instance $18 r0 *1 6.22,1.005 nmos_5p0
M$18 1 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $19 r0 *1 7.34,1.005 nmos_5p0
M$19 8 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2772P PS=1.84U PD=1.74U
* device instance $20 r0 *1 8.36,1.005 nmos_5p0
M$20 10 11 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $21 r0 *1 9.38,1.005 nmos_5p0
M$21 5 2 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $22 r0 *1 10.5,1.005 nmos_5p0
M$22 3 2 5 1 nmos_5p0 L=0.6U W=3.96U AS=1.0296P AD=1.2672P PS=5.52U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_4
* pin A2
* pin NWELL,VDD
* pin A3
* pin ZN
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_4 1 2 3 4 5 6
* net 1 A2
* net 2 NWELL,VDD
* net 3 A3
* net 4 ZN
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 12 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 2 3 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 11 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 7 1 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 9 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 3 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.59,3.78 pmos_5p0
M$7 8 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 10 1 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 9.83,3.78 pmos_5p0
M$9 4 6 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 10.95,3.78 pmos_5p0
M$10 7 6 4 2 pmos_5p0 L=0.5U W=5.49U AS=1.7019P AD=1.9398P PS=7.35U PD=9.44U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 4 1 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.9638P AD=0.8216P PS=6.39U PD=5.24U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 5 3 4 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.8216P PS=5.24U PD=5.24U
* device instance $21 r0 *1 9.88,0.74 nmos_5p0
M$21 4 6 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.9638P PS=5.24U PD=6.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.4038P PS=16.79U PD=14.7U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.8076P AD=7.0455P PS=29.4U PD=31.49U
* device instance $19 r0 *1 0.97,1.005 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=7.92U AS=2.2968P AD=2.0592P PS=12.72U PD=11.04U
* device instance $25 r0 *1 7.69,1.005 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=15.84U AS=4.1184P AD=4.356P PS=22.08U PD=23.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_12

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_2
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_2 1 2 3 4 5 6
* net 1 ZN
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A1
* net 6 A3
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 6 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 9 4 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 1 5 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 8 5 1 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 4 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 6 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 3 6 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.553P PS=3.77U PD=3.77U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 1 4 3 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 3 5 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__or2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 2 4 4 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 6 3 8 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 7 3 6 4 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 4 2 7 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.7869P PS=2.4U PD=2.69U
* device instance $5 r0 *1 5.59,3.78 pmos_5p0
M$5 5 6 4 4 pmos_5p0 L=0.5U W=7.32U AS=2.3973P AD=2.4156P PS=9.94U PD=11.79U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 6 2 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7788P PS=5.36U PD=3.82U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 1 3 6 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.54,1.005 nmos_5p0
M$13 5 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4652P AD=1.6104P PS=7.5U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A2
* pin A1
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A2
* net 4 A1
* net 5 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.61305P PS=4.54U PD=2.5U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 5 4 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 3 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 5 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 6 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 2 3 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $9 r0 *1 0.92,1.04 nmos_5p0
M$9 5 3 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1224P AD=1.1224P PS=7.04U PD=7.04U
* device instance $10 r0 *1 2.04,1.04 nmos_5p0
M$10 1 4 5 1 nmos_5p0 L=0.6U W=3.68U AS=0.9568P AD=0.9568P PS=5.76U PD=5.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__addh_4
* pin PWELL,VSS,gf180mcu_gnd
* pin S
* pin A
* pin B
* pin CO
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_4 1 4 5 6 8 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 4 S
* net 5 A
* net 6 B
* net 8 CO
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 2 5 11 11 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.16205P PS=6.89U PD=4.93U
* device instance $2 r0 *1 1.94,3.78 pmos_5p0
M$2 11 6 2 11 pmos_5p0 L=0.5U W=3.66U AS=0.99735P AD=0.99735P PS=4.75U PD=4.75U
* device instance $5 r0 *1 5.28,3.78 pmos_5p0
M$5 7 2 11 11 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.25355P PS=5.03U PD=5.03U
* device instance $6 r0 *1 6.35,3.78 pmos_5p0
M$6 12 5 7 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 7.52,3.78 pmos_5p0
M$7 11 6 12 11 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.5673P PS=2.5U PD=2.45U
* device instance $8 r0 *1 8.64,3.78 pmos_5p0
M$8 13 6 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 9.76,3.78 pmos_5p0
M$9 7 5 13 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 12.18,3.78 pmos_5p0
M$11 8 2 11 11 pmos_5p0 L=0.5U W=7.32U AS=2.38815P AD=2.22345P PS=9.93U PD=9.75U
* device instance $15 r0 *1 16.61,3.78 pmos_5p0
M$15 4 7 11 11 pmos_5p0 L=0.5U W=7.32U AS=2.24175P AD=2.47965P PS=9.77U
+ PD=11.86U
* device instance $19 r0 *1 0.92,1 nmos_5p0
M$19 9 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2772P PS=3.52U PD=1.74U
* device instance $20 r0 *1 1.94,1 nmos_5p0
M$20 2 6 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $21 r0 *1 3.06,1 nmos_5p0
M$21 10 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 3.98,1 nmos_5p0
M$22 1 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.396P PS=1.64U PD=2.02U
* device instance $23 r0 *1 5.28,1.22 nmos_5p0
M$23 3 2 1 1 nmos_5p0 L=0.6U W=1.76U AS=0.792P AD=0.4576P PS=4.04U PD=2.8U
* device instance $24 r0 *1 6.4,1.22 nmos_5p0
M$24 7 5 3 1 nmos_5p0 L=0.6U W=1.76U AS=0.4576P AD=0.4576P PS=2.8U PD=2.8U
* device instance $25 r0 *1 7.52,1.22 nmos_5p0
M$25 3 6 7 1 nmos_5p0 L=0.6U W=1.76U AS=0.4576P AD=0.4576P PS=2.8U PD=2.8U
* device instance $29 r0 *1 12.18,1 nmos_5p0
M$29 8 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4256P AD=1.3728P PS=7.54U PD=7.36U
* device instance $33 r0 *1 16.66,1 nmos_5p0
M$33 4 7 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_4

* cell gf180mcu_fd_sc_mcu9t5v0__inv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.7385P PS=7.02U PD=7.39U
* device instance $3 r0 *1 0.92,1.005 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.9438P AD=0.9438P PS=5.39U PD=5.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=3.96U AS=1.2672P AD=1.2672P PS=7.2U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_3

* cell gf180mcu_fd_sc_mcu9t5v0__and2_4
* pin NWELL,VDD
* pin A2
* pin A1
* pin Z
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_4 1 2 3 5 6
* net 1 NWELL,VDD
* net 2 A2
* net 3 A1
* net 5 Z
* net 6 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.875 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.28U AS=1.3336P AD=0.8528P PS=6.69U PD=4.32U
* device instance $2 r0 *1 1.89,3.875 pmos_5p0
M$2 1 3 4 1 pmos_5p0 L=0.5U W=3.28U AS=0.8528P AD=0.8528P PS=4.32U PD=4.32U
* device instance $5 r0 *1 5.13,3.78 pmos_5p0
M$5 5 4 1 1 pmos_5p0 L=0.5U W=7.32U AS=2.0394P AD=2.2326P PS=9.58U PD=11.59U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 8 2 6 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 3 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 7 3 4 6 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 6 2 7 6 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 5 4 6 6 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_4

* cell gf180mcu_fd_sc_mcu9t5v0__inv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_4 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_4 1 2 3 4 5
* net 1 NWELL,VDD
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 ZN
* net 5 A1
* device instance $1 r0 *1 0.87,3.687 pmos_5p0
M$1 4 3 1 1 pmos_5p0 L=0.5U W=6.58U AS=2.0069P AD=2.0069P PS=10.665U PD=10.665U
* device instance $2 r0 *1 1.89,3.687 pmos_5p0
M$2 1 5 4 1 pmos_5p0 L=0.5U W=6.58U AS=1.7108P AD=1.7108P PS=8.66U PD=8.66U
* device instance $9 r0 *1 1,1.005 nmos_5p0
M$9 9 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 5 9 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3729P PS=1.56U PD=1.885U
* device instance $11 r0 *1 3.005,1.005 nmos_5p0
M$11 8 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3729P AD=0.1584P PS=1.885U PD=1.56U
* device instance $12 r0 *1 3.845,1.005 nmos_5p0
M$12 2 3 8 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3663P PS=1.56U PD=1.875U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 7 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.2112P PS=1.875U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 4 5 7 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 6 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 2 3 6 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_4

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 4 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 10 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 7 5 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 9 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 4 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 11 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 7 5 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6292P PS=2.4U PD=2.55U
* device instance $9 r0 *1 9.93,3.872 pmos_5p0
M$9 4 2 7 7 pmos_5p0 L=0.5U W=6.58U AS=2.117925P AD=2.212525P PS=9.295U
+ PD=10.915U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 4 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 2.04,1.005 nmos_5p0
M$14 3 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $21 r0 *1 9.88,1.005 nmos_5p0
M$21 1 2 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_2
* pin NWELL,VDD
* pin B2
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B2
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.4758P PS=4.54U PD=2.35U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 6 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $5 r0 *1 5.45,3.78 pmos_5p0
M$5 11 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 6 7 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 10 7 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 6 5 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $14 r0 *1 6.52,1.005 nmos_5p0
M$14 8 7 6 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin A4
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 A4
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 6 7 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.896P PS=5.24U PD=5.24U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 2 3 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.91,4.055 pmos_5p0
M$3 6 4 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.93,4.055 pmos_5p0
M$4 2 5 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 13 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2442P PS=3.52U PD=1.69U
* device instance $10 r0 *1 1.89,1.005 nmos_5p0
M$10 12 3 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2442P PS=1.69U PD=1.69U
* device instance $11 r0 *1 2.86,1.005 nmos_5p0
M$11 11 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 2 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 9 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $14 r0 *1 5.97,1.005 nmos_5p0
M$14 8 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $15 r0 *1 6.99,1.005 nmos_5p0
M$15 10 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.5808P PS=1.69U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_2

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_2 1 2 3 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 NWELL,VDD
* net 5 A2
* net 6 A3
* device instance $1 r0 *1 0.87,3.85 pmos_5p0
M$1 2 6 4 4 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.022P PS=5.78U PD=5.78U
* device instance $2 r0 *1 1.89,3.85 pmos_5p0
M$2 4 5 2 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.85 pmos_5p0
M$3 2 3 4 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 1.06,1 nmos_5p0
M$7 10 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1848P PS=3.52U PD=1.6U
* device instance $8 r0 *1 1.94,1 nmos_5p0
M$8 9 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1848P AD=0.2112P PS=1.6U PD=1.64U
* device instance $9 r0 *1 2.86,1 nmos_5p0
M$9 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $10 r0 *1 3.98,1 nmos_5p0
M$10 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $11 r0 *1 4.9,1 nmos_5p0
M$11 7 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $12 r0 *1 5.92,1 nmos_5p0
M$12 1 6 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.5808P PS=1.74U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_4 1 3 4 5 6 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 RN
* net 4 Q
* net 5 CLK
* net 6 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 16.975,3.78 pmos_5p0
M$1 4 13 17 17 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U PD=11.59U
* device instance $5 r0 *1 9.55,3.71 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.285P PS=2.88U PD=1.57U
* device instance $6 r0 *1 10.62,3.71 pmos_5p0
M$6 11 2 10 17 pmos_5p0 L=0.5U W=1U AS=0.285P AD=0.26P PS=1.57U PD=1.52U
* device instance $7 r0 *1 11.64,3.71 pmos_5p0
M$7 12 8 11 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2875P PS=1.52U PD=1.575U
* device instance $8 r0 *1 12.715,3.71 pmos_5p0
M$8 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.5457P AD=0.2875P PS=2.57U PD=1.575U
* device instance $9 r0 *1 13.955,3.78 pmos_5p0
M$9 13 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5457P AD=0.4758P PS=2.57U PD=2.35U
* device instance $10 r0 *1 14.975,3.78 pmos_5p0
M$10 17 11 13 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $11 r0 *1 3.73,3.41 pmos_5p0
M$11 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $12 r0 *1 4.75,3.41 pmos_5p0
M$12 9 8 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 5.77,3.41 pmos_5p0
M$13 18 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $14 r0 *1 6.79,3.41 pmos_5p0
M$14 17 10 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $15 r0 *1 7.81,3.41 pmos_5p0
M$15 18 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $16 r0 *1 0.97,3.555 pmos_5p0
M$16 17 5 2 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $17 r0 *1 1.99,3.555 pmos_5p0
M$17 8 2 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $18 r0 *1 16.925,1.005 nmos_5p0
M$18 4 13 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $22 r0 *1 3.9,1.315 nmos_5p0
M$22 7 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $23 r0 *1 5.02,1.315 nmos_5p0
M$23 9 2 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $24 r0 *1 6.14,1.315 nmos_5p0
M$24 15 8 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0708P PS=1.11U PD=0.83U
* device instance $25 r0 *1 6.98,1.315 nmos_5p0
M$25 14 10 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.0826P PS=0.83U PD=0.87U
* device instance $26 r0 *1 7.86,1.315 nmos_5p0
M$26 1 3 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.0826P AD=0.2124P PS=0.87U PD=1.31U
* device instance $27 r0 *1 9.18,1.315 nmos_5p0
M$27 10 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2124P AD=0.190275P PS=1.31U PD=1.235U
* device instance $28 r0 *1 10.425,1.315 nmos_5p0
M$28 11 8 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.190275P AD=0.1534P PS=1.235U
+ PD=1.11U
* device instance $29 r0 *1 11.545,1.315 nmos_5p0
M$29 12 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $30 r0 *1 12.665,1.315 nmos_5p0
M$30 1 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 13.785,1.315 nmos_5p0
M$31 1 3 16 1 nmos_5p0 L=0.6U W=0.59U AS=0.3525P AD=0.1534P PS=2.02U PD=1.11U
* device instance $32 r0 *1 15.085,1.005 nmos_5p0
M$32 13 11 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3525P AD=0.5808P PS=2.02U PD=3.52U
* device instance $33 r0 *1 0.92,1.27 nmos_5p0
M$33 1 5 2 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $34 r0 *1 2.04,1.27 nmos_5p0
M$34 8 2 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin A2
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_4 1 2 3 4 5 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 A2
* net 5 B
* net 11 NWELL,VDD
* device instance $1 r0 *1 1.07,3.785 pmos_5p0
M$1 2 4 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1594P PS=11.59U PD=9.68U
* device instance $2 r0 *1 2.09,3.785 pmos_5p0
M$2 10 3 2 11 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.51,3.785 pmos_5p0
M$9 11 5 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $13 r0 *1 1.14,1 nmos_5p0
M$13 7 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $14 r0 *1 1.98,1 nmos_5p0
M$14 2 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $15 r0 *1 3.1,1 nmos_5p0
M$15 6 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $16 r0 *1 3.94,1 nmos_5p0
M$16 1 4 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 5.06,1 nmos_5p0
M$17 8 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $18 r0 *1 5.9,1 nmos_5p0
M$18 2 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $19 r0 *1 7.02,1 nmos_5p0
M$19 9 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $20 r0 *1 7.86,1 nmos_5p0
M$20 1 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.402P PS=1.56U PD=2.02U
* device instance $21 r0 *1 9.16,1.2 nmos_5p0
M$21 2 5 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1196P AD=1.1224P PS=6.34U PD=7.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_3 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.552 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=2.75U AS=1.03125P AD=0.97625P PS=5.625U PD=4.17U
* device instance $3 r0 *1 3.29,3.552 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=5.5U AS=1.82875P AD=1.88375P PS=8.16U PD=9.615U
* device instance $7 r0 *1 0.92,1.34 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.1U AS=0.385P AD=0.3455P PS=3.05U PD=2.37U
* device instance $9 r0 *1 3.34,1.365 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=2.4U AS=0.6705P AD=0.732P PS=4.66U PD=5.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3

* cell gf180mcu_fd_sc_mcu9t5v0__or3_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 2 6 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 4 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 3 5 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 9 5 3 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 6 2 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8235P PS=2.4U PD=2.73U
* device instance $7 r0 *1 7.87,3.78 pmos_5p0
M$7 7 3 6 6 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.4156P PS=9.98U PD=11.79U
* device instance $11 r0 *1 0.92,0.87 nmos_5p0
M$11 3 2 1 1 nmos_5p0 L=0.6U W=2.1U AS=0.735P AD=0.6945P PS=4.55U PD=3.59U
* device instance $12 r0 *1 2.04,0.87 nmos_5p0
M$12 1 4 3 1 nmos_5p0 L=0.6U W=2.1U AS=0.546P AD=0.546P PS=3.14U PD=3.14U
* device instance $13 r0 *1 3.16,0.87 nmos_5p0
M$13 3 5 1 1 nmos_5p0 L=0.6U W=2.1U AS=0.546P AD=0.546P PS=3.14U PD=3.14U
* device instance $17 r0 *1 7.82,1.005 nmos_5p0
M$17 7 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4511P AD=1.6104P PS=7.54U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_16 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=29.28U AS=9.3147P AD=9.3147P PS=41.29U PD=41.29U
* device instance $17 r0 *1 0.92,1.3 nmos_5p0
M$17 3 2 1 1 nmos_5p0 L=0.6U W=11.68U AS=3.1682P AD=3.1682P PS=21.09U PD=21.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_16

* cell gf180mcu_fd_sc_mcu9t5v0__or4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_4 1 3 4 5 6 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 Z
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 4 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 5 11 8 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 6 10 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 7 9 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 12 7 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 13 6 12 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 14 5 13 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 8 4 14 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.77775P PS=2.45U PD=2.68U
* device instance $9 r0 *1 10.11,3.78 pmos_5p0
M$9 3 2 8 8 pmos_5p0 L=0.5U W=7.32U AS=2.38815P AD=2.4156P PS=9.93U PD=11.79U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 2 4 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.5879P PS=3.77U PD=3.33U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 1 5 2 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $15 r0 *1 3.16,0.74 nmos_5p0
M$15 2 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $16 r0 *1 4.28,0.74 nmos_5p0
M$16 1 7 2 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $21 r0 *1 10.06,1.005 nmos_5p0
M$21 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4121P AD=1.6104P PS=7.54U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_4

* cell gf180mcu_fd_sc_mcu9t5v0__and3_4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_4 1 2 3 4 5 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS,gf180mcu_gnd
* net 5 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.87,3.595 pmos_5p0
M$1 6 1 5 5 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.0012P PS=5.78U PD=4.55U
* device instance $2 r0 *1 1.89,3.595 pmos_5p0
M$2 5 2 6 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.595 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 7 6 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.049P AD=2.2326P PS=9.62U PD=11.59U
* device instance $11 r0 *1 1,1.005 nmos_5p0
M$11 11 1 4 4 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $12 r0 *1 1.84,1.005 nmos_5p0
M$12 10 2 11 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.2772P PS=1.56U PD=1.74U
* device instance $13 r0 *1 2.86,1.005 nmos_5p0
M$13 6 3 10 4 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $14 r0 *1 3.98,1.005 nmos_5p0
M$14 9 3 6 4 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $15 r0 *1 4.9,1.005 nmos_5p0
M$15 8 2 9 4 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.1584P PS=1.64U PD=1.56U
* device instance $16 r0 *1 5.74,1.005 nmos_5p0
M$16 4 1 8 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 6.86,1.005 nmos_5p0
M$17 7 6 4 4 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_4

* cell gf180mcu_fd_sc_mcu9t5v0__addh_1
* pin CO
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A
* pin B
* pin S
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_1 1 2 3 4 5 9
* net 1 CO
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 NWELL,VDD
* net 4 A
* net 5 B
* net 9 S
* device instance $1 r0 *1 5.01,3.912 pmos_5p0
M$1 11 5 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 6.03,3.912 pmos_5p0
M$2 8 4 11 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.3294P PS=1.435U PD=1.635U
* device instance $3 r0 *1 7.25,3.912 pmos_5p0
M$3 8 6 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.50325P AD=0.3294P PS=2.53U PD=1.635U
* device instance $4 r0 *1 8.45,3.78 pmos_5p0
M$4 9 8 3 3 pmos_5p0 L=0.5U W=1.83U AS=0.50325P AD=0.8052P PS=2.53U PD=4.54U
* device instance $5 r0 *1 2.23,3.912 pmos_5p0
M$5 6 4 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.5307P AD=0.2379P PS=2.59U PD=1.435U
* device instance $6 r0 *1 3.25,3.912 pmos_5p0
M$6 3 5 6 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.4026P PS=1.435U PD=2.71U
* device instance $7 r0 *1 0.97,3.78 pmos_5p0
M$7 3 6 1 3 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5307P PS=4.54U PD=2.59U
* device instance $8 r0 *1 4.96,1.335 nmos_5p0
M$8 8 5 7 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $9 r0 *1 6.08,1.335 nmos_5p0
M$9 7 4 8 2 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.1716P PS=1.18U PD=1.18U
* device instance $10 r0 *1 7.2,1.335 nmos_5p0
M$10 7 6 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1716P PS=2.02U PD=1.18U
* device instance $11 r0 *1 8.5,1.005 nmos_5p0
M$11 9 8 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.5808P PS=2.02U PD=3.52U
* device instance $12 r0 *1 0.92,1.005 nmos_5p0
M$12 2 6 1 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3828P PS=3.52U PD=2.08U
* device instance $13 r0 *1 2.28,1.335 nmos_5p0
M$13 10 4 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.3828P AD=0.0792P PS=2.08U PD=0.9U
* device instance $14 r0 *1 3.12,1.335 nmos_5p0
M$14 6 5 10 2 nmos_5p0 L=0.6U W=0.66U AS=0.0792P AD=0.2904P PS=0.9U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_1

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A4
* pin A2
* pin A1
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_4 1 3 4 5 6 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 A3
* net 4 A4
* net 5 A2
* net 6 A1
* net 16 ZN
* net 17 NWELL,VDD
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 16 3 17 17 pmos_5p0 L=0.5U W=5.12U AS=1.5616P AD=1.3312P PS=8.84U PD=7.2U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 17 4 16 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.3312P PS=7.2U PD=7.2U
* device instance $9 r0 *1 9.03,4.055 pmos_5p0
M$9 16 5 17 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.5616P PS=7.2U PD=8.84U
* device instance $10 r0 *1 10.05,4.055 pmos_5p0
M$10 17 6 16 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.3312P PS=7.2U PD=7.2U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 7 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $18 r0 *1 1.84,1.005 nmos_5p0
M$18 1 4 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $19 r0 *1 2.96,1.005 nmos_5p0
M$19 9 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 3.88,1.005 nmos_5p0
M$20 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $21 r0 *1 5,1.005 nmos_5p0
M$21 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 5.92,1.005 nmos_5p0
M$22 1 4 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 7.04,1.005 nmos_5p0
M$23 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $24 r0 *1 8.01,1.005 nmos_5p0
M$24 11 3 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $25 r0 *1 9.03,1.005 nmos_5p0
M$25 14 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $26 r0 *1 10,1.005 nmos_5p0
M$26 16 6 14 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $27 r0 *1 11.12,1.005 nmos_5p0
M$27 15 6 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.04,1.005 nmos_5p0
M$28 2 5 15 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 13.16,1.005 nmos_5p0
M$29 10 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.08,1.005 nmos_5p0
M$30 16 6 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 15.2,1.005 nmos_5p0
M$31 13 6 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 16.12,1.005 nmos_5p0
M$32 2 5 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_4

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai221_2
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin B2
* pin C
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai221_2 1 3 4 5 6 8 9 10
* net 1 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 B2
* net 6 C
* net 8 A1
* net 9 ZN
* net 10 A2
* device instance $1 r0 *1 0.92,3.965 pmos_5p0
M$1 9 6 1 1 pmos_5p0 L=0.5U W=2.92U AS=1.17P AD=1.2274P PS=5.06U PD=6.33U
* device instance $2 r0 *1 2.12,3.78 pmos_5p0
M$2 14 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.4758P PS=2.53U PD=2.35U
* device instance $3 r0 *1 3.14,3.78 pmos_5p0
M$3 9 4 14 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $4 r0 *1 4.31,3.78 pmos_5p0
M$4 13 4 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $5 r0 *1 5.38,3.78 pmos_5p0
M$5 1 5 13 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $7 r0 *1 7.78,3.78 pmos_5p0
M$7 12 8 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.52155P PS=2.53U PD=2.4U
* device instance $8 r0 *1 8.85,3.78 pmos_5p0
M$8 1 10 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.97,3.78 pmos_5p0
M$9 11 10 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $10 r0 *1 11.04,3.78 pmos_5p0
M$10 9 8 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $11 r0 *1 0.92,1.005 nmos_5p0
M$11 2 6 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7458P PS=5.36U PD=3.77U
* device instance $12 r0 *1 2.07,1.005 nmos_5p0
M$12 3 5 2 3 nmos_5p0 L=0.6U W=2.64U AS=0.7062P AD=0.6864P PS=3.71U PD=3.68U
* device instance $13 r0 *1 3.19,1.005 nmos_5p0
M$13 2 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 7.73,1.005 nmos_5p0
M$17 9 8 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.726P AD=0.924P PS=3.74U PD=5.36U
* device instance $18 r0 *1 8.85,1.005 nmos_5p0
M$18 7 10 9 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai221_2

* cell gf180mcu_fd_sc_mcu9t5v0__tiel
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__tiel 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.97,3.315 pmos_5p0
M$1 3 3 2 2 pmos_5p0 L=0.5U W=0.9U AS=0.396P AD=0.396P PS=2.68U PD=2.68U
* device instance $2 r0 *1 0.92,1.335 nmos_5p0
M$2 4 3 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.2904P PS=2.2U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__tiel

* cell gf180mcu_fd_sc_mcu9t5v0__dlya_4
* pin I
* pin Z
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlya_4 1 5 6 7
* net 1 I
* net 5 Z
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 3.885,3.61 pmos_5p0
M$1 4 3 6 6 pmos_5p0 L=0.5U W=0.36U AS=0.429P AD=0.1584P PS=2.58U PD=1.6U
* device instance $2 r0 *1 5.135,3.78 pmos_5p0
M$2 5 4 6 6 pmos_5p0 L=0.5U W=7.32U AS=2.1309P AD=2.5071P PS=9.93U PD=11.89U
* device instance $6 r0 *1 0.875,3.61 pmos_5p0
M$6 6 1 2 6 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1116P PS=1.6U PD=0.98U
* device instance $7 r0 *1 1.995,3.61 pmos_5p0
M$7 3 2 6 6 pmos_5p0 L=0.5U W=0.36U AS=0.1116P AD=0.1584P PS=0.98U PD=1.6U
* device instance $8 r0 *1 3.885,0.94 nmos_5p0
M$8 4 3 7 7 nmos_5p0 L=0.6U W=0.36U AS=0.318P AD=0.1584P PS=2.02U PD=1.6U
* device instance $9 r0 *1 5.185,1.005 nmos_5p0
M$9 5 4 7 7 nmos_5p0 L=0.6U W=5.28U AS=1.3476P AD=1.6104P PS=7.54U PD=9.04U
* device instance $13 r0 *1 0.925,0.94 nmos_5p0
M$13 7 1 2 7 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0936P PS=1.6U PD=0.88U
* device instance $14 r0 *1 2.045,0.94 nmos_5p0
M$14 3 2 7 7 nmos_5p0 L=0.6U W=0.36U AS=0.0936P AD=0.1584P PS=0.88U PD=1.6U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlya_4

* cell gf180mcu_fd_sc_mcu9t5v0__inv_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_8 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7763P PS=21.69U PD=21.69U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.9832P AD=2.9832P PS=16.4U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_8

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_8 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7763P PS=21.69U PD=21.69U
* device instance $9 r0 *1 0.92,1.3 nmos_5p0
M$9 4 3 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.6498P AD=1.6498P PS=11.09U PD=11.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_8

* cell gf180mcu_fd_sc_mcu9t5v0__dffq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffq_4 1 8 9 10 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 8 Q
* net 9 CLK
* net 10 D
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.97,3.555 pmos_5p0
M$1 14 9 3 14 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $2 r0 *1 1.99,3.555 pmos_5p0
M$2 2 3 14 14 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $3 r0 *1 4.03,3.365 pmos_5p0
M$3 15 2 14 14 pmos_5p0 L=0.5U W=1U AS=0.9696P AD=0.12P PS=5.04U PD=1.24U
* device instance $4 r0 *1 4.77,3.365 pmos_5p0
M$4 4 10 15 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.36P PS=1.24U PD=1.72U
* device instance $5 r0 *1 5.99,3.365 pmos_5p0
M$5 16 3 4 14 pmos_5p0 L=0.5U W=1U AS=0.36P AD=0.12P PS=1.72U PD=1.24U
* device instance $6 r0 *1 6.73,3.365 pmos_5p0
M$6 14 5 16 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.45P PS=1.24U PD=1.9U
* device instance $7 r0 *1 8.13,3.365 pmos_5p0
M$7 5 4 14 14 pmos_5p0 L=0.5U W=1U AS=0.45P AD=0.3075P PS=1.9U PD=1.615U
* device instance $8 r0 *1 9.245,3.365 pmos_5p0
M$8 6 3 5 14 pmos_5p0 L=0.5U W=1U AS=0.3075P AD=0.4625P PS=1.615U PD=1.925U
* device instance $9 r0 *1 10.67,3.365 pmos_5p0
M$9 17 2 6 14 pmos_5p0 L=0.5U W=1U AS=0.4625P AD=0.14P PS=1.925U PD=1.28U
* device instance $10 r0 *1 11.45,3.365 pmos_5p0
M$10 14 7 17 14 pmos_5p0 L=0.5U W=1U AS=0.14P AD=0.5526P PS=1.28U PD=2.57U
* device instance $11 r0 *1 12.69,3.78 pmos_5p0
M$11 7 6 14 14 pmos_5p0 L=0.5U W=3.66U AS=1.0284P AD=0.9516P PS=4.92U PD=4.7U
* device instance $13 r0 *1 14.73,3.78 pmos_5p0
M$13 8 7 14 14 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=2.2326P PS=9.4U PD=11.59U
* device instance $17 r0 *1 0.92,1.27 nmos_5p0
M$17 1 9 3 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $18 r0 *1 2.04,1.27 nmos_5p0
M$18 2 3 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $19 r0 *1 3.88,1.375 nmos_5p0
M$19 11 3 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.2552P AD=0.0696P PS=2.04U PD=0.82U
* device instance $20 r0 *1 4.72,1.375 nmos_5p0
M$20 4 10 11 1 nmos_5p0 L=0.6U W=0.58U AS=0.0696P AD=0.1508P PS=0.82U PD=1.1U
* device instance $21 r0 *1 5.84,1.375 nmos_5p0
M$21 12 2 4 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $22 r0 *1 6.68,1.375 nmos_5p0
M$22 12 5 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3932P AD=0.0696P PS=2.35U PD=0.82U
* device instance $23 r0 *1 8.18,1.375 nmos_5p0
M$23 5 4 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3932P AD=0.1508P PS=2.35U PD=1.1U
* device instance $24 r0 *1 9.3,1.375 nmos_5p0
M$24 6 2 5 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.1508P PS=1.1U PD=1.1U
* device instance $25 r0 *1 10.42,1.375 nmos_5p0
M$25 13 3 6 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $26 r0 *1 11.26,1.375 nmos_5p0
M$26 13 7 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3774P AD=0.0696P PS=2.06U PD=0.82U
* device instance $27 r0 *1 12.6,1.005 nmos_5p0
M$27 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7206P AD=0.6864P PS=3.9U PD=3.68U
* device instance $29 r0 *1 14.84,1.005 nmos_5p0
M$29 8 7 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffq_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,0.995 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=2.19U AS=0.7008P AD=0.7008P PS=4.84U PD=4.84U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_3

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_4 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.3 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.8906P AD=0.8906P PS=6.09U PD=6.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_4

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_4 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.975,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.46135P AD=2.31495P PS=11.84U PD=9.85U
* device instance $5 r0 *1 5.505,3.78 pmos_5p0
M$5 12 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $6 r0 *1 6.785,3.78 pmos_5p0
M$6 6 8 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $7 r0 *1 7.805,3.78 pmos_5p0
M$7 11 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $8 r0 *1 8.545,3.78 pmos_5p0
M$8 2 7 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $9 r0 *1 9.565,3.78 pmos_5p0
M$9 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 0.975,1.005 nmos_5p0
M$10 3 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 5.455,1.005 nmos_5p0
M$14 9 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $15 r0 *1 6.295,1.005 nmos_5p0
M$15 6 5 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $16 r0 *1 7.415,1.005 nmos_5p0
M$16 10 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $17 r0 *1 8.495,1.005 nmos_5p0
M$17 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $18 r0 *1 9.615,1.005 nmos_5p0
M$18 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.8377P PS=26.59U PD=24.68U
* device instance $11 r0 *1 12.25,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.5107P AD=11.5839P PS=49.18U PD=51.09U
* device instance $31 r0 *1 0.92,1.3 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=7.3U AS=2.1091P AD=1.898P PS=13.84U PD=12.5U
* device instance $41 r0 *1 12.3,1.265 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=16U AS=4.2215P AD=4.304P PS=26.58U PD=27.56U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_2
* pin NWELL,VDD
* pin A2
* pin ZN
* pin A1
* pin B
* pin C
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 A2
* net 3 ZN
* net 4 A1
* net 5 B
* net 6 C
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 11 4 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $5 r0 *1 5.43,3.965 pmos_5p0
M$5 3 5 1 1 pmos_5p0 L=0.5U W=2.92U AS=0.9646P AD=1.022P PS=4.51U PD=5.78U
* device instance $6 r0 *1 6.45,3.965 pmos_5p0
M$6 1 6 3 1 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7062P PS=5.36U PD=3.71U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 7 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.43,1.005 nmos_5p0
M$13 9 5 8 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $14 r0 *1 6.4,1.005 nmos_5p0
M$14 7 6 9 7 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $15 r0 *1 7.52,1.005 nmos_5p0
M$15 10 6 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 8.44,1.005 nmos_5p0
M$16 8 5 10 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 10 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 10 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 11 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 11 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 8 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 8 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffq_2 1 5 6 7 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 5 Q
* net 6 CLK
* net 7 D
* net 14 NWELL,VDD
* device instance $1 r0 *1 14.6,3.78 pmos_5p0
M$1 5 4 14 14 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 4.24,3.41 pmos_5p0
M$3 15 2 14 14 pmos_5p0 L=0.5U W=1U AS=0.9462P AD=0.12P PS=4.91U PD=1.24U
* device instance $4 r0 *1 4.98,3.41 pmos_5p0
M$4 8 7 15 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.31P PS=1.24U PD=1.62U
* device instance $5 r0 *1 6.1,3.41 pmos_5p0
M$5 16 3 8 14 pmos_5p0 L=0.5U W=1U AS=0.31P AD=0.12P PS=1.62U PD=1.24U
* device instance $6 r0 *1 6.84,3.41 pmos_5p0
M$6 14 9 16 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.35P PS=1.24U PD=1.7U
* device instance $7 r0 *1 8.04,3.41 pmos_5p0
M$7 9 8 14 14 pmos_5p0 L=0.5U W=1U AS=0.35P AD=0.46P PS=1.7U PD=1.92U
* device instance $8 r0 *1 9.46,3.41 pmos_5p0
M$8 10 3 9 14 pmos_5p0 L=0.5U W=1U AS=0.46P AD=0.4P PS=1.92U PD=1.8U
* device instance $9 r0 *1 10.76,3.41 pmos_5p0
M$9 17 2 10 14 pmos_5p0 L=0.5U W=1U AS=0.4P AD=0.13P PS=1.8U PD=1.26U
* device instance $10 r0 *1 11.52,3.41 pmos_5p0
M$10 17 4 14 14 pmos_5p0 L=0.5U W=1U AS=0.6017P AD=0.13P PS=2.67U PD=1.26U
* device instance $11 r0 *1 12.86,3.78 pmos_5p0
M$11 4 10 14 14 pmos_5p0 L=0.5U W=1.83U AS=0.6017P AD=0.8052P PS=2.67U PD=4.54U
* device instance $12 r0 *1 0.87,3.555 pmos_5p0
M$12 14 6 3 14 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.4278P PS=3.64U PD=2U
* device instance $13 r0 *1 1.99,3.555 pmos_5p0
M$13 2 3 14 14 pmos_5p0 L=0.5U W=1.38U AS=0.4278P AD=0.6072P PS=2U PD=3.64U
* device instance $14 r0 *1 14.65,1.005 nmos_5p0
M$14 5 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $16 r0 *1 0.92,1.125 nmos_5p0
M$16 1 6 3 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.125 nmos_5p0
M$17 2 3 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 4.09,1.365 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.6463P AD=0.0696P PS=4U PD=0.82U
* device instance $19 r0 *1 4.93,1.365 nmos_5p0
M$19 8 7 11 1 nmos_5p0 L=0.6U W=0.58U AS=0.0696P AD=0.1508P PS=0.82U PD=1.1U
* device instance $20 r0 *1 6.05,1.365 nmos_5p0
M$20 12 2 8 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $21 r0 *1 6.89,1.365 nmos_5p0
M$21 12 9 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.40405P AD=0.0696P PS=2.425U PD=0.82U
* device instance $22 r0 *1 8.39,1.37 nmos_5p0
M$22 9 8 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.40405P AD=0.1508P PS=2.425U PD=1.1U
* device instance $23 r0 *1 9.51,1.37 nmos_5p0
M$23 10 2 9 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.1508P PS=1.1U PD=1.1U
* device instance $24 r0 *1 10.63,1.37 nmos_5p0
M$24 13 3 10 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $25 r0 *1 11.47,1.37 nmos_5p0
M$25 13 4 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3774P AD=0.0696P PS=2.06U PD=0.82U
* device instance $26 r0 *1 12.81,1 nmos_5p0
M$26 4 10 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3774P AD=0.5808P PS=2.06U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffq_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyc_2 1 7 11 13
* net 1 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* net 11 I
* net 13 NWELL,VDD
* device instance $1 r0 *1 8.34,3.365 pmos_5p0
M$1 6 5 17 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 8.34,4.085 pmos_5p0
M$2 17 5 13 13 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 10.14,3.785 pmos_5p0
M$3 7 6 13 13 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 4.34,3.365 pmos_5p0
M$5 4 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $6 r0 *1 6.18,3.365 pmos_5p0
M$6 16 4 5 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $7 r0 *1 4.34,4.085 pmos_5p0
M$7 13 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $8 r0 *1 6.18,4.085 pmos_5p0
M$8 13 4 16 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $9 r0 *1 2.18,3.365 pmos_5p0
M$9 15 2 3 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $10 r0 *1 0.87,4.085 pmos_5p0
M$10 13 11 2 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $11 r0 *1 2.18,4.085 pmos_5p0
M$11 13 2 15 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $12 r0 *1 0.92,0.795 nmos_5p0
M$12 1 11 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $13 r0 *1 2.23,0.795 nmos_5p0
M$13 12 2 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $14 r0 *1 2.23,1.515 nmos_5p0
M$14 3 2 12 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $15 r0 *1 4.39,0.52 nmos_5p0
M$15 1 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.2232P PS=1.98U PD=1.6U
* device instance $16 r0 *1 6.23,0.52 nmos_5p0
M$16 10 4 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.2232P AD=0.27P PS=1.6U PD=1.98U
* device instance $17 r0 *1 4.39,1.24 nmos_5p0
M$17 4 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $18 r0 *1 6.23,1.24 nmos_5p0
M$18 5 4 10 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $19 r0 *1 8.39,0.525 nmos_5p0
M$19 1 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $20 r0 *1 8.39,1.245 nmos_5p0
M$20 6 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $21 r0 *1 10.19,1.005 nmos_5p0
M$21 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyc_2

* cell gf180mcu_fd_sc_mcu9t5v0__addh_2
* pin PWELL,VSS,gf180mcu_gnd
* pin CO
* pin S
* pin A
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_2 1 2 6 7 8 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 CO
* net 6 S
* net 7 A
* net 8 B
* net 10 NWELL,VDD
* device instance $1 r0 *1 5.99,3.78 pmos_5p0
M$1 11 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 7.06,3.78 pmos_5p0
M$2 5 7 11 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.52155P PS=2.4U PD=2.4U
* device instance $3 r0 *1 8.13,3.78 pmos_5p0
M$3 10 3 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8784P PS=2.4U PD=2.79U
* device instance $4 r0 *1 9.59,3.78 pmos_5p0
M$4 6 5 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.32675P PS=5.19U PD=6.94U
* device instance $6 r0 *1 0.94,3.78 pmos_5p0
M$6 2 3 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.08885P PS=6.99U PD=4.85U
* device instance $8 r0 *1 3.13,3.78 pmos_5p0
M$8 3 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.4758P PS=2.4U PD=2.35U
* device instance $9 r0 *1 4.15,3.78 pmos_5p0
M$9 10 8 3 10 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 5.94,1.005 nmos_5p0
M$10 5 8 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $11 r0 *1 7.06,1.005 nmos_5p0
M$11 4 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $12 r0 *1 8.18,1.005 nmos_5p0
M$12 1 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5016P PS=1.84U PD=2.08U
* device instance $13 r0 *1 9.54,1.005 nmos_5p0
M$13 6 5 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.8448P AD=0.924P PS=3.92U PD=5.36U
* device instance $15 r0 *1 0.94,1.005 nmos_5p0
M$15 2 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $17 r0 *1 3.18,1.005 nmos_5p0
M$17 9 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 4.1,1.005 nmos_5p0
M$18 3 8 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai221_4
* pin PWELL,VSS,gf180mcu_gnd
* pin C
* pin ZN
* pin B1
* pin B2
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai221_4 1 2 5 6 7 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 C
* net 5 ZN
* net 6 B1
* net 7 B2
* net 8 A2
* net 9 A1
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 6 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 7 11 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 12 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 12 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 14 6 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 7 14 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 13 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 5 6 13 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=1.0157P PS=2.45U PD=3.12U
* device instance $9 r0 *1 10.55,3.965 pmos_5p0
M$9 10 2 5 10 pmos_5p0 L=0.5U W=5.84U AS=2.5205P AD=1.8104P PS=9.83U PD=8.32U
* device instance $13 r0 *1 15.13,3.78 pmos_5p0
M$13 16 9 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.5996P AD=0.52155P PS=2.55U PD=2.4U
* device instance $14 r0 *1 16.2,3.78 pmos_5p0
M$14 10 8 16 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $15 r0 *1 17.37,3.78 pmos_5p0
M$15 15 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $16 r0 *1 18.44,3.78 pmos_5p0
M$16 5 9 15 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $17 r0 *1 19.56,3.78 pmos_5p0
M$17 17 9 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $18 r0 *1 20.68,3.78 pmos_5p0
M$18 10 8 17 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $19 r0 *1 21.8,3.78 pmos_5p0
M$19 18 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $20 r0 *1 22.87,3.78 pmos_5p0
M$20 5 9 18 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $21 r0 *1 10.6,1.005 nmos_5p0
M$21 3 2 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $25 r0 *1 15.08,1.005 nmos_5p0
M$25 5 9 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
* device instance $26 r0 *1 16.2,1.005 nmos_5p0
M$26 4 8 5 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $33 r0 *1 0.92,1.005 nmos_5p0
M$33 3 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $34 r0 *1 2.04,1.005 nmos_5p0
M$34 1 7 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai221_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_4 1 2 3 5 6 7 9
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 3 B
* net 5 ZN
* net 6 A2
* net 7 A1
* net 9 NWELL,VDD
* device instance $1 r0 *1 14.93,3.872 pmos_5p0
M$1 5 3 9 9 pmos_5p0 L=0.5U W=6.58U AS=2.212525P AD=2.212525P PS=10.915U
+ PD=10.915U
* device instance $5 r0 *1 0.97,3.78 pmos_5p0
M$5 9 2 8 9 pmos_5p0 L=0.5U W=5.49U AS=1.89405P AD=1.65615P PS=9.39U PD=7.3U
* device instance $8 r0 *1 4.28,3.78 pmos_5p0
M$8 11 2 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 5.4,3.78 pmos_5p0
M$9 10 6 11 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 6.52,3.78 pmos_5p0
M$10 5 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 7.64,3.78 pmos_5p0
M$11 13 7 5 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.61305P PS=2.45U PD=2.5U
* device instance $12 r0 *1 8.81,3.78 pmos_5p0
M$12 8 6 13 9 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $13 r0 *1 9.88,3.78 pmos_5p0
M$13 12 6 8 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $14 r0 *1 11,3.78 pmos_5p0
M$14 5 7 12 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $15 r0 *1 12.12,3.78 pmos_5p0
M$15 14 7 5 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $16 r0 *1 13.19,3.78 pmos_5p0
M$16 8 6 14 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 5 2 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $21 r0 *1 5.4,1.005 nmos_5p0
M$21 5 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.716P PS=7.36U PD=7.88U
* device instance $22 r0 *1 6.52,1.005 nmos_5p0
M$22 4 7 5 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $29 r0 *1 14.88,1.005 nmos_5p0
M$29 1 3 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.716P AD=1.6104P PS=7.88U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* pin A2
* pin A1
* pin B
* pin ZN
* pin C
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_2 1 2 4 5 6 7 8
* net 1 A2
* net 2 A1
* net 4 B
* net 5 ZN
* net 6 C
* net 7 NWELL,VDD
* net 8 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 5 1 3 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.3359P PS=6.89U PD=5.12U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 3 2 5 7 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.37,3.78 pmos_5p0
M$5 12 4 3 7 pmos_5p0 L=0.5U W=1.83U AS=0.8601P AD=0.2196P PS=2.77U PD=2.07U
* device instance $6 r0 *1 6.11,3.78 pmos_5p0
M$6 7 6 12 7 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.549P PS=2.07U PD=2.43U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 11 6 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.549P AD=0.4392P PS=2.43U PD=2.31U
* device instance $8 r0 *1 8.19,3.78 pmos_5p0
M$8 3 4 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.4392P AD=0.8052P PS=2.31U PD=4.54U
* device instance $9 r0 *1 5.02,0.745 nmos_5p0
M$9 5 4 8 8 nmos_5p0 L=0.6U W=1.58U AS=0.5609P AD=0.553P PS=3.195U PD=3.77U
* device instance $10 r0 *1 6.14,0.745 nmos_5p0
M$10 8 6 5 8 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $13 r0 *1 0.92,0.942 nmos_5p0
M$13 10 1 8 8 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.1422P PS=3.25U PD=1.425U
* device instance $14 r0 *1 1.76,0.942 nmos_5p0
M$14 5 2 10 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 2.88,0.942 nmos_5p0
M$15 9 2 5 8 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 3.72,0.942 nmos_5p0
M$16 8 1 9 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin ZN
* pin A2
* pin B1
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_4 1 2 3 4 13 14 16
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 ZN
* net 4 A2
* net 13 B1
* net 14 A1
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 16 2 15 16 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1228P PS=11.59U PD=9.64U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 15 13 16 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.27,3.78 pmos_5p0
M$9 3 4 15 16 pmos_5p0 L=0.5U W=7.32U AS=2.1228P AD=2.2326P PS=9.64U PD=11.59U
* device instance $10 r0 *1 10.29,3.78 pmos_5p0
M$10 15 14 3 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 5 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $18 r0 *1 1.84,1.005 nmos_5p0
M$18 3 13 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $19 r0 *1 2.96,1.005 nmos_5p0
M$19 7 13 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 3.88,1.005 nmos_5p0
M$20 1 2 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $21 r0 *1 5,1.005 nmos_5p0
M$21 6 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 5.92,1.005 nmos_5p0
M$22 3 13 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 7.04,1.005 nmos_5p0
M$23 9 13 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $24 r0 *1 7.96,1.005 nmos_5p0
M$24 1 2 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5016P PS=1.64U PD=2.08U
* device instance $25 r0 *1 9.32,1.005 nmos_5p0
M$25 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5016P AD=0.2112P PS=2.08U PD=1.64U
* device instance $26 r0 *1 10.24,1.005 nmos_5p0
M$26 3 14 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $27 r0 *1 11.36,1.005 nmos_5p0
M$27 11 14 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.28,1.005 nmos_5p0
M$28 1 4 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 13.4,1.005 nmos_5p0
M$29 10 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.32,1.005 nmos_5p0
M$30 3 14 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 15.44,1.005 nmos_5p0
M$31 8 14 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 16.36,1.005 nmos_5p0
M$32 1 4 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_4

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__and4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_2 1 2 3 4 5 6 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.925,4.055 pmos_5p0
M$1 7 1 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3328P PS=3.44U PD=1.8U
* device instance $2 r0 *1 1.945,4.055 pmos_5p0
M$2 6 2 7 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $3 r0 *1 2.965,4.055 pmos_5p0
M$3 7 3 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $4 r0 *1 3.985,4.055 pmos_5p0
M$4 7 4 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.558P AD=0.3328P PS=2.53U PD=1.8U
* device instance $5 r0 *1 5.185,3.78 pmos_5p0
M$5 8 7 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.0338P AD=1.281P PS=4.88U PD=6.89U
* device instance $7 r0 *1 0.975,1.005 nmos_5p0
M$7 11 1 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $8 r0 *1 1.895,1.005 nmos_5p0
M$8 10 2 11 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $9 r0 *1 2.915,1.005 nmos_5p0
M$9 9 3 10 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $10 r0 *1 3.935,1.005 nmos_5p0
M$10 5 4 9 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $11 r0 *1 5.055,1.005 nmos_5p0
M$11 8 7 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.2993P PS=6.99U PD=5.08U
* device instance $3 r0 *1 3.29,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.5071P PS=9.98U PD=11.89U
* device instance $7 r0 *1 0.92,1.23 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.4593P PS=3.59U PD=2.75U
* device instance $9 r0 *1 3.34,1.265 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=3.2U AS=0.8935P AD=0.976P PS=5.46U PD=6.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_3
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_3 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.74115P PS=4.54U PD=2.64U
* device instance $2 r0 *1 2.18,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.87575P AD=1.9398P PS=7.54U PD=9.44U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 1 4 3 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.4686P PS=3.52U PD=2.03U
* device instance $6 r0 *1 2.23,1.005 nmos_5p0
M$6 5 4 3 3 nmos_5p0 L=0.6U W=3.96U AS=1.155P AD=1.2672P PS=5.71U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_3

* cell gf180mcu_fd_sc_mcu9t5v0__buf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.2692P PS=11.89U PD=9.8U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.5384P AD=4.7763P PS=19.6U PD=21.69U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $17 r0 *1 5.4,1.005 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.7456P AD=2.9832P PS=14.72U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_8

* cell gf180mcu_fd_sc_mcu9t5v0__nor4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A3
* pin A4
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor4_4 1 2 3 4 5 6 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 1.285,3.78 pmos_5p0
M$1 9 4 7 8 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.355,3.78 pmos_5p0
M$2 8 5 9 8 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.475,3.78 pmos_5p0
M$3 10 5 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.775,3.78 pmos_5p0
M$4 7 4 10 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $5 r0 *1 6.075,3.78 pmos_5p0
M$5 11 4 7 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.5673P PS=2.63U PD=2.45U
* device instance $6 r0 *1 7.195,3.78 pmos_5p0
M$6 8 5 11 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 8.315,3.78 pmos_5p0
M$7 14 5 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $8 r0 *1 9.615,3.78 pmos_5p0
M$8 13 4 14 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $9 r0 *1 10.915,3.78 pmos_5p0
M$9 12 3 13 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $10 r0 *1 12.215,3.78 pmos_5p0
M$10 2 6 12 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $11 r0 *1 13.515,3.78 pmos_5p0
M$11 15 6 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $12 r0 *1 14.815,3.78 pmos_5p0
M$12 7 3 15 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $13 r0 *1 16.115,3.78 pmos_5p0
M$13 16 3 7 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $14 r0 *1 17.415,3.78 pmos_5p0
M$14 2 6 16 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $15 r0 *1 18.715,3.78 pmos_5p0
M$15 17 6 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.68625P PS=2.63U PD=2.58U
* device instance $16 r0 *1 19.965,3.78 pmos_5p0
M$16 7 3 17 8 pmos_5p0 L=0.5U W=1.83U AS=0.68625P AD=0.8052P PS=2.58U PD=4.54U
* device instance $17 r0 *1 4.775,0.695 nmos_5p0
M$17 1 4 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.98415P AD=0.8057P PS=6.295U PD=5.09U
* device instance $19 r0 *1 12.215,0.695 nmos_5p0
M$19 1 6 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.925P AD=0.925P PS=5.46U PD=5.46U
* device instance $20 r0 *1 14.815,0.695 nmos_5p0
M$20 1 3 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.925P AD=0.98415P PS=5.46U PD=6.295U
* device instance $24 r0 *1 2.355,0.7 nmos_5p0
M$24 1 5 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.8057P AD=0.6864P PS=5.09U PD=4.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor4_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 11 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 10 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 9 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_4 1 2 3 4 5 6 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A2
* net 4 A1
* net 5 B
* net 6 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 1.54,3.78 pmos_5p0
M$1 2 3 11 12 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1411P PS=11.59U PD=9.66U
* device instance $2 r0 *1 2.56,3.78 pmos_5p0
M$2 11 4 2 12 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.96,3.78 pmos_5p0
M$9 13 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.5673P PS=2.61U PD=2.45U
* device instance $10 r0 *1 11.08,3.78 pmos_5p0
M$10 12 6 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $11 r0 *1 12.62,3.78 pmos_5p0
M$11 14 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $12 r0 *1 13.74,3.78 pmos_5p0
M$12 11 5 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $13 r0 *1 15.28,3.78 pmos_5p0
M$13 16 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $14 r0 *1 16.4,3.78 pmos_5p0
M$14 12 6 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $15 r0 *1 17.94,3.78 pmos_5p0
M$15 15 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $16 r0 *1 19.06,3.78 pmos_5p0
M$16 11 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $17 r0 *1 9.96,1.08 nmos_5p0
M$17 2 5 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.33065P AD=0.9638P PS=6.745U PD=6.39U
* device instance $18 r0 *1 11.08,1.08 nmos_5p0
M$18 2 6 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.5056P AD=0.8216P PS=7.04U PD=5.24U
* device instance $25 r0 *1 1.54,0.937 nmos_5p0
M$25 7 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.74655P AD=0.219225P PS=3.63U
+ PD=1.555U
* device instance $26 r0 *1 2.51,0.937 nmos_5p0
M$26 2 4 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.63,0.937 nmos_5p0
M$27 9 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 4.55,0.937 nmos_5p0
M$28 1 3 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.67,0.937 nmos_5p0
M$29 8 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 6.59,0.937 nmos_5p0
M$30 2 4 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.71,0.937 nmos_5p0
M$31 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $32 r0 *1 8.63,0.937 nmos_5p0
M$32 1 3 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.37245P PS=1.505U
+ PD=1.915U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_2 1 2 3 4 5 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 NWELL,VDD
* net 4 B1
* net 5 ZN
* net 7 A2
* net 8 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 6 3 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.9516P PS=6.89U PD=4.7U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 6 4 3 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 4.95,3.78 pmos_5p0
M$5 5 7 6 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.281P PS=4.7U PD=6.89U
* device instance $6 r0 *1 5.97,3.78 pmos_5p0
M$6 6 8 5 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 12 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 5 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 11 4 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 1 2 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 10 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 5 8 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 9 8 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_4 1 3 4 5 6 7 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 ZN
* net 4 A2
* net 5 A1
* net 6 B
* net 7 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 13 4 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 3 5 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 14 5 3 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 12 4 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 15 4 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 3 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 16 5 3 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 12 4 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $9 r0 *1 9.91,3.965 pmos_5p0
M$9 3 6 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.7238P AD=1.7812P PS=8.47U PD=9.74U
* device instance $10 r0 *1 10.93,3.965 pmos_5p0
M$10 12 7 3 12 pmos_5p0 L=0.5U W=5.84U AS=1.5184P AD=1.5184P PS=7.92U PD=7.92U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 3 4 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3926P PS=9.04U PD=7.39U
* device instance $18 r0 *1 2.04,1.005 nmos_5p0
M$18 2 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $25 r0 *1 9.91,1.005 nmos_5p0
M$25 10 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $26 r0 *1 10.88,1.005 nmos_5p0
M$26 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $27 r0 *1 12,1.005 nmos_5p0
M$27 11 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.92,1.005 nmos_5p0
M$28 2 6 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 14.04,1.005 nmos_5p0
M$29 9 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.96,1.005 nmos_5p0
M$30 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 16.08,1.005 nmos_5p0
M$31 8 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 17,1.005 nmos_5p0
M$32 2 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_4

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
