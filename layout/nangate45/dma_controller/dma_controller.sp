* cell dma_controller
* pin channel_length[123]
* pin channel_length[124]
* pin channel_length[127]
* pin channel_length[126]
* pin channel_length[125]
* pin channel_length[96]
* pin channel_length[98]
* pin channel_length[112]
* pin channel_length[99]
* pin channel_length[119]
* pin channel_length[113]
* pin channel_length[114]
* pin channel_length[118]
* pin channel_length[116]
* pin channel_length[117]
* pin channel_length[115]
* pin channel_length[111]
* pin channel_length[104]
* pin channel_length[110]
* pin channel_length[105]
* pin channel_length[106]
* pin channel_length[108]
* pin channel_length[109]
* pin channel_length[107]
* pin debug_channel_state[3]
* pin dst_wdata[18]
* pin dst_wdata[36]
* pin dst_wdata[0]
* pin dst_addr[68]
* pin debug_transfer_count[18]
* pin dst_addr[95]
* pin dst_wdata[49]
* pin dst_wdata[111]
* pin dst_addr[107]
* pin dst_wdata[125]
* pin dst_wdata[45]
* pin debug_transfer_count[52]
* pin dst_wdata[52]
* pin dst_wdata[43]
* pin dst_addr[40]
* pin dst_addr[26]
* pin dst_addr[69]
* pin dst_addr[75]
* pin dst_addr[82]
* pin dst_wdata[27]
* pin dst_wdata[3]
* pin debug_transfer_count[91]
* pin debug_transfer_count[110]
* pin debug_transfer_count[69]
* pin dst_wdata[26]
* pin dst_wdata[115]
* pin debug_transfer_count[46]
* pin dst_wdata[4]
* pin dst_addr[35]
* pin dst_addr[76]
* pin debug_transfer_count[79]
* pin dst_wdata[113]
* pin debug_transfer_count[58]
* pin debug_transfer_count[64]
* pin debug_transfer_count[62]
* pin dst_addr[100]
* pin dst_wdata[110]
* pin debug_transfer_count[96]
* pin debug_transfer_count[77]
* pin debug_transfer_count[72]
* pin dst_wdata[41]
* pin debug_transfer_count[89]
* pin dst_addr[16]
* pin dst_wdata[127]
* pin dst_addr[17]
* pin dst_addr[59]
* pin dst_wdata[39]
* pin dst_wdata[54]
* pin dst_wdata[63]
* pin dst_wdata[116]
* pin dst_addr[64]
* pin dst_wdata[101]
* pin dst_wdata[12]
* pin dst_wdata[48]
* pin dst_addr[7]
* pin dst_wdata[122]
* pin dst_addr[57]
* pin dst_addr[89]
* pin dst_wdata[69]
* pin dst_addr[87]
* pin dst_wdata[104]
* pin dst_wdata[19]
* pin dst_wdata[105]
* pin dst_wdata[102]
* pin dst_addr[6]
* pin dst_addr[72]
* pin dst_wdata[60]
* pin dst_wdata[15]
* pin dst_addr[97]
* pin dst_wdata[51]
* pin dst_wdata[119]
* pin dst_addr[73]
* pin dst_addr[58]
* pin dst_wdata[32]
* pin dst_wdata[66]
* pin dst_wdata[67]
* pin dst_addr[8]
* pin dst_wdata[50]
* pin dst_addr[81]
* pin dst_addr[77]
* pin dst_wdata[61]
* pin dst_wdata[34]
* pin dst_wdata[65]
* pin dst_addr[61]
* pin dst_wdata[2]
* pin dst_addr[67]
* pin dst_wdata[47]
* pin dst_addr[84]
* pin dst_wdata[5]
* pin dst_addr[99]
* pin dst_wdata[37]
* pin dst_addr[66]
* pin dst_addr[91]
* pin dst_wdata[13]
* pin dst_wdata[42]
* pin dst_wdata[29]
* pin dst_wdata[124]
* pin dst_wdata[46]
* pin dst_wdata[31]
* pin dst_wdata[59]
* pin dst_wdata[68]
* pin dst_wdata[64]
* pin dst_wdata[44]
* pin dst_wdata[28]
* pin dst_wdata[1]
* pin dst_wdata[106]
* pin dst_wdata[11]
* pin dst_addr[78]
* pin dst_wdata[20]
* pin dst_wdata[14]
* pin dst_addr[55]
* pin dst_addr[85]
* pin dst_addr[88]
* pin dst_wdata[103]
* pin dst_wdata[58]
* pin dst_wdata[107]
* pin dst_addr[56]
* pin dst_wdata[38]
* pin dst_wdata[17]
* pin dst_wdata[56]
* pin dst_wdata[30]
* pin dst_addr[70]
* pin dst_wdata[35]
* pin dst_addr[65]
* pin dst_wdata[118]
* pin dst_wdata[53]
* pin dst_wdata[121]
* pin dst_wdata[33]
* pin dst_addr[96]
* pin dst_wdata[126]
* pin dst_wdata[123]
* pin dst_wdata[25]
* pin dst_wdata[23]
* pin dst_addr[94]
* pin dst_addr[92]
* pin dst_wdata[117]
* pin dst_addr[9]
* pin dst_wdata[120]
* pin dst_wdata[22]
* pin dst_addr[71]
* pin dst_wdata[55]
* pin dst_addr[98]
* pin dst_addr[5]
* pin dst_wdata[21]
* pin dst_wdata[100]
* pin dst_addr[93]
* pin dst_wdata[108]
* pin dst_addr[74]
* pin dst_wdata[57]
* pin dst_addr[62]
* pin dst_wdata[24]
* pin dst_addr[63]
* pin dst_addr[90]
* pin dst_wdata[112]
* pin dst_wdata[16]
* pin dst_addr[60]
* pin dst_wdata[109]
* pin dst_addr[83]
* pin dst_wdata[114]
* pin dst_wdata[40]
* pin dst_wdata[10]
* pin dst_addr[80]
* pin dst_addr[79]
* pin dst_addr[86]
* pin debug_channel_state[11]
* pin debug_transfer_count[95]
* pin debug_transfer_count[7]
* pin debug_transfer_count[120]
* pin dst_addr[121]
* pin dst_addr[39]
* pin debug_transfer_count[40]
* pin dst_addr[24]
* pin debug_transfer_count[21]
* pin dst_addr[115]
* pin dst_addr[4]
* pin debug_transfer_count[103]
* pin dst_addr[45]
* pin debug_transfer_count[3]
* pin debug_transfer_count[54]
* pin dst_addr[104]
* pin debug_transfer_count[37]
* pin debug_transfer_count[98]
* pin debug_transfer_count[70]
* pin dst_addr[10]
* pin debug_transfer_count[38]
* pin dst_addr[52]
* pin debug_transfer_count[6]
* pin dst_addr[12]
* pin debug_transfer_count[73]
* pin debug_transfer_count[90]
* pin debug_transfer_count[127]
* pin dst_addr[108]
* pin debug_transfer_count[42]
* pin dst_addr[28]
* pin dst_addr[109]
* pin debug_transfer_count[105]
* pin debug_transfer_count[25]
* pin debug_transfer_count[9]
* pin dst_addr[41]
* pin debug_transfer_count[15]
* pin debug_transfer_count[116]
* pin dst_addr[113]
* pin debug_channel_state[0]
* pin dst_addr[127]
* pin dst_addr[30]
* pin dst_addr[119]
* pin dst_addr[101]
* pin debug_transfer_count[84]
* pin debug_transfer_count[19]
* pin dst_addr[44]
* pin dst_addr[15]
* pin debug_transfer_count[114]
* pin debug_transfer_count[55]
* pin dst_addr[110]
* pin dst_addr[126]
* pin dst_addr[23]
* pin debug_transfer_count[63]
* pin debug_transfer_count[27]
* pin dst_addr[18]
* pin debug_transfer_count[99]
* pin debug_transfer_count[66]
* pin debug_transfer_count[13]
* pin debug_transfer_count[23]
* pin dst_addr[38]
* pin debug_transfer_count[67]
* pin debug_transfer_count[101]
* pin dst_addr[31]
* pin debug_transfer_count[59]
* pin debug_transfer_count[78]
* pin debug_channel_state[2]
* pin debug_transfer_count[44]
* pin debug_transfer_count[60]
* pin debug_transfer_count[85]
* pin debug_transfer_count[24]
* pin debug_transfer_count[28]
* pin debug_transfer_count[31]
* pin debug_transfer_count[104]
* pin debug_transfer_count[1]
* pin debug_transfer_count[113]
* pin dst_addr[105]
* pin dst_addr[27]
* pin debug_transfer_count[47]
* pin NWELL
* pin PWELL
* pin debug_transfer_count[71]
* pin debug_transfer_count[112]
* pin debug_channel_state[8]
* pin debug_transfer_count[126]
* pin debug_transfer_count[49]
* pin dst_addr[102]
* pin debug_transfer_count[4]
* pin debug_transfer_count[124]
* pin debug_transfer_count[39]
* pin debug_transfer_count[48]
* pin dst_addr[1]
* pin debug_transfer_count[97]
* pin debug_transfer_count[26]
* pin channel_error[2]
* pin debug_transfer_count[2]
* pin debug_transfer_count[121]
* pin debug_transfer_count[109]
* pin debug_transfer_count[119]
* pin dst_addr[46]
* pin dst_addr[34]
* pin debug_transfer_count[20]
* pin dst_addr[14]
* pin debug_channel_state[1]
* pin debug_transfer_count[32]
* pin debug_transfer_count[5]
* pin dst_addr[33]
* pin debug_transfer_count[106]
* pin debug_transfer_count[107]
* pin dst_addr[114]
* pin debug_channel_state[9]
* pin dst_addr[2]
* pin debug_transfer_count[75]
* pin debug_transfer_count[86]
* pin debug_transfer_count[51]
* pin debug_transfer_count[61]
* pin dst_addr[29]
* pin debug_transfer_count[82]
* pin dst_addr[13]
* pin debug_transfer_count[115]
* pin dst_addr[36]
* pin debug_transfer_count[30]
* pin debug_transfer_count[10]
* pin dst_addr[47]
* pin dst_addr[43]
* pin debug_transfer_count[17]
* pin debug_transfer_count[29]
* pin debug_transfer_count[80]
* pin debug_transfer_count[68]
* pin src_addr[97]
* pin debug_transfer_count[74]
* pin dst_addr[120]
* pin dst_addr[22]
* pin debug_transfer_count[22]
* pin debug_transfer_count[76]
* pin dst_addr[112]
* pin dst_addr[103]
* pin dst_addr[32]
* pin dst_addr[20]
* pin debug_transfer_count[117]
* pin dst_addr[19]
* pin debug_transfer_count[87]
* pin debug_transfer_count[34]
* pin debug_transfer_count[11]
* pin dst_addr[0]
* pin debug_transfer_count[123]
* pin debug_transfer_count[65]
* pin debug_transfer_count[125]
* pin dst_addr[11]
* pin debug_transfer_count[122]
* pin debug_transfer_count[12]
* pin dst_addr[111]
* pin dst_addr[48]
* pin dst_addr[118]
* pin src_addr[89]
* pin debug_transfer_count[88]
* pin dst_addr[122]
* pin debug_channel_state[7]
* pin debug_transfer_count[45]
* pin dst_addr[3]
* pin dst_addr[124]
* pin debug_transfer_count[94]
* pin dst_addr[51]
* pin debug_transfer_count[108]
* pin debug_transfer_count[57]
* pin debug_transfer_count[56]
* pin debug_transfer_count[16]
* pin channel_length[60]
* pin channel_length[59]
* pin debug_channel_state[10]
* pin channel_length[61]
* pin channel_length[58]
* pin channel_length[63]
* pin dst_addr[125]
* pin debug_transfer_count[102]
* pin dst_addr[117]
* pin channel_length[56]
* pin channel_length[62]
* pin channel_length[57]
* pin dst_addr[106]
* pin dst_addr[25]
* pin debug_transfer_count[33]
* pin debug_transfer_count[92]
* pin debug_transfer_count[8]
* pin debug_transfer_count[43]
* pin debug_transfer_count[53]
* pin channel_length[48]
* pin channel_length[55]
* pin channel_length[50]
* pin channel_error[0]
* pin dst_addr[37]
* pin debug_transfer_count[41]
* pin debug_transfer_count[111]
* pin channel_length[51]
* pin channel_length[49]
* pin debug_transfer_count[14]
* pin channel_length[54]
* pin channel_length[53]
* pin channel_length[52]
* pin dst_addr[116]
* pin channel_error[3]
* pin dst_addr[42]
* pin channel_length[120]
* pin channel_error[1]
* pin debug_transfer_count[83]
* pin dst_addr[49]
* pin debug_transfer_count[93]
* pin channel_length[121]
* pin debug_channel_state[5]
* pin channel_length[122]
* pin dst_addr[50]
* pin dst_addr[53]
* pin dst_addr[21]
* pin debug_transfer_count[100]
* pin debug_transfer_count[0]
* pin debug_transfer_count[118]
* pin debug_channel_state[4]
* pin debug_transfer_count[35]
* pin debug_transfer_count[36]
* pin channel_done[1]
* pin dst_addr[123]
* pin rst_n
* pin debug_channel_state[6]
* pin debug_transfer_count[50]
* pin channel_length[45]
* pin channel_length[46]
* pin channel_length[44]
* pin dst_addr[54]
* pin debug_transfer_count[81]
* pin src_addr[26]
* pin src_addr[39]
* pin channel_length[47]
* pin src_addr[19]
* pin channel_done[3]
* pin channel_start[1]
* pin channel_enable[1]
* pin src_addr[87]
* pin dst_wdata[92]
* pin src_addr[14]
* pin src_addr[115]
* pin channel_busy[1]
* pin channel_length[43]
* pin dst_wdata[84]
* pin channel_length[32]
* pin channel_length[42]
* pin dst_wready[3]
* pin src_addr[35]
* pin src_addr[48]
* pin dst_wstrb[14]
* pin channel_start[3]
* pin channel_length[40]
* pin dst_wdata[77]
* pin src_addr[59]
* pin channel_length[33]
* pin channel_length[35]
* pin channel_length[41]
* pin src_addr[123]
* pin src_addr[120]
* pin src_addr[43]
* pin channel_length[36]
* pin channel_length[37]
* pin channel_enable[3]
* pin dst_wdata[75]
* pin dst_wstrb[8]
* pin channel_length[34]
* pin src_read[1]
* pin dst_wstrb[2]
* pin src_addr[12]
* pin dst_wstrb[5]
* pin src_addr[24]
* pin dst_wready[1]
* pin channel_busy[3]
* pin src_rvalid[1]
* pin src_addr[113]
* pin src_addr[37]
* pin channel_length[38]
* pin channel_length[39]
* pin src_addr[52]
* pin dst_wstrb[6]
* pin src_addr[27]
* pin dst_wdata[91]
* pin src_addr[23]
* pin src_addr[66]
* pin src_addr[68]
* pin src_addr[4]
* pin dst_wdata[62]
* pin src_addr[100]
* pin src_addr[17]
* pin src_addr[106]
* pin src_addr[55]
* pin src_addr[117]
* pin src_addr[50]
* pin src_addr[64]
* pin dst_wdata[96]
* pin src_addr[80]
* pin src_addr[31]
* pin dst_wdata[93]
* pin src_addr[49]
* pin dst_wdata[6]
* pin dst_wdata[80]
* pin src_addr[121]
* pin clk
* pin src_addr[72]
* pin src_addr[13]
* pin dst_wstrb[12]
* pin src_addr[20]
* pin src_addr[28]
* pin src_addr[84]
* pin src_addr[82]
* pin src_addr[122]
* pin dst_wdata[72]
* pin dst_wdata[76]
* pin src_addr[103]
* pin dst_wdata[70]
* pin dst_wdata[94]
* pin src_addr[18]
* pin src_addr[46]
* pin dst_wdata[97]
* pin src_addr[3]
* pin src_addr[63]
* pin dst_wdata[71]
* pin src_addr[61]
* pin dst_wdata[99]
* pin src_addr[78]
* pin dst_wdata[82]
* pin dst_wstrb[15]
* pin src_addr[7]
* pin dst_wdata[7]
* pin dst_wdata[8]
* pin dst_wstrb[4]
* pin src_addr[60]
* pin src_addr[71]
* pin channel_length[67]
* pin src_addr[57]
* pin channel_length[70]
* pin src_addr[30]
* pin channel_length[9]
* pin src_addr[16]
* pin dst_wdata[9]
* pin dst_wdata[85]
* pin channel_length[69]
* pin channel_length[97]
* pin dst_wdata[74]
* pin channel_length[103]
* pin src_addr[5]
* pin dst_wdata[95]
* pin channel_length[75]
* pin channel_length[85]
* pin src_addr[108]
* pin channel_length[84]
* pin dst_wstrb[7]
* pin src_addr[114]
* pin channel_length[79]
* pin src_addr[56]
* pin dst_wdata[79]
* pin src_addr[111]
* pin channel_length[76]
* pin src_addr[102]
* pin src_addr[126]
* pin src_addr[119]
* pin src_addr[109]
* pin channel_length[78]
* pin src_addr[29]
* pin channel_length[102]
* pin channel_length[88]
* pin dst_wstrb[3]
* pin src_addr[33]
* pin channel_length[101]
* pin channel_length[90]
* pin channel_length[100]
* pin channel_length[91]
* pin src_addr[45]
* pin channel_length[73]
* pin channel_length[95]
* pin channel_length[83]
* pin src_addr[73]
* pin src_addr[21]
* pin channel_length[82]
* pin channel_length[80]
* pin channel_length[92]
* pin src_addr[74]
* pin src_addr[22]
* pin dst_wdata[81]
* pin src_addr[47]
* pin channel_length[71]
* pin src_addr[15]
* pin channel_length[64]
* pin dst_wdata[83]
* pin src_addr[36]
* pin src_addr[65]
* pin src_addr[86]
* pin dst_wstrb[10]
* pin src_addr[0]
* pin channel_length[65]
* pin channel_length[72]
* pin src_addr[70]
* pin src_addr[85]
* pin dst_wstrb[0]
* pin src_addr[79]
* pin src_addr[112]
* pin src_addr[32]
* pin src_addr[54]
* pin src_addr[77]
* pin channel_length[66]
* pin src_addr[118]
* pin src_addr[62]
* pin src_addr[44]
* pin dst_wdata[78]
* pin channel_enable[2]
* pin src_addr[125]
* pin src_addr[51]
* pin src_addr[83]
* pin src_addr[10]
* pin src_addr[40]
* pin src_addr[1]
* pin channel_length[74]
* pin channel_length[89]
* pin src_addr[34]
* pin src_addr[107]
* pin dst_wdata[88]
* pin src_addr[53]
* pin src_addr[6]
* pin src_addr[41]
* pin src_addr[11]
* pin dst_wstrb[9]
* pin dst_wstrb[13]
* pin channel_length[81]
* pin dst_wdata[98]
* pin dst_wstrb[1]
* pin src_addr[76]
* pin dst_wstrb[11]
* pin src_addr[124]
* pin src_addr[2]
* pin dst_wdata[86]
* pin src_addr[58]
* pin dst_wdata[87]
* pin src_addr[116]
* pin channel_length[77]
* pin src_addr[67]
* pin src_addr[127]
* pin dst_wdata[73]
* pin src_addr[105]
* pin src_addr[75]
* pin src_addr[104]
* pin channel_length[87]
* pin src_addr[81]
* pin src_addr[38]
* pin src_addr[101]
* pin dst_wdata[90]
* pin src_addr[110]
* pin channel_length[68]
* pin dst_wdata[89]
* pin src_addr[42]
* pin channel_length[86]
* pin src_addr[69]
* pin src_addr[25]
* pin channel_start[0]
* pin channel_length[17]
* pin channel_length[1]
* pin src_read[3]
* pin channel_length[28]
* pin channel_length[25]
* pin channel_length[8]
* pin src_addr[88]
* pin src_addr[95]
* pin channel_length[11]
* pin src_addr[93]
* pin channel_length[5]
* pin src_addr[90]
* pin src_addr[8]
* pin src_addr[98]
* pin channel_length[15]
* pin src_addr[99]
* pin channel_length[14]
* pin src_addr[96]
* pin src_addr[92]
* pin src_addr[9]
* pin channel_length[16]
* pin channel_length[2]
* pin src_addr[91]
* pin src_addr[94]
* pin channel_length[19]
* pin channel_length[20]
* pin channel_length[93]
* pin channel_busy[2]
* pin src_read[2]
* pin channel_length[0]
* pin channel_done[2]
* pin channel_length[23]
* pin src_rvalid[2]
* pin channel_length[29]
* pin channel_length[31]
* pin dst_write[3]
* pin src_rready[3]
* pin channel_busy[0]
* pin channel_done[0]
* pin channel_enable[0]
* pin debug_active_channels[1]
* pin src_rready[2]
* pin src_rvalid[0]
* pin src_read[0]
* pin src_rvalid[3]
* pin src_rready[1]
* pin debug_active_channels[3]
* pin dst_write[2]
* pin dst_wready[0]
* pin debug_active_channels[0]
* pin src_rready[0]
* pin debug_has_active_channels
* pin dst_write[0]
* pin channel_length[24]
* pin channel_length[26]
* pin channel_length[27]
* pin channel_length[10]
* pin channel_length[6]
* pin channel_length[7]
* pin channel_length[4]
* pin channel_length[12]
* pin channel_length[13]
* pin channel_length[3]
* pin channel_length[18]
* pin channel_length[21]
* pin channel_length[22]
* pin channel_length[30]
* pin dst_write[1]
* pin debug_active_channels[2]
* pin channel_start[2]
* pin dst_wready[2]
* pin channel_length[94]
.SUBCKT dma_controller 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22
+ 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48
+ 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73 74
+ 75 76 77 78 79 80 81 82 83 84 85 86 87 88 89 90 91 92 93 94 95 96 97 98 99
+ 100 101 102 103 104 105 106 107 108 109 110 111 112 113 114 115 116 117 118
+ 119 120 121 122 123 124 125 126 127 128 129 130 131 132 133 134 135 136 137
+ 138 139 140 141 142 143 144 145 146 147 148 149 150 151 152 153 154 155 156
+ 157 158 159 160 161 162 163 164 165 166 167 168 169 170 171 172 173 174 175
+ 176 177 178 179 180 181 182 183 184 185 186 187 188 189 258 259 260 261 262
+ 263 264 265 266 267 268 269 270 271 272 273 274 275 276 277 278 279 280 281
+ 282 283 284 285 286 287 288 289 290 291 292 293 294 295 296 297 298 299 300
+ 301 302 303 304 305 306 307 308 309 310 311 312 313 314 315 316 317 318 319
+ 320 321 322 323 324 325 326 327 328 329 330 331 332 333 334 335 395 428 527
+ 528 529 530 531 532 533 539 540 541 542 543 544 551 552 553 554 555 556 563
+ 564 565 566 567 568 575 576 577 578 579 580 590 591 592 593 594 595 601 602
+ 603 604 605 606 614 615 616 617 618 623 625 626 627 628 629 642 643 652 653
+ 654 655 656 676 677 688 689 690 691 709 710 711 722 723 724 738 745 746 768
+ 781 782 783 812 813 844 845 846 848 861 862 885 898 899 900 915 916 917 935
+ 936 937 949 950 951 952 983 984 1003 1016 1017 1018 1028 1029 1030 1032 1038
+ 1039 1053 1077 1078 1079 1102 1103 1104 1118 1131 1132 1178 1179 1195 1206
+ 1222 1236 1237 1265 1266 1267 1268 1269 1301 1302 1310 1321 1334 1351 1352
+ 1367 1368 1369 1387 1388 1389 1390 1391 1431 1436 1437 1438 1451 1452 1453
+ 1462 1475 1476 1485 1492 1493 1494 1517 1518 1519 1536 1537 1555 1556 1577
+ 1578 1579 1600 1601 1602 1623 1624 1625 1640 1641 1671 1672 1682 1683 1684
+ 1685 1693 1694 1695 1710 1711 1736 1737 1750 1751 1777 1778 1812 1813 1838
+ 1839 1856 1857 1858 1875 1876 1877 1892 1893 1894 1904 1905 1906 1907 1908
+ 1909 1910 1917 1918 1919 1920 1921 1922 1923 1931 1932 1933 1934 1935 1936
+ 1937 1944 1945 1946 1947 1948 1949 1950 1959 1960 1961 1962 1963 1964 1965
+ 1973 1974 1975 1976 1977 1978 1979 1986 1989 1990 1991 1992 1993 2003 2004
+ 2005 2006 2007 2021 2022 2023 2042 2043 2044 2056 2076 2077 2078 2098 2099
+ 2100 2116 2117 2118 2128 2129 2130 2131 2178 2179 2180 2196 2220 2221 2222
+ 2236 2237 2238 2254 2255 2256 2257 2259 2278 2279 2280 2281 2310 2311 2333
+ 2334 2335 2336 2361 2362 2382 2383 2384 2385 2399 2400 2417 2449 2450 2452
+ 2482 2483 2484 2485 2490 2528 2529 2530 2531 2532 2552 2553 2554 2571 2572
+ 2573 2589 2590 2602 2603 2604 2605 2606 2607 2608 2609 2610 2611 2633 2634
+ 2635 2636 2637 2655 2656 2657 2680 2681 2682 2701 2725 2726 2727 2728 2755
+ 2768 2769 2770 2771 2798 2810 2811 3168 3192 3193 3196 3198 3207 3209 3210
+ 3211 3214 3215 3216 3218 3220 3222 3223 3225 3226 3228 3229 3231 3232 3234
+ 3236 3237 3238 3239 3242 3243 3244 3245 3246 3247 3248 3249 3250 3251 3252
+ 3253 3254 3255 3256 3257 3258 3259 3260 3261 3262 3263 3264 3265 3266 3267
+ 3268 3269 3270 3271 3272 3273 3274 3275 3276 3277 3278 3279 3280 3281 3282
+ 3283 3284 3285 3286 3287
* net 1 channel_length[123]
* net 2 channel_length[124]
* net 3 channel_length[127]
* net 4 channel_length[126]
* net 5 channel_length[125]
* net 6 channel_length[96]
* net 7 channel_length[98]
* net 8 channel_length[112]
* net 9 channel_length[99]
* net 10 channel_length[119]
* net 11 channel_length[113]
* net 12 channel_length[114]
* net 13 channel_length[118]
* net 14 channel_length[116]
* net 15 channel_length[117]
* net 16 channel_length[115]
* net 17 channel_length[111]
* net 18 channel_length[104]
* net 19 channel_length[110]
* net 20 channel_length[105]
* net 21 channel_length[106]
* net 22 channel_length[108]
* net 23 channel_length[109]
* net 24 channel_length[107]
* net 25 debug_channel_state[3]
* net 26 dst_wdata[18]
* net 27 dst_wdata[36]
* net 28 dst_wdata[0]
* net 29 dst_addr[68]
* net 30 debug_transfer_count[18]
* net 31 dst_addr[95]
* net 32 dst_wdata[49]
* net 33 dst_wdata[111]
* net 34 dst_addr[107]
* net 35 dst_wdata[125]
* net 36 dst_wdata[45]
* net 37 debug_transfer_count[52]
* net 38 dst_wdata[52]
* net 39 dst_wdata[43]
* net 40 dst_addr[40]
* net 41 dst_addr[26]
* net 42 dst_addr[69]
* net 43 dst_addr[75]
* net 44 dst_addr[82]
* net 45 dst_wdata[27]
* net 46 dst_wdata[3]
* net 47 debug_transfer_count[91]
* net 48 debug_transfer_count[110]
* net 49 debug_transfer_count[69]
* net 50 dst_wdata[26]
* net 51 dst_wdata[115]
* net 52 debug_transfer_count[46]
* net 53 dst_wdata[4]
* net 54 dst_addr[35]
* net 55 dst_addr[76]
* net 56 debug_transfer_count[79]
* net 57 dst_wdata[113]
* net 58 debug_transfer_count[58]
* net 59 debug_transfer_count[64]
* net 60 debug_transfer_count[62]
* net 61 dst_addr[100]
* net 62 dst_wdata[110]
* net 63 debug_transfer_count[96]
* net 64 debug_transfer_count[77]
* net 65 debug_transfer_count[72]
* net 66 dst_wdata[41]
* net 67 debug_transfer_count[89]
* net 68 dst_addr[16]
* net 69 dst_wdata[127]
* net 70 dst_addr[17]
* net 71 dst_addr[59]
* net 72 dst_wdata[39]
* net 73 dst_wdata[54]
* net 74 dst_wdata[63]
* net 75 dst_wdata[116]
* net 76 dst_addr[64]
* net 77 dst_wdata[101]
* net 78 dst_wdata[12]
* net 79 dst_wdata[48]
* net 80 dst_addr[7]
* net 81 dst_wdata[122]
* net 82 dst_addr[57]
* net 83 dst_addr[89]
* net 84 dst_wdata[69]
* net 85 dst_addr[87]
* net 86 dst_wdata[104]
* net 87 dst_wdata[19]
* net 88 dst_wdata[105]
* net 89 dst_wdata[102]
* net 90 dst_addr[6]
* net 91 dst_addr[72]
* net 92 dst_wdata[60]
* net 93 dst_wdata[15]
* net 94 dst_addr[97]
* net 95 dst_wdata[51]
* net 96 dst_wdata[119]
* net 97 dst_addr[73]
* net 98 dst_addr[58]
* net 99 dst_wdata[32]
* net 100 dst_wdata[66]
* net 101 dst_wdata[67]
* net 102 dst_addr[8]
* net 103 dst_wdata[50]
* net 104 dst_addr[81]
* net 105 dst_addr[77]
* net 106 dst_wdata[61]
* net 107 dst_wdata[34]
* net 108 dst_wdata[65]
* net 109 dst_addr[61]
* net 110 dst_wdata[2]
* net 111 dst_addr[67]
* net 112 dst_wdata[47]
* net 113 dst_addr[84]
* net 114 dst_wdata[5]
* net 115 dst_addr[99]
* net 116 dst_wdata[37]
* net 117 dst_addr[66]
* net 118 dst_addr[91]
* net 119 dst_wdata[13]
* net 120 dst_wdata[42]
* net 121 dst_wdata[29]
* net 122 dst_wdata[124]
* net 123 dst_wdata[46]
* net 124 dst_wdata[31]
* net 125 dst_wdata[59]
* net 126 dst_wdata[68]
* net 127 dst_wdata[64]
* net 128 dst_wdata[44]
* net 129 dst_wdata[28]
* net 130 dst_wdata[1]
* net 131 dst_wdata[106]
* net 132 dst_wdata[11]
* net 133 dst_addr[78]
* net 134 dst_wdata[20]
* net 135 dst_wdata[14]
* net 136 dst_addr[55]
* net 137 dst_addr[85]
* net 138 dst_addr[88]
* net 139 dst_wdata[103]
* net 140 dst_wdata[58]
* net 141 dst_wdata[107]
* net 142 dst_addr[56]
* net 143 dst_wdata[38]
* net 144 dst_wdata[17]
* net 145 dst_wdata[56]
* net 146 dst_wdata[30]
* net 147 dst_addr[70]
* net 148 dst_wdata[35]
* net 149 dst_addr[65]
* net 150 dst_wdata[118]
* net 151 dst_wdata[53]
* net 152 dst_wdata[121]
* net 153 dst_wdata[33]
* net 154 dst_addr[96]
* net 155 dst_wdata[126]
* net 156 dst_wdata[123]
* net 157 dst_wdata[25]
* net 158 dst_wdata[23]
* net 159 dst_addr[94]
* net 160 dst_addr[92]
* net 161 dst_wdata[117]
* net 162 dst_addr[9]
* net 163 dst_wdata[120]
* net 164 dst_wdata[22]
* net 165 dst_addr[71]
* net 166 dst_wdata[55]
* net 167 dst_addr[98]
* net 168 dst_addr[5]
* net 169 dst_wdata[21]
* net 170 dst_wdata[100]
* net 171 dst_addr[93]
* net 172 dst_wdata[108]
* net 173 dst_addr[74]
* net 174 dst_wdata[57]
* net 175 dst_addr[62]
* net 176 dst_wdata[24]
* net 177 dst_addr[63]
* net 178 dst_addr[90]
* net 179 dst_wdata[112]
* net 180 dst_wdata[16]
* net 181 dst_addr[60]
* net 182 dst_wdata[109]
* net 183 dst_addr[83]
* net 184 dst_wdata[114]
* net 185 dst_wdata[40]
* net 186 dst_wdata[10]
* net 187 dst_addr[80]
* net 188 dst_addr[79]
* net 189 dst_addr[86]
* net 258 debug_channel_state[11]
* net 259 debug_transfer_count[95]
* net 260 debug_transfer_count[7]
* net 261 debug_transfer_count[120]
* net 262 dst_addr[121]
* net 263 dst_addr[39]
* net 264 debug_transfer_count[40]
* net 265 dst_addr[24]
* net 266 debug_transfer_count[21]
* net 267 dst_addr[115]
* net 268 dst_addr[4]
* net 269 debug_transfer_count[103]
* net 270 dst_addr[45]
* net 271 debug_transfer_count[3]
* net 272 debug_transfer_count[54]
* net 273 dst_addr[104]
* net 274 debug_transfer_count[37]
* net 275 debug_transfer_count[98]
* net 276 debug_transfer_count[70]
* net 277 dst_addr[10]
* net 278 debug_transfer_count[38]
* net 279 dst_addr[52]
* net 280 debug_transfer_count[6]
* net 281 dst_addr[12]
* net 282 debug_transfer_count[73]
* net 283 debug_transfer_count[90]
* net 284 debug_transfer_count[127]
* net 285 dst_addr[108]
* net 286 debug_transfer_count[42]
* net 287 dst_addr[28]
* net 288 dst_addr[109]
* net 289 debug_transfer_count[105]
* net 290 debug_transfer_count[25]
* net 291 debug_transfer_count[9]
* net 292 dst_addr[41]
* net 293 debug_transfer_count[15]
* net 294 debug_transfer_count[116]
* net 295 dst_addr[113]
* net 296 debug_channel_state[0]
* net 297 dst_addr[127]
* net 298 dst_addr[30]
* net 299 dst_addr[119]
* net 300 dst_addr[101]
* net 301 debug_transfer_count[84]
* net 302 debug_transfer_count[19]
* net 303 dst_addr[44]
* net 304 dst_addr[15]
* net 305 debug_transfer_count[114]
* net 306 debug_transfer_count[55]
* net 307 dst_addr[110]
* net 308 dst_addr[126]
* net 309 dst_addr[23]
* net 310 debug_transfer_count[63]
* net 311 debug_transfer_count[27]
* net 312 dst_addr[18]
* net 313 debug_transfer_count[99]
* net 314 debug_transfer_count[66]
* net 315 debug_transfer_count[13]
* net 316 debug_transfer_count[23]
* net 317 dst_addr[38]
* net 318 debug_transfer_count[67]
* net 319 debug_transfer_count[101]
* net 320 dst_addr[31]
* net 321 debug_transfer_count[59]
* net 322 debug_transfer_count[78]
* net 323 debug_channel_state[2]
* net 324 debug_transfer_count[44]
* net 325 debug_transfer_count[60]
* net 326 debug_transfer_count[85]
* net 327 debug_transfer_count[24]
* net 328 debug_transfer_count[28]
* net 329 debug_transfer_count[31]
* net 330 debug_transfer_count[104]
* net 331 debug_transfer_count[1]
* net 332 debug_transfer_count[113]
* net 333 dst_addr[105]
* net 334 dst_addr[27]
* net 335 debug_transfer_count[47]
* net 395 NWELL
* net 428 PWELL
* net 527 debug_transfer_count[71]
* net 528 debug_transfer_count[112]
* net 529 debug_channel_state[8]
* net 530 debug_transfer_count[126]
* net 531 debug_transfer_count[49]
* net 532 dst_addr[102]
* net 533 debug_transfer_count[4]
* net 539 debug_transfer_count[124]
* net 540 debug_transfer_count[39]
* net 541 debug_transfer_count[48]
* net 542 dst_addr[1]
* net 543 debug_transfer_count[97]
* net 544 debug_transfer_count[26]
* net 551 channel_error[2]
* net 552 debug_transfer_count[2]
* net 553 debug_transfer_count[121]
* net 554 debug_transfer_count[109]
* net 555 debug_transfer_count[119]
* net 556 dst_addr[46]
* net 563 dst_addr[34]
* net 564 debug_transfer_count[20]
* net 565 dst_addr[14]
* net 566 debug_channel_state[1]
* net 567 debug_transfer_count[32]
* net 568 debug_transfer_count[5]
* net 575 dst_addr[33]
* net 576 debug_transfer_count[106]
* net 577 debug_transfer_count[107]
* net 578 dst_addr[114]
* net 579 debug_channel_state[9]
* net 580 dst_addr[2]
* net 590 debug_transfer_count[75]
* net 591 debug_transfer_count[86]
* net 592 debug_transfer_count[51]
* net 593 debug_transfer_count[61]
* net 594 dst_addr[29]
* net 595 debug_transfer_count[82]
* net 601 dst_addr[13]
* net 602 debug_transfer_count[115]
* net 603 dst_addr[36]
* net 604 debug_transfer_count[30]
* net 605 debug_transfer_count[10]
* net 606 dst_addr[47]
* net 614 dst_addr[43]
* net 615 debug_transfer_count[17]
* net 616 debug_transfer_count[29]
* net 617 debug_transfer_count[80]
* net 618 debug_transfer_count[68]
* net 623 src_addr[97]
* net 625 debug_transfer_count[74]
* net 626 dst_addr[120]
* net 627 dst_addr[22]
* net 628 debug_transfer_count[22]
* net 629 debug_transfer_count[76]
* net 642 dst_addr[112]
* net 643 dst_addr[103]
* net 652 dst_addr[32]
* net 653 dst_addr[20]
* net 654 debug_transfer_count[117]
* net 655 dst_addr[19]
* net 656 debug_transfer_count[87]
* net 676 debug_transfer_count[34]
* net 677 debug_transfer_count[11]
* net 688 dst_addr[0]
* net 689 debug_transfer_count[123]
* net 690 debug_transfer_count[65]
* net 691 debug_transfer_count[125]
* net 709 dst_addr[11]
* net 710 debug_transfer_count[122]
* net 711 debug_transfer_count[12]
* net 722 dst_addr[111]
* net 723 dst_addr[48]
* net 724 dst_addr[118]
* net 738 src_addr[89]
* net 745 debug_transfer_count[88]
* net 746 dst_addr[122]
* net 768 debug_channel_state[7]
* net 781 debug_transfer_count[45]
* net 782 dst_addr[3]
* net 783 dst_addr[124]
* net 812 debug_transfer_count[94]
* net 813 dst_addr[51]
* net 844 debug_transfer_count[108]
* net 845 debug_transfer_count[57]
* net 846 debug_transfer_count[56]
* net 848 debug_transfer_count[16]
* net 861 channel_length[60]
* net 862 channel_length[59]
* net 885 debug_channel_state[10]
* net 898 channel_length[61]
* net 899 channel_length[58]
* net 900 channel_length[63]
* net 915 dst_addr[125]
* net 916 debug_transfer_count[102]
* net 917 dst_addr[117]
* net 935 channel_length[56]
* net 936 channel_length[62]
* net 937 channel_length[57]
* net 949 dst_addr[106]
* net 950 dst_addr[25]
* net 951 debug_transfer_count[33]
* net 952 debug_transfer_count[92]
* net 983 debug_transfer_count[8]
* net 984 debug_transfer_count[43]
* net 1003 debug_transfer_count[53]
* net 1016 channel_length[48]
* net 1017 channel_length[55]
* net 1018 channel_length[50]
* net 1028 channel_error[0]
* net 1029 dst_addr[37]
* net 1030 debug_transfer_count[41]
* net 1032 debug_transfer_count[111]
* net 1038 channel_length[51]
* net 1039 channel_length[49]
* net 1053 debug_transfer_count[14]
* net 1077 channel_length[54]
* net 1078 channel_length[53]
* net 1079 channel_length[52]
* net 1102 dst_addr[116]
* net 1103 channel_error[3]
* net 1104 dst_addr[42]
* net 1118 channel_length[120]
* net 1131 channel_error[1]
* net 1132 debug_transfer_count[83]
* net 1178 dst_addr[49]
* net 1179 debug_transfer_count[93]
* net 1195 channel_length[121]
* net 1206 debug_channel_state[5]
* net 1222 channel_length[122]
* net 1236 dst_addr[50]
* net 1237 dst_addr[53]
* net 1265 dst_addr[21]
* net 1266 debug_transfer_count[100]
* net 1267 debug_transfer_count[0]
* net 1268 debug_transfer_count[118]
* net 1269 debug_channel_state[4]
* net 1301 debug_transfer_count[35]
* net 1302 debug_transfer_count[36]
* net 1310 channel_done[1]
* net 1321 dst_addr[123]
* net 1334 rst_n
* net 1351 debug_channel_state[6]
* net 1352 debug_transfer_count[50]
* net 1367 channel_length[45]
* net 1368 channel_length[46]
* net 1369 channel_length[44]
* net 1387 dst_addr[54]
* net 1388 debug_transfer_count[81]
* net 1389 src_addr[26]
* net 1390 src_addr[39]
* net 1391 channel_length[47]
* net 1431 src_addr[19]
* net 1436 channel_done[3]
* net 1437 channel_start[1]
* net 1438 channel_enable[1]
* net 1451 src_addr[87]
* net 1452 dst_wdata[92]
* net 1453 src_addr[14]
* net 1462 src_addr[115]
* net 1475 channel_busy[1]
* net 1476 channel_length[43]
* net 1485 dst_wdata[84]
* net 1492 channel_length[32]
* net 1493 channel_length[42]
* net 1494 dst_wready[3]
* net 1517 src_addr[35]
* net 1518 src_addr[48]
* net 1519 dst_wstrb[14]
* net 1536 channel_start[3]
* net 1537 channel_length[40]
* net 1555 dst_wdata[77]
* net 1556 src_addr[59]
* net 1577 channel_length[33]
* net 1578 channel_length[35]
* net 1579 channel_length[41]
* net 1600 src_addr[123]
* net 1601 src_addr[120]
* net 1602 src_addr[43]
* net 1623 channel_length[36]
* net 1624 channel_length[37]
* net 1625 channel_enable[3]
* net 1640 dst_wdata[75]
* net 1641 dst_wstrb[8]
* net 1671 channel_length[34]
* net 1672 src_read[1]
* net 1682 dst_wstrb[2]
* net 1683 src_addr[12]
* net 1684 dst_wstrb[5]
* net 1685 src_addr[24]
* net 1693 dst_wready[1]
* net 1694 channel_busy[3]
* net 1695 src_rvalid[1]
* net 1710 src_addr[113]
* net 1711 src_addr[37]
* net 1736 channel_length[38]
* net 1737 channel_length[39]
* net 1750 src_addr[52]
* net 1751 dst_wstrb[6]
* net 1777 src_addr[27]
* net 1778 dst_wdata[91]
* net 1812 src_addr[23]
* net 1813 src_addr[66]
* net 1838 src_addr[68]
* net 1839 src_addr[4]
* net 1856 dst_wdata[62]
* net 1857 src_addr[100]
* net 1858 src_addr[17]
* net 1875 src_addr[106]
* net 1876 src_addr[55]
* net 1877 src_addr[117]
* net 1892 src_addr[50]
* net 1893 src_addr[64]
* net 1894 dst_wdata[96]
* net 1904 src_addr[80]
* net 1905 src_addr[31]
* net 1906 dst_wdata[93]
* net 1907 src_addr[49]
* net 1908 dst_wdata[6]
* net 1909 dst_wdata[80]
* net 1910 src_addr[121]
* net 1917 clk
* net 1918 src_addr[72]
* net 1919 src_addr[13]
* net 1920 dst_wstrb[12]
* net 1921 src_addr[20]
* net 1922 src_addr[28]
* net 1923 src_addr[84]
* net 1931 src_addr[82]
* net 1932 src_addr[122]
* net 1933 dst_wdata[72]
* net 1934 dst_wdata[76]
* net 1935 src_addr[103]
* net 1936 dst_wdata[70]
* net 1937 dst_wdata[94]
* net 1944 src_addr[18]
* net 1945 src_addr[46]
* net 1946 dst_wdata[97]
* net 1947 src_addr[3]
* net 1948 src_addr[63]
* net 1949 dst_wdata[71]
* net 1950 src_addr[61]
* net 1959 dst_wdata[99]
* net 1960 src_addr[78]
* net 1961 dst_wdata[82]
* net 1962 dst_wstrb[15]
* net 1963 src_addr[7]
* net 1964 dst_wdata[7]
* net 1965 dst_wdata[8]
* net 1973 dst_wstrb[4]
* net 1974 src_addr[60]
* net 1975 src_addr[71]
* net 1976 channel_length[67]
* net 1977 src_addr[57]
* net 1978 channel_length[70]
* net 1979 src_addr[30]
* net 1986 channel_length[9]
* net 1989 src_addr[16]
* net 1990 dst_wdata[9]
* net 1991 dst_wdata[85]
* net 1992 channel_length[69]
* net 1993 channel_length[97]
* net 2003 dst_wdata[74]
* net 2004 channel_length[103]
* net 2005 src_addr[5]
* net 2006 dst_wdata[95]
* net 2007 channel_length[75]
* net 2021 channel_length[85]
* net 2022 src_addr[108]
* net 2023 channel_length[84]
* net 2042 dst_wstrb[7]
* net 2043 src_addr[114]
* net 2044 channel_length[79]
* net 2056 src_addr[56]
* net 2076 dst_wdata[79]
* net 2077 src_addr[111]
* net 2078 channel_length[76]
* net 2098 src_addr[102]
* net 2099 src_addr[126]
* net 2100 src_addr[119]
* net 2116 src_addr[109]
* net 2117 channel_length[78]
* net 2118 src_addr[29]
* net 2128 channel_length[102]
* net 2129 channel_length[88]
* net 2130 dst_wstrb[3]
* net 2131 src_addr[33]
* net 2178 channel_length[101]
* net 2179 channel_length[90]
* net 2180 channel_length[100]
* net 2196 channel_length[91]
* net 2220 src_addr[45]
* net 2221 channel_length[73]
* net 2222 channel_length[95]
* net 2236 channel_length[83]
* net 2237 src_addr[73]
* net 2238 src_addr[21]
* net 2254 channel_length[82]
* net 2255 channel_length[80]
* net 2256 channel_length[92]
* net 2257 src_addr[74]
* net 2259 src_addr[22]
* net 2278 dst_wdata[81]
* net 2279 src_addr[47]
* net 2280 channel_length[71]
* net 2281 src_addr[15]
* net 2310 channel_length[64]
* net 2311 dst_wdata[83]
* net 2333 src_addr[36]
* net 2334 src_addr[65]
* net 2335 src_addr[86]
* net 2336 dst_wstrb[10]
* net 2361 src_addr[0]
* net 2362 channel_length[65]
* net 2382 channel_length[72]
* net 2383 src_addr[70]
* net 2384 src_addr[85]
* net 2385 dst_wstrb[0]
* net 2399 src_addr[79]
* net 2400 src_addr[112]
* net 2417 src_addr[32]
* net 2449 src_addr[54]
* net 2450 src_addr[77]
* net 2452 channel_length[66]
* net 2482 src_addr[118]
* net 2483 src_addr[62]
* net 2484 src_addr[44]
* net 2485 dst_wdata[78]
* net 2490 channel_enable[2]
* net 2528 src_addr[125]
* net 2529 src_addr[51]
* net 2530 src_addr[83]
* net 2531 src_addr[10]
* net 2532 src_addr[40]
* net 2552 src_addr[1]
* net 2553 channel_length[74]
* net 2554 channel_length[89]
* net 2571 src_addr[34]
* net 2572 src_addr[107]
* net 2573 dst_wdata[88]
* net 2589 src_addr[53]
* net 2590 src_addr[6]
* net 2602 src_addr[41]
* net 2603 src_addr[11]
* net 2604 dst_wstrb[9]
* net 2605 dst_wstrb[13]
* net 2606 channel_length[81]
* net 2607 dst_wdata[98]
* net 2608 dst_wstrb[1]
* net 2609 src_addr[76]
* net 2610 dst_wstrb[11]
* net 2611 src_addr[124]
* net 2633 src_addr[2]
* net 2634 dst_wdata[86]
* net 2635 src_addr[58]
* net 2636 dst_wdata[87]
* net 2637 src_addr[116]
* net 2655 channel_length[77]
* net 2656 src_addr[67]
* net 2657 src_addr[127]
* net 2680 dst_wdata[73]
* net 2681 src_addr[105]
* net 2682 src_addr[75]
* net 2701 src_addr[104]
* net 2725 channel_length[87]
* net 2726 src_addr[81]
* net 2727 src_addr[38]
* net 2728 src_addr[101]
* net 2755 dst_wdata[90]
* net 2768 src_addr[110]
* net 2769 channel_length[68]
* net 2770 dst_wdata[89]
* net 2771 src_addr[42]
* net 2798 channel_length[86]
* net 2810 src_addr[69]
* net 2811 src_addr[25]
* net 3168 channel_start[0]
* net 3192 channel_length[17]
* net 3193 channel_length[1]
* net 3196 src_read[3]
* net 3198 channel_length[28]
* net 3207 channel_length[25]
* net 3209 channel_length[8]
* net 3210 src_addr[88]
* net 3211 src_addr[95]
* net 3214 channel_length[11]
* net 3215 src_addr[93]
* net 3216 channel_length[5]
* net 3218 src_addr[90]
* net 3220 src_addr[8]
* net 3222 src_addr[98]
* net 3223 channel_length[15]
* net 3225 src_addr[99]
* net 3226 channel_length[14]
* net 3228 src_addr[96]
* net 3229 src_addr[92]
* net 3231 src_addr[9]
* net 3232 channel_length[16]
* net 3234 channel_length[2]
* net 3236 src_addr[91]
* net 3237 src_addr[94]
* net 3238 channel_length[19]
* net 3239 channel_length[20]
* net 3242 channel_length[93]
* net 3243 channel_busy[2]
* net 3244 src_read[2]
* net 3245 channel_length[0]
* net 3246 channel_done[2]
* net 3247 channel_length[23]
* net 3248 src_rvalid[2]
* net 3249 channel_length[29]
* net 3250 channel_length[31]
* net 3251 dst_write[3]
* net 3252 src_rready[3]
* net 3253 channel_busy[0]
* net 3254 channel_done[0]
* net 3255 channel_enable[0]
* net 3256 debug_active_channels[1]
* net 3257 src_rready[2]
* net 3258 src_rvalid[0]
* net 3259 src_read[0]
* net 3260 src_rvalid[3]
* net 3261 src_rready[1]
* net 3262 debug_active_channels[3]
* net 3263 dst_write[2]
* net 3264 dst_wready[0]
* net 3265 debug_active_channels[0]
* net 3266 src_rready[0]
* net 3267 debug_has_active_channels
* net 3268 dst_write[0]
* net 3269 channel_length[24]
* net 3270 channel_length[26]
* net 3271 channel_length[27]
* net 3272 channel_length[10]
* net 3273 channel_length[6]
* net 3274 channel_length[7]
* net 3275 channel_length[4]
* net 3276 channel_length[12]
* net 3277 channel_length[13]
* net 3278 channel_length[3]
* net 3279 channel_length[18]
* net 3280 channel_length[21]
* net 3281 channel_length[22]
* net 3282 channel_length[30]
* net 3283 dst_write[1]
* net 3284 debug_active_channels[2]
* net 3285 channel_start[2]
* net 3286 dst_wready[2]
* net 3287 channel_length[94]
* cell instance $2 r0 *1 126.54,1.4
X$2 1 428 395 337 BUF_X2
* cell instance $8 r0 *1 129.2,1.4
X$8 2 428 395 613 CLKBUF_X2
* cell instance $15 r0 *1 128.44,1.4
X$15 3 428 395 338 CLKBUF_X2
* cell instance $20 r0 *1 129.96,1.4
X$20 4 428 395 336 CLKBUF_X2
* cell instance $26 r0 *1 130.91,1.4
X$26 5 428 395 658 CLKBUF_X2
* cell instance $32 r0 *1 131.86,1.4
X$32 6 428 395 339 BUF_X1
* cell instance $38 r0 *1 133.57,1.4
X$38 7 428 395 1261 BUF_X2
* cell instance $47 r0 *1 136.61,1.4
X$47 8 428 395 637 BUF_X1
* cell instance $51 r0 *1 135.85,1.4
X$51 9 428 395 341 BUF_X2
* cell instance $57 m0 *1 136.23,4.2
X$57 10 428 395 190 CLKBUF_X2
* cell instance $62 r0 *1 137.37,1.4
X$62 11 428 395 649 BUF_X1
* cell instance $68 r0 *1 138.89,1.4
X$68 12 428 395 588 BUF_X1
* cell instance $75 r0 *1 138.13,1.4
X$75 13 428 395 191 CLKBUF_X2
* cell instance $80 m0 *1 138.51,4.2
X$80 14 428 395 340 CLKBUF_X2
* cell instance $86 r0 *1 139.65,1.4
X$86 15 428 395 702 CLKBUF_X2
* cell instance $92 r0 *1 141.17,1.4
X$92 16 428 395 589 BUF_X1
* cell instance $102 r0 *1 151.81,1.4
X$102 17 428 395 192 BUF_X2
* cell instance $104 r0 *1 152.76,1.4
X$104 18 428 395 342 BUF_X2
* cell instance $110 m0 *1 154.09,4.2
X$110 19 428 395 947 CLKBUF_X2
* cell instance $117 r0 *1 153.71,1.4
X$117 20 428 395 193 BUF_X2
* cell instance $126 r0 *1 155.23,1.4
X$126 21 428 395 194 BUF_X2
* cell instance $129 r0 *1 154.47,1.4
X$129 22 428 395 1129 BUF_X2
* cell instance $134 r0 *1 156.18,1.4
X$134 23 428 395 195 CLKBUF_X2
* cell instance $140 m0 *1 156.75,4.2
X$140 24 428 395 1300 BUF_X2
* cell instance $146 r0 *1 157.13,1.4
X$146 196 428 395 25 BUF_X1
* cell instance $152 m0 *1 155.99,4.2
X$152 343 428 395 26 BUF_X1
* cell instance $158 r0 *1 158.08,1.4
X$158 197 428 395 27 BUF_X1
* cell instance $164 r0 *1 158.65,1.4
X$164 346 428 395 28 BUF_X1
* cell instance $170 r0 *1 159.22,1.4
X$170 345 428 395 29 BUF_X1
* cell instance $176 r0 *1 159.79,1.4
X$176 198 428 395 30 BUF_X1
* cell instance $182 m0 *1 160.36,4.2
X$182 344 428 395 31 BUF_X1
* cell instance $188 r0 *1 160.74,1.4
X$188 199 428 395 32 BUF_X1
* cell instance $198 r0 *1 161.5,1.4
X$198 200 428 395 33 BUF_X1
* cell instance $204 r0 *1 162.07,1.4
X$204 201 428 395 34 BUF_X1
* cell instance $206 r0 *1 162.64,1.4
X$206 202 428 395 35 BUF_X1
* cell instance $212 r0 *1 163.21,1.4
X$212 203 428 395 36 BUF_X1
* cell instance $218 r0 *1 163.78,1.4
X$218 348 428 395 37 BUF_X1
* cell instance $224 r0 *1 164.35,1.4
X$224 347 428 395 38 BUF_X1
* cell instance $230 r0 *1 164.92,1.4
X$230 204 428 395 39 BUF_X1
* cell instance $236 r0 *1 165.49,1.4
X$236 350 428 395 40 BUF_X1
* cell instance $242 r0 *1 166.25,1.4
X$242 205 428 395 41 BUF_X1
* cell instance $248 r0 *1 166.82,1.4
X$248 206 428 395 42 BUF_X1
* cell instance $254 r0 *1 167.39,1.4
X$254 349 428 395 43 BUF_X1
* cell instance $260 r0 *1 168.15,1.4
X$260 354 428 395 44 BUF_X1
* cell instance $266 r0 *1 167.77,4.2
X$266 355 428 395 45 BUF_X1
* cell instance $272 r0 *1 168.72,1.4
X$272 207 428 395 46 BUF_X1
* cell instance $282 r0 *1 169.29,1.4
X$282 353 428 395 47 BUF_X1
* cell instance $288 r0 *1 169.86,1.4
X$288 352 428 395 48 BUF_X1
* cell instance $290 r0 *1 170.43,1.4
X$290 208 428 395 49 BUF_X1
* cell instance $296 m0 *1 170.62,4.2
X$296 351 428 395 50 BUF_X1
* cell instance $302 r0 *1 171.38,1.4
X$302 361 428 395 51 BUF_X1
* cell instance $308 r0 *1 171.95,1.4
X$308 360 428 395 52 BUF_X1
* cell instance $314 r0 *1 172.52,1.4
X$314 359 428 395 53 BUF_X1
* cell instance $320 r0 *1 173.09,1.4
X$320 358 428 395 54 BUF_X1
* cell instance $326 r0 *1 173.66,1.4
X$326 357 428 395 55 BUF_X1
* cell instance $332 r0 *1 174.23,1.4
X$332 356 428 395 56 BUF_X1
* cell instance $338 r0 *1 174.8,1.4
X$338 368 428 395 57 BUF_X1
* cell instance $344 r0 *1 175.37,1.4
X$344 367 428 395 58 BUF_X1
* cell instance $350 r0 *1 175.94,1.4
X$350 366 428 395 59 BUF_X1
* cell instance $356 r0 *1 176.51,1.4
X$356 365 428 395 60 BUF_X1
* cell instance $362 r0 *1 177.08,1.4
X$362 364 428 395 61 BUF_X1
* cell instance $368 r0 *1 177.65,1.4
X$368 363 428 395 62 BUF_X1
* cell instance $374 r0 *1 178.22,1.4
X$374 362 428 395 63 BUF_X1
* cell instance $384 r0 *1 178.79,1.4
X$384 372 428 395 64 BUF_X1
* cell instance $390 r0 *1 179.36,1.4
X$390 371 428 395 65 BUF_X1
* cell instance $392 r0 *1 179.93,1.4
X$392 370 428 395 66 BUF_X1
* cell instance $398 r0 *1 180.5,1.4
X$398 369 428 395 67 BUF_X1
* cell instance $404 m0 *1 181.07,4.2
X$404 209 428 395 68 BUF_X1
* cell instance $410 r0 *1 181.45,1.4
X$410 210 428 395 69 BUF_X1
* cell instance $416 r0 *1 182.02,1.4
X$416 211 428 395 70 BUF_X1
* cell instance $422 r0 *1 182.59,1.4
X$422 376 428 395 71 BUF_X1
* cell instance $428 r0 *1 183.16,1.4
X$428 375 428 395 72 BUF_X1
* cell instance $434 r0 *1 183.73,1.4
X$434 212 428 395 73 BUF_X1
* cell instance $440 r0 *1 184.3,1.4
X$440 374 428 395 74 BUF_X1
* cell instance $446 r0 *1 184.87,1.4
X$446 373 428 395 75 BUF_X1
* cell instance $452 r0 *1 185.44,1.4
X$452 382 428 395 76 BUF_X1
* cell instance $458 r0 *1 186.01,1.4
X$458 381 428 395 77 BUF_X1
* cell instance $464 r0 *1 186.58,1.4
X$464 380 428 395 78 BUF_X1
* cell instance $470 r0 *1 187.15,1.4
X$470 379 428 395 79 BUF_X1
* cell instance $476 r0 *1 187.72,1.4
X$476 378 428 395 80 BUF_X1
* cell instance $482 r0 *1 188.29,1.4
X$482 377 428 395 81 BUF_X1
* cell instance $488 r0 *1 188.86,1.4
X$488 213 428 395 82 BUF_X1
* cell instance $494 r0 *1 189.43,1.4
X$494 389 428 395 83 BUF_X1
* cell instance $500 r0 *1 190,1.4
X$500 388 428 395 84 BUF_X1
* cell instance $506 r0 *1 190.57,1.4
X$506 387 428 395 85 BUF_X1
* cell instance $512 r0 *1 191.14,1.4
X$512 386 428 395 86 BUF_X1
* cell instance $518 r0 *1 191.71,1.4
X$518 385 428 395 87 BUF_X1
* cell instance $524 r0 *1 192.28,1.4
X$524 384 428 395 88 BUF_X1
* cell instance $530 r0 *1 192.85,1.4
X$530 383 428 395 89 BUF_X1
* cell instance $540 r0 *1 193.42,1.4
X$540 394 428 395 90 BUF_X1
* cell instance $546 r0 *1 193.99,1.4
X$546 393 428 395 91 BUF_X1
* cell instance $548 r0 *1 194.56,1.4
X$548 392 428 395 92 BUF_X1
* cell instance $554 r0 *1 195.13,1.4
X$554 391 428 395 93 BUF_X1
* cell instance $560 r0 *1 195.89,1.4
X$560 214 428 395 94 BUF_X1
* cell instance $566 m0 *1 196.27,4.2
X$566 390 428 395 95 BUF_X1
* cell instance $572 r0 *1 197.41,4.2
X$572 398 428 395 96 BUF_X1
* cell instance $578 r0 *1 197.41,1.4
X$578 397 428 395 97 BUF_X1
* cell instance $584 r0 *1 198.17,1.4
X$584 396 428 395 98 BUF_X1
* cell instance $590 r0 *1 198.93,1.4
X$590 216 428 395 99 BUF_X1
* cell instance $596 r0 *1 196.65,1.4
X$596 215 428 395 100 BUF_X1
* cell instance $602 r0 *1 199.69,1.4
X$602 217 428 395 101 BUF_X1
* cell instance $608 r0 *1 200.26,1.4
X$608 400 428 395 102 BUF_X1
* cell instance $614 r0 *1 201.02,1.4
X$614 399 428 395 103 BUF_X1
* cell instance $620 m0 *1 201.4,4.2
X$620 218 428 395 104 BUF_X1
* cell instance $630 r0 *1 201.78,1.4
X$630 219 428 395 105 BUF_X1
* cell instance $632 r0 *1 202.35,1.4
X$632 220 428 395 106 BUF_X1
* cell instance $638 r0 *1 202.92,1.4
X$638 404 428 395 107 BUF_X1
* cell instance $644 r0 *1 204.06,1.4
X$644 402 428 395 108 BUF_X1
* cell instance $650 r0 *1 203.49,1.4
X$650 403 428 395 109 BUF_X1
* cell instance $656 r0 *1 204.82,1.4
X$656 401 428 395 110 BUF_X1
* cell instance $662 r0 *1 205.58,1.4
X$662 221 428 395 111 BUF_X1
* cell instance $668 r0 *1 206.91,1.4
X$668 222 428 395 112 BUF_X1
* cell instance $674 m0 *1 206.53,4.2
X$674 409 428 395 113 BUF_X1
* cell instance $680 r0 *1 206.15,1.4
X$680 410 428 395 114 BUF_X1
* cell instance $686 r0 *1 207.48,1.4
X$686 408 428 395 115 BUF_X1
* cell instance $692 r0 *1 208.24,1.4
X$692 406 428 395 116 BUF_X1
* cell instance $698 r0 *1 208.81,1.4
X$698 405 428 395 117 BUF_X1
* cell instance $704 r0 *1 208.05,4.2
X$704 407 428 395 118 BUF_X1
* cell instance $710 r0 *1 209.57,1.4
X$710 413 428 395 119 BUF_X1
* cell instance $716 r0 *1 210.14,1.4
X$716 223 428 395 120 BUF_X1
* cell instance $722 r0 *1 211.28,4.2
X$722 411 428 395 121 BUF_X1
* cell instance $728 r0 *1 211.09,1.4
X$728 412 428 395 122 BUF_X1
* cell instance $734 r0 *1 212.04,1.4
X$734 224 428 395 123 BUF_X1
* cell instance $740 r0 *1 212.61,1.4
X$740 225 428 395 124 BUF_X1
* cell instance $746 m0 *1 212.99,4.2
X$746 416 428 395 125 BUF_X1
* cell instance $752 r0 *1 213.75,1.4
X$752 226 428 395 126 BUF_X1
* cell instance $758 r0 *1 214.32,1.4
X$758 415 428 395 127 BUF_X1
* cell instance $764 r0 *1 214.89,1.4
X$764 227 428 395 128 BUF_X1
* cell instance $770 r0 *1 215.46,1.4
X$770 414 428 395 129 BUF_X1
* cell instance $776 r0 *1 216.03,1.4
X$776 228 428 395 130 BUF_X1
* cell instance $782 m0 *1 215.65,4.2
X$782 422 428 395 131 BUF_X1
* cell instance $788 r0 *1 216.79,1.4
X$788 421 428 395 132 BUF_X1
* cell instance $794 r0 *1 217.36,1.4
X$794 420 428 395 133 BUF_X1
* cell instance $800 r0 *1 217.93,1.4
X$800 419 428 395 134 BUF_X1
* cell instance $806 r0 *1 218.5,1.4
X$806 418 428 395 135 BUF_X1
* cell instance $812 r0 *1 219.07,1.4
X$812 417 428 395 136 BUF_X1
* cell instance $818 r0 *1 223.82,1.4
X$818 425 428 395 137 BUF_X1
* cell instance $824 r0 *1 224.39,1.4
X$824 424 428 395 138 BUF_X1
* cell instance $830 r0 *1 224.96,1.4
X$830 423 428 395 139 BUF_X1
* cell instance $836 r0 *1 225.91,1.4
X$836 229 428 395 140 BUF_X1
* cell instance $842 r0 *1 226.48,1.4
X$842 230 428 395 141 BUF_X1
* cell instance $848 r0 *1 227.05,1.4
X$848 231 428 395 142 BUF_X1
* cell instance $854 m0 *1 227.62,4.2
X$854 427 428 395 143 BUF_X1
* cell instance $860 r0 *1 228.19,1.4
X$860 426 428 395 144 BUF_X1
* cell instance $866 r0 *1 228.76,1.4
X$866 430 428 395 145 BUF_X1
* cell instance $876 r0 *1 229.33,1.4
X$876 232 428 395 146 BUF_X1
* cell instance $882 r0 *1 229.9,1.4
X$882 233 428 395 147 BUF_X1
* cell instance $888 r0 *1 230.47,1.4
X$888 429 428 395 148 BUF_X1
* cell instance $890 r0 *1 231.04,1.4
X$890 234 428 395 149 BUF_X1
* cell instance $896 r0 *1 231.61,1.4
X$896 235 428 395 150 BUF_X1
* cell instance $902 m0 *1 232.18,4.2
X$902 434 428 395 151 BUF_X1
* cell instance $908 r0 *1 232.56,1.4
X$908 236 428 395 152 BUF_X1
* cell instance $914 r0 *1 233.13,1.4
X$914 433 428 395 153 BUF_X1
* cell instance $920 r0 *1 233.7,1.4
X$920 432 428 395 154 BUF_X1
* cell instance $926 m0 *1 234.08,4.2
X$926 431 428 395 155 BUF_X1
* cell instance $932 r0 *1 234.65,1.4
X$932 440 428 395 156 BUF_X1
* cell instance $938 r0 *1 235.22,1.4
X$938 439 428 395 157 BUF_X1
* cell instance $944 r0 *1 235.79,1.4
X$944 438 428 395 158 BUF_X1
* cell instance $950 r0 *1 236.36,1.4
X$950 437 428 395 159 BUF_X1
* cell instance $956 r0 *1 236.93,1.4
X$956 436 428 395 160 BUF_X1
* cell instance $962 r0 *1 237.5,1.4
X$962 435 428 395 161 BUF_X1
* cell instance $968 r0 *1 238.07,1.4
X$968 445 428 395 162 BUF_X1
* cell instance $974 r0 *1 238.64,1.4
X$974 444 428 395 163 BUF_X1
* cell instance $980 r0 *1 239.21,1.4
X$980 443 428 395 164 BUF_X1
* cell instance $986 r0 *1 239.78,1.4
X$986 442 428 395 165 BUF_X1
* cell instance $992 r0 *1 241.68,1.4
X$992 238 428 395 166 BUF_X1
* cell instance $998 r0 *1 241.11,1.4
X$998 237 428 395 167 BUF_X1
* cell instance $1004 r0 *1 241.3,4.2
X$1004 441 428 395 168 BUF_X1
* cell instance $1010 r0 *1 242.25,4.2
X$1010 449 428 395 169 BUF_X1
* cell instance $1016 r0 *1 242.82,1.4
X$1016 447 428 395 170 BUF_X1
* cell instance $1022 r0 *1 243.39,1.4
X$1022 239 428 395 171 BUF_X1
* cell instance $1028 r0 *1 242.25,1.4
X$1028 448 428 395 172 BUF_X1
* cell instance $1034 r0 *1 244.15,1.4
X$1034 446 428 395 173 BUF_X1
* cell instance $1040 r0 *1 244.91,1.4
X$1040 240 428 395 174 BUF_X1
* cell instance $1046 r0 *1 245.48,1.4
X$1046 452 428 395 175 BUF_X1
* cell instance $1052 r0 *1 246.24,1.4
X$1052 241 428 395 176 BUF_X1
* cell instance $1058 m0 *1 246.43,4.2
X$1058 242 428 395 177 BUF_X1
* cell instance $1064 r0 *1 247.19,1.4
X$1064 450 428 395 178 BUF_X1
* cell instance $1074 r0 *1 247.76,1.4
X$1074 459 428 395 179 BUF_X1
* cell instance $1076 r0 *1 248.33,1.4
X$1076 243 428 395 180 BUF_X1
* cell instance $1082 r0 *1 247.95,4.2
X$1082 458 428 395 181 BUF_X1
* cell instance $1088 r0 *1 249.09,1.4
X$1088 457 428 395 182 BUF_X1
* cell instance $1094 r0 *1 249.66,4.2
X$1094 455 428 395 183 BUF_X1
* cell instance $1100 r0 *1 249.66,1.4
X$1100 453 428 395 184 BUF_X1
* cell instance $1106 r0 *1 250.23,1.4
X$1106 244 428 395 185 BUF_X1
* cell instance $1112 m0 *1 249.85,7
X$1112 456 428 395 186 BUF_X1
* cell instance $1118 r0 *1 252.32,1.4
X$1118 252 428 395 187 BUF_X1
* cell instance $1124 r0 *1 251.75,4.2
X$1124 472 428 395 188 BUF_X1
* cell instance $1130 m0 *1 252.89,7
X$1130 521 428 395 189 BUF_X1
* cell instance $1136 r0 *1 135.66,79.8
X$1136 190 685 684 395 428 700 HA_X1
* cell instance $1139 r0 *1 137.56,82.6
X$1139 191 719 718 395 428 736 HA_X1
* cell instance $1151 r0 *1 151.05,102.2
X$1151 192 1190 1188 395 428 1177 HA_X1
* cell instance $1155 r0 *1 153.33,107.8
X$1155 193 1297 1264 395 428 1329 HA_X1
* cell instance $1163 r0 *1 155.23,107.8
X$1163 194 1449 1319 395 428 1299 HA_X1
* cell instance $1165 m0 *1 155.8,99.4
X$1165 195 1034 1100 395 428 1061 HA_X1
* cell instance $1169 m0 *1 157.51,4.2
X$1169 196 428 395 LOGIC0_X1
* cell instance $1171 r0 *1 158.27,4.2
X$1171 197 428 395 LOGIC0_X1
* cell instance $1175 m0 *1 159.6,4.2
X$1175 198 428 395 LOGIC0_X1
* cell instance $1177 r0 *1 160.74,4.2
X$1177 199 428 395 LOGIC0_X1
* cell instance $1181 m0 *1 161.88,4.2
X$1181 200 428 395 LOGIC0_X1
* cell instance $1184 m0 *1 162.26,4.2
X$1184 201 428 395 LOGIC0_X1
* cell instance $1187 m0 *1 163.21,4.2
X$1187 202 428 395 LOGIC0_X1
* cell instance $1189 r0 *1 163.21,4.2
X$1189 203 428 395 LOGIC0_X1
* cell instance $1193 m0 *1 164.73,4.2
X$1193 204 428 395 LOGIC0_X1
* cell instance $1196 m0 *1 166.63,4.2
X$1196 205 428 395 LOGIC0_X1
* cell instance $1198 r0 *1 166.63,4.2
X$1198 206 428 395 LOGIC0_X1
* cell instance $1202 m0 *1 168.91,4.2
X$1202 207 428 395 LOGIC0_X1
* cell instance $1205 m0 *1 170.24,4.2
X$1205 208 428 395 LOGIC0_X1
* cell instance $1207 r0 *1 181.26,4.2
X$1207 209 428 395 LOGIC0_X1
* cell instance $1210 m0 *1 181.64,4.2
X$1210 210 428 395 LOGIC0_X1
* cell instance $1214 m0 *1 182.21,4.2
X$1214 211 428 395 LOGIC0_X1
* cell instance $1216 m0 *1 183.54,4.2
X$1216 212 428 395 LOGIC0_X1
* cell instance $1219 m0 *1 188.67,4.2
X$1219 213 428 395 LOGIC0_X1
* cell instance $1223 m0 *1 195.51,4.2
X$1223 214 428 395 LOGIC0_X1
* cell instance $1225 m0 *1 196.84,4.2
X$1225 215 428 395 LOGIC0_X1
* cell instance $1229 m0 *1 198.93,4.2
X$1229 216 428 395 LOGIC0_X1
* cell instance $1232 m0 *1 199.88,4.2
X$1232 217 428 395 LOGIC0_X1
* cell instance $1235 m0 *1 200.64,4.2
X$1235 218 428 395 LOGIC0_X1
* cell instance $1238 m0 *1 201.97,4.2
X$1238 219 428 395 LOGIC0_X1
* cell instance $1240 r0 *1 202.54,4.2
X$1240 220 428 395 LOGIC0_X1
* cell instance $1244 m0 *1 205.77,4.2
X$1244 221 428 395 LOGIC0_X1
* cell instance $1247 m0 *1 207.1,4.2
X$1247 222 428 395 LOGIC0_X1
* cell instance $1250 m0 *1 210.33,4.2
X$1250 223 428 395 LOGIC0_X1
* cell instance $1253 m0 *1 211.66,4.2
X$1253 224 428 395 LOGIC0_X1
* cell instance $1256 m0 *1 212.23,4.2
X$1256 225 428 395 LOGIC0_X1
* cell instance $1258 m0 *1 213.94,4.2
X$1258 226 428 395 LOGIC0_X1
* cell instance $1262 m0 *1 214.7,4.2
X$1262 227 428 395 LOGIC0_X1
* cell instance $1264 m0 *1 216.22,4.2
X$1264 228 428 395 LOGIC0_X1
* cell instance $1268 m0 *1 226.29,4.2
X$1268 229 428 395 LOGIC0_X1
* cell instance $1270 m0 *1 225.91,4.2
X$1270 230 428 395 LOGIC0_X1
* cell instance $1273 m0 *1 226.67,4.2
X$1273 231 428 395 LOGIC0_X1
* cell instance $1277 m0 *1 229.71,4.2
X$1277 232 428 395 LOGIC0_X1
* cell instance $1279 m0 *1 230.09,4.2
X$1279 233 428 395 LOGIC0_X1
* cell instance $1282 m0 *1 230.85,4.2
X$1282 234 428 395 LOGIC0_X1
* cell instance $1286 m0 *1 231.23,4.2
X$1286 235 428 395 LOGIC0_X1
* cell instance $1289 m0 *1 232.75,4.2
X$1289 236 428 395 LOGIC0_X1
* cell instance $1292 m0 *1 241.3,4.2
X$1292 237 428 395 LOGIC0_X1
* cell instance $1295 m0 *1 241.87,4.2
X$1295 238 428 395 LOGIC0_X1
* cell instance $1297 m0 *1 243.58,4.2
X$1297 239 428 395 LOGIC0_X1
* cell instance $1301 m0 *1 245.1,4.2
X$1301 240 428 395 LOGIC0_X1
* cell instance $1304 m0 *1 246.05,4.2
X$1304 241 428 395 LOGIC0_X1
* cell instance $1306 r0 *1 246.62,4.2
X$1306 242 428 395 LOGIC0_X1
* cell instance $1309 m0 *1 248.14,4.2
X$1309 243 428 395 LOGIC0_X1
* cell instance $1313 m0 *1 250.42,4.2
X$1313 244 428 395 LOGIC0_X1
* cell instance $1315 r0 *1 251.75,15.4
X$1315 245 428 395 281 BUF_X1
* cell instance $1317 r0 *1 250.23,15.4
X$1317 245 428 395 LOGIC0_X1
* cell instance $1319 r0 *1 250.8,1.4
X$1319 246 428 395 278 BUF_X1
* cell instance $1321 m0 *1 250.8,7
X$1321 246 428 395 LOGIC0_X1
* cell instance $1323 m0 *1 251.18,7
X$1323 247 428 395 263 BUF_X1
* cell instance $1325 m0 *1 250.42,7
X$1325 247 428 395 LOGIC0_X1
* cell instance $1327 m0 *1 251.18,9.8
X$1327 248 428 395 300 BUF_X1
* cell instance $1329 m0 *1 250.42,9.8
X$1329 248 428 395 LOGIC0_X1
* cell instance $1331 r0 *1 251.56,9.8
X$1331 249 428 395 319 BUF_X1
* cell instance $1333 r0 *1 250.61,9.8
X$1333 249 428 395 LOGIC0_X1
* cell instance $1335 m0 *1 251.75,15.4
X$1335 250 428 395 318 BUF_X1
* cell instance $1337 m0 *1 250.99,15.4
X$1337 250 428 395 LOGIC0_X1
* cell instance $1339 m0 *1 250.8,9.8
X$1339 251 428 395 LOGIC0_X1
* cell instance $1341 m0 *1 251.75,9.8
X$1341 251 428 395 325 BUF_X1
* cell instance $1344 m0 *1 252.13,7
X$1344 252 428 395 LOGIC0_X1
* cell instance $1346 r0 *1 252.7,7
X$1346 253 428 395 LOGIC0_X1
* cell instance $1348 m0 *1 252.89,4.2
X$1348 253 428 395 290 BUF_X1
* cell instance $1350 r0 *1 252.7,12.6
X$1350 254 428 395 303 BUF_X1
* cell instance $1352 m0 *1 253.08,15.4
X$1352 254 428 395 LOGIC0_X1
* cell instance $1354 r0 *1 253.08,26.6
X$1354 255 428 395 LOGIC0_X1
* cell instance $1356 m0 *1 252.89,26.6
X$1356 255 428 395 314 BUF_X1
* cell instance $1358 r0 *1 253.08,43.4
X$1358 256 428 395 LOGIC0_X1
* cell instance $1360 m0 *1 252.89,43.4
X$1360 256 428 395 266 BUF_X1
* cell instance $1362 r0 *1 252.89,4.2
X$1362 257 428 395 LOGIC0_X1
* cell instance $1364 r0 *1 252.89,1.4
X$1364 257 428 395 298 BUF_X1
* cell instance $1366 r0 *1 252.13,43.4
X$1366 511 428 395 258 BUF_X1
* cell instance $1371 m0 *1 251.75,21
X$1371 488 428 395 259 BUF_X1
* cell instance $1376 r0 *1 252.7,18.2
X$1376 509 428 395 260 BUF_X1
* cell instance $1381 r0 *1 252.89,35
X$1381 519 428 395 261 BUF_X1
* cell instance $1386 m0 *1 251.56,18.2
X$1386 473 428 395 262 BUF_X1
* cell instance $1395 m0 *1 252.7,23.8
X$1395 498 428 395 264 BUF_X1
* cell instance $1400 m0 *1 250.61,35
X$1400 465 428 395 265 BUF_X1
* cell instance $1409 r0 *1 249.85,7
X$1409 454 428 395 267 BUF_X1
* cell instance $1414 m0 *1 252.7,35
X$1414 501 428 395 268 BUF_X1
* cell instance $1419 r0 *1 252.89,15.4
X$1419 522 428 395 269 BUF_X1
* cell instance $1424 r0 *1 251.18,4.2
X$1424 474 428 395 270 BUF_X1
* cell instance $1429 r0 *1 247.38,4.2
X$1429 451 428 395 271 BUF_X1
* cell instance $1434 m0 *1 251.75,35
X$1434 485 428 395 272 BUF_X1
* cell instance $1439 r0 *1 251.75,1.4
X$1439 482 428 395 273 BUF_X1
* cell instance $1444 r0 *1 251.94,40.6
X$1444 495 428 395 274 BUF_X1
* cell instance $1449 m0 *1 252.7,40.6
X$1449 503 428 395 275 BUF_X1
* cell instance $1454 r0 *1 252.89,40.6
X$1454 525 428 395 276 BUF_X1
* cell instance $1459 m0 *1 251.75,40.6
X$1459 478 428 395 277 BUF_X1
* cell instance $1468 m0 *1 252.32,4.2
X$1468 502 428 395 279 BUF_X1
* cell instance $1473 m0 *1 250.61,40.6
X$1473 466 428 395 280 BUF_X1
* cell instance $1482 r0 *1 250.8,18.2
X$1482 463 428 395 282 BUF_X1
* cell instance $1487 r0 *1 251.18,37.8
X$1487 493 428 395 283 BUF_X1
* cell instance $1492 m0 *1 251.75,4.2
X$1492 484 428 395 284 BUF_X1
* cell instance $1497 r0 *1 252.7,37.8
X$1497 505 428 395 285 BUF_X1
* cell instance $1502 m0 *1 250.99,18.2
X$1502 461 428 395 286 BUF_X1
* cell instance $1507 m0 *1 250.61,21
X$1507 469 428 395 287 BUF_X1
* cell instance $1512 m0 *1 252.89,37.8
X$1512 516 428 395 288 BUF_X1
* cell instance $1517 m0 *1 250.8,4.2
X$1517 460 428 395 289 BUF_X1
* cell instance $1526 m0 *1 251.18,43.4
X$1526 480 428 395 291 BUF_X1
* cell instance $1531 m0 *1 252.13,37.8
X$1531 508 428 395 292 BUF_X1
* cell instance $1536 r0 *1 250.61,15.4
X$1536 471 428 395 293 BUF_X1
* cell instance $1541 m0 *1 251.18,37.8
X$1541 475 428 395 294 BUF_X1
* cell instance $1546 m0 *1 252.32,43.4
X$1546 514 428 395 295 BUF_X1
* cell instance $1551 m0 *1 252.7,18.2
X$1551 500 428 395 296 BUF_X1
* cell instance $1556 r0 *1 250.8,35
X$1556 483 428 395 297 BUF_X1
* cell instance $1565 m0 *1 252.89,29.4
X$1565 518 428 395 299 BUF_X1
* cell instance $1574 m0 *1 251.94,32.2
X$1574 496 428 395 301 BUF_X1
* cell instance $1579 r0 *1 251.18,23.8
X$1579 476 428 395 302 BUF_X1
* cell instance $1588 m0 *1 252.7,9.8
X$1588 499 428 395 304 BUF_X1
* cell instance $1593 r0 *1 251.18,29.4
X$1593 491 428 395 305 BUF_X1
* cell instance $1598 m0 *1 251.18,26.6
X$1598 481 428 395 306 BUF_X1
* cell instance $1603 r0 *1 252.89,29.4
X$1603 520 428 395 307 BUF_X1
* cell instance $1608 m0 *1 252.89,12.6
X$1608 517 428 395 308 BUF_X1
* cell instance $1613 m0 *1 251.75,29.4
X$1613 487 428 395 309 BUF_X1
* cell instance $1618 r0 *1 252.51,9.8
X$1618 504 428 395 310 BUF_X1
* cell instance $1623 r0 *1 250.99,9.8
X$1623 470 428 395 311 BUF_X1
* cell instance $1628 m0 *1 252.7,21
X$1628 497 428 395 312 BUF_X1
* cell instance $1633 m0 *1 252.32,15.4
X$1633 494 428 395 313 BUF_X1
* cell instance $1642 r0 *1 252.89,21
X$1642 524 428 395 315 BUF_X1
* cell instance $1647 m0 *1 252.32,12.6
X$1647 510 428 395 316 BUF_X1
* cell instance $1652 m0 *1 250.61,29.4
X$1652 467 428 395 317 BUF_X1
* cell instance $1665 m0 *1 252.32,26.6
X$1665 515 428 395 320 BUF_X1
* cell instance $1670 r0 *1 251.56,21
X$1670 492 428 395 321 BUF_X1
* cell instance $1675 r0 *1 251.56,26.6
X$1675 489 428 395 322 BUF_X1
* cell instance $1680 r0 *1 252.51,26.6
X$1680 506 428 395 323 BUF_X1
* cell instance $1685 r0 *1 251.56,32.2
X$1685 490 428 395 324 BUF_X1
* cell instance $1694 m0 *1 252.89,32.2
X$1694 523 428 395 326 BUF_X1
* cell instance $1699 m0 *1 250.61,23.8
X$1699 464 428 395 327 BUF_X1
* cell instance $1704 r0 *1 250.99,7
X$1704 462 428 395 328 BUF_X1
* cell instance $1709 r0 *1 252.13,7
X$1709 512 428 395 329 BUF_X1
* cell instance $1714 r0 *1 252.7,23.8
X$1714 507 428 395 330 BUF_X1
* cell instance $1719 r0 *1 252.13,12.6
X$1719 513 428 395 331 BUF_X1
* cell instance $1724 m0 *1 251.75,23.8
X$1724 486 428 395 332 BUF_X1
* cell instance $1729 r0 *1 250.61,32.2
X$1729 468 428 395 333 BUF_X1
* cell instance $1734 r0 *1 251.18,12.6
X$1734 477 428 395 334 BUF_X1
* cell instance $1739 r0 *1 252.89,32.2
X$1739 526 428 395 335 BUF_X1
* cell instance $1747 m0 *1 128.82,79.8
X$1747 336 693 670 395 428 683 HA_X1
* cell instance $1752 m0 *1 118.56,99.4
X$1752 337 1155 1050 395 428 1075 HA_X1
* cell instance $1757 m0 *1 124.83,79.8
X$1757 338 715 668 395 428 669 HA_X1
* cell instance $1760 m0 *1 132.24,4.2
X$1760 339 428 395 1430 INV_X2
* cell instance $1764 m0 *1 136.8,82.6
X$1764 340 811 737 395 428 720 HA_X1
* cell instance $1772 r0 *1 135.09,110.6
X$1772 341 1551 1347 395 428 1419 HA_X1
* cell instance $1776 m0 *1 152.57,110.6
X$1776 342 1330 1331 395 428 1328 HA_X1
* cell instance $1784 m0 *1 155.61,4.2
X$1784 343 428 395 LOGIC0_X1
* cell instance $1786 m0 *1 159.98,4.2
X$1786 344 428 395 LOGIC0_X1
* cell instance $1789 m0 *1 159.22,4.2
X$1789 345 428 395 LOGIC0_X1
* cell instance $1793 m0 *1 158.65,4.2
X$1793 346 428 395 LOGIC0_X1
* cell instance $1796 m0 *1 164.35,4.2
X$1796 347 428 395 LOGIC0_X1
* cell instance $1799 m0 *1 163.78,4.2
X$1799 348 428 395 LOGIC0_X1
* cell instance $1801 m0 *1 167.39,4.2
X$1801 349 428 395 LOGIC0_X1
* cell instance $1805 m0 *1 165.49,4.2
X$1805 350 428 395 LOGIC0_X1
* cell instance $1807 r0 *1 170.62,4.2
X$1807 351 428 395 LOGIC0_X1
* cell instance $1810 m0 *1 169.86,4.2
X$1810 352 428 395 LOGIC0_X1
* cell instance $1814 m0 *1 169.29,4.2
X$1814 353 428 395 LOGIC0_X1
* cell instance $1816 m0 *1 168.15,4.2
X$1816 354 428 395 LOGIC0_X1
* cell instance $1821 r0 *1 168.34,4.2
X$1821 355 428 395 LOGIC0_X1
* cell instance $1825 m0 *1 174.23,4.2
X$1825 356 428 395 LOGIC0_X1
* cell instance $1827 m0 *1 173.66,4.2
X$1827 357 428 395 LOGIC0_X1
* cell instance $1830 m0 *1 173.09,4.2
X$1830 358 428 395 LOGIC0_X1
* cell instance $1833 m0 *1 172.52,4.2
X$1833 359 428 395 LOGIC0_X1
* cell instance $1836 m0 *1 171.95,4.2
X$1836 360 428 395 LOGIC0_X1
* cell instance $1840 m0 *1 171.38,4.2
X$1840 361 428 395 LOGIC0_X1
* cell instance $1843 m0 *1 178.22,4.2
X$1843 362 428 395 LOGIC0_X1
* cell instance $1845 m0 *1 177.65,4.2
X$1845 363 428 395 LOGIC0_X1
* cell instance $1849 m0 *1 177.08,4.2
X$1849 364 428 395 LOGIC0_X1
* cell instance $1852 m0 *1 176.51,4.2
X$1852 365 428 395 LOGIC0_X1
* cell instance $1854 m0 *1 175.94,4.2
X$1854 366 428 395 LOGIC0_X1
* cell instance $1858 m0 *1 175.37,4.2
X$1858 367 428 395 LOGIC0_X1
* cell instance $1861 m0 *1 174.8,4.2
X$1861 368 428 395 LOGIC0_X1
* cell instance $1863 m0 *1 180.5,4.2
X$1863 369 428 395 LOGIC0_X1
* cell instance $1866 m0 *1 179.93,4.2
X$1866 370 428 395 LOGIC0_X1
* cell instance $1870 m0 *1 179.36,4.2
X$1870 371 428 395 LOGIC0_X1
* cell instance $1873 m0 *1 178.79,4.2
X$1873 372 428 395 LOGIC0_X1
* cell instance $1875 m0 *1 184.87,4.2
X$1875 373 428 395 LOGIC0_X1
* cell instance $1878 m0 *1 184.3,4.2
X$1878 374 428 395 LOGIC0_X1
* cell instance $1882 m0 *1 183.16,4.2
X$1882 375 428 395 LOGIC0_X1
* cell instance $1885 m0 *1 182.59,4.2
X$1885 376 428 395 LOGIC0_X1
* cell instance $1887 m0 *1 188.29,4.2
X$1887 377 428 395 LOGIC0_X1
* cell instance $1891 m0 *1 187.72,4.2
X$1891 378 428 395 LOGIC0_X1
* cell instance $1894 m0 *1 187.15,4.2
X$1894 379 428 395 LOGIC0_X1
* cell instance $1896 m0 *1 186.58,4.2
X$1896 380 428 395 LOGIC0_X1
* cell instance $1899 m0 *1 186.01,4.2
X$1899 381 428 395 LOGIC0_X1
* cell instance $1902 m0 *1 185.44,4.2
X$1902 382 428 395 LOGIC0_X1
* cell instance $1905 m0 *1 192.85,4.2
X$1905 383 428 395 LOGIC0_X1
* cell instance $1909 m0 *1 192.28,4.2
X$1909 384 428 395 LOGIC0_X1
* cell instance $1912 m0 *1 191.71,4.2
X$1912 385 428 395 LOGIC0_X1
* cell instance $1915 m0 *1 191.14,4.2
X$1915 386 428 395 LOGIC0_X1
* cell instance $1918 m0 *1 190.57,4.2
X$1918 387 428 395 LOGIC0_X1
* cell instance $1921 m0 *1 190,4.2
X$1921 388 428 395 LOGIC0_X1
* cell instance $1924 m0 *1 189.43,4.2
X$1924 389 428 395 LOGIC0_X1
* cell instance $1927 m0 *1 195.89,4.2
X$1927 390 428 395 LOGIC0_X1
* cell instance $1930 m0 *1 195.13,4.2
X$1930 391 428 395 LOGIC0_X1
* cell instance $1932 m0 *1 194.56,4.2
X$1932 392 428 395 LOGIC0_X1
* cell instance $1935 m0 *1 193.99,4.2
X$1935 393 428 395 LOGIC0_X1
* cell instance $1938 m0 *1 193.42,4.2
X$1938 394 428 395 LOGIC0_X1
* cell instance $1940 r0 *1 35.34,138.6
X$1940 749 428 395 3295 INV_X8
* cell instance $1941 r0 *1 34.39,138.6
X$1941 1276 428 395 753 CLKBUF_X3
* cell instance $1942 r0 *1 37.05,138.6
X$1942 1276 428 395 749 CLKBUF_X3
* cell instance $2053 m0 *1 250.23,141.4
X$2053 1930 428 395 LOGIC0_X1
* cell instance $2054 m0 *1 250.61,141.4
X$2054 1930 428 395 1919 BUF_X1
* cell instance $2055 r0 *1 251.18,138.6
X$2055 1928 428 395 1908 BUF_X1
* cell instance $2056 r0 *1 250.8,138.6
X$2056 1928 428 395 LOGIC0_X1
* cell instance $2058 r0 *1 251.94,138.6
X$2058 1929 428 395 LOGIC0_X1
* cell instance $2059 r0 *1 252.32,138.6
X$2059 1929 428 395 1920 BUF_X1
* cell instance $2060 r0 *1 252.89,138.6
X$2060 1912 428 395 LOGIC0_X1
* cell instance $2063 m0 *1 251.18,141.4
X$2063 1925 428 395 LOGIC0_X1
* cell instance $2065 m0 *1 251.75,141.4
X$2065 1927 428 395 LOGIC0_X1
* cell instance $2066 m0 *1 252.13,141.4
X$2066 1927 428 395 1922 BUF_X1
* cell instance $2068 m0 *1 252.89,141.4
X$2068 1925 428 395 1921 BUF_X1
* cell instance $2070 r0 *1 16.15,113.4
X$2070 1358 1433 428 395 1424 XNOR2_X2
* cell instance $2071 r0 *1 15.2,113.4
X$2071 1373 1152 1148 1424 395 428 1524 OAI22_X1
* cell instance $2073 r0 *1 18.81,113.4
X$2073 1315 1403 1459 1374 395 1433 428 NOR4_X2
* cell instance $2097 m0 *1 1.9,116.2
X$2097 1476 428 395 1454 BUF_X1
* cell instance $2100 r0 *1 6.46,113.4
X$2100 1440 428 395 1436 BUF_X1
* cell instance $2101 r0 *1 4.75,113.4
X$2101 1392 1336 1423 1335 428 1495 395 NAND4_X2
* cell instance $2103 r0 *1 7.22,113.4
X$2103 1457 1423 1371 428 1456 395 AOI21_X1
* cell instance $2107 m0 *1 4.75,116.2
X$2107 1454 1455 1477 395 428 1487 HA_X1
* cell instance $2109 m0 *1 12.73,116.2
X$2109 428 3343 1458 1439 725 395 DFF_X1
* cell instance $2111 m0 *1 16.15,116.2
X$2111 1458 428 395 1358 BUF_X2
* cell instance $2116 m0 *1 28.31,116.2
X$2116 428 3355 1364 1489 1117 395 DFF_X1
* cell instance $2123 m0 *1 39.33,116.2
X$2123 1411 1434 1291 428 395 NOR2_X4
* cell instance $2140 r0 *1 115.33,113.4
X$2140 428 1435 752 3319 1440 395 DFF_X2
* cell instance $2142 r0 *1 118.94,113.4
X$2142 1469 1425 1426 428 395 1442 OR3_X1
* cell instance $2144 r0 *1 120.08,113.4
X$2144 1425 1426 1443 428 395 1435 OR3_X1
* cell instance $2148 r0 *1 123.5,113.4
X$2148 1175 1434 809 428 395 NOR2_X4
* cell instance $2149 r0 *1 125.21,113.4
X$2149 1428 1473 1474 1441 1009 395 428 1731 OAI221_X1
* cell instance $2153 m0 *1 118.75,116.2
X$2153 810 1440 1441 1535 395 428 1443 AND4_X1
* cell instance $2157 m0 *1 121.98,116.2
X$2157 1471 1488 395 428 1344 AND2_X1
* cell instance $2158 m0 *1 122.74,116.2
X$2158 1488 1471 428 1175 395 NAND2_X4
* cell instance $2161 m0 *1 125.4,116.2
X$2161 428 1444 1507 3307 1479 395 DFF_X2
* cell instance $2163 r0 *1 126.73,113.4
X$2163 1472 1428 1429 428 1444 395 AOI21_X1
* cell instance $2165 r0 *1 128.44,113.4
X$2165 1427 1204 1258 1479 1416 395 428 1472 OAI221_X1
* cell instance $2170 m0 *1 130.72,116.2
X$2170 1441 1175 428 395 1202 NAND2_X2
* cell instance $2171 r0 *1 131.67,113.4
X$2171 1480 1470 395 428 1418 AND2_X1
* cell instance $2173 r0 *1 132.43,113.4
X$2173 1430 1468 1470 395 428 1445 HA_X1
* cell instance $2177 r0 *1 139.08,113.4
X$2177 1380 428 395 1349 CLKBUF_X3
* cell instance $2199 m0 *1 132.05,116.2
X$2199 1480 428 395 1467 INV_X1
* cell instance $2202 m0 *1 133,116.2
X$2202 1491 428 395 1446 INV_X1
* cell instance $2203 m0 *1 133.38,116.2
X$2203 1467 1445 1446 395 1466 428 OAI21_X1
* cell instance $2207 m0 *1 138.32,116.2
X$2207 1447 1349 1465 428 395 1238 NAND3_X2
* cell instance $2208 m0 *1 139.65,116.2
X$2208 428 1464 1447 1465 1349 1174 395 NAND4_X4
* cell instance $2214 m0 *1 149.34,116.2
X$2214 1066 1357 428 395 1481 NAND2_X1
* cell instance $2215 m0 *1 149.91,116.2
X$2215 1481 1448 395 1449 428 XOR2_X2
* cell instance $2216 m0 *1 151.62,116.2
X$2216 883 1357 1448 428 395 1483 NAND3_X2
* cell instance $2219 m0 *1 155.23,116.2
X$2219 1483 1482 395 1386 428 XOR2_X2
* cell instance $2246 m0 *1 250.23,116.2
X$2246 1450 428 395 LOGIC0_X1
* cell instance $2247 m0 *1 250.61,116.2
X$2247 1484 428 395 LOGIC0_X1
* cell instance $2248 r0 *1 250.8,113.4
X$2248 1461 428 395 LOGIC0_X1
* cell instance $2251 m0 *1 250.99,116.2
X$2251 1450 428 395 1462 BUF_X1
* cell instance $2252 m0 *1 251.56,116.2
X$2252 1484 428 395 1452 BUF_X1
* cell instance $2253 r0 *1 251.75,113.4
X$2253 1463 428 395 LOGIC0_X1
* cell instance $2255 r0 *1 252.13,113.4
X$2255 1463 428 395 1389 BUF_X1
* cell instance $2257 r0 *1 252.89,113.4
X$2257 1461 428 395 1453 BUF_X1
* cell instance $2260 m0 *1 252.32,116.2
X$2260 1460 428 395 LOGIC0_X1
* cell instance $2261 m0 *1 252.7,116.2
X$2261 1460 428 395 1451 BUF_X1
* cell instance $2264 r0 *1 2.28,127.4
X$2264 428 3413 1674 1765 749 395 DFF_X1
* cell instance $2265 r0 *1 1.71,127.4
X$2265 1736 428 395 1814 BUF_X1
* cell instance $2266 r0 *1 5.51,127.4
X$2266 1793 1794 428 395 1739 NAND2_X1
* cell instance $2267 r0 *1 6.08,127.4
X$2267 1815 1794 1795 428 1780 395 AOI21_X1
* cell instance $2274 m0 *1 4.56,130.2
X$2274 1814 1843 1793 395 428 1795 HA_X1
* cell instance $2276 r0 *1 7.41,127.4
X$2276 1779 1796 1794 395 428 1815 HA_X1
* cell instance $2282 m0 *1 10.26,130.2
X$2282 428 1817 749 3314 1798 395 DFF_X2
* cell instance $2284 r0 *1 11.97,127.4
X$2284 1585 1816 395 428 1817 AND2_X1
* cell instance $2285 r0 *1 12.92,127.4
X$2285 1148 1526 1797 395 1816 428 OAI21_X1
* cell instance $2286 r0 *1 13.68,127.4
X$2286 1503 1339 1798 428 395 1797 NAND3_X1
* cell instance $2290 m0 *1 14.44,130.2
X$2290 1503 1339 1826 428 395 1859 NAND3_X1
* cell instance $2291 r0 *1 16.72,127.4
X$2291 1827 1821 395 428 1796 XNOR2_X1
* cell instance $2292 r0 *1 14.82,127.4
X$2292 1798 1860 428 395 1526 XNOR2_X2
* cell instance $2294 r0 *1 18.05,127.4
X$2294 1690 1827 428 395 1761 NAND2_X1
* cell instance $2298 m0 *1 15.58,130.2
X$2298 428 1744 1827 1798 1826 1315 395 NAND4_X4
* cell instance $2300 r0 *1 19.95,127.4
X$2300 1340 1403 428 395 1821 NOR2_X2
* cell instance $2306 m0 *1 23.94,130.2
X$2306 1786 1844 428 395 1741 XNOR2_X2
* cell instance $2307 r0 *1 24.51,127.4
X$2307 1762 1741 1045 428 1886 395 AOI21_X1
* cell instance $2309 r0 *1 25.27,127.4
X$2309 1340 1764 428 395 1844 NOR2_X1
* cell instance $2312 m0 *1 26.03,130.2
X$2312 1853 1799 428 395 1843 XNOR2_X2
* cell instance $2313 r0 *1 27.17,127.4
X$2313 1786 1763 1759 395 428 1799 AND3_X1
* cell instance $2314 r0 *1 26.22,127.4
X$2314 1156 428 395 1148 CLKBUF_X3
* cell instance $2315 r0 *1 28.12,127.4
X$2315 1763 428 395 1764 INV_X1
* cell instance $2317 r0 *1 28.69,127.4
X$2317 1759 1045 1764 428 395 1846 NAND3_X1
* cell instance $2318 r0 *1 29.45,127.4
X$2318 1759 1148 428 395 1800 NOR2_X1
* cell instance $2319 r0 *1 30.02,127.4
X$2319 1800 1256 1763 395 1801 428 OAI21_X1
* cell instance $2323 r0 *1 40.66,127.4
X$2323 1790 428 395 1802 INV_X1
* cell instance $2324 r0 *1 41.04,127.4
X$2324 1765 1766 1291 428 1790 395 AOI21_X1
* cell instance $2326 r0 *1 41.99,127.4
X$2326 1754 1767 428 395 1766 NOR2_X1
* cell instance $2327 r0 *1 42.56,127.4
X$2327 1803 428 395 1767 INV_X1
* cell instance $2328 r0 *1 42.94,127.4
X$2328 1766 1699 428 395 1824 NOR2_X1
* cell instance $2329 r0 *1 43.51,127.4
X$2329 1413 1803 1754 395 428 1792 AND3_X1
* cell instance $2330 r0 *1 44.46,127.4
X$2330 428 3439 1700 1792 725 395 DFF_X1
* cell instance $2331 r0 *1 47.69,127.4
X$2331 1700 1698 428 395 1804 NOR2_X2
* cell instance $2332 r0 *1 48.64,127.4
X$2332 428 1789 1534 1745 1804 395 AOI21_X4
* cell instance $2346 m0 *1 30.97,130.2
X$2346 1514 1846 1801 428 1847 395 AOI21_X1
* cell instance $2350 m0 *1 31.73,130.2
X$2350 428 3352 1848 1847 749 395 DFF_X1
* cell instance $2351 m0 *1 34.96,130.2
X$2351 1848 428 395 1763 BUF_X2
* cell instance $2354 m0 *1 40.28,130.2
X$2354 428 3353 1803 1802 725 395 DFF_X1
* cell instance $2358 m0 *1 50.54,130.2
X$2358 1768 1804 1829 428 395 1828 NAND3_X1
* cell instance $2359 m0 *1 51.3,130.2
X$2359 1867 1824 1828 428 1850 395 AOI21_X1
* cell instance $2362 m0 *1 53.2,130.2
X$2362 428 1850 725 3299 1829 395 DFF_X2
* cell instance $2377 r0 *1 113.81,127.4
X$2377 428 3461 1769 1805 1507 395 DFF_X1
* cell instance $2379 r0 *1 117.99,127.4
X$2379 1769 428 395 1806 INV_X1
* cell instance $2380 r0 *1 118.37,127.4
X$2380 1413 1769 1831 395 428 1772 AND3_X1
* cell instance $2387 r0 *1 134.9,127.4
X$2387 428 3420 1808 1825 1807 395 DFF_X1
* cell instance $2388 r0 *1 138.13,127.4
X$2388 1808 395 1465 428 BUF_X4
* cell instance $2389 r0 *1 139.46,127.4
X$2389 1232 1774 1809 395 1845 428 OAI21_X1
* cell instance $2390 r0 *1 140.22,127.4
X$2390 1441 1204 1465 428 395 1809 NAND3_X1
* cell instance $2392 r0 *1 141.17,127.4
X$2392 1232 1785 1810 395 1834 428 OAI21_X1
* cell instance $2393 r0 *1 141.93,127.4
X$2393 1441 1204 1773 428 395 1810 NAND3_X1
* cell instance $2394 r0 *1 142.69,127.4
X$2394 1823 1773 395 1785 428 XOR2_X2
* cell instance $2395 r0 *1 144.4,127.4
X$2395 1775 1232 1783 395 1835 428 OAI21_X1
* cell instance $2398 m0 *1 114.57,130.2
X$2398 1849 1356 428 395 1805 NOR2_X1
* cell instance $2402 m0 *1 117.61,130.2
X$2402 1788 1830 1441 428 1849 395 AOI21_X1
* cell instance $2403 m0 *1 118.37,130.2
X$2403 1831 1806 428 395 1830 NOR2_X1
* cell instance $2407 m0 *1 137.18,130.2
X$2407 1832 1845 395 428 1825 AND2_X1
* cell instance $2411 m0 *1 140.6,130.2
X$2411 1832 1834 395 428 1833 AND2_X1
* cell instance $2419 m0 *1 144.21,130.2
X$2419 1832 1835 395 428 1855 AND2_X1
* cell instance $2422 r0 *1 146.3,127.4
X$2422 1811 428 395 1708 BUF_X2
* cell instance $2425 r0 *1 152.38,127.4
X$2425 1776 1775 1746 395 428 1822 HA_X1
* cell instance $2426 r0 *1 154.28,127.4
X$2426 1999 1774 1748 395 428 1820 HA_X1
* cell instance $2448 m0 *1 152.38,130.2
X$2448 1842 1785 1747 395 428 1836 HA_X1
* cell instance $2449 m0 *1 154.28,130.2
X$2449 1820 1748 1836 428 1752 395 AOI21_X1
* cell instance $2474 r0 *1 32.87,105
X$2474 1254 1243 1092 428 395 1278 NAND3_X1
* cell instance $2475 r0 *1 31.92,105
X$2475 1252 1278 428 395 1248 NOR2_X2
* cell instance $2476 r0 *1 33.63,105
X$2476 1243 428 395 1199 INV_X1
* cell instance $2479 r0 *1 35.72,105
X$2479 1156 1224 1046 428 1226 395 AOI21_X1
* cell instance $2481 r0 *1 36.67,105
X$2481 1226 1256 1243 395 1279 428 OAI21_X1
* cell instance $2482 r0 *1 37.43,105
X$2482 1153 1225 1279 428 1227 395 AOI21_X1
* cell instance $2483 r0 *1 38.19,105
X$2483 1256 1045 1198 428 1245 395 AOI21_X1
* cell instance $2485 r0 *1 39.14,105
X$2485 1280 1165 1156 1198 428 395 1257 OR4_X1
* cell instance $2486 r0 *1 40.28,105
X$2486 1245 1228 1257 395 1244 428 OAI21_X1
* cell instance $2487 r0 *1 41.04,105
X$2487 1165 1258 428 395 1228 NAND2_X1
* cell instance $2488 r0 *1 41.61,105
X$2488 428 3471 1282 1244 725 395 DFF_X1
* cell instance $2489 r0 *1 44.84,105
X$2489 1282 428 395 1165 BUF_X2
* cell instance $2494 m0 *1 32.11,107.8
X$2494 1046 1255 1253 428 395 1252 NAND3_X1
* cell instance $2496 m0 *1 33.06,107.8
X$2496 1243 1254 1253 1255 395 428 1166 AND4_X2
* cell instance $2497 m0 *1 34.39,107.8
X$2497 1254 1253 1255 395 428 1224 AND3_X1
* cell instance $2502 r0 *1 49.97,105
X$2502 428 1258 395 810 BUF_X8
* cell instance $2517 r0 *1 121.22,105
X$2517 1259 1229 1242 428 1286 395 AOI21_X1
* cell instance $2518 r0 *1 121.98,105
X$2518 1260 428 395 1229 INV_X1
* cell instance $2533 m0 *1 120.65,107.8
X$2533 428 3369 1260 1286 752 395 DFF_X1
* cell instance $2534 r0 *1 123.69,105
X$2534 428 3468 1114 1241 752 395 DFF_X1
* cell instance $2538 r0 *1 130.15,105
X$2538 1240 1170 428 395 1231 NAND2_X1
* cell instance $2539 r0 *1 130.72,105
X$2539 1009 1230 1231 428 1239 395 AOI21_X1
* cell instance $2540 r0 *1 131.48,105
X$2540 428 3422 1287 1239 752 395 DFF_X1
* cell instance $2541 r0 *1 134.71,105
X$2541 1287 428 395 1170 BUF_X2
* cell instance $2543 r0 *1 136.23,105
X$2543 428 3419 1285 1262 752 395 DFF_X1
* cell instance $2544 r0 *1 139.46,105
X$2544 1285 395 881 428 BUF_X4
* cell instance $2551 r0 *1 141.93,105
X$2551 1024 1232 428 395 1281 NOR2_X1
* cell instance $2552 r0 *1 141.17,105
X$2552 1194 1024 395 428 1284 AND2_X1
* cell instance $2553 r0 *1 142.5,105
X$2553 1202 1052 428 395 1283 NAND2_X1
* cell instance $2557 r0 *1 152.38,105
X$2557 1233 1234 428 395 1235 NOR2_X1
* cell instance $2576 m0 *1 141.74,107.8
X$2576 1284 1052 1258 1281 1283 395 428 1296 OAI221_X1
* cell instance $2577 m0 *1 142.88,107.8
X$2577 428 3398 1277 1263 981 395 DFF_X1
* cell instance $2578 m0 *1 146.11,107.8
X$2578 1277 428 395 1052 BUF_X2
* cell instance $2582 m0 *1 152.19,107.8
X$2582 981 428 395 3293 INV_X8
* cell instance $2583 m0 *1 153.9,107.8
X$2583 1276 428 395 981 CLKBUF_X3
* cell instance $2606 m0 *1 250.23,107.8
X$2606 1275 428 395 LOGIC0_X1
* cell instance $2607 m0 *1 250.61,107.8
X$2607 1275 428 395 1268 BUF_X1
* cell instance $2608 r0 *1 250.8,105
X$2608 1274 428 395 LOGIC0_X1
* cell instance $2610 r0 *1 251.18,105
X$2610 1274 428 395 1269 BUF_X1
* cell instance $2612 m0 *1 251.18,107.8
X$2612 1272 428 395 LOGIC0_X1
* cell instance $2614 m0 *1 251.75,107.8
X$2614 1272 428 395 1267 BUF_X1
* cell instance $2616 r0 *1 252.13,105
X$2616 1270 428 395 LOGIC0_X1
* cell instance $2617 r0 *1 252.7,105
X$2617 1270 428 395 1237 BUF_X1
* cell instance $2620 m0 *1 252.32,107.8
X$2620 1271 428 395 LOGIC0_X1
* cell instance $2621 m0 *1 252.7,107.8
X$2621 1271 428 395 1265 BUF_X1
* cell instance $2633 r0 *1 45.98,119
X$2633 1547 1622 1576 395 1592 428 OAI21_X1
* cell instance $2634 r0 *1 45.22,119
X$2634 1546 1544 1591 428 1547 395 AOI21_X1
* cell instance $2640 m0 *1 45.22,121.8
X$2640 428 3361 1663 1592 725 395 DFF_X1
* cell instance $2641 m0 *1 48.45,121.8
X$2641 1663 428 395 1546 BUF_X2
* cell instance $2646 r0 *1 63.84,119
X$2646 1280 395 1514 428 BUF_X4
* cell instance $2665 r0 *1 109.82,119
X$2665 1536 428 395 1548 BUF_X2
* cell instance $2673 r0 *1 114.95,119
X$2673 1548 1549 395 428 1593 AND2_X1
* cell instance $2675 r0 *1 115.71,119
X$2675 1548 428 395 1594 INV_X1
* cell instance $2676 r0 *1 116.09,119
X$2676 1548 1508 810 428 395 1595 NAND3_X1
* cell instance $2677 r0 *1 116.85,119
X$2677 1595 1621 1549 428 1469 395 AOI21_X1
* cell instance $2678 r0 *1 117.61,119
X$2678 1621 1548 1549 395 428 1416 AND3_X2
* cell instance $2680 r0 *1 120.27,119
X$2680 1619 1550 1413 395 1669 428 OAI21_X1
* cell instance $2684 m0 *1 114.95,121.8
X$2684 1665 1593 1576 395 1635 428 OAI21_X1
* cell instance $2686 m0 *1 116.09,121.8
X$2686 1621 1594 1508 428 1665 395 AOI21_X1
* cell instance $2687 m0 *1 116.85,121.8
X$2687 1548 1621 1549 428 1441 395 NAND3_X4
* cell instance $2691 m0 *1 120.65,121.8
X$2691 1669 428 395 1668 INV_X1
* cell instance $2692 m0 *1 121.03,121.8
X$2692 428 3375 1670 1668 1507 395 DFF_X1
* cell instance $2693 m0 *1 124.26,121.8
X$2693 1670 428 395 1471 BUF_X2
* cell instance $2695 r0 *1 130.91,119
X$2695 1441 1232 1596 428 395 1511 NAND3_X1
* cell instance $2696 r0 *1 127.68,119
X$2696 428 1468 1596 1573 1507 395 DFF_X1
* cell instance $2703 m0 *1 130.53,121.8
X$2703 1636 428 395 1618 INV_X1
* cell instance $2707 r0 *1 136.99,119
X$2707 1613 1552 1553 428 1597 395 AOI21_X1
* cell instance $2708 r0 *1 135.85,119
X$2708 1552 1464 395 428 1551 XNOR2_X1
* cell instance $2709 r0 *1 137.75,119
X$2709 992 1203 1552 428 395 1613 NOR3_X1
* cell instance $2732 m0 *1 136.8,121.8
X$2732 1597 1127 428 395 1598 NOR2_X1
* cell instance $2733 m0 *1 137.37,121.8
X$2733 428 3394 1662 1598 981 395 DFF_X1
* cell instance $2734 m0 *1 140.6,121.8
X$2734 1662 428 395 1552 BUF_X2
* cell instance $2742 m0 *1 151.43,121.8
X$2742 1554 992 1599 428 395 1656 OR3_X1
* cell instance $2745 m0 *1 153.52,121.8
X$2745 1194 1599 395 428 1639 AND2_X1
* cell instance $2771 m0 *1 250.23,121.8
X$2771 1650 428 395 LOGIC0_X1
* cell instance $2772 m0 *1 250.61,121.8
X$2772 1650 428 395 1601 BUF_X1
* cell instance $2774 m0 *1 251.37,121.8
X$2774 1649 428 395 LOGIC0_X1
* cell instance $2775 r0 *1 251.56,119
X$2775 1607 428 395 LOGIC0_X1
* cell instance $2777 r0 *1 251.94,119
X$2777 1607 428 395 1602 BUF_X1
* cell instance $2778 r0 *1 252.51,119
X$2778 1608 428 395 LOGIC0_X1
* cell instance $2779 r0 *1 252.89,119
X$2779 1608 428 395 1555 BUF_X1
* cell instance $2781 m0 *1 251.75,121.8
X$2781 1649 428 395 1600 BUF_X1
* cell instance $2782 m0 *1 252.32,121.8
X$2782 1648 428 395 LOGIC0_X1
* cell instance $2783 m0 *1 252.7,121.8
X$2783 1648 428 395 1640 BUF_X1
* cell instance $2786 r0 *1 2.66,102.2
X$2786 1181 1207 428 395 1183 NAND2_X1
* cell instance $2788 r0 *1 3.23,102.2
X$2788 1105 1182 1181 395 428 1209 HA_X1
* cell instance $2789 r0 *1 5.13,102.2
X$2789 1210 1161 1119 395 1162 428 OAI21_X1
* cell instance $2790 r0 *1 5.89,102.2
X$2790 1183 1161 1040 395 1120 428 NOR3_X2
* cell instance $2791 r0 *1 7.22,102.2
X$2791 1120 1140 428 395 1184 NAND2_X1
* cell instance $2792 r0 *1 7.79,102.2
X$2792 1120 1140 973 1162 1082 1211 395 428 AOI221_X2
* cell instance $2793 r0 *1 9.88,102.2
X$2793 973 1082 1162 428 1163 395 AOI21_X1
* cell instance $2796 r0 *1 11.59,102.2
X$2796 1146 1164 1042 428 1085 395 AOI21_X1
* cell instance $2799 r0 *1 1.33,102.2
X$2799 1118 428 395 1180 BUF_X2
* cell instance $2803 m0 *1 1.33,105
X$2803 1222 428 395 1073 BUF_X2
* cell instance $2804 m0 *1 2.09,105
X$2804 1195 428 395 1160 BUF_X2
* cell instance $2806 m0 *1 3.04,105
X$2806 1208 1219 1207 395 428 1196 HA_X1
* cell instance $2807 m0 *1 4.94,105
X$2807 1196 1209 1207 428 1210 395 AOI21_X1
* cell instance $2810 m0 *1 8.93,105
X$2810 1211 1197 428 395 1189 NAND2_X2
* cell instance $2811 m0 *1 9.88,105
X$2811 1163 1197 428 395 1217 NAND2_X1
* cell instance $2814 r0 *1 19,102.2
X$2814 1153 1086 1186 428 1147 395 AOI21_X1
* cell instance $2821 r0 *1 30.97,102.2
X$2821 1165 1166 1167 395 428 1090 AND3_X1
* cell instance $2822 r0 *1 28.5,102.2
X$2822 1166 1165 1167 428 831 395 NAND3_X4
* cell instance $2823 r0 *1 31.92,102.2
X$2823 1166 1168 395 428 1067 AND2_X1
* cell instance $2839 r0 *1 114.95,102.2
X$2839 1180 1193 1192 395 428 1158 HA_X1
* cell instance $2845 m0 *1 29.26,105
X$2845 1198 1165 395 1144 428 XOR2_X2
* cell instance $2850 m0 *1 31.16,105
X$2850 1168 1167 1166 428 395 1198 NAND3_X2
* cell instance $2852 m0 *1 32.68,105
X$2852 1199 1200 428 395 1219 XNOR2_X2
* cell instance $2854 m0 *1 34.77,105
X$2854 1046 1224 428 395 1200 NAND2_X1
* cell instance $2855 m0 *1 35.34,105
X$2855 1123 1046 1224 1199 428 395 1225 NAND4_X1
* cell instance $2857 m0 *1 36.67,105
X$2857 428 3399 1243 1227 1117 395 DFF_X1
* cell instance $2876 m0 *1 119.51,105
X$2876 1229 1169 395 428 1193 XNOR2_X1
* cell instance $2882 r0 *1 125.97,102.2
X$2882 1114 992 1112 428 395 1220 OR3_X1
* cell instance $2883 r0 *1 126.92,102.2
X$2883 752 428 395 3474 INV_X2
* cell instance $2886 r0 *1 130.72,102.2
X$2886 1170 428 395 1171 INV_X1
* cell instance $2889 r0 *1 135.66,102.2
X$2889 428 1174 910 911 909 395 NOR3_X4
* cell instance $2891 r0 *1 139.84,102.2
X$2891 911 1174 428 395 1173 NOR2_X2
* cell instance $2894 r0 *1 145.35,102.2
X$2894 1125 1175 428 395 1176 NOR2_X1
* cell instance $2895 r0 *1 145.92,102.2
X$2895 1176 797 1191 428 395 1149 NOR3_X1
* cell instance $2897 r0 *1 146.87,102.2
X$2897 1098 428 395 1191 INV_X1
* cell instance $2898 r0 *1 147.25,102.2
X$2898 1098 1125 1194 428 1126 395 AOI21_X1
* cell instance $2901 r0 *1 148.96,102.2
X$2901 1098 1125 395 428 1190 XNOR2_X1
* cell instance $2905 r0 *1 153.71,102.2
X$2905 1099 1100 1188 1128 428 1233 395 NAND4_X2
* cell instance $2923 r0 *1 251.18,102.2
X$2923 1187 428 395 LOGIC0_X1
* cell instance $2924 r0 *1 251.56,102.2
X$2924 1187 428 395 1178 BUF_X1
* cell instance $2925 r0 *1 252.13,102.2
X$2925 1185 428 395 LOGIC0_X1
* cell instance $2926 r0 *1 252.51,102.2
X$2926 1185 428 395 1132 BUF_X1
* cell instance $2927 r0 *1 253.08,102.2
X$2927 1205 428 395 LOGIC0_X1
* cell instance $2929 m0 *1 121.41,105
X$2929 1169 809 1229 810 797 428 395 1259 AOI221_X1
* cell instance $2930 m0 *1 122.55,105
X$2930 908 1170 428 395 1169 NAND2_X1
* cell instance $2931 m0 *1 123.12,105
X$2931 908 880 1170 428 395 1242 NAND3_X1
* cell instance $2932 m0 *1 123.88,105
X$2932 1260 1170 395 428 999 AND2_X1
* cell instance $2934 m0 *1 125.02,105
X$2934 1009 1220 1221 428 1241 395 AOI21_X1
* cell instance $2936 m0 *1 125.97,105
X$2936 1293 1201 1114 428 395 1221 NAND3_X1
* cell instance $2938 m0 *1 127.11,105
X$2938 1202 909 1037 999 428 395 1201 NAND4_X1
* cell instance $2939 m0 *1 128.06,105
X$2939 1276 428 395 752 CLKBUF_X3
* cell instance $2940 m0 *1 129.01,105
X$2940 909 1232 1202 395 1240 428 OAI21_X1
* cell instance $2943 m0 *1 130.34,105
X$2943 1194 998 1171 428 395 1230 NAND3_X1
* cell instance $2946 m0 *1 134.33,105
X$2946 428 1203 1238 910 911 998 395 NOR4_X4
* cell instance $2947 m0 *1 137.75,105
X$2947 1218 1127 428 395 1262 NOR2_X1
* cell instance $2950 m0 *1 138.89,105
X$2950 1204 881 428 395 1172 NOR2_X1
* cell instance $2951 m0 *1 139.46,105
X$2951 1173 1172 881 1216 428 395 1218 AOI22_X1
* cell instance $2953 m0 *1 140.6,105
X$2953 1173 1204 1202 395 1216 428 OAI21_X1
* cell instance $2961 m0 *1 152.19,105
X$2961 1235 1215 1177 1188 1214 1318 395 428 AOI221_X2
* cell instance $2985 m0 *1 250.8,105
X$2985 1213 428 395 LOGIC0_X1
* cell instance $2986 m0 *1 251.18,105
X$2986 1213 428 395 1236 BUF_X1
* cell instance $2987 m0 *1 251.75,105
X$2987 1212 428 395 LOGIC0_X1
* cell instance $2988 m0 *1 252.13,105
X$2988 1212 428 395 1179 BUF_X1
* cell instance $2990 m0 *1 252.89,105
X$2990 1205 428 395 1206 BUF_X1
* cell instance $2992 r0 *1 2.47,93.8
X$2992 953 963 954 395 428 957 HA_X1
* cell instance $2994 r0 *1 4.37,93.8
X$2994 938 939 918 954 428 1004 395 NAND4_X2
* cell instance $2995 r0 *1 6.08,93.8
X$2995 939 918 428 395 940 NAND2_X1
* cell instance $2996 r0 *1 6.65,93.8
X$2996 919 940 959 395 1005 428 OAI21_X1
* cell instance $3000 r0 *1 16.72,93.8
X$3000 902 941 942 395 960 428 OAI21_X1
* cell instance $3001 r0 *1 17.48,93.8
X$3001 943 902 428 395 942 NAND2_X1
* cell instance $3022 r0 *1 1.33,93.8
X$3022 935 428 395 958 BUF_X1
* cell instance $3029 m0 *1 3.99,96.6
X$3029 958 985 938 395 428 955 HA_X1
* cell instance $3034 m0 *1 15.96,96.6
X$3034 902 974 395 428 985 XNOR2_X1
* cell instance $3035 m0 *1 17.1,96.6
X$3035 974 793 428 395 941 NAND2_X1
* cell instance $3036 m0 *1 17.67,96.6
X$3036 800 974 801 395 943 428 OAI21_X1
* cell instance $3038 m0 *1 18.62,96.6
X$3038 428 975 803 831 804 974 395 NOR4_X4
* cell instance $3042 m0 *1 27.36,96.6
X$3042 428 3350 1011 1020 753 395 DFF_X1
* cell instance $3044 m0 *1 30.78,96.6
X$3044 870 428 395 800 CLKBUF_X3
* cell instance $3064 r0 *1 122.17,93.8
X$3064 933 428 395 758 BUF_X2
* cell instance $3071 m0 *1 121.98,96.6
X$3071 995 809 944 810 797 428 395 976 AOI221_X1
* cell instance $3076 m0 *1 136.42,96.6
X$3076 879 992 972 428 395 977 OR3_X1
* cell instance $3078 r0 *1 137.18,93.8
X$3078 428 910 911 912 908 395 NOR3_X4
* cell instance $3081 m0 *1 137.37,96.6
X$3081 1013 428 395 879 CLKBUF_X2
* cell instance $3084 r0 *1 140.98,93.8
X$3084 906 978 880 945 428 395 946 AOI22_X1
* cell instance $3105 m0 *1 142.69,96.6
X$3105 906 978 880 1001 428 395 990 AOI22_X1
* cell instance $3106 m0 *1 143.64,96.6
X$3106 979 758 1001 428 395 991 OR3_X1
* cell instance $3107 m0 *1 144.59,96.6
X$3107 980 990 991 395 1012 428 OAI21_X1
* cell instance $3108 m0 *1 145.35,96.6
X$3108 979 428 395 980 INV_X1
* cell instance $3113 m0 *1 151.24,96.6
X$3113 428 3390 988 989 981 395 DFF_X1
* cell instance $3114 m0 *1 154.47,96.6
X$3114 988 428 395 948 BUF_X2
* cell instance $3136 m0 *1 250.23,96.6
X$3136 987 428 395 LOGIC0_X1
* cell instance $3138 r0 *1 250.23,93.8
X$3138 967 428 395 LOGIC0_X1
* cell instance $3139 r0 *1 251.37,93.8
X$3139 967 428 395 951 BUF_X1
* cell instance $3141 r0 *1 252.13,93.8
X$3141 964 428 395 LOGIC0_X1
* cell instance $3142 r0 *1 252.51,93.8
X$3142 964 428 395 950 BUF_X1
* cell instance $3143 r0 *1 253.08,93.8
X$3143 982 428 395 LOGIC0_X1
* cell instance $3147 m0 *1 251.18,96.6
X$3147 987 428 395 949 BUF_X1
* cell instance $3148 m0 *1 251.75,96.6
X$3148 986 428 395 LOGIC0_X1
* cell instance $3150 m0 *1 252.32,96.6
X$3150 986 428 395 983 BUF_X1
* cell instance $3151 m0 *1 252.89,96.6
X$3151 982 428 395 984 BUF_X1
* cell instance $3225 r0 *1 250.23,18.2
X$3225 463 428 395 LOGIC0_X1
* cell instance $3229 r0 *1 251.56,18.2
X$3229 473 428 395 LOGIC0_X1
* cell instance $3231 r0 *1 252.13,18.2
X$3231 509 428 395 LOGIC0_X1
* cell instance $3236 m0 *1 250.23,21
X$3236 469 428 395 LOGIC0_X1
* cell instance $3238 m0 *1 251.37,21
X$3238 488 428 395 LOGIC0_X1
* cell instance $3239 m0 *1 252.32,21
X$3239 497 428 395 LOGIC0_X1
* cell instance $3242 r0 *1 250.23,54.6
X$3242 571 428 395 LOGIC0_X1
* cell instance $3245 r0 *1 250.8,54.6
X$3245 571 428 395 568 BUF_X1
* cell instance $3247 r0 *1 251.56,54.6
X$3247 569 428 395 LOGIC0_X1
* cell instance $3248 r0 *1 251.94,54.6
X$3248 569 428 395 552 BUF_X1
* cell instance $3249 r0 *1 252.51,54.6
X$3249 574 428 395 LOGIC0_X1
* cell instance $3250 r0 *1 252.89,54.6
X$3250 574 428 395 564 BUF_X1
* cell instance $3253 m0 *1 250.23,57.4
X$3253 572 428 395 LOGIC0_X1
* cell instance $3254 m0 *1 250.61,57.4
X$3254 572 428 395 566 BUF_X1
* cell instance $3256 m0 *1 251.37,57.4
X$3256 570 428 395 LOGIC0_X1
* cell instance $3257 m0 *1 251.75,57.4
X$3257 570 428 395 567 BUF_X1
* cell instance $3258 m0 *1 252.32,57.4
X$3258 573 428 395 LOGIC0_X1
* cell instance $3259 m0 *1 252.7,57.4
X$3259 573 428 395 563 BUF_X1
* cell instance $3262 r0 *1 250.23,147
X$3262 1956 428 395 LOGIC0_X1
* cell instance $3266 m0 *1 250.23,149.8
X$3266 1957 428 395 LOGIC0_X1
* cell instance $3268 m0 *1 250.8,149.8
X$3268 1954 428 395 LOGIC0_X1
* cell instance $3269 r0 *1 251.18,147
X$3269 1956 428 395 1950 BUF_X1
* cell instance $3272 r0 *1 252.51,147
X$3272 1952 428 395 LOGIC0_X1
* cell instance $3273 r0 *1 252.89,147
X$3273 1952 428 395 1949 BUF_X1
* cell instance $3275 m0 *1 251.18,149.8
X$3275 1954 428 395 1947 BUF_X1
* cell instance $3276 m0 *1 251.75,149.8
X$3276 1957 428 395 1948 BUF_X1
* cell instance $3277 m0 *1 252.32,149.8
X$3277 1951 428 395 LOGIC0_X1
* cell instance $3279 m0 *1 252.89,149.8
X$3279 1951 428 395 1944 BUF_X1
* cell instance $3281 r0 *1 250.23,49
X$3281 549 428 395 LOGIC0_X1
* cell instance $3283 r0 *1 250.61,49
X$3283 549 428 395 542 BUF_X1
* cell instance $3286 r0 *1 252.13,49
X$3286 545 428 395 LOGIC0_X1
* cell instance $3288 r0 *1 252.7,49
X$3288 545 428 395 540 BUF_X1
* cell instance $3292 m0 *1 250.23,51.8
X$3292 561 428 395 LOGIC0_X1
* cell instance $3293 m0 *1 250.61,51.8
X$3293 561 428 395 544 BUF_X1
* cell instance $3295 m0 *1 251.37,51.8
X$3295 560 428 395 LOGIC0_X1
* cell instance $3296 m0 *1 251.75,51.8
X$3296 560 428 395 539 BUF_X1
* cell instance $3297 m0 *1 252.32,51.8
X$3297 558 428 395 LOGIC0_X1
* cell instance $3298 m0 *1 252.7,51.8
X$3298 558 428 395 556 BUF_X1
* cell instance $3301 r0 *1 250.23,65.8
X$3301 610 428 395 LOGIC0_X1
* cell instance $3303 r0 *1 250.61,65.8
X$3303 610 428 395 605 BUF_X1
* cell instance $3306 m0 *1 250.23,68.6
X$3306 622 428 395 LOGIC0_X1
* cell instance $3307 m0 *1 250.61,68.6
X$3307 622 428 395 604 BUF_X1
* cell instance $3309 r0 *1 251.94,65.8
X$3309 611 428 395 601 BUF_X1
* cell instance $3310 r0 *1 251.56,65.8
X$3310 611 428 395 LOGIC0_X1
* cell instance $3311 r0 *1 252.51,65.8
X$3311 607 428 395 LOGIC0_X1
* cell instance $3312 r0 *1 252.89,65.8
X$3312 607 428 395 602 BUF_X1
* cell instance $3315 m0 *1 252.32,68.6
X$3315 619 428 395 614 BUF_X1
* cell instance $3316 m0 *1 252.89,68.6
X$3316 619 428 395 LOGIC0_X1
* cell instance $3319 r0 *1 250.23,127.4
X$3319 1819 428 395 LOGIC0_X1
* cell instance $3323 m0 *1 250.23,130.2
X$3323 1841 428 395 LOGIC0_X1
* cell instance $3324 m0 *1 250.61,130.2
X$3324 1841 428 395 1839 BUF_X1
* cell instance $3325 r0 *1 251.18,127.4
X$3325 1818 428 395 LOGIC0_X1
* cell instance $3329 m0 *1 251.56,130.2
X$3329 1840 428 395 LOGIC0_X1
* cell instance $3330 r0 *1 252.13,127.4
X$3330 1819 428 395 1813 BUF_X1
* cell instance $3332 r0 *1 252.7,127.4
X$3332 1818 428 395 1778 BUF_X1
* cell instance $3335 m0 *1 251.94,130.2
X$3335 1837 428 395 LOGIC0_X1
* cell instance $3336 m0 *1 252.32,130.2
X$3336 1840 428 395 1838 BUF_X1
* cell instance $3337 m0 *1 252.89,130.2
X$3337 1837 428 395 1812 BUF_X1
* cell instance $3339 r0 *1 250.23,32.2
X$3339 468 428 395 LOGIC0_X1
* cell instance $3341 r0 *1 251.18,32.2
X$3341 490 428 395 LOGIC0_X1
* cell instance $3344 m0 *1 250.23,35
X$3344 465 428 395 LOGIC0_X1
* cell instance $3346 m0 *1 251.37,35
X$3346 485 428 395 LOGIC0_X1
* cell instance $3347 m0 *1 252.32,35
X$3347 501 428 395 LOGIC0_X1
* cell instance $3348 r0 *1 252.51,32.2
X$3348 526 428 395 LOGIC0_X1
* cell instance $3352 r0 *1 250.23,214.2
X$3352 2660 428 395 LOGIC0_X1
* cell instance $3354 r0 *1 250.61,214.2
X$3354 2660 428 395 2657 BUF_X1
* cell instance $3358 m0 *1 250.23,217
X$3358 2704 428 395 LOGIC0_X1
* cell instance $3359 m0 *1 250.61,217
X$3359 2704 428 395 2681 BUF_X1
* cell instance $3360 m0 *1 251.18,217
X$3360 2703 428 395 LOGIC0_X1
* cell instance $3362 m0 *1 251.75,217
X$3362 2702 428 395 LOGIC0_X1
* cell instance $3363 m0 *1 252.13,217
X$3363 2703 428 395 2680 BUF_X1
* cell instance $3364 r0 *1 252.51,214.2
X$3364 2659 428 395 LOGIC0_X1
* cell instance $3366 r0 *1 252.89,214.2
X$3366 2659 428 395 2656 BUF_X1
* cell instance $3369 m0 *1 252.89,217
X$3369 2702 428 395 2682 BUF_X1
* cell instance $3377 m0 *1 211.09,4.2
X$3377 412 428 395 LOGIC0_X1
* cell instance $3381 m0 *1 212.61,4.2
X$3381 416 428 395 LOGIC0_X1
* cell instance $3383 m0 *1 214.32,4.2
X$3383 415 428 395 LOGIC0_X1
* cell instance $3385 m0 *1 215.27,4.2
X$3385 422 428 395 LOGIC0_X1
* cell instance $3387 m0 *1 216.79,4.2
X$3387 421 428 395 LOGIC0_X1
* cell instance $3389 m0 *1 217.36,4.2
X$3389 420 428 395 LOGIC0_X1
* cell instance $3391 m0 *1 217.93,4.2
X$3391 419 428 395 LOGIC0_X1
* cell instance $3393 m0 *1 218.5,4.2
X$3393 418 428 395 LOGIC0_X1
* cell instance $3395 m0 *1 219.07,4.2
X$3395 417 428 395 LOGIC0_X1
* cell instance $3401 m0 *1 223.82,4.2
X$3401 425 428 395 LOGIC0_X1
* cell instance $3403 m0 *1 224.39,4.2
X$3403 424 428 395 LOGIC0_X1
* cell instance $3405 m0 *1 224.96,4.2
X$3405 423 428 395 LOGIC0_X1
* cell instance $3410 m0 *1 227.24,4.2
X$3410 427 428 395 LOGIC0_X1
* cell instance $3413 m0 *1 228.19,4.2
X$3413 426 428 395 LOGIC0_X1
* cell instance $3415 m0 *1 228.76,4.2
X$3415 430 428 395 LOGIC0_X1
* cell instance $3418 m0 *1 230.47,4.2
X$3418 429 428 395 LOGIC0_X1
* cell instance $3420 m0 *1 231.8,4.2
X$3420 434 428 395 LOGIC0_X1
* cell instance $3422 m0 *1 233.13,4.2
X$3422 433 428 395 LOGIC0_X1
* cell instance $3424 m0 *1 233.7,4.2
X$3424 432 428 395 LOGIC0_X1
* cell instance $3426 m0 *1 234.65,4.2
X$3426 440 428 395 LOGIC0_X1
* cell instance $3428 m0 *1 235.22,4.2
X$3428 439 428 395 LOGIC0_X1
* cell instance $3430 m0 *1 235.79,4.2
X$3430 438 428 395 LOGIC0_X1
* cell instance $3432 m0 *1 236.36,4.2
X$3432 437 428 395 LOGIC0_X1
* cell instance $3434 m0 *1 236.93,4.2
X$3434 436 428 395 LOGIC0_X1
* cell instance $3436 m0 *1 237.5,4.2
X$3436 435 428 395 LOGIC0_X1
* cell instance $3438 m0 *1 238.07,4.2
X$3438 445 428 395 LOGIC0_X1
* cell instance $3440 m0 *1 238.64,4.2
X$3440 444 428 395 LOGIC0_X1
* cell instance $3442 m0 *1 239.21,4.2
X$3442 443 428 395 LOGIC0_X1
* cell instance $3444 m0 *1 239.78,4.2
X$3444 442 428 395 LOGIC0_X1
* cell instance $3455 m0 *1 242.25,4.2
X$3455 448 428 395 LOGIC0_X1
* cell instance $3457 m0 *1 242.82,4.2
X$3457 447 428 395 LOGIC0_X1
* cell instance $3460 m0 *1 244.15,4.2
X$3460 446 428 395 LOGIC0_X1
* cell instance $3463 m0 *1 245.48,4.2
X$3463 452 428 395 LOGIC0_X1
* cell instance $3466 m0 *1 247.19,4.2
X$3466 450 428 395 LOGIC0_X1
* cell instance $3468 r0 *1 251.37,1.4
X$3468 482 428 395 LOGIC0_X1
* cell instance $3471 m0 *1 247.76,4.2
X$3471 459 428 395 LOGIC0_X1
* cell instance $3474 m0 *1 249.09,4.2
X$3474 457 428 395 LOGIC0_X1
* cell instance $3476 m0 *1 249.66,4.2
X$3476 453 428 395 LOGIC0_X1
* cell instance $3478 m0 *1 251.37,4.2
X$3478 484 428 395 LOGIC0_X1
* cell instance $3480 r0 *1 252.89,158.2
X$3480 1995 428 395 1991 BUF_X1
* cell instance $3481 r0 *1 252.51,158.2
X$3481 1995 428 395 LOGIC0_X1
* cell instance $3484 m0 *1 252.7,161
X$3484 1996 428 395 1990 BUF_X1
* cell instance $3487 r0 *1 6.46,124.6
X$3487 1479 428 395 1694 BUF_X1
* cell instance $3495 r0 *1 29.26,124.6
X$3495 1247 428 395 793 CLKBUF_X3
* cell instance $3499 r0 *1 37.24,124.6
X$3499 1697 1434 428 395 1247 NOR2_X2
* cell instance $3500 r0 *1 38.19,124.6
X$3500 1698 1676 428 395 1697 NAND2_X2
* cell instance $3501 r0 *1 39.14,124.6
X$3501 428 3446 1699 1727 1117 395 DFF_X1
* cell instance $3503 r0 *1 45.41,124.6
X$3503 1729 1700 1413 395 1701 428 OAI21_X1
* cell instance $3504 r0 *1 46.17,124.6
X$3504 1701 428 395 1758 INV_X1
* cell instance $3518 r0 *1 117.23,124.6
X$3518 1479 1549 428 395 1730 NAND2_X1
* cell instance $3519 r0 *1 117.8,124.6
X$3519 428 3454 1550 1772 1507 395 DFF_X1
* cell instance $3523 r0 *1 122.93,124.6
X$3523 428 3410 1788 1731 1507 395 DFF_X1
* cell instance $3527 r0 *1 128.63,124.6
X$3527 428 3438 1678 1703 1507 395 DFF_X1
* cell instance $3534 m0 *1 1.52,127.4
X$3534 1737 428 395 1779 BUF_X1
* cell instance $3537 m0 *1 2.66,127.4
X$3537 1673 1741 1696 395 428 1738 HA_X1
* cell instance $3538 r0 *1 3.42,124.6
X$3538 1696 1713 428 395 1642 NAND2_X1
* cell instance $3540 r0 *1 3.99,124.6
X$3540 1712 1722 1713 395 428 1714 HA_X1
* cell instance $3542 m0 *1 4.56,127.4
X$3542 1738 1714 1696 428 1760 395 AOI21_X1
* cell instance $3543 m0 *1 5.32,127.4
X$3543 1760 1739 1780 395 1581 428 OAI21_X1
* cell instance $3546 m0 *1 7.22,127.4
X$3546 1695 428 395 1754 BUF_X1
* cell instance $3552 m0 *1 16.72,127.4
X$3552 1761 1744 395 1742 428 XOR2_X2
* cell instance $3555 m0 *1 19,127.4
X$3555 1743 1045 1742 428 1879 395 AOI21_X1
* cell instance $3557 m0 *1 19.95,127.4
X$3557 1247 1744 1291 428 1743 395 AOI21_X1
* cell instance $3562 m0 *1 25.08,127.4
X$3562 793 1786 1291 428 1762 395 AOI21_X1
* cell instance $3565 m0 *1 26.79,127.4
X$3565 1763 1759 428 395 1722 XNOR2_X2
* cell instance $3568 m0 *1 35.15,127.4
X$3568 1697 428 395 1339 CLKBUF_X3
* cell instance $3569 m0 *1 36.1,127.4
X$3569 1503 1697 428 1152 395 NAND2_X4
* cell instance $3570 m0 *1 37.81,127.4
X$3570 1697 395 1156 428 BUF_X4
* cell instance $3573 m0 *1 42.56,127.4
X$3573 810 1699 395 428 1765 AND2_X1
* cell instance $3574 m0 *1 43.32,127.4
X$3574 1803 1699 1546 395 1745 428 NOR3_X2
* cell instance $3576 m0 *1 44.84,127.4
X$3576 428 1758 749 3312 1698 395 DFF_X2
* cell instance $3577 m0 *1 48.45,127.4
X$3577 1757 1745 395 428 1768 AND2_X1
* cell instance $3591 m0 *1 117.04,127.4
X$3591 1788 1769 1621 428 395 1770 NOR3_X1
* cell instance $3592 m0 *1 117.8,127.4
X$3592 1791 1770 395 428 1771 AND2_X1
* cell instance $3594 m0 *1 118.75,127.4
X$3594 1730 1770 1702 428 1866 395 AOI21_X2
* cell instance $3599 m0 *1 130.15,127.4
X$3599 428 3396 1787 1735 1807 395 DFF_X1
* cell instance $3600 r0 *1 133,124.6
X$3600 1706 978 1680 395 1705 428 OAI21_X1
* cell instance $3601 r0 *1 132.24,124.6
X$3601 1009 1704 1705 428 1735 395 AOI21_X1
* cell instance $3605 r0 *1 138.51,124.6
X$3605 1447 1464 428 395 1707 NAND2_X1
* cell instance $3608 r0 *1 141.36,124.6
X$3608 1464 1638 1552 428 395 1756 NAND3_X1
* cell instance $3609 r0 *1 142.12,124.6
X$3609 428 1638 1708 1773 1552 1447 395 AND4_X4
* cell instance $3612 m0 *1 133.38,127.4
X$3612 1787 428 395 1680 BUF_X2
* cell instance $3615 m0 *1 138.7,127.4
X$3615 1707 1465 395 1774 428 XOR2_X2
* cell instance $3617 m0 *1 141.93,127.4
X$3617 1441 1204 1708 428 395 1783 NAND3_X1
* cell instance $3619 m0 *1 142.88,127.4
X$3619 1756 1708 395 1775 428 XOR2_X2
* cell instance $3622 r0 *1 145.73,124.6
X$3622 1688 1638 395 1721 428 XOR2_X2
* cell instance $3628 m0 *1 149.72,127.4
X$3628 1749 1721 1784 395 428 1755 HA_X1
* cell instance $3629 m0 *1 151.62,127.4
X$3629 1784 1746 428 395 1385 NAND2_X1
* cell instance $3630 m0 *1 152.19,127.4
X$3630 1822 1746 1755 428 1753 395 AOI21_X1
* cell instance $3632 r0 *1 152.38,124.6
X$3632 1753 1350 1752 395 1215 428 OAI21_X1
* cell instance $3649 r0 *1 251.18,124.6
X$3649 1717 428 395 LOGIC0_X1
* cell instance $3650 r0 *1 251.56,124.6
X$3650 1717 428 395 1711 BUF_X1
* cell instance $3651 r0 *1 252.13,124.6
X$3651 1715 428 395 LOGIC0_X1
* cell instance $3652 r0 *1 252.51,124.6
X$3652 1715 428 395 1710 BUF_X1
* cell instance $3653 r0 *1 253.08,124.6
X$3653 1709 428 395 LOGIC0_X1
* cell instance $3655 m0 *1 152.95,127.4
X$3655 1747 1748 428 395 1350 NAND2_X1
* cell instance $3677 m0 *1 250.8,127.4
X$3677 1782 428 395 LOGIC0_X1
* cell instance $3678 m0 *1 251.18,127.4
X$3678 1782 428 395 1750 BUF_X1
* cell instance $3679 m0 *1 251.75,127.4
X$3679 1781 428 395 LOGIC0_X1
* cell instance $3681 m0 *1 252.32,127.4
X$3681 1781 428 395 1777 BUF_X1
* cell instance $3682 m0 *1 252.89,127.4
X$3682 1709 428 395 1751 BUF_X1
* cell instance $3696 r0 *1 250.8,23.8
X$3696 476 428 395 LOGIC0_X1
* cell instance $3698 m0 *1 250.8,26.6
X$3698 481 428 395 LOGIC0_X1
* cell instance $3699 m0 *1 251.75,26.6
X$3699 515 428 395 LOGIC0_X1
* cell instance $3702 r0 *1 252.13,23.8
X$3702 507 428 395 LOGIC0_X1
* cell instance $3706 r0 *1 252.89,203
X$3706 2575 428 395 2573 BUF_X1
* cell instance $3707 r0 *1 252.51,203
X$3707 2575 428 395 LOGIC0_X1
* cell instance $3709 m0 *1 252.51,205.8
X$3709 2612 428 395 LOGIC0_X1
* cell instance $3710 m0 *1 252.89,205.8
X$3710 2612 428 395 2605 BUF_X1
* cell instance $3712 r0 *1 3.8,110.6
X$3712 1367 428 395 1311 BUF_X1
* cell instance $3713 r0 *1 3.23,110.6
X$3713 1364 428 395 1310 BUF_X1
* cell instance $3714 r0 *1 4.37,110.6
X$3714 1368 428 395 1396 BUF_X1
* cell instance $3718 m0 *1 3.42,113.4
X$3718 1369 428 395 1393 BUF_X1
* cell instance $3719 m0 *1 3.99,113.4
X$3719 1393 1424 1392 395 428 1370 HA_X1
* cell instance $3722 r0 *1 6.08,110.6
X$3722 1335 1336 1370 428 395 1394 NAND3_X1
* cell instance $3724 r0 *1 10.64,110.6
X$3724 428 3470 1312 1355 1117 395 DFF_X1
* cell instance $3726 m0 *1 6.27,113.4
X$3726 1337 1394 428 395 1371 NAND2_X1
* cell instance $3728 m0 *1 7.03,113.4
X$3728 1395 1362 1423 395 428 1457 HA_X1
* cell instance $3732 m0 *1 13.87,113.4
X$3732 1313 1314 395 428 1455 XNOR2_X1
* cell instance $3733 r0 *1 14.44,110.6
X$3733 1314 1398 1313 1338 428 395 1372 AOI22_X1
* cell instance $3735 r0 *1 15.39,110.6
X$3735 1372 1356 428 395 1355 NOR2_X1
* cell instance $3740 r0 *1 21.47,110.6
X$3740 1403 1340 428 395 1121 OR2_X2
* cell instance $3742 r0 *1 22.61,110.6
X$3742 428 1403 1340 1315 1316 1046 395 NOR4_X4
* cell instance $3743 r0 *1 26.03,110.6
X$3743 804 1156 1255 428 395 1341 NOR3_X1
* cell instance $3744 r0 *1 26.79,110.6
X$3744 1341 1255 1342 428 1359 395 AOI21_X1
* cell instance $3746 r0 *1 27.74,110.6
X$3746 1359 1356 428 395 1375 NOR2_X1
* cell instance $3750 m0 *1 15.77,113.4
X$3750 1358 428 395 1373 INV_X1
* cell instance $3753 m0 *1 18.05,113.4
X$3753 1313 428 395 1459 INV_X1
* cell instance $3754 m0 *1 18.43,113.4
X$3754 428 804 1374 1316 1315 1403 395 OR4_X4
* cell instance $3756 m0 *1 21.66,113.4
X$3756 428 1403 1315 1316 1374 1168 395 NOR4_X4
* cell instance $3761 m0 *1 27.93,113.4
X$3761 428 3354 1405 1375 753 395 DFF_X1
* cell instance $3765 m0 *1 31.16,113.4
X$3765 1405 395 1255 428 BUF_X4
* cell instance $3766 r0 *1 31.92,110.6
X$3766 1343 1253 395 1362 428 XOR2_X2
* cell instance $3768 r0 *1 33.63,110.6
X$3768 1046 1255 428 395 1343 NAND2_X1
* cell instance $3769 r0 *1 34.2,110.6
X$3769 1339 1343 428 395 1407 NOR2_X1
* cell instance $3770 r0 *1 34.77,110.6
X$3770 1339 1255 1046 428 1365 395 AOI21_X1
* cell instance $3775 r0 *1 36.86,110.6
X$3775 1317 1406 1254 1366 428 395 1408 AOI22_X1
* cell instance $3777 r0 *1 37.81,110.6
X$3777 1407 1253 1413 1365 1363 395 428 1409 OAI221_X1
* cell instance $3778 r0 *1 38.95,110.6
X$3778 428 3463 1360 1412 1117 395 DFF_X1
* cell instance $3785 m0 *1 38,113.4
X$3785 1411 1123 1280 395 874 428 NOR3_X2
* cell instance $3786 m0 *1 39.33,113.4
X$3786 1408 1356 428 395 1412 NOR2_X1
* cell instance $3790 r0 *1 53.39,110.6
X$3790 1292 395 810 428 BUF_X4
* cell instance $3825 m0 *1 121.6,113.4
X$3825 1427 933 428 395 1426 NOR2_X1
* cell instance $3828 r0 *1 122.36,110.6
X$3828 1344 1292 428 395 933 NAND2_X1
* cell instance $3831 r0 *1 125.02,110.6
X$3831 1416 1344 797 428 395 NOR2_X4
* cell instance $3833 m0 *1 125.21,113.4
X$3833 1427 809 428 395 1473 NAND2_X1
* cell instance $3834 m0 *1 125.78,113.4
X$3834 1427 1294 880 428 395 1474 NAND3_X1
* cell instance $3836 m0 *1 126.73,113.4
X$3836 1294 1232 428 395 1429 NOR2_X1
* cell instance $3837 r0 *1 127.3,110.6
X$3837 1295 1345 735 428 1425 395 AOI21_X1
* cell instance $3843 m0 *1 127.68,113.4
X$3843 735 1345 428 395 1428 NAND2_X1
* cell instance $3845 m0 *1 128.63,113.4
X$3845 1344 428 395 1194 CLKBUF_X3
* cell instance $3848 m0 *1 130.53,113.4
X$3848 1418 1346 1377 735 428 1427 395 NAND4_X2
* cell instance $3850 r0 *1 133.19,110.6
X$3850 1261 1378 1376 395 428 1379 HA_X1
* cell instance $3851 r0 *1 132.24,110.6
X$3851 1175 428 395 1204 CLKBUF_X3
* cell instance $3854 r0 *1 137.94,110.6
X$3854 1422 428 395 1421 INV_X1
* cell instance $3858 m0 *1 132.81,113.4
X$3858 1347 1376 395 428 1377 AND2_X1
* cell instance $3860 m0 *1 133.76,113.4
X$3860 1466 1377 1419 1347 1379 1432 395 428 AOI221_X2
* cell instance $3861 m0 *1 135.85,113.4
X$3861 428 3391 1380 1421 981 395 DFF_X1
* cell instance $3863 m0 *1 139.27,113.4
X$3863 1348 1420 1413 395 1422 428 OAI21_X1
* cell instance $3864 r0 *1 139.65,110.6
X$3864 1381 1232 1349 428 395 1348 NOR3_X1
* cell instance $3869 m0 *1 140.22,113.4
X$3869 797 1194 1381 428 1417 395 AOI21_X1
* cell instance $3871 m0 *1 141.17,113.4
X$3871 1417 1382 428 395 1420 NOR2_X1
* cell instance $3872 r0 *1 141.74,110.6
X$3872 1349 428 395 1382 INV_X1
* cell instance $3874 r0 *1 142.12,110.6
X$3874 1382 1381 395 428 1330 XNOR2_X1
* cell instance $3876 r0 *1 144.78,110.6
X$3876 428 3423 1410 1383 981 395 DFF_X1
* cell instance $3877 r0 *1 148.01,110.6
X$3877 1410 395 1357 428 BUF_X4
* cell instance $3880 r0 *1 151.05,110.6
X$3880 1350 1233 1234 1385 395 1346 428 NOR4_X2
* cell instance $3881 r0 *1 152.76,110.6
X$3881 1234 1233 1350 1385 428 395 1404 OR4_X1
* cell instance $3885 m0 *1 142.69,113.4
X$3885 883 1204 1202 395 1414 428 OAI21_X1
* cell instance $3890 m0 *1 144.21,113.4
X$3890 1175 1174 1357 428 395 1415 NOR3_X1
* cell instance $3891 m0 *1 144.97,113.4
X$3891 1415 1357 1414 428 1384 395 AOI21_X1
* cell instance $3892 m0 *1 145.73,113.4
X$3892 1384 1127 428 395 1383 NOR2_X1
* cell instance $3898 m0 *1 152.19,113.4
X$3898 1318 1309 1404 1432 1345 428 395 OAI211_X2
* cell instance $3900 r0 *1 154.47,110.6
X$3900 1319 1264 1326 1331 428 1234 395 NAND4_X2
* cell instance $3902 r0 *1 156.18,110.6
X$3902 1300 1386 1326 395 428 1320 HA_X1
* cell instance $3919 r0 *1 250.8,110.6
X$3919 1401 428 395 LOGIC0_X1
* cell instance $3921 r0 *1 251.94,110.6
X$3921 1397 428 395 LOGIC0_X1
* cell instance $3922 r0 *1 252.32,110.6
X$3922 1397 428 395 1352 BUF_X1
* cell instance $3923 r0 *1 252.89,110.6
X$3923 1401 428 395 1387 BUF_X1
* cell instance $3950 m0 *1 250.23,113.4
X$3950 1402 428 395 LOGIC0_X1
* cell instance $3951 m0 *1 250.61,113.4
X$3951 1402 428 395 1388 BUF_X1
* cell instance $3953 m0 *1 251.37,113.4
X$3953 1400 428 395 LOGIC0_X1
* cell instance $3954 m0 *1 251.75,113.4
X$3954 1399 428 395 LOGIC0_X1
* cell instance $3955 m0 *1 252.13,113.4
X$3955 1400 428 395 1431 BUF_X1
* cell instance $3957 m0 *1 252.89,113.4
X$3957 1399 428 395 1390 BUF_X1
* cell instance $3959 r0 *1 3.04,99.4
X$3959 1039 428 395 1208 BUF_X1
* cell instance $3961 r0 *1 3.61,99.4
X$3961 1077 428 395 1062 BUF_X1
* cell instance $3962 r0 *1 4.18,99.4
X$3962 1054 1106 1133 395 428 1081 HA_X1
* cell instance $3963 r0 *1 6.08,99.4
X$3963 1040 1004 1041 395 1082 428 NOR3_X2
* cell instance $3964 r0 *1 7.41,99.4
X$3964 1004 1041 428 395 1140 NOR2_X2
* cell instance $3965 r0 *1 8.36,99.4
X$3965 1041 428 395 1083 INV_X1
* cell instance $3967 r0 *1 9.5,99.4
X$3967 1084 1060 1043 1042 428 1040 395 NAND4_X2
* cell instance $3968 r0 *1 11.21,99.4
X$3968 1085 1110 1109 395 1108 428 OAI21_X1
* cell instance $3969 r0 *1 11.97,99.4
X$3969 1044 1043 1064 428 1109 395 AOI21_X1
* cell instance $3975 m0 *1 1.33,102.2
X$3975 1078 428 395 1145 BUF_X1
* cell instance $3976 r0 *1 1.9,99.4
X$3976 1038 428 395 1080 BUF_X1
* cell instance $3981 m0 *1 2.47,102.2
X$3981 1080 1137 1139 395 428 1138 HA_X1
* cell instance $3982 m0 *1 4.37,102.2
X$3982 1133 1139 428 395 1161 NAND2_X1
* cell instance $3983 m0 *1 4.94,102.2
X$3983 1138 1139 1081 428 1119 395 AOI21_X1
* cell instance $3985 m0 *1 7.22,102.2
X$3985 1079 428 395 1143 BUF_X1
* cell instance $3986 m0 *1 7.79,102.2
X$3986 1140 1108 1005 1083 428 395 1197 AOI22_X2
* cell instance $3987 m0 *1 9.5,102.2
X$3987 1143 1144 1084 395 428 1164 HA_X1
* cell instance $3988 m0 *1 11.4,102.2
X$3988 1060 1043 428 395 1110 NAND2_X1
* cell instance $3990 m0 *1 12.35,102.2
X$3990 1145 1113 1042 395 428 1146 HA_X1
* cell instance $3992 r0 *1 13.87,99.4
X$3992 1062 1111 1060 395 428 1064 HA_X1
* cell instance $3994 r0 *1 19,99.4
X$3994 1045 903 975 428 395 1086 NAND3_X1
* cell instance $3995 r0 *1 19.76,99.4
X$3995 1087 428 395 866 BUF_X2
* cell instance $3996 r0 *1 20.52,99.4
X$3996 428 803 831 1121 1088 903 395 NOR4_X4
* cell instance $3999 r0 *1 25.65,99.4
X$3999 993 1065 395 428 1111 XNOR2_X1
* cell instance $4000 r0 *1 26.79,99.4
X$4000 1089 993 428 803 395 NAND2_X4
* cell instance $4001 r0 *1 28.5,99.4
X$4001 1090 1089 993 1046 428 871 395 NAND4_X2
* cell instance $4007 m0 *1 17.1,102.2
X$4007 428 3380 1087 1147 749 395 DFF_X1
* cell instance $4008 m0 *1 20.33,102.2
X$4008 1150 866 428 395 1186 NAND2_X1
* cell instance $4011 m0 *1 21.47,102.2
X$4011 903 1148 1152 395 1150 428 OAI21_X1
* cell instance $4012 m0 *1 22.23,102.2
X$4012 1088 1121 831 428 395 857 OR3_X4
* cell instance $4016 m0 *1 26.41,102.2
X$4016 857 1089 395 1113 428 XOR2_X2
* cell instance $4018 m0 *1 28.31,102.2
X$4018 1089 1090 1168 395 428 1065 AND3_X1
* cell instance $4020 r0 *1 30.78,99.4
X$4020 1092 1067 428 395 1106 XNOR2_X2
* cell instance $4022 r0 *1 32.68,99.4
X$4022 1067 1045 1068 428 395 1093 NAND3_X1
* cell instance $4023 r0 *1 33.44,99.4
X$4023 1092 428 395 1068 INV_X1
* cell instance $4026 r0 *1 34.77,99.4
X$4026 1069 428 395 1092 BUF_X2
* cell instance $4027 r0 *1 35.53,99.4
X$4027 428 3442 1070 1071 1117 395 DFF_X1
* cell instance $4028 r0 *1 38.76,99.4
X$4028 1070 428 395 1089 CLKBUF_X3
* cell instance $4048 m0 *1 31.73,102.2
X$4048 1148 1067 1152 395 1091 428 OAI21_X1
* cell instance $4049 m0 *1 32.49,102.2
X$4049 1091 1092 428 395 1122 NAND2_X1
* cell instance $4050 m0 *1 33.06,102.2
X$4050 1153 1093 1122 428 1021 395 AOI21_X1
* cell instance $4053 m0 *1 34.96,102.2
X$4053 1123 428 395 1045 CLKBUF_X3
* cell instance $4057 m0 *1 37.24,102.2
X$4057 1152 1089 428 395 1154 NAND2_X1
* cell instance $4058 m0 *1 37.81,102.2
X$4058 1154 857 1123 428 1157 395 AOI21_X1
* cell instance $4059 m0 *1 38.57,102.2
X$4059 1156 857 428 395 1094 NOR2_X1
* cell instance $4060 m0 *1 39.14,102.2
X$4060 1094 1089 428 395 1095 NOR2_X1
* cell instance $4061 m0 *1 39.71,102.2
X$4061 1157 1095 1127 428 395 1071 NOR3_X1
* cell instance $4079 m0 *1 115.14,102.2
X$4079 1160 1151 1159 395 428 1116 HA_X1
* cell instance $4080 r0 *1 116.28,99.4
X$4080 1116 1159 1158 428 1047 395 AOI21_X1
* cell instance $4083 m0 *1 117.04,102.2
X$4083 428 1096 1192 1050 1159 704 395 NAND4_X4
* cell instance $4084 r0 *1 117.99,99.4
X$4084 1073 1115 1096 395 428 1074 HA_X1
* cell instance $4085 r0 *1 117.42,99.4
X$4085 1096 1050 428 395 1048 NAND2_X1
* cell instance $4096 m0 *1 124.83,102.2
X$4096 1112 1114 395 1155 428 XOR2_X2
* cell instance $4097 r0 *1 126.35,99.4
X$4097 1114 999 1037 395 428 934 AND3_X1
* cell instance $4099 r0 *1 127.3,99.4
X$4099 1000 1097 395 428 1151 XNOR2_X1
* cell instance $4100 r0 *1 128.44,99.4
X$4100 998 999 428 395 1097 NAND2_X1
* cell instance $4101 r0 *1 129.01,99.4
X$4101 906 978 1097 880 428 395 1072 AOI22_X1
* cell instance $4106 r0 *1 141.36,99.4
X$4106 1025 1052 1107 428 911 395 NAND3_X4
* cell instance $4110 r0 *1 146.3,99.4
X$4110 979 948 1098 395 428 1107 AND3_X1
* cell instance $4111 r0 *1 147.25,99.4
X$4111 979 948 1025 883 395 428 1125 AND4_X1
* cell instance $4115 r0 *1 156.18,99.4
X$4115 1063 1099 1061 428 1101 395 AOI21_X1
* cell instance $4132 r0 *1 251.18,99.4
X$4132 1057 428 395 LOGIC0_X1
* cell instance $4133 r0 *1 251.56,99.4
X$4133 1057 428 395 1053 BUF_X1
* cell instance $4134 r0 *1 252.13,99.4
X$4134 1056 428 395 LOGIC0_X1
* cell instance $4135 r0 *1 252.51,99.4
X$4135 1056 428 395 1102 BUF_X1
* cell instance $4137 m0 *1 126.54,102.2
X$4137 998 1037 999 428 395 1112 NAND3_X1
* cell instance $4141 m0 *1 134.52,102.2
X$4141 1170 909 428 395 685 XNOR2_X2
* cell instance $4143 m0 *1 142.5,102.2
X$4143 1025 1107 1066 395 428 1024 AND3_X1
* cell instance $4149 m0 *1 144.02,102.2
X$4149 428 3400 1098 1124 981 395 DFF_X1
* cell instance $4150 m0 *1 147.25,102.2
X$4150 1149 1126 1127 428 395 1124 NOR3_X1
* cell instance $4156 m0 *1 153.9,102.2
X$4156 1129 1142 1128 395 428 1141 HA_X1
* cell instance $4157 m0 *1 155.8,102.2
X$4157 1141 1099 1100 428 395 1130 NAND3_X1
* cell instance $4158 m0 *1 156.56,102.2
X$4158 1101 1130 428 395 1214 NAND2_X1
* cell instance $4182 m0 *1 250.61,102.2
X$4182 1135 428 395 LOGIC0_X1
* cell instance $4183 m0 *1 250.99,102.2
X$4183 1136 428 395 LOGIC0_X1
* cell instance $4184 m0 *1 251.37,102.2
X$4184 1136 428 395 1103 BUF_X1
* cell instance $4185 m0 *1 251.94,102.2
X$4185 1134 428 395 LOGIC0_X1
* cell instance $4186 m0 *1 252.32,102.2
X$4186 1134 428 395 1104 BUF_X1
* cell instance $4187 m0 *1 252.89,102.2
X$4187 1135 428 395 1131 BUF_X1
* cell instance $4190 r0 *1 1.33,71.4
X$4190 630 428 395 623 BUF_X1
* cell instance $4192 r0 *1 1.9,71.4
X$4192 630 428 395 LOGIC0_X1
* cell instance $4238 r0 *1 251.18,71.4
X$4238 624 428 395 LOGIC0_X1
* cell instance $4239 r0 *1 251.56,71.4
X$4239 634 428 395 LOGIC0_X1
* cell instance $4240 r0 *1 251.94,71.4
X$4240 634 428 395 629 BUF_X1
* cell instance $4241 r0 *1 252.51,71.4
X$4241 632 428 395 LOGIC0_X1
* cell instance $4242 r0 *1 252.89,71.4
X$4242 632 428 395 628 BUF_X1
* cell instance $4275 m0 *1 136.8,74.2
X$4275 649 633 636 395 428 648 HA_X1
* cell instance $4276 m0 *1 138.7,74.2
X$4276 588 647 662 395 428 641 HA_X1
* cell instance $4307 m0 *1 250.23,74.2
X$4307 646 428 395 LOGIC0_X1
* cell instance $4308 m0 *1 250.61,74.2
X$4308 646 428 395 643 BUF_X1
* cell instance $4309 m0 *1 251.18,74.2
X$4309 645 428 395 LOGIC0_X1
* cell instance $4311 m0 *1 251.75,74.2
X$4311 645 428 395 625 BUF_X1
* cell instance $4312 m0 *1 252.32,74.2
X$4312 644 428 395 LOGIC0_X1
* cell instance $4313 m0 *1 252.7,74.2
X$4313 644 428 395 627 BUF_X1
* cell instance $4316 r0 *1 1.33,91
X$4316 898 428 395 847 BUF_X1
* cell instance $4319 r0 *1 3.42,91
X$4319 900 428 395 893 BUF_X1
* cell instance $4320 r0 *1 3.99,91
X$4320 886 864 918 395 428 921 HA_X1
* cell instance $4323 m0 *1 1.33,93.8
X$4323 937 428 395 953 BUF_X1
* cell instance $4324 m0 *1 1.9,93.8
X$4324 899 428 395 956 BUF_X1
* cell instance $4326 m0 *1 2.66,93.8
X$4326 936 428 395 923 BUF_X1
* cell instance $4328 m0 *1 3.99,93.8
X$4328 957 955 954 428 919 395 AOI21_X1
* cell instance $4330 m0 *1 4.94,93.8
X$4330 956 895 939 395 428 901 HA_X1
* cell instance $4332 r0 *1 6.27,91
X$4332 428 889 863 828 887 1041 395 NAND4_X4
* cell instance $4334 m0 *1 6.84,93.8
X$4334 921 918 901 428 959 395 AOI21_X1
* cell instance $4338 m0 *1 8.93,93.8
X$4338 926 922 961 395 428 973 OAI21_X2
* cell instance $4341 r0 *1 10.83,91
X$4341 894 828 829 428 926 395 AOI21_X1
* cell instance $4343 r0 *1 15.39,91
X$4343 756 830 395 428 895 XNOR2_X1
* cell instance $4345 r0 *1 18.05,91
X$4345 866 902 808 428 395 865 NAND3_X2
* cell instance $4346 r0 *1 19.38,91
X$4346 756 808 902 866 395 428 805 AND4_X2
* cell instance $4347 r0 *1 20.71,91
X$4347 866 902 428 395 867 NAND2_X1
* cell instance $4349 r0 *1 22.04,91
X$4349 903 805 428 395 927 NAND2_X1
* cell instance $4350 r0 *1 22.61,91
X$4350 927 807 395 864 428 XOR2_X2
* cell instance $4354 m0 *1 14.25,93.8
X$4354 428 3371 962 960 749 395 DFF_X1
* cell instance $4355 m0 *1 17.48,93.8
X$4355 962 428 395 902 BUF_X2
* cell instance $4358 m0 *1 21.66,93.8
X$4358 808 868 428 395 963 XNOR2_X2
* cell instance $4360 r0 *1 26.03,91
X$4360 868 800 801 395 869 428 OAI21_X1
* cell instance $4361 r0 *1 24.7,91
X$4361 857 803 867 395 868 428 NOR3_X2
* cell instance $4362 r0 *1 26.79,91
X$4362 896 808 869 428 395 833 MUX2_X1
* cell instance $4363 r0 *1 28.12,91
X$4363 870 871 867 428 395 896 NOR3_X1
* cell instance $4372 r0 *1 33.82,91
X$4372 870 805 903 428 873 395 AOI21_X1
* cell instance $4373 r0 *1 33.06,91
X$4373 793 903 805 428 395 928 NAND3_X1
* cell instance $4374 r0 *1 34.58,91
X$4374 807 928 929 395 904 428 OAI21_X1
* cell instance $4376 r0 *1 35.53,91
X$4376 873 874 807 395 929 428 OAI21_X1
* cell instance $4380 m0 *1 34.77,93.8
X$4380 428 3348 930 904 725 395 DFF_X1
* cell instance $4382 r0 *1 36.67,91
X$4382 930 428 395 807 BUF_X2
* cell instance $4419 m0 *1 119.13,93.8
X$4419 428 3377 875 970 752 395 DFF_X1
* cell instance $4420 r0 *1 123.31,91
X$4420 875 428 395 897 INV_X1
* cell instance $4421 r0 *1 122.36,91
X$4421 875 933 907 428 395 905 OR3_X1
* cell instance $4422 r0 *1 123.69,91
X$4422 908 876 428 395 907 NAND2_X1
* cell instance $4423 r0 *1 124.26,91
X$4423 876 909 875 428 395 759 NAND3_X1
* cell instance $4426 r0 *1 127.3,91
X$4426 858 934 998 395 428 761 AND3_X1
* cell instance $4427 r0 *1 128.25,91
X$4427 763 858 934 395 428 876 AND3_X1
* cell instance $4429 r0 *1 129.39,91
X$4429 858 758 877 428 395 839 OR3_X1
* cell instance $4432 m0 *1 122.36,93.8
X$4432 897 971 905 395 970 428 OAI21_X1
* cell instance $4433 m0 *1 123.12,93.8
X$4433 906 797 880 907 428 395 971 AOI22_X1
* cell instance $4437 m0 *1 128.25,93.8
X$4437 908 934 428 395 877 NAND2_X1
* cell instance $4439 m0 *1 129.2,93.8
X$4439 906 797 880 877 428 395 878 AOI22_X1
* cell instance $4442 m0 *1 136.61,93.8
X$4442 972 879 395 811 428 XOR2_X2
* cell instance $4443 r0 *1 136.99,91
X$4443 428 931 932 911 912 779 395 NOR4_X4
* cell instance $4445 r0 *1 140.41,91
X$4445 913 880 881 914 428 395 882 NAND4_X1
* cell instance $4446 r0 *1 141.36,91
X$4446 914 946 882 395 969 428 OAI21_X1
* cell instance $4448 m0 *1 138.32,93.8
X$4448 931 911 912 428 395 972 OR3_X2
* cell instance $4449 m0 *1 139.46,93.8
X$4449 912 911 428 395 913 NOR2_X1
* cell instance $4450 m0 *1 140.03,93.8
X$4450 913 881 428 395 945 NAND2_X1
* cell instance $4451 m0 *1 140.6,93.8
X$4451 914 945 395 428 647 XNOR2_X1
* cell instance $4453 r0 *1 142.69,91
X$4453 883 843 884 395 428 766 AND3_X1
* cell instance $4474 r0 *1 250.23,91
X$4474 925 428 395 LOGIC0_X1
* cell instance $4475 r0 *1 250.61,91
X$4475 925 428 395 916 BUF_X1
* cell instance $4476 r0 *1 251.18,91
X$4476 924 428 395 LOGIC0_X1
* cell instance $4477 r0 *1 251.56,91
X$4477 924 428 395 885 BUF_X1
* cell instance $4478 r0 *1 252.13,91
X$4478 920 428 395 LOGIC0_X1
* cell instance $4479 r0 *1 252.51,91
X$4479 920 428 395 845 BUF_X1
* cell instance $4482 m0 *1 142.69,93.8
X$4482 428 3329 842 969 752 395 DFF_X1
* cell instance $4513 m0 *1 250.23,93.8
X$4513 968 428 395 LOGIC0_X1
* cell instance $4514 m0 *1 250.61,93.8
X$4514 968 428 395 917 BUF_X1
* cell instance $4516 m0 *1 251.37,93.8
X$4516 965 428 395 LOGIC0_X1
* cell instance $4517 m0 *1 251.75,93.8
X$4517 965 428 395 952 BUF_X1
* cell instance $4518 m0 *1 252.32,93.8
X$4518 966 428 395 LOGIC0_X1
* cell instance $4519 m0 *1 252.7,93.8
X$4519 966 428 395 915 BUF_X1
* cell instance $4524 r0 *1 250.8,43.4
X$4524 479 428 395 LOGIC0_X1
* cell instance $4525 m0 *1 250.99,46.2
X$4525 537 428 395 LOGIC0_X1
* cell instance $4526 r0 *1 251.18,43.4
X$4526 479 428 395 527 BUF_X1
* cell instance $4527 m0 *1 251.37,46.2
X$4527 537 428 395 531 BUF_X1
* cell instance $4528 r0 *1 251.75,43.4
X$4528 511 428 395 LOGIC0_X1
* cell instance $4531 m0 *1 252.51,46.2
X$4531 536 428 395 LOGIC0_X1
* cell instance $4533 m0 *1 252.89,46.2
X$4533 536 428 395 532 BUF_X1
* cell instance $4537 r0 *1 250.8,12.6
X$4537 477 428 395 LOGIC0_X1
* cell instance $4538 m0 *1 251.37,15.4
X$4538 494 428 395 LOGIC0_X1
* cell instance $4539 r0 *1 251.75,12.6
X$4539 513 428 395 LOGIC0_X1
* cell instance $4550 r0 *1 3.42,119
X$4550 1579 428 395 1606 BUF_X1
* cell instance $4552 r0 *1 3.99,119
X$4552 1583 1561 1558 1477 428 395 1580 NAND4_X1
* cell instance $4556 m0 *1 4.18,121.8
X$4556 1577 428 395 1652 BUF_X1
* cell instance $4558 m0 *1 4.94,121.8
X$4558 1580 1495 428 395 1603 NOR2_X1
* cell instance $4559 r0 *1 7.03,119
X$4559 1557 1742 1561 395 428 1582 HA_X1
* cell instance $4560 r0 *1 5.32,119
X$4560 1581 1603 1567 1565 428 395 1605 AOI22_X2
* cell instance $4561 r0 *1 8.93,119
X$4561 1456 1605 1643 1538 1496 428 395 OAI211_X2
* cell instance $4564 m0 *1 5.89,121.8
X$4564 1644 1582 1583 428 1604 395 AOI21_X1
* cell instance $4565 m0 *1 6.65,121.8
X$4565 1606 1740 1583 395 428 1644 HA_X1
* cell instance $4568 m0 *1 10.83,121.8
X$4568 1627 428 395 1610 INV_X1
* cell instance $4569 r0 *1 11.21,119
X$4569 1609 1539 1627 428 395 1584 NAND3_X1
* cell instance $4571 r0 *1 11.97,119
X$4571 1610 1570 1611 395 1628 428 OAI21_X1
* cell instance $4574 r0 *1 19,119
X$4574 1153 1616 1615 428 1614 395 AOI21_X1
* cell instance $4576 r0 *1 19.95,119
X$4576 1503 1148 1540 428 395 1616 NAND3_X1
* cell instance $4577 r0 *1 20.71,119
X$4577 428 1541 753 3324 1587 395 DFF_X2
* cell instance $4578 r0 *1 24.32,119
X$4578 1540 1587 1542 395 428 1588 HA_X1
* cell instance $4583 r0 *1 36.29,119
X$4583 428 3472 1544 1620 725 395 DFF_X1
* cell instance $4584 r0 *1 39.52,119
X$4584 1500 1574 1127 1503 395 428 1727 OAI22_X1
* cell instance $4585 r0 *1 40.47,119
X$4585 1506 1546 1505 428 1503 395 NAND3_X4
* cell instance $4586 r0 *1 42.94,119
X$4586 1505 1546 428 395 1545 NAND2_X1
* cell instance $4588 r0 *1 43.7,119
X$4588 1506 428 395 1591 INV_X1
* cell instance $4589 r0 *1 44.08,119
X$4589 1506 1505 395 428 1622 AND2_X1
* cell instance $4591 m0 *1 11.21,121.8
X$4591 1652 1612 1627 395 428 1654 HA_X1
* cell instance $4592 m0 *1 13.11,121.8
X$4592 1654 428 395 1611 INV_X1
* cell instance $4596 m0 *1 14.82,121.8
X$4596 1542 428 395 1612 INV_X1
* cell instance $4598 m0 *1 16.72,121.8
X$4598 428 1614 753 1586 1540 395 DFF_X2
* cell instance $4599 m0 *1 20.33,121.8
X$4599 1045 1586 428 395 1615 NAND2_X1
* cell instance $4600 m0 *1 20.9,121.8
X$4600 1045 1542 428 395 1629 NAND2_X1
* cell instance $4602 m0 *1 21.66,121.8
X$4602 1153 1617 1629 428 1541 395 AOI21_X1
* cell instance $4603 m0 *1 22.42,121.8
X$4603 1503 1148 1587 428 395 1617 NAND3_X1
* cell instance $4604 m0 *1 23.18,121.8
X$4604 428 1587 1540 1630 1589 1340 395 NAND4_X4
* cell instance $4606 m0 *1 26.98,121.8
X$4606 1588 428 395 1631 BUF_X2
* cell instance $4608 m0 *1 28.12,121.8
X$4608 1339 1631 428 395 1590 NOR2_X1
* cell instance $4609 m0 *1 28.69,121.8
X$4609 1589 428 395 1632 INV_X1
* cell instance $4610 m0 *1 29.07,121.8
X$4610 1590 1256 1589 395 1633 428 OAI21_X1
* cell instance $4617 m0 *1 34.01,121.8
X$4617 1634 1123 395 428 1658 AND2_X1
* cell instance $4622 m0 *1 43.32,121.8
X$4622 1677 1544 1591 428 395 1504 NAND3_X1
* cell instance $4630 m0 *1 1.52,113.4
X$4630 1391 428 395 1395 BUF_X1
* cell instance $4635 r0 *1 2.09,116.2
X$4635 1502 428 395 1475 BUF_X1
* cell instance $4640 m0 *1 1.33,119
X$4640 1492 428 395 1560 BUF_X1
* cell instance $4641 m0 *1 1.9,119
X$4641 1537 428 395 1557 BUF_X1
* cell instance $4643 m0 *1 2.66,119
X$4643 1493 428 395 1559 BUF_X1
* cell instance $4644 m0 *1 3.23,119
X$4644 1559 1526 1558 395 428 1520 HA_X1
* cell instance $4645 m0 *1 5.13,119
X$4645 1558 1477 428 395 1563 NAND2_X1
* cell instance $4647 r0 *1 5.32,116.2
X$4647 1487 1477 1520 428 1486 395 AOI21_X1
* cell instance $4649 m0 *1 5.7,119
X$4649 1495 428 395 1565 INV_X1
* cell instance $4650 m0 *1 6.08,119
X$4650 1604 1563 1486 395 1567 428 OAI21_X1
* cell instance $4653 r0 *1 7.98,116.2
X$4653 1494 428 395 1488 CLKBUF_X3
* cell instance $4656 m0 *1 8.36,119
X$4656 1560 428 395 1525 INV_X1
* cell instance $4659 m0 *1 10.45,119
X$4659 1538 1184 1584 428 395 1498 OR3_X2
* cell instance $4660 m0 *1 11.59,119
X$4660 1525 1586 1539 395 428 1570 HA_X1
* cell instance $4662 r0 *1 13.11,116.2
X$4662 1585 1524 395 428 1439 AND2_X1
* cell instance $4669 r0 *1 28.5,116.2
X$4669 1217 1496 428 395 1497 OR2_X1
* cell instance $4670 r0 *1 27.93,116.2
X$4670 1496 1217 428 395 1500 NOR2_X1
* cell instance $4673 r0 *1 30.21,116.2
X$4673 1497 1528 800 1499 428 395 1489 AOI22_X1
* cell instance $4674 r0 *1 31.16,116.2
X$4674 1189 1498 1499 395 428 1528 AND3_X1
* cell instance $4675 r0 *1 32.11,116.2
X$4675 1504 1291 1364 428 395 1499 NAND3_X1
* cell instance $4681 r0 *1 33.44,116.2
X$4681 1529 1497 1501 800 428 395 1620 AOI22_X1
* cell instance $4683 r0 *1 34.39,116.2
X$4683 1501 1189 1498 395 428 1529 AND3_X1
* cell instance $4687 m0 *1 35.15,119
X$4687 1498 1189 793 428 395 1574 NAND3_X1
* cell instance $4688 m0 *1 35.91,119
X$4688 1531 1498 1189 428 395 1530 NAND3_X1
* cell instance $4690 r0 *1 36.48,116.2
X$4690 1438 428 395 1505 BUF_X2
* cell instance $4692 m0 *1 37.43,119
X$4692 1502 428 395 1575 INV_X1
* cell instance $4693 r0 *1 37.81,116.2
X$4693 428 1478 1117 3317 1502 395 DFF_X2
* cell instance $4695 r0 *1 41.42,116.2
X$4695 1437 428 395 1506 BUF_X2
* cell instance $4710 m0 *1 37.81,119
X$4710 1280 1503 1575 428 1531 395 AOI21_X1
* cell instance $4712 m0 *1 38.95,119
X$4712 1500 1530 1045 1543 395 428 1478 OAI22_X1
* cell instance $4713 m0 *1 39.9,119
X$4713 1411 1502 1258 395 1543 428 OAI21_X1
* cell instance $4716 m0 *1 41.23,119
X$4716 1502 1505 428 395 1534 NAND2_X1
* cell instance $4717 m0 *1 41.8,119
X$4717 1546 1506 1505 395 428 1411 AND3_X2
* cell instance $4718 m0 *1 42.94,119
X$4718 1545 1544 1506 810 428 395 1501 NAND4_X1
* cell instance $4735 r0 *1 117.23,116.2
X$4735 428 3455 1508 1442 1507 395 DFF_X1
* cell instance $4739 m0 *1 118.56,119
X$4739 1594 1508 1509 428 395 1535 NAND3_X1
* cell instance $4741 m0 *1 119.7,119
X$4741 1416 1488 1509 428 395 1619 NOR3_X1
* cell instance $4742 m0 *1 120.46,119
X$4742 1471 428 395 1509 INV_X1
* cell instance $4752 r0 *1 130.15,116.2
X$4752 1194 1468 428 395 1510 NAND2_X1
* cell instance $4755 m0 *1 130.34,119
X$4755 1514 1511 1510 428 1573 395 AOI21_X1
* cell instance $4756 r0 *1 131.29,116.2
X$4756 1523 1618 1480 395 428 1491 HA_X1
* cell instance $4760 r0 *1 136.99,116.2
X$4760 1464 1204 1202 395 1553 428 OAI21_X1
* cell instance $4761 r0 *1 137.75,116.2
X$4761 1464 428 395 1203 INV_X1
* cell instance $4765 r0 *1 141.93,116.2
X$4765 1465 1349 1447 1512 395 428 1066 AND4_X2
* cell instance $4766 r0 *1 138.51,116.2
X$4766 428 1447 1512 1465 1349 912 395 NAND4_X4
* cell instance $4770 m0 *1 139.46,119
X$4770 1512 1447 1465 428 395 1381 NAND3_X2
* cell instance $4771 m0 *1 140.79,119
X$4771 1465 1349 1464 1447 395 428 1572 AND4_X1
* cell instance $4773 m0 *1 142.31,119
X$4773 1572 428 395 883 CLKBUF_X3
* cell instance $4780 r0 *1 145.16,116.2
X$4780 1204 1357 1066 428 1490 395 AOI21_X1
* cell instance $4782 r0 *1 146.87,116.2
X$4782 1490 978 1448 395 1532 428 OAI21_X1
* cell instance $4784 m0 *1 145.54,119
X$4784 428 3397 1513 1571 981 395 DFF_X1
* cell instance $4785 r0 *1 148.77,116.2
X$4785 1448 992 1481 428 395 1533 OR3_X1
* cell instance $4786 r0 *1 148.01,116.2
X$4786 1513 428 395 1448 BUF_X2
* cell instance $4788 r0 *1 149.91,116.2
X$4788 1357 1448 1482 1066 428 1599 395 NAND4_X2
* cell instance $4790 r0 *1 151.81,116.2
X$4790 1554 1482 1448 1357 395 428 1025 AND4_X2
* cell instance $4792 r0 *1 153.33,116.2
X$4792 1482 992 1483 428 395 1515 OR3_X1
* cell instance $4794 r0 *1 154.47,116.2
X$4794 1194 1483 395 428 1527 AND2_X1
* cell instance $4795 r0 *1 155.23,116.2
X$4795 1527 978 1482 395 1569 428 OAI21_X1
* cell instance $4797 r0 *1 157.51,116.2
X$4797 1516 428 395 1482 CLKBUF_X2
* cell instance $4814 r0 *1 250.23,116.2
X$4814 1522 428 395 LOGIC0_X1
* cell instance $4815 r0 *1 250.61,116.2
X$4815 1522 428 395 1519 BUF_X1
* cell instance $4818 m0 *1 148.77,119
X$4818 1514 1533 1532 428 1571 395 AOI21_X1
* cell instance $4821 m0 *1 153.33,119
X$4821 1599 1554 395 1142 428 XOR2_X2
* cell instance $4822 m0 *1 155.04,119
X$4822 1514 1515 1569 428 1568 395 AOI21_X1
* cell instance $4823 m0 *1 155.8,119
X$4823 428 3392 1516 1568 981 395 DFF_X1
* cell instance $4847 m0 *1 250.23,119
X$4847 1566 428 395 LOGIC0_X1
* cell instance $4848 m0 *1 250.61,119
X$4848 1566 428 395 1556 BUF_X1
* cell instance $4850 m0 *1 251.37,119
X$4850 1564 428 395 LOGIC0_X1
* cell instance $4851 m0 *1 251.75,119
X$4851 1564 428 395 1518 BUF_X1
* cell instance $4852 m0 *1 252.32,119
X$4852 1562 428 395 LOGIC0_X1
* cell instance $4853 r0 *1 252.51,116.2
X$4853 1521 428 395 LOGIC0_X1
* cell instance $4855 r0 *1 252.89,116.2
X$4855 1521 428 395 1485 BUF_X1
* cell instance $4857 m0 *1 252.7,119
X$4857 1562 428 395 1517 BUF_X1
* cell instance $4866 m0 *1 1.9,124.6
X$4866 1623 428 395 1712 BUF_X1
* cell instance $4868 r0 *1 3.04,121.8
X$4868 1671 428 395 1645 BUF_X1
* cell instance $4869 r0 *1 2.47,121.8
X$4869 1624 428 395 1673 BUF_X1
* cell instance $4871 r0 *1 4.37,121.8
X$4871 1578 428 395 1686 BUF_X1
* cell instance $4872 r0 *1 4.94,121.8
X$4872 1495 1580 1739 1642 428 395 1538 OR4_X1
* cell instance $4875 m0 *1 3.23,124.6
X$4875 1674 428 395 1672 BUF_X1
* cell instance $4878 m0 *1 7.22,124.6
X$4878 1693 428 395 1676 BUF_X1
* cell instance $4880 r0 *1 8.17,121.8
X$4880 1645 1691 1647 395 428 1651 HA_X1
* cell instance $4882 r0 *1 10.07,121.8
X$4882 1675 1647 395 428 1609 AND2_X1
* cell instance $4883 r0 *1 10.83,121.8
X$4883 1628 1609 1626 1675 1651 1643 395 428 AOI221_X2
* cell instance $4888 m0 *1 10.83,124.6
X$4888 1686 1689 1675 395 428 1626 HA_X1
* cell instance $4894 m0 *1 18.62,124.6
X$4894 1374 1403 428 395 1690 NOR2_X1
* cell instance $4896 r0 *1 21.85,121.8
X$4896 1589 1631 395 428 1691 XNOR2_X1
* cell instance $4898 r0 *1 22.99,121.8
X$4898 1634 1630 395 1689 428 XOR2_X2
* cell instance $4900 r0 *1 24.89,121.8
X$4900 1540 1587 1589 428 395 1634 NAND3_X2
* cell instance $4904 m0 *1 22.61,124.6
X$4904 1589 1630 1631 428 1374 395 NAND3_X4
* cell instance $4908 m0 *1 27.17,124.6
X$4908 1630 1589 1631 395 428 1759 AND3_X1
* cell instance $4910 r0 *1 28.31,121.8
X$4910 1045 1631 1632 428 395 1657 NAND3_X1
* cell instance $4912 r0 *1 29.07,121.8
X$4912 1153 1657 1633 428 1724 395 AOI21_X1
* cell instance $4914 r0 *1 32.87,121.8
X$4914 1630 1634 1156 428 395 1661 OR3_X1
* cell instance $4915 r0 *1 33.82,121.8
X$4915 1514 1661 1692 428 1725 395 AOI21_X1
* cell instance $4916 r0 *1 34.58,121.8
X$4916 1658 1256 1630 395 1692 428 OAI21_X1
* cell instance $4918 r0 *1 38.38,121.8
X$4918 1411 1123 428 395 1256 NOR2_X2
* cell instance $4932 r0 *1 113.05,121.8
X$4932 428 3433 1666 1635 1507 395 DFF_X1
* cell instance $4933 r0 *1 116.28,121.8
X$4933 1666 428 395 1621 BUF_X2
* cell instance $4935 m0 *1 28.5,124.6
X$4935 428 3344 1723 1724 753 395 DFF_X1
* cell instance $4936 m0 *1 31.73,124.6
X$4936 1723 428 395 1589 CLKBUF_X3
* cell instance $4939 m0 *1 33.25,124.6
X$4939 428 3393 1726 1725 749 395 DFF_X1
* cell instance $4940 m0 *1 36.48,124.6
X$4940 1726 428 395 1630 CLKBUF_X3
* cell instance $4943 m0 *1 38.38,124.6
X$4943 1676 1698 395 428 1728 AND2_X1
* cell instance $4944 m0 *1 39.14,124.6
X$4944 1728 428 395 1123 CLKBUF_X3
* cell instance $4948 m0 *1 42.75,124.6
X$4948 1698 428 395 1677 INV_X1
* cell instance $4949 m0 *1 43.13,124.6
X$4949 1411 1677 1676 428 395 1729 NOR3_X1
* cell instance $4953 m0 *1 46.36,124.6
X$4953 1544 428 395 1757 INV_X1
* cell instance $4966 m0 *1 108.49,124.6
X$4966 1625 428 395 1549 BUF_X2
* cell instance $4969 r0 *1 117.61,121.8
X$4969 1508 428 395 1791 INV_X1
* cell instance $4977 m0 *1 119.89,124.6
X$4977 1471 1550 428 395 1702 NOR2_X2
* cell instance $4981 m0 *1 126.16,124.6
X$4981 810 395 906 428 BUF_X4
* cell instance $4984 m0 *1 129.2,124.6
X$4984 1009 1734 1733 428 1703 395 AOI21_X1
* cell instance $4985 r0 *1 129.39,121.8
X$4985 1194 1636 428 395 1733 NAND2_X1
* cell instance $4987 r0 *1 129.96,121.8
X$4987 1596 1678 1636 395 428 1667 HA_X1
* cell instance $4988 r0 *1 131.86,121.8
X$4988 1667 428 395 1679 BUF_X1
* cell instance $4989 r0 *1 132.43,121.8
X$4989 1680 1678 1596 395 428 1664 AND3_X1
* cell instance $4990 r0 *1 133.38,121.8
X$4990 1680 1679 395 428 1378 XNOR2_X1
* cell instance $4991 r0 *1 134.52,121.8
X$4991 1664 428 395 1464 BUF_X2
* cell instance $4996 m0 *1 130.34,124.6
X$4996 1441 1232 1678 428 395 1734 NAND3_X1
* cell instance $4998 m0 *1 131.86,124.6
X$4998 1194 1679 1732 428 395 1704 NAND3_X1
* cell instance $4999 m0 *1 132.62,124.6
X$4999 1680 428 395 1732 INV_X1
* cell instance $5000 m0 *1 133,124.6
X$5000 1204 1679 428 395 1706 NOR2_X1
* cell instance $5003 m0 *1 134.14,124.6
X$5003 1680 1679 395 428 1512 AND2_X2
* cell instance $5006 r0 *1 142.69,121.8
X$5006 1512 1552 428 395 1688 NAND2_X1
* cell instance $5008 r0 *1 143.26,121.8
X$5008 992 1552 1512 428 1637 395 AOI21_X1
* cell instance $5009 r0 *1 144.02,121.8
X$5009 1637 978 1638 395 1660 428 OAI21_X1
* cell instance $5010 r0 *1 144.78,121.8
X$5010 1638 992 1688 428 395 1659 OR3_X1
* cell instance $5011 r0 *1 145.73,121.8
X$5011 1009 1659 1660 428 1681 395 AOI21_X1
* cell instance $5016 m0 *1 142.69,124.6
X$5016 1638 1708 1552 1512 428 1823 395 NAND4_X2
* cell instance $5019 m0 *1 145.54,124.6
X$5019 428 3402 1720 1681 981 395 DFF_X1
* cell instance $5020 m0 *1 148.77,124.6
X$5020 1720 428 395 1638 BUF_X2
* cell instance $5023 m0 *1 150.67,124.6
X$5023 428 1687 981 3298 1554 395 DFF_X2
* cell instance $5025 r0 *1 152.19,121.8
X$5025 1514 1656 1655 428 1687 395 AOI21_X1
* cell instance $5027 r0 *1 153.33,121.8
X$5027 1639 978 1554 395 1655 428 OAI21_X1
* cell instance $5046 r0 *1 250.8,121.8
X$5046 1653 428 395 LOGIC0_X1
* cell instance $5047 r0 *1 251.18,121.8
X$5047 1653 428 395 1683 BUF_X1
* cell instance $5071 m0 *1 250.23,124.6
X$5071 1719 428 395 LOGIC0_X1
* cell instance $5072 m0 *1 250.61,124.6
X$5072 1719 428 395 1684 BUF_X1
* cell instance $5074 m0 *1 251.37,124.6
X$5074 1718 428 395 LOGIC0_X1
* cell instance $5075 m0 *1 251.75,124.6
X$5075 1718 428 395 1685 BUF_X1
* cell instance $5076 r0 *1 252.51,121.8
X$5076 1646 428 395 1641 BUF_X1
* cell instance $5077 r0 *1 252.13,121.8
X$5077 1646 428 395 LOGIC0_X1
* cell instance $5079 m0 *1 252.32,124.6
X$5079 1716 428 395 LOGIC0_X1
* cell instance $5080 m0 *1 252.7,124.6
X$5080 1716 428 395 1682 BUF_X1
* cell instance $5260 m0 *1 197.41,4.2
X$5260 397 428 395 LOGIC0_X1
* cell instance $5262 m0 *1 198.17,4.2
X$5262 396 428 395 LOGIC0_X1
* cell instance $5269 m0 *1 200.26,4.2
X$5269 400 428 395 LOGIC0_X1
* cell instance $5270 m0 *1 201.02,4.2
X$5270 399 428 395 LOGIC0_X1
* cell instance $5273 m0 *1 202.92,4.2
X$5273 404 428 395 LOGIC0_X1
* cell instance $5275 m0 *1 203.49,4.2
X$5275 403 428 395 LOGIC0_X1
* cell instance $5277 m0 *1 204.06,4.2
X$5277 402 428 395 LOGIC0_X1
* cell instance $5279 m0 *1 204.82,4.2
X$5279 401 428 395 LOGIC0_X1
* cell instance $5281 m0 *1 205.39,4.2
X$5281 409 428 395 LOGIC0_X1
* cell instance $5282 m0 *1 206.15,4.2
X$5282 410 428 395 LOGIC0_X1
* cell instance $5283 m0 *1 207.48,4.2
X$5283 408 428 395 LOGIC0_X1
* cell instance $5285 m0 *1 208.24,4.2
X$5285 406 428 395 LOGIC0_X1
* cell instance $5287 m0 *1 208.81,4.2
X$5287 405 428 395 LOGIC0_X1
* cell instance $5289 m0 *1 209.57,4.2
X$5289 413 428 395 LOGIC0_X1
* cell instance $5387 m0 *1 250.23,63
X$5387 600 428 395 LOGIC0_X1
* cell instance $5389 m0 *1 250.61,63
X$5389 600 428 395 595 BUF_X1
* cell instance $5390 r0 *1 251.18,60.2
X$5390 587 428 395 577 BUF_X1
* cell instance $5392 m0 *1 251.37,63
X$5392 598 428 395 LOGIC0_X1
* cell instance $5393 m0 *1 251.75,63
X$5393 598 428 395 594 BUF_X1
* cell instance $5394 r0 *1 251.75,60.2
X$5394 587 428 395 LOGIC0_X1
* cell instance $5395 r0 *1 252.13,60.2
X$5395 583 428 395 LOGIC0_X1
* cell instance $5396 m0 *1 252.32,63
X$5396 597 428 395 LOGIC0_X1
* cell instance $5398 m0 *1 252.7,63
X$5398 597 428 395 593 BUF_X1
* cell instance $5399 r0 *1 252.7,60.2
X$5399 583 428 395 580 BUF_X1
* cell instance $5510 r0 *1 250.61,155.4
X$5510 1976 428 395 1972 BUF_X1
* cell instance $5512 m0 *1 251.18,158.2
X$5512 1983 428 395 1974 BUF_X1
* cell instance $5513 m0 *1 251.75,158.2
X$5513 1983 428 395 LOGIC0_X1
* cell instance $5515 m0 *1 252.13,158.2
X$5515 1982 428 395 LOGIC0_X1
* cell instance $5517 m0 *1 252.51,158.2
X$5517 1982 428 395 1975 BUF_X1
* cell instance $5518 r0 *1 252.51,155.4
X$5518 1980 428 395 LOGIC0_X1
* cell instance $5519 r0 *1 252.89,155.4
X$5519 1980 428 395 1973 BUF_X1
* cell instance $5628 r0 *1 249.47,7
X$5628 454 428 395 LOGIC0_X1
* cell instance $5629 r0 *1 250.42,7
X$5629 462 428 395 LOGIC0_X1
* cell instance $5632 r0 *1 251.75,7
X$5632 512 428 395 LOGIC0_X1
* cell instance $5633 m0 *1 252.32,9.8
X$5633 499 428 395 LOGIC0_X1
* cell instance $5745 m0 *1 250.23,29.4
X$5745 467 428 395 LOGIC0_X1
* cell instance $5748 r0 *1 251.18,26.6
X$5748 489 428 395 LOGIC0_X1
* cell instance $5749 m0 *1 251.37,29.4
X$5749 487 428 395 LOGIC0_X1
* cell instance $5750 r0 *1 252.13,26.6
X$5750 506 428 395 LOGIC0_X1
* cell instance $5751 m0 *1 252.32,29.4
X$5751 518 428 395 LOGIC0_X1
* cell instance $5967 m0 *1 250.8,32.2
X$5967 496 428 395 LOGIC0_X1
* cell instance $5969 r0 *1 251.75,29.4
X$5969 491 428 395 LOGIC0_X1
* cell instance $5971 r0 *1 252.51,29.4
X$5971 520 428 395 LOGIC0_X1
* cell instance $5972 m0 *1 252.51,32.2
X$5972 523 428 395 LOGIC0_X1
* cell instance $6082 m0 *1 250.23,23.8
X$6082 464 428 395 LOGIC0_X1
* cell instance $6084 r0 *1 251.18,21
X$6084 492 428 395 LOGIC0_X1
* cell instance $6086 m0 *1 251.37,23.8
X$6086 486 428 395 LOGIC0_X1
* cell instance $6088 m0 *1 252.32,23.8
X$6088 498 428 395 LOGIC0_X1
* cell instance $6089 r0 *1 252.51,21
X$6089 524 428 395 LOGIC0_X1
* cell instance $6198 r0 *1 197.03,4.2
X$6198 398 428 395 LOGIC0_X1
* cell instance $6208 r0 *1 207.67,4.2
X$6208 407 428 395 LOGIC0_X1
* cell instance $6214 r0 *1 212.04,4.2
X$6214 411 428 395 LOGIC0_X1
* cell instance $6217 r0 *1 215.46,4.2
X$6217 414 428 395 LOGIC0_X1
* cell instance $6224 r0 *1 234.08,4.2
X$6224 431 428 395 LOGIC0_X1
* cell instance $6230 r0 *1 240.92,4.2
X$6230 441 428 395 LOGIC0_X1
* cell instance $6233 r0 *1 241.87,4.2
X$6233 449 428 395 LOGIC0_X1
* cell instance $6236 r0 *1 247,4.2
X$6236 451 428 395 LOGIC0_X1
* cell instance $6238 r0 *1 248.52,4.2
X$6238 458 428 395 LOGIC0_X1
* cell instance $6241 r0 *1 249.09,4.2
X$6241 455 428 395 LOGIC0_X1
* cell instance $6242 m0 *1 249.09,7
X$6242 456 428 395 LOGIC0_X1
* cell instance $6246 r0 *1 250.42,4.2
X$6246 474 428 395 LOGIC0_X1
* cell instance $6247 r0 *1 250.8,4.2
X$6247 460 428 395 LOGIC0_X1
* cell instance $6248 m0 *1 251.75,7
X$6248 472 428 395 LOGIC0_X1
* cell instance $6249 r0 *1 252.32,4.2
X$6249 502 428 395 LOGIC0_X1
* cell instance $6250 m0 *1 252.51,7
X$6250 521 428 395 LOGIC0_X1
* cell instance $6349 m0 *1 250.61,37.8
X$6349 475 428 395 LOGIC0_X1
* cell instance $6351 r0 *1 251.37,35
X$6351 483 428 395 LOGIC0_X1
* cell instance $6352 m0 *1 251.75,37.8
X$6352 516 428 395 LOGIC0_X1
* cell instance $6354 r0 *1 252.13,35
X$6354 508 428 395 LOGIC0_X1
* cell instance $6355 r0 *1 252.51,35
X$6355 519 428 395 LOGIC0_X1
* cell instance $6492 m0 *1 35.15,138.6
X$6492 753 428 395 3292 INV_X8
* cell instance $6522 r0 *1 117.42,135.8
X$6522 428 1890 1507 3322 1903 395 DFF_X2
* cell instance $6528 r0 *1 126.54,135.8
X$6528 906 395 1576 428 BUF_X4
* cell instance $6577 m0 *1 250.23,138.6
X$6577 1915 428 395 LOGIC0_X1
* cell instance $6578 r0 *1 250.23,135.8
X$6578 1916 428 395 LOGIC0_X1
* cell instance $6579 r0 *1 250.61,135.8
X$6579 1916 428 395 1909 BUF_X1
* cell instance $6582 m0 *1 251.18,138.6
X$6582 1915 428 395 1905 BUF_X1
* cell instance $6583 r0 *1 251.18,135.8
X$6583 1913 428 395 LOGIC0_X1
* cell instance $6584 r0 *1 251.56,135.8
X$6584 1913 428 395 1910 BUF_X1
* cell instance $6585 m0 *1 251.75,138.6
X$6585 1914 428 395 LOGIC0_X1
* cell instance $6587 m0 *1 252.13,138.6
X$6587 1914 428 395 1906 BUF_X1
* cell instance $6588 r0 *1 252.51,135.8
X$6588 1911 428 395 LOGIC0_X1
* cell instance $6590 r0 *1 252.89,135.8
X$6590 1911 428 395 1892 BUF_X1
* cell instance $6591 m0 *1 252.89,138.6
X$6591 1912 428 395 1904 BUF_X1
* cell instance $6684 m0 *1 216.41,163.8
X$6684 428 3386 2015 2030 2001 395 DFF_X1
* cell instance $6691 r0 *1 225.91,161
X$6691 1832 2000 395 428 1987 AND2_X1
* cell instance $6695 m0 *1 227.05,163.8
X$6695 1832 2002 395 428 2011 AND2_X1
* cell instance $6698 m0 *1 228.38,163.8
X$6698 428 3373 2026 2011 2001 395 DFF_X1
* cell instance $6709 m0 *1 250.61,163.8
X$6709 2007 428 395 2020 BUF_X1
* cell instance $6711 m0 *1 251.18,163.8
X$6711 2010 428 395 LOGIC0_X1
* cell instance $6712 m0 *1 251.56,163.8
X$6712 2010 428 395 2003 BUF_X1
* cell instance $6714 m0 *1 252.51,163.8
X$6714 2009 428 395 LOGIC0_X1
* cell instance $6715 r0 *1 252.51,161
X$6715 2008 428 395 LOGIC0_X1
* cell instance $6716 r0 *1 252.89,161
X$6716 2008 428 395 2005 BUF_X1
* cell instance $6717 m0 *1 252.89,163.8
X$6717 2009 428 395 2006 BUF_X1
* cell instance $6826 r0 *1 250.8,51.8
X$6826 550 428 395 LOGIC0_X1
* cell instance $6829 r0 *1 251.37,51.8
X$6829 562 428 395 LOGIC0_X1
* cell instance $6830 m0 *1 251.37,54.6
X$6830 562 428 395 553 BUF_X1
* cell instance $6831 r0 *1 251.75,51.8
X$6831 550 428 395 554 BUF_X1
* cell instance $6833 m0 *1 252.13,54.6
X$6833 557 428 395 LOGIC0_X1
* cell instance $6834 r0 *1 252.32,51.8
X$6834 559 428 395 LOGIC0_X1
* cell instance $6836 m0 *1 252.7,54.6
X$6836 557 428 395 551 BUF_X1
* cell instance $6838 r0 *1 252.89,51.8
X$6838 559 428 395 555 BUF_X1
* cell instance $6864 m0 *1 2.28,99.4
X$6864 1016 428 395 1105 BUF_X1
* cell instance $6865 m0 *1 2.85,99.4
X$6865 1018 428 395 1054 BUF_X1
* cell instance $6868 m0 *1 4.37,99.4
X$6868 1017 428 395 1033 BUF_X1
* cell instance $6871 m0 *1 11.21,99.4
X$6871 1033 1031 1043 395 428 1044 HA_X1
* cell instance $6875 m0 *1 18.05,99.4
X$6875 866 903 395 428 1031 XNOR2_X1
* cell instance $6876 m0 *1 19.19,99.4
X$6876 866 428 395 975 INV_X1
* cell instance $6880 m0 *1 26.22,99.4
X$6880 800 1065 801 395 1019 428 OAI21_X1
* cell instance $6881 r0 *1 27.36,96.6
X$6881 993 994 1010 395 1020 428 OAI21_X1
* cell instance $6882 r0 *1 26.79,96.6
X$6882 1019 993 428 395 1010 NAND2_X1
* cell instance $6885 r0 *1 29.07,96.6
X$6885 1011 428 395 993 BUF_X2
* cell instance $6902 r0 *1 121.22,96.6
X$6902 428 3426 1022 996 752 395 DFF_X1
* cell instance $6903 r0 *1 124.45,96.6
X$6903 908 999 997 428 395 995 NAND3_X1
* cell instance $6908 m0 *1 27.74,99.4
X$6908 1065 793 428 395 994 NAND2_X1
* cell instance $6911 m0 *1 32.87,99.4
X$6911 428 3336 1069 1021 725 395 DFF_X1
* cell instance $6927 m0 *1 117.04,99.4
X$6927 1047 1048 1049 395 732 428 OAI21_X1
* cell instance $6928 m0 *1 117.8,99.4
X$6928 1075 1050 1074 428 1049 395 AOI21_X1
* cell instance $6929 m0 *1 120.46,99.4
X$6929 944 995 395 428 1115 XNOR2_X1
* cell instance $6930 m0 *1 121.6,99.4
X$6930 976 944 1051 428 996 395 AOI21_X1
* cell instance $6932 m0 *1 122.74,99.4
X$6932 758 995 428 395 1051 OR2_X1
* cell instance $6934 m0 *1 123.88,99.4
X$6934 1022 428 395 944 INV_X1
* cell instance $6936 m0 *1 125.02,99.4
X$6936 1022 997 395 428 1037 AND2_X1
* cell instance $6937 m0 *1 125.78,99.4
X$6937 428 3357 997 1076 752 395 DFF_X1
* cell instance $6939 r0 *1 127.87,96.6
X$6939 997 428 395 1000 INV_X1
* cell instance $6941 r0 *1 128.63,96.6
X$6941 880 998 999 1000 428 395 1023 NAND4_X1
* cell instance $6944 m0 *1 129.01,99.4
X$6944 1000 1072 1023 395 1076 428 OAI21_X1
* cell instance $6946 r0 *1 136.99,96.6
X$6946 1009 977 1036 428 1015 395 AOI21_X1
* cell instance $6947 r0 *1 133.76,96.6
X$6947 428 3430 1013 1015 752 395 DFF_X1
* cell instance $6949 r0 *1 137.94,96.6
X$6949 1014 978 879 395 1036 428 OAI21_X1
* cell instance $6953 r0 *1 143.45,96.6
X$6953 428 3457 979 1012 752 395 DFF_X1
* cell instance $6954 r0 *1 146.68,96.6
X$6954 980 1001 395 428 1035 XNOR2_X1
* cell instance $6957 r0 *1 151.05,96.6
X$6957 992 1025 883 428 1008 395 AOI21_X1
* cell instance $6959 r0 *1 152,96.6
X$6959 948 1026 992 428 395 1002 OR3_X1
* cell instance $6960 r0 *1 152.95,96.6
X$6960 1009 1002 1027 428 989 395 AOI21_X1
* cell instance $6961 r0 *1 153.71,96.6
X$6961 1008 978 948 395 1027 428 OAI21_X1
* cell instance $6981 r0 *1 251.18,96.6
X$6981 1006 428 395 LOGIC0_X1
* cell instance $6982 r0 *1 251.56,96.6
X$6982 1006 428 395 1028 BUF_X1
* cell instance $6985 m0 *1 136.61,99.4
X$6985 1194 972 395 428 1014 AND2_X1
* cell instance $6988 m0 *1 138.51,99.4
X$6988 881 1173 428 395 633 XNOR2_X2
* cell instance $6990 m0 *1 141.17,99.4
X$6990 1052 1024 428 395 666 XNOR2_X2
* cell instance $6991 m0 *1 143.07,99.4
X$6991 1052 1025 1107 395 428 884 AND3_X1
* cell instance $6995 m0 *1 146.49,99.4
X$6995 1066 1025 948 428 395 1001 NAND3_X1
* cell instance $6999 m0 *1 151.43,99.4
X$6999 883 1025 428 395 1026 NAND2_X1
* cell instance $7001 m0 *1 152.19,99.4
X$7001 1026 948 395 1034 428 XOR2_X2
* cell instance $7002 m0 *1 153.9,99.4
X$7002 947 1035 1099 395 428 1063 HA_X1
* cell instance $7026 m0 *1 250.23,99.4
X$7026 1059 428 395 LOGIC0_X1
* cell instance $7027 m0 *1 250.61,99.4
X$7027 1059 428 395 1030 BUF_X1
* cell instance $7029 m0 *1 251.37,99.4
X$7029 1058 428 395 LOGIC0_X1
* cell instance $7030 m0 *1 251.75,99.4
X$7030 1058 428 395 1029 BUF_X1
* cell instance $7031 m0 *1 252.32,99.4
X$7031 1055 428 395 LOGIC0_X1
* cell instance $7032 r0 *1 252.89,96.6
X$7032 1007 428 395 1003 BUF_X1
* cell instance $7033 r0 *1 252.51,96.6
X$7033 1007 428 395 LOGIC0_X1
* cell instance $7035 m0 *1 252.7,99.4
X$7035 1055 428 395 1032 BUF_X1
* cell instance $7063 m0 *1 15.96,107.8
X$7063 1148 1246 428 395 1303 NOR2_X1
* cell instance $7065 m0 *1 16.91,107.8
X$7065 428 1290 725 3311 1289 395 DFF_X2
* cell instance $7068 m0 *1 21.47,107.8
X$7068 1291 1156 428 801 395 NAND2_X4
* cell instance $7069 r0 *1 22.42,105
X$7069 1223 1248 428 395 1137 XNOR2_X2
* cell instance $7071 r0 *1 24.32,105
X$7071 793 1248 1251 428 395 1250 NAND3_X1
* cell instance $7072 r0 *1 25.08,105
X$7072 1223 428 395 1251 INV_X1
* cell instance $7078 m0 *1 23.75,107.8
X$7078 1247 1223 428 395 1249 NAND2_X1
* cell instance $7079 m0 *1 24.32,107.8
X$7079 1248 1249 1250 801 1251 395 428 1273 OAI221_X1
* cell instance $7081 m0 *1 25.65,107.8
X$7081 428 1273 725 3309 1223 395 DFF_X2
* cell instance $7084 r0 *1 30.59,105
X$7084 1223 1092 395 428 1167 AND2_X2
* cell instance $7095 r0 *1 15.01,107.8
X$7095 1246 1289 395 1288 428 XOR2_X2
* cell instance $7096 r0 *1 16.72,107.8
X$7096 1304 1303 1288 800 395 428 1290 OAI22_X1
* cell instance $7103 m0 *1 4.18,110.6
X$7103 1311 1288 1335 395 428 1322 HA_X1
* cell instance $7104 m0 *1 6.08,110.6
X$7104 1354 1336 1322 428 1337 395 AOI21_X1
* cell instance $7105 m0 *1 6.84,110.6
X$7105 1396 1332 1336 395 428 1354 HA_X1
* cell instance $7107 m0 *1 8.93,110.6
X$7107 428 1292 395 1334 BUF_X8
* cell instance $7111 m0 *1 13.49,110.6
X$7111 1312 428 395 1313 CLKBUF_X3
* cell instance $7112 m0 *1 14.44,110.6
X$7112 1339 1313 428 395 1398 NOR2_X1
* cell instance $7114 m0 *1 15.2,110.6
X$7114 1314 1339 1152 395 1338 428 OAI21_X1
* cell instance $7115 m0 *1 15.96,110.6
X$7115 1314 1313 1358 428 395 1246 NAND3_X2
* cell instance $7116 m0 *1 17.29,110.6
X$7116 1358 1289 1313 428 1316 395 NAND3_X4
* cell instance $7117 r0 *1 18.24,107.8
X$7117 1291 1289 428 395 1304 NAND2_X1
* cell instance $7125 m0 *1 21.47,110.6
X$7125 1315 1121 428 395 1314 NOR2_X2
* cell instance $7126 m0 *1 22.42,110.6
X$7126 1315 1316 428 395 1088 OR2_X2
* cell instance $7128 m0 *1 24.13,110.6
X$7128 1255 1168 428 395 1332 XNOR2_X2
* cell instance $7130 m0 *1 26.79,110.6
X$7130 1148 1168 1152 395 1342 428 OAI21_X1
* cell instance $7135 m0 *1 31.92,110.6
X$7135 1253 1255 1168 395 428 1317 AND3_X1
* cell instance $7137 r0 *1 32.11,107.8
X$7137 1254 1317 428 395 1182 XNOR2_X2
* cell instance $7138 r0 *1 34.2,107.8
X$7138 1123 1292 428 395 870 NAND2_X2
* cell instance $7163 m0 *1 35.72,110.6
X$7163 1339 1317 1152 395 1366 428 OAI21_X1
* cell instance $7165 m0 *1 36.86,110.6
X$7165 1156 1254 428 395 1406 NOR2_X1
* cell instance $7166 m0 *1 37.43,110.6
X$7166 1152 1253 428 395 1363 NAND2_X1
* cell instance $7169 m0 *1 39.14,110.6
X$7169 1409 428 395 1333 INV_X1
* cell instance $7171 m0 *1 39.9,110.6
X$7171 1361 428 395 1253 BUF_X2
* cell instance $7172 m0 *1 40.66,110.6
X$7172 1360 428 395 1254 BUF_X2
* cell instance $7173 m0 *1 41.42,110.6
X$7173 428 3409 1361 1333 1117 395 DFF_X1
* cell instance $7189 m0 *1 124.83,110.6
X$7189 809 428 395 880 CLKBUF_X3
* cell instance $7191 m0 *1 125.97,110.6
X$7191 1416 1232 428 395 1293 NAND2_X1
* cell instance $7193 r0 *1 127.49,107.8
X$7193 730 694 809 428 395 1295 NAND3_X1
* cell instance $7194 r0 *1 126.92,107.8
X$7194 730 694 428 395 1294 NAND2_X1
* cell instance $7201 m0 *1 130.91,110.6
X$7201 1175 428 395 1232 CLKBUF_X3
* cell instance $7204 m0 *1 133.76,110.6
X$7204 1175 428 395 992 CLKBUF_X3
* cell instance $7206 r0 *1 135.66,107.8
X$7206 797 428 395 978 CLKBUF_X3
* cell instance $7209 r0 *1 142.69,107.8
X$7209 1296 428 395 1263 INV_X1
* cell instance $7213 r0 *1 152.38,107.8
X$7213 1233 428 395 1308 INV_X1
* cell instance $7214 r0 *1 152.76,107.8
X$7214 1298 1308 428 395 1309 NAND2_X1
* cell instance $7235 m0 *1 151.43,110.6
X$7235 1357 883 395 428 1297 XNOR2_X1
* cell instance $7236 m0 *1 154.47,110.6
X$7236 1329 1264 1328 428 1327 395 AOI21_X1
* cell instance $7237 m0 *1 155.23,110.6
X$7237 1319 1326 428 395 1353 NAND2_X1
* cell instance $7239 m0 *1 155.99,110.6
X$7239 1327 1353 1325 395 1298 428 OAI21_X1
* cell instance $7241 m0 *1 157.13,110.6
X$7241 1320 1326 1299 428 1325 395 AOI21_X1
* cell instance $7262 r0 *1 250.23,107.8
X$7262 1307 428 395 LOGIC0_X1
* cell instance $7263 r0 *1 250.8,107.8
X$7263 1307 428 395 1301 BUF_X1
* cell instance $7264 r0 *1 251.37,107.8
X$7264 1306 428 395 LOGIC0_X1
* cell instance $7266 r0 *1 251.94,107.8
X$7266 1306 428 395 1266 BUF_X1
* cell instance $7267 r0 *1 252.51,107.8
X$7267 1305 428 395 LOGIC0_X1
* cell instance $7268 r0 *1 252.89,107.8
X$7268 1305 428 395 1302 BUF_X1
* cell instance $7271 m0 *1 250.8,110.6
X$7271 1324 428 395 LOGIC0_X1
* cell instance $7272 m0 *1 251.18,110.6
X$7272 1323 428 395 LOGIC0_X1
* cell instance $7273 m0 *1 251.56,110.6
X$7273 1323 428 395 1321 BUF_X1
* cell instance $7274 m0 *1 252.13,110.6
X$7274 1324 428 395 1351 BUF_X1
* cell instance $7302 r0 *1 65.93,222.6
X$7302 428 3469 2813 2801 2714 395 DFF_X1
* cell instance $7303 r0 *1 69.16,222.6
X$7303 2813 428 395 2792 BUF_X2
* cell instance $7305 r0 *1 70.11,222.6
X$7305 2792 2688 2823 428 395 2815 OR3_X1
* cell instance $7306 r0 *1 71.06,222.6
X$7306 1153 2815 2816 428 2801 395 AOI21_X1
* cell instance $7326 m0 *1 65.74,225.4
X$7326 2812 1356 428 395 2844 NOR2_X1
* cell instance $7329 m0 *1 67.26,225.4
X$7329 1276 428 395 2714 CLKBUF_X3
* cell instance $7330 m0 *1 68.21,225.4
X$7330 2714 428 395 INV_X4
* cell instance $7333 m0 *1 71.44,225.4
X$7333 2746 2758 395 428 2970 XNOR2_X1
* cell instance $7335 r0 *1 73.15,222.6
X$7335 2817 2717 2792 395 2816 428 OAI21_X1
* cell instance $7337 r0 *1 73.91,222.6
X$7337 2685 2823 395 428 2817 AND2_X1
* cell instance $7339 r0 *1 74.86,222.6
X$7339 2688 428 395 2759 CLKBUF_X3
* cell instance $7342 r0 *1 87.97,222.6
X$7342 2825 428 395 2805 BUF_X2
* cell instance $7346 m0 *1 79.23,225.4
X$7346 428 2738 2803 2838 2823 2787 395 NOR4_X4
* cell instance $7349 m0 *1 84.93,225.4
X$7349 428 3334 2825 2824 2644 395 DFF_X1
* cell instance $7354 m0 *1 88.35,225.4
X$7354 2805 2828 2827 395 2824 428 OAI21_X1
* cell instance $7355 m0 *1 89.11,225.4
X$7355 2826 2805 428 395 2827 NAND2_X1
* cell instance $7356 r0 *1 89.3,222.6
X$7356 2805 2793 2788 395 428 2711 AND3_X1
* cell instance $7358 r0 *1 90.25,222.6
X$7358 2631 2672 2805 2793 395 428 2750 AND4_X2
* cell instance $7359 r0 *1 91.58,222.6
X$7359 428 2805 2793 2631 2672 2794 395 NAND4_X4
* cell instance $7361 m0 *1 89.68,225.4
X$7361 2692 2840 2675 395 2826 428 OAI21_X1
* cell instance $7362 m0 *1 90.44,225.4
X$7362 2793 2805 2672 428 395 2830 NAND3_X1
* cell instance $7364 m0 *1 91.39,225.4
X$7364 2672 2711 395 428 2832 XNOR2_X1
* cell instance $7367 m0 *1 94.24,225.4
X$7367 2644 428 395 3290 INV_X8
* cell instance $7369 r0 *1 95.38,222.6
X$7369 1276 428 395 2644 CLKBUF_X3
* cell instance $7370 r0 *1 96.52,222.6
X$7370 428 2794 2738 2795 2796 2712 395 NOR4_X4
* cell instance $7373 r0 *1 102.22,222.6
X$7373 2694 2766 428 395 2806 NOR2_X1
* cell instance $7374 r0 *1 102.79,222.6
X$7374 2694 2766 2696 428 395 2833 NOR3_X1
* cell instance $7376 m0 *1 95.95,225.4
X$7376 2795 2738 2794 428 395 2764 OR3_X4
* cell instance $7381 m0 *1 103.17,225.4
X$7381 2833 2842 2807 428 395 2808 MUX2_X1
* cell instance $7383 r0 *1 103.93,222.6
X$7383 2696 2806 2720 395 2807 428 OAI21_X1
* cell instance $7386 r0 *1 108.68,222.6
X$7386 2764 2752 2767 395 2809 428 NOR3_X2
* cell instance $7388 r0 *1 110.77,222.6
X$7388 2694 2696 2797 428 395 2799 NOR3_X1
* cell instance $7389 r0 *1 111.53,222.6
X$7389 2694 2797 428 395 2822 NOR2_X1
* cell instance $7390 r0 *1 112.1,222.6
X$7390 2696 2822 2720 395 2821 428 OAI21_X1
* cell instance $7393 r0 *1 113.81,222.6
X$7393 2799 2800 2821 428 395 2819 MUX2_X1
* cell instance $7394 r0 *1 115.14,222.6
X$7394 428 3411 2800 2819 2466 395 DFF_X1
* cell instance $7401 m0 *1 109.44,225.4
X$7401 2809 2696 428 395 2831 OR2_X1
* cell instance $7403 m0 *1 113.24,225.4
X$7403 2800 2822 428 395 2820 XNOR2_X2
* cell instance $7463 m0 *1 250.99,225.4
X$7463 2818 428 395 LOGIC0_X1
* cell instance $7464 m0 *1 251.37,225.4
X$7464 2818 428 395 2811 BUF_X1
* cell instance $7466 r0 *1 252.51,222.6
X$7466 2814 428 395 LOGIC0_X1
* cell instance $7468 r0 *1 252.89,222.6
X$7468 2814 428 395 2810 BUF_X1
* cell instance $7499 m0 *1 5.7,161
X$7499 1986 428 395 1994 BUF_X2
* cell instance $7564 m0 *1 225.15,161
X$7564 428 3381 1988 1987 2001 395 DFF_X1
* cell instance $7573 m0 *1 246.05,161
X$7573 2004 428 395 1999 BUF_X2
* cell instance $7575 r0 *1 247.19,158.2
X$7575 1978 428 395 2046 BUF_X1
* cell instance $7580 r0 *1 248.9,158.2
X$7580 1993 428 395 1523 BUF_X2
* cell instance $7581 r0 *1 251.18,158.2
X$7581 1997 428 395 LOGIC0_X1
* cell instance $7582 r0 *1 251.56,158.2
X$7582 1997 428 395 1989 BUF_X1
* cell instance $7587 m0 *1 251.18,161
X$7587 1992 428 395 1998 BUF_X1
* cell instance $7588 m0 *1 251.75,161
X$7588 1996 428 395 LOGIC0_X1
* cell instance $7651 r0 *1 125.59,166.6
X$7651 1917 428 395 1276 CLKBUF_X3
* cell instance $7671 r0 *1 217.17,166.6
X$7671 2049 428 395 2065 INV_X1
* cell instance $7672 r0 *1 217.55,166.6
X$7672 2065 2166 2033 2051 395 428 2013 OAI22_X1
* cell instance $7673 r0 *1 218.5,166.6
X$7673 2048 2061 428 395 2034 OR2_X1
* cell instance $7674 r0 *1 219.26,166.6
X$7674 2032 2050 428 395 2061 XNOR2_X2
* cell instance $7693 m0 *1 212.42,169.4
X$7693 428 2087 2001 3308 2067 395 DFF_X2
* cell instance $7696 m0 *1 217.74,169.4
X$7696 2068 2067 2032 428 395 2070 NAND3_X2
* cell instance $7698 m0 *1 219.26,169.4
X$7698 2049 2089 428 395 2051 XNOR2_X2
* cell instance $7699 m0 *1 221.16,169.4
X$7699 2069 2070 428 395 2089 NOR2_X1
* cell instance $7701 r0 *1 221.54,166.6
X$7701 2032 2050 395 428 2052 AND2_X1
* cell instance $7704 m0 *1 224.77,169.4
X$7704 428 2036 2072 2071 2018 2069 395 NAND4_X4
* cell instance $7705 r0 *1 225.91,166.6
X$7705 2048 2031 2071 428 395 2066 NAND3_X1
* cell instance $7707 r0 *1 226.67,166.6
X$7707 2033 2053 2066 395 2002 428 OAI21_X1
* cell instance $7708 r0 *1 227.43,166.6
X$7708 2072 2036 2071 2052 428 2047 395 NAND4_X2
* cell instance $7713 m0 *1 228.19,169.4
X$7713 2070 2071 395 2053 428 XOR2_X2
* cell instance $7714 m0 *1 229.9,169.4
X$7714 2070 428 395 2088 INV_X1
* cell instance $7716 m0 *1 230.47,169.4
X$7716 2088 2072 2071 428 395 2073 NAND3_X1
* cell instance $7719 m0 *1 231.8,169.4
X$7719 428 3374 2086 2074 2001 395 DFF_X1
* cell instance $7720 m0 *1 235.03,169.4
X$7720 2086 428 395 2072 BUF_X2
* cell instance $7722 r0 *1 238.07,166.6
X$7722 2064 2054 428 395 2063 NAND2_X2
* cell instance $7724 r0 *1 239.02,166.6
X$7724 2059 2051 2054 395 428 2062 HA_X1
* cell instance $7725 r0 *1 240.92,166.6
X$7725 2062 2054 2037 428 2085 395 AOI21_X1
* cell instance $7727 r0 *1 242.44,166.6
X$7727 1972 2053 2038 395 428 2105 HA_X1
* cell instance $7729 r0 *1 245.1,166.6
X$7729 2039 2055 2060 428 2082 395 AOI21_X1
* cell instance $7738 m0 *1 241.49,169.4
X$7738 2082 2063 2085 395 2084 428 OAI21_X1
* cell instance $7741 m0 *1 242.82,169.4
X$7741 2038 2083 395 428 2095 AND2_X1
* cell instance $7742 m0 *1 243.58,169.4
X$7742 2081 2061 2083 395 428 2096 HA_X1
* cell instance $7743 m0 *1 245.48,169.4
X$7743 2075 2055 428 395 2153 NAND2_X2
* cell instance $7744 m0 *1 246.43,169.4
X$7744 2115 2094 2075 395 428 2060 HA_X1
* cell instance $7749 m0 *1 251.18,169.4
X$7749 2080 428 395 LOGIC0_X1
* cell instance $7750 m0 *1 251.56,169.4
X$7750 2080 428 395 2076 BUF_X1
* cell instance $7751 r0 *1 252.13,166.6
X$7751 2057 428 395 LOGIC0_X1
* cell instance $7752 r0 *1 251.56,166.6
X$7752 2023 428 395 2058 BUF_X1
* cell instance $7753 r0 *1 252.51,166.6
X$7753 2057 428 395 2056 BUF_X1
* cell instance $7756 m0 *1 252.51,169.4
X$7756 2079 428 395 LOGIC0_X1
* cell instance $7757 m0 *1 252.89,169.4
X$7757 2079 428 395 2077 BUF_X1
* cell instance $7971 m0 *1 217.36,205.8
X$7971 428 3387 2618 2595 2247 395 DFF_X1
* cell instance $7972 r0 *1 220.59,203
X$7972 2564 2518 428 395 2582 NAND2_X1
* cell instance $7974 r0 *1 221.16,203
X$7974 2518 2565 2582 395 2595 428 OAI21_X1
* cell instance $7978 r0 *1 224.39,203
X$7978 2517 428 395 2583 INV_X1
* cell instance $7980 r0 *1 225.53,203
X$7980 2583 2566 428 395 2569 XNOR2_X2
* cell instance $7982 r0 *1 227.62,203
X$7982 2585 2567 2441 2519 428 2566 395 NAND4_X2
* cell instance $7984 r0 *1 229.52,203
X$7984 2567 428 395 2568 INV_X1
* cell instance $7985 r0 *1 229.9,203
X$7985 2568 2593 395 428 2591 XNOR2_X1
* cell instance $7986 r0 *1 231.04,203
X$7986 2519 2585 428 395 2593 NAND2_X1
* cell instance $7988 m0 *1 220.59,205.8
X$7988 2618 428 395 2518 CLKBUF_X2
* cell instance $7992 m0 *1 224.01,205.8
X$7992 2517 2352 2566 428 395 2596 OR3_X1
* cell instance $7993 m0 *1 224.96,205.8
X$7993 2583 2584 2596 395 2620 428 OAI21_X1
* cell instance $7994 m0 *1 225.72,205.8
X$7994 2192 2113 2566 428 2584 395 AOI21_X1
* cell instance $7997 m0 *1 228.76,205.8
X$7997 2113 2519 2585 2568 428 395 2622 NAND4_X1
* cell instance $7998 m0 *1 229.71,205.8
X$7998 2568 2594 2622 395 2621 428 OAI21_X1
* cell instance $7999 m0 *1 230.47,205.8
X$7999 2192 2593 2113 428 2594 395 AOI21_X1
* cell instance $8001 r0 *1 232.75,203
X$8001 2352 2303 2519 428 2586 395 AOI21_X1
* cell instance $8002 r0 *1 231.99,203
X$8002 2550 2570 395 428 2585 AND2_X1
* cell instance $8006 m0 *1 232.56,205.8
X$8006 2113 2519 2303 428 395 2598 NAND3_X1
* cell instance $8007 m0 *1 233.32,205.8
X$8007 2586 2192 2475 395 2623 428 OAI21_X1
* cell instance $8008 r0 *1 234.08,203
X$8008 2587 2444 2475 2303 395 428 2570 AND4_X2
* cell instance $8010 r0 *1 235.41,203
X$8010 2444 2475 2303 395 428 2588 AND3_X1
* cell instance $8013 m0 *1 234.08,205.8
X$8013 2352 2588 2519 428 2600 395 AOI21_X1
* cell instance $8014 m0 *1 234.84,205.8
X$8014 2113 2519 2588 428 395 2624 NAND3_X1
* cell instance $8016 m0 *1 235.79,205.8
X$8016 2519 2588 428 395 2592 NAND2_X1
* cell instance $8018 r0 *1 237.69,203
X$8018 428 3416 2581 2579 2208 395 DFF_X1
* cell instance $8020 r0 *1 240.92,203
X$8020 2581 428 395 2550 BUF_X2
* cell instance $8023 r0 *1 250.8,203
X$8023 2577 428 395 LOGIC0_X1
* cell instance $8025 m0 *1 237.88,205.8
X$8025 2592 2587 395 2578 428 XOR2_X2
* cell instance $8033 m0 *1 250.23,205.8
X$8033 2629 428 395 LOGIC0_X1
* cell instance $8034 m0 *1 250.61,205.8
X$8034 2629 428 395 2589 BUF_X1
* cell instance $8035 m0 *1 251.18,205.8
X$8035 2617 428 395 LOGIC0_X1
* cell instance $8036 m0 *1 251.56,205.8
X$8036 2617 428 395 2590 BUF_X1
* cell instance $8038 r0 *1 251.56,203
X$8038 2577 428 395 2571 BUF_X1
* cell instance $8120 r0 *1 251.18,149.8
X$8120 1971 428 395 LOGIC0_X1
* cell instance $8121 r0 *1 251.56,149.8
X$8121 1971 428 395 1945 BUF_X1
* cell instance $8151 m0 *1 250.23,152.6
X$8151 1970 428 395 LOGIC0_X1
* cell instance $8154 m0 *1 251.18,152.6
X$8154 1970 428 395 1964 BUF_X1
* cell instance $8155 m0 *1 251.75,152.6
X$8155 1966 428 395 LOGIC0_X1
* cell instance $8156 m0 *1 252.13,152.6
X$8156 1966 428 395 1965 BUF_X1
* cell instance $8157 r0 *1 252.89,149.8
X$8157 1968 428 395 1962 BUF_X1
* cell instance $8158 r0 *1 252.51,149.8
X$8158 1968 428 395 LOGIC0_X1
* cell instance $8161 m0 *1 252.89,152.6
X$8161 1958 428 395 1959 BUF_X1
* cell instance $8241 r0 *1 212.42,200.2
X$8241 428 3443 2559 2558 2247 395 DFF_X1
* cell instance $8242 r0 *1 215.65,200.2
X$8242 2559 428 395 2513 BUF_X1
* cell instance $8247 m0 *1 125.02,203
X$8247 428 3362 2563 2429 2466 395 DFF_X1
* cell instance $8269 r0 *1 217.36,200.2
X$8269 2514 2513 428 395 2546 NAND2_X1
* cell instance $8270 r0 *1 216.6,200.2
X$8270 2513 2557 2546 395 2558 428 OAI21_X1
* cell instance $8272 r0 *1 218.12,200.2
X$8272 2203 2515 428 395 2557 NAND2_X1
* cell instance $8273 r0 *1 218.69,200.2
X$8273 2421 2560 2211 2272 395 2515 428 NOR4_X2
* cell instance $8274 r0 *1 220.4,200.2
X$8274 2441 2517 2518 428 395 2560 NAND3_X1
* cell instance $8275 r0 *1 221.16,200.2
X$8275 2272 2421 2562 2170 395 2561 428 NOR4_X2
* cell instance $8276 r0 *1 222.87,200.2
X$8276 2441 2517 428 395 2562 NAND2_X1
* cell instance $8280 r0 *1 228.19,200.2
X$8280 2272 2211 2519 428 395 NOR2_X4
* cell instance $8286 m0 *1 220.78,203
X$8286 2352 2561 2200 395 2564 428 OAI21_X1
* cell instance $8287 m0 *1 221.54,203
X$8287 2561 2203 428 395 2565 NAND2_X1
* cell instance $8292 m0 *1 229.52,203
X$8292 2550 2567 2570 428 2421 395 NAND3_X4
* cell instance $8295 r0 *1 233.32,200.2
X$8295 2170 2272 2547 395 2548 428 NOR3_X2
* cell instance $8297 r0 *1 235.6,200.2
X$8297 2352 2548 2200 395 2549 428 OAI21_X1
* cell instance $8298 r0 *1 236.36,200.2
X$8298 2549 2550 428 395 2580 NAND2_X1
* cell instance $8299 r0 *1 236.93,200.2
X$8299 2548 2203 428 395 2551 NAND2_X1
* cell instance $8302 r0 *1 239.78,200.2
X$8302 2550 2548 395 428 2543 XNOR2_X1
* cell instance $8307 m0 *1 233.89,203
X$8307 2570 428 395 2547 INV_X1
* cell instance $8311 m0 *1 236.74,203
X$8311 2550 2551 2580 395 2579 428 OAI21_X1
* cell instance $8316 m0 *1 241.3,203
X$8316 2736 2578 2446 395 428 2478 HA_X1
* cell instance $8318 r0 *1 245.29,200.2
X$8318 2556 2591 2523 395 428 2525 HA_X1
* cell instance $8324 r0 *1 250.42,200.2
X$8324 2553 428 395 2235 BUF_X1
* cell instance $8325 r0 *1 249.85,200.2
X$8325 2554 428 395 2556 BUF_X1
* cell instance $8329 m0 *1 251.37,203
X$8329 2576 428 395 LOGIC0_X1
* cell instance $8330 r0 *1 251.56,200.2
X$8330 2555 428 395 LOGIC0_X1
* cell instance $8332 r0 *1 251.94,200.2
X$8332 2555 428 395 2531 BUF_X1
* cell instance $8334 m0 *1 251.75,203
X$8334 2576 428 395 2572 BUF_X1
* cell instance $8335 m0 *1 252.32,203
X$8335 2574 428 395 LOGIC0_X1
* cell instance $8337 m0 *1 252.89,203
X$8337 2574 428 395 2552 BUF_X1
* cell instance $8338 r0 *1 253.08,200.2
X$8338 2527 428 395 LOGIC0_X1
* cell instance $8381 r0 *1 108.3,191.8
X$8381 1280 395 1867 428 BUF_X4
* cell instance $8394 m0 *1 125.97,194.6
X$8394 2374 2460 2394 395 2457 428 NOR3_X2
* cell instance $8396 r0 *1 126.16,191.8
X$8396 906 2374 395 428 2429 AND2_X1
* cell instance $8398 m0 *1 127.3,194.6
X$8398 2460 2394 2395 2374 395 2426 428 NOR4_X2
* cell instance $8399 r0 *1 128.63,191.8
X$8399 2422 2406 1576 395 2371 428 OAI21_X1
* cell instance $8400 r0 *1 128.06,191.8
X$8400 2394 2395 428 395 2406 NOR2_X1
* cell instance $8403 r0 *1 131.1,191.8
X$8403 2372 428 395 2394 CLKBUF_X3
* cell instance $8406 r0 *1 133,191.8
X$8406 2394 2410 2409 428 2031 395 NAND3_X4
* cell instance $8412 m0 *1 131.48,194.6
X$8412 2409 428 395 2461 INV_X1
* cell instance $8413 m0 *1 131.86,194.6
X$8413 2411 2461 2394 428 2422 395 AOI21_X1
* cell instance $8416 m0 *1 133.57,194.6
X$8416 2409 2394 2410 428 395 2377 AND3_X4
* cell instance $8417 m0 *1 135.66,194.6
X$8417 2410 428 395 2411 INV_X1
* cell instance $8418 m0 *1 136.04,194.6
X$8418 2431 428 395 2432 INV_X1
* cell instance $8420 m0 *1 136.61,194.6
X$8420 2432 2395 2411 428 395 2424 NAND3_X1
* cell instance $8422 r0 *1 136.61,191.8
X$8422 2410 2395 2108 395 428 2390 AND3_X1
* cell instance $8425 r0 *1 140.03,191.8
X$8425 2368 2373 2423 428 395 2408 OR3_X1
* cell instance $8426 r0 *1 140.98,191.8
X$8426 428 2408 1807 3323 2412 395 DFF_X2
* cell instance $8438 r0 *1 205.58,191.8
X$8438 2377 1434 2108 428 395 NOR2_X4
* cell instance $8439 r0 *1 207.29,191.8
X$8439 428 2393 2247 3315 2379 395 DFF_X2
* cell instance $8442 r0 *1 218.5,191.8
X$8442 428 2211 2421 2272 2407 2355 395 NOR4_X4
* cell instance $8444 r0 *1 223.44,191.8
X$8444 2396 428 395 2200 CLKBUF_X3
* cell instance $8449 r0 *1 239.78,191.8
X$8449 2419 2346 2380 2389 2405 2404 395 428 AOI221_X2
* cell instance $8450 r0 *1 241.87,191.8
X$8450 2403 2397 2448 2381 2404 2350 428 395 OAI221_X2
* cell instance $8451 r0 *1 243.96,191.8
X$8451 2397 2415 428 395 2381 OR2_X2
* cell instance $8455 r0 *1 250.23,191.8
X$8455 2402 428 395 LOGIC0_X1
* cell instance $8456 r0 *1 250.61,191.8
X$8456 2402 428 395 2384 BUF_X1
* cell instance $8458 r0 *1 251.37,191.8
X$8458 2401 428 395 LOGIC0_X1
* cell instance $8459 r0 *1 251.75,191.8
X$8459 2401 428 395 2399 BUF_X1
* cell instance $8462 m0 *1 137.56,194.6
X$8462 2412 2108 2424 395 428 2423 AND3_X1
* cell instance $8475 m0 *1 201.59,194.6
X$8475 2431 2430 428 2269 395 NAND2_X4
* cell instance $8476 m0 *1 203.3,194.6
X$8476 2430 2431 395 428 2110 AND2_X2
* cell instance $8480 m0 *1 207.86,194.6
X$8480 428 1434 2377 2110 2192 395 NOR3_X4
* cell instance $8485 m0 *1 220.21,194.6
X$8485 2435 2413 428 395 2407 OR2_X1
* cell instance $8489 m0 *1 222.3,194.6
X$8489 2507 2508 428 395 2405 NAND2_X1
* cell instance $8490 m0 *1 222.87,194.6
X$8490 2286 2545 2420 395 428 2436 HA_X1
* cell instance $8491 m0 *1 224.77,194.6
X$8491 2437 2463 2389 2420 428 2397 395 NAND4_X2
* cell instance $8493 m0 *1 226.86,194.6
X$8493 2352 2440 2396 395 2439 428 OAI21_X1
* cell instance $8495 m0 *1 227.81,194.6
X$8495 2273 2421 428 395 2440 NOR2_X1
* cell instance $8497 m0 *1 234.46,194.6
X$8497 2273 2303 395 2418 428 XOR2_X2
* cell instance $8502 m0 *1 241.3,194.6
X$8502 2414 2415 2397 428 395 2419 NOR3_X1
* cell instance $8504 m0 *1 242.44,194.6
X$8504 2058 2418 2504 395 428 2455 HA_X1
* cell instance $8505 m0 *1 244.34,194.6
X$8505 2416 2447 2455 428 2496 395 AOI21_X1
* cell instance $8510 m0 *1 250.23,194.6
X$8510 2453 428 395 LOGIC0_X1
* cell instance $8511 m0 *1 250.61,194.6
X$8511 2453 428 395 2417 BUF_X1
* cell instance $8512 m0 *1 251.18,194.6
X$8512 2454 428 395 LOGIC0_X1
* cell instance $8513 m0 *1 251.56,194.6
X$8513 2454 428 395 2449 BUF_X1
* cell instance $8514 m0 *1 252.13,194.6
X$8514 2398 428 395 LOGIC0_X1
* cell instance $8515 m0 *1 252.51,194.6
X$8515 2451 428 395 LOGIC0_X1
* cell instance $8517 r0 *1 252.7,191.8
X$8517 2398 428 395 2400 BUF_X1
* cell instance $8519 m0 *1 252.89,194.6
X$8519 2451 428 395 2450 BUF_X1
* cell instance $8582 r0 *1 142.5,152.6
X$8582 906 395 1585 428 BUF_X4
* cell instance $8628 m0 *1 250.61,155.4
X$8628 1985 428 395 LOGIC0_X1
* cell instance $8629 r0 *1 250.8,152.6
X$8629 1969 428 395 LOGIC0_X1
* cell instance $8631 r0 *1 251.18,152.6
X$8631 1969 428 395 1960 BUF_X1
* cell instance $8632 r0 *1 251.75,152.6
X$8632 1984 428 395 LOGIC0_X1
* cell instance $8633 r0 *1 252.13,152.6
X$8633 1967 428 395 LOGIC0_X1
* cell instance $8634 r0 *1 252.51,152.6
X$8634 1967 428 395 1963 BUF_X1
* cell instance $8635 r0 *1 253.08,152.6
X$8635 1958 428 395 LOGIC0_X1
* cell instance $8638 m0 *1 251.18,155.4
X$8638 1985 428 395 1977 BUF_X1
* cell instance $8639 m0 *1 251.75,155.4
X$8639 1984 428 395 1961 BUF_X1
* cell instance $8640 m0 *1 252.32,155.4
X$8640 1981 428 395 LOGIC0_X1
* cell instance $8641 m0 *1 252.7,155.4
X$8641 1981 428 395 1979 BUF_X1
* cell instance $8717 r0 *1 125.59,197.4
X$8717 2460 428 395 2538 INV_X1
* cell instance $8719 r0 *1 125.97,197.4
X$8719 2538 2539 428 395 2428 NOR2_X1
* cell instance $8722 r0 *1 127.49,197.4
X$8722 1413 2539 2460 395 428 2540 AND3_X1
* cell instance $8724 r0 *1 129.96,197.4
X$8724 428 3437 2495 2540 2466 395 DFF_X1
* cell instance $8727 r0 *1 135.47,197.4
X$8727 428 3432 2471 2498 1807 395 DFF_X1
* cell instance $8743 r0 *1 219.45,197.4
X$8743 2544 2516 2463 395 428 2473 HA_X1
* cell instance $8748 r0 *1 232.75,197.4
X$8748 2303 2475 428 395 2442 NAND2_X1
* cell instance $8751 r0 *1 235.6,197.4
X$8751 2520 2475 395 2499 428 XOR2_X2
* cell instance $8783 m0 *1 217.74,200.2
X$8783 2515 2215 2200 395 2514 428 OAI21_X1
* cell instance $8785 m0 *1 218.69,200.2
X$8785 2513 2515 395 428 2516 XNOR2_X1
* cell instance $8786 m0 *1 219.83,200.2
X$8786 2517 2518 2513 2441 428 2413 395 NAND4_X2
* cell instance $8788 m0 *1 221.73,200.2
X$8788 2518 2561 395 428 2545 XNOR2_X1
* cell instance $8793 m0 *1 235.6,200.2
X$8793 2519 2303 428 395 2520 NAND2_X1
* cell instance $8796 r0 *1 242.63,197.4
X$8796 2241 2569 2479 395 428 2521 HA_X1
* cell instance $8797 r0 *1 240.73,197.4
X$8797 2477 2445 2476 395 428 2494 HA_X1
* cell instance $8798 r0 *1 244.53,197.4
X$8798 2521 2479 2541 428 2403 395 AOI21_X1
* cell instance $8799 r0 *1 245.29,197.4
X$8799 2522 2480 2523 2479 428 395 2415 NAND4_X1
* cell instance $8800 r0 *1 246.24,197.4
X$8800 2480 428 395 2537 INV_X1
* cell instance $8801 r0 *1 246.62,197.4
X$8801 2537 2526 2542 395 2541 428 OAI21_X1
* cell instance $8805 r0 *1 251.37,197.4
X$8805 2534 428 395 LOGIC0_X1
* cell instance $8806 r0 *1 251.75,197.4
X$8806 2534 428 395 2529 BUF_X1
* cell instance $8807 r0 *1 252.32,197.4
X$8807 2533 428 395 LOGIC0_X1
* cell instance $8808 r0 *1 252.7,197.4
X$8808 2533 428 395 2482 BUF_X1
* cell instance $8817 m0 *1 244.15,200.2
X$8817 2133 2543 2522 395 428 2524 HA_X1
* cell instance $8818 m0 *1 246.05,200.2
X$8818 2525 2523 2524 428 2526 395 AOI21_X1
* cell instance $8821 m0 *1 250.23,200.2
X$8821 2536 428 395 LOGIC0_X1
* cell instance $8822 m0 *1 250.61,200.2
X$8822 2536 428 395 2530 BUF_X1
* cell instance $8825 m0 *1 251.75,200.2
X$8825 2535 428 395 LOGIC0_X1
* cell instance $8827 m0 *1 252.32,200.2
X$8827 2535 428 395 2532 BUF_X1
* cell instance $8828 m0 *1 252.89,200.2
X$8828 2527 428 395 2528 BUF_X1
* cell instance $8912 m0 *1 211.09,183.4
X$8912 428 3358 2289 2262 2247 395 DFF_X1
* cell instance $8913 m0 *1 214.32,183.4
X$8913 2263 1127 428 395 2262 NOR2_X1
* cell instance $8914 m0 *1 214.89,183.4
X$8914 2289 428 395 2228 BUF_X1
* cell instance $8915 m0 *1 215.46,183.4
X$8915 2265 2228 2290 428 2263 395 AOI21_X1
* cell instance $8916 m0 *1 216.22,183.4
X$8916 2170 2269 2228 428 395 2265 NOR3_X1
* cell instance $8917 r0 *1 216.79,180.6
X$8917 2048 2266 2166 395 2290 428 OAI21_X1
* cell instance $8919 r0 *1 217.55,180.6
X$8919 1276 428 395 2247 CLKBUF_X3
* cell instance $8920 r0 *1 218.5,180.6
X$8920 2247 428 395 INV_X4
* cell instance $8921 r0 *1 219.45,180.6
X$8921 2170 428 395 2266 INV_X1
* cell instance $8925 r0 *1 229.71,180.6
X$8925 2246 428 395 2215 CLKBUF_X3
* cell instance $8930 m0 *1 220.02,183.4
X$8930 2113 428 395 2203 CLKBUF_X3
* cell instance $8934 m0 *1 222.3,183.4
X$8934 2245 395 2170 428 BUF_X4
* cell instance $8939 m0 *1 228,183.4
X$8939 428 3327 2297 2268 2208 395 DFF_X1
* cell instance $8940 m0 *1 231.23,183.4
X$8940 2297 428 395 2274 BUF_X2
* cell instance $8943 m0 *1 232.94,183.4
X$8943 2274 2299 2301 395 2268 428 OAI21_X1
* cell instance $8944 r0 *1 233.51,180.6
X$8944 2170 2230 2249 395 2248 428 NOR3_X2
* cell instance $8946 r0 *1 234.84,180.6
X$8946 2231 428 395 2249 INV_X1
* cell instance $8948 r0 *1 235.41,180.6
X$8948 2232 2203 2249 428 395 2264 NAND3_X1
* cell instance $8950 r0 *1 236.93,180.6
X$8950 2264 2250 428 395 2261 NAND2_X1
* cell instance $8952 r0 *1 237.69,180.6
X$8952 428 3450 2231 2261 2112 395 DFF_X1
* cell instance $8956 m0 *1 233.7,183.4
X$8956 2248 2203 428 395 2299 NAND2_X1
* cell instance $8957 m0 *1 234.27,183.4
X$8957 2267 2274 428 395 2301 NAND2_X1
* cell instance $8958 m0 *1 234.84,183.4
X$8958 2215 2248 2200 395 2267 428 OAI21_X1
* cell instance $8967 m0 *1 244.91,183.4
X$8967 2291 2090 2294 395 428 2276 HA_X1
* cell instance $8968 r0 *1 245.29,180.6
X$8968 2251 428 395 2252 INV_X1
* cell instance $8970 r0 *1 245.67,180.6
X$8970 2253 2243 2251 395 428 2260 HA_X1
* cell instance $8972 r0 *1 247.76,180.6
X$8972 2260 428 395 2287 INV_X1
* cell instance $8976 m0 *1 246.81,183.4
X$8976 2252 2276 2287 395 2104 428 OAI21_X1
* cell instance $8977 m0 *1 247.57,183.4
X$8977 2284 428 395 2291 INV_X1
* cell instance $8980 m0 *1 248.52,183.4
X$8980 2254 428 395 2314 BUF_X1
* cell instance $8984 m0 *1 251.56,183.4
X$8984 2283 428 395 LOGIC0_X1
* cell instance $8985 m0 *1 251.94,183.4
X$8985 2277 428 395 LOGIC0_X1
* cell instance $8986 m0 *1 252.32,183.4
X$8986 2283 428 395 2259 BUF_X1
* cell instance $8987 r0 *1 252.51,180.6
X$8987 2258 428 395 LOGIC0_X1
* cell instance $8989 r0 *1 252.89,180.6
X$8989 2258 428 395 2238 BUF_X1
* cell instance $8991 m0 *1 252.89,183.4
X$8991 2277 428 395 2257 BUF_X1
* cell instance $9070 r0 *1 219.45,175
X$9070 2093 2069 428 395 2190 NOR2_X2
* cell instance $9071 r0 *1 220.4,175
X$9071 2202 2164 428 395 2185 XNOR2_X2
* cell instance $9072 r0 *1 222.3,175
X$9072 2226 2147 2146 2069 428 395 2167 OR4_X1
* cell instance $9099 m0 *1 213.75,177.8
X$9099 2048 2189 428 395 2188 NOR2_X1
* cell instance $9100 m0 *1 214.32,177.8
X$9100 2190 2188 2189 2206 428 395 2224 AOI22_X1
* cell instance $9101 m0 *1 215.27,177.8
X$9101 2048 2190 2166 395 2206 428 OAI21_X1
* cell instance $9103 m0 *1 216.79,177.8
X$9103 1832 2201 395 428 2207 AND2_X1
* cell instance $9104 m0 *1 217.55,177.8
X$9104 2189 2190 428 395 2198 XNOR2_X2
* cell instance $9105 m0 *1 219.45,177.8
X$9105 2189 428 395 2146 INV_X1
* cell instance $9106 m0 *1 219.83,177.8
X$9106 2202 428 395 2147 INV_X1
* cell instance $9107 m0 *1 220.21,177.8
X$9107 2147 2166 2185 2033 395 428 2201 OAI22_X1
* cell instance $9108 m0 *1 221.16,177.8
X$9108 2225 2069 2145 428 395 2211 OR3_X4
* cell instance $9109 m0 *1 223.25,177.8
X$9109 2205 2165 428 395 2210 XNOR2_X2
* cell instance $9110 r0 *1 224.77,175
X$9110 2167 2145 428 395 2150 NOR2_X1
* cell instance $9112 r0 *1 225.34,175
X$9112 2168 2149 2145 2167 428 395 2191 OR4_X1
* cell instance $9115 r0 *1 229.71,175
X$9115 2187 2191 395 428 2172 XNOR2_X1
* cell instance $9120 m0 *1 229.14,177.8
X$9120 2192 2191 2203 428 2212 395 AOI21_X1
* cell instance $9121 m0 *1 229.9,177.8
X$9121 2187 2212 2213 395 2204 428 OAI21_X1
* cell instance $9122 m0 *1 230.66,177.8
X$9122 2214 428 395 2187 INV_X1
* cell instance $9124 r0 *1 232.56,175
X$9124 2168 2170 395 428 2127 XNOR2_X1
* cell instance $9125 r0 *1 231.23,175
X$9125 2170 2168 2187 395 2169 428 NOR3_X2
* cell instance $9126 r0 *1 233.7,175
X$9126 2152 2169 395 428 2123 XNOR2_X1
* cell instance $9130 r0 *1 237.31,175
X$9130 2172 2234 2141 395 428 2125 HA_X1
* cell instance $9134 r0 *1 241.68,175
X$9134 2136 2174 428 395 2173 NOR2_X1
* cell instance $9138 m0 *1 232.37,177.8
X$9138 2169 2203 428 395 2151 NAND2_X1
* cell instance $9140 m0 *1 233.32,177.8
X$9140 2215 2169 2200 395 2171 428 OAI21_X1
* cell instance $9146 r0 *1 246.05,175
X$9146 2136 428 395 2175 INV_X1
* cell instance $9147 r0 *1 242.63,175
X$9147 428 2174 2136 2063 2153 2193 395 NOR4_X4
* cell instance $9148 r0 *1 246.43,175
X$9148 2183 2175 428 395 2186 NAND2_X1
* cell instance $9149 r0 *1 247,175
X$9149 2240 2185 2176 395 428 2184 HA_X1
* cell instance $9150 r0 *1 248.9,175
X$9150 2184 2176 2194 428 2177 395 AOI21_X1
* cell instance $9151 r0 *1 249.66,175
X$9151 2177 2195 2182 395 2183 428 OAI21_X1
* cell instance $9153 r0 *1 250.61,175
X$9153 2181 2156 2216 428 2182 395 AOI21_X1
* cell instance $9154 r0 *1 251.37,175
X$9154 2180 428 395 1749 BUF_X2
* cell instance $9156 r0 *1 252.32,175
X$9156 2178 428 395 1776 BUF_X2
* cell instance $9157 r0 *1 253.08,175
X$9157 2154 428 395 LOGIC0_X1
* cell instance $9160 m0 *1 243.58,177.8
X$9160 428 2197 2199 2156 2176 2174 395 NAND4_X4
* cell instance $9161 m0 *1 247,177.8
X$9161 2223 2198 2199 395 428 2194 HA_X1
* cell instance $9164 m0 *1 249.47,177.8
X$9164 2197 2156 428 395 2195 NAND2_X1
* cell instance $9168 m0 *1 251.37,177.8
X$9168 2179 428 395 2217 BUF_X1
* cell instance $9232 r0 *1 213.94,163.8
X$9232 428 3431 2012 2028 2001 395 DFF_X1
* cell instance $9233 r0 *1 217.17,163.8
X$9233 1832 2013 395 428 2028 AND2_X1
* cell instance $9254 m0 *1 216.6,166.6
X$9254 2012 428 395 2049 BUF_X2
* cell instance $9255 m0 *1 217.36,166.6
X$9255 2033 2031 2032 428 395 2014 NAND3_X1
* cell instance $9257 m0 *1 218.31,166.6
X$9257 1514 2014 2034 428 2030 395 AOI21_X1
* cell instance $9259 r0 *1 219.26,163.8
X$9259 2015 428 395 2032 CLKBUF_X3
* cell instance $9266 r0 *1 226.48,163.8
X$9266 2019 2033 2027 395 2000 428 OAI21_X1
* cell instance $9267 r0 *1 222.87,163.8
X$9267 428 2029 2001 3326 2018 395 DFF_X2
* cell instance $9269 r0 *1 228,163.8
X$9269 1988 428 395 2036 BUF_X2
* cell instance $9271 r0 *1 230.28,163.8
X$9271 2026 428 395 2071 CLKBUF_X3
* cell instance $9277 m0 *1 223.25,166.6
X$9277 1832 2016 395 428 2029 AND2_X1
* cell instance $9278 m0 *1 224.01,166.6
X$9278 2033 2035 2017 395 2016 428 OAI21_X1
* cell instance $9279 m0 *1 224.77,166.6
X$9279 2048 2031 2018 428 395 2017 NAND3_X1
* cell instance $9281 m0 *1 225.72,166.6
X$9281 2048 2031 2036 428 395 2027 NAND3_X1
* cell instance $9282 m0 *1 226.48,166.6
X$9282 2047 2018 395 2035 428 XOR2_X2
* cell instance $9285 m0 *1 228.76,166.6
X$9285 2073 2036 395 2019 428 XOR2_X2
* cell instance $9289 m0 *1 238.26,166.6
X$9289 2046 2035 2064 395 428 2037 HA_X1
* cell instance $9297 m0 *1 244.15,166.6
X$9297 1998 2019 2055 395 428 2039 HA_X1
* cell instance $9301 r0 *1 250.8,163.8
X$9301 2021 428 395 2025 BUF_X1
* cell instance $9305 m0 *1 250.99,166.6
X$9305 2044 428 395 2040 BUF_X1
* cell instance $9306 m0 *1 251.56,166.6
X$9306 2045 428 395 LOGIC0_X1
* cell instance $9307 m0 *1 251.94,166.6
X$9307 2041 428 395 LOGIC0_X1
* cell instance $9308 m0 *1 252.32,166.6
X$9308 2045 428 395 2042 BUF_X1
* cell instance $9309 r0 *1 252.89,163.8
X$9309 2024 428 395 2022 BUF_X1
* cell instance $9310 r0 *1 252.51,163.8
X$9310 2024 428 395 LOGIC0_X1
* cell instance $9312 m0 *1 252.89,166.6
X$9312 2041 428 395 2043 BUF_X1
* cell instance $9420 m0 *1 212.04,175
X$9420 1585 2144 395 428 2161 AND2_X1
* cell instance $9421 m0 *1 212.8,175
X$9421 428 2161 2112 3306 2148 395 DFF_X2
* cell instance $9425 m0 *1 220.02,175
X$9425 2069 2145 2146 395 2164 428 NOR3_X2
* cell instance $9426 m0 *1 221.35,175
X$9426 2069 2146 2147 2093 395 2165 428 NOR4_X2
* cell instance $9427 m0 *1 223.06,175
X$9427 2149 2166 2033 2157 395 428 2144 OAI22_X1
* cell instance $9428 m0 *1 224.01,175
X$9428 2148 428 395 2149 INV_X1
* cell instance $9429 m0 *1 224.39,175
X$9429 2148 2150 428 395 2157 XNOR2_X2
* cell instance $9431 r0 *1 231.99,172.2
X$9431 428 3441 2162 2143 2112 395 DFF_X1
* cell instance $9435 r0 *1 236.17,172.2
X$9435 2123 2114 2120 395 428 2124 HA_X1
* cell instance $9436 r0 *1 238.07,172.2
X$9436 2124 2120 2125 428 2142 395 AOI21_X1
* cell instance $9437 r0 *1 238.83,172.2
X$9437 2139 2120 2141 428 395 2140 NAND3_X1
* cell instance $9438 r0 *1 239.59,172.2
X$9438 2127 2097 2126 395 428 2139 HA_X1
* cell instance $9439 r0 *1 241.49,172.2
X$9439 2173 2084 2134 2135 2137 2160 395 428 AOI221_X2
* cell instance $9440 r0 *1 243.58,172.2
X$9440 2040 2242 2135 395 428 2134 HA_X1
* cell instance $9444 r0 *1 249.47,172.2
X$9444 2128 428 395 1842 BUF_X2
* cell instance $9447 r0 *1 252.51,172.2
X$9447 2132 428 395 LOGIC0_X1
* cell instance $9448 r0 *1 252.89,172.2
X$9448 2132 428 395 2118 BUF_X1
* cell instance $9450 m0 *1 232.37,175
X$9450 2152 2151 2163 395 2143 428 OAI21_X1
* cell instance $9452 m0 *1 233.32,175
X$9452 2171 2152 428 395 2163 NAND2_X1
* cell instance $9455 m0 *1 235.03,175
X$9455 2162 428 395 2152 BUF_X1
* cell instance $9457 m0 *1 237.12,175
X$9457 428 2120 2126 2135 2141 2136 395 NAND4_X4
* cell instance $9458 m0 *1 240.54,175
X$9458 2142 2140 428 395 2137 NAND2_X1
* cell instance $9460 m0 *1 241.3,175
X$9460 428 2160 2186 2158 2138 2159 395 OAI211_X4
* cell instance $9461 m0 *1 244.53,175
X$9461 2174 2136 2063 2153 395 2158 428 OR4_X2
* cell instance $9465 m0 *1 249.47,175
X$9465 2020 2157 2156 395 428 2181 HA_X1
* cell instance $9466 m0 *1 251.37,175
X$9466 2129 428 395 2133 BUF_X1
* cell instance $9467 m0 *1 251.94,175
X$9467 2155 428 395 LOGIC0_X1
* cell instance $9468 m0 *1 252.32,175
X$9468 2155 428 395 2130 BUF_X1
* cell instance $9469 m0 *1 252.89,175
X$9469 2154 428 395 2131 BUF_X1
* cell instance $9513 r0 *1 111.91,186.2
X$9513 1009 395 1356 428 BUF_X4
* cell instance $9550 r0 *1 211.47,186.2
X$9550 2269 428 395 2048 CLKBUF_X3
* cell instance $9557 m0 *1 215.08,189
X$9557 2369 428 395 2351 INV_X1
* cell instance $9559 r0 *1 219.83,186.2
X$9559 2272 2170 2110 395 2343 428 OAI21_X1
* cell instance $9561 r0 *1 220.59,186.2
X$9561 2343 2166 428 395 2302 NAND2_X1
* cell instance $9563 r0 *1 221.35,186.2
X$9563 2302 2303 428 395 2270 NAND2_X1
* cell instance $9567 r0 *1 223.25,186.2
X$9567 2345 428 395 2303 CLKBUF_X3
* cell instance $9571 r0 *1 225.91,186.2
X$9571 2113 2320 395 428 2321 AND2_X1
* cell instance $9575 m0 *1 226.1,189
X$9575 2321 2304 2322 428 395 2347 MUX2_X1
* cell instance $9576 m0 *1 227.43,189
X$9576 428 3331 2304 2347 2208 395 DFF_X1
* cell instance $9577 r0 *1 230.28,186.2
X$9577 2304 2320 395 428 2315 XNOR2_X1
* cell instance $9579 r0 *1 231.42,186.2
X$9579 2304 2305 2307 395 428 2306 AND3_X1
* cell instance $9582 r0 *1 233.32,186.2
X$9582 2307 428 395 2324 INV_X1
* cell instance $9583 r0 *1 233.7,186.2
X$9583 2170 2300 2324 395 2275 428 NOR3_X2
* cell instance $9586 r0 *1 235.98,186.2
X$9586 2215 2275 2200 395 2349 428 OAI21_X1
* cell instance $9587 r0 *1 236.74,186.2
X$9587 2349 2305 428 395 2318 NAND2_X1
* cell instance $9588 r0 *1 237.31,186.2
X$9588 428 3452 2309 2308 2112 395 DFF_X1
* cell instance $9589 r0 *1 240.54,186.2
X$9589 2309 428 395 2305 BUF_X1
* cell instance $9595 m0 *1 231.8,189
X$9595 2305 2307 2323 395 428 2320 AND3_X1
* cell instance $9596 m0 *1 232.75,189
X$9596 2203 2323 2324 428 395 2348 NAND3_X1
* cell instance $9597 m0 *1 233.51,189
X$9597 2300 2211 428 395 2323 NOR2_X2
* cell instance $9605 r0 *1 245.67,186.2
X$9605 2340 2315 2329 395 428 2331 HA_X1
* cell instance $9606 r0 *1 243.77,186.2
X$9606 2288 2295 2325 395 428 2327 HA_X1
* cell instance $9609 r0 *1 250.8,186.2
X$9609 2339 428 395 LOGIC0_X1
* cell instance $9610 r0 *1 251.18,186.2
X$9610 2313 428 395 LOGIC0_X1
* cell instance $9611 r0 *1 251.56,186.2
X$9611 2339 428 395 2334 BUF_X1
* cell instance $9612 r0 *1 252.13,186.2
X$9612 2313 428 395 2311 BUF_X1
* cell instance $9613 r0 *1 252.7,186.2
X$9613 2332 428 395 2333 BUF_X1
* cell instance $9616 m0 *1 243.96,189
X$9616 2344 2326 2341 395 2346 428 OAI21_X1
* cell instance $9617 m0 *1 244.72,189
X$9617 2342 2360 2327 428 2326 395 AOI21_X1
* cell instance $9618 m0 *1 245.48,189
X$9618 2328 2329 428 395 2344 NAND2_X1
* cell instance $9621 m0 *1 246.62,189
X$9621 2331 2329 2330 428 2341 395 AOI21_X1
* cell instance $9625 m0 *1 250.99,189
X$9625 2338 428 395 LOGIC0_X1
* cell instance $9626 m0 *1 251.37,189
X$9626 2337 428 395 LOGIC0_X1
* cell instance $9627 m0 *1 251.75,189
X$9627 2338 428 395 2336 BUF_X1
* cell instance $9628 m0 *1 252.32,189
X$9628 2337 428 395 2335 BUF_X1
* cell instance $9630 m0 *1 253.08,189
X$9630 2332 428 395 LOGIC0_X1
* cell instance $9722 r0 *1 214.89,169.4
X$9722 2033 2031 2068 428 395 2106 NAND3_X1
* cell instance $9723 r0 *1 211.28,169.4
X$9723 428 2121 2001 2090 2068 395 DFF_X2
* cell instance $9725 r0 *1 215.84,169.4
X$9725 2033 2031 2067 428 395 2091 NAND3_X1
* cell instance $9729 m0 *1 213.37,172.2
X$9729 2110 2090 428 395 2122 NAND2_X1
* cell instance $9730 m0 *1 213.94,172.2
X$9730 1514 2106 2122 428 2121 395 AOI21_X1
* cell instance $9732 m0 *1 216.22,172.2
X$9732 1514 2091 2092 428 2087 395 AOI21_X1
* cell instance $9733 m0 *1 216.98,172.2
X$9733 2110 2111 428 395 2092 NAND2_X1
* cell instance $9735 r0 *1 221.16,169.4
X$9735 2049 2050 2032 428 395 2093 NAND3_X2
* cell instance $9736 r0 *1 217.74,169.4
X$9736 428 2068 2049 2032 2067 2145 395 NAND4_X4
* cell instance $9740 r0 *1 227.24,169.4
X$9740 1276 428 395 2112 CLKBUF_X3
* cell instance $9742 r0 *1 228.38,169.4
X$9742 2052 2071 428 395 2109 NAND2_X1
* cell instance $9743 r0 *1 228.95,169.4
X$9743 2109 2072 395 2094 428 XOR2_X2
* cell instance $9745 m0 *1 217.93,172.2
X$9745 2068 2067 2111 395 428 2050 HA_X1
* cell instance $9748 m0 *1 226.29,172.2
X$9748 1276 428 395 2001 CLKBUF_X3
* cell instance $9749 m0 *1 227.24,172.2
X$9749 2001 428 395 3288 INV_X8
* cell instance $9750 m0 *1 228.95,172.2
X$9750 2112 428 395 3291 INV_X8
* cell instance $9752 r0 *1 231.8,169.4
X$9752 2107 2110 2094 428 2074 395 AOI21_X1
* cell instance $9753 r0 *1 231.04,169.4
X$9753 2113 2072 2108 428 2107 395 AOI21_X1
* cell instance $9764 r0 *1 243.01,169.4
X$9764 2104 2095 2105 2038 2096 2159 395 428 AOI221_X2
* cell instance $9768 r0 *1 246.81,169.4
X$9768 2078 428 395 2097 BUF_X1
* cell instance $9773 r0 *1 250.23,169.4
X$9773 2103 428 395 LOGIC0_X1
* cell instance $9775 r0 *1 250.61,169.4
X$9775 2103 428 395 2099 BUF_X1
* cell instance $9776 r0 *1 251.18,169.4
X$9776 2102 428 395 LOGIC0_X1
* cell instance $9777 r0 *1 251.56,169.4
X$9777 2102 428 395 2098 BUF_X1
* cell instance $9778 r0 *1 252.13,169.4
X$9778 2101 428 395 LOGIC0_X1
* cell instance $9779 r0 *1 252.51,169.4
X$9779 2101 428 395 2100 BUF_X1
* cell instance $9784 m0 *1 251.75,172.2
X$9784 2117 428 395 2114 BUF_X1
* cell instance $9786 m0 *1 252.51,172.2
X$9786 2119 428 395 LOGIC0_X1
* cell instance $9787 m0 *1 252.89,172.2
X$9787 2119 428 395 2116 BUF_X1
* cell instance $9910 m0 *1 250.23,65.8
X$9910 609 428 395 LOGIC0_X1
* cell instance $9911 m0 *1 250.61,65.8
X$9911 609 428 395 591 BUF_X1
* cell instance $9913 r0 *1 250.8,63
X$9913 599 428 395 LOGIC0_X1
* cell instance $9914 r0 *1 251.37,63
X$9914 599 428 395 590 BUF_X1
* cell instance $9916 r0 *1 252.13,63
X$9916 596 428 395 LOGIC0_X1
* cell instance $9917 r0 *1 252.51,63
X$9917 596 428 395 592 BUF_X1
* cell instance $9919 m0 *1 251.18,65.8
X$9919 608 428 395 LOGIC0_X1
* cell instance $9920 m0 *1 251.56,65.8
X$9920 612 428 395 LOGIC0_X1
* cell instance $9921 m0 *1 251.94,65.8
X$9921 612 428 395 603 BUF_X1
* cell instance $9923 m0 *1 252.7,65.8
X$9923 608 428 395 606 BUF_X1
* cell instance $10004 m0 *1 209,180.6
X$10004 2110 1292 428 395 2246 NAND2_X2
* cell instance $10008 m0 *1 212.42,180.6
X$10008 428 3359 2227 2244 2247 395 DFF_X1
* cell instance $10009 r0 *1 212.99,177.8
X$10009 2224 1127 428 395 2244 NOR2_X1
* cell instance $10013 r0 *1 215.65,177.8
X$10013 2227 428 395 2189 CLKBUF_X2
* cell instance $10015 r0 *1 216.41,177.8
X$10015 428 3447 2202 2207 2112 395 DFF_X1
* cell instance $10017 r0 *1 219.83,177.8
X$10017 2208 428 395 3297 INV_X8
* cell instance $10018 r0 *1 221.54,177.8
X$10018 1276 428 395 2208 CLKBUF_X3
* cell instance $10019 r0 *1 222.49,177.8
X$10019 2069 2225 2093 428 395 2245 OR3_X1
* cell instance $10020 r0 *1 223.44,177.8
X$10020 2205 428 395 2226 INV_X1
* cell instance $10022 r0 *1 224.01,177.8
X$10022 428 3415 2205 2209 2208 395 DFF_X1
* cell instance $10027 m0 *1 219.64,180.6
X$10027 2189 2202 2205 2148 428 395 2225 NAND4_X1
* cell instance $10031 m0 *1 223.06,180.6
X$10031 2226 2200 2215 2210 395 428 2209 OAI22_X1
* cell instance $10034 r0 *1 227.62,177.8
X$10034 2228 428 395 2168 INV_X1
* cell instance $10036 r0 *1 229.33,177.8
X$10036 2214 2168 2211 2246 428 395 2213 OR4_X1
* cell instance $10038 r0 *1 230.47,177.8
X$10038 428 3421 2214 2204 2208 395 DFF_X1
* cell instance $10042 r0 *1 248.9,177.8
X$10042 2235 2210 2197 395 428 2216 HA_X1
* cell instance $10046 m0 *1 231.99,180.6
X$10046 2152 2214 2228 2231 395 428 2229 AND4_X1
* cell instance $10047 m0 *1 233.13,180.6
X$10047 2228 2214 2152 428 395 2230 NAND3_X1
* cell instance $10048 m0 *1 233.89,180.6
X$10048 2230 2211 428 395 2232 NOR2_X1
* cell instance $10052 m0 *1 235.79,180.6
X$10052 2215 2232 2200 395 2233 428 OAI21_X1
* cell instance $10054 m0 *1 236.74,180.6
X$10054 2233 2231 428 395 2250 NAND2_X1
* cell instance $10055 m0 *1 237.31,180.6
X$10055 2111 428 395 2243 INV_X1
* cell instance $10059 m0 *1 239.02,180.6
X$10059 2231 2232 395 428 2242 XNOR2_X1
* cell instance $10066 m0 *1 248.33,180.6
X$10066 2236 428 395 2340 BUF_X1
* cell instance $10069 m0 *1 250.61,180.6
X$10069 2196 428 395 2241 BUF_X1
* cell instance $10071 r0 *1 251.37,177.8
X$10071 2222 428 395 2218 BUF_X1
* cell instance $10073 r0 *1 251.94,177.8
X$10073 2219 428 395 LOGIC0_X1
* cell instance $10074 r0 *1 252.32,177.8
X$10074 2221 428 395 2240 BUF_X1
* cell instance $10075 r0 *1 252.89,177.8
X$10075 2219 428 395 2220 BUF_X1
* cell instance $10079 m0 *1 252.51,180.6
X$10079 2239 428 395 LOGIC0_X1
* cell instance $10080 m0 *1 252.89,180.6
X$10080 2239 428 395 2237 BUF_X1
* cell instance $10142 m0 *1 110.77,186.2
X$10142 1280 395 1009 428 BUF_X4
* cell instance $10183 r0 *1 207.48,183.4
X$10183 2269 1434 2113 428 395 NOR2_X4
* cell instance $10186 r0 *1 216.22,183.4
X$10186 2269 2031 428 395 2166 NAND2_X2
* cell instance $10189 r0 *1 220.97,183.4
X$10189 1514 2270 2293 428 2271 395 AOI21_X1
* cell instance $10193 m0 *1 215.46,186.2
X$10193 2269 428 395 2033 CLKBUF_X3
* cell instance $10196 m0 *1 220.21,186.2
X$10196 428 3332 2345 2271 2208 395 DFF_X1
* cell instance $10198 r0 *1 222.87,183.4
X$10198 2272 2245 428 395 2273 OR2_X2
* cell instance $10200 r0 *1 230.66,183.4
X$10200 2229 2274 2306 428 2272 395 NAND3_X4
* cell instance $10201 r0 *1 233.13,183.4
X$10201 2229 2274 428 395 2300 NAND2_X1
* cell instance $10203 m0 *1 223.44,186.2
X$10203 2303 2048 2273 428 395 2293 OR3_X1
* cell instance $10207 r0 *1 234.08,183.4
X$10207 2274 2248 395 428 2295 XNOR2_X1
* cell instance $10211 m0 *1 236.93,186.2
X$10211 2275 2203 428 395 2298 NAND2_X1
* cell instance $10212 m0 *1 237.5,186.2
X$10212 2305 2298 2318 395 2308 428 OAI21_X1
* cell instance $10216 m0 *1 239.59,186.2
X$10216 2305 2275 395 428 2292 XNOR2_X1
* cell instance $10221 m0 *1 242.44,186.2
X$10221 428 2316 2317 2095 2193 2296 395 NAND4_X4
* cell instance $10223 r0 *1 244.72,183.4
X$10223 2251 2294 395 428 2317 AND2_X1
* cell instance $10224 r0 *1 247,183.4
X$10224 2255 428 395 2288 BUF_X1
* cell instance $10226 r0 *1 249.09,183.4
X$10226 2256 428 395 2286 BUF_X1
* cell instance $10228 m0 *1 245.86,186.2
X$10228 2314 2292 2328 395 428 2330 HA_X1
* cell instance $10231 r0 *1 250.04,183.4
X$10231 2280 428 395 2059 BUF_X1
* cell instance $10233 r0 *1 251.18,183.4
X$10233 2285 428 395 LOGIC0_X1
* cell instance $10235 r0 *1 251.56,183.4
X$10235 2285 428 395 2281 BUF_X1
* cell instance $10238 m0 *1 251.75,186.2
X$10238 2310 428 395 2284 BUF_X1
* cell instance $10240 m0 *1 252.51,186.2
X$10240 2312 428 395 LOGIC0_X1
* cell instance $10241 r0 *1 252.89,183.4
X$10241 2282 428 395 2279 BUF_X1
* cell instance $10242 r0 *1 252.51,183.4
X$10242 2282 428 395 LOGIC0_X1
* cell instance $10244 m0 *1 252.89,186.2
X$10244 2312 428 395 2278 BUF_X1
* cell instance $10299 m0 *1 128.44,191.8
X$10299 428 3368 2372 2371 2466 395 DFF_X1
* cell instance $10302 m0 *1 134.9,191.8
X$10302 906 395 1832 428 BUF_X4
* cell instance $10303 m0 *1 136.23,191.8
X$10303 428 2391 1807 3301 2395 395 DFF_X2
* cell instance $10304 r0 *1 136.99,189
X$10304 906 395 1413 428 BUF_X4
* cell instance $10319 r0 *1 206.91,189
X$10319 2375 2367 2366 2031 1009 395 428 2365 OAI221_X1
* cell instance $10320 r0 *1 208.05,189
X$10320 2113 2296 428 395 2367 NAND2_X1
* cell instance $10323 m0 *1 140.03,191.8
X$10323 2390 2368 2373 428 395 2391 OR3_X1
* cell instance $10335 m0 *1 202.54,191.8
X$10335 428 2365 2247 3304 2374 395 DFF_X2
* cell instance $10339 m0 *1 208.81,191.8
X$10339 2352 2296 428 395 2373 NOR2_X2
* cell instance $10341 r0 *1 209,189
X$10341 2113 2296 2350 428 395 2366 NAND3_X1
* cell instance $10342 m0 *1 209.76,191.8
X$10342 2378 2375 2376 428 2393 395 AOI21_X1
* cell instance $10343 r0 *1 211.09,189
X$10343 2350 2033 428 395 2376 NOR2_X1
* cell instance $10344 r0 *1 210.14,189
X$10344 2246 428 395 2352 CLKBUF_X3
* cell instance $10345 r0 *1 211.66,189
X$10345 2246 2350 2138 2316 2368 395 428 AOI211_X2
* cell instance $10346 r0 *1 213.37,189
X$10346 2316 2138 428 395 2375 NAND2_X1
* cell instance $10348 r0 *1 214.13,189
X$10348 428 3440 2353 2351 2247 395 DFF_X1
* cell instance $10349 r0 *1 217.36,189
X$10349 2353 2370 2355 2354 428 395 2369 AOI22_X1
* cell instance $10350 r0 *1 218.31,189
X$10350 2215 2353 428 395 2354 NOR2_X1
* cell instance $10351 r0 *1 218.88,189
X$10351 2352 2355 2396 395 2370 428 OAI21_X1
* cell instance $10355 m0 *1 210.52,191.8
X$10355 2377 2379 1258 2296 2048 395 428 2378 OAI221_X1
* cell instance $10360 m0 *1 217.36,191.8
X$10360 2108 2269 428 395 2396 NAND2_X1
* cell instance $10361 m0 *1 217.93,191.8
X$10361 2353 2355 428 395 2388 XNOR2_X2
* cell instance $10365 r0 *1 226.86,189
X$10365 2352 2320 2396 395 2322 428 OAI21_X1
* cell instance $10370 m0 *1 230.28,191.8
X$10370 428 3367 2392 2356 2208 395 DFF_X1
* cell instance $10371 r0 *1 231.23,189
X$10371 2348 2357 428 395 2356 NAND2_X1
* cell instance $10373 r0 *1 231.8,189
X$10373 2358 2307 428 395 2357 NAND2_X1
* cell instance $10374 r0 *1 232.37,189
X$10374 2323 2215 2200 395 2358 428 OAI21_X1
* cell instance $10376 r0 *1 233.32,189
X$10376 2392 428 395 2307 BUF_X1
* cell instance $10379 r0 *1 234.84,189
X$10379 2307 2323 395 428 2364 XNOR2_X1
* cell instance $10383 r0 *1 244.34,189
X$10383 2325 2360 428 395 2359 NAND2_X1
* cell instance $10384 r0 *1 244.91,189
X$10384 2493 2364 2360 395 428 2342 HA_X1
* cell instance $10386 r0 *1 249.85,189
X$10386 2362 428 395 2253 BUF_X1
* cell instance $10387 r0 *1 250.42,189
X$10387 2382 428 395 2223 BUF_X1
* cell instance $10389 r0 *1 252.51,189
X$10389 2363 428 395 LOGIC0_X1
* cell instance $10390 r0 *1 252.89,189
X$10390 2363 428 395 2361 BUF_X1
* cell instance $10396 m0 *1 238.64,191.8
X$10396 2218 2388 2389 395 428 2380 HA_X1
* cell instance $10402 m0 *1 241.87,191.8
X$10402 428 2381 2414 2344 2359 2316 395 NOR4_X4
* cell instance $10404 m0 *1 251.37,191.8
X$10404 2387 428 395 LOGIC0_X1
* cell instance $10405 m0 *1 251.75,191.8
X$10405 2386 428 395 LOGIC0_X1
* cell instance $10406 m0 *1 252.13,191.8
X$10406 2387 428 395 2385 BUF_X1
* cell instance $10407 m0 *1 252.7,191.8
X$10407 2386 428 395 2383 BUF_X1
* cell instance $10481 r0 *1 139.27,141.4
X$10481 1276 428 395 1807 CLKBUF_X3
* cell instance $10482 r0 *1 137.56,141.4
X$10482 1807 428 395 3296 INV_X8
* cell instance $10502 r0 *1 251.18,141.4
X$10502 1926 428 395 LOGIC0_X1
* cell instance $10503 r0 *1 251.56,141.4
X$10503 1926 428 395 1935 BUF_X1
* cell instance $10536 m0 *1 250.23,144.2
X$10536 1941 428 395 LOGIC0_X1
* cell instance $10537 m0 *1 250.61,144.2
X$10537 1941 428 395 1932 BUF_X1
* cell instance $10539 m0 *1 251.37,144.2
X$10539 1940 428 395 LOGIC0_X1
* cell instance $10540 m0 *1 251.75,144.2
X$10540 1940 428 395 1937 BUF_X1
* cell instance $10541 m0 *1 252.32,144.2
X$10541 1938 428 395 LOGIC0_X1
* cell instance $10542 r0 *1 252.89,141.4
X$10542 1924 428 395 1918 BUF_X1
* cell instance $10543 r0 *1 252.51,141.4
X$10543 1924 428 395 LOGIC0_X1
* cell instance $10545 m0 *1 252.7,144.2
X$10545 1938 428 395 1923 BUF_X1
* cell instance $10559 r0 *1 49.21,231
X$10559 1280 395 1153 428 BUF_X4
* cell instance $10563 r0 *1 68.78,231
X$10563 2759 2873 2835 428 395 2896 NAND3_X1
* cell instance $10574 m0 *1 44.27,233.8
X$10574 428 1127 395 1280 BUF_X8
* cell instance $10579 m0 *1 62.13,233.8
X$10579 428 3406 2930 2895 2714 395 DFF_X1
* cell instance $10580 m0 *1 65.36,233.8
X$10580 1585 2905 395 428 2931 AND2_X1
* cell instance $10583 m0 *1 67.07,233.8
X$10583 2906 428 395 2835 BUF_X2
* cell instance $10584 m0 *1 67.83,233.8
X$10584 2871 2898 2896 395 2905 428 OAI21_X1
* cell instance $10585 m0 *1 68.59,233.8
X$10585 2897 1356 428 395 2895 NOR2_X1
* cell instance $10586 m0 *1 69.16,233.8
X$10586 2835 2908 428 395 2898 XNOR2_X2
* cell instance $10587 r0 *1 70.11,231
X$10587 2823 2803 2874 395 2908 428 NOR3_X2
* cell instance $10591 r0 *1 75.24,231
X$10591 428 3449 2912 2910 2714 395 DFF_X1
* cell instance $10594 r0 *1 85.31,231
X$10594 2877 2913 428 395 2899 XNOR2_X2
* cell instance $10597 m0 *1 71.06,233.8
X$10597 2759 2932 2804 395 2933 428 OAI21_X1
* cell instance $10601 m0 *1 76.76,233.8
X$10601 1153 2911 2937 428 2910 395 AOI21_X1
* cell instance $10602 m0 *1 77.52,233.8
X$10602 2871 2873 2939 428 395 2911 NAND3_X1
* cell instance $10603 m0 *1 78.28,233.8
X$10603 2912 428 395 2939 CLKBUF_X3
* cell instance $10606 m0 *1 82.65,233.8
X$10606 2688 2901 428 395 2804 NAND2_X2
* cell instance $10609 m0 *1 87.4,233.8
X$10609 428 3333 2878 2914 2714 395 DFF_X1
* cell instance $10611 r0 *1 88.35,231
X$10611 2877 2675 2899 2692 395 428 2914 OAI22_X1
* cell instance $10613 r0 *1 90.63,231
X$10613 2692 2876 2675 395 2900 428 OAI21_X1
* cell instance $10617 m0 *1 91.39,233.8
X$10617 2900 2894 428 395 2918 NAND2_X1
* cell instance $10618 r0 *1 91.96,231
X$10618 2879 2915 428 395 2893 XNOR2_X2
* cell instance $10620 r0 *1 93.86,231
X$10620 2879 2675 2692 2893 395 428 2890 OAI22_X1
* cell instance $10624 r0 *1 105.45,231
X$10624 2685 2921 2717 428 395 NOR2_X4
* cell instance $10625 r0 *1 107.16,231
X$10625 428 3429 2902 2883 2884 395 DFF_X1
* cell instance $10633 m0 *1 99.37,233.8
X$10633 1280 2901 2944 428 2919 395 AOI21_X1
* cell instance $10635 m0 *1 101.65,233.8
X$10635 2920 428 395 2944 INV_X1
* cell instance $10637 m0 *1 103.55,233.8
X$10637 2921 2920 1258 395 2945 428 OAI21_X1
* cell instance $10639 m0 *1 104.69,233.8
X$10639 2901 428 395 2873 CLKBUF_X3
* cell instance $10640 m0 *1 105.64,233.8
X$10640 2909 395 2685 428 BUF_X4
* cell instance $10641 m0 *1 106.97,233.8
X$10641 2922 2923 428 2688 395 NAND2_X4
* cell instance $10642 m0 *1 108.68,233.8
X$10642 2964 1356 428 395 2883 NOR2_X1
* cell instance $10643 m0 *1 109.25,233.8
X$10643 2923 2922 395 428 2909 AND2_X1
* cell instance $10644 m0 *1 110.01,233.8
X$10644 1413 2902 2963 395 428 2925 AND3_X1
* cell instance $10646 r0 *1 113.81,231
X$10646 2903 428 395 2886 INV_X1
* cell instance $10647 r0 *1 113.05,231
X$10647 2907 2885 1832 395 2903 428 OAI21_X1
* cell instance $10648 r0 *1 114.19,231
X$10648 428 3436 2904 2886 2884 395 DFF_X1
* cell instance $10654 m0 *1 116.66,233.8
X$10654 2904 428 395 2923 CLKBUF_X2
* cell instance $10657 m0 *1 118.37,233.8
X$10657 428 2961 2466 2935 2936 395 DFF_X2
* cell instance $10686 m0 *1 122.93,233.8
X$10686 2928 1258 428 395 2958 NAND2_X1
* cell instance $10731 r0 *1 15.96,133
X$10731 428 3418 1872 1879 753 395 DFF_X1
* cell instance $10741 m0 *1 17.86,135.8
X$10741 428 3384 1885 1884 753 395 DFF_X1
* cell instance $10743 r0 *1 20.33,133
X$10743 1872 395 1744 428 BUF_X4
* cell instance $10746 r0 *1 23.75,133
X$10746 428 3467 1896 1886 749 395 DFF_X1
* cell instance $10751 m0 *1 27.36,135.8
X$10751 428 3383 1888 1887 753 395 DFF_X1
* cell instance $10753 r0 *1 28.12,133
X$10753 1895 1356 428 395 1887 NOR2_X1
* cell instance $10765 m0 *1 39.52,135.8
X$10765 1117 428 395 3289 INV_X8
* cell instance $10766 r0 *1 39.9,133
X$10766 1276 428 395 725 CLKBUF_X3
* cell instance $10768 r0 *1 40.85,133
X$10768 725 428 395 INV_X4
* cell instance $10784 r0 *1 118.75,133
X$10784 1867 1889 1901 428 1890 395 AOI21_X1
* cell instance $10785 r0 *1 119.51,133
X$10785 1771 1702 1903 428 395 1901 NAND3_X1
* cell instance $10786 r0 *1 120.27,133
X$10786 1867 1902 1702 428 1874 395 AOI21_X1
* cell instance $10788 r0 *1 121.22,133
X$10788 1771 1891 428 395 1902 NAND2_X1
* cell instance $10792 m0 *1 41.23,135.8
X$10792 1276 428 395 1117 CLKBUF_X3
* cell instance $10810 m0 *1 119.7,135.8
X$10810 428 1874 1807 3300 1891 395 DFF_X2
* cell instance $10812 r0 *1 124.64,133
X$10812 1585 1788 395 428 2319 AND2_X1
* cell instance $10836 r0 *1 250.8,133
X$10836 1899 428 395 LOGIC0_X1
* cell instance $10869 m0 *1 251.37,135.8
X$10869 1898 428 395 LOGIC0_X1
* cell instance $10870 r0 *1 251.75,133
X$10870 1897 428 395 LOGIC0_X1
* cell instance $10872 r0 *1 252.13,133
X$10872 1897 428 395 1894 BUF_X1
* cell instance $10874 r0 *1 252.89,133
X$10874 1899 428 395 1875 BUF_X1
* cell instance $10877 m0 *1 251.94,135.8
X$10877 1900 428 395 LOGIC0_X1
* cell instance $10878 m0 *1 252.32,135.8
X$10878 1900 428 395 1907 BUF_X1
* cell instance $10879 m0 *1 252.89,135.8
X$10879 1898 428 395 1893 BUF_X1
* cell instance $10892 m0 *1 12.35,133
X$10892 1585 1851 395 428 1878 AND2_X1
* cell instance $10894 r0 *1 13.11,130.2
X$10894 1740 1148 1859 395 1851 428 OAI21_X1
* cell instance $10895 m0 *1 13.11,133
X$10895 428 1878 749 3310 1826 395 DFF_X2
* cell instance $10897 r0 *1 14.25,130.2
X$10897 1861 1826 395 1740 428 XOR2_X2
* cell instance $10898 r0 *1 16.72,130.2
X$10898 1826 1744 1827 1690 395 428 1860 AND4_X1
* cell instance $10899 r0 *1 17.86,130.2
X$10899 1821 1827 1744 428 395 1861 NAND3_X1
* cell instance $10903 m0 *1 18.62,133
X$10903 1862 1356 428 395 1884 NOR2_X1
* cell instance $10904 r0 *1 19.95,130.2
X$10904 1821 1339 1152 395 1852 428 OAI21_X1
* cell instance $10905 r0 *1 19,130.2
X$10905 1821 1863 1827 1852 428 395 1862 AOI22_X1
* cell instance $10906 r0 *1 20.71,130.2
X$10906 1156 1827 428 395 1863 NOR2_X1
* cell instance $10909 r0 *1 25.84,130.2
X$10909 1786 1853 1763 428 1403 395 NAND3_X4
* cell instance $10910 r0 *1 28.31,130.2
X$10910 1339 1799 1152 395 1880 428 OAI21_X1
* cell instance $10911 r0 *1 29.07,130.2
X$10911 1156 1853 428 395 1873 NOR2_X1
* cell instance $10919 m0 *1 20.71,133
X$10919 1885 395 1827 428 BUF_X4
* cell instance $10923 m0 *1 26.79,133
X$10923 1896 428 395 1786 BUF_X2
* cell instance $10925 m0 *1 27.74,133
X$10925 1799 1873 1853 1880 428 395 1895 AOI22_X1
* cell instance $10927 m0 *1 29.45,133
X$10927 1888 428 395 1853 BUF_X2
* cell instance $10935 r0 *1 51.11,130.2
X$10935 1867 1854 1804 428 1871 395 AOI21_X1
* cell instance $10936 r0 *1 50.54,130.2
X$10936 1768 1870 428 395 1854 NAND2_X1
* cell instance $10937 r0 *1 51.87,130.2
X$10937 428 1871 725 3318 1870 395 DFF_X2
* cell instance $10967 r0 *1 118.37,130.2
X$10967 428 1868 1866 1789 1869 395 NOR3_X4
* cell instance $10974 m0 *1 118.18,133
X$10974 1830 1788 428 395 1889 NOR2_X1
* cell instance $10978 m0 *1 120.08,133
X$10978 1507 428 395 3294 INV_X8
* cell instance $10979 m0 *1 121.79,133
X$10979 1276 428 395 1507 CLKBUF_X3
* cell instance $10983 r0 *1 140.03,130.2
X$10983 428 1833 1807 3325 1773 395 DFF_X2
* cell instance $10985 r0 *1 143.64,130.2
X$10985 428 3464 1811 1855 1807 395 DFF_X1
* cell instance $11005 r0 *1 251.18,130.2
X$11005 1865 428 395 LOGIC0_X1
* cell instance $11006 r0 *1 251.56,130.2
X$11006 1865 428 395 1857 BUF_X1
* cell instance $11007 r0 *1 252.13,130.2
X$11007 1864 428 395 LOGIC0_X1
* cell instance $11008 r0 *1 252.51,130.2
X$11008 1864 428 395 1856 BUF_X1
* cell instance $11042 m0 *1 250.23,133
X$11042 1883 428 395 LOGIC0_X1
* cell instance $11043 m0 *1 250.61,133
X$11043 1883 428 395 1858 BUF_X1
* cell instance $11045 m0 *1 251.37,133
X$11045 1882 428 395 LOGIC0_X1
* cell instance $11046 m0 *1 251.75,133
X$11046 1881 428 395 LOGIC0_X1
* cell instance $11047 m0 *1 252.13,133
X$11047 1882 428 395 1876 BUF_X1
* cell instance $11049 m0 *1 252.89,133
X$11049 1881 428 395 1877 BUF_X1
* cell instance $11080 m0 *1 42.37,214.2
X$11080 428 1280 395 1434 BUF_X8
* cell instance $11089 r0 *1 86.83,211.4
X$11089 428 3462 2630 2638 2644 395 DFF_X1
* cell instance $11100 m0 *1 89.68,214.2
X$11100 2630 428 395 2631 BUF_X2
* cell instance $11102 m0 *1 90.63,214.2
X$11102 428 3382 2647 2646 2644 395 DFF_X1
* cell instance $11105 m0 *1 95.76,214.2
X$11105 428 3407 2649 2648 2466 395 DFF_X1
* cell instance $11106 m0 *1 98.99,214.2
X$11106 428 3405 2651 2662 2466 395 DFF_X1
* cell instance $11109 m0 *1 102.79,214.2
X$11109 428 3342 2661 2653 2466 395 DFF_X1
* cell instance $11170 m0 *1 249.09,214.2
X$11170 2655 428 395 2234 BUF_X1
* cell instance $11172 r0 *1 251.18,211.4
X$11172 2642 428 395 2635 BUF_X1
* cell instance $11173 r0 *1 250.8,211.4
X$11173 2642 428 395 LOGIC0_X1
* cell instance $11174 r0 *1 251.75,211.4
X$11174 2640 428 395 LOGIC0_X1
* cell instance $11175 r0 *1 252.13,211.4
X$11175 2640 428 395 2633 BUF_X1
* cell instance $11177 r0 *1 252.89,211.4
X$11177 2632 428 395 2637 BUF_X1
* cell instance $11181 m0 *1 251.75,214.2
X$11181 2658 428 395 LOGIC0_X1
* cell instance $11183 m0 *1 252.32,214.2
X$11183 2658 428 395 2636 BUF_X1
* cell instance $11185 m0 *1 253.08,214.2
X$11185 2632 428 395 LOGIC0_X1
* cell instance $11200 r0 *1 71.25,219.8
X$11200 1867 2757 2772 428 2756 395 AOI21_X1
* cell instance $11220 m0 *1 71.44,222.6
X$11220 2773 2746 428 395 2772 NAND2_X1
* cell instance $11221 m0 *1 72.01,222.6
X$11221 2759 2758 2804 395 2773 428 OAI21_X1
* cell instance $11223 r0 *1 73.91,219.8
X$11223 2758 2685 2747 428 395 2757 NAND3_X1
* cell instance $11224 r0 *1 73.15,219.8
X$11224 1585 2802 395 428 2774 AND2_X1
* cell instance $11225 r0 *1 74.67,219.8
X$11225 2746 428 395 2747 INV_X1
* cell instance $11227 r0 *1 75.62,219.8
X$11227 2758 2746 2715 428 395 2686 NAND3_X2
* cell instance $11229 r0 *1 76.95,219.8
X$11229 2686 2687 395 2780 428 XOR2_X2
* cell instance $11230 r0 *1 78.66,219.8
X$11230 2748 2760 2716 2761 428 395 2781 AOI22_X1
* cell instance $11234 r0 *1 82.08,219.8
X$11234 2738 2747 428 395 2783 NOR2_X1
* cell instance $11236 r0 *1 85.69,219.8
X$11236 2758 2750 2749 2783 428 2739 395 NAND4_X2
* cell instance $11239 m0 *1 76.19,222.6
X$11239 2715 2687 428 395 2777 NAND2_X1
* cell instance $11240 m0 *1 76.76,222.6
X$11240 2795 2777 428 395 2748 NOR2_X2
* cell instance $11243 m0 *1 78.28,222.6
X$11243 2759 2716 428 395 2760 NOR2_X1
* cell instance $11244 m0 *1 78.85,222.6
X$11244 2748 2759 2804 395 2761 428 OAI21_X1
* cell instance $11246 m0 *1 79.99,222.6
X$11246 2716 2748 428 395 2782 XNOR2_X2
* cell instance $11251 r0 *1 91.2,219.8
X$11251 2749 428 395 2762 INV_X1
* cell instance $11252 r0 *1 87.78,219.8
X$11252 428 2750 2787 2690 2749 2694 395 NAND4_X4
* cell instance $11253 r0 *1 91.58,219.8
X$11253 2762 2789 2763 395 2718 428 OAI21_X1
* cell instance $11255 r0 *1 92.53,219.8
X$11255 1258 2717 2764 2670 428 395 2789 AOI22_X1
* cell instance $11259 r0 *1 95.95,219.8
X$11259 2749 2690 428 395 2752 NAND2_X1
* cell instance $11260 r0 *1 96.52,219.8
X$11260 2690 2749 395 428 2765 AND2_X1
* cell instance $11264 m0 *1 88.73,222.6
X$11264 2739 2690 395 2785 428 XOR2_X2
* cell instance $11267 m0 *1 91.01,222.6
X$11267 2670 2788 2750 2762 428 395 2763 NAND4_X1
* cell instance $11269 m0 *1 92.15,222.6
X$11269 2762 2764 428 395 2880 XNOR2_X2
* cell instance $11272 m0 *1 97.28,222.6
X$11272 428 2794 2738 2795 2790 2674 395 NOR4_X4
* cell instance $11273 r0 *1 100.89,219.8
X$11273 2765 2751 428 395 2790 NAND2_X1
* cell instance $11274 r0 *1 99.18,219.8
X$11274 2751 2650 2676 2765 428 2796 395 NAND4_X2
* cell instance $11276 m0 *1 100.7,222.6
X$11276 2650 2674 428 395 2784 XNOR2_X2
* cell instance $11278 r0 *1 101.84,219.8
X$11278 2751 2650 2676 2652 428 395 2766 NAND4_X1
* cell instance $11285 m0 *1 106.97,222.6
X$11285 2723 2753 428 395 2791 XNOR2_X2
* cell instance $11286 r0 *1 107.16,219.8
X$11286 2764 2752 428 395 2753 NOR2_X1
* cell instance $11288 r0 *1 107.73,219.8
X$11288 2752 2764 2670 395 2754 428 OAI21_X1
* cell instance $11295 m0 *1 109.44,222.6
X$11295 2723 2724 428 395 2767 NAND2_X1
* cell instance $11297 m0 *1 110.2,222.6
X$11297 2800 2786 2724 2723 395 428 2751 AND4_X2
* cell instance $11299 m0 *1 111.91,222.6
X$11299 2723 2724 2786 428 395 2797 NAND3_X1
* cell instance $11303 r0 *1 119.51,219.8
X$11303 1276 428 395 2466 CLKBUF_X3
* cell instance $11306 r0 *1 121.22,219.8
X$11306 2466 428 395 INV_X4
* cell instance $11329 r0 *1 250.04,219.8
X$11329 2769 428 395 2115 BUF_X1
* cell instance $11331 r0 *1 251.37,219.8
X$11331 2779 428 395 LOGIC0_X1
* cell instance $11332 r0 *1 251.75,219.8
X$11332 2779 428 395 2755 BUF_X1
* cell instance $11333 r0 *1 252.32,219.8
X$11333 2776 428 395 LOGIC0_X1
* cell instance $11335 r0 *1 252.89,219.8
X$11335 2776 428 395 2770 BUF_X1
* cell instance $11367 m0 *1 250.8,222.6
X$11367 2798 428 395 2477 BUF_X1
* cell instance $11368 m0 *1 251.37,222.6
X$11368 2778 428 395 LOGIC0_X1
* cell instance $11370 m0 *1 251.94,222.6
X$11370 2778 428 395 2771 BUF_X1
* cell instance $11371 m0 *1 252.51,222.6
X$11371 2775 428 395 LOGIC0_X1
* cell instance $11372 m0 *1 252.89,222.6
X$11372 2775 428 395 2768 BUF_X1
* cell instance $11383 r0 *1 44.65,208.6
X$11383 1292 428 395 1434 INV_X8
* cell instance $11472 r0 *1 234.08,208.6
X$11472 2599 428 395 2475 BUF_X2
* cell instance $11482 r0 *1 250.8,208.6
X$11482 2627 428 395 LOGIC0_X1
* cell instance $11483 r0 *1 250.42,208.6
X$11483 2615 428 395 LOGIC0_X1
* cell instance $11484 r0 *1 251.18,208.6
X$11484 2627 428 395 2604 BUF_X1
* cell instance $11485 r0 *1 251.75,208.6
X$11485 2626 428 395 LOGIC0_X1
* cell instance $11486 r0 *1 252.13,208.6
X$11486 2626 428 395 2611 BUF_X1
* cell instance $11488 r0 *1 252.89,208.6
X$11488 2615 428 395 2609 BUF_X1
* cell instance $11491 m0 *1 251.18,211.4
X$11491 2639 428 395 LOGIC0_X1
* cell instance $11493 m0 *1 251.75,211.4
X$11493 2639 428 395 2603 BUF_X1
* cell instance $11494 m0 *1 252.32,211.4
X$11494 2641 428 395 LOGIC0_X1
* cell instance $11495 m0 *1 252.7,211.4
X$11495 2641 428 395 2634 BUF_X1
* cell instance $11520 r0 *1 119.13,194.6
X$11520 2426 2465 428 395 2425 NAND2_X1
* cell instance $11521 r0 *1 119.7,194.6
X$11521 1867 2425 2427 428 2456 395 AOI21_X1
* cell instance $11552 m0 *1 115.14,197.4
X$11552 428 3395 2465 2456 2466 395 DFF_X1
* cell instance $11553 m0 *1 118.37,197.4
X$11553 428 3389 2467 2486 2466 395 DFF_X1
* cell instance $11556 r0 *1 121.22,194.6
X$11556 2426 2427 2467 428 395 2468 NAND3_X1
* cell instance $11558 r0 *1 122.74,194.6
X$11558 428 1868 2459 2457 2427 395 AOI21_X4
* cell instance $11559 r0 *1 125.21,194.6
X$11559 2458 428 395 2469 INV_X1
* cell instance $11560 r0 *1 125.59,194.6
X$11560 2428 2374 428 395 2488 NOR2_X1
* cell instance $11561 r0 *1 126.16,194.6
X$11561 2429 2428 2108 428 2458 395 AOI21_X1
* cell instance $11564 r0 *1 127.87,194.6
X$11564 2379 2409 428 395 2459 NAND2_X1
* cell instance $11568 m0 *1 121.6,197.4
X$11568 1867 2488 2468 428 2486 395 AOI21_X1
* cell instance $11569 m0 *1 122.36,197.4
X$11569 2490 428 395 2409 BUF_X2
* cell instance $11571 m0 *1 124.64,197.4
X$11571 428 2469 2466 3302 2460 395 DFF_X2
* cell instance $11574 r0 *1 132.62,194.6
X$11574 2495 2431 428 395 2427 NOR2_X2
* cell instance $11576 r0 *1 134.52,194.6
X$11576 2462 2495 1832 395 2470 428 OAI21_X1
* cell instance $11577 r0 *1 135.28,194.6
X$11577 2377 2432 2430 428 395 2462 NOR3_X1
* cell instance $11594 m0 *1 135.09,197.4
X$11594 2470 428 395 2498 INV_X1
* cell instance $11599 m0 *1 138.32,197.4
X$11599 2471 428 395 2431 CLKBUF_X3
* cell instance $11620 m0 *1 214.13,197.4
X$11620 428 3356 2503 2502 2247 395 DFF_X1
* cell instance $11621 r0 *1 216.41,194.6
X$11621 2464 2433 428 395 2502 NAND2_X1
* cell instance $11623 r0 *1 216.98,194.6
X$11623 2501 2503 428 395 2433 NAND2_X1
* cell instance $11624 r0 *1 217.55,194.6
X$11624 2215 2434 2200 395 2501 428 OAI21_X1
* cell instance $11625 r0 *1 218.31,194.6
X$11625 2503 428 395 2435 INV_X1
* cell instance $11627 r0 *1 218.88,194.6
X$11627 2434 2203 2435 428 395 2464 NAND3_X1
* cell instance $11628 r0 *1 219.64,194.6
X$11628 2170 2272 2421 2413 395 2434 428 NOR4_X2
* cell instance $11633 m0 *1 217.74,197.4
X$11633 2503 2434 395 428 2472 XNOR2_X1
* cell instance $11636 m0 *1 219.45,197.4
X$11636 2505 2472 2437 395 428 2506 HA_X1
* cell instance $11637 m0 *1 221.35,197.4
X$11637 2506 2437 2473 428 2507 395 AOI21_X1
* cell instance $11640 r0 *1 224.01,194.6
X$11640 2436 2437 2463 428 395 2508 NAND3_X1
* cell instance $11641 r0 *1 225.34,194.6
X$11641 2273 2352 2421 428 395 2438 NOR3_X1
* cell instance $11643 r0 *1 226.1,194.6
X$11643 2438 2441 2439 428 395 2509 MUX2_X1
* cell instance $11646 m0 *1 225.34,197.4
X$11646 428 3403 2511 2509 2247 395 DFF_X1
* cell instance $11647 r0 *1 228,194.6
X$11647 2441 2440 395 428 2492 XNOR2_X1
* cell instance $11652 m0 *1 228.57,197.4
X$11652 2511 428 395 2441 BUF_X2
* cell instance $11654 r0 *1 231.99,194.6
X$11654 2108 2444 428 395 2512 NAND2_X1
* cell instance $11656 r0 *1 232.56,194.6
X$11656 2273 2048 2442 428 395 2443 NOR3_X1
* cell instance $11657 r0 *1 233.32,194.6
X$11657 2512 2443 2215 2445 395 428 2474 OAI22_X1
* cell instance $11659 r0 *1 235.03,194.6
X$11659 2273 2442 428 395 2510 NOR2_X1
* cell instance $11662 m0 *1 233.13,197.4
X$11662 428 2474 2208 3305 2444 395 DFF_X2
* cell instance $11663 r0 *1 236.17,194.6
X$11663 2444 2510 428 395 2445 XNOR2_X2
* cell instance $11666 r0 *1 241.11,194.6
X$11666 2476 2447 2446 2504 428 2414 395 NAND4_X2
* cell instance $11667 r0 *1 242.82,194.6
X$11667 2025 2499 2447 395 428 2416 HA_X1
* cell instance $11668 r0 *1 244.72,194.6
X$11668 2496 428 395 2497 INV_X1
* cell instance $11675 m0 *1 241.3,197.4
X$11675 2446 2476 395 428 2500 AND2_X1
* cell instance $11678 m0 *1 242.63,197.4
X$11678 2500 2497 2478 2446 2494 2448 395 428 AOI221_X2
* cell instance $11681 r0 *1 245.48,194.6
X$11681 2217 2492 2480 395 428 2481 HA_X1
* cell instance $11683 m0 *1 247,197.4
X$11683 2481 428 395 2542 INV_X1
* cell instance $11685 r0 *1 247.95,194.6
X$11685 2452 428 395 2081 BUF_X1
* cell instance $11689 r0 *1 249.47,194.6
X$11689 2491 428 395 LOGIC0_X1
* cell instance $11692 r0 *1 250.8,194.6
X$11692 2491 428 395 2483 BUF_X1
* cell instance $11695 r0 *1 252.13,194.6
X$11695 2487 428 395 2484 BUF_X1
* cell instance $11696 r0 *1 251.75,194.6
X$11696 2487 428 395 LOGIC0_X1
* cell instance $11701 m0 *1 252.51,197.4
X$11701 2489 428 395 LOGIC0_X1
* cell instance $11702 m0 *1 252.89,197.4
X$11702 2489 428 395 2485 BUF_X1
* cell instance $11778 r0 *1 251.18,144.2
X$11778 1942 428 395 LOGIC0_X1
* cell instance $11779 r0 *1 251.56,144.2
X$11779 1942 428 395 1934 BUF_X1
* cell instance $11780 r0 *1 252.13,144.2
X$11780 1939 428 395 LOGIC0_X1
* cell instance $11782 r0 *1 252.7,144.2
X$11782 1939 428 395 1936 BUF_X1
* cell instance $11819 m0 *1 250.23,147
X$11819 1955 428 395 LOGIC0_X1
* cell instance $11820 m0 *1 250.61,147
X$11820 1955 428 395 1933 BUF_X1
* cell instance $11821 m0 *1 251.18,147
X$11821 1953 428 395 LOGIC0_X1
* cell instance $11823 m0 *1 251.94,147
X$11823 1943 428 395 LOGIC0_X1
* cell instance $11824 m0 *1 252.32,147
X$11824 1953 428 395 1946 BUF_X1
* cell instance $11825 m0 *1 252.89,147
X$11825 1943 428 395 1931 BUF_X1
* cell instance $11842 r0 *1 76,217
X$11842 2685 2686 395 428 2732 AND2_X1
* cell instance $11843 r0 *1 76.76,217
X$11843 2732 2717 2687 395 2664 428 OAI21_X1
* cell instance $11858 m0 *1 68.21,219.8
X$11858 428 3349 2729 2756 2714 395 DFF_X1
* cell instance $11859 m0 *1 71.44,219.8
X$11859 2729 428 395 2746 BUF_X2
* cell instance $11860 m0 *1 72.2,219.8
X$11860 428 3378 2731 2774 2714 395 DFF_X1
* cell instance $11861 m0 *1 75.43,219.8
X$11861 2731 428 395 2715 CLKBUF_X3
* cell instance $11864 m0 *1 77.52,219.8
X$11864 2687 2716 2715 428 2738 395 NAND3_X4
* cell instance $11865 r0 *1 79.61,217
X$11865 2781 1356 428 395 2665 NOR2_X1
* cell instance $11869 r0 *1 80.75,217
X$11869 2708 428 395 2716 BUF_X2
* cell instance $11873 r0 *1 84.74,217
X$11873 1280 2690 2688 2739 428 395 2689 OR4_X1
* cell instance $11874 r0 *1 85.88,217
X$11874 2717 2685 2739 428 2709 395 AOI21_X1
* cell instance $11883 m0 *1 91.39,219.8
X$11883 428 3363 2742 2718 2644 395 DFF_X1
* cell instance $11884 m0 *1 94.62,219.8
X$11884 2742 428 395 2749 BUF_X2
* cell instance $11886 r0 *1 98.61,217
X$11886 2685 1292 428 395 2693 NAND2_X1
* cell instance $11888 r0 *1 99.18,217
X$11888 2693 428 395 2692 CLKBUF_X3
* cell instance $11889 r0 *1 100.13,217
X$11889 2694 2693 2743 428 395 2695 NOR3_X1
* cell instance $11890 r0 *1 100.89,217
X$11890 2693 428 395 2696 CLKBUF_X3
* cell instance $11891 r0 *1 101.84,217
X$11891 2696 2719 2720 395 2697 428 OAI21_X1
* cell instance $11896 r0 *1 108.11,217
X$11896 2698 1258 2717 428 2722 395 AOI21_X1
* cell instance $11901 m0 *1 99.75,219.8
X$11901 2751 2650 428 395 2743 NAND2_X1
* cell instance $11902 m0 *1 100.32,219.8
X$11902 2676 2719 428 395 2744 XNOR2_X2
* cell instance $11903 m0 *1 102.22,219.8
X$11903 2694 2743 428 395 2719 NOR2_X1
* cell instance $11905 m0 *1 103.55,219.8
X$11905 2717 1292 428 395 2720 NAND2_X2
* cell instance $11910 m0 *1 107.35,219.8
X$11910 2723 2670 2753 428 2745 395 AOI21_X1
* cell instance $11911 m0 *1 108.11,219.8
X$11911 2745 2754 2722 428 2721 395 AOI21_X1
* cell instance $11913 r0 *1 109.44,217
X$11913 2723 428 395 2698 INV_X1
* cell instance $11915 r0 *1 109.82,217
X$11915 2699 428 395 2723 BUF_X2
* cell instance $11917 r0 *1 110.77,217
X$11917 2694 2698 428 395 2707 NOR2_X1
* cell instance $11918 r0 *1 111.34,217
X$11918 2694 2696 2698 428 395 2700 NOR3_X1
* cell instance $11919 r0 *1 112.1,217
X$11919 2700 2724 2679 428 395 2741 MUX2_X1
* cell instance $11920 r0 *1 113.43,217
X$11920 428 3451 2737 2741 2466 395 DFF_X1
* cell instance $11921 r0 *1 116.66,217
X$11921 2737 428 395 2724 CLKBUF_X2
* cell instance $11926 m0 *1 110.2,219.8
X$11926 2720 428 395 2675 CLKBUF_X3
* cell instance $11927 m0 *1 111.15,219.8
X$11927 2724 2707 428 395 2740 XNOR2_X2
* cell instance $11979 m0 *1 249.66,219.8
X$11979 2725 428 395 2736 BUF_X1
* cell instance $11982 m0 *1 250.8,219.8
X$11982 2735 428 395 LOGIC0_X1
* cell instance $11983 r0 *1 250.99,217
X$11983 2733 428 395 2701 BUF_X1
* cell instance $11985 r0 *1 251.56,217
X$11985 2733 428 395 LOGIC0_X1
* cell instance $11987 m0 *1 251.18,219.8
X$11987 2735 428 395 2727 BUF_X1
* cell instance $11989 m0 *1 252.13,219.8
X$11989 2734 428 395 LOGIC0_X1
* cell instance $11990 r0 *1 252.51,217
X$11990 2730 428 395 LOGIC0_X1
* cell instance $11992 r0 *1 252.89,217
X$11992 2730 428 395 2728 BUF_X1
* cell instance $11994 m0 *1 252.51,219.8
X$11994 2734 428 395 2726 BUF_X1
* cell instance $12101 r0 *1 220.59,205.8
X$12101 428 3466 2619 2620 2112 395 DFF_X1
* cell instance $12103 r0 *1 223.82,205.8
X$12103 2619 428 395 2517 CLKBUF_X2
* cell instance $12109 r0 *1 227.24,205.8
X$12109 428 2621 2247 3316 2567 395 DFF_X2
* cell instance $12110 r0 *1 232.37,205.8
X$12110 2475 2598 2623 395 2597 428 OAI21_X1
* cell instance $12116 m0 *1 231.42,208.6
X$12116 428 3345 2599 2597 2247 395 DFF_X1
* cell instance $12117 r0 *1 235.03,205.8
X$12117 2587 2624 2625 395 2601 428 OAI21_X1
* cell instance $12118 r0 *1 234.27,205.8
X$12118 2600 2192 2587 395 2625 428 OAI21_X1
* cell instance $12123 m0 *1 234.65,208.6
X$12123 428 2601 2247 3303 2587 395 DFF_X2
* cell instance $12134 m0 *1 250.23,208.6
X$12134 2628 428 395 LOGIC0_X1
* cell instance $12135 m0 *1 250.61,208.6
X$12135 2628 428 395 2602 BUF_X1
* cell instance $12137 r0 *1 251.56,205.8
X$12137 2606 428 395 2493 BUF_X1
* cell instance $12140 r0 *1 252.32,205.8
X$12140 2613 428 395 LOGIC0_X1
* cell instance $12141 r0 *1 252.7,205.8
X$12141 2613 428 395 2610 BUF_X1
* cell instance $12144 m0 *1 251.37,208.6
X$12144 2616 428 395 LOGIC0_X1
* cell instance $12145 m0 *1 251.75,208.6
X$12145 2616 428 395 2607 BUF_X1
* cell instance $12146 m0 *1 252.32,208.6
X$12146 2614 428 395 LOGIC0_X1
* cell instance $12148 m0 *1 252.89,208.6
X$12148 2614 428 395 2608 BUF_X1
* cell instance $12179 r0 *1 75.62,214.2
X$12179 428 3428 2705 2643 2644 395 DFF_X1
* cell instance $12183 r0 *1 83.41,214.2
X$12183 428 3460 2667 2666 2644 395 DFF_X1
* cell instance $12186 r0 *1 89.87,214.2
X$12186 2631 2668 2645 395 2638 428 OAI21_X1
* cell instance $12187 r0 *1 90.63,214.2
X$12187 2669 2631 428 395 2645 NAND2_X1
* cell instance $12189 m0 *1 75.81,217
X$12189 1153 2706 2664 428 2643 395 AOI21_X1
* cell instance $12190 m0 *1 76.57,217
X$12190 2687 2688 2686 428 395 2706 OR3_X1
* cell instance $12193 m0 *1 78.66,217
X$12193 2705 428 395 2687 BUF_X2
* cell instance $12194 m0 *1 79.42,217
X$12194 428 3370 2708 2665 2644 395 DFF_X1
* cell instance $12198 m0 *1 84.74,217
X$12198 2709 2710 2689 395 2666 428 OAI21_X1
* cell instance $12199 m0 *1 85.5,217
X$12199 2690 1258 428 395 2710 NAND2_X1
* cell instance $12201 m0 *1 86.26,217
X$12201 2667 428 395 2690 BUF_X2
* cell instance $12203 m0 *1 90.06,217
X$12203 2692 2691 2675 395 2669 428 OAI21_X1
* cell instance $12204 m0 *1 90.82,217
X$12204 2691 2670 428 395 2668 NAND2_X1
* cell instance $12206 m0 *1 91.58,217
X$12206 2711 2713 2672 2684 428 395 2671 AOI22_X1
* cell instance $12207 r0 *1 91.77,214.2
X$12207 2671 428 395 2646 INV_X1
* cell instance $12211 m0 *1 92.53,217
X$12211 2711 2692 2675 395 2684 428 OAI21_X1
* cell instance $12213 r0 *1 93.29,214.2
X$12213 2647 428 395 2672 BUF_X2
* cell instance $12215 m0 *1 93.29,217
X$12215 2696 2672 428 395 2713 NOR2_X1
* cell instance $12218 r0 *1 97.66,214.2
X$12218 2650 2673 2663 395 2648 428 OAI21_X1
* cell instance $12223 m0 *1 98.23,217
X$12223 2670 2674 428 395 2673 NAND2_X1
* cell instance $12224 m0 *1 98.8,217
X$12224 2674 2692 2675 395 2683 428 OAI21_X1
* cell instance $12225 r0 *1 98.99,214.2
X$12225 2683 2650 428 395 2663 NAND2_X1
* cell instance $12229 r0 *1 100.13,214.2
X$12229 2649 428 395 2650 BUF_X2
* cell instance $12233 m0 *1 100.7,217
X$12233 2695 2676 2697 428 395 2662 MUX2_X1
* cell instance $12234 r0 *1 101.46,214.2
X$12234 2651 428 395 2676 CLKBUF_X2
* cell instance $12238 r0 *1 103.17,214.2
X$12238 2677 2652 2654 428 395 2653 MUX2_X1
* cell instance $12239 r0 *1 104.5,214.2
X$12239 2661 428 395 2652 CLKBUF_X2
* cell instance $12246 m0 *1 102.6,217
X$12246 2712 2678 395 428 2677 AND2_X1
* cell instance $12247 m0 *1 103.36,217
X$12247 2712 2696 2720 395 2654 428 OAI21_X1
* cell instance $12248 m0 *1 104.12,217
X$12248 2688 1434 428 395 2678 NOR2_X1
* cell instance $12249 m0 *1 104.69,217
X$12249 2678 428 395 2670 CLKBUF_X3
* cell instance $12253 m0 *1 106.97,217
X$12253 428 3339 2699 2721 2466 395 DFF_X1
* cell instance $12257 m0 *1 111.53,217
X$12257 2696 2707 2675 395 2679 428 OAI21_X1
* cell instance $12336 r0 *1 68.4,242.2
X$12336 3022 2898 3038 395 428 3037 HA_X1
* cell instance $12337 r0 *1 70.3,242.2
X$12337 3005 3037 3023 428 3081 395 AOI21_X1
* cell instance $12339 r0 *1 71.25,242.2
X$12339 3038 3039 3024 3023 428 3062 395 NAND4_X2
* cell instance $12340 r0 *1 72.96,242.2
X$12340 3039 3024 428 395 3056 NAND2_X1
* cell instance $12341 r0 *1 73.53,242.2
X$12341 3123 2855 3024 395 428 3064 HA_X1
* cell instance $12345 r0 *1 89.11,242.2
X$12345 3120 3042 3045 395 428 3044 HA_X1
* cell instance $12346 r0 *1 91.01,242.2
X$12346 3045 3026 428 395 3069 NAND2_X1
* cell instance $12347 r0 *1 91.58,242.2
X$12347 3028 3044 3026 428 3047 395 AOI21_X1
* cell instance $12362 m0 *1 71.25,245
X$12362 3072 2970 3039 395 428 3063 HA_X1
* cell instance $12363 m0 *1 73.15,245
X$12363 3064 3024 3063 428 3082 395 AOI21_X1
* cell instance $12369 m0 *1 84.36,245
X$12369 3086 2971 3066 395 428 3057 HA_X1
* cell instance $12370 m0 *1 86.26,245
X$12370 3067 428 395 3087 INV_X1
* cell instance $12371 m0 *1 86.64,245
X$12371 3058 3065 3067 395 428 3088 HA_X1
* cell instance $12374 r0 *1 92.91,242.2
X$12374 3047 3030 3031 395 3092 428 OAI21_X1
* cell instance $12378 r0 *1 99.94,242.2
X$12378 428 3425 3011 3054 2884 395 DFF_X1
* cell instance $12382 r0 *1 115.52,242.2
X$12382 1576 2936 395 428 3068 AND2_X1
* cell instance $12388 m0 *1 93.1,245
X$12388 3069 3030 3059 395 3077 428 NOR3_X2
* cell instance $12391 m0 *1 97.85,245
X$12391 3060 3071 428 395 2951 NAND2_X2
* cell instance $12392 m0 *1 98.8,245
X$12392 3095 3071 428 395 3009 NAND2_X1
* cell instance $12395 m0 *1 105.64,245
X$12395 1576 2975 395 428 3061 AND2_X1
* cell instance $12397 m0 *1 107.16,245
X$12397 2990 2983 395 428 3070 AND2_X1
* cell instance $12398 m0 *1 107.92,245
X$12398 3033 3070 1576 395 3090 428 OAI21_X1
* cell instance $12402 m0 *1 110.01,245
X$12402 3079 428 395 2974 CLKBUF_X2
* cell instance $12406 m0 *1 120.65,245
X$12406 1576 2959 395 428 3206 AND2_X1
* cell instance $12407 m0 *1 121.41,245
X$12407 1576 3034 395 428 3111 AND2_X1
* cell instance $12408 r0 *1 121.79,242.2
X$12408 2959 3034 2936 428 395 3049 NAND3_X1
* cell instance $12410 r0 *1 122.55,242.2
X$12410 3035 3049 428 395 3041 XOR2_X1
* cell instance $12434 m0 *1 122.17,245
X$12434 1576 3035 395 428 3080 AND2_X1
* cell instance $12489 r0 *1 70.49,247.8
X$12489 3174 3121 3096 395 428 3145 HA_X1
* cell instance $12490 r0 *1 72.39,247.8
X$12490 3122 3136 3139 395 428 3124 HA_X1
* cell instance $12492 r0 *1 75.05,247.8
X$12492 3139 3096 3097 3125 428 3074 395 NAND4_X2
* cell instance $12493 r0 *1 76.76,247.8
X$12493 3096 3097 428 395 3146 NAND2_X1
* cell instance $12512 m0 *1 72.39,250.6
X$12512 3186 2854 3097 395 428 3160 HA_X1
* cell instance $12513 m0 *1 74.29,250.6
X$12513 3160 3097 3145 428 3161 395 AOI21_X1
* cell instance $12514 m0 *1 75.05,250.6
X$12514 3175 3124 3125 428 3163 395 AOI21_X1
* cell instance $12516 m0 *1 76,250.6
X$12516 3161 3163 3146 395 428 3126 OAI21_X2
* cell instance $12519 m0 *1 79.04,250.6
X$12519 3176 2780 3165 395 428 3150 HA_X1
* cell instance $12521 r0 *1 79.99,247.8
X$12521 3165 3148 3127 3147 428 3073 395 NAND4_X2
* cell instance $12522 m0 *1 80.94,250.6
X$12522 3147 3148 3150 428 395 3149 NAND3_X1
* cell instance $12525 r0 *1 82.08,247.8
X$12525 3142 3127 3151 428 3116 395 AOI21_X2
* cell instance $12527 m0 *1 82.65,250.6
X$12527 3166 2875 3148 395 428 3167 HA_X1
* cell instance $12529 r0 *1 83.79,247.8
X$12529 3190 2899 3127 395 428 3142 HA_X1
* cell instance $12535 r0 *1 90.06,247.8
X$12535 3152 2852 3144 395 428 3128 HA_X1
* cell instance $12540 m0 *1 90.44,250.6
X$12540 3178 2880 3153 395 428 3194 HA_X1
* cell instance $12541 r0 *1 92.53,247.8
X$12541 3154 2785 3102 395 428 3129 HA_X1
* cell instance $12545 r0 *1 97.66,247.8
X$12545 3078 3171 3106 3104 428 395 3071 AOI22_X2
* cell instance $12547 r0 *1 99.56,247.8
X$12547 3130 3156 428 395 3105 NAND2_X1
* cell instance $12548 r0 *1 100.13,247.8
X$12548 3105 3201 3131 395 3091 428 OAI21_X1
* cell instance $12549 r0 *1 100.89,247.8
X$12549 3143 2850 3130 395 428 3173 HA_X1
* cell instance $12550 r0 *1 102.79,247.8
X$12550 3141 2882 3156 395 428 3157 HA_X1
* cell instance $12555 m0 *1 92.53,250.6
X$12555 3144 3102 3155 3153 428 3059 395 NAND4_X2
* cell instance $12556 m0 *1 94.24,250.6
X$12556 3169 3155 3129 428 3197 395 AOI21_X1
* cell instance $12557 m0 *1 95,250.6
X$12557 3170 2791 3155 395 428 3169 HA_X1
* cell instance $12560 m0 *1 99.18,250.6
X$12560 3180 3130 3156 3172 428 3103 395 NAND4_X2
* cell instance $12562 m0 *1 101.08,250.6
X$12562 3199 2881 3172 395 428 3182 HA_X1
* cell instance $12563 m0 *1 102.98,250.6
X$12563 3157 3156 3173 428 3131 395 AOI21_X1
* cell instance $12566 m0 *1 104.88,250.6
X$12566 3168 428 395 2990 CLKBUF_X2
* cell instance $12568 m0 *1 111.72,250.6
X$12568 3132 3158 3134 3108 428 3118 395 NAND4_X2
* cell instance $12569 r0 *1 112.1,247.8
X$12569 3137 3140 3108 428 3109 395 AOI21_X1
* cell instance $12572 r0 *1 113.05,247.8
X$12572 3133 2740 3132 395 428 3140 HA_X1
* cell instance $12573 r0 *1 114.95,247.8
X$12573 3158 3134 428 395 3110 NAND2_X1
* cell instance $12603 m0 *1 113.43,250.6
X$12603 3109 3110 3162 395 3106 428 OAI21_X1
* cell instance $12605 m0 *1 114.38,250.6
X$12605 3159 2784 3134 395 428 3164 HA_X1
* cell instance $12606 m0 *1 116.28,250.6
X$12606 3164 3134 3184 428 3162 395 AOI21_X1
* cell instance $12607 m0 *1 117.04,250.6
X$12607 428 3338 3204 2998 2884 395 DFF_X1
* cell instance $12608 m0 *1 120.27,250.6
X$12608 428 3372 3202 3080 2884 395 DFF_X1
* cell instance $12610 m0 *1 124.26,250.6
X$12610 428 3360 3185 2319 2884 395 DFF_X1
* cell instance $12661 r0 *1 65.36,239.4
X$12661 1585 2995 395 428 3003 AND2_X1
* cell instance $12664 r0 *1 67.83,239.4
X$12664 3004 428 395 2977 BUF_X2
* cell instance $12666 r0 *1 68.78,239.4
X$12666 1994 2872 3023 395 428 3005 HA_X1
* cell instance $12683 m0 *1 64.41,242.2
X$12683 428 3401 3004 3003 2714 395 DFF_X1
* cell instance $12688 m0 *1 77.33,242.2
X$12688 428 3379 3040 3025 2714 395 DFF_X1
* cell instance $12689 r0 *1 78.09,239.4
X$12689 1585 3015 395 428 3025 AND2_X1
* cell instance $12691 r0 *1 78.85,239.4
X$12691 2984 2871 3016 395 3015 428 OAI21_X1
* cell instance $12693 r0 *1 80.37,239.4
X$12693 3006 2979 395 2984 428 XOR2_X2
* cell instance $12697 r0 *1 91.39,239.4
X$12697 3027 2832 3029 395 428 3007 HA_X1
* cell instance $12698 r0 *1 93.29,239.4
X$12698 3051 2841 3048 395 428 3050 HA_X1
* cell instance $12702 r0 *1 97.66,239.4
X$12702 2950 3002 395 428 3052 AND2_X1
* cell instance $12703 r0 *1 98.42,239.4
X$12703 3008 3009 428 395 2954 NOR2_X1
* cell instance $12704 r0 *1 98.99,239.4
X$12704 2951 2986 3008 3009 3053 428 395 OAI211_X2
* cell instance $12705 r0 *1 100.7,239.4
X$12705 3002 2692 428 395 2988 NAND2_X1
* cell instance $12706 r0 *1 101.27,239.4
X$12706 3020 2988 395 428 3021 AND2_X1
* cell instance $12708 r0 *1 102.79,239.4
X$12708 3010 2901 3011 1292 428 395 2987 NAND4_X1
* cell instance $12711 m0 *1 80.56,242.2
X$12711 3040 428 395 2979 BUF_X2
* cell instance $12716 m0 *1 84.17,242.2
X$12716 2947 428 395 3065 INV_X1
* cell instance $12719 m0 *1 90.82,242.2
X$12719 3046 2893 3026 395 428 3028 HA_X1
* cell instance $12720 m0 *1 92.72,242.2
X$12720 3007 3029 3050 428 3031 395 AOI21_X1
* cell instance $12721 m0 *1 93.48,242.2
X$12721 3048 3029 428 395 3030 NAND2_X1
* cell instance $12726 m0 *1 98.42,242.2
X$12726 2951 3052 3008 3009 3020 428 395 OAI211_X2
* cell instance $12727 m0 *1 100.13,242.2
X$12727 3053 3055 395 428 3054 AND2_X1
* cell instance $12729 m0 *1 101.65,242.2
X$12729 428 3366 2989 3021 2884 395 DFF_X1
* cell instance $12731 r0 *1 105.07,239.4
X$12731 3019 2990 2989 1292 428 395 3002 NAND4_X1
* cell instance $12733 r0 *1 106.02,239.4
X$12733 2983 2974 428 395 3019 NAND2_X1
* cell instance $12738 m0 *1 107.35,242.2
X$12738 2990 428 395 3032 INV_X1
* cell instance $12739 r0 *1 107.92,239.4
X$12739 3032 2989 2955 428 395 3010 NAND3_X1
* cell instance $12743 r0 *1 109.63,239.4
X$12743 428 3448 3018 2991 2884 395 DFF_X1
* cell instance $12744 r0 *1 112.86,239.4
X$12744 1867 3017 2957 428 2999 395 AOI21_X1
* cell instance $12745 r0 *1 113.62,239.4
X$12745 428 3435 2993 2999 2884 395 DFF_X1
* cell instance $12750 m0 *1 107.92,242.2
X$12750 2974 3032 2989 428 3033 395 AOI21_X1
* cell instance $12755 m0 *1 119.51,242.2
X$12755 428 3385 3035 3043 2884 395 DFF_X1
* cell instance $12759 r0 *1 121.6,239.4
X$12759 2936 2959 3473 395 428 3013 HA_X1
* cell instance $12783 m0 *1 122.74,242.2
X$12783 3035 3034 428 395 3014 NOR2_X1
* cell instance $12784 m0 *1 123.31,242.2
X$12784 3041 2958 428 395 3043 NOR2_X1
* cell instance $12785 m0 *1 123.88,242.2
X$12785 3013 3034 395 428 3036 XNOR2_X1
* cell instance $12786 m0 *1 125.02,242.2
X$12786 3036 2958 428 395 3012 NOR2_X1
* cell instance $12788 m0 *1 125.97,242.2
X$12788 428 3365 3034 3012 2884 395 DFF_X1
* cell instance $12839 r0 *1 68.97,236.6
X$12839 2759 2873 2977 428 395 2968 NAND3_X1
* cell instance $12841 r0 *1 70.49,236.6
X$12841 2977 428 395 2978 INV_X1
* cell instance $12842 r0 *1 70.87,236.6
X$12842 2851 2969 428 395 2997 NOR2_X1
* cell instance $12858 m0 *1 69.16,239.4
X$12858 2996 2871 2968 395 2995 428 OAI21_X1
* cell instance $12859 m0 *1 69.92,239.4
X$12859 2977 2997 428 395 2996 XNOR2_X2
* cell instance $12860 r0 *1 72.01,236.6
X$12860 2969 2823 395 428 3136 XNOR2_X1
* cell instance $12866 r0 *1 77.52,236.6
X$12866 428 2946 2948 2979 2939 2851 395 NAND4_X4
* cell instance $12868 r0 *1 80.94,236.6
X$12868 2939 2979 2949 428 2823 395 NAND3_X4
* cell instance $12869 r0 *1 83.41,236.6
X$12869 2871 2873 2948 428 395 2973 NAND3_X1
* cell instance $12873 m0 *1 78.85,239.4
X$12873 2759 2873 2979 428 395 3016 NAND3_X1
* cell instance $12874 m0 *1 79.61,239.4
X$12874 2948 2946 2939 428 395 3006 NAND3_X1
* cell instance $12875 m0 *1 80.37,239.4
X$12875 2939 2949 428 395 2971 XNOR2_X2
* cell instance $12879 m0 *1 83.6,239.4
X$12879 428 2972 2714 2985 2948 395 DFF_X2
* cell instance $12880 r0 *1 85.31,236.6
X$12880 2685 2985 428 395 2982 NAND2_X1
* cell instance $12881 r0 *1 84.55,236.6
X$12881 1867 2973 2982 428 2972 395 AOI21_X1
* cell instance $12887 r0 *1 106.4,236.6
X$12887 2974 2990 2983 395 428 2921 AND3_X2
* cell instance $12895 m0 *1 99.18,239.4
X$12895 2950 2987 395 428 2986 AND2_X1
* cell instance $12896 m0 *1 99.94,239.4
X$12896 2987 2692 428 395 3055 NAND2_X1
* cell instance $12900 m0 *1 105.45,239.4
X$12900 2983 2990 2974 428 395 2901 NAND3_X2
* cell instance $12902 r0 *1 108.68,236.6
X$12902 2956 2975 428 395 2980 NOR2_X1
* cell instance $12903 r0 *1 107.92,236.6
X$12903 2981 2920 2983 428 395 2926 NAND3_X1
* cell instance $12904 r0 *1 109.25,236.6
X$12904 2975 2902 2974 428 395 2976 NOR3_X1
* cell instance $12905 r0 *1 110.01,236.6
X$12905 2957 2976 428 395 2981 NAND2_X1
* cell instance $12911 m0 *1 109.06,239.4
X$12911 2989 428 395 3001 INV_X1
* cell instance $12912 m0 *1 109.44,239.4
X$12912 3001 2976 395 428 2992 AND2_X1
* cell instance $12913 m0 *1 110.2,239.4
X$12913 1867 2980 3000 428 2991 395 AOI21_X1
* cell instance $12914 m0 *1 110.96,239.4
X$12914 2992 2957 3018 428 395 3000 NAND3_X1
* cell instance $12916 m0 *1 112.48,239.4
X$12916 2992 2993 428 395 3017 NAND2_X1
* cell instance $12946 m0 *1 122.93,239.4
X$12946 1127 3014 2994 428 2998 395 AOI21_X1
* cell instance $12997 r0 *1 63.08,225.4
X$12997 428 3427 2845 2844 2714 395 DFF_X1
* cell instance $12998 r0 *1 66.31,225.4
X$12998 2845 428 395 2834 BUF_X2
* cell instance $12999 r0 *1 67.07,225.4
X$12999 2688 2834 428 395 2846 NOR2_X1
* cell instance $13001 r0 *1 67.83,225.4
X$13001 2836 2846 2834 2847 428 395 2812 AOI22_X1
* cell instance $13017 m0 *1 68.78,228.2
X$13017 2835 2853 2837 395 428 2836 AND3_X1
* cell instance $13019 r0 *1 69.16,225.4
X$13019 2836 2759 2804 395 2847 428 OAI21_X1
* cell instance $13021 m0 *1 69.92,228.2
X$13021 428 2835 2853 2746 2834 2838 395 NAND4_X4
* cell instance $13022 r0 *1 70.49,225.4
X$13022 2853 2835 2834 428 395 2849 NAND3_X2
* cell instance $13024 r0 *1 71.82,225.4
X$13024 428 2803 2849 2823 2758 395 NOR3_X4
* cell instance $13026 r0 *1 75.24,225.4
X$13026 2838 2803 2851 428 395 2795 OR3_X4
* cell instance $13032 m0 *1 76,228.2
X$13032 2795 2715 395 2855 428 XOR2_X2
* cell instance $13035 r0 *1 78.47,225.4
X$13035 428 2738 2851 2803 2838 2788 395 NOR4_X4
* cell instance $13039 m0 *1 79.61,228.2
X$13039 428 2839 2823 2838 2803 2738 395 OR4_X4
* cell instance $13043 r0 *1 90.06,225.4
X$13043 2840 2670 428 395 2828 NAND2_X1
* cell instance $13044 r0 *1 89.11,225.4
X$13044 2839 2830 428 395 2691 NOR2_X2
* cell instance $13045 r0 *1 90.63,225.4
X$13045 2631 2691 428 395 2852 XNOR2_X2
* cell instance $13046 r0 *1 92.53,225.4
X$13046 2805 2840 395 428 2841 XNOR2_X1
* cell instance $13050 r0 *1 101.46,225.4
X$13050 2842 2806 428 395 2850 XNOR2_X2
* cell instance $13051 r0 *1 103.36,225.4
X$13051 428 3465 2842 2808 2884 395 DFF_X1
* cell instance $13054 m0 *1 89.3,228.2
X$13054 2839 2859 428 395 2840 NOR2_X1
* cell instance $13055 m0 *1 89.87,228.2
X$13055 2793 428 395 2859 INV_X1
* cell instance $13061 m0 *1 101.46,228.2
X$13061 2652 2712 428 395 2881 XNOR2_X2
* cell instance $13062 m0 *1 103.36,228.2
X$13062 2712 2652 2842 428 395 2862 NAND3_X1
* cell instance $13064 r0 *1 110.77,225.4
X$13064 2829 2831 2843 428 2848 395 AOI21_X1
* cell instance $13065 r0 *1 110.01,225.4
X$13065 2786 2670 2809 428 2829 395 AOI21_X1
* cell instance $13067 r0 *1 111.72,225.4
X$13067 2786 2809 428 395 3107 XNOR2_X2
* cell instance $13073 m0 *1 110.77,228.2
X$13073 2786 2675 395 428 2843 AND2_X1
* cell instance $13074 m0 *1 111.53,228.2
X$13074 428 3388 2865 2848 2466 395 DFF_X1
* cell instance $13075 m0 *1 114.76,228.2
X$13075 2865 428 395 2786 CLKBUF_X2
* cell instance $13155 r0 *1 67.45,228.2
X$13155 1585 2863 395 428 2864 AND2_X1
* cell instance $13156 r0 *1 68.21,228.2
X$13156 2834 2836 395 428 2872 XNOR2_X1
* cell instance $13157 r0 *1 69.35,228.2
X$13157 2853 2837 428 395 2854 XNOR2_X2
* cell instance $13158 r0 *1 71.25,228.2
X$13158 2803 2851 428 395 2837 NOR2_X1
* cell instance $13178 m0 *1 64.98,231
X$13178 428 3408 2887 2864 2714 395 DFF_X1
* cell instance $13179 m0 *1 68.21,231
X$13179 2887 428 395 2853 CLKBUF_X3
* cell instance $13180 m0 *1 69.16,231
X$13180 2854 2871 2866 395 2863 428 OAI21_X1
* cell instance $13181 m0 *1 69.92,231
X$13181 2759 2873 2853 428 395 2866 NAND3_X1
* cell instance $13182 m0 *1 70.68,231
X$13182 2853 428 395 2874 INV_X1
* cell instance $13184 r0 *1 74.67,228.2
X$13184 2855 2871 2868 395 2802 428 OAI21_X1
* cell instance $13186 r0 *1 75.43,228.2
X$13186 2759 2873 2715 428 395 2868 NAND3_X1
* cell instance $13193 m0 *1 79.61,231
X$13193 2688 428 395 2871 CLKBUF_X3
* cell instance $13194 r0 *1 80.75,228.2
X$13194 428 3434 2870 2869 2714 395 DFF_X1
* cell instance $13195 r0 *1 80.37,228.2
X$13195 2856 428 395 2869 INV_X1
* cell instance $13196 r0 *1 83.98,228.2
X$13196 2870 428 395 2858 CLKBUF_X2
* cell instance $13201 m0 *1 80.56,231
X$13201 2889 2891 1413 395 2856 428 OAI21_X1
* cell instance $13202 m0 *1 81.32,231
X$13202 2717 2685 2839 428 2892 395 AOI21_X1
* cell instance $13203 m0 *1 82.08,231
X$13203 2892 2857 428 395 2891 NOR2_X1
* cell instance $13204 m0 *1 82.65,231
X$13204 2857 2839 395 428 2875 XNOR2_X1
* cell instance $13205 m0 *1 83.79,231
X$13205 2839 2871 2858 428 395 2889 NOR3_X1
* cell instance $13206 m0 *1 84.55,231
X$13206 2858 428 395 2857 INV_X1
* cell instance $13209 m0 *1 85.88,231
X$13209 2788 2858 428 395 2913 NAND2_X1
* cell instance $13212 m0 *1 87.02,231
X$13212 2839 2857 2877 395 2876 428 NOR3_X2
* cell instance $13215 m0 *1 88.54,231
X$13215 2878 428 395 2877 INV_X1
* cell instance $13217 m0 *1 89.11,231
X$13217 2858 2878 2894 2788 428 2915 395 NAND4_X2
* cell instance $13219 m0 *1 91.01,231
X$13219 2860 2894 2878 2858 395 428 2793 AND4_X2
* cell instance $13221 m0 *1 93.1,231
X$13221 2860 428 395 2879 INV_X1
* cell instance $13222 m0 *1 93.48,231
X$13222 428 3404 2860 2890 2644 395 DFF_X1
* cell instance $13224 m0 *1 97.47,231
X$13224 428 3341 2867 2888 2644 395 DFF_X1
* cell instance $13225 r0 *1 100.51,228.2
X$13225 2867 428 395 2861 INV_X1
* cell instance $13230 m0 *1 100.7,231
X$13230 2861 2675 2692 2882 395 428 2888 OAI22_X1
* cell instance $13233 m0 *1 102.22,231
X$13233 2861 2862 428 395 2882 XNOR2_X2
* cell instance $13236 r0 *1 113.62,228.2
X$13236 1276 428 395 2884 CLKBUF_X3
* cell instance $13314 r0 *1 63.08,233.8
X$13314 428 3444 2906 2931 2714 395 DFF_X1
* cell instance $13315 r0 *1 66.31,233.8
X$13315 2930 428 395 2916 BUF_X2
* cell instance $13317 r0 *1 67.83,233.8
X$13317 2688 2916 428 395 2917 NOR2_X1
* cell instance $13318 r0 *1 68.4,233.8
X$13318 2932 2917 2916 2933 428 395 2897 AOI22_X1
* cell instance $13319 r0 *1 69.35,233.8
X$13319 2977 2916 2792 428 2803 395 NAND3_X4
* cell instance $13321 r0 *1 72.01,233.8
X$13321 2792 428 395 2969 INV_X1
* cell instance $13341 m0 *1 68.97,236.6
X$13341 2916 2932 395 428 3121 XNOR2_X1
* cell instance $13342 m0 *1 70.11,236.6
X$13342 2823 2969 2978 395 2932 428 NOR3_X2
* cell instance $13347 m0 *1 74.29,236.6
X$13347 428 2962 2714 3313 2946 395 DFF_X2
* cell instance $13348 r0 *1 77.33,233.8
X$13348 2871 2873 2946 428 395 2938 NAND3_X1
* cell instance $13349 r0 *1 76.57,233.8
X$13349 1153 2938 2940 428 2962 395 AOI21_X1
* cell instance $13354 r0 *1 88.92,233.8
X$13354 2894 2876 395 428 3042 XNOR2_X1
* cell instance $13356 r0 *1 90.82,233.8
X$13356 2876 2670 428 395 2942 NAND2_X1
* cell instance $13357 r0 *1 91.39,233.8
X$13357 2894 2942 2918 395 2966 428 OAI21_X1
* cell instance $13358 r0 *1 92.15,233.8
X$13358 2943 428 395 2894 CLKBUF_X2
* cell instance $13363 m0 *1 77.9,236.6
X$13363 2871 2971 428 395 2937 OR2_X1
* cell instance $13364 m0 *1 78.66,236.6
X$13364 2685 2947 428 395 2940 NAND2_X1
* cell instance $13367 m0 *1 79.8,236.6
X$13367 2948 2946 2947 395 428 2949 HA_X1
* cell instance $13374 m0 *1 91.01,236.6
X$13374 428 3376 2943 2966 2644 395 DFF_X1
* cell instance $13378 m0 *1 98.42,236.6
X$13378 2950 2951 2670 428 395 2967 NAND3_X1
* cell instance $13380 r0 *1 98.61,233.8
X$13380 428 2952 2884 3320 2920 395 DFF_X2
* cell instance $13384 m0 *1 99.18,236.6
X$13384 2919 2950 2951 428 395 2953 NAND3_X1
* cell instance $13385 m0 *1 99.94,236.6
X$13385 2954 2953 2685 2945 395 428 2952 OAI22_X1
* cell instance $13386 m0 *1 100.89,236.6
X$13386 2967 2954 1127 2873 395 428 2965 OAI22_X1
* cell instance $13388 m0 *1 102.03,236.6
X$13388 428 3335 2975 2965 2884 395 DFF_X1
* cell instance $13390 r0 *1 108.11,233.8
X$13390 2921 2922 2955 428 395 2907 NOR3_X1
* cell instance $13392 r0 *1 108.87,233.8
X$13392 2923 428 395 2955 INV_X1
* cell instance $13394 r0 *1 109.44,233.8
X$13394 2902 428 395 2924 INV_X1
* cell instance $13395 r0 *1 109.82,233.8
X$13395 428 3417 2885 2925 2884 395 DFF_X1
* cell instance $13396 r0 *1 113.05,233.8
X$13396 2885 2923 428 395 2957 NOR2_X1
* cell instance $13401 m0 *1 108.49,236.6
X$13401 2975 2956 2873 428 2964 395 AOI21_X1
* cell instance $13402 m0 *1 109.25,236.6
X$13402 2963 2924 428 395 2956 NOR2_X1
* cell instance $13405 r0 *1 119.13,233.8
X$13405 2926 1869 428 395 2928 NAND2_X1
* cell instance $13406 r0 *1 118.56,233.8
X$13406 2926 2936 428 395 2941 NOR2_X1
* cell instance $13407 r0 *1 119.7,233.8
X$13407 2935 1869 2941 428 395 2960 MUX2_X1
* cell instance $13412 m0 *1 119.51,236.6
X$13412 1576 2960 395 428 2961 AND2_X1
* cell instance $13414 r0 *1 122.55,233.8
X$13414 2935 2934 2927 395 428 2994 HA_X1
* cell instance $13415 r0 *1 121.6,233.8
X$13415 1413 2927 2928 395 428 2929 AND3_X1
* cell instance $13439 m0 *1 121.79,236.6
X$13439 428 2934 2959 2929 2884 395 DFF_X1
* cell instance $13487 r0 *1 74.48,250.6
X$13487 3187 2996 3125 395 428 3175 HA_X1
* cell instance $13505 m0 *1 70.11,253.4
X$13505 3209 428 395 3022 BUF_X1
* cell instance $13508 m0 *1 71.25,253.4
X$13508 3273 428 395 3174 BUF_X1
* cell instance $13509 m0 *1 71.82,253.4
X$13509 3272 428 395 3072 BUF_X1
* cell instance $13511 m0 *1 73.91,253.4
X$13511 3214 428 395 3123 BUF_X1
* cell instance $13512 m0 *1 74.48,253.4
X$13512 3274 428 395 3186 BUF_X1
* cell instance $13513 m0 *1 75.05,253.4
X$13513 3275 428 395 3122 BUF_X1
* cell instance $13514 m0 *1 75.62,253.4
X$13514 3216 428 395 3187 BUF_X1
* cell instance $13518 m0 *1 80.37,253.4
X$13518 3276 428 395 3176 BUF_X1
* cell instance $13519 r0 *1 82.46,250.6
X$13519 3167 3148 3189 428 3188 395 AOI21_X1
* cell instance $13520 r0 *1 80.56,250.6
X$13520 3177 2782 3147 395 428 3189 HA_X1
* cell instance $13523 r0 *1 90.06,250.6
X$13523 3192 428 395 3046 BUF_X1
* cell instance $13524 r0 *1 90.63,250.6
X$13524 3193 428 395 3058 BUF_X1
* cell instance $13528 m0 *1 81.51,253.4
X$13528 3277 428 395 3177 BUF_X1
* cell instance $13529 m0 *1 82.08,253.4
X$13529 3188 3149 428 395 3151 NAND2_X1
* cell instance $13532 m0 *1 83.79,253.4
X$13532 3223 428 395 3190 BUF_X1
* cell instance $13533 m0 *1 84.36,253.4
X$13533 3226 428 395 3166 BUF_X1
* cell instance $13536 m0 *1 86.64,253.4
X$13536 3278 428 395 3075 BUF_X1
* cell instance $13537 m0 *1 87.21,253.4
X$13537 3232 428 395 3120 BUF_X1
* cell instance $13538 m0 *1 87.78,253.4
X$13538 3234 428 395 3086 BUF_X1
* cell instance $13541 m0 *1 90.25,253.4
X$13541 3239 428 395 3152 BUF_X1
* cell instance $13542 m0 *1 90.82,253.4
X$13542 3280 428 395 3178 BUF_X1
* cell instance $13543 m0 *1 91.39,253.4
X$13543 3238 428 395 3027 BUF_X1
* cell instance $13545 r0 *1 91.58,250.6
X$13545 3194 3128 3153 428 3195 395 AOI21_X1
* cell instance $13547 m0 *1 91.96,253.4
X$13547 3279 428 395 3051 BUF_X1
* cell instance $13549 m0 *1 92.91,253.4
X$13549 3281 428 395 3154 BUF_X1
* cell instance $13550 r0 *1 94.05,250.6
X$13550 3195 3179 3197 395 3171 428 OAI21_X1
* cell instance $13551 r0 *1 93.48,250.6
X$13551 3102 3155 428 395 3179 NAND2_X1
* cell instance $13555 m0 *1 93.48,253.4
X$13555 3208 428 395 3191 INV_X1
* cell instance $13556 m0 *1 93.86,253.4
X$13556 3245 428 395 3208 BUF_X1
* cell instance $13559 m0 *1 96.14,253.4
X$13559 3247 428 395 3170 BUF_X1
* cell instance $13561 r0 *1 99.18,250.6
X$13561 3198 428 395 3200 BUF_X1
* cell instance $13564 r0 *1 99.94,250.6
X$13564 3200 2744 3180 395 428 3181 HA_X1
* cell instance $13565 r0 *1 101.84,250.6
X$13565 3182 3181 3172 428 3201 395 AOI21_X1
* cell instance $13568 m0 *1 99.75,253.4
X$13568 3249 428 395 3199 BUF_X1
* cell instance $13569 m0 *1 100.32,253.4
X$13569 3282 428 395 3143 BUF_X1
* cell instance $13571 m0 *1 101.27,253.4
X$13571 3250 428 395 3141 BUF_X1
* cell instance $13572 m0 *1 101.84,253.4
X$13572 2920 428 395 3253 BUF_X1
* cell instance $13576 m0 *1 103.74,253.4
X$13576 3011 428 395 3254 BUF_X1
* cell instance $13577 m0 *1 104.31,253.4
X$13577 3255 428 395 2983 CLKBUF_X2
* cell instance $13578 r0 *1 104.69,250.6
X$13578 428 3445 3205 3061 2884 395 DFF_X1
* cell instance $13581 r0 *1 114,250.6
X$13581 3207 428 395 3138 BUF_X1
* cell instance $13582 r0 *1 114.57,250.6
X$13582 3183 2820 3158 395 428 3184 HA_X1
* cell instance $13585 m0 *1 105.07,253.4
X$13585 3203 428 395 3256 BUF_X1
* cell instance $13587 m0 *1 105.83,253.4
X$13587 1870 428 395 3283 BUF_X1
* cell instance $13588 m0 *1 106.4,253.4
X$13588 3258 428 395 2963 BUF_X1
* cell instance $13589 m0 *1 106.97,253.4
X$13589 3205 428 395 3259 BUF_X1
* cell instance $13590 m0 *1 107.54,253.4
X$13590 1829 428 395 3261 BUF_X1
* cell instance $13593 m0 *1 108.68,253.4
X$13593 3264 428 395 2922 CLKBUF_X2
* cell instance $13596 m0 *1 111.15,253.4
X$13596 3018 428 395 3266 BUF_X1
* cell instance $13599 m0 *1 112.29,253.4
X$13599 3084 428 395 3265 BUF_X1
* cell instance $13600 m0 *1 112.86,253.4
X$13600 2993 428 395 3268 BUF_X1
* cell instance $13601 m0 *1 113.43,253.4
X$13601 3269 428 395 3133 BUF_X1
* cell instance $13602 m0 *1 114,253.4
X$13602 3270 428 395 3183 BUF_X1
* cell instance $13604 m0 *1 114.95,253.4
X$13604 3271 428 395 3159 BUF_X1
* cell instance $13607 m0 *1 116.47,253.4
X$13607 3204 428 395 3267 BUF_X1
* cell instance $13608 m0 *1 117.04,253.4
X$13608 3202 428 395 3262 BUF_X1
* cell instance $13609 r0 *1 117.8,250.6
X$13609 428 3414 3203 3206 2884 395 DFF_X1
* cell instance $13615 r0 *1 126.54,250.6
X$13615 3185 428 395 3196 BUF_X1
* cell instance $13640 m0 *1 117.61,253.4
X$13640 2465 428 395 3263 BUF_X1
* cell instance $13642 m0 *1 119.7,253.4
X$13642 3260 428 395 1831 BUF_X2
* cell instance $13643 m0 *1 120.46,253.4
X$13643 2467 428 395 3257 BUF_X1
* cell instance $13646 m0 *1 121.6,253.4
X$13646 1903 428 395 3252 BUF_X1
* cell instance $13647 m0 *1 122.17,253.4
X$13647 3135 428 395 3284 BUF_X1
* cell instance $13649 m0 *1 122.93,253.4
X$13649 1891 428 395 3251 BUF_X1
* cell instance $13652 m0 *1 124.64,253.4
X$13652 3285 428 395 2410 CLKBUF_X3
* cell instance $13653 m0 *1 125.59,253.4
X$13653 3248 428 395 2539 BUF_X1
* cell instance $13654 m0 *1 126.16,253.4
X$13654 2412 428 395 3246 BUF_X1
* cell instance $13657 m0 *1 127.87,253.4
X$13657 2563 428 395 3244 BUF_X1
* cell instance $13659 m0 *1 128.82,253.4
X$13659 2379 428 395 3243 BUF_X1
* cell instance $13661 m0 *1 130.91,253.4
X$13661 3286 428 395 2430 CLKBUF_X3
* cell instance $13667 m0 *1 154.66,253.4
X$13667 3242 428 395 2544 BUF_X2
* cell instance $13668 m0 *1 155.42,253.4
X$13668 3287 428 395 2505 BUF_X2
* cell instance $13674 m0 *1 186.58,253.4
X$13674 3241 428 395 LOGIC0_X1
* cell instance $13675 m0 *1 186.96,253.4
X$13675 3241 428 395 3237 BUF_X1
* cell instance $13679 m0 *1 194.18,253.4
X$13679 3240 428 395 LOGIC0_X1
* cell instance $13681 m0 *1 194.75,253.4
X$13681 3240 428 395 3236 BUF_X1
* cell instance $13682 m0 *1 195.32,253.4
X$13682 3235 428 395 LOGIC0_X1
* cell instance $13683 m0 *1 195.7,253.4
X$13683 3235 428 395 3231 BUF_X1
* cell instance $13685 m0 *1 197.79,253.4
X$13685 3233 428 395 LOGIC0_X1
* cell instance $13686 m0 *1 198.17,253.4
X$13686 3233 428 395 3229 BUF_X1
* cell instance $13688 m0 *1 198.93,253.4
X$13688 3230 428 395 LOGIC0_X1
* cell instance $13689 m0 *1 199.31,253.4
X$13689 3230 428 395 3228 BUF_X1
* cell instance $13690 m0 *1 199.88,253.4
X$13690 3227 428 395 LOGIC0_X1
* cell instance $13691 m0 *1 200.26,253.4
X$13691 3227 428 395 3225 BUF_X1
* cell instance $13692 m0 *1 200.83,253.4
X$13692 3224 428 395 3222 BUF_X1
* cell instance $13694 m0 *1 201.59,253.4
X$13694 3224 428 395 LOGIC0_X1
* cell instance $13697 m0 *1 203.87,253.4
X$13697 3221 428 395 LOGIC0_X1
* cell instance $13698 m0 *1 204.25,253.4
X$13698 3221 428 395 3220 BUF_X1
* cell instance $13702 m0 *1 206.15,253.4
X$13702 3219 428 395 LOGIC0_X1
* cell instance $13703 m0 *1 206.53,253.4
X$13703 3219 428 395 3218 BUF_X1
* cell instance $13704 m0 *1 207.1,253.4
X$13704 3217 428 395 LOGIC0_X1
* cell instance $13705 m0 *1 207.48,253.4
X$13705 3217 428 395 3215 BUF_X1
* cell instance $13706 m0 *1 208.05,253.4
X$13706 3212 428 395 3211 BUF_X1
* cell instance $13708 m0 *1 208.81,253.4
X$13708 3212 428 395 LOGIC0_X1
* cell instance $13712 m0 *1 213.37,253.4
X$13712 3213 428 395 LOGIC0_X1
* cell instance $13713 m0 *1 213.75,253.4
X$13713 3213 428 395 3210 BUF_X1
* cell instance $13751 r0 *1 72.77,245
X$13751 3082 3081 3056 395 428 3112 OAI21_X2
* cell instance $13755 r0 *1 76.57,245
X$13755 3062 3073 428 395 3113 NOR2_X1
* cell instance $13773 m0 *1 75.62,247.8
X$13773 428 3126 3113 3114 3112 3098 395 AOI22_X4
* cell instance $13775 r0 *1 77.52,245
X$13775 3073 428 395 3098 INV_X1
* cell instance $13776 r0 *1 78.66,245
X$13776 3074 3062 3073 395 3083 428 NOR3_X2
* cell instance $13779 m0 *1 78.85,247.8
X$13779 3073 3062 3074 428 395 3115 OR3_X1
* cell instance $13782 m0 *1 80.37,247.8
X$13782 428 3116 3114 3119 3008 3115 395 OAI211_X4
* cell instance $13783 r0 *1 83.6,245
X$13783 3075 2984 3085 395 428 3099 HA_X1
* cell instance $13785 r0 *1 85.5,245
X$13785 3085 3066 395 428 3100 AND2_X1
* cell instance $13787 r0 *1 86.45,245
X$13787 3087 3089 3101 395 3117 428 OAI21_X1
* cell instance $13788 r0 *1 87.21,245
X$13788 3088 428 395 3101 INV_X1
* cell instance $13789 r0 *1 87.59,245
X$13789 3067 3076 3100 395 428 3094 AND3_X1
* cell instance $13792 m0 *1 83.98,247.8
X$13792 3117 3100 3099 3085 3057 3119 395 428 AOI221_X2
* cell instance $13795 r0 *1 88.92,245
X$13795 3191 2985 3076 395 428 3089 HA_X1
* cell instance $13798 r0 *1 92.91,245
X$13798 3077 3083 3078 3094 428 2950 395 NAND4_X2
* cell instance $13802 r0 *1 96.33,245
X$13802 3077 3078 3091 3092 3093 3060 395 428 AOI221_X2
* cell instance $13803 r0 *1 98.42,245
X$13803 3091 3093 3092 428 3095 395 AOI21_X1
* cell instance $13809 m0 *1 97.47,247.8
X$13809 3118 3103 428 395 3078 NOR2_X2
* cell instance $13810 m0 *1 98.42,247.8
X$13810 3103 428 395 3104 INV_X1
* cell instance $13811 m0 *1 98.8,247.8
X$13811 3059 3118 3103 395 3093 428 NOR3_X2
* cell instance $13814 r0 *1 107.35,245
X$13814 428 3459 3079 3090 2884 395 DFF_X1
* cell instance $13817 r0 *1 111.34,245
X$13817 428 3424 3084 3068 2884 395 DFF_X1
* cell instance $13821 m0 *1 112.48,247.8
X$13821 3138 3107 3108 395 428 3137 HA_X1
* cell instance $13826 m0 *1 120.08,247.8
X$13826 428 3337 3135 3111 2884 395 DFF_X1
* cell instance $13960 r0 *1 251.37,40.6
X$13960 495 428 395 LOGIC0_X1
* cell instance $13962 r0 *1 252.51,40.6
X$13962 525 428 395 LOGIC0_X1
* cell instance $13992 m0 *1 250.8,43.4
X$13992 480 428 395 LOGIC0_X1
* cell instance $13993 m0 *1 251.75,43.4
X$13993 514 428 395 LOGIC0_X1
* cell instance $14074 r0 *1 249.85,15.4
X$14074 471 428 395 LOGIC0_X1
* cell instance $14103 m0 *1 250.42,18.2
X$14103 461 428 395 LOGIC0_X1
* cell instance $14107 r0 *1 252.51,15.4
X$14107 522 428 395 LOGIC0_X1
* cell instance $14110 m0 *1 252.32,18.2
X$14110 500 428 395 LOGIC0_X1
* cell instance $14333 r0 *1 250.23,57.4
X$14333 581 428 395 LOGIC0_X1
* cell instance $14336 r0 *1 250.8,57.4
X$14336 585 428 395 LOGIC0_X1
* cell instance $14337 r0 *1 251.18,57.4
X$14337 586 428 395 LOGIC0_X1
* cell instance $14338 r0 *1 251.56,57.4
X$14338 586 428 395 578 BUF_X1
* cell instance $14339 r0 *1 252.13,57.4
X$14339 585 428 395 579 BUF_X1
* cell instance $14341 r0 *1 252.89,57.4
X$14341 581 428 395 565 BUF_X1
* cell instance $14344 m0 *1 250.8,60.2
X$14344 584 428 395 LOGIC0_X1
* cell instance $14346 m0 *1 251.94,60.2
X$14346 584 428 395 576 BUF_X1
* cell instance $14347 m0 *1 252.51,60.2
X$14347 582 428 395 LOGIC0_X1
* cell instance $14348 m0 *1 252.89,60.2
X$14348 582 428 395 575 BUF_X1
* cell instance $14418 r0 *1 251.75,37.8
X$14418 493 428 395 LOGIC0_X1
* cell instance $14419 r0 *1 252.13,37.8
X$14419 505 428 395 LOGIC0_X1
* cell instance $14451 m0 *1 250.23,40.6
X$14451 466 428 395 LOGIC0_X1
* cell instance $14453 m0 *1 251.37,40.6
X$14453 478 428 395 LOGIC0_X1
* cell instance $14454 m0 *1 252.32,40.6
X$14454 503 428 395 LOGIC0_X1
* cell instance $14673 r0 *1 250.23,46.2
X$14673 535 428 395 LOGIC0_X1
* cell instance $14675 r0 *1 250.61,46.2
X$14675 535 428 395 529 BUF_X1
* cell instance $14676 r0 *1 251.18,46.2
X$14676 538 428 395 LOGIC0_X1
* cell instance $14677 r0 *1 251.56,46.2
X$14677 538 428 395 528 BUF_X1
* cell instance $14678 r0 *1 252.13,46.2
X$14678 534 428 395 LOGIC0_X1
* cell instance $14679 r0 *1 252.51,46.2
X$14679 534 428 395 533 BUF_X1
* cell instance $14681 m0 *1 250.42,49
X$14681 548 428 395 LOGIC0_X1
* cell instance $14682 m0 *1 250.8,49
X$14682 548 428 395 530 BUF_X1
* cell instance $14683 m0 *1 251.37,49
X$14683 547 428 395 LOGIC0_X1
* cell instance $14685 m0 *1 251.94,49
X$14685 547 428 395 543 BUF_X1
* cell instance $14686 m0 *1 252.51,49
X$14686 546 428 395 LOGIC0_X1
* cell instance $14687 m0 *1 252.89,49
X$14687 546 428 395 541 BUF_X1
* cell instance $14803 r0 *1 250.23,9.8
X$14803 470 428 395 LOGIC0_X1
* cell instance $14805 r0 *1 252.13,9.8
X$14805 504 428 395 LOGIC0_X1
* cell instance $14809 m0 *1 251.56,12.6
X$14809 517 428 395 LOGIC0_X1
* cell instance $14810 m0 *1 251.94,12.6
X$14810 510 428 395 LOGIC0_X1
* cell instance $15029 r0 *1 7.6,88.2
X$15029 847 821 863 395 428 799 HA_X1
* cell instance $15030 r0 *1 9.5,88.2
X$15030 923 852 887 395 428 829 HA_X1
* cell instance $15035 m0 *1 1.71,91
X$15035 861 428 395 888 BUF_X1
* cell instance $15038 m0 *1 3.42,91
X$15038 862 428 395 886 BUF_X1
* cell instance $15043 m0 *1 6.84,91
X$15043 887 828 428 395 922 NAND2_X1
* cell instance $15044 m0 *1 7.41,91
X$15044 888 849 889 395 428 892 HA_X1
* cell instance $15045 m0 *1 9.31,91
X$15045 799 892 863 428 961 395 AOI21_X1
* cell instance $15048 m0 *1 11.21,91
X$15048 893 859 828 395 428 894 HA_X1
* cell instance $15050 r0 *1 15.96,88.2
X$15050 830 793 428 395 773 NAND2_X1
* cell instance $15051 r0 *1 14.82,88.2
X$15051 714 774 395 428 852 XNOR2_X1
* cell instance $15052 r0 *1 16.53,88.2
X$15052 800 830 801 395 819 428 OAI21_X1
* cell instance $15055 r0 *1 19,88.2
X$15055 428 803 831 853 804 774 395 NOR4_X4
* cell instance $15059 m0 *1 18.05,91
X$15059 428 865 803 831 804 830 395 NOR4_X4
* cell instance $15062 m0 *1 22.04,91
X$15062 831 803 832 804 395 775 428 NOR4_X2
* cell instance $15064 r0 *1 22.8,88.2
X$15064 805 807 428 395 832 NAND2_X1
* cell instance $15065 r0 *1 24.13,88.2
X$15065 806 856 428 395 821 XNOR2_X2
* cell instance $15067 r0 *1 26.79,88.2
X$15067 856 800 801 395 825 428 OAI21_X1
* cell instance $15068 r0 *1 27.55,88.2
X$15068 805 807 757 428 395 834 NAND3_X1
* cell instance $15069 r0 *1 28.31,88.2
X$15069 807 757 806 805 428 853 395 NAND4_X2
* cell instance $15070 r0 *1 30.02,88.2
X$15070 428 3453 835 827 753 395 DFF_X1
* cell instance $15073 m0 *1 26.79,91
X$15073 857 803 834 395 856 428 NOR3_X2
* cell instance $15074 m0 *1 28.12,91
X$15074 870 871 834 428 395 824 NOR3_X1
* cell instance $15076 m0 *1 29.26,91
X$15076 802 871 853 428 395 872 OR3_X2
* cell instance $15078 m0 *1 31.16,91
X$15078 836 872 428 395 859 XNOR2_X2
* cell instance $15081 r0 *1 33.63,88.2
X$15081 835 428 395 836 INV_X1
* cell instance $15083 m0 *1 34.01,91
X$15083 835 870 872 428 395 860 OR3_X1
* cell instance $15084 r0 *1 34.58,88.2
X$15084 836 837 860 395 827 428 OAI21_X1
* cell instance $15101 m0 *1 34.96,91
X$15101 874 793 872 428 837 395 AOI21_X1
* cell instance $15121 r0 *1 128.82,88.2
X$15121 858 428 395 838 INV_X1
* cell instance $15128 m0 *1 123.31,91
X$15128 897 907 395 428 693 XNOR2_X1
* cell instance $15131 m0 *1 125.02,91
X$15131 428 3364 858 855 752 395 DFF_X1
* cell instance $15132 m0 *1 128.25,91
X$15132 838 877 395 428 672 XNOR2_X1
* cell instance $15133 m0 *1 129.39,91
X$15133 838 878 839 395 855 428 OAI21_X1
* cell instance $15137 r0 *1 135.66,88.2
X$15137 854 764 428 395 841 NAND2_X1
* cell instance $15138 r0 *1 134.9,88.2
X$15138 764 840 841 395 823 428 OAI21_X1
* cell instance $15140 r0 *1 136.99,88.2
X$15140 741 764 843 428 910 395 NAND3_X4
* cell instance $15161 r0 *1 251.18,88.2
X$15161 851 428 395 LOGIC0_X1
* cell instance $15162 r0 *1 251.56,88.2
X$15162 815 428 395 LOGIC0_X1
* cell instance $15163 r0 *1 251.94,88.2
X$15163 851 428 395 844 BUF_X1
* cell instance $15164 r0 *1 252.51,88.2
X$15164 850 428 395 LOGIC0_X1
* cell instance $15165 r0 *1 252.89,88.2
X$15165 850 428 395 812 BUF_X1
* cell instance $15168 m0 *1 135.28,91
X$15168 779 880 428 395 840 NAND2_X1
* cell instance $15171 m0 *1 137.75,91
X$15171 879 741 428 395 932 NAND2_X1
* cell instance $15174 m0 *1 139.46,91
X$15174 881 842 765 428 395 931 NAND3_X2
* cell instance $15175 m0 *1 140.79,91
X$15175 842 428 395 914 INV_X1
* cell instance $15176 m0 *1 141.17,91
X$15176 879 765 842 881 395 428 843 AND4_X1
* cell instance $15178 m0 *1 142.5,91
X$15178 842 881 883 884 395 428 780 AND4_X1
* cell instance $15201 m0 *1 250.99,91
X$15201 891 428 395 LOGIC0_X1
* cell instance $15203 m0 *1 251.56,91
X$15203 891 428 395 846 BUF_X1
* cell instance $15204 m0 *1 252.13,91
X$15204 890 428 395 LOGIC0_X1
* cell instance $15206 m0 *1 252.7,91
X$15206 890 428 395 848 BUF_X1
* cell instance $15227 r0 *1 15.96,85.4
X$15227 756 773 787 395 784 428 OAI21_X1
* cell instance $15228 r0 *1 16.72,85.4
X$15228 819 756 428 395 787 NAND2_X1
* cell instance $15232 r0 *1 21.28,85.4
X$15232 776 757 428 395 769 NAND2_X1
* cell instance $15233 r0 *1 21.85,85.4
X$15233 757 777 769 395 739 428 OAI21_X1
* cell instance $15240 m0 *1 14.63,88.2
X$15240 785 772 428 395 713 NAND2_X1
* cell instance $15241 m0 *1 15.2,88.2
X$15241 817 714 428 395 772 NAND2_X1
* cell instance $15243 m0 *1 16.15,88.2
X$15243 774 793 802 428 395 785 NAND3_X1
* cell instance $15244 m0 *1 16.91,88.2
X$15244 800 774 801 395 817 428 OAI21_X1
* cell instance $15245 m0 *1 17.67,88.2
X$15245 714 428 395 802 INV_X1
* cell instance $15247 m0 *1 19.57,88.2
X$15247 757 775 395 428 849 XNOR2_X1
* cell instance $15248 m0 *1 20.71,88.2
X$15248 800 775 801 395 776 428 OAI21_X1
* cell instance $15249 m0 *1 21.47,88.2
X$15249 775 793 428 395 777 NAND2_X1
* cell instance $15251 r0 *1 23.18,85.4
X$15251 794 428 395 757 CLKBUF_X2
* cell instance $15253 r0 *1 23.94,85.4
X$15253 428 771 725 3321 806 395 DFF_X2
* cell instance $15276 m0 *1 26.22,88.2
X$15276 824 806 825 428 395 771 MUX2_X1
* cell instance $15278 m0 *1 28.31,88.2
X$15278 826 428 395 808 CLKBUF_X2
* cell instance $15295 r0 *1 123.31,85.4
X$15295 795 740 796 428 754 395 AOI21_X1
* cell instance $15297 r0 *1 124.07,85.4
X$15297 758 759 428 395 796 OR2_X1
* cell instance $15301 r0 *1 127.3,85.4
X$15301 798 763 760 428 395 778 MUX2_X1
* cell instance $15302 r0 *1 128.63,85.4
X$15302 761 758 762 395 760 428 OAI21_X1
* cell instance $15303 r0 *1 129.39,85.4
X$15303 763 761 395 428 674 XNOR2_X1
* cell instance $15307 r0 *1 135.28,85.4
X$15307 758 779 762 395 854 428 OAI21_X1
* cell instance $15310 r0 *1 137.75,85.4
X$15310 764 779 395 428 719 XNOR2_X1
* cell instance $15315 m0 *1 123.69,88.2
X$15315 759 809 740 810 797 428 395 795 AOI221_X1
* cell instance $15319 m0 *1 126.16,88.2
X$15319 797 810 428 395 762 NAND2_X2
* cell instance $15321 m0 *1 127.49,88.2
X$15321 761 809 395 428 798 AND2_X1
* cell instance $15322 m0 *1 128.25,88.2
X$15322 428 3347 763 778 752 395 DFF_X1
* cell instance $15325 m0 *1 133.19,88.2
X$15325 428 3351 822 823 752 395 DFF_X1
* cell instance $15326 m0 *1 136.42,88.2
X$15326 822 428 395 764 BUF_X2
* cell instance $15328 r0 *1 141.74,85.4
X$15328 765 780 395 428 770 XNOR2_X1
* cell instance $15330 r0 *1 142.88,85.4
X$15330 766 758 762 395 767 428 OAI21_X1
* cell instance $15332 r0 *1 143.83,85.4
X$15332 758 765 428 395 818 NOR2_X1
* cell instance $15333 r0 *1 144.4,85.4
X$15333 792 428 395 765 BUF_X2
* cell instance $15334 r0 *1 145.16,85.4
X$15334 791 428 395 790 INV_X1
* cell instance $15335 r0 *1 145.54,85.4
X$15335 428 3456 792 790 752 395 DFF_X1
* cell instance $15355 m0 *1 143.26,88.2
X$15355 758 780 762 395 820 428 OAI21_X1
* cell instance $15356 m0 *1 144.02,88.2
X$15356 780 818 765 820 428 395 791 AOI22_X1
* cell instance $15381 r0 *1 250.61,85.4
X$15381 789 428 395 781 BUF_X1
* cell instance $15382 r0 *1 250.23,85.4
X$15382 789 428 395 LOGIC0_X1
* cell instance $15383 r0 *1 251.18,85.4
X$15383 788 428 395 LOGIC0_X1
* cell instance $15384 r0 *1 251.56,85.4
X$15384 788 428 395 768 BUF_X1
* cell instance $15386 r0 *1 252.32,85.4
X$15386 786 428 395 LOGIC0_X1
* cell instance $15388 r0 *1 252.89,85.4
X$15388 786 428 395 745 BUF_X1
* cell instance $15390 m0 *1 250.23,88.2
X$15390 816 428 395 LOGIC0_X1
* cell instance $15392 m0 *1 250.8,88.2
X$15392 816 428 395 783 BUF_X1
* cell instance $15394 m0 *1 251.56,88.2
X$15394 815 428 395 813 BUF_X1
* cell instance $15395 m0 *1 252.13,88.2
X$15395 814 428 395 LOGIC0_X1
* cell instance $15397 m0 *1 252.7,88.2
X$15397 814 428 395 782 BUF_X1
* cell instance $15475 r0 *1 126.35,77
X$15475 428 670 671 668 673 703 395 NAND4_X4
* cell instance $15477 m0 *1 126.73,79.8
X$15477 692 712 669 668 697 694 395 428 AOI221_X2
* cell instance $15479 r0 *1 130.15,77
X$15479 680 670 673 428 395 682 NAND3_X1
* cell instance $15480 r0 *1 131.1,77
X$15480 683 670 681 428 675 395 AOI21_X1
* cell instance $15502 r0 *1 251.18,77
X$15502 679 428 395 LOGIC0_X1
* cell instance $15503 r0 *1 251.56,77
X$15503 679 428 395 677 BUF_X1
* cell instance $15504 r0 *1 252.13,77
X$15504 678 428 395 LOGIC0_X1
* cell instance $15505 r0 *1 252.51,77
X$15505 678 428 395 652 BUF_X1
* cell instance $15507 m0 *1 130.72,79.8
X$15507 675 682 428 395 697 NAND2_X1
* cell instance $15545 m0 *1 250.23,79.8
X$15545 699 428 395 LOGIC0_X1
* cell instance $15546 m0 *1 250.61,79.8
X$15546 699 428 395 676 BUF_X1
* cell instance $15548 m0 *1 251.37,79.8
X$15548 698 428 395 LOGIC0_X1
* cell instance $15549 m0 *1 251.75,79.8
X$15549 698 428 395 689 BUF_X1
* cell instance $15550 m0 *1 252.32,79.8
X$15550 695 428 395 LOGIC0_X1
* cell instance $15552 m0 *1 252.89,79.8
X$15552 695 428 395 690 BUF_X1
* cell instance $15710 r0 *1 136.42,74.2
X$15710 648 636 638 428 650 395 AOI21_X1
* cell instance $15712 r0 *1 137.37,74.2
X$15712 662 636 640 660 428 651 395 NAND4_X2
* cell instance $15713 r0 *1 139.08,74.2
X$15713 662 640 428 395 639 NAND2_X1
* cell instance $15719 m0 *1 128.44,77
X$15719 613 672 671 395 428 680 HA_X1
* cell instance $15720 m0 *1 130.34,77
X$15720 658 674 673 395 428 681 HA_X1
* cell instance $15723 m0 *1 136.8,77
X$15723 650 639 661 395 692 428 OAI21_X1
* cell instance $15724 m0 *1 137.56,77
X$15724 637 666 660 395 428 638 HA_X1
* cell instance $15726 r0 *1 140.22,74.2
X$15726 667 640 641 428 661 395 AOI21_X1
* cell instance $15728 r0 *1 140.98,74.2
X$15728 589 770 640 395 428 667 HA_X1
* cell instance $15748 r0 *1 250.8,74.2
X$15748 663 428 395 LOGIC0_X1
* cell instance $15749 r0 *1 251.18,74.2
X$15749 663 428 395 653 BUF_X1
* cell instance $15776 m0 *1 250.23,77
X$15776 665 428 395 LOGIC0_X1
* cell instance $15777 m0 *1 250.61,77
X$15777 665 428 395 655 BUF_X1
* cell instance $15778 m0 *1 251.18,77
X$15778 664 428 395 LOGIC0_X1
* cell instance $15780 m0 *1 251.75,77
X$15780 664 428 395 654 BUF_X1
* cell instance $15781 r0 *1 252.51,74.2
X$15781 659 428 395 642 BUF_X1
* cell instance $15782 r0 *1 252.13,74.2
X$15782 659 428 395 LOGIC0_X1
* cell instance $15784 m0 *1 252.32,77
X$15784 657 428 395 LOGIC0_X1
* cell instance $15785 m0 *1 252.7,77
X$15785 657 428 395 656 BUF_X1
* cell instance $15875 r0 *1 251.18,68.6
X$15875 620 428 395 LOGIC0_X1
* cell instance $15877 r0 *1 251.75,68.6
X$15877 621 428 395 LOGIC0_X1
* cell instance $15878 r0 *1 252.13,68.6
X$15878 621 428 395 616 BUF_X1
* cell instance $15879 r0 *1 252.7,68.6
X$15879 620 428 395 618 BUF_X1
* cell instance $15916 m0 *1 250.23,71.4
X$15916 635 428 395 LOGIC0_X1
* cell instance $15918 m0 *1 250.8,71.4
X$15918 635 428 395 615 BUF_X1
* cell instance $15920 m0 *1 251.56,71.4
X$15920 624 428 395 626 BUF_X1
* cell instance $15922 m0 *1 252.32,71.4
X$15922 631 428 395 LOGIC0_X1
* cell instance $15924 m0 *1 252.89,71.4
X$15924 631 428 395 617 BUF_X1
* cell instance $15930 r0 *1 15.01,82.6
X$15930 428 3412 714 713 725 395 DFF_X1
* cell instance $15954 r0 *1 127.49,82.6
X$15954 706 716 732 717 428 395 730 AOI22_X2
* cell instance $15962 m0 *1 1.33,85.4
X$15962 747 428 395 738 BUF_X1
* cell instance $15963 m0 *1 1.9,85.4
X$15963 747 428 395 LOGIC0_X1
* cell instance $15968 m0 *1 13.11,85.4
X$15968 428 3346 748 784 749 395 DFF_X1
* cell instance $15969 m0 *1 16.34,85.4
X$15969 748 428 395 756 BUF_X1
* cell instance $15972 m0 *1 20.14,85.4
X$15972 428 3328 794 739 749 395 DFF_X1
* cell instance $15976 m0 *1 27.55,85.4
X$15976 428 3340 826 833 753 395 DFF_X1
* cell instance $16001 m0 *1 120.27,85.4
X$16001 428 3330 755 754 752 395 DFF_X1
* cell instance $16002 m0 *1 123.5,85.4
X$16002 755 428 395 740 INV_X1
* cell instance $16003 m0 *1 123.88,85.4
X$16003 740 759 395 428 715 XNOR2_X1
* cell instance $16008 m0 *1 140.41,85.4
X$16008 741 766 395 428 734 XNOR2_X1
* cell instance $16009 m0 *1 141.55,85.4
X$16009 758 741 428 395 742 NOR2_X1
* cell instance $16010 m0 *1 142.12,85.4
X$16010 766 742 741 767 428 395 743 AOI22_X1
* cell instance $16011 r0 *1 142.31,82.6
X$16011 428 3458 744 721 752 395 DFF_X1
* cell instance $16035 m0 *1 143.07,85.4
X$16035 743 428 395 721 INV_X1
* cell instance $16039 m0 *1 144.78,85.4
X$16039 744 428 395 741 BUF_X2
* cell instance $16065 r0 *1 250.23,82.6
X$16065 729 428 395 LOGIC0_X1
* cell instance $16069 r0 *1 251.56,82.6
X$16069 729 428 395 722 BUF_X1
* cell instance $16070 r0 *1 252.13,82.6
X$16070 726 428 395 LOGIC0_X1
* cell instance $16072 r0 *1 252.7,82.6
X$16072 726 428 395 723 BUF_X1
* cell instance $16076 m0 *1 250.8,85.4
X$16076 751 428 395 LOGIC0_X1
* cell instance $16077 m0 *1 251.18,85.4
X$16077 751 428 395 724 BUF_X1
* cell instance $16080 m0 *1 252.32,85.4
X$16080 750 428 395 LOGIC0_X1
* cell instance $16082 m0 *1 252.89,85.4
X$16082 750 428 395 746 BUF_X1
* cell instance $16246 r0 *1 137.56,79.8
X$16246 700 684 736 428 686 395 AOI21_X1
* cell instance $16248 r0 *1 139.08,79.8
X$16248 702 734 687 395 428 733 HA_X1
* cell instance $16272 m0 *1 127.3,82.6
X$16272 705 704 703 428 395 712 NOR3_X1
* cell instance $16273 m0 *1 128.06,82.6
X$16273 704 703 428 395 716 NOR2_X1
* cell instance $16274 m0 *1 128.63,82.6
X$16274 703 428 395 717 INV_X1
* cell instance $16275 m0 *1 129.01,82.6
X$16275 428 703 704 705 651 735 395 NOR4_X4
* cell instance $16278 m0 *1 133.57,82.6
X$16278 718 687 684 737 428 705 395 NAND4_X2
* cell instance $16279 m0 *1 135.28,82.6
X$16279 708 707 686 395 706 428 OAI21_X1
* cell instance $16280 m0 *1 136.04,82.6
X$16280 718 684 428 395 707 NAND2_X1
* cell instance $16282 m0 *1 138.7,82.6
X$16282 733 687 720 428 708 395 AOI21_X1
* cell instance $16315 m0 *1 250.23,82.6
X$16315 728 428 395 LOGIC0_X1
* cell instance $16316 m0 *1 250.61,82.6
X$16316 728 428 395 709 BUF_X1
* cell instance $16317 r0 *1 251.18,79.8
X$16317 701 428 395 688 BUF_X1
* cell instance $16318 r0 *1 250.8,79.8
X$16318 701 428 395 LOGIC0_X1
* cell instance $16320 m0 *1 251.18,82.6
X$16320 731 428 395 LOGIC0_X1
* cell instance $16322 m0 *1 251.75,82.6
X$16322 731 428 395 710 BUF_X1
* cell instance $16324 r0 *1 252.13,79.8
X$16324 696 428 395 LOGIC0_X1
* cell instance $16325 r0 *1 252.7,79.8
X$16325 696 428 395 691 BUF_X1
* cell instance $16328 m0 *1 252.32,82.6
X$16328 727 428 395 LOGIC0_X1
* cell instance $16330 m0 *1 252.89,82.6
X$16330 727 428 395 711 BUF_X1
.ENDS dma_controller

* cell AND4_X4
* pin PWELL,VSS
* pin A4
* pin A3
* pin A2
* pin A1
* pin ZN
* pin NWELL,VDD
.SUBCKT AND4_X4 1 2 3 4 6 7 14
* net 1 PWELL,VSS
* net 2 A4
* net 3 A3
* net 4 A2
* net 6 A1
* net 7 ZN
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 2 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 14 3 5 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 5 4 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 14 6 5 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.705,0.995 PMOS_VTL
M$9 7 5 14 14 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.375,0.2975 NMOS_VTL
M$14 9 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.565,0.2975 NMOS_VTL
M$15 10 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.755,0.2975 NMOS_VTL
M$16 5 6 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 12 6 5 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 11 4 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 13 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 2 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 7 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND4_X4

* cell OR3_X2
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 5 1 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 4 2 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 5 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR3_X2

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell BUF_X8
* pin PWELL,VSS
* pin Z
* pin NWELL,VDD
* pin A
.SUBCKT BUF_X8 1 3 4 5
* net 1 PWELL,VSS
* net 3 Z
* net 4 NWELL,VDD
* net 5 A
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 5 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 3 2 4 4 PMOS_VTL L=0.05U W=5.04U AS=0.3528P AD=0.37485P PS=6.16U PD=6.86U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.2324P AD=0.246925P PS=4.44U PD=4.925U
.ENDS BUF_X8

* cell AOI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT AOI22_X4 1 2 3 4 5 6 16
* net 1 PWELL,VSS
* net 2 B2
* net 3 B1
* net 4 ZN
* net 5 A2
* net 6 A1
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.695,0.995 PMOS_VTL
M$9 4 5 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $10 r0 *1 1.885,0.995 PMOS_VTL
M$10 15 6 4 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $17 r0 *1 0.175,0.2975 NMOS_VTL
M$17 7 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.365,0.2975 NMOS_VTL
M$18 4 3 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.555,0.2975 NMOS_VTL
M$19 10 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.745,0.2975 NMOS_VTL
M$20 1 2 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.935,0.2975 NMOS_VTL
M$21 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.125,0.2975 NMOS_VTL
M$22 4 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.315,0.2975 NMOS_VTL
M$23 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.505,0.2975 NMOS_VTL
M$24 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.695,0.2975 NMOS_VTL
M$25 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $26 r0 *1 1.885,0.2975 NMOS_VTL
M$26 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $27 r0 *1 2.075,0.2975 NMOS_VTL
M$27 11 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $28 r0 *1 2.265,0.2975 NMOS_VTL
M$28 1 5 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $29 r0 *1 2.455,0.2975 NMOS_VTL
M$29 14 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $30 r0 *1 2.645,0.2975 NMOS_VTL
M$30 4 6 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $31 r0 *1 2.835,0.2975 NMOS_VTL
M$31 9 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $32 r0 *1 3.025,0.2975 NMOS_VTL
M$32 1 5 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X4

* cell OAI21_X2
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X2 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 3 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 5 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 6 1 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 7 2 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 4 3 7 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI21_X2

* cell OR4_X4
* pin PWELL,VSS
* pin ZN
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT OR4_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 ZN
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 4 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 5 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 6 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 2 7 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 13 7 2 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 14 6 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 4 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 3 2 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 4 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 1 5 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 2 6 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 7 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 1.69,0.2975 NMOS_VTL
M$21 3 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS OR4_X4

* cell OAI211_X2
* pin A
* pin B
* pin C2
* pin C1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI211_X2 1 2 3 4 6 7 8
* net 1 A
* net 2 B
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 6 1 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.111825P AD=0.0882P PS=2.245U PD=1.54U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 8 2 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.089775P PS=1.54U PD=1.545U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 9 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 8 3 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.205,0.2975 NMOS_VTL
M$9 12 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.395,0.2975 NMOS_VTL
M$10 7 2 12 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.585,0.2975 NMOS_VTL
M$11 11 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 5 1 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.02905P PS=0.56U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 6 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 5 4 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI211_X2

* cell XOR2_X1
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT XOR2_X1 1 3 4 5 6
* net 1 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 8 1 2 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 7 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 6 1 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 7 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 2 1 4 4 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 4 3 2 4 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.555,0.2975 NMOS_VTL
M$8 6 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.745,0.2975 NMOS_VTL
M$9 9 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.935,0.2975 NMOS_VTL
M$10 4 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XOR2_X1

* cell AND3_X2
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 9 1 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 8 2 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND3_X2

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT INV_X4 1 2 3
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell AND4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X1 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 5 4 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 10 1 5 7 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 11 2 10 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 9 3 11 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 7 4 9 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 5 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND4_X1

* cell OR4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR4_X1 1 2 3 4 5 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 10 1 6 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 2 10 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 11 3 9 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 6 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 6 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 5 2 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 5 4 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 6 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR4_X1

* cell OAI211_X4
* pin PWELL,VSS
* pin A
* pin B
* pin C2
* pin ZN
* pin C1
* pin NWELL,VDD
.SUBCKT OAI211_X4 1 3 4 5 6 7 12
* net 1 PWELL,VSS
* net 3 A
* net 4 B
* net 5 C2
* net 6 ZN
* net 7 C1
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 3 12 12 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 12 4 6 12 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 15 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 12 5 15 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 14 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 14 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 12 5 16 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 8 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 1 4 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.55,0.2975 NMOS_VTL
M$19 10 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.74,0.2975 NMOS_VTL
M$20 2 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.93,0.2975 NMOS_VTL
M$21 9 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.12,0.2975 NMOS_VTL
M$22 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.31,0.2975 NMOS_VTL
M$23 11 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.5,0.2975 NMOS_VTL
M$24 2 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI211_X4

* cell OR4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OR4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 ZN
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 11 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 7 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 5 1 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 8 2 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 5 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 8 4 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 7 5 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR4_X2

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell OR3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 11 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.585,0.995 PMOS_VTL
M$3 4 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.775,0.995 PMOS_VTL
M$4 9 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.965,0.995 PMOS_VTL
M$5 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.155,0.995 PMOS_VTL
M$6 6 1 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.345,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.177975P AD=0.200025P PS=3.085U
+ PD=3.785U
* device instance $11 r0 *1 0.205,0.2975 NMOS_VTL
M$11 4 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.395,0.2975 NMOS_VTL
M$12 5 2 4 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.585,0.2975 NMOS_VTL
M$13 4 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.345,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1172375P AD=0.1317625P PS=2.225U
+ PD=2.71U
.ENDS OR3_X4

* cell NAND3_X2
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 10 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 9 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 1 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X2

* cell INV_X8
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X8 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.37485P PS=6.86U PD=6.86U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 4 1 2 2 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.246925P PS=4.925U
+ PD=4.925U
.ENDS INV_X8

* cell AND3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AND3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 4 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 3 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 11 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 10 2 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 4 3 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 8 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 9 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.12,0.2975 NMOS_VTL
M$16 5 1 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.31,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND3_X4

* cell OAI221_X2
* pin C2
* pin C1
* pin B1
* pin B2
* pin A
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI221_X2 1 2 3 4 5 7 9 10
* net 1 C2
* net 2 C1
* net 3 B1
* net 4 B2
* net 5 A
* net 7 ZN
* net 9 PWELL,VSS
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 1 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 2 12 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 11 2 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 10 1 11 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 5 10 10 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 14 3 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 10 4 14 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 13 4 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.73,0.995 PMOS_VTL
M$9 7 3 13 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 0.21,0.2975 NMOS_VTL
M$11 7 1 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.4,0.2975 NMOS_VTL
M$12 6 2 7 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.97,0.2975 NMOS_VTL
M$15 8 5 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $16 r0 *1 1.16,0.2975 NMOS_VTL
M$16 9 3 8 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.35,0.2975 NMOS_VTL
M$17 8 4 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI221_X2

* cell OR2_X2
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X2 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 3 2 4 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 4 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR2_X2

* cell OAI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X1 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 9 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 7 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 5 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 8 3 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 8 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI22_X1

* cell AND4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 11 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 10 2 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 9 3 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 7 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 8 5 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND4_X2

* cell NAND3_X4
* pin A2
* pin A1
* pin A3
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND3_X4 1 2 3 4 5 6
* net 1 A2
* net 2 A1
* net 3 A3
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 3 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 6 1 5 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.21,0.2975 NMOS_VTL
M$13 13 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.4,0.2975 NMOS_VTL
M$14 12 1 13 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.59,0.2975 NMOS_VTL
M$15 5 2 12 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.78,0.2975 NMOS_VTL
M$16 10 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.97,0.2975 NMOS_VTL
M$17 8 1 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.16,0.2975 NMOS_VTL
M$18 4 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.35,0.2975 NMOS_VTL
M$19 9 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.54,0.2975 NMOS_VTL
M$20 7 1 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.73,0.2975 NMOS_VTL
M$21 5 2 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.92,0.2975 NMOS_VTL
M$22 14 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.11,0.2975 NMOS_VTL
M$23 11 1 14 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.3,0.2975 NMOS_VTL
M$24 4 3 11 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X4

* cell CLKBUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.17,0.1875 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $5 r0 *1 0.36,0.1875 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.39U AS=0.0273P AD=0.034125P PS=0.67U PD=0.935U
.ENDS CLKBUF_X2

* cell NOR3_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR3_X4 1 2 3 4 5 8
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 ZN
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 2 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 6 3 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 6 4 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $13 r0 *1 1.875,0.2975 NMOS_VTL
M$13 5 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 5 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 0.93,0.2975 NMOS_VTL
M$21 5 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NOR3_X4

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell NAND4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 4 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 7 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 13 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 12 1 13 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 11 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 6 3 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 8 3 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 9 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X2

* cell AND2_X2
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X2 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 3 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND2_X2

* cell NOR2_X4
* pin A2
* pin A1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT NOR2_X4 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 ZN
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 9 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 3 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 8 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 1 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 3 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 6 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 1 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 3 1 4 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 4 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS NOR2_X4

* cell AOI211_X2
* pin B
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI211_X2 1 2 3 4 6 7 8
* net 1 B
* net 2 A
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 10 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 7 2 10 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 9 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 5 1 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.055125P PS=0.77U PD=0.805U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 6 3 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.099225P AD=0.11025P PS=1.575U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 5 4 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 6 1 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0653625P PS=1.595U
+ PD=1.145U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 6 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 11 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.0363125P AD=0.02905P PS=0.59U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 6 4 11 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 12 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 8 3 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI211_X2

* cell OR3_X1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 8 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 5 1 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 4 2 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 5 3 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR3_X1

* cell AOI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X1 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 8 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 8 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 8 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 9 3 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X1

* cell OAI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI221_X1 1 2 3 4 5 7 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 12 1 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 12 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 5 11 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 8 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 6 2 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 10 3 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 9 4 10 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 10 5 9 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI221_X1

* cell NOR4_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin A4
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR4_X4 1 2 3 4 5 6 10
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 1.92,0.995 PMOS_VTL
M$1 8 4 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 2.68,0.995 PMOS_VTL
M$5 10 5 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.995 PMOS_VTL
M$9 6 2 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $13 r0 *1 0.93,0.995 PMOS_VTL
M$13 8 3 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 6 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 0.93,0.2975 NMOS_VTL
M$21 6 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 1.92,0.2975 NMOS_VTL
M$25 1 4 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 2.68,0.2975 NMOS_VTL
M$29 1 5 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NOR4_X4

* cell DFF_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 8 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 0.185,0.285 NMOS_VTL
M$17 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $18 r0 *1 0.375,0.345 NMOS_VTL
M$18 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $19 r0 *1 0.565,0.345 NMOS_VTL
M$19 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $20 r0 *1 1.14,0.285 NMOS_VTL
M$20 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $21 r0 *1 0.76,0.3175 NMOS_VTL
M$21 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $22 r0 *1 0.95,0.3175 NMOS_VTL
M$22 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $23 r0 *1 2.125,0.345 NMOS_VTL
M$23 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $24 r0 *1 2.32,0.345 NMOS_VTL
M$24 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $25 r0 *1 1.555,0.36 NMOS_VTL
M$25 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $26 r0 *1 1.745,0.36 NMOS_VTL
M$26 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $27 r0 *1 1.935,0.36 NMOS_VTL
M$27 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $28 r0 *1 2.51,0.36 NMOS_VTL
M$28 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
.ENDS DFF_X1

* cell DFF_X2
* pin PWELL,VSS
* pin D
* pin CK
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFF_X2 1 6 8 10 11 16
* net 1 PWELL,VSS
* net 6 D
* net 8 CK
* net 10 QN
* net 11 Q
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.855,0.995 PMOS_VTL
M$1 10 9 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.235,0.995 PMOS_VTL
M$3 11 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.2,0.9275 PMOS_VTL
M$5 16 7 3 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $6 r0 *1 0.39,1.04 PMOS_VTL
M$6 17 4 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $7 r0 *1 0.58,1.04 PMOS_VTL
M$7 17 7 5 16 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $8 r0 *1 0.77,0.975 PMOS_VTL
M$8 18 3 5 16 PMOS_VTL L=0.05U W=0.42U AS=0.01785P AD=0.0294P PS=0.56U PD=0.56U
* device instance $9 r0 *1 0.96,0.975 PMOS_VTL
M$9 16 6 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 1.15,1.0275 PMOS_VTL
M$10 4 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $11 r0 *1 2.135,0.915 PMOS_VTL
M$11 20 3 9 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $12 r0 *1 2.325,0.915 PMOS_VTL
M$12 20 2 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $13 r0 *1 1.565,1.0275 PMOS_VTL
M$13 16 8 7 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $14 r0 *1 1.755,1.0275 PMOS_VTL
M$14 19 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $15 r0 *1 1.945,1.0275 PMOS_VTL
M$15 9 7 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.515,0.995 PMOS_VTL
M$16 2 9 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 2.855,0.2975 NMOS_VTL
M$17 10 9 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $19 r0 *1 3.235,0.2975 NMOS_VTL
M$19 11 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $21 r0 *1 0.39,0.31 NMOS_VTL
M$21 12 4 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $22 r0 *1 0.58,0.31 NMOS_VTL
M$22 12 3 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $23 r0 *1 1.15,0.25 NMOS_VTL
M$23 4 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $24 r0 *1 0.77,0.2825 NMOS_VTL
M$24 13 7 5 1 NMOS_VTL L=0.05U W=0.275U AS=0.012775P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $25 r0 *1 0.96,0.2825 NMOS_VTL
M$25 1 6 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $26 r0 *1 0.2,0.37 NMOS_VTL
M$26 1 7 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $27 r0 *1 1.565,0.35 NMOS_VTL
M$27 1 8 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $28 r0 *1 1.755,0.35 NMOS_VTL
M$28 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $29 r0 *1 1.945,0.35 NMOS_VTL
M$29 9 3 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $30 r0 *1 2.135,0.41 NMOS_VTL
M$30 15 7 9 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $31 r0 *1 2.325,0.41 NMOS_VTL
M$31 15 2 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $32 r0 *1 2.515,0.2975 NMOS_VTL
M$32 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFF_X2

* cell LOGIC0_X1
* pin Z
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT LOGIC0_X1 1 3 4
* net 1 Z
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.185,1.19 PMOS_VTL
M$1 4 2 2 4 PMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
* device instance $2 r0 *1 0.185,0.21 NMOS_VTL
M$2 3 2 1 3 NMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
.ENDS LOGIC0_X1

* cell HA_X1
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin CO
.SUBCKT HA_X1 1 2 4 5 6 9
* net 1 A
* net 2 B
* net 4 S
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 9 CO
* device instance $1 r0 *1 0.785,1.0275 PMOS_VTL
M$1 10 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $2 r0 *1 0.975,1.0275 PMOS_VTL
M$2 7 1 10 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $3 r0 *1 0.21,0.995 PMOS_VTL
M$3 4 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $4 r0 *1 0.4,0.995 PMOS_VTL
M$4 3 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.59,0.995 PMOS_VTL
M$5 5 7 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0338625P PS=0.77U PD=0.775U
* device instance $6 r0 *1 1.345,1.0275 PMOS_VTL
M$6 8 1 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $7 r0 *1 1.535,1.0275 PMOS_VTL
M$7 8 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $8 r0 *1 1.725,0.995 PMOS_VTL
M$8 9 8 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.785,0.195 NMOS_VTL
M$9 7 2 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.0224P AD=0.0147P PS=0.56U PD=0.35U
* device instance $10 r0 *1 0.975,0.195 NMOS_VTL
M$10 6 1 7 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $11 r0 *1 0.21,0.2975 NMOS_VTL
M$11 11 2 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.4,0.2975 NMOS_VTL
M$12 4 1 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.59,0.2975 NMOS_VTL
M$13 6 7 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0224P PS=0.555U PD=0.56U
* device instance $14 r0 *1 1.345,0.195 NMOS_VTL
M$14 12 1 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $15 r0 *1 1.535,0.195 NMOS_VTL
M$15 6 2 12 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $16 r0 *1 1.725,0.2975 NMOS_VTL
M$16 9 8 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS HA_X1

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell AOI21_X4
* pin PWELL,VSS
* pin ZN
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
.SUBCKT AOI21_X4 1 2 3 4 5 11
* net 1 PWELL,VSS
* net 2 ZN
* net 3 A
* net 4 B2
* net 5 B1
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 11 3 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 2 4 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 10 5 2 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 2 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 8 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 2 5 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 9 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 6 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.895,0.2975 NMOS_VTL
M$22 2 5 6 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.085,0.2975 NMOS_VTL
M$23 7 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.275,0.2975 NMOS_VTL
M$24 1 4 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X4

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X2 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell AOI21_X2
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X2 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 9 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X2

* cell AOI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X2 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 8 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.125,0.995 PMOS_VTL
M$6 6 4 8 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 12 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.555,0.2975 NMOS_VTL
M$11 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.745,0.2975 NMOS_VTL
M$12 5 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.935,0.2975 NMOS_VTL
M$13 11 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.125,0.2975 NMOS_VTL
M$14 8 4 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.315,0.2975 NMOS_VTL
M$15 9 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.505,0.2975 NMOS_VTL
M$16 5 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X2

* cell NAND2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 4 1 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 5 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND2_X4

* cell AOI221_X2
* pin B1
* pin B2
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI221_X2 1 2 3 4 5 6 8 9
* net 1 B1
* net 2 B2
* net 3 A
* net 4 C2
* net 5 C1
* net 6 ZN
* net 8 NWELL,VDD
* net 9 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 3 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.09135P PS=2.24U PD=1.55U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 1 7 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.32,0.995 PMOS_VTL
M$7 6 4 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.09135P AD=0.11025P PS=1.55U PD=2.24U
* device instance $8 r0 *1 1.51,0.995 PMOS_VTL
M$8 10 5 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 6 3 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.060175P PS=1.595U
+ PD=1.12U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 14 1 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 9 2 14 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 13 2 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 6 1 13 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.32,0.2975 NMOS_VTL
M$17 12 4 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.031125P AD=0.02905P PS=0.565U
+ PD=0.555U
* device instance $18 r0 *1 1.51,0.2975 NMOS_VTL
M$18 6 5 12 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.7,0.2975 NMOS_VTL
M$19 11 5 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.89,0.2975 NMOS_VTL
M$20 9 4 11 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X2

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell NOR2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 4 1 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.21,0.2975 NMOS_VTL
M$5 5 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $6 r0 *1 0.4,0.2975 NMOS_VTL
M$6 3 2 5 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR2_X2

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell NOR4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 11 1 12 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 10 2 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 6 3 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 9 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 13 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 8 1 13 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 4 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 6 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 7 1 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 6 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 7 3 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR4_X2

* cell AND3_X1
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 4 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 8 1 4 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 9 2 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 6 3 9 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND3_X1

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell XNOR2_X2
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT XNOR2_X2 2 3 4 5 7
* net 2 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 1.135,0.995 PMOS_VTL
M$1 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 1.325,0.995 PMOS_VTL
M$2 9 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 1.515,0.995 PMOS_VTL
M$3 5 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 1.705,0.995 PMOS_VTL
M$4 8 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.18,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $7 r0 *1 0.56,0.995 PMOS_VTL
M$7 1 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 0.75,0.995 PMOS_VTL
M$8 5 2 1 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.135,0.2975 NMOS_VTL
M$9 6 2 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $11 r0 *1 1.515,0.2975 NMOS_VTL
M$11 6 3 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $13 r0 *1 0.18,0.2975 NMOS_VTL
M$13 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $15 r0 *1 0.56,0.2975 NMOS_VTL
M$15 10 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.75,0.2975 NMOS_VTL
M$16 1 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X2

* cell NOR3_X2
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 10 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 9 2 10 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 3 9 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 8 3 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 4 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 5 1 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 6 2 5 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 5 3 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR3_X2

* cell XNOR2_X1
* pin A
* pin B
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT XNOR2_X1 1 2 4 5 7
* net 1 A
* net 2 B
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.18,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.37,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 7 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 8 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 4 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.18,0.195 NMOS_VTL
M$6 9 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.37,0.195 NMOS_VTL
M$7 5 2 9 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.565,0.2975 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.755,0.2975 NMOS_VTL
M$9 7 1 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.945,0.2975 NMOS_VTL
M$10 6 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X1

* cell NAND4_X4
* pin PWELL,VSS
* pin A3
* pin A4
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X4 1 2 3 7 8 9 10
* net 1 PWELL,VSS
* net 2 A3
* net 3 A4
* net 7 A1
* net 8 A2
* net 9 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 10 7 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 10 8 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.22365P PS=3.08U PD=3.23U
* device instance $9 r0 *1 1.885,0.995 PMOS_VTL
M$9 10 2 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.22365P AD=0.1764P PS=3.23U PD=3.08U
* device instance $13 r0 *1 2.645,0.995 PMOS_VTL
M$13 10 3 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.885,0.2975 NMOS_VTL
M$17 5 2 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.645,0.2975 NMOS_VTL
M$21 1 3 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.215,0.2975 NMOS_VTL
M$25 9 7 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.975,0.2975 NMOS_VTL
M$29 5 8 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND4_X4

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell XOR2_X2
* pin B
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT XOR2_X2 1 2 4 5 7
* net 1 B
* net 2 A
* net 4 NWELL,VDD
* net 5 Z
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.2,0.995 PMOS_VTL
M$1 8 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.39,0.995 PMOS_VTL
M$2 4 1 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.58,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.77,0.995 PMOS_VTL
M$4 5 2 6 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.96,0.995 PMOS_VTL
M$5 6 1 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.2,0.2975 NMOS_VTL
M$9 3 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.39,0.2975 NMOS_VTL
M$10 7 1 3 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.58,0.2975 NMOS_VTL
M$11 5 3 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $12 r0 *1 0.77,0.2975 NMOS_VTL
M$12 10 2 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.96,0.2975 NMOS_VTL
M$13 7 1 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.15,0.2975 NMOS_VTL
M$14 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.34,0.2975 NMOS_VTL
M$15 5 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
.ENDS XOR2_X2

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4
