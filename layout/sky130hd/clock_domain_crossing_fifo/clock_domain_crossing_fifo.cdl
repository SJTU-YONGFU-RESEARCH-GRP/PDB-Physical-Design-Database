* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT clock_domain_crossing_fifo rd_almost_empty rd_clk
+ rd_count[0] rd_count[1] rd_count[2] rd_count[3] rd_count[4]
+ rd_data[0] rd_data[10] rd_data[11] rd_data[12] rd_data[13]
+ rd_data[14] rd_data[15] rd_data[16] rd_data[17] rd_data[18]
+ rd_data[19] rd_data[1] rd_data[20] rd_data[21] rd_data[22]
+ rd_data[23] rd_data[24] rd_data[25] rd_data[26] rd_data[27]
+ rd_data[28] rd_data[29] rd_data[2] rd_data[30] rd_data[31]
+ rd_data[3] rd_data[4] rd_data[5] rd_data[6] rd_data[7] rd_data[8]
+ rd_data[9] rd_empty rd_en rd_rst_n wr_almost_full wr_clk wr_count[0]
+ wr_count[1] wr_count[2] wr_count[3] wr_count[4] wr_data[0]
+ wr_data[10] wr_data[11] wr_data[12] wr_data[13] wr_data[14]
+ wr_data[15] wr_data[16] wr_data[17] wr_data[18] wr_data[19]
+ wr_data[1] wr_data[20] wr_data[21] wr_data[22] wr_data[23]
+ wr_data[24] wr_data[25] wr_data[26] wr_data[27] wr_data[28]
+ wr_data[29] wr_data[2] wr_data[30] wr_data[31] wr_data[3]
+ wr_data[4] wr_data[5] wr_data[6] wr_data[7] wr_data[8] wr_data[9]
+ wr_en wr_full wr_rst_n
X_0889_ rd_ptr_gray_sync2\[3\] rd_ptr_gray_sync2\[4\] VSS
+ VSS VDD VDD _0856_ sky130_fd_sc_hd__xnor2_1
X_0890_ rd_ptr_gray_sync2\[2\] _0856_ VSS VSS VDD VDD _0853_
+ sky130_fd_sc_hd__xor2_1
X_0891_ rd_ptr_gray_sync2\[1\] _0853_ VSS VSS VDD VDD _0846_
+ sky130_fd_sc_hd__xor2_1
X_0892_ _0888_ VSS VSS VDD VDD net79 sky130_fd_sc_hd__inv_1
X_0893_ rd_ptr_gray_sync2\[4\] wr_ptr_bin\[4\] VSS VSS VDD
+ VDD _0590_ sky130_fd_sc_hd__xnor2_4
X_0894_ _0858_ _0855_ _0852_ _0888_ VSS VSS VDD VDD _0591_
+ sky130_fd_sc_hd__nand4_2
X_0895_ _0590_ _0591_ VSS VSS VDD VDD net84 sky130_fd_sc_hd__nor2_1
X_0896_ wr_ptr_bin\[2\] VSS VSS VDD VDD _0592_ sky130_fd_sc_hd__clkbuf_4
X_0897_ wr_ptr_bin\[3\] VSS VSS VDD VDD _0593_ sky130_fd_sc_hd__clkbuf_4
X_0898_ net84 net37 VSS VSS VDD VDD _0594_ sky130_fd_sc_hd__nor2b_1
X_0899_ _0594_ VSS VSS VDD VDD _0595_ sky130_fd_sc_hd__clkbuf_4
X_0900_ _0592_ _0593_ _0595_ VSS VSS VDD VDD _0596_ sky130_fd_sc_hd__nand3_4
X_0901_ net38 _0872_ VSS VSS VDD VDD _0597_ sky130_fd_sc_hd__nand2_8
X_0902_ _0596_ _0597_ VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__nor2_8
X_0903_ _0842_ VSS VSS VDD VDD _0598_ sky130_fd_sc_hd__inv_1
X_0904_ _0598_ _0852_ _0851_ VSS VSS VDD VDD _0599_ sky130_fd_sc_hd__a21o_1
X_0905_ _0855_ _0599_ _0854_ VSS VSS VDD VDD _0600_ sky130_fd_sc_hd__a21oi_1
X_0906_ _0858_ _0600_ VSS VSS VDD VDD net82 sky130_fd_sc_hd__xnor2_1
X_0907_ _0844_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__inv_1
X_0908_ _0601_ _0855_ _0854_ VSS VSS VDD VDD _0602_ sky130_fd_sc_hd__a21o_1
X_0909_ _0858_ _0602_ _0857_ VSS VSS VDD VDD _0603_ sky130_fd_sc_hd__a21oi_1
X_0910_ _0590_ _0603_ VSS VSS VDD VDD net83 sky130_fd_sc_hd__xnor2_1
X_0911_ net38 _0871_ VSS VSS VDD VDD _0604_ sky130_fd_sc_hd__nand2_8
X_0912_ _0590_ _0591_ net37 VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__o21ai_4
X_0913_ _0592_ _0593_ _0605_ VSS VSS VDD VDD _0606_ sky130_fd_sc_hd__or3_4
X_0914_ _0604_ _0606_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__nor2_8
X_0915_ net38 _0874_ VSS VSS VDD VDD _0607_ sky130_fd_sc_hd__nand2_8
X_0916_ _0606_ _0607_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__nor2_8
X_0917_ _0597_ _0606_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__nor2_8
X_0918_ _0876_ VSS VSS VDD VDD _0608_ sky130_fd_sc_hd__clkbuf_4
X_0919_ net38 _0608_ VSS VSS VDD VDD _0609_ sky130_fd_sc_hd__nand2_8
X_0920_ _0606_ _0609_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__nor2_8
X_0921_ _0593_ _0595_ _0592_ VSS VSS VDD VDD _0610_ sky130_fd_sc_hd__nand3b_4
X_0922_ _0604_ _0610_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__nor2_8
X_0923_ _0607_ _0610_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__nor2_8
X_0924_ _0597_ _0610_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__nor2_8
X_0925_ _0609_ _0610_ VSS VSS VDD VDD _0008_ sky130_fd_sc_hd__nor2_8
X_0926_ _0592_ _0593_ _0595_ VSS VSS VDD VDD _0611_ sky130_fd_sc_hd__nand3b_4
X_0927_ _0604_ _0611_ VSS VSS VDD VDD _0007_ sky130_fd_sc_hd__nor2_8
X_0928_ _0607_ _0611_ VSS VSS VDD VDD _0006_ sky130_fd_sc_hd__nor2_8
X_0929_ _0597_ _0611_ VSS VSS VDD VDD _0005_ sky130_fd_sc_hd__nor2_8
X_0930_ _0609_ _0611_ VSS VSS VDD VDD _0004_ sky130_fd_sc_hd__nor2_8
X_0931_ _0596_ _0604_ VSS VSS VDD VDD _0003_ sky130_fd_sc_hd__nor2_8
X_0932_ _0596_ _0609_ VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__nor2_8
X_0933_ _0596_ _0607_ VSS VSS VDD VDD _0002_ sky130_fd_sc_hd__nor2_8
X_0934_ wr_ptr_gray_sync2\[3\] wr_ptr_gray_sync2\[4\] VSS
+ VSS VDD VDD _0864_ sky130_fd_sc_hd__xor2_1
X_0935_ wr_ptr_gray_sync2\[2\] _0864_ VSS VSS VDD VDD _0612_
+ sky130_fd_sc_hd__xnor2_1
X_0936_ wr_ptr_gray_sync2\[1\] _0612_ VSS VSS VDD VDD _0848_
+ sky130_fd_sc_hd__xor2_2
X_0937_ _0850_ VSS VSS VDD VDD net41 sky130_fd_sc_hd__inv_1
X_0938_ _0849_ _0870_ VSS VSS VDD VDD net42 sky130_fd_sc_hd__xnor2_1
X_0939_ _0847_ VSS VSS VDD VDD _0613_ sky130_fd_sc_hd__inv_1
X_0940_ _0862_ _0613_ _0861_ VSS VSS VDD VDD _0614_ sky130_fd_sc_hd__a21o_1
X_0941_ _0870_ _0614_ _0869_ VSS VSS VDD VDD _0615_ sky130_fd_sc_hd__a21oi_1
X_0942_ _0866_ _0615_ VSS VSS VDD VDD net43 sky130_fd_sc_hd__xnor2_1
X_0943_ wr_ptr_gray_sync2\[4\] rd_ptr_bin\[4\] VSS VSS VDD
+ VDD _0616_ sky130_fd_sc_hd__xor2_1
X_0944_ _0849_ VSS VSS VDD VDD _0617_ sky130_fd_sc_hd__inv_1
X_0945_ _0617_ _0870_ _0869_ VSS VSS VDD VDD _0618_ sky130_fd_sc_hd__a21o_1
X_0946_ _0866_ _0618_ _0865_ VSS VSS VDD VDD _0619_ sky130_fd_sc_hd__a21oi_1
X_0947_ _0616_ _0619_ VSS VSS VDD VDD net44 sky130_fd_sc_hd__xor2_1
X_0948_ wr_ptr_gray_sync2\[2\] rd_ptr_gray\[2\] VSS VSS VDD
+ VDD _0620_ sky130_fd_sc_hd__xor2_1
X_0949_ wr_ptr_gray_sync2\[1\] rd_ptr_gray\[1\] VSS VSS VDD
+ VDD _0621_ sky130_fd_sc_hd__xor2_1
X_0950_ wr_ptr_gray_sync2\[0\] rd_ptr_gray\[0\] VSS VSS VDD
+ VDD _0622_ sky130_fd_sc_hd__xor2_1
X_0951_ wr_ptr_gray_sync2\[3\] rd_ptr_gray\[3\] VSS VSS VDD
+ VDD _0623_ sky130_fd_sc_hd__xor2_1
X_0952_ _0616_ _0622_ _0623_ VSS VSS VDD VDD _0624_ sky130_fd_sc_hd__or3_1
X_0953_ _0620_ _0621_ _0624_ VSS VSS VDD VDD _0625_ sky130_fd_sc_hd__or3_1
X_0954_ _0625_ VSS VSS VDD VDD net77 sky130_fd_sc_hd__inv_1
X_0955_ rd_ptr_bin\[2\] VSS VSS VDD VDD _0626_ sky130_fd_sc_hd__buf_4
X_0956_ _0626_ VSS VSS VDD VDD _0627_ sky130_fd_sc_hd__inv_2
X_0957_ _0627_ VSS VSS VDD VDD _0628_ sky130_fd_sc_hd__clkbuf_4
X_0958_ _0628_ VSS VSS VDD VDD _0867_ sky130_fd_sc_hd__clkbuf_8
X_0959_ rd_ptr_bin\[3\] VSS VSS VDD VDD _0629_ sky130_fd_sc_hd__buf_4
X_0960_ _0629_ VSS VSS VDD VDD _0630_ sky130_fd_sc_hd__clkinv_2
X_0961_ _0630_ VSS VSS VDD VDD _0863_ sky130_fd_sc_hd__buf_6
X_0962_ _0846_ VSS VSS VDD VDD _0843_ sky130_fd_sc_hd__inv_1
X_0963_ wr_ptr_bin\[0\] VSS VSS VDD VDD _0631_ sky130_fd_sc_hd__clkbuf_2
X_0964_ _0631_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__inv_1
X_0965_ rd_ptr_bin\[0\] VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__inv_1
X_0966_ _0848_ VSS VSS VDD VDD _0860_ sky130_fd_sc_hd__inv_1
X_0967_ _0612_ VSS VSS VDD VDD _0868_ sky130_fd_sc_hd__inv_1
X_0968_ wr_ptr_bin\[1\] VSS VSS VDD VDD _0841_ sky130_fd_sc_hd__clkinvlp_4
X_0969_ rd_ptr_bin\[1\] VSS VSS VDD VDD _0859_ sky130_fd_sc_hd__inv_1
X_0970_ wr_ptr_gray_sync2\[0\] _0848_ VSS VSS VDD VDD _0885_
+ sky130_fd_sc_hd__xor2_1
X_0971_ rd_ptr_gray_sync2\[0\] _0846_ VSS VSS VDD VDD _0887_
+ sky130_fd_sc_hd__xnor2_1
X_0972_ _0886_ VSS VSS VDD VDD net40 sky130_fd_sc_hd__inv_1
X_0973_ _0620_ _0621_ _0624_ net2 VSS VSS VDD VDD _0632_ sky130_fd_sc_hd__o31ai_4
X_0974_ _0632_ VSS VSS VDD VDD _0633_ sky130_fd_sc_hd__buf_6
X_0975_ _0878_ VSS VSS VDD VDD _0634_ sky130_fd_sc_hd__clkbuf_4
X_0976_ rd_ptr_bin\[3\] rd_ptr_bin\[2\] _0634_ VSS VSS VDD
+ VDD _0635_ sky130_fd_sc_hd__o21ai_2
X_0977_ _0635_ VSS VSS VDD VDD _0636_ sky130_fd_sc_hd__buf_4
X_0978_ _0883_ VSS VSS VDD VDD _0637_ sky130_fd_sc_hd__clkbuf_4
X_0979_ _0881_ VSS VSS VDD VDD _0638_ sky130_fd_sc_hd__buf_4
X_0980_ _0637_ _0879_ _0638_ VSS VSS VDD VDD _0639_ sky130_fd_sc_hd__nor3_2
X_0981_ _0639_ VSS VSS VDD VDD _0640_ sky130_fd_sc_hd__buf_4
X_0982_ _0636_ _0640_ VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__nand2_2
X_0983_ mem\[0\]\[0\] _0641_ VSS VSS VDD VDD _0642_ sky130_fd_sc_hd__nor2_1
X_0984_ _0633_ _0642_ VSS VSS VDD VDD _0643_ sky130_fd_sc_hd__nor2_1
X_0985_ _0629_ VSS VSS VDD VDD _0644_ sky130_fd_sc_hd__clkbuf_8
X_0986_ _0644_ VSS VSS VDD VDD _0645_ sky130_fd_sc_hd__buf_4
X_0987_ _0879_ VSS VSS VDD VDD _0646_ sky130_fd_sc_hd__buf_4
X_0988_ _0646_ VSS VSS VDD VDD _0647_ sky130_fd_sc_hd__buf_4
X_0989_ _0626_ VSS VSS VDD VDD _0648_ sky130_fd_sc_hd__buf_6
X_0990_ _0648_ VSS VSS VDD VDD _0649_ sky130_fd_sc_hd__clkbuf_4
X_0991_ mem\[10\]\[0\] _0647_ _0649_ VSS VSS VDD VDD _0650_
+ sky130_fd_sc_hd__a21oi_1
X_0992_ _0634_ VSS VSS VDD VDD _0651_ sky130_fd_sc_hd__clkbuf_8
X_0993_ _0638_ VSS VSS VDD VDD _0652_ sky130_fd_sc_hd__buf_4
X_0994_ mem\[12\]\[0\] _0651_ _0652_ mem\[13\]\[0\] VSS VSS
+ VDD VDD _0653_ sky130_fd_sc_hd__a22oi_1
X_0995_ _0648_ VSS VSS VDD VDD _0654_ sky130_fd_sc_hd__buf_4
X_0996_ _0654_ VSS VSS VDD VDD _0655_ sky130_fd_sc_hd__buf_4
X_0997_ _0626_ _0637_ VSS VSS VDD VDD _0656_ sky130_fd_sc_hd__nor2b_1
X_0998_ _0656_ VSS VSS VDD VDD _0657_ sky130_fd_sc_hd__buf_6
X_0999_ _0657_ VSS VSS VDD VDD _0658_ sky130_fd_sc_hd__buf_6
X_1000_ _0629_ VSS VSS VDD VDD _0659_ sky130_fd_sc_hd__clkbuf_4
X_1001_ _0659_ VSS VSS VDD VDD _0660_ sky130_fd_sc_hd__buf_4
X_1002_ mem\[3\]\[0\] _0658_ _0660_ VSS VSS VDD VDD _0661_
+ sky130_fd_sc_hd__a21oi_1
X_1003_ _0645_ _0650_ _0653_ _0655_ _0661_ VSS VSS VDD VDD
+ _0662_ sky130_fd_sc_hd__a221o_1
X_1004_ _0644_ VSS VSS VDD VDD _0663_ sky130_fd_sc_hd__buf_6
X_1005_ _0663_ VSS VSS VDD VDD _0664_ sky130_fd_sc_hd__clkbuf_4
X_1006_ _0649_ VSS VSS VDD VDD _0665_ sky130_fd_sc_hd__buf_4
X_1007_ _0879_ VSS VSS VDD VDD _0666_ sky130_fd_sc_hd__clkbuf_8
X_1008_ _0666_ VSS VSS VDD VDD _0667_ sky130_fd_sc_hd__clkbuf_4
X_1009_ mem\[2\]\[0\] _0667_ VSS VSS VDD VDD _0668_ sky130_fd_sc_hd__nand2_1
X_1010_ _0634_ VSS VSS VDD VDD _0669_ sky130_fd_sc_hd__buf_4
X_1011_ _0669_ VSS VSS VDD VDD _0670_ sky130_fd_sc_hd__buf_4
X_1012_ _0665_ mem\[4\]\[0\] _0670_ VSS VSS VDD VDD _0671_
+ sky130_fd_sc_hd__nand3_1
X_1013_ _0665_ _0668_ _0671_ VSS VSS VDD VDD _0672_ sky130_fd_sc_hd__o21ai_0
X_1014_ _0649_ VSS VSS VDD VDD _0673_ sky130_fd_sc_hd__buf_4
X_1015_ _0638_ VSS VSS VDD VDD _0674_ sky130_fd_sc_hd__clkbuf_4
X_1016_ _0674_ VSS VSS VDD VDD _0675_ sky130_fd_sc_hd__buf_4
X_1017_ mem\[9\]\[0\] _0675_ VSS VSS VDD VDD _0676_ sky130_fd_sc_hd__nand2_1
X_1018_ _0646_ VSS VSS VDD VDD _0677_ sky130_fd_sc_hd__buf_6
X_1019_ _0677_ VSS VSS VDD VDD _0678_ sky130_fd_sc_hd__buf_4
X_1020_ _0665_ mem\[14\]\[0\] _0678_ VSS VSS VDD VDD _0679_
+ sky130_fd_sc_hd__nand3_1
X_1021_ _0673_ _0676_ _0679_ _0664_ VSS VSS VDD VDD _0680_
+ sky130_fd_sc_hd__o211ai_1
X_1022_ _0664_ _0672_ _0680_ VSS VSS VDD VDD _0681_ sky130_fd_sc_hd__o21ai_0
X_1023_ _0630_ VSS VSS VDD VDD _0682_ sky130_fd_sc_hd__buf_4
X_1024_ _0646_ VSS VSS VDD VDD _0683_ sky130_fd_sc_hd__buf_4
X_1025_ rd_ptr_bin\[3\] _0637_ VSS VSS VDD VDD _0684_ sky130_fd_sc_hd__and2_0
X_1026_ _0684_ VSS VSS VDD VDD _0685_ sky130_fd_sc_hd__dlymetal6s2s_1
X_1027_ _0685_ VSS VSS VDD VDD _0686_ sky130_fd_sc_hd__buf_4
X_1028_ _0682_ mem\[6\]\[0\] _0683_ _0686_ mem\[15\]\[0\]
+ VSS VSS VDD VDD _0687_ sky130_fd_sc_hd__a32o_1
X_1029_ _0663_ VSS VSS VDD VDD _0688_ sky130_fd_sc_hd__buf_4
X_1030_ mem\[1\]\[0\] _0675_ VSS VSS VDD VDD _0689_ sky130_fd_sc_hd__nand2_1
X_1031_ _0645_ mem\[8\]\[0\] _0670_ VSS VSS VDD VDD _0690_
+ sky130_fd_sc_hd__nand3_1
X_1032_ _0688_ _0689_ _0690_ _0867_ VSS VSS VDD VDD _0691_
+ sky130_fd_sc_hd__o211ai_1
X_1033_ _0867_ _0687_ _0691_ VSS VSS VDD VDD _0692_ sky130_fd_sc_hd__o21ai_0
X_1034_ _0629_ _0648_ _0638_ VSS VSS VDD VDD _0693_ sky130_fd_sc_hd__and3b_1
X_1035_ _0693_ VSS VSS VDD VDD _0694_ sky130_fd_sc_hd__clkbuf_8
X_1036_ _0629_ _0626_ VSS VSS VDD VDD _0695_ sky130_fd_sc_hd__nor2b_1
X_1037_ _0626_ _0629_ VSS VSS VDD VDD _0696_ sky130_fd_sc_hd__nor2b_4
X_1038_ mem\[7\]\[0\] _0695_ _0696_ mem\[11\]\[0\] VSS VSS
+ VDD VDD _0697_ sky130_fd_sc_hd__a22o_1
X_1039_ _0637_ VSS VSS VDD VDD _0698_ sky130_fd_sc_hd__buf_4
X_1040_ _0635_ _0639_ VSS VSS VDD VDD _0699_ sky130_fd_sc_hd__and2_0
X_1041_ mem\[5\]\[0\] _0694_ _0697_ _0698_ _0699_ VSS VSS
+ VDD VDD _0700_ sky130_fd_sc_hd__a221oi_1
X_1042_ _0662_ _0681_ _0692_ _0700_ VSS VSS VDD VDD _0701_
+ sky130_fd_sc_hd__nand4_1
X_1043_ net45 _0633_ _0643_ _0701_ VSS VSS VDD VDD _0020_
+ sky130_fd_sc_hd__a22o_1
X_1044_ _0632_ VSS VSS VDD VDD _0702_ sky130_fd_sc_hd__buf_4
X_1045_ _0648_ VSS VSS VDD VDD _0703_ sky130_fd_sc_hd__clkbuf_4
X_1046_ _0703_ VSS VSS VDD VDD _0704_ sky130_fd_sc_hd__clkbuf_4
X_1047_ _0698_ mem\[15\]\[10\] mem\[14\]\[10\] _0647_ VSS
+ VSS VDD VDD _0705_ sky130_fd_sc_hd__a22oi_1
X_1048_ _0646_ VSS VSS VDD VDD _0706_ sky130_fd_sc_hd__buf_4
X_1049_ _0698_ mem\[7\]\[10\] mem\[6\]\[10\] _0706_ _0663_
+ VSS VSS VDD VDD _0707_ sky130_fd_sc_hd__a221oi_1
X_1050_ _0660_ _0705_ _0707_ VSS VSS VDD VDD _0708_ sky130_fd_sc_hd__a21oi_1
X_1051_ _0634_ VSS VSS VDD VDD _0709_ sky130_fd_sc_hd__buf_4
X_1052_ _0638_ VSS VSS VDD VDD _0710_ sky130_fd_sc_hd__buf_4
X_1053_ _0629_ VSS VSS VDD VDD _0711_ sky130_fd_sc_hd__buf_4
X_1054_ _0626_ VSS VSS VDD VDD _0712_ sky130_fd_sc_hd__clkbuf_4
X_1055_ _0711_ _0712_ VSS VSS VDD VDD _0713_ sky130_fd_sc_hd__nand2_4
X_1056_ mem\[12\]\[10\] _0709_ _0710_ mem\[13\]\[10\] _0713_
+ VSS VSS VDD VDD _0714_ sky130_fd_sc_hd__a221oi_1
X_1057_ _0629_ _0648_ VSS VSS VDD VDD _0715_ sky130_fd_sc_hd__nand2b_2
X_1058_ mem\[4\]\[10\] _0709_ _0710_ mem\[5\]\[10\] _0715_
+ VSS VSS VDD VDD _0716_ sky130_fd_sc_hd__a221oi_1
X_1059_ _0638_ VSS VSS VDD VDD _0717_ sky130_fd_sc_hd__buf_4
X_1060_ mem\[10\]\[10\] _0646_ _0717_ mem\[9\]\[10\] VSS VSS
+ VDD VDD _0718_ sky130_fd_sc_hd__a22oi_1
X_1061_ _0637_ VSS VSS VDD VDD _0719_ sky130_fd_sc_hd__buf_6
X_1062_ _0719_ mem\[3\]\[10\] mem\[2\]\[10\] _0666_ VSS VSS
+ VDD VDD _0720_ sky130_fd_sc_hd__a22oi_1
X_1063_ _0644_ _0648_ VSS VSS VDD VDD _0721_ sky130_fd_sc_hd__nor2_4
X_1064_ _0696_ _0718_ _0720_ _0721_ VSS VSS VDD VDD _0722_
+ sky130_fd_sc_hd__a22o_1
X_1065_ _0714_ _0716_ _0722_ VSS VSS VDD VDD _0723_ sky130_fd_sc_hd__nor3_1
X_1066_ _0682_ mem\[1\]\[10\] _0652_ _0686_ mem\[11\]\[10\]
+ VSS VSS VDD VDD _0724_ sky130_fd_sc_hd__a32oi_1
X_1067_ _0660_ mem\[8\]\[10\] _0670_ VSS VSS VDD VDD _0725_
+ sky130_fd_sc_hd__nand3_1
X_1068_ _0724_ _0725_ _0673_ VSS VSS VDD VDD _0726_ sky130_fd_sc_hd__a21oi_1
X_1069_ _0699_ VSS VSS VDD VDD _0727_ sky130_fd_sc_hd__clkbuf_8
X_1070_ _0704_ _0708_ _0723_ _0726_ _0727_ VSS VSS VDD VDD
+ _0728_ sky130_fd_sc_hd__a2111oi_0
X_1071_ _0641_ VSS VSS VDD VDD _0729_ sky130_fd_sc_hd__buf_4
X_1072_ mem\[0\]\[10\] _0729_ VSS VSS VDD VDD _0730_ sky130_fd_sc_hd__nor2_1
X_1073_ _0633_ VSS VSS VDD VDD _0731_ sky130_fd_sc_hd__buf_4
X_1074_ net46 _0731_ VSS VSS VDD VDD _0732_ sky130_fd_sc_hd__nand2_1
X_1075_ _0702_ _0728_ _0730_ _0732_ VSS VSS VDD VDD _0021_
+ sky130_fd_sc_hd__o31ai_1
X_1076_ _0657_ VSS VSS VDD VDD _0733_ sky130_fd_sc_hd__buf_6
X_1077_ _0644_ VSS VSS VDD VDD _0734_ sky130_fd_sc_hd__clkbuf_4
X_1078_ mem\[3\]\[11\] _0733_ _0734_ VSS VSS VDD VDD _0735_
+ sky130_fd_sc_hd__a21oi_1
X_1079_ _0637_ VSS VSS VDD VDD _0736_ sky130_fd_sc_hd__buf_6
X_1080_ _0646_ VSS VSS VDD VDD _0737_ sky130_fd_sc_hd__buf_4
X_1081_ _0736_ mem\[7\]\[11\] mem\[4\]\[11\] _0669_ _0737_
+ mem\[6\]\[11\] VSS VSS VDD VDD _0738_ sky130_fd_sc_hd__a222oi_1
X_1082_ rd_ptr_bin\[2\] _0879_ VSS VSS VDD VDD _0739_ sky130_fd_sc_hd__nor2b_1
X_1083_ _0739_ VSS VSS VDD VDD _0740_ sky130_fd_sc_hd__buf_2
X_1084_ _0740_ VSS VSS VDD VDD _0741_ sky130_fd_sc_hd__clkbuf_4
X_1085_ _0630_ VSS VSS VDD VDD _0742_ sky130_fd_sc_hd__buf_4
X_1086_ mem\[10\]\[11\] _0741_ _0742_ VSS VSS VDD VDD _0743_
+ sky130_fd_sc_hd__a21oi_1
X_1087_ _0638_ VSS VSS VDD VDD _0744_ sky130_fd_sc_hd__clkbuf_4
X_1088_ mem\[14\]\[11\] _0677_ _0744_ mem\[13\]\[11\] mem\[12\]\[11\]
+ _0651_ VSS VSS VDD VDD _0745_ sky130_fd_sc_hd__a222oi_1
X_1089_ _0735_ _0738_ _0743_ _0745_ VSS VSS VDD VDD _0746_
+ sky130_fd_sc_hd__a22oi_1
X_1090_ _0735_ _0743_ _0867_ VSS VSS VDD VDD _0747_ sky130_fd_sc_hd__o21ai_0
X_1091_ _0630_ VSS VSS VDD VDD _0748_ sky130_fd_sc_hd__buf_4
X_1092_ _0685_ VSS VSS VDD VDD _0749_ sky130_fd_sc_hd__buf_4
X_1093_ _0748_ mem\[1\]\[11\] _0652_ _0749_ mem\[11\]\[11\]
+ VSS VSS VDD VDD _0750_ sky130_fd_sc_hd__a32oi_1
X_1094_ _0628_ VSS VSS VDD VDD _0751_ sky130_fd_sc_hd__clkbuf_4
X_1095_ _0626_ VSS VSS VDD VDD _0752_ sky130_fd_sc_hd__buf_4
X_1096_ _0638_ VSS VSS VDD VDD _0753_ sky130_fd_sc_hd__buf_2
X_1097_ _0752_ mem\[5\]\[11\] _0753_ VSS VSS VDD VDD _0754_
+ sky130_fd_sc_hd__and3_1
X_1098_ _0751_ mem\[2\]\[11\] _0683_ _0754_ VSS VSS VDD VDD
+ _0755_ sky130_fd_sc_hd__a31oi_1
X_1099_ _0665_ _0750_ _0755_ _0664_ VSS VSS VDD VDD _0756_
+ sky130_fd_sc_hd__o22ai_1
X_1100_ _0629_ _0627_ VSS VSS VDD VDD _0757_ sky130_fd_sc_hd__nand2_4
X_1101_ _0757_ VSS VSS VDD VDD _0758_ sky130_fd_sc_hd__buf_4
X_1102_ _0634_ VSS VSS VDD VDD _0759_ sky130_fd_sc_hd__buf_4
X_1103_ _0759_ VSS VSS VDD VDD _0760_ sky130_fd_sc_hd__buf_6
X_1104_ mem\[8\]\[11\] _0760_ _0675_ mem\[9\]\[11\] VSS VSS
+ VDD VDD _0761_ sky130_fd_sc_hd__a22oi_1
X_1105_ _0629_ _0626_ _0637_ VSS VSS VDD VDD _0762_ sky130_fd_sc_hd__and3_1
X_1106_ _0762_ VSS VSS VDD VDD _0763_ sky130_fd_sc_hd__buf_4
X_1107_ _0763_ VSS VSS VDD VDD _0764_ sky130_fd_sc_hd__buf_4
X_1108_ mem\[15\]\[11\] _0764_ VSS VSS VDD VDD _0765_ sky130_fd_sc_hd__nand2_1
X_1109_ _0758_ _0761_ _0765_ VSS VSS VDD VDD _0766_ sky130_fd_sc_hd__o21ai_0
X_1110_ _0746_ _0747_ _0727_ _0756_ _0766_ VSS VSS VDD VDD
+ _0767_ sky130_fd_sc_hd__a2111oi_1
X_1111_ mem\[0\]\[11\] _0729_ VSS VSS VDD VDD _0768_ sky130_fd_sc_hd__nor2_1
X_1112_ net47 _0731_ VSS VSS VDD VDD _0769_ sky130_fd_sc_hd__nand2_1
X_1113_ _0702_ _0767_ _0768_ _0769_ VSS VSS VDD VDD _0022_
+ sky130_fd_sc_hd__o31ai_1
X_1114_ _0644_ VSS VSS VDD VDD _0770_ sky130_fd_sc_hd__buf_4
X_1115_ _0770_ _0703_ mem\[14\]\[12\] VSS VSS VDD VDD _0771_
+ sky130_fd_sc_hd__and3_1
X_1116_ _0663_ _0649_ mem\[2\]\[12\] VSS VSS VDD VDD _0772_
+ sky130_fd_sc_hd__nor3b_1
X_1117_ _0771_ _0772_ _0678_ VSS VSS VDD VDD _0773_ sky130_fd_sc_hd__o21ai_0
X_1118_ _0770_ mem\[12\]\[12\] _0709_ VSS VSS VDD VDD _0774_
+ sky130_fd_sc_hd__and3_1
X_1119_ _0711_ mem\[6\]\[12\] _0677_ VSS VSS VDD VDD _0775_
+ sky130_fd_sc_hd__and3b_1
X_1120_ _0774_ _0775_ _0673_ VSS VSS VDD VDD _0776_ sky130_fd_sc_hd__o21ai_0
X_1121_ mem\[1\]\[12\] _0675_ _0721_ _0636_ _0640_ VSS VSS
+ VDD VDD _0777_ sky130_fd_sc_hd__a32oi_1
X_1122_ _0711_ _0703_ mem\[7\]\[12\] VSS VSS VDD VDD _0778_
+ sky130_fd_sc_hd__and3b_1
X_1123_ _0703_ mem\[11\]\[12\] _0659_ VSS VSS VDD VDD _0779_
+ sky130_fd_sc_hd__and3b_1
X_1124_ _0778_ _0779_ _0698_ VSS VSS VDD VDD _0780_ sky130_fd_sc_hd__o21ai_0
X_1125_ _0773_ _0776_ _0777_ _0780_ VSS VSS VDD VDD _0781_
+ sky130_fd_sc_hd__nand4_1
X_1126_ mem\[8\]\[12\] _0670_ _0675_ mem\[9\]\[12\] VSS VSS
+ VDD VDD _0782_ sky130_fd_sc_hd__a22oi_1
X_1127_ _0752_ VSS VSS VDD VDD _0783_ sky130_fd_sc_hd__buf_4
X_1128_ _0783_ mem\[4\]\[12\] _0760_ _0658_ mem\[3\]\[12\]
+ VSS VSS VDD VDD _0784_ sky130_fd_sc_hd__a32oi_1
X_1129_ mem\[15\]\[12\] _0764_ VSS VSS VDD VDD _0785_ sky130_fd_sc_hd__nand2_1
X_1130_ _0758_ _0782_ _0784_ _0664_ _0785_ VSS VSS VDD VDD
+ _0786_ sky130_fd_sc_hd__o221ai_1
X_1131_ mem\[10\]\[12\] _0683_ VSS VSS VDD VDD _0787_ sky130_fd_sc_hd__nand2_1
X_1132_ _0649_ mem\[13\]\[12\] _0652_ VSS VSS VDD VDD _0788_
+ sky130_fd_sc_hd__nand3_1
X_1133_ _0783_ _0787_ _0788_ VSS VSS VDD VDD _0789_ sky130_fd_sc_hd__o21ai_0
X_1134_ mem\[5\]\[12\] _0694_ _0789_ _0664_ VSS VSS VDD VDD
+ _0790_ sky130_fd_sc_hd__a22o_1
X_1135_ _0781_ _0786_ _0790_ VSS VSS VDD VDD _0791_ sky130_fd_sc_hd__nor3_1
X_1136_ mem\[0\]\[12\] _0729_ VSS VSS VDD VDD _0792_ sky130_fd_sc_hd__nor2_1
X_1137_ net48 _0731_ VSS VSS VDD VDD _0793_ sky130_fd_sc_hd__nand2_1
X_1138_ _0702_ _0791_ _0792_ _0793_ VSS VSS VDD VDD _0023_
+ sky130_fd_sc_hd__o31ai_1
X_1139_ mem\[3\]\[13\] _0733_ _0734_ VSS VSS VDD VDD _0794_
+ sky130_fd_sc_hd__a21oi_1
X_1140_ _0736_ mem\[7\]\[13\] mem\[4\]\[13\] _0669_ _0737_
+ mem\[6\]\[13\] VSS VSS VDD VDD _0795_ sky130_fd_sc_hd__a222oi_1
X_1141_ mem\[10\]\[13\] _0741_ _0742_ VSS VSS VDD VDD _0796_
+ sky130_fd_sc_hd__a21oi_1
X_1142_ mem\[14\]\[13\] _0677_ _0744_ mem\[13\]\[13\] mem\[12\]\[13\]
+ _0651_ VSS VSS VDD VDD _0797_ sky130_fd_sc_hd__a222oi_1
X_1143_ _0794_ _0795_ _0796_ _0797_ VSS VSS VDD VDD _0798_
+ sky130_fd_sc_hd__a22oi_1
X_1144_ _0794_ _0796_ _0867_ VSS VSS VDD VDD _0799_ sky130_fd_sc_hd__o21ai_0
X_1145_ _0748_ mem\[1\]\[13\] _0652_ _0749_ mem\[11\]\[13\]
+ VSS VSS VDD VDD _0800_ sky130_fd_sc_hd__a32oi_1
X_1146_ _0752_ mem\[5\]\[13\] _0753_ VSS VSS VDD VDD _0801_
+ sky130_fd_sc_hd__and3_1
X_1147_ _0751_ mem\[2\]\[13\] _0683_ _0801_ VSS VSS VDD VDD
+ _0802_ sky130_fd_sc_hd__a31oi_1
X_1148_ _0665_ _0800_ _0802_ _0664_ VSS VSS VDD VDD _0803_
+ sky130_fd_sc_hd__o22ai_1
X_1149_ mem\[8\]\[13\] _0760_ _0675_ mem\[9\]\[13\] VSS VSS
+ VDD VDD _0804_ sky130_fd_sc_hd__a22oi_1
X_1150_ mem\[15\]\[13\] _0764_ VSS VSS VDD VDD _0805_ sky130_fd_sc_hd__nand2_1
X_1151_ _0758_ _0804_ _0805_ VSS VSS VDD VDD _0806_ sky130_fd_sc_hd__o21ai_0
X_1152_ _0798_ _0799_ _0727_ _0803_ _0806_ VSS VSS VDD VDD
+ _0807_ sky130_fd_sc_hd__a2111oi_1
X_1153_ mem\[0\]\[13\] _0729_ VSS VSS VDD VDD _0808_ sky130_fd_sc_hd__nor2_1
X_1154_ net49 _0731_ VSS VSS VDD VDD _0809_ sky130_fd_sc_hd__nand2_1
X_1155_ _0702_ _0807_ _0808_ _0809_ VSS VSS VDD VDD _0024_
+ sky130_fd_sc_hd__o31ai_1
X_1156_ _0682_ mem\[6\]\[14\] _0647_ _0686_ mem\[15\]\[14\]
+ VSS VSS VDD VDD _0810_ sky130_fd_sc_hd__a32o_1
X_1157_ _0711_ VSS VSS VDD VDD _0811_ sky130_fd_sc_hd__clkbuf_4
X_1158_ _0811_ mem\[8\]\[14\] _0670_ VSS VSS VDD VDD _0812_
+ sky130_fd_sc_hd__nand3_1
X_1159_ _0638_ VSS VSS VDD VDD _0813_ sky130_fd_sc_hd__buf_2
X_1160_ _0813_ VSS VSS VDD VDD _0814_ sky130_fd_sc_hd__clkbuf_4
X_1161_ _0863_ mem\[1\]\[14\] _0814_ VSS VSS VDD VDD _0815_
+ sky130_fd_sc_hd__nand3_1
X_1162_ _0649_ VSS VSS VDD VDD _0816_ sky130_fd_sc_hd__clkbuf_4
X_1163_ _0812_ _0815_ _0816_ VSS VSS VDD VDD _0817_ sky130_fd_sc_hd__a21oi_1
X_1164_ _0813_ VSS VSS VDD VDD _0818_ sky130_fd_sc_hd__clkbuf_4
X_1165_ _0783_ mem\[13\]\[14\] _0818_ VSS VSS VDD VDD _0819_
+ sky130_fd_sc_hd__nand3_1
X_1166_ _0628_ VSS VSS VDD VDD _0820_ sky130_fd_sc_hd__buf_4
X_1167_ _0820_ mem\[10\]\[14\] _0667_ VSS VSS VDD VDD _0821_
+ sky130_fd_sc_hd__nand3_1
X_1168_ _0626_ VSS VSS VDD VDD _0822_ sky130_fd_sc_hd__clkbuf_4
X_1169_ _0634_ VSS VSS VDD VDD _0823_ sky130_fd_sc_hd__clkbuf_4
X_1170_ _0822_ mem\[4\]\[14\] _0823_ VSS VSS VDD VDD _0824_
+ sky130_fd_sc_hd__and3_1
X_1171_ _0711_ VSS VSS VDD VDD _0825_ sky130_fd_sc_hd__clkbuf_4
X_1172_ mem\[3\]\[14\] _0658_ _0824_ _0825_ VSS VSS VDD VDD
+ _0826_ sky130_fd_sc_hd__a211oi_1
X_1173_ _0688_ _0819_ _0821_ _0826_ VSS VSS VDD VDD _0827_
+ sky130_fd_sc_hd__a31oi_1
X_1174_ _0736_ VSS VSS VDD VDD _0828_ sky130_fd_sc_hd__inv_1
X_1175_ _0828_ VSS VSS VDD VDD _0829_ sky130_fd_sc_hd__buf_8
X_1176_ _0695_ VSS VSS VDD VDD _0830_ sky130_fd_sc_hd__buf_6
X_1177_ _0696_ VSS VSS VDD VDD _0831_ sky130_fd_sc_hd__buf_6
X_1178_ mem\[7\]\[14\] _0830_ _0831_ mem\[11\]\[14\] VSS VSS
+ VDD VDD _0832_ sky130_fd_sc_hd__a22oi_4
X_1179_ _0626_ VSS VSS VDD VDD _0833_ sky130_fd_sc_hd__buf_2
X_1180_ _0711_ _0833_ mem\[14\]\[14\] VSS VSS VDD VDD _0834_
+ sky130_fd_sc_hd__and3_1
X_1181_ _0770_ _0654_ mem\[2\]\[14\] VSS VSS VDD VDD _0835_
+ sky130_fd_sc_hd__nor3b_1
X_1182_ _0834_ _0835_ _0678_ VSS VSS VDD VDD _0836_ sky130_fd_sc_hd__o21ai_1
X_1183_ _0636_ _0640_ _0694_ mem\[5\]\[14\] VSS VSS VDD VDD
+ _0837_ sky130_fd_sc_hd__a22oi_2
X_1184_ _0703_ mem\[12\]\[14\] _0759_ VSS VSS VDD VDD _0838_
+ sky130_fd_sc_hd__and3_1
X_1185_ _0712_ mem\[9\]\[14\] _0674_ VSS VSS VDD VDD _0839_
+ sky130_fd_sc_hd__and3b_1
X_1186_ _0838_ _0839_ _0645_ VSS VSS VDD VDD _0840_ sky130_fd_sc_hd__o21ai_1
X_1187_ _0829_ _0832_ _0836_ _0837_ _0840_ VSS VSS VDD VDD
+ _0070_ sky130_fd_sc_hd__o2111ai_4
X_1188_ _0704_ _0810_ _0817_ _0827_ _0070_ VSS VSS VDD VDD
+ _0071_ sky130_fd_sc_hd__a2111oi_0
X_1189_ mem\[0\]\[14\] _0729_ VSS VSS VDD VDD _0072_ sky130_fd_sc_hd__nor2_1
X_1190_ net50 _0731_ VSS VSS VDD VDD _0073_ sky130_fd_sc_hd__nand2_1
X_1191_ _0702_ _0071_ _0072_ _0073_ VSS VSS VDD VDD _0025_
+ sky130_fd_sc_hd__o31ai_1
X_1192_ mem\[3\]\[15\] _0733_ _0734_ VSS VSS VDD VDD _0074_
+ sky130_fd_sc_hd__a21oi_1
X_1193_ _0736_ mem\[7\]\[15\] mem\[4\]\[15\] _0669_ _0737_
+ mem\[6\]\[15\] VSS VSS VDD VDD _0075_ sky130_fd_sc_hd__a222oi_1
X_1194_ mem\[10\]\[15\] _0741_ _0742_ VSS VSS VDD VDD _0076_
+ sky130_fd_sc_hd__a21oi_1
X_1195_ _0646_ VSS VSS VDD VDD _0077_ sky130_fd_sc_hd__buf_4
X_1196_ mem\[14\]\[15\] _0077_ _0744_ mem\[13\]\[15\] mem\[12\]\[15\]
+ _0651_ VSS VSS VDD VDD _0078_ sky130_fd_sc_hd__a222oi_1
X_1197_ _0074_ _0075_ _0076_ _0078_ VSS VSS VDD VDD _0079_
+ sky130_fd_sc_hd__a22oi_1
X_1198_ _0074_ _0076_ _0867_ VSS VSS VDD VDD _0080_ sky130_fd_sc_hd__o21ai_0
X_1199_ _0630_ VSS VSS VDD VDD _0081_ sky130_fd_sc_hd__clkbuf_4
X_1200_ _0081_ mem\[1\]\[15\] _0652_ _0749_ mem\[11\]\[15\]
+ VSS VSS VDD VDD _0082_ sky130_fd_sc_hd__a32oi_1
X_1201_ _0752_ mem\[5\]\[15\] _0753_ VSS VSS VDD VDD _0083_
+ sky130_fd_sc_hd__and3_1
X_1202_ _0751_ mem\[2\]\[15\] _0683_ _0083_ VSS VSS VDD VDD
+ _0084_ sky130_fd_sc_hd__a31oi_1
X_1203_ _0665_ _0082_ _0084_ _0664_ VSS VSS VDD VDD _0085_
+ sky130_fd_sc_hd__o22ai_1
X_1204_ _0759_ VSS VSS VDD VDD _0086_ sky130_fd_sc_hd__buf_4
X_1205_ mem\[8\]\[15\] _0086_ _0675_ mem\[9\]\[15\] VSS VSS
+ VDD VDD _0087_ sky130_fd_sc_hd__a22oi_1
X_1206_ mem\[15\]\[15\] _0764_ VSS VSS VDD VDD _0088_ sky130_fd_sc_hd__nand2_1
X_1207_ _0758_ _0087_ _0088_ VSS VSS VDD VDD _0089_ sky130_fd_sc_hd__o21ai_0
X_1208_ _0079_ _0080_ _0727_ _0085_ _0089_ VSS VSS VDD VDD
+ _0090_ sky130_fd_sc_hd__a2111oi_0
X_1209_ mem\[0\]\[15\] _0729_ VSS VSS VDD VDD _0091_ sky130_fd_sc_hd__nor2_1
X_1210_ net51 _0731_ VSS VSS VDD VDD _0092_ sky130_fd_sc_hd__nand2_1
X_1211_ _0702_ _0090_ _0091_ _0092_ VSS VSS VDD VDD _0026_
+ sky130_fd_sc_hd__o31ai_1
X_1212_ _0698_ mem\[15\]\[16\] mem\[14\]\[16\] _0647_ VSS
+ VSS VDD VDD _0093_ sky130_fd_sc_hd__a22oi_1
X_1213_ _0698_ mem\[7\]\[16\] mem\[6\]\[16\] _0706_ _0663_
+ VSS VSS VDD VDD _0094_ sky130_fd_sc_hd__a221oi_1
X_1214_ _0660_ _0093_ _0094_ VSS VSS VDD VDD _0095_ sky130_fd_sc_hd__a21oi_1
X_1215_ mem\[12\]\[16\] _0709_ _0710_ mem\[13\]\[16\] _0713_
+ VSS VSS VDD VDD _0096_ sky130_fd_sc_hd__a221oi_1
X_1216_ mem\[4\]\[16\] _0709_ _0710_ mem\[5\]\[16\] _0715_
+ VSS VSS VDD VDD _0097_ sky130_fd_sc_hd__a221oi_1
X_1217_ mem\[10\]\[16\] _0646_ _0717_ mem\[9\]\[16\] VSS VSS
+ VDD VDD _0098_ sky130_fd_sc_hd__a22oi_1
X_1218_ _0719_ mem\[3\]\[16\] mem\[2\]\[16\] _0666_ VSS VSS
+ VDD VDD _0099_ sky130_fd_sc_hd__a22oi_1
X_1219_ _0696_ _0098_ _0099_ _0721_ VSS VSS VDD VDD _0100_
+ sky130_fd_sc_hd__a22o_1
X_1220_ _0096_ _0097_ _0100_ VSS VSS VDD VDD _0101_ sky130_fd_sc_hd__nor3_1
X_1221_ _0682_ mem\[1\]\[16\] _0652_ _0686_ mem\[11\]\[16\]
+ VSS VSS VDD VDD _0102_ sky130_fd_sc_hd__a32oi_1
X_1222_ _0660_ mem\[8\]\[16\] _0670_ VSS VSS VDD VDD _0103_
+ sky130_fd_sc_hd__nand3_1
X_1223_ _0102_ _0103_ _0673_ VSS VSS VDD VDD _0104_ sky130_fd_sc_hd__a21oi_1
X_1224_ _0704_ _0095_ _0101_ _0104_ _0727_ VSS VSS VDD VDD
+ _0105_ sky130_fd_sc_hd__a2111oi_0
X_1225_ mem\[0\]\[16\] _0729_ VSS VSS VDD VDD _0106_ sky130_fd_sc_hd__nor2_1
X_1226_ net52 _0731_ VSS VSS VDD VDD _0107_ sky130_fd_sc_hd__nand2_1
X_1227_ _0702_ _0105_ _0106_ _0107_ VSS VSS VDD VDD _0027_
+ sky130_fd_sc_hd__o31ai_1
X_1228_ mem\[3\]\[17\] _0733_ _0734_ VSS VSS VDD VDD _0108_
+ sky130_fd_sc_hd__a21oi_1
X_1229_ _0736_ mem\[7\]\[17\] mem\[4\]\[17\] _0669_ _0737_
+ mem\[6\]\[17\] VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__a222oi_1
X_1230_ mem\[10\]\[17\] _0741_ _0742_ VSS VSS VDD VDD _0110_
+ sky130_fd_sc_hd__a21oi_1
X_1231_ mem\[14\]\[17\] _0077_ _0744_ mem\[13\]\[17\] mem\[12\]\[17\]
+ _0651_ VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__a222oi_1
X_1232_ _0108_ _0109_ _0110_ _0111_ VSS VSS VDD VDD _0112_
+ sky130_fd_sc_hd__a22oi_1
X_1233_ _0108_ _0110_ _0867_ VSS VSS VDD VDD _0113_ sky130_fd_sc_hd__o21ai_0
X_1234_ _0081_ mem\[1\]\[17\] _0652_ _0749_ mem\[11\]\[17\]
+ VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__a32oi_1
X_1235_ _0752_ mem\[5\]\[17\] _0753_ VSS VSS VDD VDD _0115_
+ sky130_fd_sc_hd__and3_1
X_1236_ _0751_ mem\[2\]\[17\] _0683_ _0115_ VSS VSS VDD VDD
+ _0116_ sky130_fd_sc_hd__a31oi_1
X_1237_ _0665_ _0114_ _0116_ _0664_ VSS VSS VDD VDD _0117_
+ sky130_fd_sc_hd__o22ai_1
X_1238_ mem\[8\]\[17\] _0086_ _0675_ mem\[9\]\[17\] VSS VSS
+ VDD VDD _0118_ sky130_fd_sc_hd__a22oi_1
X_1239_ mem\[15\]\[17\] _0764_ VSS VSS VDD VDD _0119_ sky130_fd_sc_hd__nand2_1
X_1240_ _0758_ _0118_ _0119_ VSS VSS VDD VDD _0120_ sky130_fd_sc_hd__o21ai_0
X_1241_ _0112_ _0113_ _0727_ _0117_ _0120_ VSS VSS VDD VDD
+ _0121_ sky130_fd_sc_hd__a2111oi_0
X_1242_ mem\[0\]\[17\] _0729_ VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__nor2_1
X_1243_ net53 _0731_ VSS VSS VDD VDD _0123_ sky130_fd_sc_hd__nand2_1
X_1244_ _0702_ _0121_ _0122_ _0123_ VSS VSS VDD VDD _0028_
+ sky130_fd_sc_hd__o31ai_1
X_1245_ _0698_ mem\[15\]\[18\] mem\[14\]\[18\] _0647_ VSS
+ VSS VDD VDD _0124_ sky130_fd_sc_hd__a22oi_1
X_1246_ _0698_ mem\[7\]\[18\] mem\[6\]\[18\] _0706_ _0663_
+ VSS VSS VDD VDD _0125_ sky130_fd_sc_hd__a221oi_1
X_1247_ _0660_ _0124_ _0125_ VSS VSS VDD VDD _0126_ sky130_fd_sc_hd__a21oi_1
X_1248_ mem\[12\]\[18\] _0709_ _0710_ mem\[13\]\[18\] _0713_
+ VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__a221oi_1
X_1249_ mem\[4\]\[18\] _0709_ _0710_ mem\[5\]\[18\] _0715_
+ VSS VSS VDD VDD _0128_ sky130_fd_sc_hd__a221oi_1
X_1250_ mem\[10\]\[18\] _0646_ _0717_ mem\[9\]\[18\] VSS VSS
+ VDD VDD _0129_ sky130_fd_sc_hd__a22oi_1
X_1251_ _0637_ mem\[3\]\[18\] mem\[2\]\[18\] _0666_ VSS VSS
+ VDD VDD _0130_ sky130_fd_sc_hd__a22oi_1
X_1252_ _0696_ _0129_ _0130_ _0721_ VSS VSS VDD VDD _0131_
+ sky130_fd_sc_hd__a22o_1
X_1253_ _0127_ _0128_ _0131_ VSS VSS VDD VDD _0132_ sky130_fd_sc_hd__nor3_1
X_1254_ _0682_ mem\[1\]\[18\] _0652_ _0686_ mem\[11\]\[18\]
+ VSS VSS VDD VDD _0133_ sky130_fd_sc_hd__a32oi_1
X_1255_ _0811_ mem\[8\]\[18\] _0670_ VSS VSS VDD VDD _0134_
+ sky130_fd_sc_hd__nand3_1
X_1256_ _0133_ _0134_ _0673_ VSS VSS VDD VDD _0135_ sky130_fd_sc_hd__a21oi_1
X_1257_ _0704_ _0126_ _0132_ _0135_ _0727_ VSS VSS VDD VDD
+ _0136_ sky130_fd_sc_hd__a2111oi_0
X_1258_ mem\[0\]\[18\] _0729_ VSS VSS VDD VDD _0137_ sky130_fd_sc_hd__nor2_1
X_1259_ net54 _0731_ VSS VSS VDD VDD _0138_ sky130_fd_sc_hd__nand2_1
X_1260_ _0702_ _0136_ _0137_ _0138_ VSS VSS VDD VDD _0029_
+ sky130_fd_sc_hd__o31ai_1
X_1261_ mem\[3\]\[19\] _0733_ _0734_ VSS VSS VDD VDD _0139_
+ sky130_fd_sc_hd__a21oi_1
X_1262_ _0736_ mem\[7\]\[19\] mem\[4\]\[19\] _0669_ _0737_
+ mem\[6\]\[19\] VSS VSS VDD VDD _0140_ sky130_fd_sc_hd__a222oi_1
X_1263_ mem\[10\]\[19\] _0741_ _0742_ VSS VSS VDD VDD _0141_
+ sky130_fd_sc_hd__a21oi_1
X_1264_ mem\[14\]\[19\] _0077_ _0744_ mem\[13\]\[19\] mem\[12\]\[19\]
+ _0651_ VSS VSS VDD VDD _0142_ sky130_fd_sc_hd__a222oi_1
X_1265_ _0139_ _0140_ _0141_ _0142_ VSS VSS VDD VDD _0143_
+ sky130_fd_sc_hd__a22oi_1
X_1266_ _0139_ _0141_ _0867_ VSS VSS VDD VDD _0144_ sky130_fd_sc_hd__o21ai_0
X_1267_ _0638_ VSS VSS VDD VDD _0145_ sky130_fd_sc_hd__clkbuf_4
X_1268_ _0081_ mem\[1\]\[19\] _0145_ _0749_ mem\[11\]\[19\]
+ VSS VSS VDD VDD _0146_ sky130_fd_sc_hd__a32oi_1
X_1269_ _0648_ VSS VSS VDD VDD _0147_ sky130_fd_sc_hd__clkbuf_4
X_1270_ _0147_ mem\[5\]\[19\] _0753_ VSS VSS VDD VDD _0148_
+ sky130_fd_sc_hd__and3_1
X_1271_ _0751_ mem\[2\]\[19\] _0683_ _0148_ VSS VSS VDD VDD
+ _0149_ sky130_fd_sc_hd__a31oi_1
X_1272_ _0665_ _0146_ _0149_ _0664_ VSS VSS VDD VDD _0150_
+ sky130_fd_sc_hd__o22ai_1
X_1273_ mem\[8\]\[19\] _0086_ _0675_ mem\[9\]\[19\] VSS VSS
+ VDD VDD _0151_ sky130_fd_sc_hd__a22oi_1
X_1274_ mem\[15\]\[19\] _0764_ VSS VSS VDD VDD _0152_ sky130_fd_sc_hd__nand2_1
X_1275_ _0758_ _0151_ _0152_ VSS VSS VDD VDD _0153_ sky130_fd_sc_hd__o21ai_0
X_1276_ _0143_ _0144_ _0727_ _0150_ _0153_ VSS VSS VDD VDD
+ _0154_ sky130_fd_sc_hd__a2111oi_1
X_1277_ mem\[0\]\[19\] _0729_ VSS VSS VDD VDD _0155_ sky130_fd_sc_hd__nor2_1
X_1278_ net55 _0731_ VSS VSS VDD VDD _0156_ sky130_fd_sc_hd__nand2_1
X_1279_ _0702_ _0154_ _0155_ _0156_ VSS VSS VDD VDD _0030_
+ sky130_fd_sc_hd__o31ai_1
X_1280_ _0632_ VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__buf_6
X_1281_ mem\[3\]\[1\] _0733_ _0734_ VSS VSS VDD VDD _0158_
+ sky130_fd_sc_hd__a21oi_1
X_1282_ _0736_ mem\[7\]\[1\] mem\[4\]\[1\] _0669_ _0737_ mem\[6\]\[1\]
+ VSS VSS VDD VDD _0159_ sky130_fd_sc_hd__a222oi_1
X_1283_ mem\[10\]\[1\] _0741_ _0742_ VSS VSS VDD VDD _0160_
+ sky130_fd_sc_hd__a21oi_1
X_1284_ _0634_ VSS VSS VDD VDD _0161_ sky130_fd_sc_hd__clkbuf_4
X_1285_ _0161_ VSS VSS VDD VDD _0162_ sky130_fd_sc_hd__buf_6
X_1286_ mem\[14\]\[1\] _0077_ _0744_ mem\[13\]\[1\] mem\[12\]\[1\]
+ _0162_ VSS VSS VDD VDD _0163_ sky130_fd_sc_hd__a222oi_1
X_1287_ _0158_ _0159_ _0160_ _0163_ VSS VSS VDD VDD _0164_
+ sky130_fd_sc_hd__a22oi_1
X_1288_ _0158_ _0160_ _0867_ VSS VSS VDD VDD _0165_ sky130_fd_sc_hd__o21ai_0
X_1289_ _0685_ VSS VSS VDD VDD _0166_ sky130_fd_sc_hd__clkbuf_4
X_1290_ _0081_ mem\[1\]\[1\] _0145_ _0166_ mem\[11\]\[1\]
+ VSS VSS VDD VDD _0167_ sky130_fd_sc_hd__a32oi_1
X_1291_ _0666_ VSS VSS VDD VDD _0168_ sky130_fd_sc_hd__clkbuf_4
X_1292_ _0147_ mem\[5\]\[1\] _0753_ VSS VSS VDD VDD _0169_
+ sky130_fd_sc_hd__and3_1
X_1293_ _0751_ mem\[2\]\[1\] _0168_ _0169_ VSS VSS VDD VDD
+ _0170_ sky130_fd_sc_hd__a31oi_1
X_1294_ _0665_ _0167_ _0170_ _0664_ VSS VSS VDD VDD _0171_
+ sky130_fd_sc_hd__o22ai_2
X_1295_ mem\[8\]\[1\] _0086_ _0675_ mem\[9\]\[1\] VSS VSS
+ VDD VDD _0172_ sky130_fd_sc_hd__a22oi_1
X_1296_ mem\[15\]\[1\] _0764_ VSS VSS VDD VDD _0173_ sky130_fd_sc_hd__nand2_1
X_1297_ _0758_ _0172_ _0173_ VSS VSS VDD VDD _0174_ sky130_fd_sc_hd__o21ai_0
X_1298_ _0164_ _0165_ _0727_ _0171_ _0174_ VSS VSS VDD VDD
+ _0175_ sky130_fd_sc_hd__a2111oi_2
X_1299_ _0641_ VSS VSS VDD VDD _0176_ sky130_fd_sc_hd__buf_6
X_1300_ mem\[0\]\[1\] _0176_ VSS VSS VDD VDD _0177_ sky130_fd_sc_hd__nor2_1
X_1301_ _0633_ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__buf_6
X_1302_ net56 _0178_ VSS VSS VDD VDD _0179_ sky130_fd_sc_hd__nand2_1
X_1303_ _0157_ _0175_ _0177_ _0179_ VSS VSS VDD VDD _0031_
+ sky130_fd_sc_hd__o31ai_1
X_1304_ _0682_ mem\[6\]\[20\] _0647_ _0686_ mem\[15\]\[20\]
+ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__a32o_1
X_1305_ _0811_ mem\[8\]\[20\] _0670_ VSS VSS VDD VDD _0181_
+ sky130_fd_sc_hd__nand3_1
X_1306_ _0863_ mem\[1\]\[20\] _0814_ VSS VSS VDD VDD _0182_
+ sky130_fd_sc_hd__nand3_1
X_1307_ _0181_ _0182_ _0816_ VSS VSS VDD VDD _0183_ sky130_fd_sc_hd__a21oi_1
X_1308_ _0783_ mem\[13\]\[20\] _0818_ VSS VSS VDD VDD _0184_
+ sky130_fd_sc_hd__nand3_1
X_1309_ _0820_ mem\[10\]\[20\] _0667_ VSS VSS VDD VDD _0185_
+ sky130_fd_sc_hd__nand3_1
X_1310_ _0822_ mem\[4\]\[20\] _0161_ VSS VSS VDD VDD _0186_
+ sky130_fd_sc_hd__and3_1
X_1311_ mem\[3\]\[20\] _0658_ _0186_ _0825_ VSS VSS VDD VDD
+ _0187_ sky130_fd_sc_hd__a211oi_1
X_1312_ _0688_ _0184_ _0185_ _0187_ VSS VSS VDD VDD _0188_
+ sky130_fd_sc_hd__a31oi_1
X_1313_ mem\[7\]\[20\] _0830_ _0831_ mem\[11\]\[20\] VSS VSS
+ VDD VDD _0189_ sky130_fd_sc_hd__a22oi_2
X_1314_ _0711_ _0833_ mem\[14\]\[20\] VSS VSS VDD VDD _0190_
+ sky130_fd_sc_hd__and3_1
X_1315_ _0770_ _0654_ mem\[2\]\[20\] VSS VSS VDD VDD _0191_
+ sky130_fd_sc_hd__nor3b_1
X_1316_ _0190_ _0191_ _0678_ VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__o21ai_2
X_1317_ _0636_ _0640_ _0694_ mem\[5\]\[20\] VSS VSS VDD VDD
+ _0193_ sky130_fd_sc_hd__a22oi_2
X_1318_ _0703_ mem\[12\]\[20\] _0823_ VSS VSS VDD VDD _0194_
+ sky130_fd_sc_hd__and3_1
X_1319_ _0712_ mem\[9\]\[20\] _0674_ VSS VSS VDD VDD _0195_
+ sky130_fd_sc_hd__and3b_1
X_1320_ _0194_ _0195_ _0645_ VSS VSS VDD VDD _0196_ sky130_fd_sc_hd__o21ai_2
X_1321_ _0829_ _0189_ _0192_ _0193_ _0196_ VSS VSS VDD VDD
+ _0197_ sky130_fd_sc_hd__o2111ai_4
X_1322_ _0704_ _0180_ _0183_ _0188_ _0197_ VSS VSS VDD VDD
+ _0198_ sky130_fd_sc_hd__a2111oi_1
X_1323_ mem\[0\]\[20\] _0176_ VSS VSS VDD VDD _0199_ sky130_fd_sc_hd__nor2_1
X_1324_ net57 _0178_ VSS VSS VDD VDD _0200_ sky130_fd_sc_hd__nand2_1
X_1325_ _0157_ _0198_ _0199_ _0200_ VSS VSS VDD VDD _0032_
+ sky130_fd_sc_hd__o31ai_1
X_1326_ mem\[3\]\[21\] _0733_ _0734_ VSS VSS VDD VDD _0201_
+ sky130_fd_sc_hd__a21oi_1
X_1327_ _0736_ mem\[7\]\[21\] mem\[4\]\[21\] _0669_ _0737_
+ mem\[6\]\[21\] VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__a222oi_1
X_1328_ _0630_ VSS VSS VDD VDD _0203_ sky130_fd_sc_hd__buf_4
X_1329_ mem\[10\]\[21\] _0741_ _0203_ VSS VSS VDD VDD _0204_
+ sky130_fd_sc_hd__a21oi_1
X_1330_ mem\[14\]\[21\] _0077_ _0744_ mem\[13\]\[21\] mem\[12\]\[21\]
+ _0162_ VSS VSS VDD VDD _0205_ sky130_fd_sc_hd__a222oi_1
X_1331_ _0201_ _0202_ _0204_ _0205_ VSS VSS VDD VDD _0206_
+ sky130_fd_sc_hd__a22oi_1
X_1332_ _0628_ VSS VSS VDD VDD _0207_ sky130_fd_sc_hd__buf_4
X_1333_ _0201_ _0204_ _0207_ VSS VSS VDD VDD _0208_ sky130_fd_sc_hd__o21ai_0
X_1334_ _0699_ VSS VSS VDD VDD _0209_ sky130_fd_sc_hd__buf_4
X_1335_ _0081_ mem\[1\]\[21\] _0145_ _0166_ mem\[11\]\[21\]
+ VSS VSS VDD VDD _0210_ sky130_fd_sc_hd__a32oi_1
X_1336_ _0147_ mem\[5\]\[21\] _0753_ VSS VSS VDD VDD _0211_
+ sky130_fd_sc_hd__and3_1
X_1337_ _0751_ mem\[2\]\[21\] _0168_ _0211_ VSS VSS VDD VDD
+ _0212_ sky130_fd_sc_hd__a31oi_1
X_1338_ _0663_ VSS VSS VDD VDD _0213_ sky130_fd_sc_hd__buf_4
X_1339_ _0665_ _0210_ _0212_ _0213_ VSS VSS VDD VDD _0214_
+ sky130_fd_sc_hd__o22ai_1
X_1340_ _0674_ VSS VSS VDD VDD _0215_ sky130_fd_sc_hd__buf_4
X_1341_ mem\[8\]\[21\] _0086_ _0215_ mem\[9\]\[21\] VSS VSS
+ VDD VDD _0216_ sky130_fd_sc_hd__a22oi_1
X_1342_ mem\[15\]\[21\] _0764_ VSS VSS VDD VDD _0217_ sky130_fd_sc_hd__nand2_1
X_1343_ _0758_ _0216_ _0217_ VSS VSS VDD VDD _0218_ sky130_fd_sc_hd__o21ai_0
X_1344_ _0206_ _0208_ _0209_ _0214_ _0218_ VSS VSS VDD VDD
+ _0219_ sky130_fd_sc_hd__a2111oi_1
X_1345_ mem\[0\]\[21\] _0176_ VSS VSS VDD VDD _0220_ sky130_fd_sc_hd__nor2_1
X_1346_ net58 _0178_ VSS VSS VDD VDD _0221_ sky130_fd_sc_hd__nand2_1
X_1347_ _0157_ _0219_ _0220_ _0221_ VSS VSS VDD VDD _0033_
+ sky130_fd_sc_hd__o31ai_1
X_1348_ _0748_ mem\[6\]\[22\] _0647_ _0686_ mem\[15\]\[22\]
+ VSS VSS VDD VDD _0222_ sky130_fd_sc_hd__a32o_1
X_1349_ _0811_ mem\[8\]\[22\] _0670_ VSS VSS VDD VDD _0223_
+ sky130_fd_sc_hd__nand3_1
X_1350_ _0863_ mem\[1\]\[22\] _0814_ VSS VSS VDD VDD _0224_
+ sky130_fd_sc_hd__nand3_1
X_1351_ _0223_ _0224_ _0816_ VSS VSS VDD VDD _0225_ sky130_fd_sc_hd__a21oi_1
X_1352_ _0783_ mem\[13\]\[22\] _0818_ VSS VSS VDD VDD _0226_
+ sky130_fd_sc_hd__nand3_1
X_1353_ _0820_ mem\[10\]\[22\] _0667_ VSS VSS VDD VDD _0227_
+ sky130_fd_sc_hd__nand3_1
X_1354_ _0822_ mem\[4\]\[22\] _0161_ VSS VSS VDD VDD _0228_
+ sky130_fd_sc_hd__and3_1
X_1355_ mem\[3\]\[22\] _0658_ _0228_ _0825_ VSS VSS VDD VDD
+ _0229_ sky130_fd_sc_hd__a211oi_1
X_1356_ _0688_ _0226_ _0227_ _0229_ VSS VSS VDD VDD _0230_
+ sky130_fd_sc_hd__a31oi_1
X_1357_ mem\[7\]\[22\] _0830_ _0831_ mem\[11\]\[22\] VSS VSS
+ VDD VDD _0231_ sky130_fd_sc_hd__a22oi_2
X_1358_ _0711_ _0833_ mem\[14\]\[22\] VSS VSS VDD VDD _0232_
+ sky130_fd_sc_hd__and3_1
X_1359_ _0659_ _0654_ mem\[2\]\[22\] VSS VSS VDD VDD _0233_
+ sky130_fd_sc_hd__nor3b_1
X_1360_ _0232_ _0233_ _0678_ VSS VSS VDD VDD _0234_ sky130_fd_sc_hd__o21ai_1
X_1361_ _0636_ _0640_ _0694_ mem\[5\]\[22\] VSS VSS VDD VDD
+ _0235_ sky130_fd_sc_hd__a22oi_2
X_1362_ _0703_ mem\[12\]\[22\] _0823_ VSS VSS VDD VDD _0236_
+ sky130_fd_sc_hd__and3_1
X_1363_ _0712_ mem\[9\]\[22\] _0813_ VSS VSS VDD VDD _0237_
+ sky130_fd_sc_hd__and3b_1
X_1364_ _0236_ _0237_ _0645_ VSS VSS VDD VDD _0238_ sky130_fd_sc_hd__o21ai_1
X_1365_ _0829_ _0231_ _0234_ _0235_ _0238_ VSS VSS VDD VDD
+ _0239_ sky130_fd_sc_hd__o2111ai_4
X_1366_ _0704_ _0222_ _0225_ _0230_ _0239_ VSS VSS VDD VDD
+ _0240_ sky130_fd_sc_hd__a2111oi_1
X_1367_ mem\[0\]\[22\] _0176_ VSS VSS VDD VDD _0241_ sky130_fd_sc_hd__nor2_1
X_1368_ net59 _0178_ VSS VSS VDD VDD _0242_ sky130_fd_sc_hd__nand2_1
X_1369_ _0157_ _0240_ _0241_ _0242_ VSS VSS VDD VDD _0034_
+ sky130_fd_sc_hd__o31ai_1
X_1370_ mem\[3\]\[23\] _0733_ _0734_ VSS VSS VDD VDD _0243_
+ sky130_fd_sc_hd__a21oi_1
X_1371_ _0736_ mem\[7\]\[23\] mem\[4\]\[23\] _0669_ _0737_
+ mem\[6\]\[23\] VSS VSS VDD VDD _0244_ sky130_fd_sc_hd__a222oi_1
X_1372_ mem\[10\]\[23\] _0741_ _0203_ VSS VSS VDD VDD _0245_
+ sky130_fd_sc_hd__a21oi_1
X_1373_ mem\[14\]\[23\] _0077_ _0744_ mem\[13\]\[23\] mem\[12\]\[23\]
+ _0162_ VSS VSS VDD VDD _0246_ sky130_fd_sc_hd__a222oi_1
X_1374_ _0243_ _0244_ _0245_ _0246_ VSS VSS VDD VDD _0247_
+ sky130_fd_sc_hd__a22oi_1
X_1375_ _0243_ _0245_ _0207_ VSS VSS VDD VDD _0248_ sky130_fd_sc_hd__o21ai_0
X_1376_ _0081_ mem\[1\]\[23\] _0145_ _0166_ mem\[11\]\[23\]
+ VSS VSS VDD VDD _0249_ sky130_fd_sc_hd__a32oi_1
X_1377_ _0147_ mem\[5\]\[23\] _0753_ VSS VSS VDD VDD _0250_
+ sky130_fd_sc_hd__and3_1
X_1378_ _0751_ mem\[2\]\[23\] _0168_ _0250_ VSS VSS VDD VDD
+ _0251_ sky130_fd_sc_hd__a31oi_1
X_1379_ _0655_ _0249_ _0251_ _0213_ VSS VSS VDD VDD _0252_
+ sky130_fd_sc_hd__o22ai_1
X_1380_ mem\[8\]\[23\] _0086_ _0215_ mem\[9\]\[23\] VSS VSS
+ VDD VDD _0253_ sky130_fd_sc_hd__a22oi_1
X_1381_ mem\[15\]\[23\] _0763_ VSS VSS VDD VDD _0254_ sky130_fd_sc_hd__nand2_1
X_1382_ _0758_ _0253_ _0254_ VSS VSS VDD VDD _0255_ sky130_fd_sc_hd__o21ai_0
X_1383_ _0247_ _0248_ _0209_ _0252_ _0255_ VSS VSS VDD VDD
+ _0256_ sky130_fd_sc_hd__a2111oi_1
X_1384_ mem\[0\]\[23\] _0176_ VSS VSS VDD VDD _0257_ sky130_fd_sc_hd__nor2_1
X_1385_ net60 _0178_ VSS VSS VDD VDD _0258_ sky130_fd_sc_hd__nand2_1
X_1386_ _0157_ _0256_ _0257_ _0258_ VSS VSS VDD VDD _0035_
+ sky130_fd_sc_hd__o31ai_1
X_1387_ _0748_ mem\[6\]\[24\] _0647_ _0686_ mem\[15\]\[24\]
+ VSS VSS VDD VDD _0259_ sky130_fd_sc_hd__a32o_1
X_1388_ _0811_ mem\[8\]\[24\] _0760_ VSS VSS VDD VDD _0260_
+ sky130_fd_sc_hd__nand3_1
X_1389_ _0863_ mem\[1\]\[24\] _0814_ VSS VSS VDD VDD _0261_
+ sky130_fd_sc_hd__nand3_1
X_1390_ _0260_ _0261_ _0816_ VSS VSS VDD VDD _0262_ sky130_fd_sc_hd__a21oi_1
X_1391_ _0783_ mem\[13\]\[24\] _0818_ VSS VSS VDD VDD _0263_
+ sky130_fd_sc_hd__nand3_1
X_1392_ _0820_ mem\[10\]\[24\] _0667_ VSS VSS VDD VDD _0264_
+ sky130_fd_sc_hd__nand3_1
X_1393_ _0822_ mem\[4\]\[24\] _0161_ VSS VSS VDD VDD _0265_
+ sky130_fd_sc_hd__and3_1
X_1394_ mem\[3\]\[24\] _0658_ _0265_ _0825_ VSS VSS VDD VDD
+ _0266_ sky130_fd_sc_hd__a211oi_1
X_1395_ _0688_ _0263_ _0264_ _0266_ VSS VSS VDD VDD _0267_
+ sky130_fd_sc_hd__a31oi_1
X_1396_ mem\[7\]\[24\] _0830_ _0831_ mem\[11\]\[24\] VSS VSS
+ VDD VDD _0268_ sky130_fd_sc_hd__a22oi_2
X_1397_ _0711_ _0833_ mem\[14\]\[24\] VSS VSS VDD VDD _0269_
+ sky130_fd_sc_hd__and3_1
X_1398_ _0659_ _0654_ mem\[2\]\[24\] VSS VSS VDD VDD _0270_
+ sky130_fd_sc_hd__nor3b_1
X_1399_ _0269_ _0270_ _0678_ VSS VSS VDD VDD _0271_ sky130_fd_sc_hd__o21ai_1
X_1400_ _0636_ _0640_ _0694_ mem\[5\]\[24\] VSS VSS VDD VDD
+ _0272_ sky130_fd_sc_hd__a22oi_2
X_1401_ _0703_ mem\[12\]\[24\] _0823_ VSS VSS VDD VDD _0273_
+ sky130_fd_sc_hd__and3_1
X_1402_ _0712_ mem\[9\]\[24\] _0813_ VSS VSS VDD VDD _0274_
+ sky130_fd_sc_hd__and3b_1
X_1403_ _0273_ _0274_ _0645_ VSS VSS VDD VDD _0275_ sky130_fd_sc_hd__o21ai_1
X_1404_ _0829_ _0268_ _0271_ _0272_ _0275_ VSS VSS VDD VDD
+ _0276_ sky130_fd_sc_hd__o2111ai_4
X_1405_ _0704_ _0259_ _0262_ _0267_ _0276_ VSS VSS VDD VDD
+ _0277_ sky130_fd_sc_hd__a2111oi_1
X_1406_ mem\[0\]\[24\] _0176_ VSS VSS VDD VDD _0278_ sky130_fd_sc_hd__nor2_1
X_1407_ net61 _0178_ VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__nand2_1
X_1408_ _0157_ _0277_ _0278_ _0279_ VSS VSS VDD VDD _0036_
+ sky130_fd_sc_hd__o31ai_1
X_1409_ mem\[3\]\[25\] _0657_ _0734_ VSS VSS VDD VDD _0280_
+ sky130_fd_sc_hd__a21oi_1
X_1410_ _0719_ mem\[7\]\[25\] mem\[4\]\[25\] _0669_ _0737_
+ mem\[6\]\[25\] VSS VSS VDD VDD _0281_ sky130_fd_sc_hd__a222oi_1
X_1411_ mem\[10\]\[25\] _0741_ _0203_ VSS VSS VDD VDD _0282_
+ sky130_fd_sc_hd__a21oi_1
X_1412_ mem\[14\]\[25\] _0077_ _0744_ mem\[13\]\[25\] mem\[12\]\[25\]
+ _0162_ VSS VSS VDD VDD _0283_ sky130_fd_sc_hd__a222oi_1
X_1413_ _0280_ _0281_ _0282_ _0283_ VSS VSS VDD VDD _0284_
+ sky130_fd_sc_hd__a22oi_1
X_1414_ _0280_ _0282_ _0207_ VSS VSS VDD VDD _0285_ sky130_fd_sc_hd__o21ai_0
X_1415_ _0081_ mem\[1\]\[25\] _0145_ _0166_ mem\[11\]\[25\]
+ VSS VSS VDD VDD _0286_ sky130_fd_sc_hd__a32oi_1
X_1416_ _0147_ mem\[5\]\[25\] _0753_ VSS VSS VDD VDD _0287_
+ sky130_fd_sc_hd__and3_1
X_1417_ _0751_ mem\[2\]\[25\] _0168_ _0287_ VSS VSS VDD VDD
+ _0288_ sky130_fd_sc_hd__a31oi_1
X_1418_ _0655_ _0286_ _0288_ _0213_ VSS VSS VDD VDD _0289_
+ sky130_fd_sc_hd__o22ai_1
X_1419_ mem\[8\]\[25\] _0086_ _0215_ mem\[9\]\[25\] VSS VSS
+ VDD VDD _0290_ sky130_fd_sc_hd__a22oi_1
X_1420_ mem\[15\]\[25\] _0763_ VSS VSS VDD VDD _0291_ sky130_fd_sc_hd__nand2_1
X_1421_ _0758_ _0290_ _0291_ VSS VSS VDD VDD _0292_ sky130_fd_sc_hd__o21ai_0
X_1422_ _0284_ _0285_ _0209_ _0289_ _0292_ VSS VSS VDD VDD
+ _0293_ sky130_fd_sc_hd__a2111oi_1
X_1423_ mem\[0\]\[25\] _0176_ VSS VSS VDD VDD _0294_ sky130_fd_sc_hd__nor2_1
X_1424_ net62 _0178_ VSS VSS VDD VDD _0295_ sky130_fd_sc_hd__nand2_1
X_1425_ _0157_ _0293_ _0294_ _0295_ VSS VSS VDD VDD _0037_
+ sky130_fd_sc_hd__o31ai_1
X_1426_ _0748_ mem\[6\]\[26\] _0706_ _0686_ mem\[15\]\[26\]
+ VSS VSS VDD VDD _0296_ sky130_fd_sc_hd__a32o_1
X_1427_ _0811_ mem\[8\]\[26\] _0760_ VSS VSS VDD VDD _0297_
+ sky130_fd_sc_hd__nand3_1
X_1428_ _0863_ mem\[1\]\[26\] _0814_ VSS VSS VDD VDD _0298_
+ sky130_fd_sc_hd__nand3_1
X_1429_ _0297_ _0298_ _0816_ VSS VSS VDD VDD _0299_ sky130_fd_sc_hd__a21oi_1
X_1430_ _0783_ mem\[13\]\[26\] _0818_ VSS VSS VDD VDD _0300_
+ sky130_fd_sc_hd__nand3_1
X_1431_ _0820_ mem\[10\]\[26\] _0667_ VSS VSS VDD VDD _0301_
+ sky130_fd_sc_hd__nand3_1
X_1432_ _0822_ mem\[4\]\[26\] _0161_ VSS VSS VDD VDD _0302_
+ sky130_fd_sc_hd__and3_1
X_1433_ mem\[3\]\[26\] _0658_ _0302_ _0825_ VSS VSS VDD VDD
+ _0303_ sky130_fd_sc_hd__a211oi_1
X_1434_ _0688_ _0300_ _0301_ _0303_ VSS VSS VDD VDD _0304_
+ sky130_fd_sc_hd__a31oi_1
X_1435_ mem\[7\]\[26\] _0830_ _0831_ mem\[11\]\[26\] VSS VSS
+ VDD VDD _0305_ sky130_fd_sc_hd__a22oi_2
X_1436_ _0711_ _0833_ mem\[14\]\[26\] VSS VSS VDD VDD _0306_
+ sky130_fd_sc_hd__and3_1
X_1437_ _0659_ _0654_ mem\[2\]\[26\] VSS VSS VDD VDD _0307_
+ sky130_fd_sc_hd__nor3b_1
X_1438_ _0306_ _0307_ _0678_ VSS VSS VDD VDD _0308_ sky130_fd_sc_hd__o21ai_1
X_1439_ _0636_ _0640_ _0694_ mem\[5\]\[26\] VSS VSS VDD VDD
+ _0309_ sky130_fd_sc_hd__a22oi_2
X_1440_ _0703_ mem\[12\]\[26\] _0823_ VSS VSS VDD VDD _0310_
+ sky130_fd_sc_hd__and3_1
X_1441_ _0712_ mem\[9\]\[26\] _0813_ VSS VSS VDD VDD _0311_
+ sky130_fd_sc_hd__and3b_1
X_1442_ _0310_ _0311_ _0645_ VSS VSS VDD VDD _0312_ sky130_fd_sc_hd__o21ai_1
X_1443_ _0829_ _0305_ _0308_ _0309_ _0312_ VSS VSS VDD VDD
+ _0313_ sky130_fd_sc_hd__o2111ai_4
X_1444_ _0704_ _0296_ _0299_ _0304_ _0313_ VSS VSS VDD VDD
+ _0314_ sky130_fd_sc_hd__a2111oi_1
X_1445_ mem\[0\]\[26\] _0176_ VSS VSS VDD VDD _0315_ sky130_fd_sc_hd__nor2_1
X_1446_ net63 _0178_ VSS VSS VDD VDD _0316_ sky130_fd_sc_hd__nand2_1
X_1447_ _0157_ _0314_ _0315_ _0316_ VSS VSS VDD VDD _0038_
+ sky130_fd_sc_hd__o31ai_1
X_1448_ mem\[3\]\[27\] _0657_ _0734_ VSS VSS VDD VDD _0317_
+ sky130_fd_sc_hd__a21oi_1
X_1449_ _0719_ mem\[7\]\[27\] mem\[4\]\[27\] _0759_ _0737_
+ mem\[6\]\[27\] VSS VSS VDD VDD _0318_ sky130_fd_sc_hd__a222oi_1
X_1450_ mem\[10\]\[27\] _0741_ _0203_ VSS VSS VDD VDD _0319_
+ sky130_fd_sc_hd__a21oi_1
X_1451_ mem\[14\]\[27\] _0077_ _0744_ mem\[13\]\[27\] mem\[12\]\[27\]
+ _0162_ VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__a222oi_1
X_1452_ _0317_ _0318_ _0319_ _0320_ VSS VSS VDD VDD _0321_
+ sky130_fd_sc_hd__a22oi_1
X_1453_ _0317_ _0319_ _0207_ VSS VSS VDD VDD _0322_ sky130_fd_sc_hd__o21ai_0
X_1454_ _0081_ mem\[1\]\[27\] _0145_ _0166_ mem\[11\]\[27\]
+ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__a32oi_1
X_1455_ _0147_ mem\[5\]\[27\] _0753_ VSS VSS VDD VDD _0324_
+ sky130_fd_sc_hd__and3_1
X_1456_ _0751_ mem\[2\]\[27\] _0168_ _0324_ VSS VSS VDD VDD
+ _0325_ sky130_fd_sc_hd__a31oi_1
X_1457_ _0655_ _0323_ _0325_ _0213_ VSS VSS VDD VDD _0326_
+ sky130_fd_sc_hd__o22ai_2
X_1458_ mem\[8\]\[27\] _0086_ _0215_ mem\[9\]\[27\] VSS VSS
+ VDD VDD _0327_ sky130_fd_sc_hd__a22oi_1
X_1459_ mem\[15\]\[27\] _0763_ VSS VSS VDD VDD _0328_ sky130_fd_sc_hd__nand2_1
X_1460_ _0757_ _0327_ _0328_ VSS VSS VDD VDD _0329_ sky130_fd_sc_hd__o21ai_1
X_1461_ _0321_ _0322_ _0209_ _0326_ _0329_ VSS VSS VDD VDD
+ _0330_ sky130_fd_sc_hd__a2111oi_2
X_1462_ mem\[0\]\[27\] _0176_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__nor2_1
X_1463_ net64 _0178_ VSS VSS VDD VDD _0332_ sky130_fd_sc_hd__nand2_1
X_1464_ _0157_ _0330_ _0331_ _0332_ VSS VSS VDD VDD _0039_
+ sky130_fd_sc_hd__o31ai_1
X_1465_ _0748_ mem\[6\]\[28\] _0706_ _0749_ mem\[15\]\[28\]
+ VSS VSS VDD VDD _0333_ sky130_fd_sc_hd__a32o_1
X_1466_ _0811_ mem\[8\]\[28\] _0760_ VSS VSS VDD VDD _0334_
+ sky130_fd_sc_hd__nand3_1
X_1467_ _0863_ mem\[1\]\[28\] _0814_ VSS VSS VDD VDD _0335_
+ sky130_fd_sc_hd__nand3_1
X_1468_ _0334_ _0335_ _0816_ VSS VSS VDD VDD _0336_ sky130_fd_sc_hd__a21oi_1
X_1469_ _0783_ mem\[13\]\[28\] _0818_ VSS VSS VDD VDD _0337_
+ sky130_fd_sc_hd__nand3_1
X_1470_ _0820_ mem\[10\]\[28\] _0667_ VSS VSS VDD VDD _0338_
+ sky130_fd_sc_hd__nand3_1
X_1471_ _0822_ mem\[4\]\[28\] _0161_ VSS VSS VDD VDD _0339_
+ sky130_fd_sc_hd__and3_1
X_1472_ mem\[3\]\[28\] _0658_ _0339_ _0825_ VSS VSS VDD VDD
+ _0340_ sky130_fd_sc_hd__a211oi_1
X_1473_ _0688_ _0337_ _0338_ _0340_ VSS VSS VDD VDD _0341_
+ sky130_fd_sc_hd__a31oi_1
X_1474_ mem\[7\]\[28\] _0830_ _0831_ mem\[11\]\[28\] VSS VSS
+ VDD VDD _0342_ sky130_fd_sc_hd__a22oi_2
X_1475_ _0644_ _0833_ mem\[14\]\[28\] VSS VSS VDD VDD _0343_
+ sky130_fd_sc_hd__and3_1
X_1476_ _0659_ _0654_ mem\[2\]\[28\] VSS VSS VDD VDD _0344_
+ sky130_fd_sc_hd__nor3b_1
X_1477_ _0343_ _0344_ _0678_ VSS VSS VDD VDD _0345_ sky130_fd_sc_hd__o21ai_1
X_1478_ _0636_ _0640_ _0694_ mem\[5\]\[28\] VSS VSS VDD VDD
+ _0346_ sky130_fd_sc_hd__a22oi_2
X_1479_ _0752_ mem\[12\]\[28\] _0823_ VSS VSS VDD VDD _0347_
+ sky130_fd_sc_hd__and3_1
X_1480_ _0712_ mem\[9\]\[28\] _0813_ VSS VSS VDD VDD _0348_
+ sky130_fd_sc_hd__and3b_1
X_1481_ _0347_ _0348_ _0645_ VSS VSS VDD VDD _0349_ sky130_fd_sc_hd__o21ai_1
X_1482_ _0829_ _0342_ _0345_ _0346_ _0349_ VSS VSS VDD VDD
+ _0350_ sky130_fd_sc_hd__o2111ai_4
X_1483_ _0704_ _0333_ _0336_ _0341_ _0350_ VSS VSS VDD VDD
+ _0351_ sky130_fd_sc_hd__a2111oi_2
X_1484_ mem\[0\]\[28\] _0176_ VSS VSS VDD VDD _0352_ sky130_fd_sc_hd__nor2_1
X_1485_ net65 _0178_ VSS VSS VDD VDD _0353_ sky130_fd_sc_hd__nand2_1
X_1486_ _0157_ _0351_ _0352_ _0353_ VSS VSS VDD VDD _0040_
+ sky130_fd_sc_hd__o31ai_1
X_1487_ _0632_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__buf_6
X_1488_ mem\[3\]\[29\] _0657_ _0770_ VSS VSS VDD VDD _0355_
+ sky130_fd_sc_hd__a21oi_1
X_1489_ _0719_ mem\[7\]\[29\] mem\[4\]\[29\] _0759_ _0677_
+ mem\[6\]\[29\] VSS VSS VDD VDD _0356_ sky130_fd_sc_hd__a222oi_1
X_1490_ mem\[10\]\[29\] _0740_ _0203_ VSS VSS VDD VDD _0357_
+ sky130_fd_sc_hd__a21oi_1
X_1491_ mem\[14\]\[29\] _0077_ _0674_ mem\[13\]\[29\] mem\[12\]\[29\]
+ _0162_ VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__a222oi_1
X_1492_ _0355_ _0356_ _0357_ _0358_ VSS VSS VDD VDD _0359_
+ sky130_fd_sc_hd__a22oi_1
X_1493_ _0355_ _0357_ _0207_ VSS VSS VDD VDD _0360_ sky130_fd_sc_hd__o21ai_0
X_1494_ _0081_ mem\[1\]\[29\] _0145_ _0166_ mem\[11\]\[29\]
+ VSS VSS VDD VDD _0361_ sky130_fd_sc_hd__a32oi_1
X_1495_ _0147_ mem\[5\]\[29\] _0717_ VSS VSS VDD VDD _0362_
+ sky130_fd_sc_hd__and3_1
X_1496_ _0628_ mem\[2\]\[29\] _0168_ _0362_ VSS VSS VDD VDD
+ _0363_ sky130_fd_sc_hd__a31oi_1
X_1497_ _0655_ _0361_ _0363_ _0213_ VSS VSS VDD VDD _0364_
+ sky130_fd_sc_hd__o22ai_2
X_1498_ mem\[8\]\[29\] _0086_ _0215_ mem\[9\]\[29\] VSS VSS
+ VDD VDD _0365_ sky130_fd_sc_hd__a22oi_1
X_1499_ mem\[15\]\[29\] _0763_ VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__nand2_1
X_1500_ _0757_ _0365_ _0366_ VSS VSS VDD VDD _0367_ sky130_fd_sc_hd__o21ai_1
X_1501_ _0359_ _0360_ _0209_ _0364_ _0367_ VSS VSS VDD VDD
+ _0368_ sky130_fd_sc_hd__a2111oi_2
X_1502_ _0641_ VSS VSS VDD VDD _0369_ sky130_fd_sc_hd__buf_6
X_1503_ mem\[0\]\[29\] _0369_ VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__nor2_1
X_1504_ _0633_ VSS VSS VDD VDD _0371_ sky130_fd_sc_hd__buf_6
X_1505_ net66 _0371_ VSS VSS VDD VDD _0372_ sky130_fd_sc_hd__nand2_1
X_1506_ _0354_ _0368_ _0370_ _0372_ VSS VSS VDD VDD _0041_
+ sky130_fd_sc_hd__o31ai_1
X_1507_ _0748_ mem\[6\]\[2\] _0706_ _0749_ mem\[15\]\[2\]
+ VSS VSS VDD VDD _0373_ sky130_fd_sc_hd__a32o_1
X_1508_ _0811_ mem\[8\]\[2\] _0760_ VSS VSS VDD VDD _0374_
+ sky130_fd_sc_hd__nand3_1
X_1509_ _0863_ mem\[1\]\[2\] _0814_ VSS VSS VDD VDD _0375_
+ sky130_fd_sc_hd__nand3_1
X_1510_ _0374_ _0375_ _0816_ VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__a21oi_1
X_1511_ _0783_ mem\[13\]\[2\] _0818_ VSS VSS VDD VDD _0377_
+ sky130_fd_sc_hd__nand3_1
X_1512_ _0820_ mem\[10\]\[2\] _0667_ VSS VSS VDD VDD _0378_
+ sky130_fd_sc_hd__nand3_1
X_1513_ _0822_ mem\[4\]\[2\] _0161_ VSS VSS VDD VDD _0379_
+ sky130_fd_sc_hd__and3_1
X_1514_ mem\[3\]\[2\] _0658_ _0379_ _0825_ VSS VSS VDD VDD
+ _0380_ sky130_fd_sc_hd__a211oi_1
X_1515_ _0688_ _0377_ _0378_ _0380_ VSS VSS VDD VDD _0381_
+ sky130_fd_sc_hd__a31oi_1
X_1516_ mem\[7\]\[2\] _0830_ _0831_ mem\[11\]\[2\] VSS VSS
+ VDD VDD _0382_ sky130_fd_sc_hd__a22oi_2
X_1517_ _0644_ _0833_ mem\[14\]\[2\] VSS VSS VDD VDD _0383_
+ sky130_fd_sc_hd__and3_1
X_1518_ _0659_ _0654_ mem\[2\]\[2\] VSS VSS VDD VDD _0384_
+ sky130_fd_sc_hd__nor3b_1
X_1519_ _0383_ _0384_ _0678_ VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__o21ai_1
X_1520_ _0636_ _0640_ _0694_ mem\[5\]\[2\] VSS VSS VDD VDD
+ _0386_ sky130_fd_sc_hd__a22oi_2
X_1521_ _0752_ mem\[12\]\[2\] _0823_ VSS VSS VDD VDD _0387_
+ sky130_fd_sc_hd__and3_1
X_1522_ _0712_ mem\[9\]\[2\] _0813_ VSS VSS VDD VDD _0388_
+ sky130_fd_sc_hd__and3b_1
X_1523_ _0387_ _0388_ _0645_ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__o21ai_1
X_1524_ _0829_ _0382_ _0385_ _0386_ _0389_ VSS VSS VDD VDD
+ _0390_ sky130_fd_sc_hd__o2111ai_4
X_1525_ _0704_ _0373_ _0376_ _0381_ _0390_ VSS VSS VDD VDD
+ _0391_ sky130_fd_sc_hd__a2111oi_1
X_1526_ mem\[0\]\[2\] _0369_ VSS VSS VDD VDD _0392_ sky130_fd_sc_hd__nor2_1
X_1527_ net67 _0371_ VSS VSS VDD VDD _0393_ sky130_fd_sc_hd__nand2_1
X_1528_ _0354_ _0391_ _0392_ _0393_ VSS VSS VDD VDD _0042_
+ sky130_fd_sc_hd__o31ai_1
X_1529_ _0698_ mem\[15\]\[30\] mem\[14\]\[30\] _0647_ VSS
+ VSS VDD VDD _0394_ sky130_fd_sc_hd__a22oi_1
X_1530_ _0736_ mem\[7\]\[30\] mem\[6\]\[30\] _0706_ _0663_
+ VSS VSS VDD VDD _0395_ sky130_fd_sc_hd__a221oi_1
X_1531_ _0660_ _0394_ _0395_ VSS VSS VDD VDD _0396_ sky130_fd_sc_hd__a21oi_1
X_1532_ mem\[12\]\[30\] _0709_ _0710_ mem\[13\]\[30\] _0713_
+ VSS VSS VDD VDD _0397_ sky130_fd_sc_hd__a221oi_1
X_1533_ mem\[4\]\[30\] _0709_ _0710_ mem\[5\]\[30\] _0715_
+ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__a221oi_1
X_1534_ mem\[10\]\[30\] _0646_ _0717_ mem\[9\]\[30\] VSS VSS
+ VDD VDD _0399_ sky130_fd_sc_hd__a22oi_1
X_1535_ _0637_ mem\[3\]\[30\] mem\[2\]\[30\] _0666_ VSS VSS
+ VDD VDD _0400_ sky130_fd_sc_hd__a22oi_1
X_1536_ _0696_ _0399_ _0400_ _0721_ VSS VSS VDD VDD _0401_
+ sky130_fd_sc_hd__a22o_1
X_1537_ _0397_ _0398_ _0401_ VSS VSS VDD VDD _0402_ sky130_fd_sc_hd__nor3_1
X_1538_ _0682_ mem\[1\]\[30\] _0652_ _0686_ mem\[11\]\[30\]
+ VSS VSS VDD VDD _0403_ sky130_fd_sc_hd__a32oi_1
X_1539_ _0811_ mem\[8\]\[30\] _0670_ VSS VSS VDD VDD _0404_
+ sky130_fd_sc_hd__nand3_1
X_1540_ _0403_ _0404_ _0673_ VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__a21oi_1
X_1541_ _0673_ _0396_ _0402_ _0405_ _0727_ VSS VSS VDD VDD
+ _0406_ sky130_fd_sc_hd__a2111oi_1
X_1542_ mem\[0\]\[30\] _0369_ VSS VSS VDD VDD _0407_ sky130_fd_sc_hd__nor2_1
X_1543_ net68 _0371_ VSS VSS VDD VDD _0408_ sky130_fd_sc_hd__nand2_1
X_1544_ _0354_ _0406_ _0407_ _0408_ VSS VSS VDD VDD _0043_
+ sky130_fd_sc_hd__o31ai_1
X_1545_ mem\[3\]\[31\] _0657_ _0770_ VSS VSS VDD VDD _0409_
+ sky130_fd_sc_hd__a21oi_1
X_1546_ _0719_ mem\[7\]\[31\] mem\[4\]\[31\] _0759_ _0677_
+ mem\[6\]\[31\] VSS VSS VDD VDD _0410_ sky130_fd_sc_hd__a222oi_1
X_1547_ mem\[10\]\[31\] _0740_ _0203_ VSS VSS VDD VDD _0411_
+ sky130_fd_sc_hd__a21oi_1
X_1548_ mem\[14\]\[31\] _0077_ _0674_ mem\[13\]\[31\] mem\[12\]\[31\]
+ _0162_ VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__a222oi_1
X_1549_ _0409_ _0410_ _0411_ _0412_ VSS VSS VDD VDD _0413_
+ sky130_fd_sc_hd__a22oi_1
X_1550_ _0409_ _0411_ _0207_ VSS VSS VDD VDD _0414_ sky130_fd_sc_hd__o21ai_0
X_1551_ _0081_ mem\[1\]\[31\] _0145_ _0166_ mem\[11\]\[31\]
+ VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__a32oi_1
X_1552_ _0147_ mem\[5\]\[31\] _0717_ VSS VSS VDD VDD _0416_
+ sky130_fd_sc_hd__and3_1
X_1553_ _0628_ mem\[2\]\[31\] _0168_ _0416_ VSS VSS VDD VDD
+ _0417_ sky130_fd_sc_hd__a31oi_1
X_1554_ _0655_ _0415_ _0417_ _0213_ VSS VSS VDD VDD _0418_
+ sky130_fd_sc_hd__o22ai_2
X_1555_ mem\[8\]\[31\] _0086_ _0215_ mem\[9\]\[31\] VSS VSS
+ VDD VDD _0419_ sky130_fd_sc_hd__a22oi_1
X_1556_ mem\[15\]\[31\] _0763_ VSS VSS VDD VDD _0420_ sky130_fd_sc_hd__nand2_1
X_1557_ _0757_ _0419_ _0420_ VSS VSS VDD VDD _0421_ sky130_fd_sc_hd__o21ai_1
X_1558_ _0413_ _0414_ _0209_ _0418_ _0421_ VSS VSS VDD VDD
+ _0422_ sky130_fd_sc_hd__a2111oi_2
X_1559_ mem\[0\]\[31\] _0369_ VSS VSS VDD VDD _0423_ sky130_fd_sc_hd__nor2_1
X_1560_ net69 _0371_ VSS VSS VDD VDD _0424_ sky130_fd_sc_hd__nand2_1
X_1561_ _0354_ _0422_ _0423_ _0424_ VSS VSS VDD VDD _0044_
+ sky130_fd_sc_hd__o31ai_1
X_1562_ mem\[3\]\[3\] _0657_ _0770_ VSS VSS VDD VDD _0425_
+ sky130_fd_sc_hd__a21oi_1
X_1563_ _0719_ mem\[7\]\[3\] mem\[4\]\[3\] _0759_ _0677_ mem\[6\]\[3\]
+ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__a222oi_1
X_1564_ mem\[10\]\[3\] _0740_ _0203_ VSS VSS VDD VDD _0427_
+ sky130_fd_sc_hd__a21oi_1
X_1565_ mem\[14\]\[3\] _0666_ _0674_ mem\[13\]\[3\] mem\[12\]\[3\]
+ _0162_ VSS VSS VDD VDD _0428_ sky130_fd_sc_hd__a222oi_1
X_1566_ _0425_ _0426_ _0427_ _0428_ VSS VSS VDD VDD _0429_
+ sky130_fd_sc_hd__a22oi_1
X_1567_ _0425_ _0427_ _0207_ VSS VSS VDD VDD _0430_ sky130_fd_sc_hd__o21ai_0
X_1568_ _0742_ mem\[1\]\[3\] _0145_ _0166_ mem\[11\]\[3\]
+ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__a32oi_1
X_1569_ _0147_ mem\[5\]\[3\] _0717_ VSS VSS VDD VDD _0432_
+ sky130_fd_sc_hd__and3_1
X_1570_ _0628_ mem\[2\]\[3\] _0168_ _0432_ VSS VSS VDD VDD
+ _0433_ sky130_fd_sc_hd__a31oi_1
X_1571_ _0655_ _0431_ _0433_ _0213_ VSS VSS VDD VDD _0434_
+ sky130_fd_sc_hd__o22ai_2
X_1572_ mem\[8\]\[3\] _0651_ _0215_ mem\[9\]\[3\] VSS VSS
+ VDD VDD _0435_ sky130_fd_sc_hd__a22oi_1
X_1573_ mem\[15\]\[3\] _0763_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__nand2_1
X_1574_ _0757_ _0435_ _0436_ VSS VSS VDD VDD _0437_ sky130_fd_sc_hd__o21ai_0
X_1575_ _0429_ _0430_ _0209_ _0434_ _0437_ VSS VSS VDD VDD
+ _0438_ sky130_fd_sc_hd__a2111oi_1
X_1576_ mem\[0\]\[3\] _0369_ VSS VSS VDD VDD _0439_ sky130_fd_sc_hd__nor2_1
X_1577_ net70 _0371_ VSS VSS VDD VDD _0440_ sky130_fd_sc_hd__nand2_1
X_1578_ _0354_ _0438_ _0439_ _0440_ VSS VSS VDD VDD _0045_
+ sky130_fd_sc_hd__o31ai_1
X_1579_ _0748_ mem\[6\]\[4\] _0706_ _0749_ mem\[15\]\[4\]
+ VSS VSS VDD VDD _0441_ sky130_fd_sc_hd__a32o_1
X_1580_ _0811_ mem\[8\]\[4\] _0760_ VSS VSS VDD VDD _0442_
+ sky130_fd_sc_hd__nand3_1
X_1581_ _0682_ mem\[1\]\[4\] _0814_ VSS VSS VDD VDD _0443_
+ sky130_fd_sc_hd__nand3_1
X_1582_ _0442_ _0443_ _0816_ VSS VSS VDD VDD _0444_ sky130_fd_sc_hd__a21oi_1
X_1583_ _0649_ mem\[13\]\[4\] _0818_ VSS VSS VDD VDD _0445_
+ sky130_fd_sc_hd__nand3_1
X_1584_ _0820_ mem\[10\]\[4\] _0683_ VSS VSS VDD VDD _0446_
+ sky130_fd_sc_hd__nand3_1
X_1585_ _0648_ mem\[4\]\[4\] _0161_ VSS VSS VDD VDD _0447_
+ sky130_fd_sc_hd__and3_1
X_1586_ mem\[3\]\[4\] _0658_ _0447_ _0825_ VSS VSS VDD VDD
+ _0448_ sky130_fd_sc_hd__a211oi_1
X_1587_ _0688_ _0445_ _0446_ _0448_ VSS VSS VDD VDD _0449_
+ sky130_fd_sc_hd__a31oi_1
X_1588_ mem\[7\]\[4\] _0830_ _0831_ mem\[11\]\[4\] VSS VSS
+ VDD VDD _0450_ sky130_fd_sc_hd__a22oi_2
X_1589_ _0644_ _0822_ mem\[14\]\[4\] VSS VSS VDD VDD _0451_
+ sky130_fd_sc_hd__and3_1
X_1590_ _0659_ _0654_ mem\[2\]\[4\] VSS VSS VDD VDD _0452_
+ sky130_fd_sc_hd__nor3b_1
X_1591_ _0451_ _0452_ _0678_ VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__o21ai_0
X_1592_ _0636_ _0640_ _0694_ mem\[5\]\[4\] VSS VSS VDD VDD
+ _0454_ sky130_fd_sc_hd__a22oi_1
X_1593_ _0752_ mem\[12\]\[4\] _0823_ VSS VSS VDD VDD _0455_
+ sky130_fd_sc_hd__and3_1
X_1594_ _0833_ mem\[9\]\[4\] _0813_ VSS VSS VDD VDD _0456_
+ sky130_fd_sc_hd__and3b_1
X_1595_ _0455_ _0456_ _0660_ VSS VSS VDD VDD _0457_ sky130_fd_sc_hd__o21ai_0
X_1596_ _0829_ _0450_ _0453_ _0454_ _0457_ VSS VSS VDD VDD
+ _0458_ sky130_fd_sc_hd__o2111ai_2
X_1597_ _0673_ _0441_ _0444_ _0449_ _0458_ VSS VSS VDD VDD
+ _0459_ sky130_fd_sc_hd__a2111oi_2
X_1598_ mem\[0\]\[4\] _0369_ VSS VSS VDD VDD _0460_ sky130_fd_sc_hd__nor2_1
X_1599_ net71 _0371_ VSS VSS VDD VDD _0461_ sky130_fd_sc_hd__nand2_1
X_1600_ _0354_ _0459_ _0460_ _0461_ VSS VSS VDD VDD _0046_
+ sky130_fd_sc_hd__o31ai_1
X_1601_ mem\[3\]\[5\] _0657_ _0770_ VSS VSS VDD VDD _0462_
+ sky130_fd_sc_hd__a21oi_1
X_1602_ _0719_ mem\[7\]\[5\] mem\[4\]\[5\] _0759_ _0677_ mem\[6\]\[5\]
+ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__a222oi_1
X_1603_ mem\[10\]\[5\] _0740_ _0203_ VSS VSS VDD VDD _0464_
+ sky130_fd_sc_hd__a21oi_1
X_1604_ mem\[14\]\[5\] _0666_ _0674_ mem\[13\]\[5\] mem\[12\]\[5\]
+ _0162_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__a222oi_1
X_1605_ _0462_ _0463_ _0464_ _0465_ VSS VSS VDD VDD _0466_
+ sky130_fd_sc_hd__a22oi_1
X_1606_ _0462_ _0464_ _0207_ VSS VSS VDD VDD _0467_ sky130_fd_sc_hd__o21ai_0
X_1607_ _0742_ mem\[1\]\[5\] _0145_ _0166_ mem\[11\]\[5\]
+ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__a32oi_1
X_1608_ _0147_ mem\[5\]\[5\] _0717_ VSS VSS VDD VDD _0469_
+ sky130_fd_sc_hd__and3_1
X_1609_ _0628_ mem\[2\]\[5\] _0168_ _0469_ VSS VSS VDD VDD
+ _0470_ sky130_fd_sc_hd__a31oi_1
X_1610_ _0655_ _0468_ _0470_ _0213_ VSS VSS VDD VDD _0471_
+ sky130_fd_sc_hd__o22ai_1
X_1611_ mem\[8\]\[5\] _0651_ _0215_ mem\[9\]\[5\] VSS VSS
+ VDD VDD _0472_ sky130_fd_sc_hd__a22oi_1
X_1612_ mem\[15\]\[5\] _0763_ VSS VSS VDD VDD _0473_ sky130_fd_sc_hd__nand2_1
X_1613_ _0757_ _0472_ _0473_ VSS VSS VDD VDD _0474_ sky130_fd_sc_hd__o21ai_0
X_1614_ _0466_ _0467_ _0209_ _0471_ _0474_ VSS VSS VDD VDD
+ _0475_ sky130_fd_sc_hd__a2111oi_0
X_1615_ mem\[0\]\[5\] _0369_ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__nor2_1
X_1616_ net72 _0371_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__nand2_1
X_1617_ _0354_ _0475_ _0476_ _0477_ VSS VSS VDD VDD _0047_
+ sky130_fd_sc_hd__o31ai_1
X_1618_ _0748_ mem\[6\]\[6\] _0706_ _0749_ mem\[15\]\[6\]
+ VSS VSS VDD VDD _0478_ sky130_fd_sc_hd__a32o_1
X_1619_ _0825_ mem\[8\]\[6\] _0760_ VSS VSS VDD VDD _0479_
+ sky130_fd_sc_hd__nand3_1
X_1620_ _0682_ mem\[1\]\[6\] _0814_ VSS VSS VDD VDD _0480_
+ sky130_fd_sc_hd__nand3_1
X_1621_ _0479_ _0480_ _0816_ VSS VSS VDD VDD _0481_ sky130_fd_sc_hd__a21oi_1
X_1622_ _0649_ mem\[13\]\[6\] _0818_ VSS VSS VDD VDD _0482_
+ sky130_fd_sc_hd__nand3_1
X_1623_ _0820_ mem\[10\]\[6\] _0683_ VSS VSS VDD VDD _0483_
+ sky130_fd_sc_hd__nand3_1
X_1624_ _0648_ mem\[4\]\[6\] _0161_ VSS VSS VDD VDD _0484_
+ sky130_fd_sc_hd__and3_1
X_1625_ mem\[3\]\[6\] _0733_ _0484_ _0663_ VSS VSS VDD VDD
+ _0485_ sky130_fd_sc_hd__a211oi_1
X_1626_ _0688_ _0482_ _0483_ _0485_ VSS VSS VDD VDD _0486_
+ sky130_fd_sc_hd__a31oi_1
X_1627_ mem\[7\]\[6\] _0830_ _0831_ mem\[11\]\[6\] VSS VSS
+ VDD VDD _0487_ sky130_fd_sc_hd__a22oi_4
X_1628_ _0644_ _0822_ mem\[14\]\[6\] VSS VSS VDD VDD _0488_
+ sky130_fd_sc_hd__and3_1
X_1629_ _0659_ _0654_ mem\[2\]\[6\] VSS VSS VDD VDD _0489_
+ sky130_fd_sc_hd__nor3b_1
X_1630_ _0488_ _0489_ _0667_ VSS VSS VDD VDD _0490_ sky130_fd_sc_hd__o21ai_1
X_1631_ _0635_ _0639_ _0693_ mem\[5\]\[6\] VSS VSS VDD VDD
+ _0491_ sky130_fd_sc_hd__a22oi_2
X_1632_ _0752_ mem\[12\]\[6\] _0823_ VSS VSS VDD VDD _0492_
+ sky130_fd_sc_hd__and3_1
X_1633_ _0833_ mem\[9\]\[6\] _0813_ VSS VSS VDD VDD _0493_
+ sky130_fd_sc_hd__and3b_1
X_1634_ _0492_ _0493_ _0660_ VSS VSS VDD VDD _0494_ sky130_fd_sc_hd__o21ai_1
X_1635_ _0829_ _0487_ _0490_ _0491_ _0494_ VSS VSS VDD VDD
+ _0495_ sky130_fd_sc_hd__o2111ai_4
X_1636_ _0673_ _0478_ _0481_ _0486_ _0495_ VSS VSS VDD VDD
+ _0496_ sky130_fd_sc_hd__a2111oi_2
X_1637_ mem\[0\]\[6\] _0369_ VSS VSS VDD VDD _0497_ sky130_fd_sc_hd__nor2_1
X_1638_ net73 _0371_ VSS VSS VDD VDD _0498_ sky130_fd_sc_hd__nand2_1
X_1639_ _0354_ _0496_ _0497_ _0498_ VSS VSS VDD VDD _0048_
+ sky130_fd_sc_hd__o31ai_1
X_1640_ mem\[3\]\[7\] _0657_ _0770_ VSS VSS VDD VDD _0499_
+ sky130_fd_sc_hd__a21oi_1
X_1641_ _0719_ mem\[7\]\[7\] mem\[4\]\[7\] _0759_ _0677_ mem\[6\]\[7\]
+ VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__a222oi_1
X_1642_ mem\[10\]\[7\] _0740_ _0203_ VSS VSS VDD VDD _0501_
+ sky130_fd_sc_hd__a21oi_1
X_1643_ mem\[14\]\[7\] _0666_ _0674_ mem\[13\]\[7\] mem\[12\]\[7\]
+ _0162_ VSS VSS VDD VDD _0502_ sky130_fd_sc_hd__a222oi_1
X_1644_ _0499_ _0500_ _0501_ _0502_ VSS VSS VDD VDD _0503_
+ sky130_fd_sc_hd__a22oi_1
X_1645_ _0499_ _0501_ _0207_ VSS VSS VDD VDD _0504_ sky130_fd_sc_hd__o21ai_0
X_1646_ _0742_ mem\[1\]\[7\] _0710_ _0166_ mem\[11\]\[7\]
+ VSS VSS VDD VDD _0505_ sky130_fd_sc_hd__a32oi_1
X_1647_ _0712_ mem\[5\]\[7\] _0717_ VSS VSS VDD VDD _0506_
+ sky130_fd_sc_hd__and3_1
X_1648_ _0628_ mem\[2\]\[7\] _0168_ _0506_ VSS VSS VDD VDD
+ _0507_ sky130_fd_sc_hd__a31oi_1
X_1649_ _0655_ _0505_ _0507_ _0213_ VSS VSS VDD VDD _0508_
+ sky130_fd_sc_hd__o22ai_1
X_1650_ mem\[8\]\[7\] _0651_ _0215_ mem\[9\]\[7\] VSS VSS
+ VDD VDD _0509_ sky130_fd_sc_hd__a22oi_1
X_1651_ mem\[15\]\[7\] _0763_ VSS VSS VDD VDD _0510_ sky130_fd_sc_hd__nand2_1
X_1652_ _0757_ _0509_ _0510_ VSS VSS VDD VDD _0511_ sky130_fd_sc_hd__o21ai_0
X_1653_ _0503_ _0504_ _0209_ _0508_ _0511_ VSS VSS VDD VDD
+ _0512_ sky130_fd_sc_hd__a2111oi_1
X_1654_ mem\[0\]\[7\] _0369_ VSS VSS VDD VDD _0513_ sky130_fd_sc_hd__nor2_1
X_1655_ net74 _0371_ VSS VSS VDD VDD _0514_ sky130_fd_sc_hd__nand2_1
X_1656_ _0354_ _0512_ _0513_ _0514_ VSS VSS VDD VDD _0049_
+ sky130_fd_sc_hd__o31ai_1
X_1657_ _0748_ mem\[6\]\[8\] _0706_ _0749_ mem\[15\]\[8\]
+ VSS VSS VDD VDD _0515_ sky130_fd_sc_hd__a32o_1
X_1658_ _0825_ mem\[8\]\[8\] _0760_ VSS VSS VDD VDD _0516_
+ sky130_fd_sc_hd__nand3_1
X_1659_ _0682_ mem\[1\]\[8\] _0814_ VSS VSS VDD VDD _0517_
+ sky130_fd_sc_hd__nand3_1
X_1660_ _0516_ _0517_ _0816_ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__a21oi_1
X_1661_ _0649_ mem\[13\]\[8\] _0818_ VSS VSS VDD VDD _0519_
+ sky130_fd_sc_hd__nand3_1
X_1662_ _0820_ mem\[10\]\[8\] _0683_ VSS VSS VDD VDD _0520_
+ sky130_fd_sc_hd__nand3_1
X_1663_ _0648_ mem\[4\]\[8\] _0161_ VSS VSS VDD VDD _0521_
+ sky130_fd_sc_hd__and3_1
X_1664_ mem\[3\]\[8\] _0733_ _0521_ _0663_ VSS VSS VDD VDD
+ _0522_ sky130_fd_sc_hd__a211oi_1
X_1665_ _0645_ _0519_ _0520_ _0522_ VSS VSS VDD VDD _0523_
+ sky130_fd_sc_hd__a31oi_1
X_1666_ mem\[7\]\[8\] _0830_ _0831_ mem\[11\]\[8\] VSS VSS
+ VDD VDD _0524_ sky130_fd_sc_hd__a22oi_2
X_1667_ _0644_ _0822_ mem\[14\]\[8\] VSS VSS VDD VDD _0525_
+ sky130_fd_sc_hd__and3_1
X_1668_ _0659_ _0703_ mem\[2\]\[8\] VSS VSS VDD VDD _0526_
+ sky130_fd_sc_hd__nor3b_1
X_1669_ _0525_ _0526_ _0667_ VSS VSS VDD VDD _0527_ sky130_fd_sc_hd__o21ai_1
X_1670_ _0635_ _0639_ _0693_ mem\[5\]\[8\] VSS VSS VDD VDD
+ _0528_ sky130_fd_sc_hd__a22oi_2
X_1671_ _0752_ mem\[12\]\[8\] _0823_ VSS VSS VDD VDD _0529_
+ sky130_fd_sc_hd__and3_1
X_1672_ _0833_ mem\[9\]\[8\] _0813_ VSS VSS VDD VDD _0530_
+ sky130_fd_sc_hd__and3b_1
X_1673_ _0529_ _0530_ _0660_ VSS VSS VDD VDD _0531_ sky130_fd_sc_hd__o21ai_1
X_1674_ _0828_ _0524_ _0527_ _0528_ _0531_ VSS VSS VDD VDD
+ _0532_ sky130_fd_sc_hd__o2111ai_4
X_1675_ _0673_ _0515_ _0518_ _0523_ _0532_ VSS VSS VDD VDD
+ _0533_ sky130_fd_sc_hd__a2111oi_0
X_1676_ mem\[0\]\[8\] _0369_ VSS VSS VDD VDD _0534_ sky130_fd_sc_hd__nor2_1
X_1677_ net75 _0371_ VSS VSS VDD VDD _0535_ sky130_fd_sc_hd__nand2_1
X_1678_ _0354_ _0533_ _0534_ _0535_ VSS VSS VDD VDD _0050_
+ sky130_fd_sc_hd__o31ai_1
X_1679_ mem\[3\]\[9\] _0657_ _0770_ VSS VSS VDD VDD _0536_
+ sky130_fd_sc_hd__a21oi_1
X_1680_ _0719_ mem\[7\]\[9\] mem\[4\]\[9\] _0759_ _0677_ mem\[6\]\[9\]
+ VSS VSS VDD VDD _0537_ sky130_fd_sc_hd__a222oi_1
X_1681_ mem\[10\]\[9\] _0740_ _0203_ VSS VSS VDD VDD _0538_
+ sky130_fd_sc_hd__a21oi_1
X_1682_ mem\[14\]\[9\] _0666_ _0674_ mem\[13\]\[9\] mem\[12\]\[9\]
+ _0709_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__a222oi_1
X_1683_ _0536_ _0537_ _0538_ _0539_ VSS VSS VDD VDD _0540_
+ sky130_fd_sc_hd__a22oi_1
X_1684_ _0536_ _0538_ _0207_ VSS VSS VDD VDD _0541_ sky130_fd_sc_hd__o21ai_0
X_1685_ _0742_ mem\[1\]\[9\] _0710_ _0685_ mem\[11\]\[9\]
+ VSS VSS VDD VDD _0542_ sky130_fd_sc_hd__a32oi_1
X_1686_ _0712_ mem\[5\]\[9\] _0717_ VSS VSS VDD VDD _0543_
+ sky130_fd_sc_hd__and3_1
X_1687_ _0628_ mem\[2\]\[9\] _0647_ _0543_ VSS VSS VDD VDD
+ _0544_ sky130_fd_sc_hd__a31oi_1
X_1688_ _0655_ _0542_ _0544_ _0213_ VSS VSS VDD VDD _0545_
+ sky130_fd_sc_hd__o22ai_2
X_1689_ mem\[8\]\[9\] _0651_ _0215_ mem\[9\]\[9\] VSS VSS
+ VDD VDD _0546_ sky130_fd_sc_hd__a22oi_1
X_1690_ mem\[15\]\[9\] _0763_ VSS VSS VDD VDD _0547_ sky130_fd_sc_hd__nand2_1
X_1691_ _0757_ _0546_ _0547_ VSS VSS VDD VDD _0548_ sky130_fd_sc_hd__o21ai_1
X_1692_ _0540_ _0541_ _0209_ _0545_ _0548_ VSS VSS VDD VDD
+ _0549_ sky130_fd_sc_hd__a2111oi_2
X_1693_ mem\[0\]\[9\] _0641_ VSS VSS VDD VDD _0550_ sky130_fd_sc_hd__nor2_1
X_1694_ _0633_ VSS VSS VDD VDD _0551_ sky130_fd_sc_hd__buf_6
X_1695_ net76 _0551_ VSS VSS VDD VDD _0552_ sky130_fd_sc_hd__nand2_1
X_1696_ _0633_ _0549_ _0550_ _0552_ VSS VSS VDD VDD _0051_
+ sky130_fd_sc_hd__o31ai_1
X_1697_ rd_ptr_bin\[0\] _0551_ VSS VSS VDD VDD _0052_ sky130_fd_sc_hd__xnor2_1
X_1698_ _0019_ rd_ptr_bin\[1\] _0633_ VSS VSS VDD VDD _0053_
+ sky130_fd_sc_hd__mux2_1
X_1699_ _0829_ _0633_ VSS VSS VDD VDD _0553_ sky130_fd_sc_hd__nor2_1
X_1700_ _0867_ _0553_ VSS VSS VDD VDD _0054_ sky130_fd_sc_hd__xnor2_1
X_1701_ _0649_ rd_ptr_bin\[0\] rd_ptr_bin\[1\] VSS VSS VDD
+ VDD _0554_ sky130_fd_sc_hd__nand3_1
X_1702_ _0633_ _0554_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__nor2_1
X_1703_ _0863_ _0555_ VSS VSS VDD VDD _0055_ sky130_fd_sc_hd__xnor2_1
X_1704_ rd_ptr_bin\[0\] _0019_ VSS VSS VDD VDD _0556_ sky130_fd_sc_hd__xor2_1
X_1705_ rd_ptr_gray\[0\] _0551_ VSS VSS VDD VDD _0557_ sky130_fd_sc_hd__nand2_1
X_1706_ _0551_ _0556_ _0557_ VSS VSS VDD VDD _0056_ sky130_fd_sc_hd__o21ai_0
X_1707_ _0783_ _0698_ VSS VSS VDD VDD _0558_ sky130_fd_sc_hd__xor2_2
X_1708_ _0019_ _0558_ VSS VSS VDD VDD _0559_ sky130_fd_sc_hd__xnor2_1
X_1709_ rd_ptr_gray\[1\] _0551_ VSS VSS VDD VDD _0560_ sky130_fd_sc_hd__nand2_1
X_1710_ _0551_ _0559_ _0560_ VSS VSS VDD VDD _0057_ sky130_fd_sc_hd__o21ai_0
X_1711_ _0863_ _0554_ VSS VSS VDD VDD _0561_ sky130_fd_sc_hd__xnor2_1
X_1712_ _0558_ _0561_ VSS VSS VDD VDD _0562_ sky130_fd_sc_hd__xor2_1
X_1713_ rd_ptr_gray\[2\] _0551_ VSS VSS VDD VDD _0563_ sky130_fd_sc_hd__nand2_1
X_1714_ _0551_ _0562_ _0563_ VSS VSS VDD VDD _0058_ sky130_fd_sc_hd__o21ai_0
X_1715_ rd_ptr_bin\[4\] _0764_ VSS VSS VDD VDD _0564_ sky130_fd_sc_hd__xnor2_1
X_1716_ _0561_ _0564_ VSS VSS VDD VDD _0565_ sky130_fd_sc_hd__xnor2_1
X_1717_ rd_ptr_gray\[3\] _0551_ VSS VSS VDD VDD _0566_ sky130_fd_sc_hd__nand2_1
X_1718_ _0551_ _0565_ _0566_ VSS VSS VDD VDD _0059_ sky130_fd_sc_hd__o21ai_0
X_1719_ net2 _0625_ _0764_ VSS VSS VDD VDD _0567_ sky130_fd_sc_hd__nand3_1
X_1720_ rd_ptr_bin\[4\] _0567_ VSS VSS VDD VDD _0060_ sky130_fd_sc_hd__xnor2_1
X_1721_ _0631_ _0605_ VSS VSS VDD VDD _0061_ sky130_fd_sc_hd__xnor2_1
X_1722_ _0017_ _0595_ VSS VSS VDD VDD _0568_ sky130_fd_sc_hd__nand2_1
X_1723_ _0841_ _0595_ _0568_ VSS VSS VDD VDD _0062_ sky130_fd_sc_hd__o21ai_0
X_1724_ _0608_ _0595_ VSS VSS VDD VDD _0569_ sky130_fd_sc_hd__nand2_1
X_1725_ _0592_ _0569_ VSS VSS VDD VDD _0063_ sky130_fd_sc_hd__xnor2_1
X_1726_ _0592_ _0631_ wr_ptr_bin\[1\] _0595_ VSS VSS VDD VDD
+ _0570_ sky130_fd_sc_hd__nand4_1
X_1727_ _0593_ _0570_ VSS VSS VDD VDD _0064_ sky130_fd_sc_hd__xnor2_1
X_1728_ _0631_ _0017_ VSS VSS VDD VDD _0571_ sky130_fd_sc_hd__xor2_1
X_1729_ wr_ptr_gray\[0\] _0605_ VSS VSS VDD VDD _0572_ sky130_fd_sc_hd__nand2_1
X_1730_ _0605_ _0571_ _0572_ VSS VSS VDD VDD _0065_ sky130_fd_sc_hd__o21ai_0
X_1731_ _0608_ _0017_ VSS VSS VDD VDD _0573_ sky130_fd_sc_hd__xor2_1
X_1732_ _0592_ _0573_ VSS VSS VDD VDD _0574_ sky130_fd_sc_hd__xnor2_1
X_1733_ wr_ptr_gray\[1\] _0605_ VSS VSS VDD VDD _0575_ sky130_fd_sc_hd__nand2_1
X_1734_ _0605_ _0574_ _0575_ VSS VSS VDD VDD _0066_ sky130_fd_sc_hd__o21ai_0
X_1735_ _0593_ _0608_ VSS VSS VDD VDD _0576_ sky130_fd_sc_hd__xnor2_1
X_1736_ _0631_ wr_ptr_bin\[1\] VSS VSS VDD VDD _0577_ sky130_fd_sc_hd__nand2_1
X_1737_ _0592_ _0577_ VSS VSS VDD VDD _0578_ sky130_fd_sc_hd__nand2_1
X_1738_ _0576_ _0578_ VSS VSS VDD VDD _0579_ sky130_fd_sc_hd__xnor2_1
X_1739_ wr_ptr_gray\[2\] _0605_ VSS VSS VDD VDD _0580_ sky130_fd_sc_hd__nand2_1
X_1740_ _0605_ _0579_ _0580_ VSS VSS VDD VDD _0067_ sky130_fd_sc_hd__o21ai_0
X_1741_ wr_ptr_bin\[2\] _0608_ VSS VSS VDD VDD _0581_ sky130_fd_sc_hd__nand2_1
X_1742_ _0593_ _0581_ _0577_ VSS VSS VDD VDD _0582_ sky130_fd_sc_hd__a21boi_0
X_1743_ wr_ptr_bin\[2\] _0593_ _0631_ wr_ptr_bin\[1\] VSS
+ VSS VDD VDD _0583_ sky130_fd_sc_hd__nand4_1
X_1744_ _0592_ _0593_ _0608_ _0583_ VSS VSS VDD VDD _0584_
+ sky130_fd_sc_hd__o22ai_1
X_1745_ _0582_ _0584_ VSS VSS VDD VDD _0585_ sky130_fd_sc_hd__nor2_1
X_1746_ wr_ptr_bin\[4\] _0585_ VSS VSS VDD VDD _0586_ sky130_fd_sc_hd__xnor2_1
X_1747_ wr_ptr_gray\[3\] _0605_ VSS VSS VDD VDD _0587_ sky130_fd_sc_hd__nand2_1
X_1748_ _0605_ _0586_ _0587_ VSS VSS VDD VDD _0068_ sky130_fd_sc_hd__o21ai_0
X_1749_ _0592_ _0593_ _0608_ _0595_ VSS VSS VDD VDD _0588_
+ sky130_fd_sc_hd__nand4_1
X_1750_ wr_ptr_bin\[4\] _0588_ VSS VSS VDD VDD _0069_ sky130_fd_sc_hd__xnor2_1
X_1751_ net40 net41 net42 VSS VSS VDD VDD _0589_ sky130_fd_sc_hd__a21oi_1
X_1752_ net43 net44 net77 _0589_ VSS VSS VDD VDD net39 sky130_fd_sc_hd__nor4b_1
X_1753_ _0845_ VSS VSS VDD VDD net80 sky130_fd_sc_hd__inv_1
X_1754_ _0844_ _0855_ VSS VSS VDD VDD net81 sky130_fd_sc_hd__xnor2_1
X_1755_ net80 net82 net81 net83 VSS VSS VDD VDD net78 sky130_fd_sc_hd__a31o_1
X_1756_ _0841_ _0842_ _0843_ VSS VSS VDD VDD _0844_ _0845_
+ sky130_fd_sc_hd__fa_1
X_1757_ rd_ptr_bin\[1\] _0847_ _0848_ VSS VSS VDD VDD _0849_
+ _0850_ sky130_fd_sc_hd__fa_1
X_1758_ wr_ptr_bin\[1\] _0846_ VSS VSS VDD VDD _0851_ _0852_
+ sky130_fd_sc_hd__ha_1
X_1759_ wr_ptr_bin\[2\] _0853_ VSS VSS VDD VDD _0854_ _0855_
+ sky130_fd_sc_hd__ha_1
X_1760_ wr_ptr_bin\[3\] _0856_ VSS VSS VDD VDD _0857_ _0858_
+ sky130_fd_sc_hd__ha_1
X_1761_ _0859_ _0860_ VSS VSS VDD VDD _0861_ _0862_ sky130_fd_sc_hd__ha_1
X_1762_ _0863_ _0864_ VSS VSS VDD VDD _0865_ _0866_ sky130_fd_sc_hd__ha_1
X_1763_ _0867_ _0868_ VSS VSS VDD VDD _0869_ _0870_ sky130_fd_sc_hd__ha_1
X_1764_ _0016_ _0841_ VSS VSS VDD VDD _0871_ _0017_ sky130_fd_sc_hd__ha_1
X_1765_ _0016_ wr_ptr_bin\[1\] VSS VSS VDD VDD _0872_ _0873_
+ sky130_fd_sc_hd__ha_1
X_1766_ wr_ptr_bin\[0\] _0841_ VSS VSS VDD VDD _0874_ _0875_
+ sky130_fd_sc_hd__ha_1
X_1767_ wr_ptr_bin\[0\] wr_ptr_bin\[1\] VSS VSS VDD VDD _0876_
+ _0877_ sky130_fd_sc_hd__ha_1
X_1768_ _0018_ _0859_ VSS VSS VDD VDD _0878_ _0019_ sky130_fd_sc_hd__ha_1
X_1769_ _0018_ rd_ptr_bin\[1\] VSS VSS VDD VDD _0879_ _0880_
+ sky130_fd_sc_hd__ha_2
X_1770_ rd_ptr_bin\[0\] _0859_ VSS VSS VDD VDD _0881_ _0882_
+ sky130_fd_sc_hd__ha_1
X_1771_ rd_ptr_bin\[0\] rd_ptr_bin\[1\] VSS VSS VDD VDD _0883_
+ _0884_ sky130_fd_sc_hd__ha_1
X_1772_ rd_ptr_bin\[0\] _0885_ VSS VSS VDD VDD _0847_ _0886_
+ sky130_fd_sc_hd__ha_1
X_1773_ _0016_ _0887_ VSS VSS VDD VDD _0842_ _0888_ sky130_fd_sc_hd__ha_1
Xmem\[0\]\[0\]$_DFFE_PP_ net87 net5 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[10\]$_DFFE_PP_ net4 net6 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[11\]$_DFFE_PP_ net87 net7 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[12\]$_DFFE_PP_ net87 net8 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[13\]$_DFFE_PP_ net87 net9 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[14\]$_DFFE_PP_ net4 net10 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[15\]$_DFFE_PP_ net85 net11 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[16\]$_DFFE_PP_ net4 net12 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[17\]$_DFFE_PP_ net85 net13 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[18\]$_DFFE_PP_ net4 net14 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[19\]$_DFFE_PP_ net85 net15 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[1\]$_DFFE_PP_ net85 net16 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[20\]$_DFFE_PP_ net4 net17 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[21\]$_DFFE_PP_ net86 net18 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[22\]$_DFFE_PP_ net4 net19 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[23\]$_DFFE_PP_ net86 net20 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[24\]$_DFFE_PP_ net4 net21 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[25\]$_DFFE_PP_ net86 net22 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[26\]$_DFFE_PP_ net4 net23 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[27\]$_DFFE_PP_ net86 net24 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[28\]$_DFFE_PP_ net4 net25 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[29\]$_DFFE_PP_ net86 net26 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[2\]$_DFFE_PP_ net4 net27 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[30\]$_DFFE_PP_ net4 net28 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[31\]$_DFFE_PP_ net86 net29 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[3\]$_DFFE_PP_ net86 net30 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[4\]$_DFFE_PP_ net4 net31 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[5\]$_DFFE_PP_ net86 net32 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[6\]$_DFFE_PP_ net4 net33 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[7\]$_DFFE_PP_ net85 net34 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[8\]$_DFFE_PP_ net4 net35 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[9\]$_DFFE_PP_ net85 net36 _0015_ VSS VSS VDD VDD
+ mem\[0\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[0\]$_DFFE_PP_ net87 net5 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[10\]$_DFFE_PP_ net4 net6 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[11\]$_DFFE_PP_ net85 net7 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[12\]$_DFFE_PP_ net87 net8 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[13\]$_DFFE_PP_ net85 net9 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[14\]$_DFFE_PP_ net4 net10 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[15\]$_DFFE_PP_ net85 net11 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[16\]$_DFFE_PP_ net87 net12 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[17\]$_DFFE_PP_ net85 net13 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[18\]$_DFFE_PP_ net4 net14 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[19\]$_DFFE_PP_ net85 net15 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[1\]$_DFFE_PP_ net85 net16 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[20\]$_DFFE_PP_ net4 net17 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[21\]$_DFFE_PP_ net86 net18 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[22\]$_DFFE_PP_ net4 net19 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[23\]$_DFFE_PP_ net86 net20 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[24\]$_DFFE_PP_ net4 net21 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[25\]$_DFFE_PP_ net86 net22 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[26\]$_DFFE_PP_ net87 net23 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[27\]$_DFFE_PP_ net86 net24 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[28\]$_DFFE_PP_ net87 net25 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[29\]$_DFFE_PP_ net86 net26 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[2\]$_DFFE_PP_ net87 net27 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[30\]$_DFFE_PP_ net87 net28 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[31\]$_DFFE_PP_ net86 net29 _0005_ VSS VSS VDD
+ VDD mem\[10\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[3\]$_DFFE_PP_ net86 net30 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[4\]$_DFFE_PP_ net87 net31 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[5\]$_DFFE_PP_ net86 net32 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[6\]$_DFFE_PP_ net87 net33 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[7\]$_DFFE_PP_ net86 net34 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[8\]$_DFFE_PP_ net4 net35 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[9\]$_DFFE_PP_ net86 net36 _0005_ VSS VSS VDD VDD
+ mem\[10\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[0\]$_DFFE_PP_ net87 net5 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[10\]$_DFFE_PP_ net4 net6 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[11\]$_DFFE_PP_ net87 net7 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[12\]$_DFFE_PP_ net87 net8 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[13\]$_DFFE_PP_ net87 net9 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[14\]$_DFFE_PP_ net86 net10 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[15\]$_DFFE_PP_ net85 net11 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[16\]$_DFFE_PP_ net4 net12 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[17\]$_DFFE_PP_ net87 net13 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[18\]$_DFFE_PP_ net4 net14 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[19\]$_DFFE_PP_ net85 net15 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[1\]$_DFFE_PP_ net85 net16 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[20\]$_DFFE_PP_ net4 net17 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[21\]$_DFFE_PP_ net85 net18 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[22\]$_DFFE_PP_ net4 net19 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[23\]$_DFFE_PP_ net86 net20 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[24\]$_DFFE_PP_ net87 net21 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[25\]$_DFFE_PP_ net86 net22 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[26\]$_DFFE_PP_ net4 net23 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[27\]$_DFFE_PP_ net86 net24 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[28\]$_DFFE_PP_ net4 net25 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[29\]$_DFFE_PP_ net86 net26 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[2\]$_DFFE_PP_ net4 net27 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[30\]$_DFFE_PP_ net4 net28 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[31\]$_DFFE_PP_ net86 net29 _0004_ VSS VSS VDD
+ VDD mem\[11\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[3\]$_DFFE_PP_ net85 net30 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[4\]$_DFFE_PP_ net4 net31 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[5\]$_DFFE_PP_ net86 net32 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[6\]$_DFFE_PP_ net86 net33 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[7\]$_DFFE_PP_ net85 net34 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[8\]$_DFFE_PP_ net86 net35 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[9\]$_DFFE_PP_ net85 net36 _0004_ VSS VSS VDD VDD
+ mem\[11\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[0\]$_DFFE_PP_ net87 net5 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[10\]$_DFFE_PP_ net4 net6 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[11\]$_DFFE_PP_ net85 net7 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[12\]$_DFFE_PP_ net87 net8 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[13\]$_DFFE_PP_ net85 net9 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[14\]$_DFFE_PP_ net86 net10 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[15\]$_DFFE_PP_ net85 net11 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[16\]$_DFFE_PP_ net4 net12 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[17\]$_DFFE_PP_ net85 net13 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[18\]$_DFFE_PP_ net4 net14 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[19\]$_DFFE_PP_ net85 net15 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[1\]$_DFFE_PP_ net85 net16 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[20\]$_DFFE_PP_ net86 net17 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[21\]$_DFFE_PP_ net86 net18 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[22\]$_DFFE_PP_ net86 net19 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[23\]$_DFFE_PP_ net86 net20 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[24\]$_DFFE_PP_ net87 net21 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[25\]$_DFFE_PP_ net86 net22 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[26\]$_DFFE_PP_ net86 net23 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[27\]$_DFFE_PP_ net86 net24 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[28\]$_DFFE_PP_ net86 net25 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[29\]$_DFFE_PP_ net86 net26 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[2\]$_DFFE_PP_ net86 net27 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[30\]$_DFFE_PP_ net4 net28 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[31\]$_DFFE_PP_ net86 net29 _0003_ VSS VSS VDD
+ VDD mem\[12\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[3\]$_DFFE_PP_ net86 net30 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[4\]$_DFFE_PP_ net87 net31 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[5\]$_DFFE_PP_ net86 net32 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[6\]$_DFFE_PP_ net86 net33 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[7\]$_DFFE_PP_ net86 net34 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[8\]$_DFFE_PP_ net86 net35 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[9\]$_DFFE_PP_ net86 net36 _0003_ VSS VSS VDD VDD
+ mem\[12\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[0\]$_DFFE_PP_ net87 net5 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[10\]$_DFFE_PP_ net4 net6 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[11\]$_DFFE_PP_ net85 net7 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[12\]$_DFFE_PP_ net87 net8 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[13\]$_DFFE_PP_ net85 net9 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[14\]$_DFFE_PP_ net4 net10 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[15\]$_DFFE_PP_ net85 net11 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[16\]$_DFFE_PP_ net4 net12 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[17\]$_DFFE_PP_ net85 net13 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[18\]$_DFFE_PP_ net4 net14 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[19\]$_DFFE_PP_ net85 net15 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[1\]$_DFFE_PP_ net85 net16 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[20\]$_DFFE_PP_ net4 net17 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[21\]$_DFFE_PP_ net86 net18 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[22\]$_DFFE_PP_ net4 net19 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[23\]$_DFFE_PP_ net86 net20 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[24\]$_DFFE_PP_ net4 net21 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[25\]$_DFFE_PP_ net86 net22 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[26\]$_DFFE_PP_ net87 net23 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[27\]$_DFFE_PP_ net86 net24 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[28\]$_DFFE_PP_ net87 net25 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[29\]$_DFFE_PP_ net86 net26 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[2\]$_DFFE_PP_ net87 net27 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[30\]$_DFFE_PP_ net4 net28 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[31\]$_DFFE_PP_ net86 net29 _0002_ VSS VSS VDD
+ VDD mem\[13\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[3\]$_DFFE_PP_ net86 net30 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[4\]$_DFFE_PP_ net87 net31 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[5\]$_DFFE_PP_ net86 net32 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[6\]$_DFFE_PP_ net87 net33 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[7\]$_DFFE_PP_ net86 net34 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[8\]$_DFFE_PP_ net4 net35 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[9\]$_DFFE_PP_ net86 net36 _0002_ VSS VSS VDD VDD
+ mem\[13\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[0\]$_DFFE_PP_ net87 net5 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[10\]$_DFFE_PP_ net4 net6 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[11\]$_DFFE_PP_ net85 net7 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[12\]$_DFFE_PP_ net87 net8 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[13\]$_DFFE_PP_ net85 net9 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[14\]$_DFFE_PP_ net86 net10 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[15\]$_DFFE_PP_ net85 net11 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[16\]$_DFFE_PP_ net4 net12 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[17\]$_DFFE_PP_ net85 net13 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[18\]$_DFFE_PP_ net4 net14 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[19\]$_DFFE_PP_ net85 net15 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[1\]$_DFFE_PP_ net85 net16 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[20\]$_DFFE_PP_ net86 net17 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[21\]$_DFFE_PP_ net86 net18 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[22\]$_DFFE_PP_ net4 net19 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[23\]$_DFFE_PP_ net86 net20 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[24\]$_DFFE_PP_ net87 net21 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[25\]$_DFFE_PP_ net86 net22 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[26\]$_DFFE_PP_ net4 net23 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[27\]$_DFFE_PP_ net86 net24 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[28\]$_DFFE_PP_ net86 net25 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[29\]$_DFFE_PP_ net86 net26 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[2\]$_DFFE_PP_ net86 net27 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[30\]$_DFFE_PP_ net4 net28 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[31\]$_DFFE_PP_ net86 net29 _0001_ VSS VSS VDD
+ VDD mem\[14\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[3\]$_DFFE_PP_ net86 net30 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[4\]$_DFFE_PP_ net87 net31 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[5\]$_DFFE_PP_ net86 net32 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[6\]$_DFFE_PP_ net87 net33 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[7\]$_DFFE_PP_ net86 net34 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[8\]$_DFFE_PP_ net86 net35 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[9\]$_DFFE_PP_ net86 net36 _0001_ VSS VSS VDD VDD
+ mem\[14\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[0\]$_DFFE_PP_ net87 net5 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[10\]$_DFFE_PP_ net4 net6 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[11\]$_DFFE_PP_ net87 net7 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[12\]$_DFFE_PP_ net87 net8 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[13\]$_DFFE_PP_ net87 net9 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[14\]$_DFFE_PP_ net4 net10 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[15\]$_DFFE_PP_ net85 net11 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[16\]$_DFFE_PP_ net4 net12 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[17\]$_DFFE_PP_ net85 net13 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[18\]$_DFFE_PP_ net4 net14 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[19\]$_DFFE_PP_ net85 net15 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[1\]$_DFFE_PP_ net85 net16 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[20\]$_DFFE_PP_ net4 net17 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[21\]$_DFFE_PP_ net86 net18 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[22\]$_DFFE_PP_ net4 net19 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[23\]$_DFFE_PP_ net86 net20 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[24\]$_DFFE_PP_ net4 net21 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[25\]$_DFFE_PP_ net86 net22 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[26\]$_DFFE_PP_ net87 net23 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[27\]$_DFFE_PP_ net86 net24 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[28\]$_DFFE_PP_ net87 net25 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[29\]$_DFFE_PP_ net86 net26 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[2\]$_DFFE_PP_ net87 net27 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[30\]$_DFFE_PP_ net4 net28 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[31\]$_DFFE_PP_ net86 net29 _0000_ VSS VSS VDD
+ VDD mem\[15\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[3\]$_DFFE_PP_ net86 net30 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[4\]$_DFFE_PP_ net87 net31 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[5\]$_DFFE_PP_ net86 net32 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[6\]$_DFFE_PP_ net87 net33 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[7\]$_DFFE_PP_ net86 net34 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[8\]$_DFFE_PP_ net87 net35 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[9\]$_DFFE_PP_ net86 net36 _0000_ VSS VSS VDD VDD
+ mem\[15\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[0\]$_DFFE_PP_ net87 net5 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[10\]$_DFFE_PP_ net4 net6 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[11\]$_DFFE_PP_ net87 net7 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[12\]$_DFFE_PP_ net85 net8 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[13\]$_DFFE_PP_ net87 net9 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[14\]$_DFFE_PP_ net4 net10 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[15\]$_DFFE_PP_ net85 net11 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[16\]$_DFFE_PP_ net4 net12 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[17\]$_DFFE_PP_ net87 net13 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[18\]$_DFFE_PP_ net4 net14 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[19\]$_DFFE_PP_ net85 net15 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[1\]$_DFFE_PP_ net85 net16 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[20\]$_DFFE_PP_ net4 net17 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[21\]$_DFFE_PP_ net85 net18 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[22\]$_DFFE_PP_ net4 net19 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[23\]$_DFFE_PP_ net86 net20 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[24\]$_DFFE_PP_ net4 net21 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[25\]$_DFFE_PP_ net86 net22 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[26\]$_DFFE_PP_ net4 net23 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[27\]$_DFFE_PP_ net86 net24 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[28\]$_DFFE_PP_ net4 net25 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[29\]$_DFFE_PP_ net86 net26 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[2\]$_DFFE_PP_ net4 net27 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[30\]$_DFFE_PP_ net4 net28 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[31\]$_DFFE_PP_ net86 net29 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[3\]$_DFFE_PP_ net85 net30 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[4\]$_DFFE_PP_ net87 net31 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[5\]$_DFFE_PP_ net86 net32 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[6\]$_DFFE_PP_ net4 net33 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[7\]$_DFFE_PP_ net85 net34 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[8\]$_DFFE_PP_ net4 net35 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[9\]$_DFFE_PP_ net85 net36 _0014_ VSS VSS VDD VDD
+ mem\[1\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[0\]$_DFFE_PP_ net87 net5 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[10\]$_DFFE_PP_ net4 net6 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[11\]$_DFFE_PP_ net87 net7 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[12\]$_DFFE_PP_ net87 net8 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[13\]$_DFFE_PP_ net87 net9 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[14\]$_DFFE_PP_ net86 net10 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[15\]$_DFFE_PP_ net85 net11 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[16\]$_DFFE_PP_ net87 net12 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[17\]$_DFFE_PP_ net87 net13 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[18\]$_DFFE_PP_ net87 net14 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[19\]$_DFFE_PP_ net85 net15 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[1\]$_DFFE_PP_ net85 net16 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[20\]$_DFFE_PP_ net86 net17 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[21\]$_DFFE_PP_ net85 net18 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[22\]$_DFFE_PP_ net4 net19 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[23\]$_DFFE_PP_ net86 net20 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[24\]$_DFFE_PP_ net87 net21 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[25\]$_DFFE_PP_ net86 net22 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[26\]$_DFFE_PP_ net4 net23 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[27\]$_DFFE_PP_ net86 net24 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[28\]$_DFFE_PP_ net86 net25 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[29\]$_DFFE_PP_ net86 net26 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[2\]$_DFFE_PP_ net4 net27 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[30\]$_DFFE_PP_ net87 net28 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[31\]$_DFFE_PP_ net86 net29 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[3\]$_DFFE_PP_ net85 net30 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[4\]$_DFFE_PP_ net87 net31 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[5\]$_DFFE_PP_ net86 net32 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[6\]$_DFFE_PP_ net87 net33 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[7\]$_DFFE_PP_ net85 net34 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[8\]$_DFFE_PP_ net86 net35 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[9\]$_DFFE_PP_ net85 net36 _0013_ VSS VSS VDD VDD
+ mem\[2\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[0\]$_DFFE_PP_ net87 net5 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[10\]$_DFFE_PP_ net4 net6 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[11\]$_DFFE_PP_ net85 net7 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[12\]$_DFFE_PP_ net87 net8 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[13\]$_DFFE_PP_ net85 net9 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[14\]$_DFFE_PP_ net4 net10 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[15\]$_DFFE_PP_ net85 net11 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[16\]$_DFFE_PP_ net87 net12 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[17\]$_DFFE_PP_ net85 net13 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[18\]$_DFFE_PP_ net87 net14 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[19\]$_DFFE_PP_ net85 net15 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[1\]$_DFFE_PP_ net85 net16 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[20\]$_DFFE_PP_ net4 net17 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[21\]$_DFFE_PP_ net86 net18 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[22\]$_DFFE_PP_ net4 net19 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[23\]$_DFFE_PP_ net86 net20 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[24\]$_DFFE_PP_ net4 net21 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[25\]$_DFFE_PP_ net86 net22 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[26\]$_DFFE_PP_ net87 net23 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[27\]$_DFFE_PP_ net86 net24 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[28\]$_DFFE_PP_ net87 net25 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[29\]$_DFFE_PP_ net86 net26 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[2\]$_DFFE_PP_ net87 net27 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[30\]$_DFFE_PP_ net87 net28 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[31\]$_DFFE_PP_ net86 net29 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[3\]$_DFFE_PP_ net86 net30 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[4\]$_DFFE_PP_ net87 net31 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[5\]$_DFFE_PP_ net86 net32 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[6\]$_DFFE_PP_ net87 net33 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[7\]$_DFFE_PP_ net86 net34 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[8\]$_DFFE_PP_ net87 net35 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[9\]$_DFFE_PP_ net86 net36 _0012_ VSS VSS VDD VDD
+ mem\[3\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[0\]$_DFFE_PP_ net87 net5 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[10\]$_DFFE_PP_ net4 net6 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[11\]$_DFFE_PP_ net85 net7 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[12\]$_DFFE_PP_ net87 net8 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[13\]$_DFFE_PP_ net85 net9 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[14\]$_DFFE_PP_ net4 net10 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[15\]$_DFFE_PP_ net85 net11 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[16\]$_DFFE_PP_ net4 net12 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[17\]$_DFFE_PP_ net85 net13 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[18\]$_DFFE_PP_ net4 net14 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[19\]$_DFFE_PP_ net85 net15 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[1\]$_DFFE_PP_ net85 net16 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[20\]$_DFFE_PP_ net4 net17 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[21\]$_DFFE_PP_ net86 net18 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[22\]$_DFFE_PP_ net4 net19 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[23\]$_DFFE_PP_ net86 net20 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[24\]$_DFFE_PP_ net4 net21 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[25\]$_DFFE_PP_ net86 net22 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[26\]$_DFFE_PP_ net4 net23 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[27\]$_DFFE_PP_ net86 net24 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[28\]$_DFFE_PP_ net87 net25 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[29\]$_DFFE_PP_ net86 net26 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[2\]$_DFFE_PP_ net87 net27 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[30\]$_DFFE_PP_ net4 net28 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[31\]$_DFFE_PP_ net86 net29 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[3\]$_DFFE_PP_ net86 net30 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[4\]$_DFFE_PP_ net87 net31 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[5\]$_DFFE_PP_ net86 net32 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[6\]$_DFFE_PP_ net87 net33 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[7\]$_DFFE_PP_ net86 net34 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[8\]$_DFFE_PP_ net87 net35 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[9\]$_DFFE_PP_ net86 net36 _0011_ VSS VSS VDD VDD
+ mem\[4\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[0\]$_DFFE_PP_ net87 net5 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[10\]$_DFFE_PP_ net4 net6 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[11\]$_DFFE_PP_ net87 net7 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[12\]$_DFFE_PP_ net87 net8 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[13\]$_DFFE_PP_ net87 net9 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[14\]$_DFFE_PP_ net86 net10 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[15\]$_DFFE_PP_ net85 net11 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[16\]$_DFFE_PP_ net4 net12 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[17\]$_DFFE_PP_ net87 net13 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[18\]$_DFFE_PP_ net4 net14 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[19\]$_DFFE_PP_ net85 net15 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[1\]$_DFFE_PP_ net85 net16 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[20\]$_DFFE_PP_ net86 net17 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[21\]$_DFFE_PP_ net85 net18 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[22\]$_DFFE_PP_ net4 net19 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[23\]$_DFFE_PP_ net86 net20 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[24\]$_DFFE_PP_ net87 net21 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[25\]$_DFFE_PP_ net86 net22 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[26\]$_DFFE_PP_ net86 net23 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[27\]$_DFFE_PP_ net86 net24 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[28\]$_DFFE_PP_ net86 net25 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[29\]$_DFFE_PP_ net86 net26 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[2\]$_DFFE_PP_ net86 net27 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[30\]$_DFFE_PP_ net4 net28 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[31\]$_DFFE_PP_ net86 net29 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[3\]$_DFFE_PP_ net85 net30 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[4\]$_DFFE_PP_ net87 net31 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[5\]$_DFFE_PP_ net86 net32 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[6\]$_DFFE_PP_ net86 net33 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[7\]$_DFFE_PP_ net85 net34 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[8\]$_DFFE_PP_ net86 net35 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[9\]$_DFFE_PP_ net85 net36 _0010_ VSS VSS VDD VDD
+ mem\[5\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[0\]$_DFFE_PP_ net87 net5 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[10\]$_DFFE_PP_ net4 net6 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[11\]$_DFFE_PP_ net85 net7 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[12\]$_DFFE_PP_ net87 net8 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[13\]$_DFFE_PP_ net85 net9 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[14\]$_DFFE_PP_ net4 net10 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[15\]$_DFFE_PP_ net85 net11 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[16\]$_DFFE_PP_ net4 net12 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[17\]$_DFFE_PP_ net85 net13 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[18\]$_DFFE_PP_ net4 net14 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[19\]$_DFFE_PP_ net85 net15 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[1\]$_DFFE_PP_ net85 net16 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[20\]$_DFFE_PP_ net4 net17 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[21\]$_DFFE_PP_ net86 net18 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[22\]$_DFFE_PP_ net4 net19 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[23\]$_DFFE_PP_ net86 net20 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[24\]$_DFFE_PP_ net4 net21 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[25\]$_DFFE_PP_ net86 net22 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[26\]$_DFFE_PP_ net87 net23 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[27\]$_DFFE_PP_ net86 net24 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[28\]$_DFFE_PP_ net87 net25 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[29\]$_DFFE_PP_ net86 net26 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[2\]$_DFFE_PP_ net87 net27 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[30\]$_DFFE_PP_ net4 net28 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[31\]$_DFFE_PP_ net86 net29 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[3\]$_DFFE_PP_ net86 net30 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[4\]$_DFFE_PP_ net87 net31 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[5\]$_DFFE_PP_ net86 net32 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[6\]$_DFFE_PP_ net87 net33 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[7\]$_DFFE_PP_ net86 net34 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[8\]$_DFFE_PP_ net87 net35 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[9\]$_DFFE_PP_ net86 net36 _0009_ VSS VSS VDD VDD
+ mem\[6\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[0\]$_DFFE_PP_ net87 net5 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[10\]$_DFFE_PP_ net4 net6 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[11\]$_DFFE_PP_ net85 net7 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[12\]$_DFFE_PP_ net87 net8 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[13\]$_DFFE_PP_ net85 net9 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[14\]$_DFFE_PP_ net86 net10 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[15\]$_DFFE_PP_ net85 net11 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[16\]$_DFFE_PP_ net4 net12 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[17\]$_DFFE_PP_ net85 net13 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[18\]$_DFFE_PP_ net4 net14 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[19\]$_DFFE_PP_ net85 net15 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[1\]$_DFFE_PP_ net85 net16 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[20\]$_DFFE_PP_ net4 net17 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[21\]$_DFFE_PP_ net86 net18 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[22\]$_DFFE_PP_ net4 net19 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[23\]$_DFFE_PP_ net86 net20 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[24\]$_DFFE_PP_ net87 net21 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[25\]$_DFFE_PP_ net86 net22 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[26\]$_DFFE_PP_ net4 net23 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[27\]$_DFFE_PP_ net86 net24 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[28\]$_DFFE_PP_ net86 net25 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[29\]$_DFFE_PP_ net86 net26 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[2\]$_DFFE_PP_ net4 net27 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[30\]$_DFFE_PP_ net4 net28 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[31\]$_DFFE_PP_ net86 net29 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[3\]$_DFFE_PP_ net86 net30 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[4\]$_DFFE_PP_ net4 net31 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[5\]$_DFFE_PP_ net86 net32 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[6\]$_DFFE_PP_ net86 net33 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[7\]$_DFFE_PP_ net86 net34 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[8\]$_DFFE_PP_ net86 net35 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[9\]$_DFFE_PP_ net86 net36 _0008_ VSS VSS VDD VDD
+ mem\[7\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[0\]$_DFFE_PP_ net87 net5 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[10\]$_DFFE_PP_ net4 net6 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[11\]$_DFFE_PP_ net87 net7 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[12\]$_DFFE_PP_ net87 net8 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[13\]$_DFFE_PP_ net87 net9 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[14\]$_DFFE_PP_ net4 net10 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[15\]$_DFFE_PP_ net85 net11 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[16\]$_DFFE_PP_ net4 net12 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[17\]$_DFFE_PP_ net85 net13 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[18\]$_DFFE_PP_ net4 net14 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[19\]$_DFFE_PP_ net85 net15 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[1\]$_DFFE_PP_ net85 net16 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[20\]$_DFFE_PP_ net4 net17 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[21\]$_DFFE_PP_ net86 net18 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[22\]$_DFFE_PP_ net4 net19 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[23\]$_DFFE_PP_ net86 net20 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[24\]$_DFFE_PP_ net4 net21 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[25\]$_DFFE_PP_ net86 net22 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[26\]$_DFFE_PP_ net4 net23 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[27\]$_DFFE_PP_ net86 net24 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[28\]$_DFFE_PP_ net87 net25 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[29\]$_DFFE_PP_ net86 net26 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[2\]$_DFFE_PP_ net87 net27 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[30\]$_DFFE_PP_ net4 net28 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[31\]$_DFFE_PP_ net86 net29 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[3\]$_DFFE_PP_ net86 net30 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[4\]$_DFFE_PP_ net87 net31 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[5\]$_DFFE_PP_ net86 net32 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[6\]$_DFFE_PP_ net4 net33 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[7\]$_DFFE_PP_ net86 net34 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[8\]$_DFFE_PP_ net4 net35 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[9\]$_DFFE_PP_ net86 net36 _0007_ VSS VSS VDD VDD
+ mem\[8\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[0\]$_DFFE_PP_ net87 net5 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[10\]$_DFFE_PP_ net4 net6 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[11\]$_DFFE_PP_ net87 net7 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[12\]$_DFFE_PP_ net87 net8 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[13\]$_DFFE_PP_ net87 net9 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[14\]$_DFFE_PP_ net86 net10 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[15\]$_DFFE_PP_ net85 net11 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[16\]$_DFFE_PP_ net87 net12 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[17\]$_DFFE_PP_ net85 net13 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[18\]$_DFFE_PP_ net4 net14 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[19\]$_DFFE_PP_ net85 net15 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[1\]$_DFFE_PP_ net85 net16 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[20\]$_DFFE_PP_ net86 net17 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[21\]$_DFFE_PP_ net86 net18 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[22\]$_DFFE_PP_ net86 net19 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[23\]$_DFFE_PP_ net86 net20 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[24\]$_DFFE_PP_ net87 net21 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[25\]$_DFFE_PP_ net86 net22 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[26\]$_DFFE_PP_ net86 net23 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[27\]$_DFFE_PP_ net86 net24 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[28\]$_DFFE_PP_ net86 net25 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[29\]$_DFFE_PP_ net86 net26 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[2\]$_DFFE_PP_ net86 net27 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[30\]$_DFFE_PP_ net87 net28 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[31\]$_DFFE_PP_ net86 net29 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[3\]$_DFFE_PP_ net86 net30 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[4\]$_DFFE_PP_ net87 net31 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[5\]$_DFFE_PP_ net86 net32 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[6\]$_DFFE_PP_ net86 net33 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[7\]$_DFFE_PP_ net86 net34 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[8\]$_DFFE_PP_ net86 net35 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[9\]$_DFFE_PP_ net86 net36 _0006_ VSS VSS VDD VDD
+ mem\[9\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xrd_data\[0\]$_DFFE_PN0P_ net1 _0020_ net3 VSS VSS VDD VDD
+ net45 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[10\]$_DFFE_PN0P_ net1 _0021_ net3 VSS VSS VDD VDD
+ net46 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[11\]$_DFFE_PN0P_ net1 _0022_ net3 VSS VSS VDD VDD
+ net47 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[12\]$_DFFE_PN0P_ net1 _0023_ net3 VSS VSS VDD VDD
+ net48 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[13\]$_DFFE_PN0P_ net1 _0024_ net3 VSS VSS VDD VDD
+ net49 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[14\]$_DFFE_PN0P_ net1 _0025_ net3 VSS VSS VDD VDD
+ net50 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[15\]$_DFFE_PN0P_ net1 _0026_ net3 VSS VSS VDD VDD
+ net51 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[16\]$_DFFE_PN0P_ net1 _0027_ net3 VSS VSS VDD VDD
+ net52 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[17\]$_DFFE_PN0P_ net1 _0028_ net3 VSS VSS VDD VDD
+ net53 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[18\]$_DFFE_PN0P_ net1 _0029_ net3 VSS VSS VDD VDD
+ net54 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[19\]$_DFFE_PN0P_ net1 _0030_ net3 VSS VSS VDD VDD
+ net55 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[1\]$_DFFE_PN0P_ net1 _0031_ net3 VSS VSS VDD VDD
+ net56 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[20\]$_DFFE_PN0P_ net1 _0032_ net3 VSS VSS VDD VDD
+ net57 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[21\]$_DFFE_PN0P_ net1 _0033_ net3 VSS VSS VDD VDD
+ net58 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[22\]$_DFFE_PN0P_ net1 _0034_ net3 VSS VSS VDD VDD
+ net59 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[23\]$_DFFE_PN0P_ net1 _0035_ net3 VSS VSS VDD VDD
+ net60 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[24\]$_DFFE_PN0P_ net1 _0036_ net3 VSS VSS VDD VDD
+ net61 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[25\]$_DFFE_PN0P_ net1 _0037_ net3 VSS VSS VDD VDD
+ net62 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[26\]$_DFFE_PN0P_ net1 _0038_ net3 VSS VSS VDD VDD
+ net63 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[27\]$_DFFE_PN0P_ net1 _0039_ net3 VSS VSS VDD VDD
+ net64 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[28\]$_DFFE_PN0P_ net1 _0040_ net3 VSS VSS VDD VDD
+ net65 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[29\]$_DFFE_PN0P_ net1 _0041_ net3 VSS VSS VDD VDD
+ net66 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[2\]$_DFFE_PN0P_ net1 _0042_ net3 VSS VSS VDD VDD
+ net67 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[30\]$_DFFE_PN0P_ net1 _0043_ net3 VSS VSS VDD VDD
+ net68 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[31\]$_DFFE_PN0P_ net1 _0044_ net3 VSS VSS VDD VDD
+ net69 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[3\]$_DFFE_PN0P_ net1 _0045_ net3 VSS VSS VDD VDD
+ net70 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[4\]$_DFFE_PN0P_ net1 _0046_ net3 VSS VSS VDD VDD
+ net71 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[5\]$_DFFE_PN0P_ net1 _0047_ net3 VSS VSS VDD VDD
+ net72 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[6\]$_DFFE_PN0P_ net1 _0048_ net3 VSS VSS VDD VDD
+ net73 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[7\]$_DFFE_PN0P_ net1 _0049_ net3 VSS VSS VDD VDD
+ net74 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[8\]$_DFFE_PN0P_ net1 _0050_ net3 VSS VSS VDD VDD
+ net75 sky130_fd_sc_hd__dfrtp_1
Xrd_data\[9\]$_DFFE_PN0P_ net1 _0051_ net3 VSS VSS VDD VDD
+ net76 sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_bin\[0\]$_DFFE_PN0P_ net1 _0052_ net3 VSS VSS VDD
+ VDD rd_ptr_bin\[0\] sky130_fd_sc_hd__dfrtp_4
Xrd_ptr_bin\[1\]$_DFFE_PN0P_ net1 _0053_ net3 VSS VSS VDD
+ VDD rd_ptr_bin\[1\] sky130_fd_sc_hd__dfrtp_2
Xrd_ptr_bin\[2\]$_DFFE_PN0P_ net1 _0054_ net3 VSS VSS VDD
+ VDD rd_ptr_bin\[2\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_bin\[3\]$_DFFE_PN0P_ net1 _0055_ net3 VSS VSS VDD
+ VDD rd_ptr_bin\[3\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray\[0\]$_DFFE_PN0P_ net1 _0056_ net3 VSS VSS VDD
+ VDD rd_ptr_gray\[0\] sky130_fd_sc_hd__dfrtp_2
Xrd_ptr_gray\[1\]$_DFFE_PN0P_ net1 _0057_ net3 VSS VSS VDD
+ VDD rd_ptr_gray\[1\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray\[2\]$_DFFE_PN0P_ net1 _0058_ net3 VSS VSS VDD
+ VDD rd_ptr_gray\[2\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray\[3\]$_DFFE_PN0P_ net1 _0059_ net3 VSS VSS VDD
+ VDD rd_ptr_gray\[3\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray\[4\]$_DFFE_PN0P_ net1 _0060_ net3 VSS VSS VDD
+ VDD rd_ptr_bin\[4\] sky130_fd_sc_hd__dfrtp_2
Xrd_ptr_gray_sync1\[0\]$_DFF_PN0_ net87 rd_ptr_gray\[0\] net38
+ VSS VSS VDD VDD rd_ptr_gray_sync1\[0\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray_sync1\[1\]$_DFF_PN0_ net87 rd_ptr_gray\[1\] net38
+ VSS VSS VDD VDD rd_ptr_gray_sync1\[1\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray_sync1\[2\]$_DFF_PN0_ net87 rd_ptr_gray\[2\] net38
+ VSS VSS VDD VDD rd_ptr_gray_sync1\[2\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray_sync1\[3\]$_DFF_PN0_ net87 rd_ptr_gray\[3\] net38
+ VSS VSS VDD VDD rd_ptr_gray_sync1\[3\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray_sync1\[4\]$_DFF_PN0_ net87 rd_ptr_bin\[4\] net38
+ VSS VSS VDD VDD rd_ptr_gray_sync1\[4\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray_sync2\[0\]$_DFF_PN0_ net87 rd_ptr_gray_sync1\[0\]
+ net38 VSS VSS VDD VDD rd_ptr_gray_sync2\[0\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray_sync2\[1\]$_DFF_PN0_ net87 rd_ptr_gray_sync1\[1\]
+ net38 VSS VSS VDD VDD rd_ptr_gray_sync2\[1\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray_sync2\[2\]$_DFF_PN0_ net87 rd_ptr_gray_sync1\[2\]
+ net38 VSS VSS VDD VDD rd_ptr_gray_sync2\[2\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray_sync2\[3\]$_DFF_PN0_ net87 rd_ptr_gray_sync1\[3\]
+ net38 VSS VSS VDD VDD rd_ptr_gray_sync2\[3\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr_gray_sync2\[4\]$_DFF_PN0_ net87 rd_ptr_gray_sync1\[4\]
+ net38 VSS VSS VDD VDD rd_ptr_gray_sync2\[4\] sky130_fd_sc_hd__dfrtp_2
Xwr_ptr_bin\[0\]$_DFFE_PN0P_ net85 _0061_ net38 VSS VSS VDD
+ VDD wr_ptr_bin\[0\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_bin\[1\]$_DFFE_PN0P_ net85 _0062_ net38 VSS VSS VDD
+ VDD wr_ptr_bin\[1\] sky130_fd_sc_hd__dfrtp_4
Xwr_ptr_bin\[2\]$_DFFE_PN0P_ net85 _0063_ net38 VSS VSS VDD
+ VDD wr_ptr_bin\[2\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_bin\[3\]$_DFFE_PN0P_ net85 _0064_ net38 VSS VSS VDD
+ VDD wr_ptr_bin\[3\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray\[0\]$_DFFE_PN0P_ net87 _0065_ net38 VSS VSS VDD
+ VDD wr_ptr_gray\[0\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray\[1\]$_DFFE_PN0P_ net87 _0066_ net38 VSS VSS VDD
+ VDD wr_ptr_gray\[1\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray\[2\]$_DFFE_PN0P_ net87 _0067_ net38 VSS VSS VDD
+ VDD wr_ptr_gray\[2\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray\[3\]$_DFFE_PN0P_ net87 _0068_ net38 VSS VSS VDD
+ VDD wr_ptr_gray\[3\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray\[4\]$_DFFE_PN0P_ net87 _0069_ net38 VSS VSS VDD
+ VDD wr_ptr_bin\[4\] sky130_fd_sc_hd__dfrtp_4
Xwr_ptr_gray_sync1\[0\]$_DFF_PN0_ net1 wr_ptr_gray\[0\] net3
+ VSS VSS VDD VDD wr_ptr_gray_sync1\[0\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray_sync1\[1\]$_DFF_PN0_ net1 wr_ptr_gray\[1\] net3
+ VSS VSS VDD VDD wr_ptr_gray_sync1\[1\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray_sync1\[2\]$_DFF_PN0_ net1 wr_ptr_gray\[2\] net3
+ VSS VSS VDD VDD wr_ptr_gray_sync1\[2\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray_sync1\[3\]$_DFF_PN0_ net1 wr_ptr_gray\[3\] net3
+ VSS VSS VDD VDD wr_ptr_gray_sync1\[3\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray_sync1\[4\]$_DFF_PN0_ net1 wr_ptr_bin\[4\] net3
+ VSS VSS VDD VDD wr_ptr_gray_sync1\[4\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray_sync2\[0\]$_DFF_PN0_ net1 wr_ptr_gray_sync1\[0\]
+ net3 VSS VSS VDD VDD wr_ptr_gray_sync2\[0\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray_sync2\[1\]$_DFF_PN0_ net1 wr_ptr_gray_sync1\[1\]
+ net3 VSS VSS VDD VDD wr_ptr_gray_sync2\[1\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray_sync2\[2\]$_DFF_PN0_ net1 wr_ptr_gray_sync1\[2\]
+ net3 VSS VSS VDD VDD wr_ptr_gray_sync2\[2\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray_sync2\[3\]$_DFF_PN0_ net1 wr_ptr_gray_sync1\[3\]
+ net3 VSS VSS VDD VDD wr_ptr_gray_sync2\[3\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr_gray_sync2\[4\]$_DFF_PN0_ net1 wr_ptr_gray_sync1\[4\]
+ net3 VSS VSS VDD VDD wr_ptr_gray_sync2\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 rd_clk VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_12
Xinput2 rd_en VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput3 rd_rst_n VSS VSS VDD VDD net3 sky130_fd_sc_hd__buf_16
Xinput4 wr_clk VSS VSS VDD VDD net4 sky130_fd_sc_hd__buf_16
Xinput5 wr_data[0] VSS VSS VDD VDD net5 sky130_fd_sc_hd__buf_4
Xinput6 wr_data[10] VSS VSS VDD VDD net6 sky130_fd_sc_hd__buf_4
Xinput7 wr_data[11] VSS VSS VDD VDD net7 sky130_fd_sc_hd__buf_4
Xinput8 wr_data[12] VSS VSS VDD VDD net8 sky130_fd_sc_hd__buf_4
Xinput9 wr_data[13] VSS VSS VDD VDD net9 sky130_fd_sc_hd__buf_4
Xinput10 wr_data[14] VSS VSS VDD VDD net10 sky130_fd_sc_hd__buf_6
Xinput11 wr_data[15] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_4
Xinput12 wr_data[16] VSS VSS VDD VDD net12 sky130_fd_sc_hd__buf_4
Xinput13 wr_data[17] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_4
Xinput14 wr_data[18] VSS VSS VDD VDD net14 sky130_fd_sc_hd__buf_4
Xinput15 wr_data[19] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_4
Xinput16 wr_data[1] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_4
Xinput17 wr_data[20] VSS VSS VDD VDD net17 sky130_fd_sc_hd__buf_6
Xinput18 wr_data[21] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_4
Xinput19 wr_data[22] VSS VSS VDD VDD net19 sky130_fd_sc_hd__buf_4
Xinput20 wr_data[23] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_4
Xinput21 wr_data[24] VSS VSS VDD VDD net21 sky130_fd_sc_hd__buf_4
Xinput22 wr_data[25] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_4
Xinput23 wr_data[26] VSS VSS VDD VDD net23 sky130_fd_sc_hd__buf_4
Xinput24 wr_data[27] VSS VSS VDD VDD net24 sky130_fd_sc_hd__buf_4
Xinput25 wr_data[28] VSS VSS VDD VDD net25 sky130_fd_sc_hd__buf_4
Xinput26 wr_data[29] VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_4
Xinput27 wr_data[2] VSS VSS VDD VDD net27 sky130_fd_sc_hd__buf_4
Xinput28 wr_data[30] VSS VSS VDD VDD net28 sky130_fd_sc_hd__buf_4
Xinput29 wr_data[31] VSS VSS VDD VDD net29 sky130_fd_sc_hd__buf_4
Xinput30 wr_data[3] VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_4
Xinput31 wr_data[4] VSS VSS VDD VDD net31 sky130_fd_sc_hd__buf_4
Xinput32 wr_data[5] VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_4
Xinput33 wr_data[6] VSS VSS VDD VDD net33 sky130_fd_sc_hd__buf_4
Xinput34 wr_data[7] VSS VSS VDD VDD net34 sky130_fd_sc_hd__buf_4
Xinput35 wr_data[8] VSS VSS VDD VDD net35 sky130_fd_sc_hd__buf_4
Xinput36 wr_data[9] VSS VSS VDD VDD net36 sky130_fd_sc_hd__buf_4
Xinput37 wr_en VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_1
Xinput38 wr_rst_n VSS VSS VDD VDD net38 sky130_fd_sc_hd__buf_12
Xoutput39 net39 VSS VSS VDD VDD rd_almost_empty sky130_fd_sc_hd__clkbuf_1
Xoutput40 net40 VSS VSS VDD VDD rd_count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput41 net41 VSS VSS VDD VDD rd_count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput42 net42 VSS VSS VDD VDD rd_count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput43 net43 VSS VSS VDD VDD rd_count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput44 net44 VSS VSS VDD VDD rd_count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput45 net45 VSS VSS VDD VDD rd_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput46 net46 VSS VSS VDD VDD rd_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput47 net47 VSS VSS VDD VDD rd_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput48 net48 VSS VSS VDD VDD rd_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput49 net49 VSS VSS VDD VDD rd_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput50 net50 VSS VSS VDD VDD rd_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput51 net51 VSS VSS VDD VDD rd_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput52 net52 VSS VSS VDD VDD rd_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput53 net53 VSS VSS VDD VDD rd_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput54 net54 VSS VSS VDD VDD rd_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput55 net55 VSS VSS VDD VDD rd_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput56 net56 VSS VSS VDD VDD rd_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput57 net57 VSS VSS VDD VDD rd_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput58 net58 VSS VSS VDD VDD rd_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput59 net59 VSS VSS VDD VDD rd_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput60 net60 VSS VSS VDD VDD rd_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput61 net61 VSS VSS VDD VDD rd_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput62 net62 VSS VSS VDD VDD rd_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput63 net63 VSS VSS VDD VDD rd_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput64 net64 VSS VSS VDD VDD rd_data[27] sky130_fd_sc_hd__clkbuf_1
Xoutput65 net65 VSS VSS VDD VDD rd_data[28] sky130_fd_sc_hd__clkbuf_1
Xoutput66 net66 VSS VSS VDD VDD rd_data[29] sky130_fd_sc_hd__clkbuf_1
Xoutput67 net67 VSS VSS VDD VDD rd_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput68 net68 VSS VSS VDD VDD rd_data[30] sky130_fd_sc_hd__clkbuf_1
Xoutput69 net69 VSS VSS VDD VDD rd_data[31] sky130_fd_sc_hd__clkbuf_1
Xoutput70 net70 VSS VSS VDD VDD rd_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput71 net71 VSS VSS VDD VDD rd_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput72 net72 VSS VSS VDD VDD rd_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput73 net73 VSS VSS VDD VDD rd_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput74 net74 VSS VSS VDD VDD rd_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput75 net75 VSS VSS VDD VDD rd_data[8] sky130_fd_sc_hd__clkbuf_1
Xoutput76 net76 VSS VSS VDD VDD rd_data[9] sky130_fd_sc_hd__clkbuf_1
Xoutput77 net77 VSS VSS VDD VDD rd_empty sky130_fd_sc_hd__clkbuf_1
Xoutput78 net78 VSS VSS VDD VDD wr_almost_full sky130_fd_sc_hd__clkbuf_1
Xoutput79 net79 VSS VSS VDD VDD wr_count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net80 VSS VSS VDD VDD wr_count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput81 net81 VSS VSS VDD VDD wr_count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput82 net82 VSS VSS VDD VDD wr_count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput83 net83 VSS VSS VDD VDD wr_count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput84 net84 VSS VSS VDD VDD wr_full sky130_fd_sc_hd__clkbuf_1
Xload_slew85 net86 VSS VSS VDD VDD net85 sky130_fd_sc_hd__buf_16
Xload_slew86 net4 VSS VSS VDD VDD net86 sky130_fd_sc_hd__buf_16
Xload_slew87 net4 VSS VSS VDD VDD net87 sky130_fd_sc_hd__buf_16
XANTENNA_1 net10 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS clock_domain_crossing_fifo
