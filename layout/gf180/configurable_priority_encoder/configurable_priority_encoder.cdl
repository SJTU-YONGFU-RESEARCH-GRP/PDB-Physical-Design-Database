* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT configurable_priority_encoder grant_index[0] grant_index[1]
+ grant_index[2] request[0] request[1] request[2] request[3]
+ request[4] request[5] request[6] request[7] valid
X_12_ net2 _00_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13_ net7 _01_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14_ _01_ net8 net6 _02_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15_ net1 net5 net3 _03_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16_ net1 _04_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17_ _04_ net4 _05_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18_ net1 _00_ _02_ _03_ _05_ net3 net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_19_ net4 net3 _06_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20_ net7 net8 _07_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21_ net6 net5 _07_ _08_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_22_ _06_ _08_ net1 net2 net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_23_ net6 net5 _09_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_24_ _07_ _09_ _10_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_25_ _04_ _00_ _06_ _11_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_26_ _10_ _11_ net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_27_ _07_ _09_ _11_ net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 request[0] net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput2 request[1] net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput3 request[2] net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xinput4 request[3] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput5 request[4] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput6 request[5] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput7 request[6] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput8 request[7] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput9 net9 grant_index[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput10 net10 grant_index[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput11 net11 grant_index[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput12 net12 valid VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS configurable_priority_encoder
