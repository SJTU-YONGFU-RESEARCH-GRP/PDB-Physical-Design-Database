* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT dynamic_node_top_wrap clk dataIn_E[0] dataIn_E[10]
+ dataIn_E[11] dataIn_E[12] dataIn_E[13] dataIn_E[14] dataIn_E[15]
+ dataIn_E[16] dataIn_E[17] dataIn_E[18] dataIn_E[19] dataIn_E[1]
+ dataIn_E[20] dataIn_E[21] dataIn_E[22] dataIn_E[23] dataIn_E[24]
+ dataIn_E[25] dataIn_E[26] dataIn_E[27] dataIn_E[28] dataIn_E[29]
+ dataIn_E[2] dataIn_E[30] dataIn_E[31] dataIn_E[32] dataIn_E[33]
+ dataIn_E[34] dataIn_E[35] dataIn_E[36] dataIn_E[37] dataIn_E[38]
+ dataIn_E[39] dataIn_E[3] dataIn_E[40] dataIn_E[41] dataIn_E[42]
+ dataIn_E[43] dataIn_E[44] dataIn_E[45] dataIn_E[46] dataIn_E[47]
+ dataIn_E[48] dataIn_E[49] dataIn_E[4] dataIn_E[50] dataIn_E[51]
+ dataIn_E[52] dataIn_E[53] dataIn_E[54] dataIn_E[55] dataIn_E[56]
+ dataIn_E[57] dataIn_E[58] dataIn_E[59] dataIn_E[5] dataIn_E[60]
+ dataIn_E[61] dataIn_E[62] dataIn_E[63] dataIn_E[6] dataIn_E[7]
+ dataIn_E[8] dataIn_E[9] dataIn_N[0] dataIn_N[10] dataIn_N[11]
+ dataIn_N[12] dataIn_N[13] dataIn_N[14] dataIn_N[15] dataIn_N[16]
+ dataIn_N[17] dataIn_N[18] dataIn_N[19] dataIn_N[1] dataIn_N[20]
+ dataIn_N[21] dataIn_N[22] dataIn_N[23] dataIn_N[24] dataIn_N[25]
+ dataIn_N[26] dataIn_N[27] dataIn_N[28] dataIn_N[29] dataIn_N[2]
+ dataIn_N[30] dataIn_N[31] dataIn_N[32] dataIn_N[33] dataIn_N[34]
+ dataIn_N[35] dataIn_N[36] dataIn_N[37] dataIn_N[38] dataIn_N[39]
+ dataIn_N[3] dataIn_N[40] dataIn_N[41] dataIn_N[42] dataIn_N[43]
+ dataIn_N[44] dataIn_N[45] dataIn_N[46] dataIn_N[47] dataIn_N[48]
+ dataIn_N[49] dataIn_N[4] dataIn_N[50] dataIn_N[51] dataIn_N[52]
+ dataIn_N[53] dataIn_N[54] dataIn_N[55] dataIn_N[56] dataIn_N[57]
+ dataIn_N[58] dataIn_N[59] dataIn_N[5] dataIn_N[60] dataIn_N[61]
+ dataIn_N[62] dataIn_N[63] dataIn_N[6] dataIn_N[7] dataIn_N[8]
+ dataIn_N[9] dataIn_P[0] dataIn_P[10] dataIn_P[11] dataIn_P[12]
+ dataIn_P[13] dataIn_P[14] dataIn_P[15] dataIn_P[16] dataIn_P[17]
+ dataIn_P[18] dataIn_P[19] dataIn_P[1] dataIn_P[20] dataIn_P[21]
+ dataIn_P[22] dataIn_P[23] dataIn_P[24] dataIn_P[25] dataIn_P[26]
+ dataIn_P[27] dataIn_P[28] dataIn_P[29] dataIn_P[2] dataIn_P[30]
+ dataIn_P[31] dataIn_P[32] dataIn_P[33] dataIn_P[34] dataIn_P[35]
+ dataIn_P[36] dataIn_P[37] dataIn_P[38] dataIn_P[39] dataIn_P[3]
+ dataIn_P[40] dataIn_P[41] dataIn_P[42] dataIn_P[43] dataIn_P[44]
+ dataIn_P[45] dataIn_P[46] dataIn_P[47] dataIn_P[48] dataIn_P[49]
+ dataIn_P[4] dataIn_P[50] dataIn_P[51] dataIn_P[52] dataIn_P[53]
+ dataIn_P[54] dataIn_P[55] dataIn_P[56] dataIn_P[57] dataIn_P[58]
+ dataIn_P[59] dataIn_P[5] dataIn_P[60] dataIn_P[61] dataIn_P[62]
+ dataIn_P[63] dataIn_P[6] dataIn_P[7] dataIn_P[8] dataIn_P[9]
+ dataIn_S[0] dataIn_S[10] dataIn_S[11] dataIn_S[12] dataIn_S[13]
+ dataIn_S[14] dataIn_S[15] dataIn_S[16] dataIn_S[17] dataIn_S[18]
+ dataIn_S[19] dataIn_S[1] dataIn_S[20] dataIn_S[21] dataIn_S[22]
+ dataIn_S[23] dataIn_S[24] dataIn_S[25] dataIn_S[26] dataIn_S[27]
+ dataIn_S[28] dataIn_S[29] dataIn_S[2] dataIn_S[30] dataIn_S[31]
+ dataIn_S[32] dataIn_S[33] dataIn_S[34] dataIn_S[35] dataIn_S[36]
+ dataIn_S[37] dataIn_S[38] dataIn_S[39] dataIn_S[3] dataIn_S[40]
+ dataIn_S[41] dataIn_S[42] dataIn_S[43] dataIn_S[44] dataIn_S[45]
+ dataIn_S[46] dataIn_S[47] dataIn_S[48] dataIn_S[49] dataIn_S[4]
+ dataIn_S[50] dataIn_S[51] dataIn_S[52] dataIn_S[53] dataIn_S[54]
+ dataIn_S[55] dataIn_S[56] dataIn_S[57] dataIn_S[58] dataIn_S[59]
+ dataIn_S[5] dataIn_S[60] dataIn_S[61] dataIn_S[62] dataIn_S[63]
+ dataIn_S[6] dataIn_S[7] dataIn_S[8] dataIn_S[9] dataIn_W[0]
+ dataIn_W[10] dataIn_W[11] dataIn_W[12] dataIn_W[13] dataIn_W[14]
+ dataIn_W[15] dataIn_W[16] dataIn_W[17] dataIn_W[18] dataIn_W[19]
+ dataIn_W[1] dataIn_W[20] dataIn_W[21] dataIn_W[22] dataIn_W[23]
+ dataIn_W[24] dataIn_W[25] dataIn_W[26] dataIn_W[27] dataIn_W[28]
+ dataIn_W[29] dataIn_W[2] dataIn_W[30] dataIn_W[31] dataIn_W[32]
+ dataIn_W[33] dataIn_W[34] dataIn_W[35] dataIn_W[36] dataIn_W[37]
+ dataIn_W[38] dataIn_W[39] dataIn_W[3] dataIn_W[40] dataIn_W[41]
+ dataIn_W[42] dataIn_W[43] dataIn_W[44] dataIn_W[45] dataIn_W[46]
+ dataIn_W[47] dataIn_W[48] dataIn_W[49] dataIn_W[4] dataIn_W[50]
+ dataIn_W[51] dataIn_W[52] dataIn_W[53] dataIn_W[54] dataIn_W[55]
+ dataIn_W[56] dataIn_W[57] dataIn_W[58] dataIn_W[59] dataIn_W[5]
+ dataIn_W[60] dataIn_W[61] dataIn_W[62] dataIn_W[63] dataIn_W[6]
+ dataIn_W[7] dataIn_W[8] dataIn_W[9] dataOut_E[0] dataOut_E[10]
+ dataOut_E[11] dataOut_E[12] dataOut_E[13] dataOut_E[14] dataOut_E[15]
+ dataOut_E[16] dataOut_E[17] dataOut_E[18] dataOut_E[19] dataOut_E[1]
+ dataOut_E[20] dataOut_E[21] dataOut_E[22] dataOut_E[23] dataOut_E[24]
+ dataOut_E[25] dataOut_E[26] dataOut_E[27] dataOut_E[28] dataOut_E[29]
+ dataOut_E[2] dataOut_E[30] dataOut_E[31] dataOut_E[32] dataOut_E[33]
+ dataOut_E[34] dataOut_E[35] dataOut_E[36] dataOut_E[37] dataOut_E[38]
+ dataOut_E[39] dataOut_E[3] dataOut_E[40] dataOut_E[41] dataOut_E[42]
+ dataOut_E[43] dataOut_E[44] dataOut_E[45] dataOut_E[46] dataOut_E[47]
+ dataOut_E[48] dataOut_E[49] dataOut_E[4] dataOut_E[50] dataOut_E[51]
+ dataOut_E[52] dataOut_E[53] dataOut_E[54] dataOut_E[55] dataOut_E[56]
+ dataOut_E[57] dataOut_E[58] dataOut_E[59] dataOut_E[5] dataOut_E[60]
+ dataOut_E[61] dataOut_E[62] dataOut_E[63] dataOut_E[6] dataOut_E[7]
+ dataOut_E[8] dataOut_E[9] dataOut_N[0] dataOut_N[10] dataOut_N[11]
+ dataOut_N[12] dataOut_N[13] dataOut_N[14] dataOut_N[15] dataOut_N[16]
+ dataOut_N[17] dataOut_N[18] dataOut_N[19] dataOut_N[1] dataOut_N[20]
+ dataOut_N[21] dataOut_N[22] dataOut_N[23] dataOut_N[24] dataOut_N[25]
+ dataOut_N[26] dataOut_N[27] dataOut_N[28] dataOut_N[29] dataOut_N[2]
+ dataOut_N[30] dataOut_N[31] dataOut_N[32] dataOut_N[33] dataOut_N[34]
+ dataOut_N[35] dataOut_N[36] dataOut_N[37] dataOut_N[38] dataOut_N[39]
+ dataOut_N[3] dataOut_N[40] dataOut_N[41] dataOut_N[42] dataOut_N[43]
+ dataOut_N[44] dataOut_N[45] dataOut_N[46] dataOut_N[47] dataOut_N[48]
+ dataOut_N[49] dataOut_N[4] dataOut_N[50] dataOut_N[51] dataOut_N[52]
+ dataOut_N[53] dataOut_N[54] dataOut_N[55] dataOut_N[56] dataOut_N[57]
+ dataOut_N[58] dataOut_N[59] dataOut_N[5] dataOut_N[60] dataOut_N[61]
+ dataOut_N[62] dataOut_N[63] dataOut_N[6] dataOut_N[7] dataOut_N[8]
+ dataOut_N[9] dataOut_P[0] dataOut_P[10] dataOut_P[11] dataOut_P[12]
+ dataOut_P[13] dataOut_P[14] dataOut_P[15] dataOut_P[16] dataOut_P[17]
+ dataOut_P[18] dataOut_P[19] dataOut_P[1] dataOut_P[20] dataOut_P[21]
+ dataOut_P[22] dataOut_P[23] dataOut_P[24] dataOut_P[25] dataOut_P[26]
+ dataOut_P[27] dataOut_P[28] dataOut_P[29] dataOut_P[2] dataOut_P[30]
+ dataOut_P[31] dataOut_P[32] dataOut_P[33] dataOut_P[34] dataOut_P[35]
+ dataOut_P[36] dataOut_P[37] dataOut_P[38] dataOut_P[39] dataOut_P[3]
+ dataOut_P[40] dataOut_P[41] dataOut_P[42] dataOut_P[43] dataOut_P[44]
+ dataOut_P[45] dataOut_P[46] dataOut_P[47] dataOut_P[48] dataOut_P[49]
+ dataOut_P[4] dataOut_P[50] dataOut_P[51] dataOut_P[52] dataOut_P[53]
+ dataOut_P[54] dataOut_P[55] dataOut_P[56] dataOut_P[57] dataOut_P[58]
+ dataOut_P[59] dataOut_P[5] dataOut_P[60] dataOut_P[61] dataOut_P[62]
+ dataOut_P[63] dataOut_P[6] dataOut_P[7] dataOut_P[8] dataOut_P[9]
+ dataOut_S[0] dataOut_S[10] dataOut_S[11] dataOut_S[12] dataOut_S[13]
+ dataOut_S[14] dataOut_S[15] dataOut_S[16] dataOut_S[17] dataOut_S[18]
+ dataOut_S[19] dataOut_S[1] dataOut_S[20] dataOut_S[21] dataOut_S[22]
+ dataOut_S[23] dataOut_S[24] dataOut_S[25] dataOut_S[26] dataOut_S[27]
+ dataOut_S[28] dataOut_S[29] dataOut_S[2] dataOut_S[30] dataOut_S[31]
+ dataOut_S[32] dataOut_S[33] dataOut_S[34] dataOut_S[35] dataOut_S[36]
+ dataOut_S[37] dataOut_S[38] dataOut_S[39] dataOut_S[3] dataOut_S[40]
+ dataOut_S[41] dataOut_S[42] dataOut_S[43] dataOut_S[44] dataOut_S[45]
+ dataOut_S[46] dataOut_S[47] dataOut_S[48] dataOut_S[49] dataOut_S[4]
+ dataOut_S[50] dataOut_S[51] dataOut_S[52] dataOut_S[53] dataOut_S[54]
+ dataOut_S[55] dataOut_S[56] dataOut_S[57] dataOut_S[58] dataOut_S[59]
+ dataOut_S[5] dataOut_S[60] dataOut_S[61] dataOut_S[62] dataOut_S[63]
+ dataOut_S[6] dataOut_S[7] dataOut_S[8] dataOut_S[9] dataOut_W[0]
+ dataOut_W[10] dataOut_W[11] dataOut_W[12] dataOut_W[13] dataOut_W[14]
+ dataOut_W[15] dataOut_W[16] dataOut_W[17] dataOut_W[18] dataOut_W[19]
+ dataOut_W[1] dataOut_W[20] dataOut_W[21] dataOut_W[22] dataOut_W[23]
+ dataOut_W[24] dataOut_W[25] dataOut_W[26] dataOut_W[27] dataOut_W[28]
+ dataOut_W[29] dataOut_W[2] dataOut_W[30] dataOut_W[31] dataOut_W[32]
+ dataOut_W[33] dataOut_W[34] dataOut_W[35] dataOut_W[36] dataOut_W[37]
+ dataOut_W[38] dataOut_W[39] dataOut_W[3] dataOut_W[40] dataOut_W[41]
+ dataOut_W[42] dataOut_W[43] dataOut_W[44] dataOut_W[45] dataOut_W[46]
+ dataOut_W[47] dataOut_W[48] dataOut_W[49] dataOut_W[4] dataOut_W[50]
+ dataOut_W[51] dataOut_W[52] dataOut_W[53] dataOut_W[54] dataOut_W[55]
+ dataOut_W[56] dataOut_W[57] dataOut_W[58] dataOut_W[59] dataOut_W[5]
+ dataOut_W[60] dataOut_W[61] dataOut_W[62] dataOut_W[63] dataOut_W[6]
+ dataOut_W[7] dataOut_W[8] dataOut_W[9] myChipID[0] myChipID[10]
+ myChipID[11] myChipID[12] myChipID[13] myChipID[1] myChipID[2]
+ myChipID[3] myChipID[4] myChipID[5] myChipID[6] myChipID[7]
+ myChipID[8] myChipID[9] myLocX[0] myLocX[1] myLocX[2] myLocX[3]
+ myLocX[4] myLocX[5] myLocX[6] myLocX[7] myLocY[0] myLocY[1]
+ myLocY[2] myLocY[3] myLocY[4] myLocY[5] myLocY[6] myLocY[7]
+ reset_in thanksIn_P validIn_E validIn_N validIn_P validIn_S
+ validIn_W validOut_E validOut_N validOut_P validOut_S validOut_W
+ yummyIn_E yummyIn_N yummyIn_P yummyIn_S yummyIn_W yummyOut_E
+ yummyOut_N yummyOut_P yummyOut_S yummyOut_W
X_10617_ _00013_ _05124_ VDD VSS BUF_X8
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
X_10619_ _05124_ _05126_ VDD VSS BUF_X4
X_10620_ _05126_ _05127_ VDD VSS BUF_X8
X_10621_ _00014_ _05128_ VDD VSS BUF_X8
X_10622_ _05128_ _05129_ VDD VSS BUF_X16
X_10623_ _05129_ _05130_ VDD VSS BUF_X32
Xclone2 net658 net2 VDD VSS BUF_X2
X_10625_ _05130_ _05132_ VDD VSS BUF_X32
X_10626_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[42\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[42\]
+ _05132_ _05133_ VDD VSS MUX2_X1
X_10627_ _05133_ _05134_ VDD VSS INV_X1
X_10628_ _05127_ _05134_ _05135_ VDD VSS NAND2_X1
X_10629_ _05130_ _05136_ VDD VSS BUF_X32
X_10630_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[42\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[42\]
+ net745 _05137_ VDD VSS MUX2_X1
X_10631_ _05135_ _05137_ _05127_ _05138_ VDD VSS OAI21_X4
X_10632_ _05138_ _10179_ VDD VSS INV_X1
X_10633_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[34\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[34\]
+ net745 _05139_ VDD VSS MUX2_X1
X_10634_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[34\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[34\]
+ net745 _05140_ VDD VSS MUX2_X1
X_10635_ _05139_ _05140_ _05126_ _10225_ VDD VSS MUX2_X2
X_10636_ _00016_ _05141_ VDD VSS BUF_X8
X_10637_ _05141_ _05142_ VDD VSS BUF_X16
X_10638_ _05142_ _05143_ VDD VSS BUF_X32
X_10639_ _05143_ _05144_ VDD VSS BUF_X32
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
X_10641_ _05144_ _05146_ VDD VSS BUF_X32
X_10642_ _05146_ _05147_ VDD VSS BUF_X32
X_10643_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[42\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[42\]
+ _05147_ _05148_ VDD VSS MUX2_X1
X_10644_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[42\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[42\]
+ _05147_ _05149_ VDD VSS MUX2_X1
X_10645_ _00015_ _05150_ VDD VSS CLKBUF_X3
X_10646_ _05150_ _05151_ VDD VSS BUF_X4
X_10647_ _05151_ _05152_ VDD VSS CLKBUF_X3
X_10648_ _05152_ _05153_ VDD VSS BUF_X4
X_10649_ _05148_ _05149_ _05153_ _10249_ VDD VSS MUX2_X2
X_10650_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[34\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[34\]
+ net739 _05154_ VDD VSS MUX2_X1
X_10651_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[34\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[34\]
+ net739 _05155_ VDD VSS MUX2_X1
X_10652_ _05154_ _05155_ _05152_ _10252_ VDD VSS MUX2_X2
X_10653_ _00045_ _05156_ VDD VSS BUF_X4
X_10654_ _05156_ _05157_ VDD VSS INV_X2
X_10655_ dynamic_node_top.east_output.control.current_route_f\[3\]
+ _05158_ VDD VSS CLKBUF_X3
X_10656_ dynamic_node_top.east_output.control.current_route_f\[1\]
+ _05159_ VDD VSS CLKBUF_X3
X_10657_ dynamic_node_top.east_output.control.current_route_f\[4\]
+ dynamic_node_top.east_output.control.current_route_f\[2\]
+ _05158_ _05159_ _05160_ VDD VSS NOR4_X4
X_10658_ _05160_ _05161_ VDD VSS INV_X1
X_10659_ _05157_ _05161_ _05162_ VDD VSS NOR2_X1
X_10660_ _05162_ _05163_ VDD VSS BUF_X8
X_10661_ dynamic_node_top.east_output.space.is_one_f _05164_
+ VDD VSS INV_X1
X_10662_ _05164_ dynamic_node_top.east_output.space.valid_f
+ _05165_ VDD VSS NOR2_X1
X_10663_ dynamic_node_top.east_output.space.is_two_or_more_f
+ dynamic_node_top.east_output.space.yummy_f _05165_ _05166_
+ VDD VSS NOR3_X2
X_10664_ dynamic_node_top.east_output.control.current_route_f\[2\]
+ _05167_ VDD VSS CLKBUF_X3
X_10665_ dynamic_node_top.north_input.NIB.elements_in_array_f\[1\]
+ dynamic_node_top.north_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.north_input.NIB.elements_in_array_f\[2\]
+ _05168_ VDD VSS OR3_X4
X_10666_ dynamic_node_top.south_input.NIB.elements_in_array_f\[1\]
+ dynamic_node_top.south_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.south_input.NIB.elements_in_array_f\[2\]
+ _05169_ VDD VSS OR3_X1
X_10667_ _05169_ _05170_ VDD VSS CLKBUF_X3
X_10668_ dynamic_node_top.east_output.control.current_route_f\[4\]
+ _05171_ VDD VSS CLKBUF_X3
X_10669_ _05167_ _05168_ _05170_ _05171_ _05172_ VDD VSS AOI22_X1
X_10670_ dynamic_node_top.east_output.control.current_route_f\[0\]
+ _05173_ VDD VSS BUF_X2
X_10671_ dynamic_node_top.west_input.NIB.elements_in_array_f\[1\]
+ dynamic_node_top.west_input.NIB.elements_in_array_f\[0\] dynamic_node_top.west_input.NIB.elements_in_array_f\[2\]
+ _05174_ VDD VSS OR3_X1
X_10672_ _05174_ _05175_ VDD VSS CLKBUF_X3
X_10673_ dynamic_node_top.east_input.NIB.elements_in_array_f\[1\]
+ dynamic_node_top.east_input.NIB.elements_in_array_f\[0\] dynamic_node_top.east_input.NIB.elements_in_array_f\[2\]
+ _05176_ VDD VSS OR3_X1
X_10674_ _05176_ _05177_ VDD VSS BUF_X4
X_10675_ _00044_ _05178_ VDD VSS INV_X1
X_10676_ _05173_ _05175_ _05177_ _05178_ _05179_ VDD VSS AOI22_X1
X_10677_ _05172_ _05179_ _05180_ VDD VSS NAND2_X1
X_10678_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.proc_input.NIB.elements_in_array_f\[3\] dynamic_node_top.proc_input.NIB.elements_in_array_f\[2\]
+ dynamic_node_top.proc_input.NIB.elements_in_array_f\[4\] _05181_
+ VDD VSS OR4_X2
X_10679_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[1\]
+ _05181_ _05182_ VDD VSS OR2_X4
X_10680_ _05180_ _05182_ _05158_ _05183_ VDD VSS AOI21_X2
X_10681_ _05163_ _05166_ _05183_ _05184_ VDD VSS NOR3_X4
X_10682_ dynamic_node_top.west_input.control.header_last_temp
+ _05175_ _05185_ VDD VSS NAND2_X4
X_10683_ dynamic_node_top.east_input.control.my_chip_id_in\[1\]
+ _05186_ VDD VSS BUF_X4
X_10684_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[51\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[51\]
+ _05142_ _05187_ VDD VSS MUX2_X1
X_10685_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[51\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[51\]
+ _05142_ _05188_ VDD VSS MUX2_X1
X_10686_ _05187_ _05188_ _05150_ _05189_ VDD VSS MUX2_X2
X_10687_ _05186_ _05189_ _05190_ VDD VSS XNOR2_X1
X_10688_ dynamic_node_top.east_input.control.my_chip_id_in\[10\]
+ _05191_ VDD VSS BUF_X4
X_10689_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[60\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[60\]
+ _05142_ _05192_ VDD VSS MUX2_X1
X_10690_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[60\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[60\]
+ _05142_ _05193_ VDD VSS MUX2_X1
X_10691_ _05192_ _05193_ _05150_ _05194_ VDD VSS MUX2_X2
X_10692_ _05191_ _05194_ _05195_ VDD VSS XNOR2_X1
X_10693_ _05190_ _05195_ _05196_ VDD VSS NAND2_X2
X_10694_ dynamic_node_top.east_input.control.my_chip_id_in\[12\]
+ _05197_ VDD VSS BUF_X4
X_10695_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[62\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[62\]
+ net736 _05198_ VDD VSS MUX2_X1
X_10696_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[62\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[62\]
+ net736 _05199_ VDD VSS MUX2_X1
X_10697_ _05150_ _05200_ VDD VSS INV_X2
X_10698_ _05200_ _05201_ VDD VSS BUF_X4
X_10699_ _05198_ _05199_ _05201_ _05202_ VDD VSS MUX2_X1
X_10700_ _05197_ _05202_ _05203_ VDD VSS XNOR2_X2
X_10701_ dynamic_node_top.east_input.control.my_chip_id_in\[6\]
+ _05204_ VDD VSS BUF_X4
X_10702_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[56\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[56\]
+ net736 _05205_ VDD VSS MUX2_X1
X_10703_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[56\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[56\]
+ net736 _05206_ VDD VSS MUX2_X1
X_10704_ _05205_ _05206_ _05201_ _05207_ VDD VSS MUX2_X1
X_10705_ _05204_ _05207_ _05208_ VDD VSS XNOR2_X2
X_10706_ dynamic_node_top.east_input.control.my_chip_id_in\[5\]
+ _05209_ VDD VSS BUF_X4
X_10707_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[55\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[55\]
+ net736 _05210_ VDD VSS MUX2_X1
X_10708_ net672 _05211_ VDD VSS CLKBUF_X3
X_10709_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[55\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[55\]
+ _05211_ _05212_ VDD VSS MUX2_X1
X_10710_ _05210_ _05212_ _05201_ _05213_ VDD VSS MUX2_X1
X_10711_ _05209_ _05213_ _05214_ VDD VSS XNOR2_X2
X_10712_ dynamic_node_top.east_input.control.my_chip_id_in\[8\]
+ _05215_ VDD VSS BUF_X4
X_10713_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[58\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[58\]
+ _05211_ _05216_ VDD VSS MUX2_X1
X_10714_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[58\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[58\]
+ _05211_ _05217_ VDD VSS MUX2_X1
X_10715_ _05216_ _05217_ _05201_ _05218_ VDD VSS MUX2_X1
X_10716_ _05215_ _05218_ _05219_ VDD VSS XNOR2_X2
X_10717_ _05203_ _05208_ _05214_ _05219_ _05220_ VDD VSS NAND4_X4
X_10718_ dynamic_node_top.east_input.control.my_chip_id_in\[13\]
+ _05221_ VDD VSS BUF_X4
X_10719_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[63\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[63\]
+ _05211_ _05222_ VDD VSS MUX2_X1
X_10720_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[63\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[63\]
+ _05211_ _05223_ VDD VSS MUX2_X1
X_10721_ _05222_ _05223_ _05201_ _05224_ VDD VSS MUX2_X1
X_10722_ _05221_ _05224_ _05225_ VDD VSS XNOR2_X1
X_10723_ dynamic_node_top.east_input.control.my_chip_id_in\[9\]
+ _05226_ VDD VSS BUF_X4
X_10724_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[59\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[59\]
+ _05211_ _05227_ VDD VSS MUX2_X1
X_10725_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[59\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[59\]
+ _05211_ _05228_ VDD VSS MUX2_X1
X_10726_ _05227_ _05228_ _05201_ _05229_ VDD VSS MUX2_X1
X_10727_ _05226_ _05229_ _05230_ VDD VSS XNOR2_X1
X_10728_ dynamic_node_top.east_input.control.my_chip_id_in\[7\]
+ _05231_ VDD VSS BUF_X4
X_10729_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[57\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[57\]
+ _05211_ _05232_ VDD VSS MUX2_X1
X_10730_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[57\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[57\]
+ _05141_ _05233_ VDD VSS MUX2_X1
X_10731_ _05232_ _05233_ _05200_ _05234_ VDD VSS MUX2_X1
X_10732_ _05231_ _05234_ _05235_ VDD VSS XNOR2_X1
X_10733_ dynamic_node_top.east_input.control.my_chip_id_in\[11\]
+ _05236_ VDD VSS BUF_X4
X_10734_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[61\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[61\]
+ net735 _05237_ VDD VSS MUX2_X1
X_10735_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[61\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[61\]
+ net735 _05238_ VDD VSS MUX2_X1
X_10736_ _05237_ _05238_ _05200_ _05239_ VDD VSS MUX2_X1
X_10737_ _05236_ _05239_ _05240_ VDD VSS XNOR2_X1
X_10738_ _05225_ _05230_ _05235_ _05240_ _05241_ VDD VSS NAND4_X2
X_10739_ dynamic_node_top.east_input.control.my_chip_id_in\[3\]
+ _05242_ VDD VSS BUF_X4
X_10740_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[53\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[53\]
+ _05211_ _05243_ VDD VSS MUX2_X1
X_10741_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[53\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[53\]
+ _05211_ _05244_ VDD VSS MUX2_X1
X_10742_ _05243_ _05244_ _05201_ _05245_ VDD VSS MUX2_X1
X_10743_ _05242_ _05245_ _05246_ VDD VSS XNOR2_X1
X_10744_ dynamic_node_top.east_input.control.my_chip_id_in\[0\]
+ _05247_ VDD VSS BUF_X4
X_10745_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[50\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[50\]
+ net735 _05248_ VDD VSS MUX2_X1
X_10746_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[50\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[50\]
+ net735 _05249_ VDD VSS MUX2_X1
X_10747_ _05248_ _05249_ _05200_ _05250_ VDD VSS MUX2_X1
X_10748_ _05247_ _05250_ _05251_ VDD VSS XNOR2_X1
X_10749_ dynamic_node_top.east_input.control.my_chip_id_in\[4\]
+ _05252_ VDD VSS BUF_X4
X_10750_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[54\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[54\]
+ _05141_ _05253_ VDD VSS MUX2_X1
X_10751_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[54\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[54\]
+ net735 _05254_ VDD VSS MUX2_X1
X_10752_ _05253_ _05254_ _05200_ _05255_ VDD VSS MUX2_X1
X_10753_ _05252_ _05255_ _05256_ VDD VSS XNOR2_X1
X_10754_ dynamic_node_top.east_input.control.my_chip_id_in\[2\]
+ _05257_ VDD VSS BUF_X4
X_10755_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[52\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[52\]
+ _05141_ _05258_ VDD VSS MUX2_X1
X_10756_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[52\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[52\]
+ _05141_ _05259_ VDD VSS MUX2_X1
X_10757_ _05258_ _05259_ _05200_ _05260_ VDD VSS MUX2_X1
X_10758_ _05257_ _05260_ _05261_ VDD VSS XNOR2_X1
X_10759_ _05246_ _05251_ _05256_ _05261_ _05262_ VDD VSS NAND4_X2
X_10760_ _05196_ _05220_ _05241_ _05262_ _05263_ VDD VSS NOR4_X4
X_10761_ _10230_ _10233_ _10236_ _10239_ _05264_ VDD VSS NAND4_X4
X_10762_ _10242_ _10245_ _10248_ _10251_ _05265_ VDD VSS NAND4_X1
X_10763_ net734 _05265_ _05266_ VDD VSS NOR2_X4
X_10764_ _10275_ _10272_ _10254_ _10257_ _05267_ VDD VSS AND4_X2
X_10765_ _10269_ _10266_ _05268_ VDD VSS AND2_X2
X_10766_ _10260_ _10263_ _05267_ _05268_ _05269_ VDD VSS AND4_X4
X_10767_ _05266_ _05269_ _05270_ VDD VSS NAND2_X4
X_10768_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[30\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[30\]
+ net739 _05271_ VDD VSS MUX2_X1
X_10769_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[30\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[30\]
+ net739 _05272_ VDD VSS MUX2_X1
X_10770_ _05271_ _05272_ _05151_ _05273_ VDD VSS MUX2_X2
X_10771_ _05273_ _05274_ VDD VSS INV_X2
X_10772_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[32\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[32\]
+ net738 _05275_ VDD VSS MUX2_X1
X_10773_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[32\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[32\]
+ net738 _05276_ VDD VSS MUX2_X1
X_10774_ _05275_ _05276_ _05152_ _05277_ VDD VSS MUX2_X2
X_10775_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[31\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[31\]
+ net739 _05278_ VDD VSS MUX2_X1
X_10776_ _05152_ _05278_ _05279_ VDD VSS OR2_X1
X_10777_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[31\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[31\]
+ net738 _05280_ VDD VSS MUX2_X1
X_10778_ _05279_ _05280_ _05201_ _05281_ VDD VSS OAI21_X2
X_10779_ _05274_ _05277_ _05281_ _05282_ VDD VSS NAND3_X2
X_10780_ _05270_ _05282_ _05283_ VDD VSS NOR2_X4
X_10781_ _05264_ _05284_ VDD VSS INV_X1
X_10782_ _10241_ _05285_ VDD VSS INV_X1
X_10783_ _10247_ _05286_ VDD VSS INV_X1
X_10784_ _10248_ _05287_ VDD VSS INV_X1
X_10785_ _05286_ _05287_ _10250_ _05288_ VDD VSS OAI21_X2
X_10786_ _10244_ _05288_ _10245_ _05289_ VDD VSS AOI21_X2
X_10787_ _10242_ _05290_ VDD VSS INV_X1
X_10788_ _05285_ _05289_ _05290_ _05291_ VDD VSS OAI21_X2
X_10789_ _10232_ _05292_ VDD VSS INV_X1
X_10790_ _10235_ _10236_ _10238_ _05293_ VDD VSS AOI21_X1
X_10791_ _10233_ _05294_ VDD VSS INV_X1
X_10792_ _05292_ _05293_ _05294_ _05295_ VDD VSS OAI21_X1
X_10793_ _10229_ _05284_ _05291_ _05295_ net635 _05296_ VDD
+ VSS AOI221_X2
X_10794_ _05263_ _05283_ net770 _05297_ VDD VSS OAI21_X4
X_10795_ dynamic_node_top.east_input.control.my_loc_x_in\[5\]
+ dynamic_node_top.east_input.control.my_loc_x_in\[4\] dynamic_node_top.east_input.control.my_loc_x_in\[7\]
+ dynamic_node_top.east_input.control.my_loc_x_in\[6\] _05298_
+ VDD VSS NOR4_X4
X_10796_ dynamic_node_top.east_input.control.my_loc_x_in\[1\]
+ dynamic_node_top.east_input.control.my_loc_x_in\[0\] dynamic_node_top.east_input.control.my_loc_x_in\[3\]
+ dynamic_node_top.east_input.control.my_loc_x_in\[2\] _05299_
+ VDD VSS NOR4_X4
X_10797_ _05298_ _05299_ _05300_ VDD VSS AND2_X2
X_10798_ dynamic_node_top.east_input.control.my_loc_y_in\[3\]
+ dynamic_node_top.east_input.control.my_loc_y_in\[2\] dynamic_node_top.east_input.control.my_loc_y_in\[1\]
+ dynamic_node_top.east_input.control.my_loc_y_in\[0\] _05301_
+ VDD VSS NOR4_X4
X_10799_ dynamic_node_top.east_input.control.my_loc_y_in\[7\]
+ dynamic_node_top.east_input.control.my_loc_y_in\[6\] dynamic_node_top.east_input.control.my_loc_y_in\[5\]
+ dynamic_node_top.east_input.control.my_loc_y_in\[4\] _05302_
+ VDD VSS NOR4_X4
X_10800_ _05301_ _05302_ _05303_ VDD VSS AND2_X2
X_10801_ _05300_ _05303_ _05304_ VDD VSS NAND2_X4
X_10802_ _05282_ _05263_ _05304_ _05305_ VDD VSS OR3_X2
X_10803_ _05185_ _05297_ _05305_ _05306_ VDD VSS AOI21_X4
X_10804_ _00046_ _05307_ VDD VSS INV_X2
X_10805_ _05184_ _05306_ _05307_ _05308_ VDD VSS OAI21_X4
X_10806_ _05308_ net621 VDD VSS INV_X2
X_10807_ _00008_ _05309_ VDD VSS BUF_X8
X_10808_ _05309_ _05310_ VDD VSS BUF_X32
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
X_10810_ _05310_ _05312_ VDD VSS BUF_X16
X_10811_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[42\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[42\]
+ _05312_ _05313_ VDD VSS MUX2_X1
X_10812_ _05310_ _05314_ VDD VSS BUF_X32
X_10813_ _05314_ _05315_ VDD VSS BUF_X32
X_10814_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[42\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[42\]
+ _05315_ _05316_ VDD VSS MUX2_X1
X_10815_ _00007_ _05317_ VDD VSS BUF_X8
Xclone1 _05345_ _05454_ _05452_ net1 VDD VSS AOI21_X2
X_10817_ _05317_ _05319_ VDD VSS BUF_X8
X_10818_ _05319_ _05320_ VDD VSS BUF_X4
X_10819_ _05320_ _05321_ VDD VSS BUF_X8
X_10820_ _05313_ _05316_ _05321_ _10276_ VDD VSS MUX2_X2
X_10821_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[34\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[34\]
+ _05314_ _05322_ VDD VSS MUX2_X1
X_10822_ _05320_ _05322_ _05323_ VDD VSS OR2_X1
X_10823_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[34\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[34\]
+ _05312_ _05324_ VDD VSS MUX2_X1
X_10824_ _05317_ _05325_ VDD VSS INV_X2
X_10825_ _05325_ _05326_ VDD VSS BUF_X8
X_10826_ _05323_ _05324_ _05326_ _05327_ VDD VSS OAI21_X4
X_10827_ _05327_ _10321_ VDD VSS INV_X1
X_10828_ _00048_ _05328_ VDD VSS BUF_X4
X_10829_ dynamic_node_top.south_output.control.current_route_f\[4\]
+ _05329_ VDD VSS CLKBUF_X3
X_10830_ dynamic_node_top.south_output.control.current_route_f\[2\]
+ _05330_ VDD VSS CLKBUF_X3
X_10831_ dynamic_node_top.south_output.control.current_route_f\[3\]
+ _05331_ VDD VSS CLKBUF_X3
X_10832_ dynamic_node_top.south_output.control.current_route_f\[1\]
+ _05332_ VDD VSS CLKBUF_X3
X_10833_ _05329_ _05330_ _05331_ _05332_ _05333_ VDD VSS NOR4_X4
X_10834_ _05328_ _05333_ _05334_ VDD VSS AND2_X1
X_10835_ dynamic_node_top.south_output.space.is_one_f _05335_
+ VDD VSS INV_X1
X_10836_ _05335_ dynamic_node_top.south_output.space.valid_f
+ _05336_ VDD VSS NOR2_X1
X_10837_ dynamic_node_top.south_output.space.is_two_or_more_f
+ dynamic_node_top.south_output.space.yummy_f _05336_ _05337_
+ VDD VSS NOR3_X2
X_10838_ dynamic_node_top.south_output.control.current_route_f\[0\]
+ _05338_ VDD VSS BUF_X2
X_10839_ _05338_ _05168_ _05177_ _05331_ _05339_ VDD VSS AOI22_X1
X_10840_ _00047_ _05340_ VDD VSS INV_X1
X_10841_ _05340_ _05170_ _05175_ _05330_ _05341_ VDD VSS AOI22_X1
X_10842_ _05339_ _05341_ _05342_ VDD VSS NAND2_X1
X_10843_ _05342_ _05182_ _05329_ _05343_ VDD VSS AOI21_X1
X_10844_ _05334_ _05337_ _05343_ _05344_ VDD VSS NOR3_X2
X_10845_ _05344_ _05345_ VDD VSS INV_X1
X_10846_ dynamic_node_top.north_input.control.header_last_temp
+ _05168_ _05346_ VDD VSS NAND2_X1
X_10847_ _10281_ _10284_ _10287_ _10290_ _05347_ VDD VSS AND4_X2
X_10848_ _10296_ _10299_ _05348_ VDD VSS AND2_X2
X_10849_ _10278_ _10293_ _05347_ _05348_ _05349_ VDD VSS NAND4_X4
X_10850_ _05349_ _05346_ _05350_ VDD VSS NOR2_X2
X_10851_ _10308_ _10305_ _10302_ _10311_ _05351_ VDD VSS AND4_X4
X_10852_ _10313_ _10316_ net681 _05352_ VDD VSS AOI21_X1
X_10853_ net681 _10317_ _05353_ VDD VSS NAND2_X1
X_10854_ _10322_ _05354_ VDD VSS INV_X1
X_10855_ _10319_ _05354_ _10320_ _05355_ VDD VSS AOI21_X1
X_10856_ _05352_ _05353_ _05355_ _05356_ VDD VSS OAI21_X1
X_10857_ _10304_ _05357_ VDD VSS INV_X1
X_10858_ _10307_ net633 _10310_ _05358_ VDD VSS AOI21_X1
X_10859_ _10305_ _05359_ VDD VSS INV_X1
X_10860_ _05357_ _05358_ _05359_ _05360_ VDD VSS OAI21_X1
X_10861_ _10301_ _05351_ _05356_ _05360_ net691 _05361_ VDD
+ VSS AOI221_X2
X_10862_ net728 _05362_ VDD VSS CLKBUF_X3
X_10863_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[30\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[30\]
+ _05362_ _05363_ VDD VSS MUX2_X1
X_10864_ _05320_ _05363_ _05364_ VDD VSS OR2_X1
X_10865_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[30\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[30\]
+ net726 _05365_ VDD VSS MUX2_X1
X_10866_ _05364_ _05365_ _05325_ _05366_ VDD VSS OAI21_X2
X_10867_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[32\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[32\]
+ net728 _05367_ VDD VSS MUX2_X1
X_10868_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[32\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[32\]
+ net726 _05368_ VDD VSS MUX2_X1
X_10869_ _05367_ _05368_ _05319_ _05369_ VDD VSS MUX2_X1
X_10870_ _05369_ _05370_ VDD VSS BUF_X4
X_10871_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[31\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[31\]
+ net728 _05371_ VDD VSS MUX2_X1
X_10872_ _05319_ _05371_ _05372_ VDD VSS NOR2_X2
X_10873_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[31\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[31\]
+ net728 _05373_ VDD VSS MUX2_X1
X_10874_ _05325_ _05373_ _05374_ VDD VSS NOR2_X1
X_10875_ _05372_ _05374_ _05375_ VDD VSS OR2_X1
X_10876_ _05375_ _05376_ VDD VSS CLKBUF_X3
X_10877_ _10314_ _10317_ _05377_ VDD VSS AND2_X2
X_10878_ _10323_ _10320_ _05378_ VDD VSS AND2_X2
X_10879_ _05351_ _05377_ _05378_ _05379_ VDD VSS NAND3_X4
X_10880_ _05379_ _05370_ _05376_ _05366_ _05380_ VDD VSS NOR4_X4
X_10881_ _05350_ _05380_ _05361_ _05381_ VDD VSS OAI21_X1
X_10882_ _05298_ _05299_ _05382_ VDD VSS NAND2_X4
X_10883_ _05301_ _05302_ _05383_ VDD VSS NAND2_X4
X_10884_ _05382_ _05383_ _05384_ VDD VSS NOR2_X2
X_10885_ dynamic_node_top.north_input.control.header_last_temp
+ _05168_ _05385_ VDD VSS AND2_X1
X_10886_ _05385_ _05386_ VDD VSS BUF_X4
X_10887_ _05366_ _05370_ _05376_ _05387_ VDD VSS NOR3_X1
X_10888_ _05384_ _05386_ _05387_ _05388_ VDD VSS NAND3_X1
X_10889_ net678 _05389_ VDD VSS BUF_X4
X_10890_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[59\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[59\]
+ _05389_ _05390_ VDD VSS MUX2_X1
X_10891_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[59\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[59\]
+ _05389_ _05391_ VDD VSS MUX2_X1
X_10892_ _05390_ _05391_ _05317_ _05392_ VDD VSS MUX2_X1
X_10893_ _05226_ _05392_ _05393_ VDD VSS XNOR2_X2
X_10894_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[58\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[58\]
+ _05389_ _05394_ VDD VSS MUX2_X1
X_10895_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[58\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[58\]
+ _05389_ _05395_ VDD VSS MUX2_X1
X_10896_ _05394_ _05395_ _05317_ _05396_ VDD VSS MUX2_X1
X_10897_ _05215_ _05396_ _05397_ VDD VSS XNOR2_X2
X_10898_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[56\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[56\]
+ _05389_ _05398_ VDD VSS MUX2_X1
X_10899_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[56\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[56\]
+ _05389_ _05399_ VDD VSS MUX2_X1
X_10900_ _05398_ _05399_ _05317_ _05400_ VDD VSS MUX2_X1
X_10901_ _05204_ _05400_ _05401_ VDD VSS XNOR2_X2
X_10902_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[63\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[63\]
+ _05389_ _05402_ VDD VSS MUX2_X1
X_10903_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[63\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[63\]
+ _05389_ _05403_ VDD VSS MUX2_X1
X_10904_ _05402_ _05403_ _05317_ _05404_ VDD VSS MUX2_X1
X_10905_ _05221_ _05404_ _05405_ VDD VSS XNOR2_X2
X_10906_ _05393_ _05397_ _05401_ _05405_ _05406_ VDD VSS NAND4_X4
X_10907_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[54\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[54\]
+ _05389_ _05407_ VDD VSS MUX2_X1
X_10908_ net662 _05408_ VDD VSS CLKBUF_X3
X_10909_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[54\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[54\]
+ _05408_ _05409_ VDD VSS MUX2_X1
X_10910_ _05407_ _05409_ _05317_ _05410_ VDD VSS MUX2_X1
X_10911_ _05252_ _05410_ _05411_ VDD VSS XNOR2_X2
X_10912_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[51\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[51\]
+ _05408_ _05412_ VDD VSS MUX2_X1
X_10913_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[51\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[51\]
+ _05408_ _05413_ VDD VSS MUX2_X1
X_10914_ _05412_ _05413_ _05317_ _05414_ VDD VSS MUX2_X1
X_10915_ _05186_ _05414_ _05415_ VDD VSS XNOR2_X2
X_10916_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[52\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[52\]
+ _05408_ _05416_ VDD VSS MUX2_X1
X_10917_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[52\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[52\]
+ _05408_ _05417_ VDD VSS MUX2_X1
X_10918_ _05416_ _05417_ _05317_ _05418_ VDD VSS MUX2_X1
X_10919_ _05257_ _05418_ _05419_ VDD VSS XNOR2_X2
X_10920_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[55\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[55\]
+ _05408_ _05420_ VDD VSS MUX2_X1
X_10921_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[55\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[55\]
+ _05408_ _05421_ VDD VSS MUX2_X1
X_10922_ _05420_ _05421_ _05317_ _05422_ VDD VSS MUX2_X1
X_10923_ _05209_ _05422_ _05423_ VDD VSS XNOR2_X2
X_10924_ _05411_ _05415_ _05419_ _05423_ _05424_ VDD VSS NAND4_X4
X_10925_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[60\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[60\]
+ net2 _05425_ VDD VSS MUX2_X1
X_10926_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[60\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[60\]
+ net2 _05426_ VDD VSS MUX2_X1
X_10927_ _05425_ _05426_ _05317_ _05427_ VDD VSS MUX2_X2
X_10928_ _05191_ _05427_ _05428_ VDD VSS XNOR2_X2
X_10929_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[50\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[50\]
+ net2 _05429_ VDD VSS MUX2_X1
X_10930_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[50\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[50\]
+ net677 _05430_ VDD VSS MUX2_X1
X_10931_ _05429_ _05430_ _05317_ _05431_ VDD VSS MUX2_X1
X_10932_ _05247_ _05431_ _05432_ VDD VSS XNOR2_X2
X_10933_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[62\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[62\]
+ net2 _05433_ VDD VSS MUX2_X1
X_10934_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[62\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[62\]
+ net677 _05434_ VDD VSS MUX2_X1
X_10935_ _05433_ _05434_ _05317_ _05435_ VDD VSS MUX2_X1
X_10936_ _05197_ _05435_ _05436_ VDD VSS XNOR2_X2
X_10937_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[61\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[61\]
+ net2 _05437_ VDD VSS MUX2_X1
X_10938_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[61\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[61\]
+ net677 _05438_ VDD VSS MUX2_X1
X_10939_ _05437_ _05438_ _05317_ _05439_ VDD VSS MUX2_X1
X_10940_ _05236_ _05439_ _05440_ VDD VSS XNOR2_X2
X_10941_ _05428_ _05432_ _05436_ _05440_ _05441_ VDD VSS NAND4_X4
X_10942_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[57\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[57\]
+ _05389_ _05442_ VDD VSS MUX2_X1
X_10943_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[57\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[57\]
+ _05408_ _05443_ VDD VSS MUX2_X1
X_10944_ _05442_ _05443_ _05317_ _05444_ VDD VSS MUX2_X1
X_10945_ _05231_ _05444_ _05445_ VDD VSS XNOR2_X1
X_10946_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[53\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[53\]
+ _05408_ _05446_ VDD VSS MUX2_X1
X_10947_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[53\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[53\]
+ _05408_ _05447_ VDD VSS MUX2_X1
X_10948_ _05446_ _05447_ _05317_ _05448_ VDD VSS MUX2_X1
X_10949_ _05242_ _05448_ _05449_ VDD VSS XNOR2_X1
X_10950_ _05445_ _05449_ _05450_ VDD VSS NAND2_X2
X_10951_ _05406_ _05424_ _05441_ _05450_ _05451_ VDD VSS OR4_X4
X_10952_ _05381_ _05388_ _05451_ _05452_ VDD VSS MUX2_X2
Xrebuffer100 _07420_ net752 VDD VSS BUF_X1
X_10954_ _00049_ _05454_ VDD VSS BUF_X2
X_10955_ _05345_ _05454_ _05452_ net624 VDD VSS AOI21_X4
X_10956_ _00006_ _05455_ VDD VSS BUF_X8
X_10957_ _05455_ _05456_ VDD VSS BUF_X32
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
X_10959_ _05456_ _05458_ VDD VSS BUF_X32
X_10960_ _05458_ _05459_ VDD VSS BUF_X32
X_10961_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[42\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[42\]
+ _05459_ _05460_ VDD VSS MUX2_X1
X_10962_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[42\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[42\]
+ _05459_ _05461_ VDD VSS MUX2_X1
X_10963_ _00005_ _05462_ VDD VSS BUF_X4
X_10964_ _05462_ _05463_ VDD VSS BUF_X8
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
X_10966_ _05463_ _05465_ VDD VSS BUF_X2
X_10967_ _05460_ _05461_ _05465_ _10345_ VDD VSS MUX2_X2
X_10968_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[34\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[34\]
+ net721 _05466_ VDD VSS MUX2_X1
X_10969_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[34\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[34\]
+ net721 _05467_ VDD VSS MUX2_X1
X_10970_ _05463_ _05468_ VDD VSS CLKBUF_X3
X_10971_ _05466_ _05467_ _05468_ _10348_ VDD VSS MUX2_X2
X_10972_ _00051_ _05469_ VDD VSS INV_X4
X_10973_ dynamic_node_top.west_output.control.current_route_f\[3\]
+ _05470_ VDD VSS BUF_X4
X_10974_ dynamic_node_top.west_output.control.current_route_f\[1\]
+ _05471_ VDD VSS BUF_X2
X_10975_ dynamic_node_top.west_output.control.current_route_f\[4\]
+ dynamic_node_top.west_output.control.current_route_f\[2\]
+ _05470_ _05471_ _05472_ VDD VSS NOR4_X4
X_10976_ _05472_ _05473_ VDD VSS INV_X1
X_10977_ _05469_ _05473_ _05474_ VDD VSS NOR2_X2
X_10978_ dynamic_node_top.west_output.space.is_one_f _05475_
+ VDD VSS INV_X1
X_10979_ _05475_ dynamic_node_top.west_output.space.valid_f
+ _05476_ VDD VSS NOR2_X1
X_10980_ dynamic_node_top.west_output.space.is_two_or_more_f
+ dynamic_node_top.west_output.space.yummy_f _05476_ _05477_
+ VDD VSS NOR3_X2
X_10981_ dynamic_node_top.west_output.control.current_route_f\[4\]
+ _05478_ VDD VSS CLKBUF_X3
X_10982_ _00050_ _05479_ VDD VSS INV_X1
X_10983_ _05478_ _05168_ _05175_ _05479_ _05480_ VDD VSS AOI22_X1
X_10984_ dynamic_node_top.west_output.control.current_route_f\[0\]
+ _05481_ VDD VSS CLKBUF_X3
X_10985_ _05470_ _05170_ _05177_ _05481_ _05482_ VDD VSS AOI22_X1
X_10986_ _05480_ _05482_ _05483_ VDD VSS NAND2_X1
X_10987_ dynamic_node_top.west_output.control.current_route_f\[2\]
+ _05484_ VDD VSS CLKBUF_X3
X_10988_ _05483_ _05182_ _05484_ _05485_ VDD VSS AOI21_X1
X_10989_ _05474_ _05477_ _05485_ _05486_ VDD VSS NOR3_X1
X_10990_ _05486_ _05487_ VDD VSS INV_X1
X_10991_ dynamic_node_top.east_input.control.header_last_temp
+ _05488_ VDD VSS BUF_X2
X_10992_ _05488_ _05177_ _05489_ VDD VSS NAND2_X4
X_10993_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[30\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[30\]
+ net700 _05490_ VDD VSS MUX2_X1
X_10994_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[30\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[30\]
+ net701 _05491_ VDD VSS MUX2_X2
X_10995_ _05490_ _05491_ _05462_ _05492_ VDD VSS MUX2_X2
X_10996_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[31\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[31\]
+ net711 _05493_ VDD VSS MUX2_X1
X_10997_ _05463_ _05493_ _05494_ VDD VSS NOR2_X2
X_10998_ _05462_ _05495_ VDD VSS INV_X4
X_10999_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[31\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[31\]
+ net711 _05496_ VDD VSS MUX2_X1
X_11000_ _05495_ _05496_ _05497_ VDD VSS NOR2_X4
X_11001_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[32\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[32\]
+ net700 _05498_ VDD VSS MUX2_X1
X_11002_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[32\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[32\]
+ net700 _05499_ VDD VSS MUX2_X2
X_11003_ _05498_ _05499_ _05462_ _05500_ VDD VSS MUX2_X2
X_11004_ _05492_ _05494_ _05497_ _05500_ _05501_ VDD VSS NOR4_X2
X_11005_ _05382_ _05303_ _05501_ _05502_ VDD VSS AOI21_X1
X_11006_ _05489_ _05502_ _05503_ VDD VSS OR2_X1
X_11007_ _10326_ _10329_ _05504_ VDD VSS NAND2_X1
X_11008_ _10325_ _10328_ net638 _05505_ VDD VSS AOI21_X2
X_11009_ _05504_ _05505_ _05506_ VDD VSS AND2_X1
X_11010_ _10335_ _10332_ _10344_ _10347_ _05507_ VDD VSS NAND4_X2
X_11011_ _10338_ _10341_ _05508_ VDD VSS NAND2_X1
X_11012_ _05507_ _05504_ _05508_ _05509_ VDD VSS OR3_X4
X_11013_ _10368_ _10350_ _05510_ VDD VSS NAND2_X1
X_11014_ _10371_ _10362_ _05511_ VDD VSS NAND2_X2
X_11015_ _10365_ _10356_ _10359_ _10353_ _05512_ VDD VSS NAND4_X2
X_11016_ _05512_ _05511_ _05510_ _05513_ VDD VSS NOR3_X4
X_11017_ net682 _05501_ _05513_ _05514_ VDD VSS AOI21_X2
X_11018_ _05509_ _05505_ _05515_ VDD VSS NAND2_X4
X_11019_ _10331_ _05516_ VDD VSS INV_X1
X_11020_ net660 net637 _10334_ _05517_ VDD VSS OAI21_X1
X_11021_ _05516_ _05517_ _05518_ VDD VSS NAND2_X1
X_11022_ _10331_ _10334_ _10337_ _05519_ VDD VSS OR3_X1
X_11023_ _05519_ _10340_ net724 _05520_ VDD VSS AOI21_X1
X_11024_ _10346_ _05521_ VDD VSS INV_X1
X_11025_ _10343_ _05521_ net716 _05522_ VDD VSS AOI21_X1
X_11026_ _05520_ _05522_ _05508_ _05523_ VDD VSS OAI21_X2
X_11027_ _05515_ _05518_ _05523_ _05524_ VDD VSS AOI21_X4
X_11028_ _05489_ _05524_ _05514_ _05506_ _05525_ VDD VSS OR4_X4
X_11029_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[58\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[58\]
+ net711 _05526_ VDD VSS MUX2_X1
X_11030_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[58\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[58\]
+ net717 _05527_ VDD VSS MUX2_X1
X_11031_ _05526_ _05527_ _05463_ _05528_ VDD VSS MUX2_X1
X_11032_ _05215_ _05528_ _05529_ VDD VSS XNOR2_X1
X_11033_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[51\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[51\]
+ net717 _05530_ VDD VSS MUX2_X1
X_11034_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[51\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[51\]
+ net717 _05531_ VDD VSS MUX2_X1
X_11035_ _05462_ _05532_ VDD VSS CLKBUF_X3
X_11036_ _05530_ _05531_ _05532_ _05533_ VDD VSS MUX2_X1
X_11037_ _05186_ _05533_ _05534_ VDD VSS XNOR2_X1
X_11038_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[57\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[57\]
+ net717 _05535_ VDD VSS MUX2_X1
X_11039_ net699 _05536_ VDD VSS BUF_X4
X_11040_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[57\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[57\]
+ _05536_ _05537_ VDD VSS MUX2_X1
X_11041_ _05535_ _05537_ _05532_ _05538_ VDD VSS MUX2_X1
X_11042_ _05231_ _05538_ _05539_ VDD VSS XNOR2_X1
X_11043_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[62\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[62\]
+ _05536_ _05540_ VDD VSS MUX2_X1
X_11044_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[62\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[62\]
+ _05536_ _05541_ VDD VSS MUX2_X2
X_11045_ _05540_ _05541_ _05532_ _05542_ VDD VSS MUX2_X1
X_11046_ _05197_ _05542_ _05543_ VDD VSS XNOR2_X1
X_11047_ _05529_ _05534_ _05539_ _05543_ _05544_ VDD VSS NAND4_X2
X_11048_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[56\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[56\]
+ _05536_ _05545_ VDD VSS MUX2_X1
X_11049_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[56\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[56\]
+ _05536_ _05546_ VDD VSS MUX2_X1
X_11050_ _05545_ _05546_ _05532_ _05547_ VDD VSS MUX2_X1
X_11051_ _05204_ _05547_ _05548_ VDD VSS XNOR2_X1
X_11052_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[50\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[50\]
+ _05536_ _05549_ VDD VSS MUX2_X1
Xrebuffer120 _05296_ net770 VDD VSS BUF_X4
X_11054_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[50\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[50\]
+ net708 _05551_ VDD VSS MUX2_X1
X_11055_ _05549_ _05551_ _05532_ _05552_ VDD VSS MUX2_X1
X_11056_ _05247_ _05552_ _05553_ VDD VSS XNOR2_X1
X_11057_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[60\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[60\]
+ net698 _05554_ VDD VSS MUX2_X1
X_11058_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[60\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[60\]
+ net708 _05555_ VDD VSS MUX2_X1
X_11059_ _05554_ _05555_ _05462_ _05556_ VDD VSS MUX2_X2
X_11060_ _05191_ _05556_ _05557_ VDD VSS XNOR2_X1
X_11061_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[54\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[54\]
+ net708 _05558_ VDD VSS MUX2_X1
X_11062_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[54\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[54\]
+ net708 _05559_ VDD VSS MUX2_X1
X_11063_ _05558_ _05559_ _05532_ _05560_ VDD VSS MUX2_X1
X_11064_ _05252_ _05560_ _05561_ VDD VSS XNOR2_X1
X_11065_ _05548_ _05553_ _05557_ _05561_ _05562_ VDD VSS NAND4_X2
X_11066_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[61\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[61\]
+ net708 _05563_ VDD VSS MUX2_X1
X_11067_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[61\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[61\]
+ net708 _05564_ VDD VSS MUX2_X1
X_11068_ _05563_ _05564_ _05532_ _05565_ VDD VSS MUX2_X1
X_11069_ _05236_ _05565_ _05566_ VDD VSS XNOR2_X1
X_11070_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[59\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[59\]
+ net708 _05567_ VDD VSS MUX2_X1
X_11071_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[59\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[59\]
+ net708 _05568_ VDD VSS MUX2_X1
X_11072_ _05567_ _05568_ _05532_ _05569_ VDD VSS MUX2_X1
X_11073_ _05226_ _05569_ _05570_ VDD VSS XNOR2_X1
X_11074_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[55\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[55\]
+ net708 _05571_ VDD VSS MUX2_X1
X_11075_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[55\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[55\]
+ _05455_ _05572_ VDD VSS MUX2_X1
X_11076_ _05571_ _05572_ _05462_ _05573_ VDD VSS MUX2_X1
X_11077_ _05209_ _05573_ _05574_ VDD VSS XNOR2_X1
X_11078_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[63\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[63\]
+ net698 _05575_ VDD VSS MUX2_X1
X_11079_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[63\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[63\]
+ net698 _05576_ VDD VSS MUX2_X1
X_11080_ _05575_ _05576_ _05462_ _05577_ VDD VSS MUX2_X1
X_11081_ _05221_ _05577_ _05578_ VDD VSS XNOR2_X1
X_11082_ _05566_ _05570_ _05574_ _05578_ _05579_ VDD VSS NAND4_X2
X_11083_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[53\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[53\]
+ _05536_ _05580_ VDD VSS MUX2_X1
X_11084_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[53\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[53\]
+ _05536_ _05581_ VDD VSS MUX2_X1
X_11085_ _05580_ _05581_ _05532_ _05582_ VDD VSS MUX2_X1
X_11086_ _05242_ _05582_ _05583_ VDD VSS XNOR2_X1
X_11087_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[52\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[52\]
+ _05536_ _05584_ VDD VSS MUX2_X1
X_11088_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[52\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[52\]
+ net708 _05585_ VDD VSS MUX2_X1
X_11089_ _05584_ _05585_ _05532_ _05586_ VDD VSS MUX2_X1
X_11090_ _05257_ _05586_ _05587_ VDD VSS XNOR2_X1
X_11091_ _05583_ _05587_ _05588_ VDD VSS NAND2_X1
X_11092_ _05562_ _05579_ _05544_ _05588_ _05589_ VDD VSS NOR4_X4
X_11093_ _05503_ _05525_ _05589_ _05590_ VDD VSS MUX2_X2
Xrebuffer107 net625 net756 VDD VSS BUF_X4
X_11095_ _05487_ _05590_ _00052_ net625 VDD VSS AOI21_X4
X_11096_ _00054_ _05592_ VDD VSS CLKBUF_X3
X_11097_ _05592_ _05593_ VDD VSS INV_X2
X_11098_ dynamic_node_top.proc_output.control.current_route_f\[2\]
+ _05594_ VDD VSS CLKBUF_X3
X_11099_ dynamic_node_top.proc_output.control.current_route_f\[3\]
+ _05595_ VDD VSS CLKBUF_X3
X_11100_ dynamic_node_top.proc_output.control.current_route_f\[1\]
+ _05596_ VDD VSS BUF_X2
X_11101_ dynamic_node_top.proc_output.control.current_route_f\[4\]
+ _05594_ _05595_ _05596_ _05597_ VDD VSS NOR4_X4
X_11102_ _05597_ _05598_ VDD VSS INV_X1
X_11103_ _05593_ _05598_ _05599_ VDD VSS NOR2_X2
X_11104_ dynamic_node_top.proc_output.space.is_one_f _05600_
+ VDD VSS INV_X1
X_11105_ _05600_ dynamic_node_top.proc_output.space.valid_f
+ _05601_ VDD VSS NOR2_X1
X_11106_ dynamic_node_top.proc_output.space.is_two_or_more_f
+ dynamic_node_top.proc_output.space.yummy_f _05601_ _05602_
+ VDD VSS NOR3_X1
X_11107_ dynamic_node_top.proc_output.control.current_route_f\[0\]
+ _05603_ VDD VSS CLKBUF_X3
X_11108_ _05594_ _05168_ _05170_ _05603_ _05604_ VDD VSS AOI22_X1
X_11109_ dynamic_node_top.proc_output.control.current_route_f\[4\]
+ _05605_ VDD VSS BUF_X4
X_11110_ _05595_ _05175_ _05177_ _05605_ _05606_ VDD VSS AOI22_X1
X_11111_ _05604_ _05606_ _05607_ VDD VSS NAND2_X1
X_11112_ _00053_ _05608_ VDD VSS INV_X1
X_11113_ _05607_ _05182_ _05608_ _05609_ VDD VSS AOI21_X1
X_11114_ _05599_ _05602_ _05609_ _05610_ VDD VSS OR3_X2
X_11115_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[32\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[32\]
+ net746 _05611_ VDD VSS MUX2_X1
X_11116_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[32\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[32\]
+ net746 _05612_ VDD VSS MUX2_X1
X_11117_ _05611_ _05612_ _05124_ _05613_ VDD VSS MUX2_X2
X_11118_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[30\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[30\]
+ net765 _05614_ VDD VSS MUX2_X1
X_11119_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[30\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[30\]
+ net746 _05615_ VDD VSS MUX2_X1
X_11120_ _05614_ _05615_ _05124_ _05616_ VDD VSS MUX2_X2
X_11121_ _05613_ _05616_ _05617_ VDD VSS NOR2_X2
X_11122_ dynamic_node_top.south_input.control.header_last_temp
+ _05170_ _05618_ VDD VSS NAND2_X1
X_11123_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[31\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[31\]
+ net765 _05619_ VDD VSS MUX2_X1
X_11124_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[31\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[31\]
+ net765 _05620_ VDD VSS MUX2_X1
X_11125_ _05619_ _05620_ _05124_ _05621_ VDD VSS MUX2_X2
X_11126_ _05618_ _05621_ _05622_ VDD VSS NOR2_X1
X_11127_ _05384_ _05617_ _05622_ _05623_ VDD VSS NAND3_X1
X_11128_ _05617_ _05622_ _05624_ VDD VSS NAND2_X1
X_11129_ _10220_ _10214_ _10211_ _10223_ _05625_ VDD VSS NAND4_X2
X_11130_ _10205_ _10217_ _10208_ _10227_ _05626_ VDD VSS NAND4_X2
X_11131_ _05625_ _05626_ _05627_ VDD VSS NOR2_X1
X_11132_ _10190_ _10181_ _10199_ _10184_ _05628_ VDD VSS AND4_X2
X_11133_ _10187_ _10202_ _05629_ VDD VSS AND2_X1
X_11134_ _10193_ _10196_ _05628_ _05629_ _05630_ VDD VSS AND4_X4
X_11135_ _05627_ _05630_ _05631_ VDD VSS NAND2_X1
X_11136_ _05624_ _05631_ _05632_ VDD VSS OR2_X1
X_11137_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[63\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[63\]
+ net687 _05633_ VDD VSS MUX2_X1
X_11138_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[63\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[63\]
+ net687 _05634_ VDD VSS MUX2_X1
X_11139_ _05633_ _05634_ _05124_ _05635_ VDD VSS MUX2_X1
X_11140_ _05221_ _05635_ _05636_ VDD VSS XNOR2_X2
X_11141_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[60\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[60\]
+ net687 _05637_ VDD VSS MUX2_X1
X_11142_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[60\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[60\]
+ net687 _05638_ VDD VSS MUX2_X1
X_11143_ _05637_ _05638_ _05124_ _05639_ VDD VSS MUX2_X2
X_11144_ _05191_ _05639_ _05640_ VDD VSS XNOR2_X2
X_11145_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[53\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[53\]
+ _05129_ _05641_ VDD VSS MUX2_X1
X_11146_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[53\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[53\]
+ net687 _05642_ VDD VSS MUX2_X1
X_11147_ _05124_ _05643_ VDD VSS CLKBUF_X3
X_11148_ _05641_ _05642_ _05643_ _05644_ VDD VSS MUX2_X1
X_11149_ _05242_ _05644_ _05645_ VDD VSS XNOR2_X2
X_11150_ net679 _05646_ VDD VSS BUF_X4
X_11151_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[51\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[51\]
+ _05646_ _05647_ VDD VSS MUX2_X1
X_11152_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[51\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[51\]
+ _05129_ _05648_ VDD VSS MUX2_X1
X_11153_ _05647_ _05648_ _05124_ _05649_ VDD VSS MUX2_X2
X_11154_ _05186_ _05649_ _05650_ VDD VSS XNOR2_X2
X_11155_ _05636_ _05640_ _05645_ _05650_ _05651_ VDD VSS NAND4_X4
X_11156_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[52\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[52\]
+ _05129_ _05652_ VDD VSS MUX2_X1
X_11157_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[52\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[52\]
+ net687 _05653_ VDD VSS MUX2_X1
X_11158_ _05652_ _05653_ _05643_ _05654_ VDD VSS MUX2_X1
X_11159_ _05257_ _05654_ _05655_ VDD VSS XNOR2_X2
X_11160_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[56\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[56\]
+ _05646_ _05656_ VDD VSS MUX2_X1
X_11161_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[56\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[56\]
+ _05646_ _05657_ VDD VSS MUX2_X1
X_11162_ _05656_ _05657_ _05643_ _05658_ VDD VSS MUX2_X1
X_11163_ _05204_ _05658_ _05659_ VDD VSS XNOR2_X2
X_11164_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[62\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[62\]
+ _05646_ _05660_ VDD VSS MUX2_X1
X_11165_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[62\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[62\]
+ _05646_ _05661_ VDD VSS MUX2_X1
X_11166_ _05660_ _05661_ _05643_ _05662_ VDD VSS MUX2_X1
X_11167_ _05197_ _05662_ _05663_ VDD VSS XNOR2_X2
X_11168_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[54\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[54\]
+ net668 _05664_ VDD VSS MUX2_X1
X_11169_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[54\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[54\]
+ net666 _05665_ VDD VSS MUX2_X1
X_11170_ _05664_ _05665_ _05643_ _05666_ VDD VSS MUX2_X1
X_11171_ _05252_ _05666_ _05667_ VDD VSS XNOR2_X2
X_11172_ _05655_ _05659_ _05663_ _05667_ _05668_ VDD VSS NAND4_X4
X_11173_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[57\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[57\]
+ _05646_ _05669_ VDD VSS MUX2_X1
X_11174_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[57\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[57\]
+ net668 _05670_ VDD VSS MUX2_X1
X_11175_ _05669_ _05670_ _05643_ _05671_ VDD VSS MUX2_X1
X_11176_ _05231_ _05671_ _05672_ VDD VSS XNOR2_X2
X_11177_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[59\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[59\]
+ _05128_ _05673_ VDD VSS MUX2_X1
X_11178_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[59\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[59\]
+ net668 _05674_ VDD VSS MUX2_X1
X_11179_ _05673_ _05674_ _05643_ _05675_ VDD VSS MUX2_X1
X_11180_ _05226_ _05675_ _05676_ VDD VSS XNOR2_X2
X_11181_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[61\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[61\]
+ _05128_ _05677_ VDD VSS MUX2_X1
X_11182_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[61\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[61\]
+ net668 _05678_ VDD VSS MUX2_X1
X_11183_ _05677_ _05678_ _05643_ _05679_ VDD VSS MUX2_X1
X_11184_ _05236_ _05679_ _05680_ VDD VSS XNOR2_X2
X_11185_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[50\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[50\]
+ _05128_ _05681_ VDD VSS MUX2_X1
X_11186_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[50\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[50\]
+ net666 _05682_ VDD VSS MUX2_X1
X_11187_ _05681_ _05682_ _05124_ _05683_ VDD VSS MUX2_X1
X_11188_ _05247_ _05683_ _05684_ VDD VSS XNOR2_X2
X_11189_ _05672_ _05676_ _05680_ _05684_ _05685_ VDD VSS NAND4_X4
X_11190_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[55\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[55\]
+ _05646_ _05686_ VDD VSS MUX2_X1
X_11191_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[55\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[55\]
+ _05646_ _05687_ VDD VSS MUX2_X1
X_11192_ _05686_ _05687_ _05643_ _05688_ VDD VSS MUX2_X1
X_11193_ _05209_ _05688_ _05689_ VDD VSS XNOR2_X1
X_11194_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[58\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[58\]
+ _05646_ _05690_ VDD VSS MUX2_X1
X_11195_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[58\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[58\]
+ _05646_ _05691_ VDD VSS MUX2_X1
X_11196_ _05690_ _05691_ _05643_ _05692_ VDD VSS MUX2_X1
X_11197_ _05215_ _05692_ _05693_ VDD VSS XNOR2_X1
X_11198_ _05689_ _05693_ _05694_ VDD VSS NAND2_X2
X_11199_ _05668_ _05651_ _05685_ _05694_ _05695_ VDD VSS NOR4_X4
X_11200_ _05623_ _05632_ net748 _05696_ VDD VSS MUX2_X2
X_11201_ _00055_ _05697_ VDD VSS BUF_X2
X_11202_ _05610_ _05697_ _05696_ net623 VDD VSS AOI21_X4
Xrebuffer130 _00010_ net760 VDD VSS BUF_X1
X_11204_ _00010_ _05699_ VDD VSS BUF_X8
X_11205_ _05699_ _05700_ VDD VSS BUF_X16
Xrebuffer131 net760 net761 VDD VSS BUF_X1
X_11207_ _05700_ _05702_ VDD VSS BUF_X16
X_11208_ _05702_ _05703_ VDD VSS BUF_X4
X_11209_ _05703_ _05704_ VDD VSS CLKBUF_X3
X_11210_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[42\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[42\]
+ _05704_ _05705_ VDD VSS MUX2_X1
X_11211_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[42\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[42\]
+ _05704_ _05706_ VDD VSS MUX2_X1
X_11212_ _00009_ _05707_ VDD VSS BUF_X4
X_11213_ _05707_ _05708_ VDD VSS BUF_X4
X_11214_ _05708_ _05709_ VDD VSS BUF_X4
X_11215_ _05709_ _05710_ VDD VSS BUF_X4
X_11216_ _05710_ _05711_ VDD VSS BUF_X4
X_11217_ _05705_ _05706_ _05711_ _05712_ VDD VSS MUX2_X1
X_11218_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[42\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[42\]
+ _05704_ _05713_ VDD VSS MUX2_X1
X_11219_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[42\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[42\]
+ _05704_ _05714_ VDD VSS MUX2_X1
X_11220_ _05713_ _05714_ _05711_ _05715_ VDD VSS MUX2_X1
X_11221_ _00012_ _05716_ VDD VSS BUF_X4
X_11222_ _05716_ _05717_ VDD VSS BUF_X4
X_11223_ _05717_ _05718_ VDD VSS INV_X4
X_11224_ _05718_ _05719_ VDD VSS BUF_X4
X_11225_ _05719_ _05720_ VDD VSS BUF_X4
X_11226_ _05720_ _05721_ VDD VSS BUF_X4
X_11227_ _05712_ _05715_ _05721_ _05722_ VDD VSS MUX2_X1
X_11228_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[42\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[42\]
+ _05704_ _05723_ VDD VSS MUX2_X1
X_11229_ _05703_ _05724_ VDD VSS BUF_X4
X_11230_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[42\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[42\]
+ _05724_ _05725_ VDD VSS MUX2_X1
X_11231_ _05723_ _05725_ _05711_ _05726_ VDD VSS MUX2_X1
X_11232_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[42\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[42\]
+ _05724_ _05727_ VDD VSS MUX2_X1
X_11233_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[42\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[42\]
+ _05724_ _05728_ VDD VSS MUX2_X1
X_11234_ _05710_ _05729_ VDD VSS BUF_X4
X_11235_ _05727_ _05728_ _05729_ _05730_ VDD VSS MUX2_X1
X_11236_ _05726_ _05730_ _05721_ _05731_ VDD VSS MUX2_X1
X_11237_ _00011_ _05732_ VDD VSS BUF_X4
X_11238_ _05732_ _05733_ VDD VSS BUF_X4
X_11239_ _05733_ _05734_ VDD VSS BUF_X4
X_11240_ _05734_ _05735_ VDD VSS BUF_X4
X_11241_ _05735_ _05736_ VDD VSS BUF_X4
X_11242_ _05736_ _05737_ VDD VSS BUF_X4
X_11243_ _05737_ _05738_ VDD VSS BUF_X8
X_11244_ _05722_ _05731_ _05738_ _10372_ VDD VSS MUX2_X2
X_11245_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[34\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[34\]
+ _05704_ _05739_ VDD VSS MUX2_X1
X_11246_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[34\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[34\]
+ _05704_ _05740_ VDD VSS MUX2_X1
X_11247_ _05739_ _05740_ _05711_ _05741_ VDD VSS MUX2_X1
X_11248_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[34\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[34\]
+ _05704_ _05742_ VDD VSS MUX2_X1
X_11249_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[34\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[34\]
+ _05704_ _05743_ VDD VSS MUX2_X1
X_11250_ _05742_ _05743_ _05711_ _05744_ VDD VSS MUX2_X1
X_11251_ _05741_ _05744_ _05721_ _05745_ VDD VSS MUX2_X1
X_11252_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[34\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[34\]
+ _05704_ _05746_ VDD VSS MUX2_X1
X_11253_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[34\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[34\]
+ _05724_ _05747_ VDD VSS MUX2_X1
X_11254_ _05746_ _05747_ _05711_ _05748_ VDD VSS MUX2_X1
X_11255_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[34\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[34\]
+ _05724_ _05749_ VDD VSS MUX2_X1
X_11256_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[34\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[34\]
+ _05724_ _05750_ VDD VSS MUX2_X1
X_11257_ _05749_ _05750_ _05729_ _05751_ VDD VSS MUX2_X1
X_11258_ _05748_ _05751_ _05721_ _05752_ VDD VSS MUX2_X1
X_11259_ _05745_ _05752_ _05738_ _10417_ VDD VSS MUX2_X2
X_11260_ dynamic_node_top.north_output.control.current_route_f\[1\]
+ _05753_ VDD VSS BUF_X4
X_11261_ _05753_ _05754_ VDD VSS BUF_X4
X_11262_ _00056_ _05755_ VDD VSS CLKBUF_X2
X_11263_ _05755_ _05756_ VDD VSS CLKBUF_X3
X_11264_ dynamic_node_top.north_output.control.current_route_f\[4\]
+ _05757_ VDD VSS BUF_X4
X_11265_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[26\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[26\]
+ net711 _05758_ VDD VSS MUX2_X1
X_11266_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[26\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[26\]
+ net711 _05759_ VDD VSS MUX2_X1
X_11267_ _05758_ _05759_ _05463_ _05760_ VDD VSS MUX2_X2
X_11268_ _05489_ _05760_ _05761_ VDD VSS NOR2_X1
X_11269_ _05536_ _05762_ VDD VSS BUF_X4
X_11270_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[23\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[23\]
+ _05762_ _05763_ VDD VSS MUX2_X1
X_11271_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[23\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[23\]
+ net711 _05764_ VDD VSS MUX2_X1
X_11272_ _05763_ _05764_ _05463_ _05765_ VDD VSS MUX2_X2
X_11273_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[25\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[25\]
+ _05762_ _05766_ VDD VSS MUX2_X1
X_11274_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[25\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[25\]
+ _05762_ _05767_ VDD VSS MUX2_X1
X_11275_ _05766_ _05767_ _05463_ _05768_ VDD VSS MUX2_X2
X_11276_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[24\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[24\]
+ _05762_ _05769_ VDD VSS MUX2_X1
X_11277_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[24\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[24\]
+ _05762_ _05770_ VDD VSS MUX2_X1
X_11278_ _05769_ _05770_ _05463_ _05771_ VDD VSS MUX2_X2
X_11279_ _05765_ _05768_ _05771_ _05772_ VDD VSS NOR3_X1
X_11280_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[22\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[22\]
+ _05762_ _05773_ VDD VSS MUX2_X1
X_11281_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[22\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[22\]
+ net711 _05774_ VDD VSS MUX2_X1
X_11282_ _05773_ _05774_ _05463_ _05775_ VDD VSS MUX2_X2
X_11283_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[29\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[29\]
+ net711 _05776_ VDD VSS MUX2_X1
X_11284_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[29\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[29\]
+ _05762_ _05777_ VDD VSS MUX2_X1
X_11285_ _05776_ _05777_ _05463_ _05778_ VDD VSS MUX2_X2
X_11286_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[27\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[27\]
+ _05762_ _05779_ VDD VSS MUX2_X1
X_11287_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[27\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[27\]
+ _05762_ _05780_ VDD VSS MUX2_X1
X_11288_ _05779_ _05780_ _05463_ _05781_ VDD VSS MUX2_X2
X_11289_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[28\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[28\]
+ net711 _05782_ VDD VSS MUX2_X1
X_11290_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[28\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[28\]
+ _05762_ _05783_ VDD VSS MUX2_X1
X_11291_ _05782_ _05783_ _05463_ _05784_ VDD VSS MUX2_X2
X_11292_ _05775_ _05778_ _05781_ _05784_ _05785_ VDD VSS NOR4_X1
X_11293_ _05761_ _05772_ _05785_ _05786_ VDD VSS AND3_X1
X_11294_ net626 _05787_ VDD VSS BUF_X2
X_11295_ dynamic_node_top.east_input.control.tail_last_f dynamic_node_top.east_input.control.count_one_f
+ _05787_ _05788_ VDD VSS MUX2_X1
X_11296_ _05786_ _05788_ _05789_ VDD VSS OR2_X1
X_11297_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[26\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[26\]
+ net738 _05790_ VDD VSS MUX2_X1
X_11298_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[26\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[26\]
+ net738 _05791_ VDD VSS MUX2_X1
X_11299_ _05790_ _05791_ _05151_ _05792_ VDD VSS MUX2_X2
X_11300_ _05185_ _05792_ _05793_ VDD VSS NOR2_X1
X_11301_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[23\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[23\]
+ net738 _05794_ VDD VSS MUX2_X1
X_11302_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[23\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[23\]
+ net738 _05795_ VDD VSS MUX2_X1
X_11303_ _05794_ _05795_ _05151_ _05796_ VDD VSS MUX2_X2
X_11304_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[24\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[24\]
+ _05143_ _05797_ VDD VSS MUX2_X1
X_11305_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[24\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[24\]
+ net738 _05798_ VDD VSS MUX2_X1
X_11306_ _05797_ _05798_ _05151_ _05799_ VDD VSS MUX2_X2
X_11307_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[25\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[25\]
+ net740 _05800_ VDD VSS MUX2_X1
X_11308_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[25\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[25\]
+ net740 _05801_ VDD VSS MUX2_X1
X_11309_ _05800_ _05801_ _05151_ _05802_ VDD VSS MUX2_X2
X_11310_ _05796_ _05799_ _05802_ _05803_ VDD VSS NOR3_X2
X_11311_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[28\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[28\]
+ net738 _05804_ VDD VSS MUX2_X1
X_11312_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[28\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[28\]
+ net738 _05805_ VDD VSS MUX2_X1
X_11313_ _05804_ _05805_ _05151_ _05806_ VDD VSS MUX2_X2
X_11314_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[27\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[27\]
+ _05143_ _05807_ VDD VSS MUX2_X1
X_11315_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[27\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[27\]
+ _05143_ _05808_ VDD VSS MUX2_X1
X_11316_ _05807_ _05808_ _05151_ _05809_ VDD VSS MUX2_X2
X_11317_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[29\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[29\]
+ net740 _05810_ VDD VSS MUX2_X1
X_11318_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[29\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[29\]
+ net740 _05811_ VDD VSS MUX2_X1
X_11319_ _05810_ _05811_ _05151_ _05812_ VDD VSS MUX2_X2
X_11320_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[22\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[22\]
+ net740 _05813_ VDD VSS MUX2_X1
X_11321_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[22\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[22\]
+ net740 _05814_ VDD VSS MUX2_X1
X_11322_ _05813_ _05814_ _05151_ _05815_ VDD VSS MUX2_X2
X_11323_ _05806_ _05809_ _05812_ _05815_ _05816_ VDD VSS NOR4_X1
X_11324_ _05793_ _05803_ _05816_ _05817_ VDD VSS AND3_X1
X_11325_ net630 _05818_ VDD VSS BUF_X2
X_11326_ dynamic_node_top.west_input.control.tail_last_f dynamic_node_top.west_input.control.count_one_f
+ _05818_ _05819_ VDD VSS MUX2_X1
X_11327_ _05817_ _05819_ _05820_ VDD VSS OR2_X2
X_11328_ dynamic_node_top.north_output.control.current_route_f\[3\]
+ _05821_ VDD VSS CLKBUF_X3
X_11329_ _05757_ _05789_ _05820_ _05821_ _05822_ VDD VSS AOI22_X2
X_11330_ dynamic_node_top.north_output.control.current_route_f\[2\]
+ _05823_ VDD VSS BUF_X4
X_11331_ _05753_ _05757_ _05823_ _05821_ _05824_ VDD VSS NOR4_X4
X_11332_ net627 _05825_ VDD VSS BUF_X2
X_11333_ dynamic_node_top.north_input.control.tail_last_f
+ dynamic_node_top.north_input.control.count_one_f _05825_ _05826_
+ VDD VSS MUX2_X1
X_11334_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[25\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[25\]
+ _05362_ _05827_ VDD VSS MUX2_X1
X_11335_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[25\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[25\]
+ _05362_ _05828_ VDD VSS MUX2_X1
X_11336_ _05827_ _05828_ _05319_ _05829_ VDD VSS MUX2_X2
X_11337_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[26\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[26\]
+ net726 _05830_ VDD VSS MUX2_X1
X_11338_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[26\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[26\]
+ _05362_ _05831_ VDD VSS MUX2_X1
X_11339_ _05830_ _05831_ _05319_ _05832_ VDD VSS MUX2_X2
X_11340_ _05346_ _05829_ _05832_ _05833_ VDD VSS NOR3_X1
X_11341_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[27\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[27\]
+ net726 _05834_ VDD VSS MUX2_X1
X_11342_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[27\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[27\]
+ net726 _05835_ VDD VSS MUX2_X1
X_11343_ _05834_ _05835_ _05320_ _05836_ VDD VSS MUX2_X2
X_11344_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[24\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[24\]
+ _05362_ _05837_ VDD VSS MUX2_X1
X_11345_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[24\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[24\]
+ net726 _05838_ VDD VSS MUX2_X1
X_11346_ _05837_ _05838_ _05319_ _05839_ VDD VSS MUX2_X2
X_11347_ _05836_ _05839_ _05840_ VDD VSS NOR2_X1
X_11348_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[28\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[28\]
+ _05362_ _05841_ VDD VSS MUX2_X1
X_11349_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[28\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[28\]
+ _05362_ _05842_ VDD VSS MUX2_X1
X_11350_ _05841_ _05842_ _05319_ _05843_ VDD VSS MUX2_X2
X_11351_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[22\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[22\]
+ _05362_ _05844_ VDD VSS MUX2_X1
X_11352_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[22\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[22\]
+ _05362_ _05845_ VDD VSS MUX2_X1
X_11353_ _05844_ _05845_ _05319_ _05846_ VDD VSS MUX2_X1
X_11354_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[23\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[23\]
+ net726 _05847_ VDD VSS MUX2_X1
X_11355_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[23\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[23\]
+ net726 _05848_ VDD VSS MUX2_X1
X_11356_ _05847_ _05848_ _05319_ _05849_ VDD VSS MUX2_X2
X_11357_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[29\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[29\]
+ net726 _05850_ VDD VSS MUX2_X1
X_11358_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[29\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[29\]
+ _05362_ _05851_ VDD VSS MUX2_X1
X_11359_ _05850_ _05851_ _05319_ _05852_ VDD VSS MUX2_X1
X_11360_ _05843_ _05846_ _05849_ _05852_ _05853_ VDD VSS NOR4_X1
X_11361_ _05833_ _05840_ _05853_ _05854_ VDD VSS AND3_X1
X_11362_ _05826_ _05854_ _05855_ VDD VSS OR2_X1
X_11363_ _05824_ _05855_ _05753_ _05856_ VDD VSS AOI21_X1
X_11364_ _05823_ _05857_ VDD VSS INV_X1
X_11365_ net628 _05858_ VDD VSS CLKBUF_X3
X_11366_ dynamic_node_top.proc_input.control.tail_last_f _05859_
+ VDD VSS INV_X1
X_11367_ _05858_ _05859_ _05860_ VDD VSS NOR2_X1
X_11368_ _05717_ _05861_ VDD VSS BUF_X4
X_11369_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[25\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[25\]
+ _05861_ _05862_ VDD VSS MUX2_X1
X_11370_ _05735_ _05862_ _05863_ VDD VSS NOR2_X1
X_11371_ _05732_ _05864_ VDD VSS INV_X2
X_11372_ _05864_ _05865_ VDD VSS BUF_X4
X_11373_ _05716_ _05866_ VDD VSS BUF_X8
X_11374_ _05866_ _05867_ VDD VSS BUF_X4
X_11375_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[25\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[25\]
+ _05867_ _05868_ VDD VSS MUX2_X1
X_11376_ _05865_ _05868_ _05869_ VDD VSS NOR2_X1
X_11377_ net760 _05870_ VDD VSS BUF_X4
X_11378_ _05707_ _05870_ _05871_ VDD VSS OR2_X2
X_11379_ _05871_ _05872_ VDD VSS BUF_X4
X_11380_ _00009_ _05873_ VDD VSS INV_X2
X_11381_ _05873_ _05874_ VDD VSS BUF_X4
X_11382_ _05874_ _05700_ _05875_ VDD VSS NAND2_X2
X_11383_ _05716_ _05876_ VDD VSS BUF_X8
X_11384_ _05876_ _05877_ VDD VSS BUF_X4
X_11385_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[25\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[25\]
+ _05877_ _05878_ VDD VSS MUX2_X1
X_11386_ _05734_ _05878_ _05879_ VDD VSS NOR2_X1
X_11387_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[25\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[25\]
+ _05877_ _05880_ VDD VSS MUX2_X1
X_11388_ _05865_ _05880_ _05881_ VDD VSS NOR2_X1
X_11389_ _05863_ _05869_ _05872_ _05875_ _05879_ _05881_ _05882_
+ VDD VSS OAI33_X1
X_11390_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[25\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[25\]
+ _05861_ _05883_ VDD VSS MUX2_X1
X_11391_ _05735_ _05883_ _05884_ VDD VSS NOR2_X1
X_11392_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[25\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[25\]
+ _05867_ _05885_ VDD VSS MUX2_X1
X_11393_ _05865_ _05885_ _05886_ VDD VSS NOR2_X1
X_11394_ _05707_ _05887_ VDD VSS BUF_X4
X_11395_ _05887_ _05888_ VDD VSS BUF_X4
X_11396_ _05870_ _05889_ VDD VSS INV_X4
X_11397_ _05889_ _05890_ VDD VSS BUF_X4
X_11398_ _05888_ _05890_ _05891_ VDD VSS NAND2_X1
X_11399_ _05699_ _05892_ VDD VSS BUF_X4
X_11400_ _05707_ _05892_ _05893_ VDD VSS NAND2_X1
X_11401_ _05893_ _05894_ VDD VSS BUF_X4
X_11402_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[25\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[25\]
+ _05877_ _05895_ VDD VSS MUX2_X1
X_11403_ _05734_ _05895_ _05896_ VDD VSS NOR2_X1
X_11404_ _05716_ _05897_ VDD VSS BUF_X4
X_11405_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[25\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[25\]
+ _05897_ _05898_ VDD VSS MUX2_X1
X_11406_ _05865_ _05898_ _05899_ VDD VSS NOR2_X1
X_11407_ _05884_ _05886_ _05891_ _05894_ _05896_ _05899_ _05900_
+ VDD VSS OAI33_X1
X_11408_ _05882_ _05900_ _05901_ VDD VSS OR2_X2
X_11409_ _05901_ _05902_ VDD VSS CLKBUF_X3
X_11410_ _05870_ _05903_ VDD VSS BUF_X4
X_11411_ _05732_ _05904_ VDD VSS BUF_X4
X_11412_ _05903_ _05904_ _05905_ VDD VSS OR2_X2
X_11413_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[26\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[26\]
+ _05861_ _05906_ VDD VSS MUX2_X1
X_11414_ _05905_ _05906_ _05907_ VDD VSS NOR2_X1
X_11415_ _05892_ _05908_ VDD VSS BUF_X4
X_11416_ _05908_ _05909_ VDD VSS BUF_X4
X_11417_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[26\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[26\]
+ _05877_ _05910_ VDD VSS MUX2_X1
X_11418_ _05909_ _05865_ _05910_ _05911_ VDD VSS NOR3_X1
X_11419_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[26\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[26\]
+ _05897_ _05912_ VDD VSS MUX2_X1
X_11420_ _05890_ _05734_ _05912_ _05913_ VDD VSS NOR3_X1
X_11421_ _05732_ _05914_ VDD VSS BUF_X4
X_11422_ _05903_ _05914_ _05915_ VDD VSS NAND2_X2
X_11423_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[26\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[26\]
+ _05877_ _05916_ VDD VSS MUX2_X1
X_11424_ _05915_ _05916_ _05917_ VDD VSS NOR2_X1
X_11425_ _05907_ _05911_ _05913_ _05917_ _05918_ VDD VSS OR4_X4
X_11426_ dynamic_node_top.proc_input.control.header_last_temp
+ _05181_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[1\]
+ _05919_ VDD VSS OAI21_X4
X_11427_ _05709_ _05919_ _05920_ VDD VSS NOR2_X2
X_11428_ _05873_ _05921_ VDD VSS BUF_X4
X_11429_ _05921_ _05922_ VDD VSS BUF_X4
X_11430_ _05922_ _05919_ _05923_ VDD VSS NOR2_X1
X_11431_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[26\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[26\]
+ _05867_ _05924_ VDD VSS MUX2_X1
X_11432_ _05924_ _05905_ _05925_ VDD VSS NOR2_X1
X_11433_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[26\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[26\]
+ _05897_ _05926_ VDD VSS MUX2_X1
X_11434_ _05700_ _05864_ _05926_ _05927_ VDD VSS NOR3_X1
X_11435_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[26\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[26\]
+ _05717_ _05928_ VDD VSS MUX2_X1
X_11436_ _05889_ _05734_ _05928_ _05929_ VDD VSS NOR3_X1
X_11437_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[26\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[26\]
+ _05897_ _05930_ VDD VSS MUX2_X1
X_11438_ _05930_ _05915_ _05931_ VDD VSS NOR2_X1
X_11439_ _05925_ _05927_ _05929_ _05931_ _05932_ VDD VSS OR4_X4
X_11440_ _05918_ _05920_ _05923_ _05932_ _05933_ VDD VSS AOI22_X4
X_11441_ _05702_ _05719_ _05934_ VDD VSS NOR2_X4
X_11442_ _05732_ _05935_ VDD VSS BUF_X4
X_11443_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[24\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[24\]
+ _05935_ _05936_ VDD VSS MUX2_X1
X_11444_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[24\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[24\]
+ _05935_ _05937_ VDD VSS MUX2_X1
X_11445_ _05887_ _05938_ VDD VSS BUF_X4
X_11446_ _05936_ _05937_ _05938_ _05939_ VDD VSS MUX2_X1
X_11447_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[24\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[24\]
+ _05904_ _05940_ VDD VSS MUX2_X1
X_11448_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[24\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[24\]
+ _05914_ _05941_ VDD VSS MUX2_X1
X_11449_ _05940_ _05941_ _05888_ _05942_ VDD VSS MUX2_X1
X_11450_ _05877_ _05943_ VDD VSS BUF_X4
X_11451_ _05702_ _05943_ _05944_ VDD VSS NOR2_X4
X_11452_ _05934_ _05939_ _05942_ _05944_ _05945_ VDD VSS AOI22_X2
X_11453_ _05889_ _05946_ VDD VSS BUF_X4
X_11454_ _05946_ _05719_ _05947_ VDD VSS NOR2_X4
X_11455_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[24\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[24\]
+ _05914_ _05948_ VDD VSS MUX2_X1
X_11456_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[24\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[24\]
+ _05914_ _05949_ VDD VSS MUX2_X1
X_11457_ _05948_ _05949_ _05938_ _05950_ VDD VSS MUX2_X1
X_11458_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[24\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[24\]
+ _05904_ _05951_ VDD VSS MUX2_X1
X_11459_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[24\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[24\]
+ _05904_ _05952_ VDD VSS MUX2_X1
X_11460_ _05951_ _05952_ _05888_ _05953_ VDD VSS MUX2_X1
X_11461_ _05946_ _05943_ _05954_ VDD VSS NOR2_X4
X_11462_ _05947_ _05950_ _05953_ _05954_ _05955_ VDD VSS AOI22_X2
X_11463_ _05945_ _05955_ _05956_ VDD VSS NAND2_X4
X_11464_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[27\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[27\]
+ _05935_ _05957_ VDD VSS MUX2_X1
X_11465_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[27\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[27\]
+ _05935_ _05958_ VDD VSS MUX2_X1
X_11466_ _05957_ _05958_ _05938_ _05959_ VDD VSS MUX2_X1
X_11467_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[27\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[27\]
+ _05904_ _05960_ VDD VSS MUX2_X1
X_11468_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[27\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[27\]
+ _05904_ _05961_ VDD VSS MUX2_X1
X_11469_ _05960_ _05961_ _05888_ _05962_ VDD VSS MUX2_X1
X_11470_ _05934_ _05959_ _05962_ _05944_ _05963_ VDD VSS AOI22_X2
X_11471_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[27\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[27\]
+ _05914_ _05964_ VDD VSS MUX2_X1
X_11472_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[27\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[27\]
+ _05914_ _05965_ VDD VSS MUX2_X1
X_11473_ _05964_ _05965_ _05888_ _05966_ VDD VSS MUX2_X1
X_11474_ _05732_ _05967_ VDD VSS BUF_X4
X_11475_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[27\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[27\]
+ _05967_ _05968_ VDD VSS MUX2_X1
X_11476_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[27\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[27\]
+ _05967_ _05969_ VDD VSS MUX2_X1
X_11477_ _05968_ _05969_ _05888_ _05970_ VDD VSS MUX2_X1
X_11478_ _05947_ _05966_ _05970_ _05954_ _05971_ VDD VSS AOI22_X2
X_11479_ _05963_ _05971_ _05972_ VDD VSS NAND2_X4
X_11480_ _05902_ _05933_ _05956_ _05972_ _05973_ VDD VSS NOR4_X2
X_11481_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[29\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[29\]
+ _05700_ _05974_ VDD VSS MUX2_X1
X_11482_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[29\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[29\]
+ _05700_ _05975_ VDD VSS MUX2_X1
X_11483_ _05974_ _05975_ _05708_ _05976_ VDD VSS MUX2_X2
X_11484_ _05864_ _05977_ VDD VSS BUF_X4
X_11485_ _05977_ _05718_ _05978_ VDD VSS NAND2_X1
X_11486_ _05734_ _05718_ _05979_ VDD VSS NAND2_X2
X_11487_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[29\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[29\]
+ _05892_ _05980_ VDD VSS MUX2_X1
X_11488_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[29\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[29\]
+ _05892_ _05981_ VDD VSS MUX2_X1
X_11489_ _05980_ _05981_ _05708_ _05982_ VDD VSS MUX2_X2
X_11490_ _05976_ _05978_ _05979_ _05982_ _05983_ VDD VSS OAI22_X4
X_11491_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[29\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[29\]
+ _05733_ _05984_ VDD VSS MUX2_X1
X_11492_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[29\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[29\]
+ _05733_ _05985_ VDD VSS MUX2_X1
X_11493_ _05984_ _05985_ _05708_ _05986_ VDD VSS MUX2_X1
X_11494_ _05946_ _05943_ _05987_ VDD VSS NAND2_X1
X_11495_ _05909_ _05943_ _05988_ VDD VSS NAND2_X1
X_11496_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[29\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[29\]
+ _05732_ _05989_ VDD VSS MUX2_X1
X_11497_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[29\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[29\]
+ _05732_ _05990_ VDD VSS MUX2_X1
X_11498_ _05989_ _05990_ _05887_ _05991_ VDD VSS MUX2_X1
X_11499_ _05986_ _05987_ _05988_ _05991_ _05992_ VDD VSS OAI22_X4
X_11500_ _05983_ _05992_ _05993_ VDD VSS NOR2_X4
X_11501_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[28\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[28\]
+ _05935_ _05994_ VDD VSS MUX2_X1
X_11502_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[28\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[28\]
+ _05935_ _05995_ VDD VSS MUX2_X1
X_11503_ _05994_ _05995_ _05938_ _05996_ VDD VSS MUX2_X1
X_11504_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[28\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[28\]
+ _05904_ _05997_ VDD VSS MUX2_X1
X_11505_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[28\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[28\]
+ _05904_ _05998_ VDD VSS MUX2_X1
X_11506_ _05997_ _05998_ _05888_ _05999_ VDD VSS MUX2_X1
X_11507_ _05934_ _05996_ _05999_ _05944_ _06000_ VDD VSS AOI22_X4
X_11508_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[28\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[28\]
+ _05914_ _06001_ VDD VSS MUX2_X1
X_11509_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[28\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[28\]
+ _05914_ _06002_ VDD VSS MUX2_X1
X_11510_ _06001_ _06002_ _05938_ _06003_ VDD VSS MUX2_X1
X_11511_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[28\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[28\]
+ _05904_ _06004_ VDD VSS MUX2_X1
X_11512_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[28\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[28\]
+ _05904_ _06005_ VDD VSS MUX2_X1
X_11513_ _06004_ _06005_ _05888_ _06006_ VDD VSS MUX2_X2
X_11514_ _05947_ _06003_ _06006_ _05954_ _06007_ VDD VSS AOI22_X4
X_11515_ _06000_ _06007_ _06008_ VDD VSS NAND2_X4
X_11516_ _05943_ _06009_ VDD VSS CLKBUF_X3
X_11517_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[23\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[23\]
+ _05935_ _06010_ VDD VSS MUX2_X1
X_11518_ _05872_ _06010_ _06011_ VDD VSS NOR2_X1
X_11519_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[23\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[23\]
+ _05733_ _06012_ VDD VSS MUX2_X1
X_11520_ _05938_ _05890_ _06012_ _06013_ VDD VSS NOR3_X2
X_11521_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[23\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[23\]
+ _05733_ _06014_ VDD VSS MUX2_X1
X_11522_ _05874_ _05700_ _06014_ _06015_ VDD VSS NOR3_X2
X_11523_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[23\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[23\]
+ _05967_ _06016_ VDD VSS MUX2_X1
X_11524_ _05894_ _06016_ _06017_ VDD VSS NOR2_X1
X_11525_ _06011_ _06013_ _06015_ _06017_ _06018_ VDD VSS NOR4_X4
X_11526_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[22\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[22\]
+ _05935_ _06019_ VDD VSS MUX2_X1
X_11527_ _05872_ _06019_ _06020_ VDD VSS NOR2_X1
X_11528_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[22\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[22\]
+ _05733_ _06021_ VDD VSS MUX2_X1
X_11529_ _05888_ _05890_ _06021_ _06022_ VDD VSS NOR3_X2
X_11530_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[22\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[22\]
+ _05732_ _06023_ VDD VSS MUX2_X1
X_11531_ _05874_ _05700_ _06023_ _06024_ VDD VSS NOR3_X2
X_11532_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[22\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[22\]
+ _05733_ _06025_ VDD VSS MUX2_X1
X_11533_ _05894_ _06025_ _06026_ VDD VSS NOR2_X1
X_11534_ _06020_ _06022_ _06024_ _06026_ _06027_ VDD VSS NOR4_X4
X_11535_ _06009_ _06018_ _06027_ _06028_ VDD VSS OR3_X1
X_11536_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[23\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[23\]
+ _05734_ _06029_ VDD VSS MUX2_X1
X_11537_ _05872_ _06029_ _06030_ VDD VSS NOR2_X1
X_11538_ _05887_ _06031_ VDD VSS BUF_X4
X_11539_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[23\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[23\]
+ _05967_ _06032_ VDD VSS MUX2_X1
X_11540_ _06031_ _05946_ _06032_ _06033_ VDD VSS NOR3_X1
X_11541_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[23\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[23\]
+ _05733_ _06034_ VDD VSS MUX2_X1
X_11542_ _05922_ _05909_ _06034_ _06035_ VDD VSS NOR3_X1
X_11543_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[23\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[23\]
+ _05967_ _06036_ VDD VSS MUX2_X1
X_11544_ _05894_ _06036_ _06037_ VDD VSS NOR2_X1
X_11545_ _06030_ _06033_ _06035_ _06037_ _06038_ VDD VSS OR4_X4
X_11546_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[22\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[22\]
+ _05734_ _06039_ VDD VSS MUX2_X1
X_11547_ _05872_ _06039_ _06040_ VDD VSS NOR2_X1
X_11548_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[22\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[22\]
+ _05967_ _06041_ VDD VSS MUX2_X1
X_11549_ _06031_ _05890_ _06041_ _06042_ VDD VSS NOR3_X1
X_11550_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[22\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[22\]
+ _05733_ _06043_ VDD VSS MUX2_X1
X_11551_ _05922_ _05909_ _06043_ _06044_ VDD VSS NOR3_X1
X_11552_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[22\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[22\]
+ _05967_ _06045_ VDD VSS MUX2_X1
X_11553_ _05894_ _06045_ _06046_ VDD VSS NOR2_X1
X_11554_ _06040_ _06042_ _06044_ _06046_ _06047_ VDD VSS OR4_X4
X_11555_ _06009_ _06038_ _06047_ _06048_ VDD VSS NAND3_X1
X_11556_ _05993_ _06008_ _06028_ _06048_ _06049_ VDD VSS AOI211_X2
X_11557_ _05860_ _05973_ _06049_ _05858_ dynamic_node_top.proc_input.control.count_one_f
+ _06050_ VDD VSS AOI221_X2
X_11558_ _05822_ _05856_ _05857_ _06050_ _06051_ VDD VSS OAI211_X2
X_11559_ net629 _06052_ VDD VSS BUF_X2
X_11560_ dynamic_node_top.south_input.control.tail_last_f
+ dynamic_node_top.south_input.control.count_one_f _06052_ _06053_
+ VDD VSS MUX2_X1
X_11561_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[26\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[26\]
+ net746 _06054_ VDD VSS MUX2_X1
X_11562_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[26\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[26\]
+ net746 _06055_ VDD VSS MUX2_X1
X_11563_ _06054_ _06055_ _05126_ _06056_ VDD VSS MUX2_X2
X_11564_ _05618_ _06056_ _06057_ VDD VSS OR2_X1
X_11565_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[23\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[23\]
+ net746 _06058_ VDD VSS MUX2_X1
X_11566_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[23\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[23\]
+ net746 _06059_ VDD VSS MUX2_X1
X_11567_ _06058_ _06059_ _05126_ _06060_ VDD VSS MUX2_X2
X_11568_ net746 _06061_ VDD VSS BUF_X8
X_11569_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[24\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[24\]
+ _06061_ _06062_ VDD VSS MUX2_X1
X_11570_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[24\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[24\]
+ _06061_ _06063_ VDD VSS MUX2_X1
X_11571_ _06062_ _06063_ _05126_ _06064_ VDD VSS MUX2_X2
X_11572_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[25\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[25\]
+ _06061_ _06065_ VDD VSS MUX2_X1
X_11573_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[25\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[25\]
+ _06061_ _06066_ VDD VSS MUX2_X1
X_11574_ _06065_ _06066_ _05124_ _06067_ VDD VSS MUX2_X2
X_11575_ _06060_ _06064_ _06067_ _06068_ VDD VSS OR3_X1
X_11576_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[29\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[29\]
+ _06061_ _06069_ VDD VSS MUX2_X1
X_11577_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[29\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[29\]
+ _06061_ _06070_ VDD VSS MUX2_X1
X_11578_ _06069_ _06070_ _05124_ _06071_ VDD VSS MUX2_X2
X_11579_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[27\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[27\]
+ _06061_ _06072_ VDD VSS MUX2_X1
X_11580_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[27\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[27\]
+ _06061_ _06073_ VDD VSS MUX2_X1
X_11581_ _06072_ _06073_ _05124_ _06074_ VDD VSS MUX2_X2
X_11582_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[28\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[28\]
+ _06061_ _06075_ VDD VSS MUX2_X1
X_11583_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[28\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[28\]
+ _06061_ _06076_ VDD VSS MUX2_X1
X_11584_ _06075_ _06076_ _05124_ _06077_ VDD VSS MUX2_X2
X_11585_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[22\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[22\]
+ net746 _06078_ VDD VSS MUX2_X1
X_11586_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[22\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[22\]
+ net746 _06079_ VDD VSS MUX2_X1
X_11587_ _06078_ _06079_ _05124_ _06080_ VDD VSS MUX2_X2
X_11588_ _06071_ _06074_ _06077_ _06080_ _06081_ VDD VSS OR4_X2
X_11589_ _06057_ _06068_ _06081_ _06082_ VDD VSS NOR3_X2
X_11590_ _06053_ _06082_ _06083_ VDD VSS NOR2_X2
X_11591_ _05824_ _06083_ _06084_ VDD VSS NAND2_X1
X_11592_ _00042_ _06085_ VDD VSS BUF_X4
X_11593_ _06085_ _05824_ _06086_ VDD VSS AND2_X2
X_11594_ dynamic_node_top.north_output.space.is_one_f _06087_
+ VDD VSS INV_X1
X_11595_ _06087_ dynamic_node_top.north_output.space.valid_f
+ _06088_ VDD VSS NOR2_X1
X_11596_ dynamic_node_top.north_output.space.is_two_or_more_f
+ dynamic_node_top.north_output.space.yummy_f _06088_ _06089_
+ VDD VSS NOR3_X1
X_11597_ dynamic_node_top.north_output.control.current_route_f\[0\]
+ _06090_ VDD VSS CLKBUF_X2
X_11598_ _05753_ _05168_ _05170_ _06090_ _06091_ VDD VSS AOI22_X1
X_11599_ _05821_ _05175_ _05177_ _05757_ _06092_ VDD VSS AOI22_X1
X_11600_ _06091_ _06092_ _06093_ VDD VSS NAND2_X1
X_11601_ _06093_ _05182_ _05823_ _06094_ VDD VSS AOI21_X1
X_11602_ _06086_ _06089_ _06094_ _06095_ VDD VSS OR3_X2
X_11603_ _05618_ _06096_ VDD VSS CLKBUF_X3
X_11604_ _05382_ _06096_ _06097_ VDD VSS NOR2_X1
X_11605_ _05613_ _06098_ VDD VSS INV_X2
X_11606_ _05616_ _06099_ VDD VSS INV_X2
X_11607_ _05621_ _06100_ VDD VSS CLKBUF_X3
X_11608_ _06098_ _06099_ _06100_ _06101_ VDD VSS NOR3_X1
X_11609_ _06097_ _06101_ _05383_ _06102_ VDD VSS OAI21_X1
X_11610_ dynamic_node_top.south_input.control.header_last_temp
+ _05170_ _06103_ VDD VSS AND2_X2
X_11611_ _06103_ _05630_ _06104_ VDD VSS AND2_X4
X_11612_ _05625_ _05626_ _06105_ VDD VSS OR2_X4
X_11613_ _10204_ _10207_ net657 _06106_ VDD VSS AOI21_X1
X_11614_ _06105_ _06106_ _06107_ VDD VSS NAND2_X4
X_11615_ _10213_ _10210_ _10216_ _06108_ VDD VSS NOR3_X1
X_11616_ _10217_ _10220_ _10219_ _06109_ VDD VSS OAI21_X1
X_11617_ _10219_ _10222_ _06110_ VDD VSS OR2_X1
X_11618_ _10226_ _06111_ VDD VSS INV_X1
X_11619_ _06110_ _06111_ _10223_ _06112_ VDD VSS AOI21_X1
X_11620_ _06108_ _06109_ _06112_ _06113_ VDD VSS OAI21_X2
X_11621_ _10208_ _10205_ _06114_ VDD VSS NAND2_X1
X_11622_ _10211_ _10214_ _10213_ _06115_ VDD VSS OAI21_X1
X_11623_ _10210_ _06116_ VDD VSS INV_X1
X_11624_ _06114_ _06115_ _06116_ _06117_ VDD VSS AOI21_X2
X_11625_ _06113_ _06117_ _06118_ VDD VSS AND2_X2
X_11626_ _06104_ _06107_ _06118_ _06105_ _06101_ _06119_ VDD
+ VSS OAI221_X2
X_11627_ _06102_ _06119_ net747 _06120_ VDD VSS MUX2_X2
Xrebuffer37 _10302_ net691 VDD VSS BUF_X1
X_11629_ _00043_ _06122_ VDD VSS BUF_X2
X_11630_ _06095_ _06120_ _06122_ net622 VDD VSS AOI21_X4
X_11631_ _06051_ _06084_ net622 _06123_ VDD VSS NAND3_X1
X_11632_ dynamic_node_top.north_output.control.planned_f _06124_
+ VDD VSS CLKBUF_X2
X_11633_ _06124_ net622 _06125_ VDD VSS OR2_X1
X_11634_ _06123_ _06125_ _06126_ VDD VSS AND2_X1
X_11635_ _06126_ _06127_ VDD VSS BUF_X2
X_11636_ _05754_ _05756_ _06127_ _06128_ VDD VSS NAND3_X1
X_11637_ _05699_ _06129_ VDD VSS BUF_X4
X_11638_ _06129_ _06130_ VDD VSS CLKBUF_X3
X_11639_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[31\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[31\]
+ _06130_ _06131_ VDD VSS MUX2_X1
X_11640_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[31\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[31\]
+ _06130_ _06132_ VDD VSS MUX2_X1
X_11641_ _06131_ _06132_ _05709_ _06133_ VDD VSS MUX2_X1
X_11642_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[31\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[31\]
+ _06130_ _06134_ VDD VSS MUX2_X1
X_11643_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[31\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[31\]
+ _06130_ _06135_ VDD VSS MUX2_X1
X_11644_ _06134_ _06135_ _05709_ _06136_ VDD VSS MUX2_X1
X_11645_ _06133_ _06136_ _05719_ _06137_ VDD VSS MUX2_X1
X_11646_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[31\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[31\]
+ _06130_ _06138_ VDD VSS MUX2_X1
X_11647_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[31\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[31\]
+ _06130_ _06139_ VDD VSS MUX2_X1
X_11648_ _06138_ _06139_ _05709_ _06140_ VDD VSS MUX2_X1
X_11649_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[31\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[31\]
+ _05700_ _06141_ VDD VSS MUX2_X1
X_11650_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[31\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[31\]
+ _05700_ _06142_ VDD VSS MUX2_X1
X_11651_ _06141_ _06142_ _05709_ _06143_ VDD VSS MUX2_X1
X_11652_ _06140_ _06143_ _05720_ _06144_ VDD VSS MUX2_X1
X_11653_ _06137_ _06144_ _05736_ _06145_ VDD VSS MUX2_X1
X_11654_ _06145_ _06146_ VDD VSS CLKBUF_X3
X_11655_ _05919_ _06146_ _06147_ VDD VSS OR2_X1
X_11656_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[32\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[32\]
+ _05903_ _06148_ VDD VSS MUX2_X1
X_11657_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[32\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[32\]
+ _05903_ _06149_ VDD VSS MUX2_X1
X_11658_ _06148_ _06149_ _05938_ _06150_ VDD VSS MUX2_X1
X_11659_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[32\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[32\]
+ _05903_ _06151_ VDD VSS MUX2_X1
X_11660_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[32\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[32\]
+ _05903_ _06152_ VDD VSS MUX2_X1
X_11661_ _06151_ _06152_ _05938_ _06153_ VDD VSS MUX2_X1
X_11662_ _06150_ _06153_ _05719_ _06154_ VDD VSS MUX2_X1
X_11663_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[32\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[32\]
+ _05903_ _06155_ VDD VSS MUX2_X1
X_11664_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[32\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[32\]
+ _05908_ _06156_ VDD VSS MUX2_X1
X_11665_ _06155_ _06156_ _05938_ _06157_ VDD VSS MUX2_X1
X_11666_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[32\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[32\]
+ _05908_ _06158_ VDD VSS MUX2_X1
X_11667_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[32\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[32\]
+ _05908_ _06159_ VDD VSS MUX2_X1
X_11668_ _06158_ _06159_ _06031_ _06160_ VDD VSS MUX2_X1
X_11669_ _06157_ _06160_ _05719_ _06161_ VDD VSS MUX2_X1
X_11670_ _06154_ _06161_ _05736_ _06162_ VDD VSS MUX2_X2
X_11671_ _06162_ _06163_ VDD VSS BUF_X4
X_11672_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[30\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[30\]
+ _05908_ _06164_ VDD VSS MUX2_X1
X_11673_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[30\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[30\]
+ _05908_ _06165_ VDD VSS MUX2_X1
X_11674_ _06164_ _06165_ _06031_ _06166_ VDD VSS MUX2_X1
X_11675_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[30\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[30\]
+ _05908_ _06167_ VDD VSS MUX2_X1
X_11676_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[30\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[30\]
+ _06130_ _06168_ VDD VSS MUX2_X1
X_11677_ _06167_ _06168_ _06031_ _06169_ VDD VSS MUX2_X1
X_11678_ _06166_ _06169_ _05719_ _06170_ VDD VSS MUX2_X1
X_11679_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[30\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[30\]
+ _05908_ _06171_ VDD VSS MUX2_X1
X_11680_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[30\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[30\]
+ _06130_ _06172_ VDD VSS MUX2_X1
X_11681_ _06171_ _06172_ _06031_ _06173_ VDD VSS MUX2_X1
X_11682_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[30\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[30\]
+ _06130_ _06174_ VDD VSS MUX2_X1
X_11683_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[30\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[30\]
+ _06130_ _06175_ VDD VSS MUX2_X1
X_11684_ _06174_ _06175_ _06031_ _06176_ VDD VSS MUX2_X1
X_11685_ _06173_ _06176_ _05719_ _06177_ VDD VSS MUX2_X1
X_11686_ _06170_ _06177_ _05736_ _06178_ VDD VSS MUX2_X2
X_11687_ _06178_ _06179_ VDD VSS BUF_X4
X_11688_ _06163_ _06179_ _06180_ VDD VSS NAND2_X1
X_11689_ _05383_ _06147_ _06180_ _06181_ VDD VSS OR3_X1
X_11690_ dynamic_node_top.proc_input.control.header_last_temp
+ _05182_ _06182_ VDD VSS AND2_X1
X_11691_ _06182_ _06183_ VDD VSS CLKBUF_X3
X_11692_ _05383_ _06183_ _06184_ VDD VSS NAND2_X1
X_11693_ _05382_ _06181_ _06184_ _06185_ VDD VSS AOI21_X1
X_11694_ _10386_ _10395_ _10392_ _10389_ _06186_ VDD VSS NAND4_X2
X_11695_ _10380_ _10374_ _10377_ _10383_ _06187_ VDD VSS NAND4_X1
X_11696_ _06186_ _06187_ _06188_ VDD VSS OR2_X1
X_11697_ _10398_ _10401_ _10404_ _10407_ _06189_ VDD VSS NAND4_X2
X_11698_ _10410_ _10413_ _10416_ _10419_ _06190_ VDD VSS NAND4_X1
X_11699_ _06189_ _06190_ _06191_ VDD VSS OR2_X2
X_11700_ _06147_ _06180_ _06191_ _06192_ VDD VSS OR3_X1
X_11701_ _10400_ _06193_ VDD VSS INV_X1
X_11702_ _10403_ _10404_ _10406_ _06194_ VDD VSS AOI21_X1
X_11703_ _10401_ _06195_ VDD VSS INV_X1
X_11704_ _06193_ _06194_ _06195_ _06196_ VDD VSS OAI21_X1
X_11705_ _10397_ _06196_ _10398_ _06197_ VDD VSS AOI21_X1
X_11706_ _10412_ _06198_ VDD VSS INV_X1
X_11707_ _10418_ _06199_ VDD VSS INV_X1
X_11708_ _10415_ _06199_ _10416_ _06200_ VDD VSS AOI21_X1
X_11709_ _10413_ _06201_ VDD VSS INV_X1
X_11710_ _06198_ _06200_ _06201_ _06202_ VDD VSS OAI21_X1
X_11711_ _10409_ _06202_ _10410_ _06203_ VDD VSS AOI21_X1
X_11712_ _06197_ _06203_ _06189_ _06204_ VDD VSS OAI21_X2
X_11713_ _06182_ _06191_ _06204_ _06205_ VDD VSS NAND3_X1
X_11714_ _06188_ _06192_ _06205_ _06206_ VDD VSS AOI21_X1
X_11715_ _05707_ _05877_ _06207_ VDD VSS NAND2_X4
X_11716_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[63\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[63\]
+ _05935_ _06208_ VDD VSS MUX2_X1
X_11717_ _05909_ _06208_ _06209_ VDD VSS NOR2_X1
X_11718_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[63\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[63\]
+ _05935_ _06210_ VDD VSS MUX2_X1
X_11719_ _05946_ _06210_ _06211_ VDD VSS NOR2_X1
X_11720_ _06031_ _05718_ _06212_ VDD VSS NAND2_X1
X_11721_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[63\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[63\]
+ _05967_ _06213_ VDD VSS MUX2_X1
X_11722_ _05909_ _06213_ _06214_ VDD VSS NOR2_X1
X_11723_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[63\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[63\]
+ _05967_ _06215_ VDD VSS MUX2_X1
X_11724_ _05890_ _06215_ _06216_ VDD VSS NOR2_X1
X_11725_ _06207_ _06209_ _06211_ _06212_ _06214_ _06216_ _06217_
+ VDD VSS OAI33_X1
X_11726_ _05922_ _06009_ _06218_ VDD VSS NAND2_X1
X_11727_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[63\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[63\]
+ _05914_ _06219_ VDD VSS MUX2_X1
X_11728_ _05909_ _06219_ _06220_ VDD VSS NOR2_X1
X_11729_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[63\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[63\]
+ _05914_ _06221_ VDD VSS MUX2_X1
X_11730_ _05946_ _06221_ _06222_ VDD VSS NOR2_X1
X_11731_ _05707_ _05717_ _06223_ VDD VSS OR2_X4
X_11732_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[63\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[63\]
+ _05967_ _06224_ VDD VSS MUX2_X1
X_11733_ _05909_ _06224_ _06225_ VDD VSS NOR2_X1
X_11734_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[63\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[63\]
+ _05733_ _06226_ VDD VSS MUX2_X1
X_11735_ _05890_ _06226_ _06227_ VDD VSS NOR2_X1
X_11736_ _06218_ _06220_ _06222_ _06223_ _06225_ _06227_ _06228_
+ VDD VSS OAI33_X1
X_11737_ _06217_ _06228_ _06229_ VDD VSS NOR2_X4
X_11738_ _05221_ _06229_ _06230_ VDD VSS XOR2_X2
X_11739_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[51\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[51\]
+ _05943_ _06231_ VDD VSS MUX2_X1
X_11740_ _05915_ _06231_ _06232_ VDD VSS NOR2_X1
X_11741_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[51\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[51\]
+ _05867_ _06233_ VDD VSS MUX2_X1
X_11742_ _05946_ _05735_ _06233_ _06234_ VDD VSS NOR3_X1
X_11743_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[51\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[51\]
+ _05867_ _06235_ VDD VSS MUX2_X1
X_11744_ _05909_ _05865_ _06235_ _06236_ VDD VSS NOR3_X1
X_11745_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[51\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[51\]
+ _05861_ _06237_ VDD VSS MUX2_X1
X_11746_ _05905_ _06237_ _06238_ VDD VSS NOR2_X1
X_11747_ _06232_ _06234_ _06236_ _06238_ _06239_ VDD VSS NOR4_X1
X_11748_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[51\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[51\]
+ _05943_ _06240_ VDD VSS MUX2_X1
X_11749_ _05915_ _06240_ _06241_ VDD VSS NOR2_X1
X_11750_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[51\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[51\]
+ _05861_ _06242_ VDD VSS MUX2_X1
X_11751_ _05909_ _05865_ _06242_ _06243_ VDD VSS NOR3_X1
X_11752_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[51\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[51\]
+ _05867_ _06244_ VDD VSS MUX2_X1
X_11753_ _05946_ _05735_ _06244_ _06245_ VDD VSS NOR3_X1
X_11754_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[51\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[51\]
+ _05861_ _06246_ VDD VSS MUX2_X1
X_11755_ _05905_ _06246_ _06247_ VDD VSS NOR2_X1
X_11756_ _06241_ _06243_ _06245_ _06247_ _06248_ VDD VSS NOR4_X1
X_11757_ _06239_ _06248_ _05922_ _06249_ VDD VSS MUX2_X2
X_11758_ _05186_ _06249_ _06250_ VDD VSS XNOR2_X1
X_11759_ _06230_ _06250_ _06251_ VDD VSS NAND2_X1
X_11760_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[60\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[60\]
+ _05735_ _06252_ VDD VSS MUX2_X1
X_11761_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[60\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[60\]
+ _05735_ _06253_ VDD VSS MUX2_X1
X_11762_ _05891_ _06252_ _06253_ _05894_ _06254_ VDD VSS OAI22_X2
X_11763_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[60\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[60\]
+ _05735_ _06255_ VDD VSS MUX2_X1
X_11764_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[60\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[60\]
+ _05735_ _06256_ VDD VSS MUX2_X1
X_11765_ _05872_ _06255_ _06256_ _05875_ _06257_ VDD VSS OAI22_X2
X_11766_ _06254_ _06257_ _06258_ VDD VSS NOR2_X2
X_11767_ _05191_ _06258_ _06259_ VDD VSS XNOR2_X2
X_11768_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[54\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[54\]
+ _05870_ _06260_ VDD VSS MUX2_X1
X_11769_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[54\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[54\]
+ _05870_ _06261_ VDD VSS MUX2_X1
X_11770_ _06207_ _06260_ _06261_ _06223_ _06262_ VDD VSS OAI22_X1
X_11771_ net761 _06263_ VDD VSS BUF_X4
X_11772_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[54\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[54\]
+ _06263_ _06264_ VDD VSS MUX2_X1
X_11773_ _05887_ _05718_ _06264_ _06265_ VDD VSS NOR3_X1
X_11774_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[54\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[54\]
+ _05699_ _06266_ VDD VSS MUX2_X1
X_11775_ _05921_ _05861_ _06266_ _06267_ VDD VSS NOR3_X1
X_11776_ _06262_ _06265_ _06267_ _06268_ VDD VSS OR3_X2
X_11777_ _05736_ _06268_ _05252_ _06269_ VDD VSS OAI21_X1
X_11778_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[50\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[50\]
+ _05870_ _06270_ VDD VSS MUX2_X1
X_11779_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[50\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[50\]
+ _05870_ _06271_ VDD VSS MUX2_X1
X_11780_ _06270_ _06271_ _05707_ _06272_ VDD VSS MUX2_X1
X_11781_ _05247_ _06272_ _06273_ VDD VSS XOR2_X1
X_11782_ _06269_ _06273_ _06009_ _05252_ _06268_ _06274_ VDD
+ VSS AOI221_X2
X_11783_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[52\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[52\]
+ _05867_ _06275_ VDD VSS MUX2_X1
X_11784_ _06031_ _05890_ _06275_ _06276_ VDD VSS NOR3_X2
X_11785_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[52\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[52\]
+ _05867_ _06277_ VDD VSS MUX2_X1
X_11786_ _05872_ _06277_ _06278_ VDD VSS NOR2_X1
X_11787_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[52\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[52\]
+ _05867_ _06279_ VDD VSS MUX2_X1
X_11788_ _05894_ _06279_ _06280_ VDD VSS NOR2_X1
X_11789_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[52\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[52\]
+ _05897_ _06281_ VDD VSS MUX2_X1
X_11790_ _05874_ _05700_ _06281_ _06282_ VDD VSS NOR3_X2
X_11791_ _06276_ _06278_ _06280_ _06282_ _06283_ VDD VSS NOR4_X4
X_11792_ _05257_ _06283_ _06284_ VDD VSS XOR2_X1
X_11793_ _05737_ _06284_ _06285_ VDD VSS NOR2_X1
X_11794_ _05720_ _06259_ _06274_ _06285_ _06286_ VDD VSS OAI22_X4
X_11795_ _05231_ _06287_ VDD VSS INV_X1
X_11796_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[57\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[57\]
+ _06129_ _06288_ VDD VSS MUX2_X1
X_11797_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[57\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[57\]
+ _06129_ _06289_ VDD VSS MUX2_X1
X_11798_ _06288_ _06289_ _05708_ _06290_ VDD VSS MUX2_X1
X_11799_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[57\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[57\]
+ _06129_ _06291_ VDD VSS MUX2_X1
X_11800_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[57\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[57\]
+ _06129_ _06292_ VDD VSS MUX2_X1
X_11801_ _06291_ _06292_ _05708_ _06293_ VDD VSS MUX2_X1
X_11802_ _06290_ _06293_ _05719_ _06294_ VDD VSS MUX2_X1
X_11803_ _06287_ _05736_ _06294_ _06295_ VDD VSS AOI21_X1
X_11804_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[57\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[57\]
+ _05866_ _06296_ VDD VSS MUX2_X1
X_11805_ _05921_ _05908_ _06296_ _06297_ VDD VSS NOR3_X2
X_11806_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[57\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[57\]
+ _05866_ _06298_ VDD VSS MUX2_X1
X_11807_ _05893_ _06298_ _06299_ VDD VSS NOR2_X1
X_11808_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[57\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[57\]
+ _05876_ _06300_ VDD VSS MUX2_X1
X_11809_ _05871_ _06300_ _06301_ VDD VSS NOR2_X1
X_11810_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[57\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[57\]
+ _05716_ _06302_ VDD VSS MUX2_X1
X_11811_ _05707_ _05889_ _06302_ _06303_ VDD VSS NOR3_X2
X_11812_ _06297_ _06299_ _06301_ _06303_ _06304_ VDD VSS NOR4_X4
X_11813_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[60\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[60\]
+ _05699_ _06305_ VDD VSS MUX2_X1
X_11814_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[60\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[60\]
+ _05699_ _06306_ VDD VSS MUX2_X1
X_11815_ _06305_ _06306_ _05707_ _06307_ VDD VSS MUX2_X1
X_11816_ _05191_ _06307_ _06308_ VDD VSS XNOR2_X1
X_11817_ _06304_ _06308_ _06009_ _06309_ VDD VSS OAI21_X1
X_11818_ _06295_ _06309_ _05737_ _06310_ VDD VSS OAI21_X1
X_11819_ _05191_ _06307_ _06311_ VDD VSS XOR2_X1
X_11820_ _05735_ _06304_ _06311_ _05719_ _06312_ VDD VSS AOI211_X2
X_11821_ _06287_ _05977_ _06294_ _06313_ VDD VSS OAI21_X1
X_11822_ _06312_ _06313_ _06314_ VDD VSS OR2_X1
X_11823_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[53\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[53\]
+ _05866_ _06315_ VDD VSS MUX2_X1
X_11824_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[53\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[53\]
+ _05866_ _06316_ VDD VSS MUX2_X1
X_11825_ _06315_ _06316_ _05903_ _06317_ VDD VSS MUX2_X1
X_11826_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[53\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[53\]
+ _05866_ _06318_ VDD VSS MUX2_X1
X_11827_ _05716_ _06319_ VDD VSS BUF_X4
X_11828_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[53\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[53\]
+ _06319_ _06320_ VDD VSS MUX2_X1
X_11829_ _06318_ _06320_ _05903_ _06321_ VDD VSS MUX2_X1
X_11830_ _06317_ _06321_ _05865_ _06322_ VDD VSS MUX2_X1
X_11831_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[53\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[53\]
+ _05876_ _06323_ VDD VSS MUX2_X1
X_11832_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[53\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[53\]
+ _05876_ _06324_ VDD VSS MUX2_X1
X_11833_ _06323_ _06324_ _05700_ _06325_ VDD VSS MUX2_X1
X_11834_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[53\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[53\]
+ _05866_ _06326_ VDD VSS MUX2_X1
X_11835_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[53\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[53\]
+ _05866_ _06327_ VDD VSS MUX2_X1
X_11836_ _06326_ _06327_ _05700_ _06328_ VDD VSS MUX2_X1
X_11837_ _06325_ _06328_ _05865_ _06329_ VDD VSS MUX2_X1
X_11838_ _06322_ _06329_ _05922_ _06330_ VDD VSS MUX2_X2
X_11839_ _05242_ _06330_ _06331_ VDD VSS XNOR2_X1
X_11840_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[56\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[56\]
+ _05717_ _06332_ VDD VSS MUX2_X1
X_11841_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[56\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[56\]
+ _05717_ _06333_ VDD VSS MUX2_X1
X_11842_ _06332_ _06333_ _05889_ _06334_ VDD VSS MUX2_X1
X_11843_ _05708_ _05865_ _06335_ VDD VSS NAND2_X2
X_11844_ _05888_ _05734_ _06336_ VDD VSS NAND2_X1
X_11845_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[56\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[56\]
+ _06319_ _06337_ VDD VSS MUX2_X1
X_11846_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[56\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[56\]
+ _06319_ _06338_ VDD VSS MUX2_X1
X_11847_ _06337_ _06338_ _05889_ _06339_ VDD VSS MUX2_X1
X_11848_ _06334_ _06335_ _06336_ _06339_ _06340_ VDD VSS OAI22_X4
X_11849_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[56\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[56\]
+ _05717_ _06341_ VDD VSS MUX2_X1
X_11850_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[56\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[56\]
+ _05717_ _06342_ VDD VSS MUX2_X1
X_11851_ _06341_ _06342_ _05864_ _06343_ VDD VSS MUX2_X1
X_11852_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[56\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[56\]
+ _06319_ _06344_ VDD VSS MUX2_X1
X_11853_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[56\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[56\]
+ _06319_ _06345_ VDD VSS MUX2_X1
X_11854_ _06344_ _06345_ _05864_ _06346_ VDD VSS MUX2_X1
X_11855_ _05872_ _06343_ _06346_ _05875_ _06347_ VDD VSS OAI22_X4
X_11856_ _05204_ _06340_ _06347_ _06348_ VDD VSS OR3_X1
X_11857_ _05204_ _06340_ _06347_ _06349_ VDD VSS OAI21_X1
X_11858_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[62\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[62\]
+ _06263_ _06350_ VDD VSS MUX2_X1
X_11859_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[62\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[62\]
+ _06263_ _06351_ VDD VSS MUX2_X1
X_11860_ _06350_ _06351_ _05921_ _06352_ VDD VSS MUX2_X1
X_11861_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[62\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[62\]
+ _06263_ _06353_ VDD VSS MUX2_X1
X_11862_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[62\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[62\]
+ _06263_ _06354_ VDD VSS MUX2_X1
X_11863_ _06353_ _06354_ _05873_ _06355_ VDD VSS MUX2_X1
X_11864_ _05734_ _05943_ _06356_ VDD VSS NAND2_X1
X_11865_ _05979_ _06352_ _06355_ _06356_ _06357_ VDD VSS OAI22_X4
X_11866_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[62\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[62\]
+ _06319_ _06358_ VDD VSS MUX2_X1
X_11867_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[62\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[62\]
+ _06319_ _06359_ VDD VSS MUX2_X1
X_11868_ _06358_ _06359_ _05889_ _06360_ VDD VSS MUX2_X1
X_11869_ _05874_ _05864_ _06361_ VDD VSS NAND2_X1
X_11870_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[62\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[62\]
+ _05876_ _06362_ VDD VSS MUX2_X1
X_11871_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[62\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[62\]
+ _05876_ _06363_ VDD VSS MUX2_X1
X_11872_ _06362_ _06363_ _05889_ _06364_ VDD VSS MUX2_X1
X_11873_ _06335_ _06360_ _06361_ _06364_ _06365_ VDD VSS OAI22_X4
X_11874_ _05197_ _06357_ _06365_ _06366_ VDD VSS OR3_X1
X_11875_ _05197_ _06357_ _06365_ _06367_ VDD VSS OAI21_X1
X_11876_ _06348_ _06349_ _06366_ _06367_ _06368_ VDD VSS AND4_X1
X_11877_ _06310_ _06314_ _06331_ _06368_ _06369_ VDD VSS NAND4_X2
X_11878_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[61\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[61\]
+ _05877_ _06370_ VDD VSS MUX2_X1
X_11879_ _05938_ _05890_ _06370_ _06371_ VDD VSS NOR3_X1
X_11880_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[61\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[61\]
+ _05897_ _06372_ VDD VSS MUX2_X1
X_11881_ _05874_ _05700_ _06372_ _06373_ VDD VSS NOR3_X1
X_11882_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[61\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[61\]
+ _05897_ _06374_ VDD VSS MUX2_X1
X_11883_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[61\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[61\]
+ _05897_ _06375_ VDD VSS MUX2_X1
X_11884_ _05872_ _06374_ _06375_ _05894_ _06376_ VDD VSS OAI22_X2
X_11885_ _06371_ _06373_ _06376_ _06377_ VDD VSS NOR3_X2
X_11886_ _05236_ _06377_ _06378_ VDD VSS XOR2_X2
X_11887_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[59\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[59\]
+ _05717_ _06379_ VDD VSS MUX2_X1
X_11888_ _05871_ _06379_ _06380_ VDD VSS NOR2_X1
X_11889_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[59\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[59\]
+ _05866_ _06381_ VDD VSS MUX2_X1
X_11890_ _05887_ _05889_ _06381_ _06382_ VDD VSS NOR3_X2
X_11891_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[59\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[59\]
+ _05876_ _06383_ VDD VSS MUX2_X1
X_11892_ _05921_ _05903_ _06383_ _06384_ VDD VSS NOR3_X2
X_11893_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[59\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[59\]
+ _06319_ _06385_ VDD VSS MUX2_X1
X_11894_ _05893_ _06385_ _06386_ VDD VSS NOR2_X1
X_11895_ _06380_ _06382_ _06384_ _06386_ _06387_ VDD VSS NOR4_X4
X_11896_ _05226_ _06387_ _06388_ VDD VSS XOR2_X2
X_11897_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[55\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[55\]
+ _05892_ _06389_ VDD VSS MUX2_X1
X_11898_ _06223_ _06389_ _06390_ VDD VSS NOR2_X1
X_11899_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[55\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[55\]
+ _06263_ _06391_ VDD VSS MUX2_X1
X_11900_ _05921_ _05861_ _06391_ _06392_ VDD VSS NOR3_X1
X_11901_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[55\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[55\]
+ _05699_ _06393_ VDD VSS MUX2_X1
X_11902_ _05887_ _05718_ _06393_ _06394_ VDD VSS NOR3_X1
X_11903_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[55\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[55\]
+ _06263_ _06395_ VDD VSS MUX2_X1
X_11904_ _06207_ _06395_ _06396_ VDD VSS NOR2_X1
X_11905_ _06390_ _06392_ _06394_ _06396_ _06397_ VDD VSS NOR4_X2
X_11906_ _05209_ _06397_ _06398_ VDD VSS XOR2_X2
X_11907_ _05736_ _06378_ _06388_ _06398_ _06399_ VDD VSS NOR4_X2
X_11908_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[61\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[61\]
+ _05867_ _06400_ VDD VSS MUX2_X1
X_11909_ _06031_ _05890_ _06400_ _06401_ VDD VSS NOR3_X1
X_11910_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[61\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[61\]
+ _05877_ _06402_ VDD VSS MUX2_X1
X_11911_ _05874_ _05700_ _06402_ _06403_ VDD VSS NOR3_X1
X_11912_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[61\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[61\]
+ _05877_ _06404_ VDD VSS MUX2_X1
X_11913_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[61\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[61\]
+ _05897_ _06405_ VDD VSS MUX2_X1
X_11914_ _05872_ _06404_ _06405_ _05894_ _06406_ VDD VSS OAI22_X1
X_11915_ _06401_ _06403_ _06406_ _06407_ VDD VSS NOR3_X1
X_11916_ _05236_ _06407_ _06408_ VDD VSS XOR2_X1
X_11917_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[59\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[59\]
+ _05700_ _06409_ VDD VSS MUX2_X1
X_11918_ _06207_ _06409_ _06410_ VDD VSS NOR2_X1
X_11919_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[59\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[59\]
+ _05870_ _06411_ VDD VSS MUX2_X1
X_11920_ _05708_ _05718_ _06411_ _06412_ VDD VSS NOR3_X1
X_11921_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[59\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[59\]
+ _05870_ _06413_ VDD VSS MUX2_X1
X_11922_ _05921_ _05943_ _06413_ _06414_ VDD VSS NOR3_X1
X_11923_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[59\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[59\]
+ _05892_ _06415_ VDD VSS MUX2_X1
X_11924_ _06223_ _06415_ _06416_ VDD VSS NOR2_X1
X_11925_ _06410_ _06412_ _06414_ _06416_ _06417_ VDD VSS NOR4_X2
X_11926_ _05226_ _06417_ _06418_ VDD VSS XOR2_X1
X_11927_ _05977_ _06408_ _06418_ _06419_ VDD VSS NOR3_X1
X_11928_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[52\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[52\]
+ _05892_ _06420_ VDD VSS MUX2_X1
X_11929_ _05874_ _05943_ _06420_ _06421_ VDD VSS NOR3_X1
X_11930_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[52\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[52\]
+ _05892_ _06422_ VDD VSS MUX2_X1
X_11931_ _06223_ _06422_ _06423_ VDD VSS NOR2_X1
X_11932_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[52\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[52\]
+ _05892_ _06424_ VDD VSS MUX2_X1
X_11933_ _06207_ _06424_ _06425_ VDD VSS NOR2_X1
X_11934_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[52\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[52\]
+ _06263_ _06426_ VDD VSS MUX2_X1
X_11935_ _05887_ _05718_ _06426_ _06427_ VDD VSS NOR3_X1
X_11936_ _06421_ _06423_ _06425_ _06427_ _06428_ VDD VSS NOR4_X2
X_11937_ _05257_ _06428_ _06429_ VDD VSS XOR2_X1
X_11938_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[58\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[58\]
+ _05876_ _06430_ VDD VSS MUX2_X1
X_11939_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[58\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[58\]
+ _05876_ _06431_ VDD VSS MUX2_X1
X_11940_ _06430_ _06431_ _05700_ _06432_ VDD VSS MUX2_X1
X_11941_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[58\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[58\]
+ _05876_ _06433_ VDD VSS MUX2_X1
X_11942_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[58\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[58\]
+ _05866_ _06434_ VDD VSS MUX2_X1
X_11943_ _06433_ _06434_ _05700_ _06435_ VDD VSS MUX2_X1
X_11944_ _06432_ _06435_ _05874_ _06436_ VDD VSS MUX2_X1
X_11945_ _05215_ _05977_ _06436_ _06437_ VDD VSS OR3_X1
X_11946_ _05215_ _05736_ _06436_ _06438_ VDD VSS NAND3_X1
X_11947_ _06429_ _06437_ _06438_ _06439_ VDD VSS AOI21_X1
X_11948_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[50\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[50\]
+ _05897_ _06440_ VDD VSS MUX2_X1
X_11949_ _05894_ _06440_ _06441_ VDD VSS NOR2_X1
X_11950_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[50\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[50\]
+ _06319_ _06442_ VDD VSS MUX2_X1
X_11951_ _05921_ _05908_ _06442_ _06443_ VDD VSS NOR3_X1
X_11952_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[50\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[50\]
+ _06319_ _06444_ VDD VSS MUX2_X1
X_11953_ _05887_ _05889_ _06444_ _06445_ VDD VSS NOR3_X1
X_11954_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[50\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[50\]
+ _05717_ _06446_ VDD VSS MUX2_X1
X_11955_ _05871_ _06446_ _06447_ VDD VSS NOR2_X1
X_11956_ _06441_ _06443_ _06445_ _06447_ _06448_ VDD VSS NOR4_X2
X_11957_ _05247_ _06448_ _06449_ VDD VSS XOR2_X1
X_11958_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[58\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[58\]
+ _05716_ _06450_ VDD VSS MUX2_X1
X_11959_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[58\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[58\]
+ _05716_ _06451_ VDD VSS MUX2_X1
X_11960_ _06450_ _06451_ _05700_ _06452_ VDD VSS MUX2_X1
X_11961_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[58\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[58\]
+ _05716_ _06453_ VDD VSS MUX2_X1
X_11962_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[58\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[58\]
+ _05716_ _06454_ VDD VSS MUX2_X1
X_11963_ _06453_ _06454_ _05700_ _06455_ VDD VSS MUX2_X1
X_11964_ _06452_ _06455_ _05874_ _06456_ VDD VSS MUX2_X2
X_11965_ _05215_ _05736_ _06456_ _06457_ VDD VSS OR3_X1
X_11966_ _05215_ _05977_ _06456_ _06458_ VDD VSS NAND3_X1
X_11967_ _06449_ _06457_ _06458_ _06459_ VDD VSS AOI21_X1
X_11968_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[50\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[50\]
+ _06129_ _06460_ VDD VSS MUX2_X1
X_11969_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[50\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[50\]
+ _06129_ _06461_ VDD VSS MUX2_X1
X_11970_ _06460_ _06461_ _05708_ _06462_ VDD VSS MUX2_X1
X_11971_ _05247_ _06462_ _06463_ VDD VSS XNOR2_X1
X_11972_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[60\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[60\]
+ _06129_ _06464_ VDD VSS MUX2_X1
X_11973_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[60\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[60\]
+ _06129_ _06465_ VDD VSS MUX2_X1
X_11974_ _06464_ _06465_ _05708_ _06466_ VDD VSS MUX2_X1
X_11975_ _05191_ _06466_ _06467_ VDD VSS XNOR2_X1
X_11976_ _06009_ _06463_ _06467_ _06468_ VDD VSS AOI21_X1
X_11977_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[55\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[55\]
+ _05892_ _06469_ VDD VSS MUX2_X1
X_11978_ _06223_ _06469_ _06470_ VDD VSS NOR2_X1
X_11979_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[55\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[55\]
+ _05699_ _06471_ VDD VSS MUX2_X1
X_11980_ _05921_ _05861_ _06471_ _06472_ VDD VSS NOR3_X2
X_11981_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[55\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[55\]
+ _05699_ _06473_ VDD VSS MUX2_X1
X_11982_ _05707_ _05718_ _06473_ _06474_ VDD VSS NOR3_X2
X_11983_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[55\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[55\]
+ _06263_ _06475_ VDD VSS MUX2_X1
X_11984_ _06207_ _06475_ _06476_ VDD VSS NOR2_X1
X_11985_ _06470_ _06472_ _06474_ _06476_ _06477_ VDD VSS NOR4_X4
X_11986_ _05209_ _06477_ _06478_ VDD VSS XOR2_X1
X_11987_ _05977_ _06468_ _06478_ _06479_ VDD VSS NOR3_X1
X_11988_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[54\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[54\]
+ _06129_ _06480_ VDD VSS MUX2_X1
X_11989_ _06223_ _06480_ _06481_ VDD VSS NOR2_X1
X_11990_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[54\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[54\]
+ _06263_ _06482_ VDD VSS MUX2_X1
X_11991_ _05921_ _05861_ _06482_ _06483_ VDD VSS NOR3_X2
X_11992_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[54\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[54\]
+ _05699_ _06484_ VDD VSS MUX2_X1
X_11993_ _05887_ _05718_ _06484_ _06485_ VDD VSS NOR3_X2
X_11994_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[54\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[54\]
+ _05870_ _06486_ VDD VSS MUX2_X1
X_11995_ _06207_ _06486_ _06487_ VDD VSS NOR2_X1
X_11996_ _06481_ _06483_ _06485_ _06487_ _06488_ VDD VSS NOR4_X4
X_11997_ _05252_ _06488_ _06489_ VDD VSS XOR2_X1
X_11998_ _05736_ _06489_ _06490_ VDD VSS NOR2_X1
X_11999_ _06399_ _06419_ _06439_ _06459_ _06479_ _06490_ _06491_
+ VDD VSS OAI222_X2
X_12000_ _06251_ _06286_ _06369_ _06491_ _06492_ VDD VSS NOR4_X4
X_12001_ _06185_ _06206_ _06492_ _06493_ VDD VSS MUX2_X2
X_12002_ _05263_ _05382_ _06494_ VDD VSS NOR2_X2
X_12003_ _10260_ _10263_ _05267_ _05268_ _06495_ VDD VSS NAND4_X2
X_12004_ _10259_ _10271_ _10274_ _06496_ VDD VSS NOR3_X1
X_12005_ _10256_ _06497_ VDD VSS INV_X1
X_12006_ _10257_ _06498_ VDD VSS INV_X1
X_12007_ _06497_ _10253_ _06498_ _06499_ VDD VSS OAI21_X1
X_12008_ _10262_ _06499_ _10263_ _06500_ VDD VSS AOI21_X1
X_12009_ _10260_ _06501_ VDD VSS INV_X1
X_12010_ _06496_ _06500_ _06501_ _06502_ VDD VSS OAI21_X1
X_12011_ _10272_ _10271_ _06503_ VDD VSS NOR2_X1
X_12012_ _10275_ _10271_ _10274_ _06504_ VDD VSS NOR3_X1
X_12013_ _06503_ _06504_ _06505_ VDD VSS NOR2_X1
X_12014_ _05268_ _06502_ _06505_ _06506_ VDD VSS NAND3_X2
X_12015_ _10265_ _10268_ _10266_ _06507_ VDD VSS AOI21_X2
X_12016_ _06495_ _06506_ _06507_ _06508_ VDD VSS NAND3_X2
X_12017_ _05266_ _05263_ _06509_ VDD VSS AND2_X1
X_12018_ _06494_ _06508_ _06509_ _06510_ VDD VSS AOI21_X4
X_12019_ dynamic_node_top.west_input.control.header_last_temp
+ _05175_ _06511_ VDD VSS AND2_X1
X_12020_ _05152_ _05275_ _06512_ VDD VSS OR2_X1
X_12021_ _06512_ _05276_ _05201_ _06513_ VDD VSS OAI21_X4
X_12022_ _05278_ _05280_ _05152_ _06514_ VDD VSS MUX2_X2
X_12023_ _05274_ _06513_ _06514_ _06515_ VDD VSS NOR3_X2
X_12024_ _05196_ _05220_ _05241_ _05262_ _06516_ VDD VSS OR4_X2
X_12025_ _06495_ _05383_ _06516_ _06517_ VDD VSS MUX2_X1
X_12026_ _06511_ _06515_ _06517_ _06518_ VDD VSS OAI21_X2
X_12027_ _06090_ _06510_ _06518_ _06519_ VDD VSS OAI21_X1
X_12028_ _05821_ _06520_ VDD VSS INV_X1
X_12029_ _06493_ _06519_ _06520_ _06521_ VDD VSS AOI21_X1
X_12030_ _05823_ _06521_ _06522_ VDD VSS NOR2_X1
X_12031_ _05406_ _05424_ _05441_ _05450_ _06523_ VDD VSS NOR4_X4
X_12032_ _05363_ _05365_ _05320_ _06524_ VDD VSS MUX2_X2
X_12033_ _06524_ _05370_ _05372_ _05374_ _06525_ VDD VSS OAI211_X2
X_12034_ _05303_ _06525_ _06526_ VDD VSS NAND2_X1
X_12035_ _05300_ _05386_ _06526_ _06527_ VDD VSS NAND3_X1
X_12036_ _06523_ _06527_ _06528_ VDD VSS OR2_X1
X_12037_ _05351_ _05377_ _05378_ _06525_ _06529_ VDD VSS NAND4_X1
X_12038_ _10301_ _05360_ net631 _06530_ VDD VSS AOI21_X1
X_12039_ net649 _10305_ net634 _10311_ _06531_ VDD VSS NAND4_X1
X_12040_ _10319_ _06532_ VDD VSS INV_X1
X_12041_ _10320_ _06533_ VDD VSS INV_X1
X_12042_ _06532_ _10322_ _06533_ _06534_ VDD VSS OAI21_X1
X_12043_ _10313_ _06534_ _05377_ _10316_ net681 _06535_ VDD
+ VSS AOI221_X2
X_12044_ _06530_ _05379_ _06531_ _06535_ _06536_ VDD VSS OAI211_X2
X_12045_ _05350_ _06529_ _06536_ _06537_ VDD VSS NAND3_X1
X_12046_ _06528_ _06537_ _05451_ _06538_ VDD VSS OAI21_X2
X_12047_ dynamic_node_top.REG_reset_fin.q _06539_ VDD VSS
+ CLKBUF_X3
X_12048_ _06539_ _06540_ VDD VSS BUF_X8
X_12049_ _06540_ _06541_ VDD VSS BUF_X4
X_12050_ _06541_ _06123_ _06125_ _06542_ VDD VSS AOI21_X1
X_12051_ _05382_ _05489_ _06543_ VDD VSS NOR2_X1
X_12052_ _05463_ _05490_ _06544_ VDD VSS OR2_X1
X_12053_ _06544_ _05491_ _05495_ _06545_ VDD VSS OAI21_X4
X_12054_ _05494_ _05497_ _06546_ VDD VSS NOR2_X2
X_12055_ _05463_ _05498_ _06547_ VDD VSS OR2_X1
X_12056_ _06547_ _05499_ _05495_ _06548_ VDD VSS OAI21_X4
X_12057_ _06545_ _06546_ _06548_ _06549_ VDD VSS NOR3_X2
X_12058_ _06543_ _06549_ _05383_ _06550_ VDD VSS OAI21_X1
X_12059_ _10365_ _10364_ _06551_ VDD VSS OR2_X1
X_12060_ _10361_ _06551_ net654 _06552_ VDD VSS AOI21_X1
X_12061_ _05489_ _05509_ _06552_ _06553_ VDD VSS NOR3_X1
X_12062_ _10361_ _10364_ _05513_ _06554_ VDD VSS OR3_X1
X_12063_ _10355_ _10367_ _10370_ _06555_ VDD VSS OR3_X1
X_12064_ _06555_ _10358_ net719 _06556_ VDD VSS AOI21_X1
X_12065_ _10349_ _06557_ VDD VSS INV_X1
X_12066_ _10352_ _06557_ net718 _06558_ VDD VSS AOI21_X1
X_12067_ net719 net725 _06559_ VDD VSS NAND2_X1
X_12068_ _06556_ _06558_ _06559_ _06560_ VDD VSS OAI21_X1
X_12069_ _10367_ _06561_ VDD VSS INV_X1
X_12070_ _10368_ _10370_ _10371_ _06562_ VDD VSS OAI21_X1
X_12071_ _06561_ _06562_ _06563_ VDD VSS NAND2_X1
X_12072_ _06560_ _06563_ _06564_ VDD VSS AND2_X1
X_12073_ _05510_ _05511_ _05512_ _06565_ VDD VSS OR3_X2
X_12074_ _06553_ _06554_ _06564_ _06565_ _06549_ _06566_ VDD
+ VSS OAI221_X2
X_12075_ _05589_ _06567_ VDD VSS CLKBUF_X3
X_12076_ _06550_ _06566_ _06567_ _06568_ VDD VSS MUX2_X2
X_12077_ _06538_ _06542_ _06568_ _06569_ VDD VSS NAND3_X1
X_12078_ _06538_ _06542_ _06570_ VDD VSS NAND2_X1
X_12079_ _05757_ _06571_ VDD VSS INV_X1
X_12080_ _06128_ _06522_ _06569_ _06570_ _06571_ _00018_ VDD
+ VSS OAI221_X1
X_12081_ _06541_ _06572_ VDD VSS CLKBUF_X3
X_12082_ _06572_ _06573_ VDD VSS BUF_X4
X_12083_ _06510_ _06518_ _06574_ VDD VSS NOR2_X1
X_12084_ _05753_ _06575_ VDD VSS BUF_X4
X_12085_ _06571_ _06540_ _06576_ VDD VSS NOR2_X1
X_12086_ _06537_ _06527_ _05451_ _06577_ VDD VSS MUX2_X1
X_12087_ _06120_ _06577_ _06578_ VDD VSS AND2_X1
X_12088_ _06575_ _06568_ _06576_ _06578_ _06579_ VDD VSS AOI22_X1
X_12089_ _05753_ _06577_ _06580_ VDD VSS NOR2_X1
X_12090_ _06539_ _06581_ VDD VSS INV_X4
X_12091_ _05753_ _05757_ _06581_ _06568_ _05823_ _06582_ VDD
+ VSS AOI221_X2
X_12092_ _06493_ _06574_ _06579_ _06580_ _06582_ _06120_ _06583_
+ VDD VSS OAI33_X1
X_12093_ _06573_ _06127_ _06583_ _06584_ VDD VSS NOR3_X1
X_12094_ _06577_ _06568_ _06585_ VDD VSS AND2_X1
X_12095_ _05823_ net667 _06586_ VDD VSS NAND2_X1
X_12096_ _06574_ _06586_ _06587_ VDD VSS NOR2_X1
X_12097_ _06585_ _06587_ _06521_ _06588_ VDD VSS OAI21_X1
X_12098_ _06541_ _06589_ VDD VSS BUF_X4
X_12099_ _06589_ _05756_ _06090_ _06590_ VDD VSS AOI21_X1
X_12100_ _06584_ _06588_ _06590_ _06127_ _00017_ VDD VSS AOI22_X1
X_12101_ _05756_ _06591_ VDD VSS BUF_X4
X_12102_ _05858_ dynamic_node_top.proc_input.control.count_one_f
+ _06592_ VDD VSS NAND2_X1
X_12103_ _05902_ _05933_ _05956_ _05972_ _06593_ VDD VSS OR4_X1
X_12104_ _06000_ _06007_ _06594_ VDD VSS AND2_X2
X_12105_ _06009_ _06018_ _06027_ _06595_ VDD VSS NOR3_X1
X_12106_ _06009_ _06038_ _06047_ _06596_ VDD VSS AND3_X1
X_12107_ _06594_ _06595_ _06596_ _05983_ _05992_ _06597_ VDD
+ VSS OAI221_X2
X_12108_ _06592_ _06593_ _06597_ _05858_ _05859_ _06598_ VDD
+ VSS OAI221_X2
X_12109_ _05786_ _05788_ _06599_ VDD VSS NOR2_X1
X_12110_ _05472_ _06599_ _06600_ VDD VSS NAND2_X1
X_12111_ _05826_ _05854_ _06601_ VDD VSS NOR2_X4
X_12112_ _05478_ _06602_ VDD VSS INV_X1
X_12113_ _05470_ _06603_ VDD VSS INV_X1
X_12114_ _05473_ _06601_ _06602_ _06083_ _06603_ _06604_ VDD
+ VSS OAI221_X2
X_12115_ _05484_ _06598_ _06600_ _06604_ _05820_ _05471_ _06605_
+ VDD VSS AOI222_X2
X_12116_ dynamic_node_top.west_output.control.planned_f _06605_
+ net625 _06606_ VDD VSS MUX2_X1
X_12117_ _06606_ _06607_ VDD VSS BUF_X2
X_12118_ _05470_ _06591_ _06607_ _06608_ VDD VSS NAND3_X1
X_12119_ _05471_ _06609_ VDD VSS BUF_X4
X_12120_ _06609_ _06610_ VDD VSS INV_X4
X_12121_ _06610_ _06611_ VDD VSS BUF_X4
X_12122_ _06611_ _06612_ VDD VSS BUF_X4
X_12123_ _05185_ _06613_ VDD VSS BUF_X4
X_12124_ net770 _05266_ _06614_ VDD VSS OR2_X1
X_12125_ _05300_ _06614_ _05263_ _06615_ VDD VSS MUX2_X2
X_12126_ _05270_ _05304_ _06516_ _06616_ VDD VSS MUX2_X1
X_12127_ _05273_ _05277_ _05281_ _06616_ _06617_ VDD VSS OR4_X2
X_12128_ _06613_ _06615_ _06617_ _06618_ VDD VSS AOI21_X4
X_12129_ _06524_ _05370_ _06619_ VDD VSS OR2_X1
X_12130_ _05383_ _05376_ _06619_ _06620_ VDD VSS NOR3_X1
X_12131_ _05382_ _06523_ _06620_ _06621_ VDD VSS OR3_X1
X_12132_ _05376_ _05379_ _06619_ _06622_ VDD VSS NOR3_X1
X_12133_ _10298_ _10299_ _10295_ _06623_ VDD VSS AOI21_X1
X_12134_ _10293_ _10290_ _10289_ _06624_ VDD VSS OAI21_X1
X_12135_ _06624_ _06625_ VDD VSS INV_X1
X_12136_ _05348_ _06625_ _10292_ _06626_ VDD VSS OAI21_X1
X_12137_ _10289_ _10286_ _10292_ _06627_ VDD VSS OR3_X1
X_12138_ _10283_ _06628_ VDD VSS INV_X1
X_12139_ net695 _06629_ VDD VSS INV_X1
X_12140_ _10277_ _06630_ VDD VSS INV_X1
X_12141_ _10280_ _06630_ _10281_ _06631_ VDD VSS AOI21_X1
X_12142_ _06628_ _06629_ _06631_ _06632_ VDD VSS OAI21_X1
X_12143_ _06627_ _06632_ _10287_ _06633_ VDD VSS AOI21_X1
X_12144_ _06623_ _06626_ _06633_ _06634_ VDD VSS OAI21_X2
X_12145_ _06622_ _06634_ _05349_ _06635_ VDD VSS MUX2_X1
X_12146_ _05386_ _06621_ _06635_ _05451_ _06636_ VDD VSS OAI211_X4
X_12147_ _05478_ _05484_ _06636_ _06637_ VDD VSS AOI21_X1
X_12148_ _06612_ _06618_ _06637_ _06638_ VDD VSS OAI21_X1
X_12149_ _05481_ net702 _06638_ _06639_ VDD VSS AOI21_X1
X_12150_ _10192_ _05630_ _06640_ VDD VSS NOR2_X1
X_12151_ _10195_ _06641_ VDD VSS INV_X1
X_12152_ net676 _10198_ _10199_ _06642_ VDD VSS OAI21_X1
X_12153_ _06641_ _06642_ _06643_ VDD VSS NAND2_X1
X_12154_ _10193_ _06643_ _06644_ VDD VSS NAND2_X1
X_12155_ _10195_ _10198_ _10201_ _06645_ VDD VSS OR3_X1
X_12156_ _10189_ _06646_ VDD VSS INV_X1
X_12157_ _10180_ _06647_ VDD VSS INV_X1
X_12158_ _10183_ _06647_ net653 _06648_ VDD VSS AOI21_X1
X_12159_ net641 _06649_ VDD VSS INV_X1
X_12160_ _06646_ _06648_ _06649_ _06650_ VDD VSS OAI21_X1
X_12161_ _06645_ _06650_ _05629_ net659 _10186_ _06651_ VDD
+ VSS AOI221_X2
X_12162_ _06640_ _06644_ _06651_ _06652_ VDD VSS OAI21_X1
X_12163_ _05617_ _06100_ _05627_ _06653_ VDD VSS NAND3_X1
X_12164_ _05630_ _06653_ _06654_ VDD VSS NAND2_X1
X_12165_ _06103_ net747 _06652_ _06654_ _06655_ VDD VSS AND4_X1
X_12166_ _05303_ _05617_ _06100_ _06656_ VDD VSS NAND3_X1
X_12167_ _06096_ _06656_ _05300_ _06657_ VDD VSS AOI21_X2
X_12168_ _05651_ _05668_ _05685_ _05694_ _06658_ VDD VSS OR4_X4
X_12169_ _06655_ _06657_ _06658_ _06659_ VDD VSS AOI21_X4
X_12170_ _06659_ _06660_ VDD VSS INV_X1
X_12171_ _06541_ _06607_ _06661_ VDD VSS NOR2_X2
X_12172_ _06660_ _06661_ _06662_ VDD VSS NAND2_X1
X_12173_ _06608_ _06639_ _06662_ _00035_ VDD VSS OAI21_X1
X_12174_ _05755_ _06663_ VDD VSS INV_X1
X_12175_ _06663_ _06664_ VDD VSS CLKBUF_X3
X_12176_ _05481_ _06659_ _06665_ VDD VSS NAND2_X1
X_12177_ _05919_ _06666_ VDD VSS CLKBUF_X3
X_12178_ _05737_ _06137_ _06667_ VDD VSS NOR2_X1
X_12179_ _05977_ _06144_ _06668_ VDD VSS NOR2_X1
X_12180_ _06667_ _06668_ _06163_ _06178_ _06669_ VDD VSS NOR4_X4
X_12181_ _05382_ _05303_ _06669_ _06670_ VDD VSS AOI21_X1
X_12182_ _06666_ _06670_ _06671_ VDD VSS OR2_X1
X_12183_ _06188_ _06191_ _06672_ VDD VSS NOR2_X1
X_12184_ _10388_ _06673_ VDD VSS INV_X1
X_12185_ _10391_ _10394_ _10392_ _06674_ VDD VSS AOI21_X1
X_12186_ _10389_ _06675_ VDD VSS INV_X1
X_12187_ _06673_ _06674_ _06675_ _06676_ VDD VSS OAI21_X1
X_12188_ _10385_ _06676_ _10386_ _06677_ VDD VSS AOI21_X1
X_12189_ _10382_ _06678_ VDD VSS INV_X1
X_12190_ _10373_ _06679_ VDD VSS INV_X1
X_12191_ _10376_ _06679_ _10377_ _06680_ VDD VSS AOI21_X1
X_12192_ _10383_ _06681_ VDD VSS INV_X1
X_12193_ _06678_ _06680_ _06681_ _06682_ VDD VSS OAI21_X1
X_12194_ _10379_ _06682_ _10380_ _06683_ VDD VSS AOI21_X1
X_12195_ _06677_ _06683_ _06186_ _06684_ VDD VSS OAI21_X1
X_12196_ _06669_ _06672_ _06684_ _06188_ _06685_ VDD VSS AOI22_X1
X_12197_ _06666_ _06685_ _06686_ VDD VSS OR2_X1
X_12198_ _06671_ _06686_ _06492_ _06687_ VDD VSS MUX2_X1
X_12199_ _06607_ _06665_ _06687_ _06688_ VDD VSS NOR3_X1
X_12200_ _06688_ _06607_ _05484_ _06689_ VDD VSS AOI21_X1
X_12201_ _05590_ _06659_ _06690_ VDD VSS AND2_X1
X_12202_ _06611_ _06691_ VDD VSS BUF_X4
X_12203_ _06691_ _06618_ _06602_ _06692_ VDD VSS OAI21_X1
X_12204_ _05470_ _06690_ _06692_ _06693_ VDD VSS AOI21_X1
X_12205_ _06666_ _06670_ _06694_ VDD VSS NOR2_X1
X_12206_ _06666_ _06685_ _06695_ VDD VSS NOR2_X1
X_12207_ _06694_ _06695_ _06492_ _06696_ VDD VSS MUX2_X1
X_12208_ _06696_ _06697_ VDD VSS BUF_X4
X_12209_ _06661_ _06697_ _06698_ VDD VSS NAND2_X1
X_12210_ _06664_ _06689_ _06693_ _06698_ _00034_ VDD VSS OAI22_X1
X_12211_ _06611_ _06699_ VDD VSS BUF_X4
X_12212_ _06607_ _06700_ VDD VSS INV_X1
X_12213_ _06511_ _06701_ VDD VSS BUF_X4
X_12214_ _06494_ _06614_ _05263_ _06702_ VDD VSS AOI21_X2
X_12215_ _05277_ _05281_ _05304_ _06703_ VDD VSS NOR3_X1
X_12216_ _05270_ _05277_ _05281_ _06704_ VDD VSS NOR3_X1
X_12217_ _06703_ _06704_ _05263_ _06705_ VDD VSS MUX2_X2
X_12218_ _06613_ _05273_ _06706_ VDD VSS NOR2_X1
X_12219_ _06701_ _06702_ _06705_ _06706_ _06707_ VDD VSS AOI22_X4
X_12220_ _05478_ _06636_ _06708_ VDD VSS NOR2_X1
X_12221_ _05478_ _05484_ _06709_ VDD VSS NOR2_X1
X_12222_ _05470_ _05481_ _06659_ _06710_ VDD VSS AOI21_X1
X_12223_ _06709_ _06697_ _06710_ _06711_ VDD VSS OAI21_X1
X_12224_ _06661_ _06711_ _06712_ VDD VSS NAND2_X1
X_12225_ _06699_ _06664_ _06700_ _06707_ _06708_ _06712_ _00033_
+ VDD VSS OAI33_X1
X_12226_ _05817_ _05819_ _06713_ VDD VSS NOR2_X2
X_12227_ _05160_ _06713_ _06714_ VDD VSS NAND2_X1
X_12228_ _06053_ _06082_ _06715_ VDD VSS OR2_X2
X_12229_ _05167_ _05855_ _06715_ _05171_ _06716_ VDD VSS AOI22_X2
X_12230_ _05160_ _05789_ _05159_ _06717_ VDD VSS AOI21_X1
X_12231_ _05158_ _06718_ VDD VSS INV_X1
X_12232_ _06716_ _06717_ _06718_ _06050_ _06719_ VDD VSS OAI211_X2
X_12233_ _06714_ _06719_ _06720_ VDD VSS NAND2_X1
X_12234_ dynamic_node_top.east_output.control.planned_f _06721_
+ VDD VSS BUF_X1
X_12235_ _06720_ _06721_ _05308_ _06722_ VDD VSS MUX2_X2
X_12236_ _05171_ _06591_ _06722_ _06723_ VDD VSS NAND3_X1
X_12237_ _05159_ _06724_ VDD VSS BUF_X4
X_12238_ _05270_ _05282_ _06725_ VDD VSS OR2_X1
X_12239_ _10229_ _05295_ net636 _06726_ VDD VSS AOI21_X1
X_12240_ _10244_ _06727_ VDD VSS INV_X1
X_12241_ _10250_ _06728_ VDD VSS INV_X1
X_12242_ _10247_ _06728_ _10248_ _06729_ VDD VSS AOI21_X1
X_12243_ _10245_ _06730_ VDD VSS INV_X1
X_12244_ _06727_ _06729_ _06730_ _06731_ VDD VSS OAI21_X1
X_12245_ _10241_ _06731_ _10242_ _06732_ VDD VSS AOI21_X1
X_12246_ _06726_ _06732_ net734 _06733_ VDD VSS OAI21_X2
X_12247_ _06516_ _06725_ _06733_ _06734_ VDD VSS AOI21_X2
X_12248_ _05282_ _05263_ _05304_ _06735_ VDD VSS NOR3_X2
X_12249_ _06701_ _06734_ _06735_ _06736_ VDD VSS OAI21_X4
X_12250_ _05173_ _06724_ _06736_ _06737_ VDD VSS AOI21_X2
X_12251_ _06162_ _06738_ VDD VSS INV_X1
X_12252_ _05919_ _06146_ _06179_ _06739_ VDD VSS NOR3_X2
X_12253_ _06739_ _06740_ VDD VSS INV_X1
X_12254_ _05304_ _06738_ _06740_ _06741_ VDD VSS NOR3_X1
X_12255_ _06666_ _06684_ _06742_ VDD VSS OR2_X1
X_12256_ _06163_ _06672_ _06739_ _06743_ VDD VSS NAND3_X1
X_12257_ _06742_ _06743_ _06744_ VDD VSS NAND2_X1
X_12258_ _06741_ _06744_ _06492_ _06745_ VDD VSS MUX2_X2
X_12259_ _06718_ _06737_ _06745_ _06746_ VDD VSS OAI21_X1
X_12260_ _05366_ _05370_ _05376_ _06747_ VDD VSS NAND3_X1
X_12261_ _05304_ _06523_ _06747_ _06748_ VDD VSS NOR3_X2
X_12262_ _05349_ _05379_ _06749_ VDD VSS OR2_X1
X_12263_ _06747_ _06749_ _06750_ VDD VSS OR2_X1
X_12264_ _05451_ _06634_ _06750_ _06751_ VDD VSS AOI21_X2
X_12265_ _05386_ _06748_ _06751_ _06752_ VDD VSS OAI21_X4
X_12266_ _05167_ _06746_ _06752_ _06753_ VDD VSS AOI21_X1
X_12267_ _06581_ _06754_ VDD VSS BUF_X4
X_12268_ _06754_ _06755_ VDD VSS BUF_X4
X_12269_ _06714_ _06719_ _06756_ VDD VSS AND2_X1
X_12270_ _06721_ _06757_ VDD VSS INV_X1
X_12271_ _06756_ _06757_ _05308_ _06758_ VDD VSS MUX2_X1
X_12272_ _05613_ _06099_ _05622_ _06759_ VDD VSS NAND3_X1
X_12273_ _05631_ _06759_ _06760_ VDD VSS OR2_X1
X_12274_ _10192_ _06096_ _06761_ VDD VSS NOR2_X1
X_12275_ _06761_ _06644_ _06651_ _06762_ VDD VSS OAI21_X1
X_12276_ _06658_ _06760_ _06762_ _06763_ VDD VSS AOI21_X2
X_12277_ _05304_ net749 _06759_ _06764_ VDD VSS NOR3_X2
X_12278_ _06763_ _06764_ _06765_ VDD VSS NOR2_X2
X_12279_ _06765_ _06766_ VDD VSS INV_X1
X_12280_ _06755_ _06758_ _06766_ _06767_ VDD VSS NAND3_X1
X_12281_ _06723_ _06753_ _06767_ _00041_ VDD VSS OAI21_X1
X_12282_ _06607_ _06618_ _06768_ VDD VSS NOR2_X1
X_12283_ _05478_ _06754_ _05590_ _06659_ _06769_ VDD VSS NAND4_X1
X_12284_ _05470_ _06636_ _06770_ VDD VSS NAND2_X1
X_12285_ _06697_ _06769_ _06770_ _06771_ VDD VSS AOI21_X1
X_12286_ _06602_ _06664_ net702 _06772_ VDD VSS NOR3_X1
X_12287_ _06768_ _06771_ _06772_ _06773_ VDD VSS OAI21_X1
X_12288_ _05484_ _06636_ _06774_ VDD VSS NAND2_X1
X_12289_ _06612_ _06618_ _06774_ _06775_ VDD VSS OAI21_X1
X_12290_ _05484_ _06776_ VDD VSS INV_X1
X_12291_ net702 _06697_ _06618_ _06776_ _06777_ VDD VSS OAI211_X2
X_12292_ _06636_ _06659_ _06778_ VDD VSS NAND2_X1
X_12293_ net702 _06778_ _06779_ VDD VSS NAND2_X1
X_12294_ _06700_ _06775_ _06777_ _06779_ _06780_ VDD VSS NAND4_X1
X_12295_ _06618_ _06697_ _06778_ _06781_ VDD VSS NOR3_X1
X_12296_ _05481_ _06700_ _06781_ _06782_ VDD VSS NAND3_X1
X_12297_ _05481_ _05756_ _06783_ VDD VSS AND2_X1
X_12298_ _06589_ _06607_ _06783_ _06784_ VDD VSS AOI21_X1
X_12299_ _06773_ _06780_ _06782_ _06784_ _00032_ VDD VSS NAND4_X1
X_12300_ _05330_ _06785_ VDD VSS INV_X1
X_12301_ _05384_ _06786_ VDD VSS CLKBUF_X3
X_12302_ _05488_ _05177_ _06787_ VDD VSS AND2_X2
X_12303_ _05494_ _05497_ _06788_ VDD VSS OR2_X1
X_12304_ _06788_ _06789_ VDD VSS CLKBUF_X3
X_12305_ _06545_ _06789_ _05500_ _06790_ VDD VSS NOR3_X2
X_12306_ _06786_ _06787_ _06790_ _06791_ VDD VSS NAND3_X1
X_12307_ _06567_ _06791_ _06792_ VDD VSS NOR2_X1
X_12308_ _05489_ _06793_ VDD VSS BUF_X4
X_12309_ net656 _10365_ _06560_ _06563_ _06794_ VDD VSS NAND4_X1
X_12310_ _10361_ _10364_ net655 _06795_ VDD VSS AOI21_X1
X_12311_ _05513_ _06790_ _06794_ _06795_ _06796_ VDD VSS AOI22_X2
X_12312_ _06793_ net684 _06796_ _06797_ VDD VSS NOR3_X4
X_12313_ _06792_ _06797_ _06567_ _06798_ VDD VSS AOI21_X4
X_12314_ _05338_ _06798_ _06799_ VDD VSS NAND2_X1
X_12315_ _05266_ _05263_ _06506_ _06507_ _06800_ VDD VSS AND4_X1
X_12316_ _06800_ _06705_ _05273_ _06801_ VDD VSS AOI21_X4
X_12317_ _06613_ _06801_ _06802_ VDD VSS NOR2_X2
X_12318_ _06785_ _06799_ _06802_ _06803_ VDD VSS OAI21_X1
X_12319_ _05331_ _05755_ _06804_ VDD VSS NAND2_X1
X_12320_ _06581_ _06798_ _06805_ VDD VSS NAND2_X2
X_12321_ _05332_ _06806_ VDD VSS BUF_X4
X_12322_ _06806_ _06807_ VDD VSS BUF_X4
X_12323_ _06807_ net680 _06808_ VDD VSS NAND2_X1
X_12324_ _06804_ _06805_ _06808_ _06809_ VDD VSS OAI21_X1
X_12325_ _06802_ _06810_ VDD VSS INV_X1
X_12326_ _06755_ _06803_ _06809_ _06810_ _06811_ VDD VSS AOI22_X1
X_12327_ dynamic_node_top.south_output.control.planned_f _06812_
+ VDD VSS BUF_X1
X_12328_ _06812_ _06813_ VDD VSS INV_X1
X_12329_ _05329_ _06598_ _06814_ VDD VSS NAND2_X1
X_12330_ _05330_ _05820_ _06715_ _05332_ _06815_ VDD VSS AOI22_X1
X_12331_ _05333_ _05789_ _05331_ _06816_ VDD VSS AOI21_X1
X_12332_ _06815_ _06816_ _06817_ VDD VSS AND2_X1
X_12333_ _05333_ _06601_ _06814_ _06817_ _06818_ VDD VSS AOI22_X4
X_12334_ _06813_ _06818_ net1 _06819_ VDD VSS MUX2_X1
X_12335_ _06819_ _06820_ VDD VSS BUF_X4
X_12336_ _06146_ _06738_ _06179_ _06821_ VDD VSS AND3_X1
X_12337_ _06786_ _06182_ _06821_ _06822_ VDD VSS AND3_X1
X_12338_ _06186_ _06187_ _06823_ VDD VSS NOR2_X1
X_12339_ _06182_ _06823_ _06824_ VDD VSS NAND2_X1
X_12340_ _06191_ _06825_ VDD VSS INV_X1
X_12341_ _06146_ _06738_ _06179_ _06825_ _06826_ VDD VSS NAND4_X1
X_12342_ _06824_ _06826_ _06204_ _06827_ VDD VSS AOI21_X1
X_12343_ _06822_ _06827_ _06492_ _06828_ VDD VSS MUX2_X2
X_12344_ _06820_ _06828_ _06829_ VDD VSS NAND2_X1
X_12345_ _05329_ _06591_ _06830_ VDD VSS NAND2_X1
X_12346_ _06811_ _06829_ _06830_ _06820_ _00031_ VDD VSS OAI22_X1
X_12347_ _06786_ _06163_ _06739_ _06831_ VDD VSS NAND3_X1
X_12348_ _06742_ _06743_ _06832_ VDD VSS AND2_X1
X_12349_ _06831_ _06832_ _06492_ _06833_ VDD VSS MUX2_X2
X_12350_ _05171_ _05167_ _06765_ _06834_ VDD VSS AOI21_X1
X_12351_ _05492_ _06546_ _06548_ _06835_ VDD VSS NOR3_X2
X_12352_ _06786_ _06835_ _06836_ VDD VSS NAND2_X1
X_12353_ net683 _06565_ _06837_ VDD VSS NOR2_X2
X_12354_ net639 net715 _05523_ _05518_ _06838_ VDD VSS NAND4_X2
X_12355_ _06835_ _06837_ _06838_ _05505_ _06839_ VDD VSS AOI22_X2
X_12356_ _06836_ _06839_ _06567_ _06840_ VDD VSS MUX2_X1
X_12357_ _06793_ _06840_ _06841_ VDD VSS OR2_X2
X_12358_ _06736_ _06841_ _06842_ VDD VSS NAND2_X1
X_12359_ _06737_ _06834_ _06842_ _06843_ VDD VSS OAI21_X1
X_12360_ _06758_ _06843_ _06844_ VDD VSS NAND2_X1
X_12361_ _06718_ _06664_ _06758_ _06833_ _06844_ _06589_ _00040_
+ VDD VSS OAI33_X1
X_12362_ _05613_ _06096_ _06845_ VDD VSS NOR2_X1
X_12363_ _05384_ _05616_ _06100_ _06845_ _06846_ VDD VSS NAND4_X1
X_12364_ _06103_ _06106_ _06847_ VDD VSS NAND2_X1
X_12365_ _06847_ _06117_ _06113_ _06848_ VDD VSS AOI21_X1
X_12366_ _05616_ _06100_ _06845_ _05627_ _06849_ VDD VSS AND4_X1
X_12367_ _05630_ _06848_ _06849_ _06850_ VDD VSS OAI21_X1
X_12368_ _06846_ _06850_ net748 _06851_ VDD VSS MUX2_X2
X_12369_ _05329_ _06851_ _06852_ VDD VSS AND2_X1
X_12370_ _05452_ _06852_ _06853_ VDD VSS NAND2_X1
X_12371_ _05338_ _06854_ VDD VSS INV_X1
X_12372_ _06541_ _06853_ _06854_ _06855_ VDD VSS AOI21_X1
X_12373_ net680 _06856_ VDD VSS INV_X1
X_12374_ _06664_ _06856_ _06857_ VDD VSS NOR2_X1
X_12375_ _05332_ _06858_ VDD VSS INV_X4
X_12376_ _06858_ _06859_ VDD VSS BUF_X4
X_12377_ _06859_ _06860_ VDD VSS BUF_X4
X_12378_ _05330_ _06851_ _06861_ VDD VSS NAND2_X1
X_12379_ _06860_ _06828_ _06861_ _06862_ VDD VSS OAI21_X1
X_12380_ _06855_ _06857_ _06862_ _06863_ VDD VSS AOI21_X1
X_12381_ _06567_ _06797_ _06864_ VDD VSS NAND2_X1
X_12382_ _06864_ _06791_ _06567_ _06865_ VDD VSS OAI21_X1
X_12383_ _06820_ _06865_ _06866_ VDD VSS NAND2_X1
X_12384_ _06820_ _06804_ _06863_ _06866_ _00030_ VDD VSS OAI22_X1
X_12385_ _06820_ _05756_ _06807_ _06867_ VDD VSS AOI21_X1
X_12386_ _06812_ net1 _06868_ VDD VSS NOR2_X1
X_12387_ _06868_ _06818_ net1 _06869_ VDD VSS AOI21_X2
X_12388_ _05329_ _06869_ _06870_ VDD VSS NOR2_X1
X_12389_ _06786_ _06183_ _06821_ _06871_ VDD VSS NAND3_X1
X_12390_ _06666_ _06188_ _06872_ VDD VSS NOR2_X1
X_12391_ _06146_ _06738_ _06179_ _06825_ _06873_ VDD VSS AND4_X1
X_12392_ _06204_ _06874_ VDD VSS INV_X1
X_12393_ _06872_ _06873_ _06874_ _06875_ VDD VSS OAI21_X1
X_12394_ _06871_ _06875_ _06492_ _06876_ VDD VSS MUX2_X2
X_12395_ _05331_ _05338_ _06798_ _06877_ VDD VSS AOI21_X2
X_12396_ _06541_ _06802_ _06877_ _06878_ VDD VSS NOR3_X2
X_12397_ _06876_ _06878_ _05330_ _06879_ VDD VSS OAI21_X1
X_12398_ _06581_ _06880_ VDD VSS BUF_X4
X_12399_ _06851_ _06881_ VDD VSS INV_X1
X_12400_ _06880_ _06881_ _06882_ VDD VSS NAND2_X1
X_12401_ _06867_ _06870_ _06879_ _06820_ _06882_ _00028_ VDD
+ VSS AOI221_X1
X_12402_ _06541_ _06877_ _06883_ VDD VSS NOR2_X1
X_12403_ _06806_ _06852_ _06884_ VDD VSS NOR2_X1
X_12404_ _06856_ _06805_ _06884_ _06885_ VDD VSS NOR3_X1
X_12405_ _06820_ _06883_ _06885_ _06886_ VDD VSS OAI21_X1
X_12406_ _06785_ _06664_ _06820_ _06801_ _06886_ _06613_ _00029_
+ VDD VSS OAI33_X1
X_12407_ _05167_ _06591_ _06722_ _06887_ VDD VSS NAND3_X1
X_12408_ _06572_ _06752_ _06888_ VDD VSS NOR2_X1
X_12409_ _05171_ _06736_ _06841_ _06889_ VDD VSS NAND3_X1
X_12410_ _06745_ _06889_ _06737_ _06890_ VDD VSS AOI21_X1
X_12411_ _06888_ _06890_ _05158_ _06891_ VDD VSS OAI21_X1
X_12412_ _06887_ _06891_ _06722_ _00039_ VDD VSS OAI21_X1
X_12413_ _06755_ _06892_ VDD VSS BUF_X4
X_12414_ _06828_ _06881_ _06893_ VDD VSS NOR2_X1
X_12415_ _05338_ _05756_ _06894_ VDD VSS AND2_X1
X_12416_ _06893_ _06878_ _06894_ _06820_ _06895_ VDD VSS OAI211_X2
X_12417_ _05332_ _05452_ _06801_ _06896_ VDD VSS NAND3_X1
X_12418_ _05332_ _05185_ _05452_ _06897_ VDD VSS NAND3_X1
X_12419_ _06861_ _06897_ _06898_ VDD VSS AND2_X1
X_12420_ _06828_ _06896_ _06898_ _06805_ net680 _06899_ VDD
+ VSS AOI221_X2
X_12421_ _06802_ _06805_ _06853_ _06900_ VDD VSS NOR3_X1
X_12422_ _06806_ _05755_ _06852_ _06901_ VDD VSS AOI21_X1
X_12423_ net680 _06901_ _06902_ VDD VSS NOR2_X1
X_12424_ _06869_ _06899_ _06900_ _06902_ _06903_ VDD VSS NOR4_X2
X_12425_ _06820_ _06894_ _06904_ VDD VSS NOR2_X1
X_12426_ _06892_ _06895_ _06903_ _06904_ _00027_ VDD VSS OAI211_X2
X_12427_ _05492_ _05500_ _06905_ VDD VSS OR2_X1
X_12428_ _05489_ _06546_ _06905_ _06906_ VDD VSS NOR3_X2
X_12429_ _06786_ _06837_ _06567_ _06907_ VDD VSS MUX2_X1
X_12430_ _06906_ _06907_ _06908_ VDD VSS NAND2_X1
X_12431_ _05346_ _06909_ VDD VSS CLKBUF_X3
X_12432_ _05372_ _05374_ _06910_ VDD VSS NOR2_X1
X_12433_ _06909_ _06910_ _06619_ _06911_ VDD VSS NOR3_X2
X_12434_ _06749_ _06912_ VDD VSS INV_X1
X_12435_ _06786_ _06912_ _06523_ _06913_ VDD VSS MUX2_X1
X_12436_ _06911_ _06913_ _06914_ VDD VSS AND2_X2
X_12437_ _05595_ _06915_ VDD VSS INV_X1
X_12438_ _05596_ _06916_ VDD VSS BUF_X4
X_12439_ _05185_ _05273_ _06514_ _06917_ VDD VSS NOR3_X2
X_12440_ _06513_ _06786_ _06917_ _06918_ VDD VSS NAND3_X1
X_12441_ _05266_ _05269_ _06513_ _06917_ _06919_ VDD VSS NAND4_X1
X_12442_ _06918_ _06919_ _05263_ _06920_ VDD VSS MUX2_X2
X_12443_ _06916_ _05696_ _06920_ _06921_ VDD VSS NAND3_X1
X_12444_ _06915_ _06921_ _06922_ VDD VSS AND2_X1
X_12445_ _06663_ _06914_ _06922_ _06923_ VDD VSS OR3_X1
X_12446_ _05603_ _06924_ VDD VSS INV_X1
X_12447_ _06917_ _06925_ VDD VSS INV_X1
X_12448_ _05277_ _06616_ _06925_ _06926_ VDD VSS NOR3_X4
X_12449_ _06924_ _06914_ _06926_ _06927_ VDD VSS NOR3_X1
X_12450_ _06880_ _06927_ _05594_ _06928_ VDD VSS OAI21_X1
X_12451_ _06908_ _06923_ _06928_ _06929_ VDD VSS AOI21_X1
X_12452_ _05605_ _05756_ _06930_ VDD VSS AND2_X1
X_12453_ dynamic_node_top.proc_output.control.planned_f _06931_
+ VDD VSS BUF_X1
X_12454_ _06931_ net744 _06932_ VDD VSS NOR2_X1
X_12455_ _05605_ _05786_ _05788_ _06933_ VDD VSS OAI21_X1
X_12456_ _05594_ _06934_ VDD VSS INV_X1
X_12457_ _06933_ _06713_ _06915_ _06934_ _06601_ _06935_ VDD
+ VSS OAI221_X2
X_12458_ _05597_ _06935_ _06598_ _05596_ _06936_ VDD VSS AOI211_X2
X_12459_ _05598_ _06715_ _06937_ VDD VSS NOR2_X2
X_12460_ _06936_ _06937_ _06938_ VDD VSS NOR2_X2
X_12461_ _06932_ _06938_ net744 _06939_ VDD VSS AOI21_X4
X_12462_ _06929_ _06930_ _06939_ _00026_ VDD VSS MUX2_X1
X_12463_ _05595_ _05756_ _06939_ _06940_ VDD VSS AND3_X1
X_12464_ _06581_ _06926_ _06941_ VDD VSS NAND2_X1
X_12465_ _05603_ _06916_ _05696_ _06942_ VDD VSS AOI21_X1
X_12466_ _06672_ _06943_ VDD VSS INV_X1
X_12467_ _05304_ _06943_ _06492_ _06944_ VDD VSS MUX2_X2
X_12468_ _06738_ _06739_ _06945_ VDD VSS NAND2_X2
X_12469_ _06786_ _06906_ _06946_ VDD VSS NAND2_X1
X_12470_ _06837_ _06906_ _06947_ VDD VSS NAND2_X1
X_12471_ _06946_ _06947_ _06567_ _06948_ VDD VSS MUX2_X1
X_12472_ _05594_ _06948_ _06949_ VDD VSS AND2_X1
X_12473_ _05696_ _06944_ _06945_ _06949_ _05605_ _06950_ VDD
+ VSS OAI221_X2
X_12474_ _06939_ _06941_ _06942_ _06950_ _06951_ VDD VSS AOI211_X2
X_12475_ _06940_ _06951_ _00025_ VDD VSS OR2_X1
X_12476_ _05173_ _05756_ _06952_ VDD VSS AND2_X1
X_12477_ _06573_ _06722_ _06952_ _06953_ VDD VSS AOI21_X1
X_12478_ _06752_ _06765_ _06841_ _06954_ VDD VSS NAND3_X1
X_12479_ _06718_ _06954_ _06955_ VDD VSS NOR2_X1
X_12480_ _05167_ _06956_ VDD VSS INV_X1
X_12481_ _06956_ _06540_ _06763_ _06764_ _06957_ VDD VSS NOR4_X1
X_12482_ _06841_ _06957_ _05171_ _06958_ VDD VSS OAI21_X1
X_12483_ _05159_ _06959_ VDD VSS INV_X2
X_12484_ _06959_ _06960_ VDD VSS BUF_X4
X_12485_ _06736_ _06958_ _06960_ _06961_ VDD VSS AOI21_X1
X_12486_ _05171_ _06752_ _06765_ _05167_ _06962_ VDD VSS AOI22_X1
X_12487_ _05159_ _06736_ _06841_ _05173_ _06963_ VDD VSS AOI22_X1
X_12488_ _06752_ _06964_ VDD VSS INV_X1
X_12489_ _06541_ _06842_ _06962_ _06963_ _06766_ _06964_ _06965_
+ VDD VSS OAI33_X1
X_12490_ _06955_ _06961_ _06965_ _06833_ _06966_ VDD VSS AOI211_X2
X_12491_ _06953_ _06966_ _06722_ _00037_ VDD VSS OAI21_X1
X_12492_ _05594_ _06591_ _06939_ _06967_ VDD VSS NAND3_X1
X_12493_ _05603_ _05755_ _06920_ _06968_ VDD VSS NAND3_X1
X_12494_ _06968_ _06922_ _06572_ _06969_ VDD VSS OAI21_X1
X_12495_ _05605_ _05756_ _05696_ _06920_ _06970_ VDD VSS AND4_X1
X_12496_ _06944_ _06945_ _06971_ VDD VSS OR2_X1
X_12497_ _06969_ _06970_ _06971_ _06972_ VDD VSS AOI21_X1
X_12498_ _06786_ _06911_ _06973_ VDD VSS NAND2_X1
X_12499_ _06912_ _06911_ _06974_ VDD VSS NAND2_X1
X_12500_ _06973_ _06974_ _06523_ _06975_ VDD VSS MUX2_X1
X_12501_ _06939_ _06975_ _06976_ VDD VSS OR2_X1
X_12502_ _06967_ _06972_ _06976_ _00024_ VDD VSS OAI21_X1
X_12503_ _06916_ _06977_ VDD VSS BUF_X4
X_12504_ _06977_ _06591_ _06939_ _06978_ VDD VSS NAND3_X1
X_12505_ _05595_ _05603_ _06920_ _06979_ VDD VSS AOI21_X1
X_12506_ _06934_ _06914_ _06979_ _06980_ VDD VSS OAI21_X1
X_12507_ _05605_ _06908_ _06980_ _06981_ VDD VSS AOI21_X1
X_12508_ _06572_ _06971_ _06981_ _06982_ VDD VSS OR3_X1
X_12509_ _06978_ _06982_ _06939_ _00023_ VDD VSS OAI21_X1
X_12510_ _06924_ _06664_ _06983_ VDD VSS NOR2_X1
X_12511_ _06573_ _06939_ _06983_ _06984_ VDD VSS AOI21_X1
X_12512_ _05304_ _05624_ _06985_ VDD VSS NOR2_X1
X_12513_ _05624_ _05631_ _06986_ VDD VSS NOR2_X1
X_12514_ _06985_ _06986_ net748 _06987_ VDD VSS MUX2_X2
X_12515_ _06906_ _06907_ _06988_ VDD VSS AND2_X1
X_12516_ _06914_ _06926_ _06988_ _06989_ VDD VSS NOR3_X1
X_12517_ _06987_ _06989_ _06990_ VDD VSS OR2_X1
X_12518_ _06987_ _06920_ _06581_ _06991_ VDD VSS AOI21_X1
X_12519_ _06987_ _06975_ _06949_ _06992_ VDD VSS NOR3_X1
X_12520_ _05605_ _06949_ _06993_ VDD VSS NOR2_X1
X_12521_ _06914_ _06988_ _06979_ _06991_ _06992_ _06993_ _06994_
+ VDD VSS OAI33_X1
X_12522_ _06916_ _06990_ _06994_ _06971_ _06995_ VDD VSS AOI22_X1
X_12523_ _06984_ _06995_ _06939_ _00022_ VDD VSS OAI21_X1
X_12524_ _06724_ _06996_ VDD VSS BUF_X4
X_12525_ _06996_ _06591_ _06722_ _06997_ VDD VSS NAND3_X1
X_12526_ _05158_ _06752_ _06765_ _06998_ VDD VSS NAND3_X1
X_12527_ _05171_ _06999_ VDD VSS INV_X1
X_12528_ _06572_ _06998_ _06999_ _07000_ VDD VSS AOI21_X1
X_12529_ _06664_ _06766_ _07001_ VDD VSS NOR2_X1
X_12530_ _05173_ _06752_ _07002_ VDD VSS NAND2_X1
X_12531_ _06956_ _06745_ _07002_ _07003_ VDD VSS OAI21_X1
X_12532_ _07000_ _07001_ _07003_ _07004_ VDD VSS AOI21_X1
X_12533_ _06722_ _06841_ _07005_ VDD VSS OR2_X1
X_12534_ _06997_ _07004_ _07005_ _00038_ VDD VSS OAI21_X1
X_12535_ _05757_ _06591_ _06127_ _07006_ VDD VSS NAND3_X1
X_12536_ _05857_ _06493_ _06519_ _07007_ VDD VSS OAI21_X1
X_12537_ _05754_ net667 _07008_ VDD VSS NAND2_X1
X_12538_ _06520_ _06574_ _07008_ _07009_ VDD VSS OAI21_X1
X_12539_ _06664_ _06493_ _07010_ VDD VSS NOR2_X1
X_12540_ _06755_ _07007_ _07009_ _07010_ _07011_ VDD VSS AOI22_X1
X_12541_ _06127_ _06568_ _07012_ VDD VSS OR2_X1
X_12542_ _07006_ _07011_ _07012_ _00021_ VDD VSS OAI21_X1
X_12543_ _06603_ _06607_ _06636_ _06697_ _07013_ VDD VSS NOR4_X1
X_12544_ _07013_ _06607_ _05478_ _07014_ VDD VSS AOI21_X1
X_12545_ _06609_ _07015_ VDD VSS BUF_X4
X_12546_ _05481_ _07015_ net702 _07016_ VDD VSS AOI21_X1
X_12547_ _06660_ _06697_ _07016_ _07017_ VDD VSS NOR3_X1
X_12548_ _06661_ _07017_ _05484_ _07018_ VDD VSS OAI21_X1
X_12549_ _06664_ _07014_ _07018_ _06636_ _00036_ VDD VSS OAI22_X1
X_12550_ _05821_ _06591_ _06127_ _07019_ VDD VSS NAND3_X1
X_12551_ _06515_ _06517_ _07020_ VDD VSS NOR2_X1
X_12552_ _06613_ _06510_ _07020_ _07021_ VDD VSS OR3_X2
X_12553_ _05753_ _07022_ VDD VSS INV_X2
X_12554_ _05757_ _05823_ _06568_ _07023_ VDD VSS AOI21_X1
X_12555_ _07022_ _06538_ _07023_ _07024_ VDD VSS OAI21_X1
X_12556_ _06090_ net667 _07024_ _07025_ VDD VSS AOI21_X1
X_12557_ _06572_ _06127_ _07021_ _07025_ _07026_ VDD VSS OR4_X1
X_12558_ _07019_ _07026_ _00020_ VDD VSS NAND2_X1
X_12559_ _05823_ _06591_ _06127_ _07027_ VDD VSS NAND3_X1
X_12560_ _06090_ _07028_ VDD VSS INV_X1
X_12561_ _06576_ _06578_ _07029_ VDD VSS NAND2_X1
X_12562_ _07028_ _07029_ _07008_ _07030_ VDD VSS NAND3_X1
X_12563_ _05821_ _07021_ _07030_ _07031_ VDD VSS AOI21_X1
X_12564_ _05383_ _06147_ _06180_ _07032_ VDD VSS NOR3_X1
X_12565_ _05303_ _06666_ _07033_ VDD VSS NOR2_X1
X_12566_ _05300_ _07032_ _07033_ _07034_ VDD VSS OAI21_X1
X_12567_ _06147_ _06180_ _06191_ _07035_ VDD VSS NOR3_X1
X_12568_ _06182_ _06191_ _06204_ _07036_ VDD VSS AND3_X1
X_12569_ _06823_ _07035_ _07036_ _07037_ VDD VSS OAI21_X1
X_12570_ _07034_ _07037_ _06492_ _07038_ VDD VSS MUX2_X2
X_12571_ _06572_ _06127_ _07038_ _07039_ VDD VSS OR3_X1
X_12572_ _07027_ _07031_ _07039_ _00019_ VDD VSS OAI21_X1
X_12573_ _05605_ _05594_ _05603_ _06916_ _07040_ VDD VSS NOR4_X2
X_12574_ _05479_ net756 net623 _07040_ _07041_ VDD VSS AOI22_X2
X_12575_ _07041_ _05308_ _05161_ _07042_ VDD VSS OAI21_X2
X_12576_ _05338_ _05332_ _07043_ VDD VSS NOR2_X1
X_12577_ net624 _07043_ _07044_ VDD VSS NAND2_X2
X_12578_ _07028_ net622 _07022_ _07045_ VDD VSS NAND3_X2
X_12579_ _05329_ _05331_ _07044_ _07045_ _05757_ _05823_ _07046_
+ VDD VSS OAI33_X1
X_12580_ _07042_ _07046_ _10498_ VDD VSS NOR2_X4
X_12581_ _10498_ dynamic_node_top.west_input.NIB.thanks_in
+ VDD VSS INV_X1
X_12582_ _05818_ dynamic_node_top.west_input.control.count_f\[0\]
+ _07047_ VDD VSS XOR2_X1
X_12583_ _05815_ _07047_ _06613_ _07048_ VDD VSS MUX2_X1
X_12584_ dynamic_node_top.west_input.control.count_f\[2\]
+ _07049_ VDD VSS BUF_X1
X_12585_ _05818_ _10481_ _07050_ VDD VSS NAND2_X1
X_12586_ _07049_ dynamic_node_top.west_input.control.count_f\[3\]
+ _07050_ _07051_ VDD VSS OR3_X1
X_12587_ dynamic_node_top.west_input.control.count_f\[4\]
+ _07051_ _07052_ VDD VSS XNOR2_X1
X_12588_ _06701_ _07052_ _07053_ VDD VSS NOR2_X1
X_12589_ _05818_ _07054_ VDD VSS INV_X1
X_12590_ _07054_ dynamic_node_top.west_input.control.count_f\[0\]
+ dynamic_node_top.west_input.control.count_f\[1\] _07049_ _07055_
+ VDD VSS OR4_X1
X_12591_ dynamic_node_top.west_input.control.count_f\[3\]
+ _07055_ _07056_ VDD VSS XNOR2_X1
X_12592_ _05818_ dynamic_node_top.west_input.control.count_f\[1\]
+ _07049_ _07057_ VDD VSS OR3_X1
X_12593_ _10481_ _07049_ _07058_ VDD VSS XNOR2_X1
X_12594_ _05818_ _10482_ _07058_ _07059_ VDD VSS NAND3_X1
X_12595_ _07056_ _07057_ _07059_ _07060_ VDD VSS AOI21_X1
X_12596_ _05793_ _05803_ _07053_ _07060_ _07061_ VDD VSS AOI22_X2
X_12597_ dynamic_node_top.west_input.control.count_f\[3\]
+ dynamic_node_top.west_input.control.count_f\[4\] _07055_ _07062_
+ VDD VSS OR3_X1
X_12598_ dynamic_node_top.west_input.control.count_f\[5\]
+ dynamic_node_top.west_input.control.count_f\[6\] _07062_ _07063_
+ VDD VSS NOR3_X1
X_12599_ dynamic_node_top.west_input.control.count_f\[7\]
+ _07063_ _07064_ VDD VSS XOR2_X1
X_12600_ _05812_ _07064_ _06613_ _07065_ VDD VSS MUX2_X1
X_12601_ dynamic_node_top.west_input.control.count_f\[4\]
+ dynamic_node_top.west_input.control.count_f\[5\] _07051_ _07066_
+ VDD VSS NOR3_X1
X_12602_ dynamic_node_top.west_input.control.count_f\[6\]
+ _07066_ _07067_ VDD VSS XNOR2_X1
X_12603_ _06701_ _07067_ _07068_ VDD VSS NOR2_X1
X_12604_ _07068_ _05806_ _06701_ _07069_ VDD VSS AOI21_X1
X_12605_ dynamic_node_top.west_input.control.count_f\[5\]
+ _07062_ _07070_ VDD VSS XOR2_X1
X_12606_ _06701_ _07070_ _07071_ VDD VSS NOR2_X1
X_12607_ _07071_ _05809_ _06701_ _07072_ VDD VSS AOI21_X1
X_12608_ _07069_ _07072_ _07073_ VDD VSS NAND2_X1
X_12609_ _07048_ _07061_ _07065_ _07073_ _07074_ VDD VSS NOR4_X1
X_12610_ _06572_ _07074_ _07075_ VDD VSS OR2_X1
X_12611_ dynamic_node_top.west_input.control.header_last_temp
+ _06572_ _07076_ VDD VSS OR2_X1
X_12612_ _07075_ _07076_ _10498_ _00004_ VDD VSS MUX2_X1
X_12613_ _05173_ _05159_ _07077_ VDD VSS OR2_X1
X_12614_ _05171_ _07077_ _07078_ VDD VSS OR2_X1
X_12615_ _05158_ _05308_ _07078_ _07079_ VDD VSS NOR3_X2
X_12616_ _05333_ net624 net622 _05753_ _07080_ VDD VSS AOI22_X1
X_12617_ _07080_ _07081_ VDD VSS INV_X1
X_12618_ _06916_ _07082_ VDD VSS INV_X4
X_12619_ _06915_ _06924_ _07082_ net623 _07083_ VDD VSS NAND4_X2
X_12620_ _05484_ _05481_ _05471_ _07084_ VDD VSS NOR3_X1
X_12621_ net625 _07084_ _07085_ VDD VSS NAND2_X2
X_12622_ _05605_ _07083_ _07085_ _05470_ _07086_ VDD VSS OAI22_X4
X_12623_ _07079_ _07081_ _07086_ _10472_ VDD VSS NOR3_X4
X_12624_ _10472_ dynamic_node_top.north_input.NIB.thanks_in
+ VDD VSS INV_X1
X_12625_ _05825_ dynamic_node_top.north_input.control.count_f\[0\]
+ _07087_ VDD VSS XOR2_X1
X_12626_ _05846_ _07087_ _06909_ _07088_ VDD VSS MUX2_X1
X_12627_ _05825_ dynamic_node_top.north_input.control.count_f\[1\]
+ _07089_ VDD VSS NOR2_X1
X_12628_ _07089_ _10423_ _05825_ _07090_ VDD VSS AOI21_X1
X_12629_ _05849_ _07090_ _06909_ _07091_ VDD VSS MUX2_X1
X_12630_ _05825_ _10422_ _07092_ VDD VSS NAND2_X1
X_12631_ dynamic_node_top.north_input.control.count_f\[2\]
+ _07092_ _07093_ VDD VSS XNOR2_X1
X_12632_ _05839_ _07093_ _06909_ _07094_ VDD VSS MUX2_X1
X_12633_ _05825_ _07095_ VDD VSS INV_X1
X_12634_ _07095_ dynamic_node_top.north_input.control.count_f\[0\]
+ dynamic_node_top.north_input.control.count_f\[1\] dynamic_node_top.north_input.control.count_f\[2\]
+ _07096_ VDD VSS NOR4_X1
X_12635_ dynamic_node_top.north_input.control.count_f\[3\]
+ _07096_ _07097_ VDD VSS XOR2_X1
X_12636_ _07097_ _07098_ VDD VSS INV_X1
X_12637_ dynamic_node_top.north_input.control.count_f\[2\]
+ dynamic_node_top.north_input.control.count_f\[3\] _07099_
+ VDD VSS NOR2_X1
X_12638_ _05825_ _10422_ _07099_ _07100_ VDD VSS NAND3_X1
X_12639_ dynamic_node_top.north_input.control.count_f\[4\]
+ _07100_ _07101_ VDD VSS XNOR2_X1
X_12640_ _05386_ _07101_ _07102_ VDD VSS NOR2_X1
X_12641_ _05833_ _07098_ _07102_ _07103_ VDD VSS AOI21_X1
X_12642_ _07091_ _07094_ _07103_ _07104_ VDD VSS NOR3_X1
X_12643_ _05852_ _07105_ VDD VSS INV_X2
X_12644_ dynamic_node_top.north_input.control.count_f\[4\]
+ _07106_ VDD VSS INV_X1
X_12645_ _07095_ dynamic_node_top.north_input.control.count_f\[0\]
+ dynamic_node_top.north_input.control.count_f\[1\] _07107_
+ VDD VSS NOR3_X1
X_12646_ _07106_ _07107_ _07099_ _07108_ VDD VSS NAND3_X1
X_12647_ dynamic_node_top.north_input.control.count_f\[5\]
+ dynamic_node_top.north_input.control.count_f\[6\] _07108_
+ _07109_ VDD VSS NOR3_X1
X_12648_ dynamic_node_top.north_input.control.count_f\[7\]
+ _07109_ _07110_ VDD VSS XNOR2_X1
X_12649_ _07105_ _07110_ _06909_ _07111_ VDD VSS MUX2_X1
X_12650_ dynamic_node_top.north_input.control.count_f\[4\]
+ dynamic_node_top.north_input.control.count_f\[5\] _07100_
+ _07112_ VDD VSS NOR3_X1
X_12651_ dynamic_node_top.north_input.control.count_f\[6\]
+ _07112_ _07113_ VDD VSS XNOR2_X1
X_12652_ _05386_ _07113_ _07114_ VDD VSS NOR2_X1
X_12653_ _07114_ _05843_ _05386_ _07115_ VDD VSS AOI21_X1
X_12654_ dynamic_node_top.north_input.control.count_f\[5\]
+ _07108_ _07116_ VDD VSS XOR2_X1
X_12655_ _05386_ _07116_ _07117_ VDD VSS NOR2_X1
X_12656_ _07117_ _05836_ _05386_ _07118_ VDD VSS AOI21_X1
X_12657_ _07104_ _07111_ _07115_ _07118_ _07119_ VDD VSS NAND4_X1
X_12658_ _06880_ _07088_ _07119_ _07120_ VDD VSS OAI21_X1
X_12659_ dynamic_node_top.north_input.control.header_last_temp
+ _06541_ _07121_ VDD VSS OR2_X1
X_12660_ _07120_ _07121_ _10472_ _00001_ VDD VSS MUX2_X1
X_12661_ _05478_ _05470_ _05481_ _06609_ _07122_ VDD VSS NOR4_X1
X_12662_ net625 _07122_ _07123_ VDD VSS AND2_X4
X_12663_ _05697_ _07124_ VDD VSS INV_X1
X_12664_ _07124_ _06987_ _07125_ VDD VSS NOR2_X1
X_12665_ _00053_ _05610_ _07125_ _05330_ _07044_ _05331_ _07126_
+ VDD VSS OAI33_X1
X_12666_ _07045_ _05821_ _05757_ _05167_ _05308_ _07078_ _07127_
+ VDD VSS OAI33_X1
X_12667_ _07126_ _07123_ _07127_ _10456_ VDD VSS NOR3_X4
X_12668_ _10456_ net620 VDD VSS INV_X2
X_12669_ _05858_ dynamic_node_top.proc_input.control.count_f\[0\]
+ _07128_ VDD VSS XNOR2_X1
X_12670_ _06183_ _07128_ _07129_ VDD VSS NOR2_X1
X_12671_ _06009_ _07130_ VDD VSS BUF_X4
X_12672_ _07130_ _06027_ _07131_ VDD VSS NOR2_X1
X_12673_ _07131_ _06047_ _07130_ _07132_ VDD VSS AOI21_X4
X_12674_ _07129_ _07132_ _06183_ _07133_ VDD VSS AOI21_X2
X_12675_ _07133_ _07134_ VDD VSS INV_X1
X_12676_ _05858_ _10533_ _07135_ VDD VSS NAND2_X1
X_12677_ dynamic_node_top.proc_input.control.count_f\[2\]
+ _07135_ _07136_ VDD VSS XOR2_X1
X_12678_ _06183_ _07136_ _07137_ VDD VSS NOR2_X1
X_12679_ _07137_ _05956_ _06183_ _07138_ VDD VSS AOI21_X1
X_12680_ dynamic_node_top.proc_input.control.count_f\[2\]
+ dynamic_node_top.proc_input.control.count_f\[3\] _07135_ _07139_
+ VDD VSS OR3_X1
X_12681_ dynamic_node_top.proc_input.control.count_f\[4\]
+ dynamic_node_top.proc_input.control.count_f\[5\] _07139_ _07140_
+ VDD VSS NOR3_X1
X_12682_ dynamic_node_top.proc_input.control.count_f\[6\]
+ _07140_ _07141_ VDD VSS XNOR2_X1
X_12683_ _06594_ _07141_ _06666_ _07142_ VDD VSS MUX2_X1
X_12684_ _07138_ _07142_ _07143_ VDD VSS NAND2_X1
X_12685_ _05858_ _07144_ VDD VSS INV_X1
X_12686_ _07144_ dynamic_node_top.proc_input.control.count_f\[0\]
+ dynamic_node_top.proc_input.control.count_f\[1\] dynamic_node_top.proc_input.control.count_f\[2\]
+ _07145_ VDD VSS NOR4_X2
X_12687_ dynamic_node_top.proc_input.control.count_f\[3\]
+ dynamic_node_top.proc_input.control.count_f\[4\] _07146_ VDD
+ VSS NOR2_X1
X_12688_ _07145_ _07146_ _07147_ VDD VSS NAND2_X1
X_12689_ dynamic_node_top.proc_input.control.count_f\[5\]
+ _07147_ _07148_ VDD VSS XNOR2_X1
X_12690_ _05972_ _07148_ _06666_ _07149_ VDD VSS MUX2_X1
X_12691_ dynamic_node_top.proc_input.control.count_f\[3\]
+ _07145_ _07150_ VDD VSS XOR2_X1
X_12692_ _05902_ _07150_ _06666_ _07151_ VDD VSS MUX2_X1
X_12693_ _07143_ _07149_ _07151_ _07152_ VDD VSS NOR3_X1
X_12694_ _05858_ dynamic_node_top.proc_input.control.count_f\[1\]
+ _07153_ VDD VSS NOR2_X1
X_12695_ _07153_ _05182_ dynamic_node_top.proc_input.control.header_last_temp
+ _05858_ _10534_ _07154_ VDD VSS AOI221_X2
X_12696_ _06009_ _06018_ _07155_ VDD VSS NOR2_X1
X_12697_ _07155_ _06038_ _07130_ _07156_ VDD VSS AOI21_X4
X_12698_ _07154_ _07156_ _06183_ _07157_ VDD VSS AOI21_X1
X_12699_ dynamic_node_top.proc_input.control.count_f\[4\]
+ _07139_ _07158_ VDD VSS XNOR2_X1
X_12700_ _05933_ _07158_ _06183_ _07159_ VDD VSS OAI21_X1
X_12701_ dynamic_node_top.proc_input.control.count_f\[5\]
+ dynamic_node_top.proc_input.control.count_f\[6\] _07147_ _07160_
+ VDD VSS NOR3_X1
X_12702_ dynamic_node_top.proc_input.control.count_f\[7\]
+ _07160_ _07161_ VDD VSS XNOR2_X1
X_12703_ _06183_ _07161_ _07162_ VDD VSS NOR2_X1
X_12704_ _07162_ _06183_ _05993_ _07163_ VDD VSS AOI21_X1
X_12705_ _07152_ _07157_ _07159_ _07163_ _07164_ VDD VSS NAND4_X1
X_12706_ _06880_ _07134_ _07164_ _07165_ VDD VSS OAI21_X1
X_12707_ dynamic_node_top.proc_input.control.header_last_temp
+ _06541_ _07166_ VDD VSS OR2_X1
X_12708_ _07165_ _07166_ _10456_ _00002_ VDD VSS MUX2_X1
X_12709_ _05167_ _05158_ _07077_ _07167_ VDD VSS OR3_X1
X_12710_ _05308_ _07167_ _07168_ VDD VSS NOR2_X2
X_12711_ _05340_ net624 _05597_ net623 _05824_ net622 _07169_
+ VDD VSS AOI222_X2
X_12712_ _07169_ _07170_ VDD VSS INV_X2
X_12713_ _05478_ _07085_ _07171_ VDD VSS NOR2_X1
X_12714_ _07168_ _07170_ _07171_ _10464_ VDD VSS NOR3_X4
X_12715_ _10464_ dynamic_node_top.south_input.NIB.thanks_in
+ VDD VSS INV_X2
X_12716_ _06052_ dynamic_node_top.south_input.control.count_f\[0\]
+ _07172_ VDD VSS XOR2_X1
X_12717_ _06080_ _07172_ _06096_ _07173_ VDD VSS MUX2_X1
X_12718_ _06057_ _06068_ _07174_ VDD VSS NOR2_X1
X_12719_ dynamic_node_top.south_input.control.count_f\[2\]
+ _07175_ VDD VSS BUF_X1
X_12720_ _06052_ _10515_ _07176_ VDD VSS NAND2_X1
X_12721_ _07175_ dynamic_node_top.south_input.control.count_f\[3\]
+ _07176_ _07177_ VDD VSS OR3_X1
X_12722_ dynamic_node_top.south_input.control.count_f\[4\]
+ _07177_ _07178_ VDD VSS XNOR2_X1
X_12723_ _06103_ _07178_ _07179_ VDD VSS NOR2_X1
X_12724_ _06052_ _07180_ VDD VSS INV_X1
X_12725_ _07180_ dynamic_node_top.south_input.control.count_f\[0\]
+ dynamic_node_top.south_input.control.count_f\[1\] _07175_
+ _07181_ VDD VSS OR4_X1
X_12726_ dynamic_node_top.south_input.control.count_f\[3\]
+ _07181_ _07182_ VDD VSS XNOR2_X1
X_12727_ _06052_ dynamic_node_top.south_input.control.count_f\[1\]
+ _07175_ _07183_ VDD VSS OR3_X1
X_12728_ _10515_ _07175_ _07184_ VDD VSS XNOR2_X1
X_12729_ _06052_ _10516_ _07184_ _07185_ VDD VSS NAND3_X1
X_12730_ _07182_ _07183_ _07185_ _07186_ VDD VSS AOI21_X1
X_12731_ _07174_ _07179_ _07186_ _07187_ VDD VSS AOI21_X1
X_12732_ dynamic_node_top.south_input.control.count_f\[3\]
+ dynamic_node_top.south_input.control.count_f\[4\] _07181_
+ _07188_ VDD VSS OR3_X1
X_12733_ dynamic_node_top.south_input.control.count_f\[5\]
+ dynamic_node_top.south_input.control.count_f\[6\] _07188_
+ _07189_ VDD VSS NOR3_X1
X_12734_ dynamic_node_top.south_input.control.count_f\[7\]
+ _07189_ _07190_ VDD VSS XOR2_X1
X_12735_ _06071_ _07190_ _06096_ _07191_ VDD VSS MUX2_X1
X_12736_ _06077_ _07192_ VDD VSS INV_X2
X_12737_ dynamic_node_top.south_input.control.count_f\[4\]
+ dynamic_node_top.south_input.control.count_f\[5\] _07177_
+ _07193_ VDD VSS NOR3_X1
X_12738_ dynamic_node_top.south_input.control.count_f\[6\]
+ _07193_ _07194_ VDD VSS XNOR2_X1
X_12739_ _07192_ _07194_ _06096_ _07195_ VDD VSS MUX2_X1
X_12740_ _06074_ _07196_ VDD VSS INV_X2
X_12741_ dynamic_node_top.south_input.control.count_f\[5\]
+ _07188_ _07197_ VDD VSS XOR2_X1
X_12742_ _07196_ _07197_ _06096_ _07198_ VDD VSS MUX2_X1
X_12743_ _07195_ _07198_ _07199_ VDD VSS NAND2_X1
X_12744_ _07173_ _07187_ _07191_ _07199_ _07200_ VDD VSS NOR4_X1
X_12745_ dynamic_node_top.south_input.control.header_last_temp
+ _07200_ dynamic_node_top.south_input.NIB.thanks_in _07201_
+ VDD VSS MUX2_X1
X_12746_ _06573_ _07201_ _00003_ VDD VSS OR2_X1
X_12747_ _05178_ _05184_ _05306_ _05307_ _07202_ VDD VSS OAI211_X2
X_12748_ _05329_ _05330_ _07203_ VDD VSS NOR2_X1
X_12749_ _07203_ net624 _07043_ _07204_ VDD VSS NAND3_X1
X_12750_ _07022_ _05857_ _06520_ _07028_ _07205_ VDD VSS NAND4_X1
X_12751_ _06095_ _07205_ _06120_ _06122_ _07206_ VDD VSS AOI211_X2
X_12752_ _05594_ _05595_ _05603_ _05596_ _07207_ VDD VSS NOR4_X2
X_12753_ _07206_ _07207_ net623 _05472_ net757 _07208_ VDD
+ VSS AOI221_X2
X_12754_ _07202_ _07204_ _07208_ _10506_ VDD VSS AND3_X2
X_12755_ _10506_ dynamic_node_top.east_input.NIB.thanks_in
+ VDD VSS INV_X1
X_12756_ _05488_ dynamic_node_top.east_input.NIB.thanks_in
+ _07209_ VDD VSS NOR2_X1
X_12757_ _05787_ dynamic_node_top.east_input.control.count_f\[0\]
+ _07210_ VDD VSS XOR2_X1
X_12758_ _05775_ _07210_ _06793_ _07211_ VDD VSS MUX2_X1
X_12759_ dynamic_node_top.east_input.control.count_f\[2\]
+ _07212_ VDD VSS BUF_X1
X_12760_ _05787_ _10440_ _07213_ VDD VSS NAND2_X1
X_12761_ _07212_ dynamic_node_top.east_input.control.count_f\[3\]
+ _07213_ _07214_ VDD VSS OR3_X1
X_12762_ dynamic_node_top.east_input.control.count_f\[4\]
+ _07214_ _07215_ VDD VSS XNOR2_X1
X_12763_ _06787_ _07215_ _07216_ VDD VSS NOR2_X1
X_12764_ _05787_ _07217_ VDD VSS INV_X1
X_12765_ _07217_ dynamic_node_top.east_input.control.count_f\[0\]
+ dynamic_node_top.east_input.control.count_f\[1\] _07212_ _07218_
+ VDD VSS OR4_X1
X_12766_ dynamic_node_top.east_input.control.count_f\[3\]
+ _07218_ _07219_ VDD VSS XNOR2_X1
X_12767_ _05787_ dynamic_node_top.east_input.control.count_f\[1\]
+ _07212_ _07220_ VDD VSS OR3_X1
X_12768_ _10440_ _07212_ _07221_ VDD VSS XNOR2_X1
X_12769_ _05787_ _10441_ _07221_ _07222_ VDD VSS NAND3_X1
X_12770_ _07219_ _07220_ _07222_ _07223_ VDD VSS AOI21_X1
X_12771_ _05761_ _05772_ _07216_ _07223_ _07224_ VDD VSS AOI22_X2
X_12772_ dynamic_node_top.east_input.control.count_f\[3\]
+ dynamic_node_top.east_input.control.count_f\[4\] _07218_ _07225_
+ VDD VSS OR3_X1
X_12773_ dynamic_node_top.east_input.control.count_f\[5\]
+ dynamic_node_top.east_input.control.count_f\[6\] _07225_ _07226_
+ VDD VSS NOR3_X1
X_12774_ dynamic_node_top.east_input.control.count_f\[7\]
+ _07226_ _07227_ VDD VSS XOR2_X1
X_12775_ _05778_ _07227_ _06793_ _07228_ VDD VSS MUX2_X1
X_12776_ _05784_ _07229_ VDD VSS INV_X2
X_12777_ dynamic_node_top.east_input.control.count_f\[4\]
+ dynamic_node_top.east_input.control.count_f\[5\] _07214_ _07230_
+ VDD VSS NOR3_X1
X_12778_ dynamic_node_top.east_input.control.count_f\[6\]
+ _07230_ _07231_ VDD VSS XNOR2_X1
X_12779_ _07229_ _07231_ _06793_ _07232_ VDD VSS MUX2_X1
X_12780_ _05781_ _07233_ VDD VSS INV_X2
X_12781_ dynamic_node_top.east_input.control.count_f\[5\]
+ _07225_ _07234_ VDD VSS XOR2_X1
X_12782_ _07233_ _07234_ _06793_ _07235_ VDD VSS MUX2_X1
X_12783_ _07232_ _07235_ _07236_ VDD VSS NAND2_X1
X_12784_ _07211_ _07224_ _07228_ _07236_ _07237_ VDD VSS NOR4_X1
X_12785_ _10506_ _07237_ _07238_ VDD VSS NOR2_X1
X_12786_ _06892_ _07209_ _07238_ _00000_ VDD VSS OAI21_X1
X_12787_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[45\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[45\]
+ net765 _07239_ VDD VSS MUX2_X1
X_12788_ _07239_ _07240_ VDD VSS INV_X1
X_12789_ _05126_ _07240_ _07241_ VDD VSS NAND2_X1
X_12790_ _05130_ _07242_ VDD VSS BUF_X8
X_12791_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[45\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[45\]
+ _07242_ _07243_ VDD VSS MUX2_X1
X_12792_ _07241_ _07243_ _05127_ _10185_ VDD VSS OAI21_X4
X_12793_ _05126_ _07244_ VDD VSS BUF_X8
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
X_12795_ _05132_ _07246_ VDD VSS BUF_X16
X_12796_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[49\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[49\]
+ _07246_ _07247_ VDD VSS MUX2_X1
X_12797_ _07247_ _07248_ VDD VSS INV_X1
X_12798_ _07244_ _07248_ _07249_ VDD VSS NAND2_X1
X_12799_ _05136_ _07250_ VDD VSS BUF_X16
X_12800_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[49\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[49\]
+ _07250_ _07251_ VDD VSS MUX2_X1
X_12801_ _07249_ _07251_ _07244_ _10191_ VDD VSS OAI21_X4
X_12802_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[47\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[47\]
+ _05130_ _07252_ VDD VSS MUX2_X1
X_12803_ _07252_ _07253_ VDD VSS INV_X1
X_12804_ _05126_ _07253_ _07254_ VDD VSS NAND2_X1
X_12805_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[47\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[47\]
+ _07242_ _07255_ VDD VSS MUX2_X1
X_12806_ _05126_ _07256_ VDD VSS BUF_X4
X_12807_ _07254_ _07255_ _07256_ _10197_ VDD VSS OAI21_X4
X_12808_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[46\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[46\]
+ _05132_ _07257_ VDD VSS MUX2_X1
X_12809_ _07257_ _07258_ VDD VSS INV_X1
X_12810_ _07256_ _07258_ _07259_ VDD VSS NAND2_X1
X_12811_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[46\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[46\]
+ _07242_ _07260_ VDD VSS MUX2_X1
X_12812_ _07259_ _05127_ _07260_ _10200_ VDD VSS OAI21_X4
X_12813_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[41\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[41\]
+ _07246_ _07261_ VDD VSS MUX2_X1
X_12814_ _07261_ _07262_ VDD VSS INV_X2
X_12815_ _07244_ _07262_ _07263_ VDD VSS NAND2_X2
X_12816_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[41\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[41\]
+ _07250_ _07264_ VDD VSS MUX2_X1
X_12817_ _07263_ _07244_ _07264_ _10203_ VDD VSS OAI21_X4
X_12818_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[37\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[37\]
+ _05136_ _07265_ VDD VSS MUX2_X1
X_12819_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[37\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[37\]
+ _05136_ _07266_ VDD VSS MUX2_X1
X_12820_ _07265_ _07266_ _07256_ _07267_ VDD VSS MUX2_X2
X_12821_ _07267_ _10215_ VDD VSS INV_X4
X_12822_ _05152_ _07268_ VDD VSS CLKBUF_X3
X_12823_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[45\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[45\]
+ net737 _07269_ VDD VSS MUX2_X1
X_12824_ _07268_ _07269_ _07270_ VDD VSS OR2_X1
X_12825_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[45\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[45\]
+ _05147_ _07271_ VDD VSS MUX2_X1
X_12826_ _05201_ _07272_ VDD VSS BUF_X8
X_12827_ _07270_ _07271_ _07272_ _10240_ VDD VSS OAI21_X4
X_12828_ _05144_ _07273_ VDD VSS BUF_X32
X_12829_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[37\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[37\]
+ _07273_ _07274_ VDD VSS MUX2_X1
X_12830_ _07268_ _07274_ _07275_ VDD VSS OR2_X1
X_12831_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[37\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[37\]
+ _05147_ _07276_ VDD VSS MUX2_X1
X_12832_ _07275_ _07276_ _07272_ _10258_ VDD VSS OAI21_X4
X_12833_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[39\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[39\]
+ _05146_ _07277_ VDD VSS MUX2_X1
X_12834_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[39\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[39\]
+ _05146_ _07278_ VDD VSS MUX2_X1
X_12835_ _07277_ _07278_ _05152_ _07279_ VDD VSS MUX2_X2
X_12836_ _07279_ _10270_ VDD VSS INV_X4
X_12837_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[38\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[38\]
+ _05144_ _07280_ VDD VSS MUX2_X1
X_12838_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[38\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[38\]
+ _05144_ _07281_ VDD VSS MUX2_X1
X_12839_ _07280_ _07281_ _05152_ _07282_ VDD VSS MUX2_X2
X_12840_ _07282_ _10273_ VDD VSS INV_X2
X_12841_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[37\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[37\]
+ _05314_ _07283_ VDD VSS MUX2_X1
X_12842_ _05321_ _07283_ _07284_ VDD VSS OR2_X2
X_12843_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[37\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[37\]
+ _05315_ _07285_ VDD VSS MUX2_X1
X_12844_ _07284_ _07285_ _05326_ _10312_ VDD VSS OAI21_X4
X_12845_ _05456_ _07286_ VDD VSS BUF_X16
X_12846_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[47\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[47\]
+ _07286_ _07287_ VDD VSS MUX2_X1
X_12847_ _05468_ _07287_ _07288_ VDD VSS OR2_X1
X_12848_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[47\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[47\]
+ net721 _07289_ VDD VSS MUX2_X1
X_12849_ _05495_ _07290_ VDD VSS BUF_X8
X_12850_ _07288_ _07289_ _07290_ _10330_ VDD VSS OAI21_X4
X_12851_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[46\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[46\]
+ _05459_ _07291_ VDD VSS MUX2_X1
X_12852_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[46\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[46\]
+ _05459_ _07292_ VDD VSS MUX2_X1
X_12853_ _07291_ _07292_ _05465_ _07293_ VDD VSS MUX2_X2
X_12854_ _07293_ _10333_ VDD VSS INV_X4
X_12855_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[45\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[45\]
+ net717 _07294_ VDD VSS MUX2_X1
X_12856_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[45\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[45\]
+ _05456_ _07295_ VDD VSS MUX2_X1
X_12857_ _07294_ _07295_ _05463_ _07296_ VDD VSS MUX2_X2
X_12858_ _07296_ _10336_ VDD VSS INV_X2
X_12859_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[43\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[43\]
+ _05458_ _07297_ VDD VSS MUX2_X1
X_12860_ _05468_ _07297_ _07298_ VDD VSS OR2_X1
X_12861_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[43\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[43\]
+ _07286_ _07299_ VDD VSS MUX2_X1
X_12862_ _07298_ _07299_ _07290_ _10342_ VDD VSS OAI21_X4
X_12863_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[35\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[35\]
+ net720 _07300_ VDD VSS MUX2_X1
X_12864_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[35\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[35\]
+ net720 _07301_ VDD VSS MUX2_X1
X_12865_ _07300_ _07301_ _05463_ _07302_ VDD VSS MUX2_X2
X_12866_ _07302_ _10351_ VDD VSS INV_X4
X_12867_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[37\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[37\]
+ _05456_ _07303_ VDD VSS MUX2_X1
X_12868_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[37\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[37\]
+ _05456_ _07304_ VDD VSS MUX2_X1
X_12869_ _07303_ _07304_ _05463_ _07305_ VDD VSS MUX2_X2
X_12870_ _07305_ _10354_ VDD VSS INV_X1
X_12871_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[39\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[39\]
+ net720 _07306_ VDD VSS MUX2_X1
X_12872_ _05468_ _07306_ _07307_ VDD VSS OR2_X1
X_12873_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[39\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[39\]
+ _07286_ _07308_ VDD VSS MUX2_X1
X_12874_ _07307_ _07308_ _07290_ _10366_ VDD VSS OAI21_X4
X_12875_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[38\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[38\]
+ net720 _07309_ VDD VSS MUX2_X1
X_12876_ _05468_ _07309_ _07310_ VDD VSS OR2_X1
X_12877_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[38\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[38\]
+ _07286_ _07311_ VDD VSS MUX2_X1
X_12878_ _07310_ _07311_ _07290_ _10369_ VDD VSS OAI21_X4
X_12879_ _05703_ _07312_ VDD VSS BUF_X4
X_12880_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[45\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[45\]
+ _07312_ _07313_ VDD VSS MUX2_X1
X_12881_ _05703_ _07314_ VDD VSS BUF_X4
X_12882_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[45\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[45\]
+ _07314_ _07315_ VDD VSS MUX2_X1
X_12883_ _05710_ _07316_ VDD VSS BUF_X4
X_12884_ _07313_ _07315_ _07316_ _07317_ VDD VSS MUX2_X1
X_12885_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[45\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[45\]
+ _07314_ _07318_ VDD VSS MUX2_X1
X_12886_ _05703_ _07319_ VDD VSS BUF_X4
X_12887_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[45\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[45\]
+ _07319_ _07320_ VDD VSS MUX2_X1
X_12888_ _05710_ _07321_ VDD VSS BUF_X4
X_12889_ _07318_ _07320_ _07321_ _07322_ VDD VSS MUX2_X1
X_12890_ _05720_ _07323_ VDD VSS BUF_X4
X_12891_ _07317_ _07322_ _07323_ _07324_ VDD VSS MUX2_X1
X_12892_ _05702_ _07325_ VDD VSS BUF_X4
X_12893_ _07325_ _07326_ VDD VSS BUF_X4
X_12894_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[45\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[45\]
+ _07326_ _07327_ VDD VSS MUX2_X1
X_12895_ _07325_ _07328_ VDD VSS BUF_X4
X_12896_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[45\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[45\]
+ _07328_ _07329_ VDD VSS MUX2_X1
X_12897_ _05710_ _07330_ VDD VSS BUF_X4
X_12898_ _07327_ _07329_ _07330_ _07331_ VDD VSS MUX2_X1
X_12899_ _07325_ _07332_ VDD VSS BUF_X4
X_12900_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[45\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[45\]
+ _07332_ _07333_ VDD VSS MUX2_X1
X_12901_ _07325_ _07334_ VDD VSS BUF_X4
X_12902_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[45\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[45\]
+ _07334_ _07335_ VDD VSS MUX2_X1
X_12903_ _05709_ _07336_ VDD VSS BUF_X4
X_12904_ _07336_ _07337_ VDD VSS BUF_X4
X_12905_ _07333_ _07335_ _07337_ _07338_ VDD VSS MUX2_X1
X_12906_ _05720_ _07339_ VDD VSS BUF_X4
X_12907_ _07331_ _07338_ _07339_ _07340_ VDD VSS MUX2_X1
X_12908_ _05738_ _07341_ VDD VSS BUF_X4
X_12909_ _07324_ _07340_ _07341_ _07342_ VDD VSS MUX2_X2
X_12910_ _07342_ _10378_ VDD VSS INV_X1
X_12911_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[47\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[47\]
+ _07312_ _07343_ VDD VSS MUX2_X1
X_12912_ _05703_ _07344_ VDD VSS BUF_X4
X_12913_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[47\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[47\]
+ _07344_ _07345_ VDD VSS MUX2_X1
X_12914_ _07343_ _07345_ _05729_ _07346_ VDD VSS MUX2_X1
X_12915_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[47\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[47\]
+ _07344_ _07347_ VDD VSS MUX2_X1
X_12916_ _05703_ _07348_ VDD VSS BUF_X4
X_12917_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[47\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[47\]
+ _07348_ _07349_ VDD VSS MUX2_X1
X_12918_ _07347_ _07349_ _07316_ _07350_ VDD VSS MUX2_X1
X_12919_ _07346_ _07350_ _05721_ _07351_ VDD VSS MUX2_X1
X_12920_ _07325_ _07352_ VDD VSS BUF_X4
X_12921_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[47\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[47\]
+ _07352_ _07353_ VDD VSS MUX2_X1
X_12922_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[47\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[47\]
+ _07326_ _07354_ VDD VSS MUX2_X1
X_12923_ _07353_ _07354_ _07330_ _07355_ VDD VSS MUX2_X1
X_12924_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[47\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[47\]
+ _07328_ _07356_ VDD VSS MUX2_X1
X_12925_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[47\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[47\]
+ _07334_ _07357_ VDD VSS MUX2_X1
X_12926_ _07336_ _07358_ VDD VSS BUF_X4
X_12927_ _07356_ _07357_ _07358_ _07359_ VDD VSS MUX2_X1
X_12928_ _07355_ _07359_ _07339_ _07360_ VDD VSS MUX2_X1
X_12929_ _07351_ _07360_ _07341_ _07361_ VDD VSS MUX2_X2
X_12930_ _07361_ _10390_ VDD VSS INV_X1
X_12931_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[46\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[46\]
+ _05724_ _07362_ VDD VSS MUX2_X1
X_12932_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[46\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[46\]
+ _07344_ _07363_ VDD VSS MUX2_X1
X_12933_ _07362_ _07363_ _05729_ _07364_ VDD VSS MUX2_X1
X_12934_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[46\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[46\]
+ _07344_ _07365_ VDD VSS MUX2_X1
X_12935_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[46\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[46\]
+ _07348_ _07366_ VDD VSS MUX2_X1
X_12936_ _07365_ _07366_ _07316_ _07367_ VDD VSS MUX2_X1
X_12937_ _07364_ _07367_ _05721_ _07368_ VDD VSS MUX2_X1
X_12938_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[46\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[46\]
+ _07352_ _07369_ VDD VSS MUX2_X1
X_12939_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[46\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[46\]
+ _07326_ _07370_ VDD VSS MUX2_X1
X_12940_ _07369_ _07370_ _07330_ _07371_ VDD VSS MUX2_X1
X_12941_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[46\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[46\]
+ _07328_ _07372_ VDD VSS MUX2_X1
X_12942_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[46\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[46\]
+ _07334_ _07373_ VDD VSS MUX2_X1
X_12943_ _07372_ _07373_ _07358_ _07374_ VDD VSS MUX2_X1
X_12944_ _07371_ _07374_ _07339_ _07375_ VDD VSS MUX2_X1
X_12945_ _07368_ _07375_ _07341_ _07376_ VDD VSS MUX2_X2
X_12946_ _07376_ _10393_ VDD VSS INV_X1
X_12947_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[41\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[41\]
+ _07319_ _07377_ VDD VSS MUX2_X1
X_12948_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[41\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[41\]
+ _07319_ _07378_ VDD VSS MUX2_X1
X_12949_ _07377_ _07378_ _07321_ _07379_ VDD VSS MUX2_X1
X_12950_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[41\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[41\]
+ _07319_ _07380_ VDD VSS MUX2_X1
X_12951_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[41\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[41\]
+ _07352_ _07381_ VDD VSS MUX2_X1
X_12952_ _07380_ _07381_ _07321_ _07382_ VDD VSS MUX2_X1
X_12953_ _07379_ _07382_ _07323_ _07383_ VDD VSS MUX2_X1
X_12954_ _07325_ _07384_ VDD VSS BUF_X4
X_12955_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[41\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[41\]
+ _07384_ _07385_ VDD VSS MUX2_X1
X_12956_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[41\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[41\]
+ _07384_ _07386_ VDD VSS MUX2_X1
X_12957_ _07385_ _07386_ _07337_ _07387_ VDD VSS MUX2_X1
X_12958_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[41\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[41\]
+ _07384_ _07388_ VDD VSS MUX2_X1
X_12959_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[41\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[41\]
+ _07384_ _07389_ VDD VSS MUX2_X1
X_12960_ _07388_ _07389_ _07337_ _07390_ VDD VSS MUX2_X1
X_12961_ _05720_ _07391_ VDD VSS BUF_X4
X_12962_ _07387_ _07390_ _07391_ _07392_ VDD VSS MUX2_X1
X_12963_ _05737_ _07393_ VDD VSS BUF_X4
X_12964_ _07383_ _07392_ _07393_ _07394_ VDD VSS MUX2_X2
X_12965_ _07394_ _10396_ VDD VSS INV_X1
X_12966_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[37\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[37\]
+ _07312_ _07395_ VDD VSS MUX2_X1
X_12967_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[37\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[37\]
+ _07314_ _07396_ VDD VSS MUX2_X1
X_12968_ _07395_ _07396_ _07316_ _07397_ VDD VSS MUX2_X1
X_12969_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[37\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[37\]
+ _07348_ _07398_ VDD VSS MUX2_X1
X_12970_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[37\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[37\]
+ _07319_ _07399_ VDD VSS MUX2_X1
X_12971_ _07398_ _07399_ _07321_ _07400_ VDD VSS MUX2_X1
X_12972_ _07397_ _07400_ _07323_ _07401_ VDD VSS MUX2_X1
X_12973_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[37\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[37\]
+ _07326_ _07402_ VDD VSS MUX2_X1
X_12974_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[37\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[37\]
+ _07332_ _07403_ VDD VSS MUX2_X1
X_12975_ _07402_ _07403_ _07358_ _07404_ VDD VSS MUX2_X1
X_12976_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[37\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[37\]
+ _07332_ _07405_ VDD VSS MUX2_X1
X_12977_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[37\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[37\]
+ _07334_ _07406_ VDD VSS MUX2_X1
X_12978_ _07405_ _07406_ _07337_ _07407_ VDD VSS MUX2_X1
X_12979_ _07404_ _07407_ _07391_ _07408_ VDD VSS MUX2_X1
X_12980_ _07401_ _07408_ _07393_ _07409_ VDD VSS MUX2_X2
X_12981_ _07409_ _10408_ VDD VSS INV_X1
X_12982_ net293 _10463_ VDD VSS INV_X2
X_12983_ net291 _10471_ VDD VSS INV_X2
X_12984_ net294 _10497_ VDD VSS INV_X2
X_12985_ net290 _10505_ VDD VSS INV_X2
X_12986_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[43\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[43\]
+ _05132_ _07410_ VDD VSS MUX2_X1
X_12987_ _07410_ _07411_ VDD VSS INV_X2
X_12988_ _07256_ _07411_ _07412_ VDD VSS NAND2_X4
X_12989_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[43\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[43\]
+ _07242_ _07413_ VDD VSS MUX2_X1
X_12990_ _07412_ _05127_ _07413_ _10182_ VDD VSS OAI21_X4
X_12991_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[44\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[44\]
+ _05132_ _07414_ VDD VSS MUX2_X1
X_12992_ _07414_ _07415_ VDD VSS INV_X2
X_12993_ _07256_ _07415_ _07416_ VDD VSS NAND2_X2
X_12994_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[44\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[44\]
+ _07242_ _07417_ VDD VSS MUX2_X1
X_12995_ _07416_ _05127_ _07417_ _10188_ VDD VSS OAI21_X4
X_12996_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[48\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[48\]
+ _07242_ _07418_ VDD VSS MUX2_X1
X_12997_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[48\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[48\]
+ _07242_ _07419_ VDD VSS MUX2_X1
X_12998_ _07418_ _07419_ _05127_ _07420_ VDD VSS MUX2_X2
X_12999_ _07420_ _10194_ VDD VSS INV_X1
X_13000_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[40\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[40\]
+ net743 _07421_ VDD VSS MUX2_X1
X_13001_ _07421_ _07422_ VDD VSS INV_X1
X_13002_ _07256_ _07422_ _07423_ VDD VSS NAND2_X1
X_13003_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[40\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[40\]
+ _07242_ _07424_ VDD VSS MUX2_X1
X_13004_ _07423_ _07424_ _05127_ _10206_ VDD VSS OAI21_X4
X_13005_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[39\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[39\]
+ net765 _07425_ VDD VSS MUX2_X1
X_13006_ _07425_ _07426_ VDD VSS INV_X1
X_13007_ _07256_ _07426_ _07427_ VDD VSS NAND2_X1
X_13008_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[39\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[39\]
+ _07242_ _07428_ VDD VSS MUX2_X1
X_13009_ _07427_ _07428_ _05127_ _10209_ VDD VSS OAI21_X4
X_13010_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[38\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[38\]
+ _07242_ _07429_ VDD VSS MUX2_X1
X_13011_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[38\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[38\]
+ net745 _07430_ VDD VSS MUX2_X1
X_13012_ _07429_ _07430_ _05126_ _07431_ VDD VSS MUX2_X2
X_13013_ _07431_ _10212_ VDD VSS INV_X1
X_13014_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[36\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[36\]
+ _05136_ _07432_ VDD VSS MUX2_X1
X_13015_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[36\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[36\]
+ _05136_ _07433_ VDD VSS MUX2_X1
X_13016_ _07432_ _07433_ _07256_ _07434_ VDD VSS MUX2_X2
X_13017_ _07434_ _10218_ VDD VSS INV_X2
X_13018_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[35\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[35\]
+ net743 _07435_ VDD VSS MUX2_X1
X_13019_ _07435_ _07436_ VDD VSS INV_X1
X_13020_ _07256_ _07436_ _07437_ VDD VSS NAND2_X1
X_13021_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[35\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[35\]
+ net743 _07438_ VDD VSS MUX2_X1
X_13022_ _07437_ _07438_ _07256_ _10221_ VDD VSS OAI21_X4
X_13023_ _05153_ _07439_ VDD VSS BUF_X4
X_13024_ _07273_ _07440_ VDD VSS BUF_X16
X_13025_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[49\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[49\]
+ _07440_ _07441_ VDD VSS MUX2_X1
X_13026_ _07441_ _07439_ _07442_ VDD VSS OR2_X4
X_13027_ _05147_ _07443_ VDD VSS BUF_X16
X_13028_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[49\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[49\]
+ _07443_ _07444_ VDD VSS MUX2_X1
X_13029_ _07272_ _07445_ VDD VSS BUF_X4
X_13030_ _07445_ _07446_ VDD VSS BUF_X8
X_13031_ _07442_ _07444_ _07446_ _10228_ VDD VSS OAI21_X4
X_13032_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[48\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[48\]
+ _07273_ _07447_ VDD VSS MUX2_X1
X_13033_ _07268_ _07447_ _07448_ VDD VSS OR2_X1
X_13034_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[48\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[48\]
+ _05147_ _07449_ VDD VSS MUX2_X1
X_13035_ _07448_ _07449_ _07272_ _10231_ VDD VSS OAI21_X4
X_13036_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[47\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[47\]
+ _05146_ _07450_ VDD VSS MUX2_X1
X_13037_ _07268_ _07450_ _07451_ VDD VSS OR2_X2
X_13038_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[47\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[47\]
+ _07273_ _07452_ VDD VSS MUX2_X1
X_13039_ _07451_ _07452_ _07272_ _10234_ VDD VSS OAI21_X4
X_13040_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[46\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[46\]
+ net737 _07453_ VDD VSS MUX2_X1
X_13041_ _05152_ _07453_ _07454_ VDD VSS OR2_X1
X_13042_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[46\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[46\]
+ _07273_ _07455_ VDD VSS MUX2_X1
X_13043_ _07454_ _07455_ _07272_ _10237_ VDD VSS OAI21_X4
X_13044_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[44\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[44\]
+ net737 _07456_ VDD VSS MUX2_X1
X_13045_ _07268_ _07456_ _07457_ VDD VSS OR2_X1
X_13046_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[44\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[44\]
+ _07273_ _07458_ VDD VSS MUX2_X1
X_13047_ _07457_ _07458_ _07272_ _10243_ VDD VSS OAI21_X4
X_13048_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[43\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[43\]
+ _05146_ _07459_ VDD VSS MUX2_X1
X_13049_ _07268_ _07459_ _07460_ VDD VSS OR2_X2
X_13050_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[43\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[43\]
+ _07273_ _07461_ VDD VSS MUX2_X1
X_13051_ _07460_ _07461_ _07272_ _10246_ VDD VSS OAI21_X4
X_13052_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[35\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[35\]
+ net737 _07462_ VDD VSS MUX2_X1
X_13053_ _07268_ _07462_ _07463_ VDD VSS OR2_X1
X_13054_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[35\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[35\]
+ _07273_ _07464_ VDD VSS MUX2_X1
X_13055_ _07463_ _07464_ _07272_ _10255_ VDD VSS OAI21_X4
X_13056_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[36\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[36\]
+ net737 _07465_ VDD VSS MUX2_X1
X_13057_ _07268_ _07465_ _07466_ VDD VSS OR2_X1
X_13058_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[36\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[36\]
+ _05147_ _07467_ VDD VSS MUX2_X1
X_13059_ _07466_ _07467_ _07272_ _10261_ VDD VSS OAI21_X4
X_13060_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[41\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[41\]
+ _07440_ _07468_ VDD VSS MUX2_X1
X_13061_ _07439_ _07468_ _07469_ VDD VSS OR2_X2
X_13062_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[41\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[41\]
+ _07443_ _07470_ VDD VSS MUX2_X1
X_13063_ _07469_ _07446_ _07470_ _10264_ VDD VSS OAI21_X4
X_13064_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[40\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[40\]
+ _05147_ _07471_ VDD VSS MUX2_X1
X_13065_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[40\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[40\]
+ _05147_ _07472_ VDD VSS MUX2_X1
X_13066_ _07471_ _07472_ _05153_ _07473_ VDD VSS MUX2_X2
X_13067_ _07473_ _10267_ VDD VSS INV_X1
X_13068_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[43\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[43\]
+ _05310_ _07474_ VDD VSS MUX2_X1
X_13069_ _05320_ _07474_ _07475_ VDD VSS OR2_X1
X_13070_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[43\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[43\]
+ _05312_ _07476_ VDD VSS MUX2_X1
X_13071_ _07475_ _07476_ _05326_ _10279_ VDD VSS OAI21_X4
X_13072_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[44\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[44\]
+ _05315_ _07477_ VDD VSS MUX2_X1
X_13073_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[44\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[44\]
+ _05315_ _07478_ VDD VSS MUX2_X1
X_13074_ _07477_ _07478_ _05321_ _07479_ VDD VSS MUX2_X2
X_13075_ _07479_ _10282_ VDD VSS INV_X1
X_13076_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[45\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[45\]
+ _05314_ _07480_ VDD VSS MUX2_X1
X_13077_ _05320_ _07480_ _07481_ VDD VSS OR2_X1
X_13078_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[45\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[45\]
+ _05312_ _07482_ VDD VSS MUX2_X1
X_13079_ _07481_ _07482_ _05326_ _10285_ VDD VSS OAI21_X4
X_13080_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[46\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[46\]
+ _05314_ _07483_ VDD VSS MUX2_X1
X_13081_ _05321_ _07483_ _07484_ VDD VSS OR2_X1
X_13082_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[46\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[46\]
+ _05312_ _07485_ VDD VSS MUX2_X1
X_13083_ _07484_ _07485_ _05326_ _10288_ VDD VSS OAI21_X4
X_13084_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[47\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[47\]
+ _05312_ _07486_ VDD VSS MUX2_X1
X_13085_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[47\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[47\]
+ _05312_ _07487_ VDD VSS MUX2_X1
X_13086_ _05320_ _07488_ VDD VSS BUF_X4
X_13087_ _07486_ _07487_ _07488_ _07489_ VDD VSS MUX2_X2
X_13088_ _07489_ _10291_ VDD VSS INV_X1
X_13089_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[48\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[48\]
+ _05314_ _07490_ VDD VSS MUX2_X1
X_13090_ _05321_ _07490_ _07491_ VDD VSS OR2_X1
X_13091_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[48\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[48\]
+ _05312_ _07492_ VDD VSS MUX2_X1
X_13092_ _07491_ _07492_ _05326_ _10294_ VDD VSS OAI21_X4
X_13093_ _07488_ _07493_ VDD VSS BUF_X4
X_13094_ _05312_ _07494_ VDD VSS BUF_X16
X_13095_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[49\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[49\]
+ _07494_ _07495_ VDD VSS MUX2_X1
X_13096_ _07493_ _07495_ _07496_ VDD VSS OR2_X1
X_13097_ _05315_ _07497_ VDD VSS BUF_X16
X_13098_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[49\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[49\]
+ _07497_ _07498_ VDD VSS MUX2_X1
X_13099_ _05326_ _07499_ VDD VSS BUF_X16
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
X_13101_ _07496_ _07498_ _07499_ _10297_ VDD VSS OAI21_X4
X_13102_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[41\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[41\]
+ _07494_ _07501_ VDD VSS MUX2_X1
X_13103_ _07501_ _07493_ _07502_ VDD VSS OR2_X4
X_13104_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[41\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[41\]
+ _07497_ _07503_ VDD VSS MUX2_X1
X_13105_ _07502_ _07499_ _07503_ _10300_ VDD VSS OAI21_X4
X_13106_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[40\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[40\]
+ _05310_ _07504_ VDD VSS MUX2_X1
X_13107_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[40\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[40\]
+ _05310_ _07505_ VDD VSS MUX2_X1
X_13108_ _07504_ _07505_ _05320_ _07506_ VDD VSS MUX2_X2
X_13109_ _07506_ _10303_ VDD VSS INV_X2
X_13110_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[39\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[39\]
+ _05315_ _07507_ VDD VSS MUX2_X1
X_13111_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[39\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[39\]
+ _05315_ _07508_ VDD VSS MUX2_X1
X_13112_ _07507_ _07508_ _05321_ _07509_ VDD VSS MUX2_X2
X_13113_ _07509_ _10306_ VDD VSS INV_X2
X_13114_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[38\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[38\]
+ _05314_ _07510_ VDD VSS MUX2_X1
X_13115_ _05321_ _07510_ _07511_ VDD VSS OR2_X1
X_13116_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[38\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[38\]
+ _05312_ _07512_ VDD VSS MUX2_X1
X_13117_ _07511_ _07512_ _05326_ _10309_ VDD VSS OAI21_X4
X_13118_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[36\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[36\]
+ net728 _07513_ VDD VSS MUX2_X1
X_13119_ _05320_ _07513_ _07514_ VDD VSS OR2_X1
X_13120_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[36\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[36\]
+ _05314_ _07515_ VDD VSS MUX2_X1
X_13121_ _07514_ _07515_ _05326_ _10315_ VDD VSS OAI21_X4
X_13122_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[35\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[35\]
+ _05315_ _07516_ VDD VSS MUX2_X1
X_13123_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[35\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[35\]
+ _05315_ _07517_ VDD VSS MUX2_X1
X_13124_ _07516_ _07517_ _05321_ _07518_ VDD VSS MUX2_X2
X_13125_ _07518_ _10318_ VDD VSS INV_X1
X_13126_ _05468_ _07519_ VDD VSS BUF_X2
X_13127_ _07286_ _07520_ VDD VSS BUF_X16
X_13128_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[49\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[49\]
+ _07520_ _07521_ VDD VSS MUX2_X1
X_13129_ _07519_ _07521_ _07522_ VDD VSS OR2_X2
X_13130_ _05459_ _07523_ VDD VSS BUF_X8
X_13131_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[49\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[49\]
+ _07523_ _07524_ VDD VSS MUX2_X1
X_13132_ _07290_ _07525_ VDD VSS BUF_X8
X_13133_ _07525_ _07526_ VDD VSS BUF_X8
X_13134_ _07522_ _07526_ _07524_ _10324_ VDD VSS OAI21_X4
X_13135_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[48\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[48\]
+ net720 _07527_ VDD VSS MUX2_X1
X_13136_ _05463_ _07527_ _07528_ VDD VSS OR2_X1
X_13137_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[48\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[48\]
+ _07286_ _07529_ VDD VSS MUX2_X1
X_13138_ _07528_ _07529_ _07290_ _10327_ VDD VSS OAI21_X4
X_13139_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[44\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[44\]
+ _05458_ _07530_ VDD VSS MUX2_X1
X_13140_ _05468_ _07530_ _07531_ VDD VSS OR2_X1
X_13141_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[44\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[44\]
+ net721 _07532_ VDD VSS MUX2_X1
X_13142_ _07531_ _07532_ _07290_ _10339_ VDD VSS OAI21_X4
X_13143_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[36\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[36\]
+ _05458_ _07533_ VDD VSS MUX2_X1
X_13144_ _05463_ _07533_ _07534_ VDD VSS OR2_X1
X_13145_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[36\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[36\]
+ _07286_ _07535_ VDD VSS MUX2_X1
X_13146_ _07534_ _07535_ _07290_ _10357_ VDD VSS OAI21_X4
X_13147_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[41\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[41\]
+ _07520_ _07536_ VDD VSS MUX2_X1
X_13148_ _07519_ _07536_ _07537_ VDD VSS OR2_X2
X_13149_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[41\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[41\]
+ _07523_ _07538_ VDD VSS MUX2_X1
X_13150_ _07537_ _07538_ _07526_ _10360_ VDD VSS OAI21_X4
X_13151_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[40\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[40\]
+ _05458_ _07539_ VDD VSS MUX2_X1
X_13152_ _05468_ _07539_ _07540_ VDD VSS OR2_X2
X_13153_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[40\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[40\]
+ _07286_ _07541_ VDD VSS MUX2_X1
X_13154_ _07540_ _07541_ _07290_ _10363_ VDD VSS OAI21_X4
X_13155_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[43\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[43\]
+ _07312_ _07542_ VDD VSS MUX2_X1
X_13156_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[43\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[43\]
+ _07314_ _07543_ VDD VSS MUX2_X1
X_13157_ _07542_ _07543_ _05729_ _07544_ VDD VSS MUX2_X1
X_13158_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[43\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[43\]
+ _07314_ _07545_ VDD VSS MUX2_X1
X_13159_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[43\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[43\]
+ _07348_ _07546_ VDD VSS MUX2_X1
X_13160_ _07545_ _07546_ _07321_ _07547_ VDD VSS MUX2_X1
X_13161_ _07544_ _07547_ _07323_ _07548_ VDD VSS MUX2_X1
X_13162_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[43\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[43\]
+ _07352_ _07549_ VDD VSS MUX2_X1
X_13163_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[43\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[43\]
+ _07328_ _07550_ VDD VSS MUX2_X1
X_13164_ _07549_ _07550_ _07330_ _07551_ VDD VSS MUX2_X1
X_13165_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[43\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[43\]
+ _07332_ _07552_ VDD VSS MUX2_X1
X_13166_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[43\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[43\]
+ _07334_ _07553_ VDD VSS MUX2_X1
X_13167_ _07552_ _07553_ _07358_ _07554_ VDD VSS MUX2_X1
X_13168_ _07551_ _07554_ _07339_ _07555_ VDD VSS MUX2_X1
X_13169_ _07548_ _07555_ _07341_ _07556_ VDD VSS MUX2_X2
X_13170_ _07556_ _10375_ VDD VSS INV_X1
X_13171_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[44\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[44\]
+ _05724_ _07557_ VDD VSS MUX2_X1
X_13172_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[44\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[44\]
+ _07344_ _07558_ VDD VSS MUX2_X1
X_13173_ _07557_ _07558_ _05729_ _07559_ VDD VSS MUX2_X1
X_13174_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[44\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[44\]
+ _07344_ _07560_ VDD VSS MUX2_X1
X_13175_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[44\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[44\]
+ _07348_ _07561_ VDD VSS MUX2_X1
X_13176_ _07560_ _07561_ _07316_ _07562_ VDD VSS MUX2_X1
X_13177_ _07559_ _07562_ _05721_ _07563_ VDD VSS MUX2_X1
X_13178_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[44\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[44\]
+ _07352_ _07564_ VDD VSS MUX2_X1
X_13179_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[44\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[44\]
+ _07326_ _07565_ VDD VSS MUX2_X1
X_13180_ _07564_ _07565_ _07330_ _07566_ VDD VSS MUX2_X1
X_13181_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[44\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[44\]
+ _07328_ _07567_ VDD VSS MUX2_X1
X_13182_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[44\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[44\]
+ _07334_ _07568_ VDD VSS MUX2_X1
X_13183_ _07567_ _07568_ _07358_ _07569_ VDD VSS MUX2_X1
X_13184_ _07566_ _07569_ _07339_ _07570_ VDD VSS MUX2_X1
X_13185_ _07563_ _07570_ _07341_ _07571_ VDD VSS MUX2_X2
X_13186_ _07571_ _10381_ VDD VSS INV_X1
X_13187_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[49\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[49\]
+ _07319_ _07572_ VDD VSS MUX2_X1
X_13188_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[49\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[49\]
+ _07319_ _07573_ VDD VSS MUX2_X1
X_13189_ _07572_ _07573_ _07321_ _07574_ VDD VSS MUX2_X1
X_13190_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[49\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[49\]
+ _07319_ _07575_ VDD VSS MUX2_X1
X_13191_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[49\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[49\]
+ _07352_ _07576_ VDD VSS MUX2_X1
X_13192_ _07575_ _07576_ _07321_ _07577_ VDD VSS MUX2_X1
X_13193_ _07574_ _07577_ _07323_ _07578_ VDD VSS MUX2_X1
X_13194_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[49\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[49\]
+ _07384_ _07579_ VDD VSS MUX2_X1
X_13195_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[49\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[49\]
+ _07384_ _07580_ VDD VSS MUX2_X1
X_13196_ _07579_ _07580_ _07337_ _07581_ VDD VSS MUX2_X1
X_13197_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[49\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[49\]
+ _07384_ _07582_ VDD VSS MUX2_X1
X_13198_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[49\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[49\]
+ _07384_ _07583_ VDD VSS MUX2_X1
X_13199_ _07582_ _07583_ _07337_ _07584_ VDD VSS MUX2_X1
X_13200_ _07581_ _07584_ _07391_ _07585_ VDD VSS MUX2_X1
X_13201_ _07578_ _07585_ _07393_ _07586_ VDD VSS MUX2_X2
X_13202_ _07586_ _10384_ VDD VSS INV_X1
X_13203_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[48\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[48\]
+ _05724_ _07587_ VDD VSS MUX2_X1
X_13204_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[48\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[48\]
+ _07312_ _07588_ VDD VSS MUX2_X1
X_13205_ _07587_ _07588_ _05729_ _07589_ VDD VSS MUX2_X1
X_13206_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[48\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[48\]
+ _07344_ _07590_ VDD VSS MUX2_X1
X_13207_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[48\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[48\]
+ _07348_ _07591_ VDD VSS MUX2_X1
X_13208_ _07590_ _07591_ _07316_ _07592_ VDD VSS MUX2_X1
X_13209_ _07589_ _07592_ _05721_ _07593_ VDD VSS MUX2_X1
X_13210_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[48\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[48\]
+ _07352_ _07594_ VDD VSS MUX2_X1
X_13211_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[48\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[48\]
+ _07326_ _07595_ VDD VSS MUX2_X1
X_13212_ _07594_ _07595_ _07330_ _07596_ VDD VSS MUX2_X1
X_13213_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[48\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[48\]
+ _07328_ _07597_ VDD VSS MUX2_X1
X_13214_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[48\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[48\]
+ _07332_ _07598_ VDD VSS MUX2_X1
X_13215_ _07597_ _07598_ _07358_ _07599_ VDD VSS MUX2_X1
X_13216_ _07596_ _07599_ _07339_ _07600_ VDD VSS MUX2_X1
X_13217_ _07593_ _07600_ _07341_ _07601_ VDD VSS MUX2_X2
X_13218_ _07601_ _10387_ VDD VSS INV_X1
X_13219_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[40\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[40\]
+ _07312_ _07602_ VDD VSS MUX2_X1
X_13220_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[40\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[40\]
+ _07314_ _07603_ VDD VSS MUX2_X1
X_13221_ _07602_ _07603_ _07316_ _07604_ VDD VSS MUX2_X1
X_13222_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[40\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[40\]
+ _07348_ _07605_ VDD VSS MUX2_X1
X_13223_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[40\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[40\]
+ _07319_ _07606_ VDD VSS MUX2_X1
X_13224_ _07605_ _07606_ _07321_ _07607_ VDD VSS MUX2_X1
X_13225_ _07604_ _07607_ _07323_ _07608_ VDD VSS MUX2_X1
X_13226_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[40\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[40\]
+ _07326_ _07609_ VDD VSS MUX2_X1
X_13227_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[40\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[40\]
+ _07332_ _07610_ VDD VSS MUX2_X1
X_13228_ _07609_ _07610_ _07358_ _07611_ VDD VSS MUX2_X1
X_13229_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[40\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[40\]
+ _07332_ _07612_ VDD VSS MUX2_X1
X_13230_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[40\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[40\]
+ _07334_ _07613_ VDD VSS MUX2_X1
X_13231_ _07612_ _07613_ _07337_ _07614_ VDD VSS MUX2_X1
X_13232_ _07611_ _07614_ _07339_ _07615_ VDD VSS MUX2_X1
X_13233_ _07608_ _07615_ _07341_ _07616_ VDD VSS MUX2_X2
X_13234_ _07616_ _10399_ VDD VSS INV_X1
X_13235_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[39\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[39\]
+ _07312_ _07617_ VDD VSS MUX2_X1
X_13236_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[39\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[39\]
+ _07344_ _07618_ VDD VSS MUX2_X1
X_13237_ _07617_ _07618_ _05729_ _07619_ VDD VSS MUX2_X1
X_13238_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[39\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[39\]
+ _07314_ _07620_ VDD VSS MUX2_X1
X_13239_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[39\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[39\]
+ _07348_ _07621_ VDD VSS MUX2_X1
X_13240_ _07620_ _07621_ _07321_ _07622_ VDD VSS MUX2_X1
X_13241_ _07619_ _07622_ _07323_ _07623_ VDD VSS MUX2_X1
X_13242_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[39\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[39\]
+ _07352_ _07624_ VDD VSS MUX2_X1
X_13243_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[39\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[39\]
+ _07328_ _07625_ VDD VSS MUX2_X1
X_13244_ _07624_ _07625_ _07330_ _07626_ VDD VSS MUX2_X1
X_13245_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[39\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[39\]
+ _07328_ _07627_ VDD VSS MUX2_X1
X_13246_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[39\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[39\]
+ _07334_ _07628_ VDD VSS MUX2_X1
X_13247_ _07627_ _07628_ _07358_ _07629_ VDD VSS MUX2_X1
X_13248_ _07626_ _07629_ _07339_ _07630_ VDD VSS MUX2_X1
X_13249_ _07623_ _07630_ _07341_ _07631_ VDD VSS MUX2_X2
X_13250_ _07631_ _10402_ VDD VSS INV_X1
X_13251_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[38\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[38\]
+ _07312_ _07632_ VDD VSS MUX2_X1
X_13252_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[38\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[38\]
+ _07314_ _07633_ VDD VSS MUX2_X1
X_13253_ _07632_ _07633_ _07316_ _07634_ VDD VSS MUX2_X1
X_13254_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[38\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[38\]
+ _07314_ _07635_ VDD VSS MUX2_X1
X_13255_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[38\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[38\]
+ _07319_ _07636_ VDD VSS MUX2_X1
X_13256_ _07635_ _07636_ _07321_ _07637_ VDD VSS MUX2_X1
X_13257_ _07634_ _07637_ _07323_ _07638_ VDD VSS MUX2_X1
X_13258_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[38\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[38\]
+ _07326_ _07639_ VDD VSS MUX2_X1
X_13259_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[38\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[38\]
+ _07332_ _07640_ VDD VSS MUX2_X1
X_13260_ _07639_ _07640_ _07330_ _07641_ VDD VSS MUX2_X1
X_13261_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[38\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[38\]
+ _07332_ _07642_ VDD VSS MUX2_X1
X_13262_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[38\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[38\]
+ _07334_ _07643_ VDD VSS MUX2_X1
X_13263_ _07642_ _07643_ _07337_ _07644_ VDD VSS MUX2_X1
X_13264_ _07641_ _07644_ _07339_ _07645_ VDD VSS MUX2_X1
X_13265_ _07638_ _07645_ _07341_ _07646_ VDD VSS MUX2_X2
X_13266_ _07646_ _10405_ VDD VSS INV_X1
X_13267_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[36\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[36\]
+ _05724_ _07647_ VDD VSS MUX2_X1
X_13268_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[36\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[36\]
+ _07312_ _07648_ VDD VSS MUX2_X1
X_13269_ _07647_ _07648_ _05729_ _07649_ VDD VSS MUX2_X1
X_13270_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[36\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[36\]
+ _07344_ _07650_ VDD VSS MUX2_X1
X_13271_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[36\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[36\]
+ _07348_ _07651_ VDD VSS MUX2_X1
X_13272_ _07650_ _07651_ _07316_ _07652_ VDD VSS MUX2_X1
X_13273_ _07649_ _07652_ _05721_ _07653_ VDD VSS MUX2_X1
X_13274_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[36\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[36\]
+ _07352_ _07654_ VDD VSS MUX2_X1
X_13275_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[36\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[36\]
+ _07326_ _07655_ VDD VSS MUX2_X1
X_13276_ _07654_ _07655_ _07330_ _07656_ VDD VSS MUX2_X1
X_13277_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[36\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[36\]
+ _07326_ _07657_ VDD VSS MUX2_X1
X_13278_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[36\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[36\]
+ _07332_ _07658_ VDD VSS MUX2_X1
X_13279_ _07657_ _07658_ _07358_ _07659_ VDD VSS MUX2_X1
X_13280_ _07656_ _07659_ _07323_ _07660_ VDD VSS MUX2_X1
X_13281_ _07653_ _07660_ _05738_ _07661_ VDD VSS MUX2_X2
X_13282_ _07661_ _10411_ VDD VSS INV_X1
X_13283_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[35\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[35\]
+ _07312_ _07662_ VDD VSS MUX2_X1
X_13284_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[35\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[35\]
+ _07344_ _07663_ VDD VSS MUX2_X1
X_13285_ _07662_ _07663_ _05729_ _07664_ VDD VSS MUX2_X1
X_13286_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[35\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[35\]
+ _07314_ _07665_ VDD VSS MUX2_X1
X_13287_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[35\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[35\]
+ _07348_ _07666_ VDD VSS MUX2_X1
X_13288_ _07665_ _07666_ _07316_ _07667_ VDD VSS MUX2_X1
X_13289_ _07664_ _07667_ _07323_ _07668_ VDD VSS MUX2_X1
X_13290_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[35\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[35\]
+ _07352_ _07669_ VDD VSS MUX2_X1
X_13291_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[35\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[35\]
+ _07328_ _07670_ VDD VSS MUX2_X1
X_13292_ _07669_ _07670_ _07330_ _07671_ VDD VSS MUX2_X1
X_13293_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[35\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[35\]
+ _07328_ _07672_ VDD VSS MUX2_X1
X_13294_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[35\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[35\]
+ _07334_ _07673_ VDD VSS MUX2_X1
X_13295_ _07672_ _07673_ _07358_ _07674_ VDD VSS MUX2_X1
X_13296_ _07671_ _07674_ _07339_ _07675_ VDD VSS MUX2_X1
X_13297_ _07668_ _07675_ _07341_ _07676_ VDD VSS MUX2_X2
X_13298_ _07676_ _10414_ VDD VSS INV_X1
X_13299_ net292 _07677_ VDD VSS BUF_X2
X_13300_ _07677_ _10457_ VDD VSS INV_X1
X_13301_ _10169_ _10569_ VDD VSS INV_X2
X_13302_ _10477_ _10165_ VDD VSS INV_X1
X_13303_ _10469_ _10172_ VDD VSS INV_X1
X_13304_ _10503_ _10175_ VDD VSS INV_X1
X_13305_ _10511_ _10162_ VDD VSS INV_X1
X_13306_ _06540_ _10505_ _07678_ VDD VSS NOR2_X4
X_13307_ _10577_ _07678_ _07679_ VDD VSS NAND2_X1
X_13308_ _07679_ _07680_ VDD VSS BUF_X4
X_13309_ _07680_ _07681_ VDD VSS BUF_X4
X_13310_ net3 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[0\]
+ _07681_ _00093_ VDD VSS MUX2_X1
X_13311_ net4 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[10\]
+ _07681_ _00094_ VDD VSS MUX2_X1
X_13312_ net5 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[11\]
+ _07681_ _00095_ VDD VSS MUX2_X1
X_13313_ net6 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[12\]
+ _07681_ _00096_ VDD VSS MUX2_X1
X_13314_ net7 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[13\]
+ _07681_ _00097_ VDD VSS MUX2_X1
X_13315_ net8 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[14\]
+ _07681_ _00098_ VDD VSS MUX2_X1
X_13316_ net9 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[15\]
+ _07681_ _00099_ VDD VSS MUX2_X1
X_13317_ net10 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[16\]
+ _07681_ _00100_ VDD VSS MUX2_X1
X_13318_ net11 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[17\]
+ _07681_ _00101_ VDD VSS MUX2_X1
X_13319_ net12 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[18\]
+ _07681_ _00102_ VDD VSS MUX2_X1
X_13320_ _07680_ _07682_ VDD VSS BUF_X4
X_13321_ net13 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[19\]
+ _07682_ _00103_ VDD VSS MUX2_X1
X_13322_ net14 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[1\]
+ _07682_ _00104_ VDD VSS MUX2_X1
X_13323_ net15 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[20\]
+ _07682_ _00105_ VDD VSS MUX2_X1
X_13324_ net16 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[21\]
+ _07682_ _00106_ VDD VSS MUX2_X1
X_13325_ net17 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[22\]
+ _07682_ _00107_ VDD VSS MUX2_X1
X_13326_ net18 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[23\]
+ _07682_ _00108_ VDD VSS MUX2_X1
X_13327_ net19 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[24\]
+ _07682_ _00109_ VDD VSS MUX2_X1
X_13328_ net20 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[25\]
+ _07682_ _00110_ VDD VSS MUX2_X1
X_13329_ net21 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[26\]
+ _07682_ _00111_ VDD VSS MUX2_X1
X_13330_ net22 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[27\]
+ _07682_ _00112_ VDD VSS MUX2_X1
X_13331_ _07680_ _07683_ VDD VSS BUF_X4
X_13332_ net23 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[28\]
+ _07683_ _00113_ VDD VSS MUX2_X1
X_13333_ net24 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[29\]
+ _07683_ _00114_ VDD VSS MUX2_X1
X_13334_ net25 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[2\]
+ _07683_ _00115_ VDD VSS MUX2_X1
X_13335_ net26 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[30\]
+ _07683_ _00116_ VDD VSS MUX2_X1
X_13336_ net27 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[31\]
+ _07683_ _00117_ VDD VSS MUX2_X1
X_13337_ net28 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[32\]
+ _07683_ _00118_ VDD VSS MUX2_X1
X_13338_ net29 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[33\]
+ _07683_ _00119_ VDD VSS MUX2_X1
X_13339_ net30 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[34\]
+ _07683_ _00120_ VDD VSS MUX2_X1
X_13340_ net31 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[35\]
+ _07683_ _00121_ VDD VSS MUX2_X1
X_13341_ net32 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[36\]
+ _07683_ _00122_ VDD VSS MUX2_X1
X_13342_ _07680_ _07684_ VDD VSS BUF_X4
X_13343_ net33 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[37\]
+ _07684_ _00123_ VDD VSS MUX2_X1
X_13344_ net34 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[38\]
+ _07684_ _00124_ VDD VSS MUX2_X1
X_13345_ net35 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[39\]
+ _07684_ _00125_ VDD VSS MUX2_X1
X_13346_ net36 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[3\]
+ _07684_ _00126_ VDD VSS MUX2_X1
X_13347_ net37 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[40\]
+ _07684_ _00127_ VDD VSS MUX2_X1
X_13348_ net38 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[41\]
+ _07684_ _00128_ VDD VSS MUX2_X1
X_13349_ net39 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[42\]
+ _07684_ _00129_ VDD VSS MUX2_X1
X_13350_ net40 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[43\]
+ _07684_ _00130_ VDD VSS MUX2_X1
X_13351_ net41 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[44\]
+ _07684_ _00131_ VDD VSS MUX2_X1
X_13352_ net42 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[45\]
+ _07684_ _00132_ VDD VSS MUX2_X1
X_13353_ _07680_ _07685_ VDD VSS BUF_X4
X_13354_ net43 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[46\]
+ _07685_ _00133_ VDD VSS MUX2_X1
X_13355_ net44 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[47\]
+ _07685_ _00134_ VDD VSS MUX2_X1
X_13356_ net45 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[48\]
+ _07685_ _00135_ VDD VSS MUX2_X1
X_13357_ net46 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[49\]
+ _07685_ _00136_ VDD VSS MUX2_X1
X_13358_ net47 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[4\]
+ _07685_ _00137_ VDD VSS MUX2_X1
X_13359_ net48 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[50\]
+ _07685_ _00138_ VDD VSS MUX2_X1
X_13360_ net49 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[51\]
+ _07685_ _00139_ VDD VSS MUX2_X1
X_13361_ net50 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[52\]
+ _07685_ _00140_ VDD VSS MUX2_X1
X_13362_ net51 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[53\]
+ _07685_ _00141_ VDD VSS MUX2_X1
X_13363_ net52 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[54\]
+ _07685_ _00142_ VDD VSS MUX2_X1
X_13364_ _07680_ _07686_ VDD VSS BUF_X4
X_13365_ net53 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[55\]
+ _07686_ _00143_ VDD VSS MUX2_X1
X_13366_ net54 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[56\]
+ _07686_ _00144_ VDD VSS MUX2_X1
X_13367_ net55 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[57\]
+ _07686_ _00145_ VDD VSS MUX2_X1
X_13368_ net56 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[58\]
+ _07686_ _00146_ VDD VSS MUX2_X1
X_13369_ net57 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[59\]
+ _07686_ _00147_ VDD VSS MUX2_X1
X_13370_ net58 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[5\]
+ _07686_ _00148_ VDD VSS MUX2_X1
X_13371_ net59 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[60\]
+ _07686_ _00149_ VDD VSS MUX2_X1
X_13372_ net60 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[61\]
+ _07686_ _00150_ VDD VSS MUX2_X1
X_13373_ net61 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[62\]
+ _07686_ _00151_ VDD VSS MUX2_X1
X_13374_ net62 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[63\]
+ _07686_ _00152_ VDD VSS MUX2_X1
X_13375_ net63 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[6\]
+ _07680_ _00153_ VDD VSS MUX2_X1
X_13376_ net64 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[7\]
+ _07680_ _00154_ VDD VSS MUX2_X1
X_13377_ net65 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[8\]
+ _07680_ _00155_ VDD VSS MUX2_X1
X_13378_ net66 dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[9\]
+ _07680_ _00156_ VDD VSS MUX2_X1
X_13379_ _10580_ _07678_ _07687_ VDD VSS NAND2_X1
X_13380_ _07687_ _07688_ VDD VSS BUF_X4
X_13381_ _07688_ _07689_ VDD VSS CLKBUF_X3
X_13382_ net3 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[0\]
+ _07689_ _00157_ VDD VSS MUX2_X1
X_13383_ net4 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[10\]
+ _07689_ _00158_ VDD VSS MUX2_X1
X_13384_ net5 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[11\]
+ _07689_ _00159_ VDD VSS MUX2_X1
X_13385_ net6 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[12\]
+ _07689_ _00160_ VDD VSS MUX2_X1
X_13386_ net7 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[13\]
+ _07689_ _00161_ VDD VSS MUX2_X1
X_13387_ net8 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[14\]
+ _07689_ _00162_ VDD VSS MUX2_X1
X_13388_ net9 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[15\]
+ _07689_ _00163_ VDD VSS MUX2_X1
X_13389_ net10 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[16\]
+ _07689_ _00164_ VDD VSS MUX2_X1
X_13390_ net11 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[17\]
+ _07689_ _00165_ VDD VSS MUX2_X1
X_13391_ net12 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[18\]
+ _07689_ _00166_ VDD VSS MUX2_X1
X_13392_ _07688_ _07690_ VDD VSS BUF_X4
X_13393_ net13 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[19\]
+ _07690_ _00167_ VDD VSS MUX2_X1
X_13394_ net14 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[1\]
+ _07690_ _00168_ VDD VSS MUX2_X1
X_13395_ net15 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[20\]
+ _07690_ _00169_ VDD VSS MUX2_X1
X_13396_ net16 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[21\]
+ _07690_ _00170_ VDD VSS MUX2_X1
X_13397_ net17 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[22\]
+ _07690_ _00171_ VDD VSS MUX2_X1
X_13398_ net18 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[23\]
+ _07690_ _00172_ VDD VSS MUX2_X1
X_13399_ net19 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[24\]
+ _07690_ _00173_ VDD VSS MUX2_X1
X_13400_ net20 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[25\]
+ _07690_ _00174_ VDD VSS MUX2_X1
X_13401_ net21 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[26\]
+ _07690_ _00175_ VDD VSS MUX2_X1
X_13402_ net22 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[27\]
+ _07690_ _00176_ VDD VSS MUX2_X1
X_13403_ _07688_ _07691_ VDD VSS BUF_X4
X_13404_ net23 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[28\]
+ _07691_ _00177_ VDD VSS MUX2_X1
X_13405_ net24 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[29\]
+ _07691_ _00178_ VDD VSS MUX2_X1
X_13406_ net25 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[2\]
+ _07691_ _00179_ VDD VSS MUX2_X1
X_13407_ net26 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[30\]
+ _07691_ _00180_ VDD VSS MUX2_X1
X_13408_ net27 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[31\]
+ _07691_ _00181_ VDD VSS MUX2_X1
X_13409_ net28 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[32\]
+ _07691_ _00182_ VDD VSS MUX2_X1
X_13410_ net29 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[33\]
+ _07691_ _00183_ VDD VSS MUX2_X1
X_13411_ net30 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[34\]
+ _07691_ _00184_ VDD VSS MUX2_X1
X_13412_ net31 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[35\]
+ _07691_ _00185_ VDD VSS MUX2_X1
X_13413_ net32 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[36\]
+ _07691_ _00186_ VDD VSS MUX2_X1
X_13414_ _07688_ _07692_ VDD VSS BUF_X4
X_13415_ net33 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[37\]
+ _07692_ _00187_ VDD VSS MUX2_X1
X_13416_ net34 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[38\]
+ _07692_ _00188_ VDD VSS MUX2_X1
X_13417_ net35 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[39\]
+ _07692_ _00189_ VDD VSS MUX2_X1
X_13418_ net36 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[3\]
+ _07692_ _00190_ VDD VSS MUX2_X1
X_13419_ net37 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[40\]
+ _07692_ _00191_ VDD VSS MUX2_X1
X_13420_ net38 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[41\]
+ _07692_ _00192_ VDD VSS MUX2_X1
X_13421_ net39 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[42\]
+ _07692_ _00193_ VDD VSS MUX2_X1
X_13422_ net40 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[43\]
+ _07692_ _00194_ VDD VSS MUX2_X1
X_13423_ net41 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[44\]
+ _07692_ _00195_ VDD VSS MUX2_X1
X_13424_ net42 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[45\]
+ _07692_ _00196_ VDD VSS MUX2_X1
X_13425_ _07688_ _07693_ VDD VSS BUF_X4
X_13426_ net43 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[46\]
+ _07693_ _00197_ VDD VSS MUX2_X1
X_13427_ net44 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[47\]
+ _07693_ _00198_ VDD VSS MUX2_X1
X_13428_ net45 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[48\]
+ _07693_ _00199_ VDD VSS MUX2_X1
X_13429_ net46 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[49\]
+ _07693_ _00200_ VDD VSS MUX2_X1
X_13430_ net47 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[4\]
+ _07693_ _00201_ VDD VSS MUX2_X1
X_13431_ net48 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[50\]
+ _07693_ _00202_ VDD VSS MUX2_X1
X_13432_ net49 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[51\]
+ _07693_ _00203_ VDD VSS MUX2_X1
X_13433_ net50 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[52\]
+ _07693_ _00204_ VDD VSS MUX2_X1
X_13434_ net51 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[53\]
+ _07693_ _00205_ VDD VSS MUX2_X1
X_13435_ net52 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[54\]
+ _07693_ _00206_ VDD VSS MUX2_X1
X_13436_ _07688_ _07694_ VDD VSS BUF_X4
X_13437_ net53 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[55\]
+ _07694_ _00207_ VDD VSS MUX2_X1
X_13438_ net54 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[56\]
+ _07694_ _00208_ VDD VSS MUX2_X1
X_13439_ net55 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[57\]
+ _07694_ _00209_ VDD VSS MUX2_X1
X_13440_ net56 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[58\]
+ _07694_ _00210_ VDD VSS MUX2_X1
X_13441_ net57 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[59\]
+ _07694_ _00211_ VDD VSS MUX2_X1
X_13442_ net58 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[5\]
+ _07694_ _00212_ VDD VSS MUX2_X1
X_13443_ net59 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[60\]
+ _07694_ _00213_ VDD VSS MUX2_X1
X_13444_ net60 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[61\]
+ _07694_ _00214_ VDD VSS MUX2_X1
X_13445_ net61 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[62\]
+ _07694_ _00215_ VDD VSS MUX2_X1
X_13446_ net62 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[63\]
+ _07694_ _00216_ VDD VSS MUX2_X1
X_13447_ net63 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[6\]
+ _07688_ _00217_ VDD VSS MUX2_X1
X_13448_ net64 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[7\]
+ _07688_ _00218_ VDD VSS MUX2_X1
X_13449_ net65 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[8\]
+ _07688_ _00219_ VDD VSS MUX2_X1
X_13450_ net66 dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[9\]
+ _07688_ _00220_ VDD VSS MUX2_X1
X_13451_ _10578_ _07678_ _07695_ VDD VSS NAND2_X1
X_13452_ _07695_ _07696_ VDD VSS BUF_X4
X_13453_ _07696_ _07697_ VDD VSS BUF_X4
X_13454_ net3 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[0\]
+ _07697_ _00221_ VDD VSS MUX2_X1
X_13455_ net4 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[10\]
+ _07697_ _00222_ VDD VSS MUX2_X1
X_13456_ net5 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[11\]
+ _07697_ _00223_ VDD VSS MUX2_X1
X_13457_ net6 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[12\]
+ _07697_ _00224_ VDD VSS MUX2_X1
X_13458_ net7 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[13\]
+ _07697_ _00225_ VDD VSS MUX2_X1
X_13459_ net8 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[14\]
+ _07697_ _00226_ VDD VSS MUX2_X1
X_13460_ net9 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[15\]
+ _07697_ _00227_ VDD VSS MUX2_X1
X_13461_ net10 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[16\]
+ _07697_ _00228_ VDD VSS MUX2_X1
X_13462_ net11 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[17\]
+ _07697_ _00229_ VDD VSS MUX2_X1
X_13463_ net12 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[18\]
+ _07697_ _00230_ VDD VSS MUX2_X1
X_13464_ _07696_ _07698_ VDD VSS BUF_X4
X_13465_ net13 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[19\]
+ _07698_ _00231_ VDD VSS MUX2_X1
X_13466_ net14 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[1\]
+ _07698_ _00232_ VDD VSS MUX2_X1
X_13467_ net15 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[20\]
+ _07698_ _00233_ VDD VSS MUX2_X1
X_13468_ net16 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[21\]
+ _07698_ _00234_ VDD VSS MUX2_X1
X_13469_ net17 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[22\]
+ _07698_ _00235_ VDD VSS MUX2_X1
X_13470_ net18 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[23\]
+ _07698_ _00236_ VDD VSS MUX2_X1
X_13471_ net19 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[24\]
+ _07698_ _00237_ VDD VSS MUX2_X1
X_13472_ net20 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[25\]
+ _07698_ _00238_ VDD VSS MUX2_X1
X_13473_ net21 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[26\]
+ _07698_ _00239_ VDD VSS MUX2_X1
X_13474_ net22 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[27\]
+ _07698_ _00240_ VDD VSS MUX2_X1
X_13475_ _07696_ _07699_ VDD VSS CLKBUF_X3
X_13476_ net23 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[28\]
+ _07699_ _00241_ VDD VSS MUX2_X1
X_13477_ net24 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[29\]
+ _07699_ _00242_ VDD VSS MUX2_X1
X_13478_ net25 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[2\]
+ _07699_ _00243_ VDD VSS MUX2_X1
X_13479_ net26 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[30\]
+ _07699_ _00244_ VDD VSS MUX2_X1
X_13480_ net27 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[31\]
+ _07699_ _00245_ VDD VSS MUX2_X1
X_13481_ net28 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[32\]
+ _07699_ _00246_ VDD VSS MUX2_X1
X_13482_ net29 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[33\]
+ _07699_ _00247_ VDD VSS MUX2_X1
X_13483_ net30 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[34\]
+ _07699_ _00248_ VDD VSS MUX2_X1
X_13484_ net31 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[35\]
+ _07699_ _00249_ VDD VSS MUX2_X1
X_13485_ net32 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[36\]
+ _07699_ _00250_ VDD VSS MUX2_X1
X_13486_ _07696_ _07700_ VDD VSS BUF_X4
X_13487_ net33 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[37\]
+ _07700_ _00251_ VDD VSS MUX2_X1
X_13488_ net34 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[38\]
+ _07700_ _00252_ VDD VSS MUX2_X1
X_13489_ net35 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[39\]
+ _07700_ _00253_ VDD VSS MUX2_X1
X_13490_ net36 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[3\]
+ _07700_ _00254_ VDD VSS MUX2_X1
X_13491_ net37 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[40\]
+ _07700_ _00255_ VDD VSS MUX2_X1
X_13492_ net38 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[41\]
+ _07700_ _00256_ VDD VSS MUX2_X1
X_13493_ net39 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[42\]
+ _07700_ _00257_ VDD VSS MUX2_X1
X_13494_ net40 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[43\]
+ _07700_ _00258_ VDD VSS MUX2_X1
X_13495_ net41 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[44\]
+ _07700_ _00259_ VDD VSS MUX2_X1
X_13496_ net42 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[45\]
+ _07700_ _00260_ VDD VSS MUX2_X1
X_13497_ _07696_ _07701_ VDD VSS BUF_X4
X_13498_ net43 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[46\]
+ _07701_ _00261_ VDD VSS MUX2_X1
X_13499_ net44 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[47\]
+ _07701_ _00262_ VDD VSS MUX2_X1
X_13500_ net45 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[48\]
+ _07701_ _00263_ VDD VSS MUX2_X1
X_13501_ net46 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[49\]
+ _07701_ _00264_ VDD VSS MUX2_X1
X_13502_ net47 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[4\]
+ _07701_ _00265_ VDD VSS MUX2_X1
X_13503_ net48 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[50\]
+ _07701_ _00266_ VDD VSS MUX2_X1
X_13504_ net49 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[51\]
+ _07701_ _00267_ VDD VSS MUX2_X1
X_13505_ net50 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[52\]
+ _07701_ _00268_ VDD VSS MUX2_X1
X_13506_ net51 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[53\]
+ _07701_ _00269_ VDD VSS MUX2_X1
X_13507_ net52 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[54\]
+ _07701_ _00270_ VDD VSS MUX2_X1
X_13508_ _07696_ _07702_ VDD VSS BUF_X4
X_13509_ net53 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[55\]
+ _07702_ _00271_ VDD VSS MUX2_X1
X_13510_ net54 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[56\]
+ _07702_ _00272_ VDD VSS MUX2_X1
X_13511_ net55 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[57\]
+ _07702_ _00273_ VDD VSS MUX2_X1
X_13512_ net56 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[58\]
+ _07702_ _00274_ VDD VSS MUX2_X1
X_13513_ net57 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[59\]
+ _07702_ _00275_ VDD VSS MUX2_X1
X_13514_ net58 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[5\]
+ _07702_ _00276_ VDD VSS MUX2_X1
X_13515_ net59 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[60\]
+ _07702_ _00277_ VDD VSS MUX2_X1
X_13516_ net60 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[61\]
+ _07702_ _00278_ VDD VSS MUX2_X1
X_13517_ net61 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[62\]
+ _07702_ _00279_ VDD VSS MUX2_X1
X_13518_ net62 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[63\]
+ _07702_ _00280_ VDD VSS MUX2_X1
X_13519_ net63 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[6\]
+ _07696_ _00281_ VDD VSS MUX2_X1
X_13520_ net64 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[7\]
+ _07696_ _00282_ VDD VSS MUX2_X1
X_13521_ net65 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[8\]
+ _07696_ _00283_ VDD VSS MUX2_X1
X_13522_ net66 dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[9\]
+ _07696_ _00284_ VDD VSS MUX2_X1
X_13523_ _10582_ _07678_ _07703_ VDD VSS NAND2_X1
X_13524_ _07703_ _07704_ VDD VSS BUF_X4
X_13525_ _07704_ _07705_ VDD VSS CLKBUF_X3
X_13526_ net3 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[0\]
+ _07705_ _00285_ VDD VSS MUX2_X1
X_13527_ net4 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[10\]
+ _07705_ _00286_ VDD VSS MUX2_X1
X_13528_ net5 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[11\]
+ _07705_ _00287_ VDD VSS MUX2_X1
X_13529_ net6 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[12\]
+ _07705_ _00288_ VDD VSS MUX2_X1
X_13530_ net7 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[13\]
+ _07705_ _00289_ VDD VSS MUX2_X1
X_13531_ net8 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[14\]
+ _07705_ _00290_ VDD VSS MUX2_X1
X_13532_ net9 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[15\]
+ _07705_ _00291_ VDD VSS MUX2_X1
X_13533_ net10 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[16\]
+ _07705_ _00292_ VDD VSS MUX2_X1
X_13534_ net11 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[17\]
+ _07705_ _00293_ VDD VSS MUX2_X1
X_13535_ net12 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[18\]
+ _07705_ _00294_ VDD VSS MUX2_X1
X_13536_ _07704_ _07706_ VDD VSS BUF_X4
X_13537_ net13 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[19\]
+ _07706_ _00295_ VDD VSS MUX2_X1
X_13538_ net14 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[1\]
+ _07706_ _00296_ VDD VSS MUX2_X1
X_13539_ net15 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[20\]
+ _07706_ _00297_ VDD VSS MUX2_X1
X_13540_ net16 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[21\]
+ _07706_ _00298_ VDD VSS MUX2_X1
X_13541_ net17 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[22\]
+ _07706_ _00299_ VDD VSS MUX2_X1
X_13542_ net18 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[23\]
+ _07706_ _00300_ VDD VSS MUX2_X1
X_13543_ net19 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[24\]
+ _07706_ _00301_ VDD VSS MUX2_X1
X_13544_ net20 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[25\]
+ _07706_ _00302_ VDD VSS MUX2_X1
X_13545_ net21 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[26\]
+ _07706_ _00303_ VDD VSS MUX2_X1
X_13546_ net22 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[27\]
+ _07706_ _00304_ VDD VSS MUX2_X1
X_13547_ _07704_ _07707_ VDD VSS BUF_X4
X_13548_ net23 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[28\]
+ _07707_ _00305_ VDD VSS MUX2_X1
X_13549_ net24 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[29\]
+ _07707_ _00306_ VDD VSS MUX2_X1
X_13550_ net25 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[2\]
+ _07707_ _00307_ VDD VSS MUX2_X1
X_13551_ net26 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[30\]
+ _07707_ _00308_ VDD VSS MUX2_X1
X_13552_ net27 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[31\]
+ _07707_ _00309_ VDD VSS MUX2_X1
X_13553_ net28 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[32\]
+ _07707_ _00310_ VDD VSS MUX2_X1
X_13554_ net29 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[33\]
+ _07707_ _00311_ VDD VSS MUX2_X1
X_13555_ net30 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[34\]
+ _07707_ _00312_ VDD VSS MUX2_X1
X_13556_ net31 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[35\]
+ _07707_ _00313_ VDD VSS MUX2_X1
X_13557_ net32 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[36\]
+ _07707_ _00314_ VDD VSS MUX2_X1
X_13558_ _07704_ _07708_ VDD VSS BUF_X4
X_13559_ net33 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[37\]
+ _07708_ _00315_ VDD VSS MUX2_X1
X_13560_ net34 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[38\]
+ _07708_ _00316_ VDD VSS MUX2_X1
X_13561_ net35 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[39\]
+ _07708_ _00317_ VDD VSS MUX2_X1
X_13562_ net36 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[3\]
+ _07708_ _00318_ VDD VSS MUX2_X1
X_13563_ net37 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[40\]
+ _07708_ _00319_ VDD VSS MUX2_X1
X_13564_ net38 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[41\]
+ _07708_ _00320_ VDD VSS MUX2_X1
X_13565_ net39 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[42\]
+ _07708_ _00321_ VDD VSS MUX2_X1
X_13566_ net40 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[43\]
+ _07708_ _00322_ VDD VSS MUX2_X1
X_13567_ net41 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[44\]
+ _07708_ _00323_ VDD VSS MUX2_X1
X_13568_ net42 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[45\]
+ _07708_ _00324_ VDD VSS MUX2_X1
X_13569_ _07704_ _07709_ VDD VSS BUF_X4
X_13570_ net43 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[46\]
+ _07709_ _00325_ VDD VSS MUX2_X1
X_13571_ net44 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[47\]
+ _07709_ _00326_ VDD VSS MUX2_X1
X_13572_ net45 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[48\]
+ _07709_ _00327_ VDD VSS MUX2_X1
X_13573_ net46 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[49\]
+ _07709_ _00328_ VDD VSS MUX2_X1
X_13574_ net47 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[4\]
+ _07709_ _00329_ VDD VSS MUX2_X1
X_13575_ net48 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[50\]
+ _07709_ _00330_ VDD VSS MUX2_X1
X_13576_ net49 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[51\]
+ _07709_ _00331_ VDD VSS MUX2_X1
X_13577_ net50 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[52\]
+ _07709_ _00332_ VDD VSS MUX2_X1
X_13578_ net51 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[53\]
+ _07709_ _00333_ VDD VSS MUX2_X1
X_13579_ net52 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[54\]
+ _07709_ _00334_ VDD VSS MUX2_X1
X_13580_ _07704_ _07710_ VDD VSS BUF_X4
X_13581_ net53 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[55\]
+ _07710_ _00335_ VDD VSS MUX2_X1
X_13582_ net54 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[56\]
+ _07710_ _00336_ VDD VSS MUX2_X1
X_13583_ net55 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[57\]
+ _07710_ _00337_ VDD VSS MUX2_X1
X_13584_ net56 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[58\]
+ _07710_ _00338_ VDD VSS MUX2_X1
X_13585_ net57 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[59\]
+ _07710_ _00339_ VDD VSS MUX2_X1
X_13586_ net58 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[5\]
+ _07710_ _00340_ VDD VSS MUX2_X1
X_13587_ net59 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[60\]
+ _07710_ _00341_ VDD VSS MUX2_X1
X_13588_ net60 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[61\]
+ _07710_ _00342_ VDD VSS MUX2_X1
X_13589_ net61 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[62\]
+ _07710_ _00343_ VDD VSS MUX2_X1
X_13590_ net62 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[63\]
+ _07710_ _00344_ VDD VSS MUX2_X1
X_13591_ net63 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[6\]
+ _07704_ _00345_ VDD VSS MUX2_X1
X_13592_ net64 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[7\]
+ _07704_ _00346_ VDD VSS MUX2_X1
X_13593_ net65 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[8\]
+ _07704_ _00347_ VDD VSS MUX2_X1
X_13594_ net66 dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[9\]
+ _07704_ _00348_ VDD VSS MUX2_X1
X_13595_ _06540_ _10471_ _07711_ VDD VSS NOR2_X2
X_13596_ _10585_ _07711_ _07712_ VDD VSS NAND2_X1
X_13597_ _07712_ _07713_ VDD VSS BUF_X4
X_13598_ _07713_ _07714_ VDD VSS CLKBUF_X3
X_13599_ net67 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[0\]
+ _07714_ _00404_ VDD VSS MUX2_X1
X_13600_ net68 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[10\]
+ _07714_ _00405_ VDD VSS MUX2_X1
X_13601_ net69 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[11\]
+ _07714_ _00406_ VDD VSS MUX2_X1
X_13602_ net70 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[12\]
+ _07714_ _00407_ VDD VSS MUX2_X1
X_13603_ net71 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[13\]
+ _07714_ _00408_ VDD VSS MUX2_X1
X_13604_ net72 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[14\]
+ _07714_ _00409_ VDD VSS MUX2_X1
X_13605_ net73 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[15\]
+ _07714_ _00410_ VDD VSS MUX2_X1
X_13606_ net74 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[16\]
+ _07714_ _00411_ VDD VSS MUX2_X1
X_13607_ net75 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[17\]
+ _07714_ _00412_ VDD VSS MUX2_X1
X_13608_ net76 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[18\]
+ _07714_ _00413_ VDD VSS MUX2_X1
X_13609_ _07713_ _07715_ VDD VSS BUF_X4
X_13610_ net77 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[19\]
+ _07715_ _00414_ VDD VSS MUX2_X1
X_13611_ net78 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[1\]
+ _07715_ _00415_ VDD VSS MUX2_X1
X_13612_ net79 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[20\]
+ _07715_ _00416_ VDD VSS MUX2_X1
X_13613_ net80 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[21\]
+ _07715_ _00417_ VDD VSS MUX2_X1
X_13614_ net81 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[22\]
+ _07715_ _00418_ VDD VSS MUX2_X1
X_13615_ net82 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[23\]
+ _07715_ _00419_ VDD VSS MUX2_X1
X_13616_ net83 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[24\]
+ _07715_ _00420_ VDD VSS MUX2_X1
X_13617_ net84 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[25\]
+ _07715_ _00421_ VDD VSS MUX2_X1
X_13618_ net85 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[26\]
+ _07715_ _00422_ VDD VSS MUX2_X1
X_13619_ net86 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[27\]
+ _07715_ _00423_ VDD VSS MUX2_X1
X_13620_ _07713_ _07716_ VDD VSS BUF_X4
X_13621_ net87 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[28\]
+ _07716_ _00424_ VDD VSS MUX2_X1
X_13622_ net88 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[29\]
+ _07716_ _00425_ VDD VSS MUX2_X1
X_13623_ net89 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[2\]
+ _07716_ _00426_ VDD VSS MUX2_X1
X_13624_ net90 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[30\]
+ _07716_ _00427_ VDD VSS MUX2_X1
X_13625_ net91 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[31\]
+ _07716_ _00428_ VDD VSS MUX2_X1
X_13626_ net92 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[32\]
+ _07716_ _00429_ VDD VSS MUX2_X1
X_13627_ net93 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[33\]
+ _07716_ _00430_ VDD VSS MUX2_X1
X_13628_ net94 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[34\]
+ _07716_ _00431_ VDD VSS MUX2_X1
X_13629_ net95 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[35\]
+ _07716_ _00432_ VDD VSS MUX2_X1
X_13630_ net96 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[36\]
+ _07716_ _00433_ VDD VSS MUX2_X1
X_13631_ _07713_ _07717_ VDD VSS BUF_X4
X_13632_ net97 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[37\]
+ _07717_ _00434_ VDD VSS MUX2_X1
X_13633_ net98 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[38\]
+ _07717_ _00435_ VDD VSS MUX2_X1
X_13634_ net99 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[39\]
+ _07717_ _00436_ VDD VSS MUX2_X1
X_13635_ net100 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[3\]
+ _07717_ _00437_ VDD VSS MUX2_X1
X_13636_ net101 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[40\]
+ _07717_ _00438_ VDD VSS MUX2_X1
X_13637_ net102 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[41\]
+ _07717_ _00439_ VDD VSS MUX2_X1
X_13638_ net103 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[42\]
+ _07717_ _00440_ VDD VSS MUX2_X1
X_13639_ net104 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[43\]
+ _07717_ _00441_ VDD VSS MUX2_X1
X_13640_ net105 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[44\]
+ _07717_ _00442_ VDD VSS MUX2_X1
X_13641_ net106 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[45\]
+ _07717_ _00443_ VDD VSS MUX2_X1
X_13642_ _07713_ _07718_ VDD VSS BUF_X4
X_13643_ net107 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[46\]
+ _07718_ _00444_ VDD VSS MUX2_X1
X_13644_ net108 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[47\]
+ _07718_ _00445_ VDD VSS MUX2_X1
X_13645_ net109 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[48\]
+ _07718_ _00446_ VDD VSS MUX2_X1
X_13646_ net110 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[49\]
+ _07718_ _00447_ VDD VSS MUX2_X1
X_13647_ net111 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[4\]
+ _07718_ _00448_ VDD VSS MUX2_X1
X_13648_ net112 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[50\]
+ _07718_ _00449_ VDD VSS MUX2_X1
X_13649_ net113 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[51\]
+ _07718_ _00450_ VDD VSS MUX2_X1
X_13650_ net114 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[52\]
+ _07718_ _00451_ VDD VSS MUX2_X1
X_13651_ net115 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[53\]
+ _07718_ _00452_ VDD VSS MUX2_X1
X_13652_ net116 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[54\]
+ _07718_ _00453_ VDD VSS MUX2_X1
X_13653_ _07713_ _07719_ VDD VSS BUF_X4
X_13654_ net117 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[55\]
+ _07719_ _00454_ VDD VSS MUX2_X1
X_13655_ net118 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[56\]
+ _07719_ _00455_ VDD VSS MUX2_X1
X_13656_ net119 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[57\]
+ _07719_ _00456_ VDD VSS MUX2_X1
X_13657_ net120 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[58\]
+ _07719_ _00457_ VDD VSS MUX2_X1
X_13658_ net121 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[59\]
+ _07719_ _00458_ VDD VSS MUX2_X1
X_13659_ net122 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[5\]
+ _07719_ _00459_ VDD VSS MUX2_X1
X_13660_ net123 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[60\]
+ _07719_ _00460_ VDD VSS MUX2_X1
X_13661_ net124 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[61\]
+ _07719_ _00461_ VDD VSS MUX2_X1
X_13662_ net125 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[62\]
+ _07719_ _00462_ VDD VSS MUX2_X1
X_13663_ net126 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[63\]
+ _07719_ _00463_ VDD VSS MUX2_X1
X_13664_ net127 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[6\]
+ _07713_ _00464_ VDD VSS MUX2_X1
X_13665_ net128 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[7\]
+ _07713_ _00465_ VDD VSS MUX2_X1
X_13666_ net129 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[8\]
+ _07713_ _00466_ VDD VSS MUX2_X1
X_13667_ net130 dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[9\]
+ _07713_ _00467_ VDD VSS MUX2_X1
X_13668_ _10588_ _07711_ _07720_ VDD VSS NAND2_X1
X_13669_ _07720_ _07721_ VDD VSS BUF_X4
X_13670_ _07721_ _07722_ VDD VSS BUF_X4
X_13671_ net67 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[0\]
+ _07722_ _00468_ VDD VSS MUX2_X1
X_13672_ net68 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[10\]
+ _07722_ _00469_ VDD VSS MUX2_X1
X_13673_ net69 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[11\]
+ _07722_ _00470_ VDD VSS MUX2_X1
X_13674_ net70 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[12\]
+ _07722_ _00471_ VDD VSS MUX2_X1
X_13675_ net71 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[13\]
+ _07722_ _00472_ VDD VSS MUX2_X1
X_13676_ net72 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[14\]
+ _07722_ _00473_ VDD VSS MUX2_X1
X_13677_ net73 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[15\]
+ _07722_ _00474_ VDD VSS MUX2_X1
X_13678_ net74 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[16\]
+ _07722_ _00475_ VDD VSS MUX2_X1
X_13679_ net75 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[17\]
+ _07722_ _00476_ VDD VSS MUX2_X1
X_13680_ net76 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[18\]
+ _07722_ _00477_ VDD VSS MUX2_X1
X_13681_ _07721_ _07723_ VDD VSS BUF_X4
X_13682_ net77 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[19\]
+ _07723_ _00478_ VDD VSS MUX2_X1
X_13683_ net78 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[1\]
+ _07723_ _00479_ VDD VSS MUX2_X1
X_13684_ net79 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[20\]
+ _07723_ _00480_ VDD VSS MUX2_X1
X_13685_ net80 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[21\]
+ _07723_ _00481_ VDD VSS MUX2_X1
X_13686_ net81 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[22\]
+ _07723_ _00482_ VDD VSS MUX2_X1
X_13687_ net82 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[23\]
+ _07723_ _00483_ VDD VSS MUX2_X1
X_13688_ net83 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[24\]
+ _07723_ _00484_ VDD VSS MUX2_X1
X_13689_ net84 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[25\]
+ _07723_ _00485_ VDD VSS MUX2_X1
X_13690_ net85 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[26\]
+ _07723_ _00486_ VDD VSS MUX2_X1
X_13691_ net86 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[27\]
+ _07723_ _00487_ VDD VSS MUX2_X1
X_13692_ _07721_ _07724_ VDD VSS BUF_X4
X_13693_ net87 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[28\]
+ _07724_ _00488_ VDD VSS MUX2_X1
X_13694_ net88 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[29\]
+ _07724_ _00489_ VDD VSS MUX2_X1
X_13695_ net89 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[2\]
+ _07724_ _00490_ VDD VSS MUX2_X1
X_13696_ net90 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[30\]
+ _07724_ _00491_ VDD VSS MUX2_X1
X_13697_ net91 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[31\]
+ _07724_ _00492_ VDD VSS MUX2_X1
X_13698_ net92 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[32\]
+ _07724_ _00493_ VDD VSS MUX2_X1
X_13699_ net93 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[33\]
+ _07724_ _00494_ VDD VSS MUX2_X1
X_13700_ net94 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[34\]
+ _07724_ _00495_ VDD VSS MUX2_X1
X_13701_ net95 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[35\]
+ _07724_ _00496_ VDD VSS MUX2_X1
X_13702_ net96 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[36\]
+ _07724_ _00497_ VDD VSS MUX2_X1
X_13703_ _07721_ _07725_ VDD VSS BUF_X4
X_13704_ net97 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[37\]
+ _07725_ _00498_ VDD VSS MUX2_X1
X_13705_ net98 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[38\]
+ _07725_ _00499_ VDD VSS MUX2_X1
X_13706_ net99 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[39\]
+ _07725_ _00500_ VDD VSS MUX2_X1
X_13707_ net100 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[3\]
+ _07725_ _00501_ VDD VSS MUX2_X1
X_13708_ net101 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[40\]
+ _07725_ _00502_ VDD VSS MUX2_X1
X_13709_ net102 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[41\]
+ _07725_ _00503_ VDD VSS MUX2_X1
X_13710_ net103 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[42\]
+ _07725_ _00504_ VDD VSS MUX2_X1
X_13711_ net104 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[43\]
+ _07725_ _00505_ VDD VSS MUX2_X1
X_13712_ net105 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[44\]
+ _07725_ _00506_ VDD VSS MUX2_X1
X_13713_ net106 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[45\]
+ _07725_ _00507_ VDD VSS MUX2_X1
X_13714_ _07721_ _07726_ VDD VSS CLKBUF_X3
X_13715_ net107 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[46\]
+ _07726_ _00508_ VDD VSS MUX2_X1
X_13716_ net108 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[47\]
+ _07726_ _00509_ VDD VSS MUX2_X1
X_13717_ net109 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[48\]
+ _07726_ _00510_ VDD VSS MUX2_X1
X_13718_ net110 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[49\]
+ _07726_ _00511_ VDD VSS MUX2_X1
X_13719_ net111 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[4\]
+ _07726_ _00512_ VDD VSS MUX2_X1
X_13720_ net112 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[50\]
+ _07726_ _00513_ VDD VSS MUX2_X1
X_13721_ net113 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[51\]
+ _07726_ _00514_ VDD VSS MUX2_X1
X_13722_ net114 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[52\]
+ _07726_ _00515_ VDD VSS MUX2_X1
X_13723_ net115 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[53\]
+ _07726_ _00516_ VDD VSS MUX2_X1
X_13724_ net116 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[54\]
+ _07726_ _00517_ VDD VSS MUX2_X1
X_13725_ _07721_ _07727_ VDD VSS BUF_X4
X_13726_ net117 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[55\]
+ _07727_ _00518_ VDD VSS MUX2_X1
X_13727_ net118 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[56\]
+ _07727_ _00519_ VDD VSS MUX2_X1
X_13728_ net119 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[57\]
+ _07727_ _00520_ VDD VSS MUX2_X1
X_13729_ net120 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[58\]
+ _07727_ _00521_ VDD VSS MUX2_X1
X_13730_ net121 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[59\]
+ _07727_ _00522_ VDD VSS MUX2_X1
X_13731_ net122 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[5\]
+ _07727_ _00523_ VDD VSS MUX2_X1
X_13732_ net123 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[60\]
+ _07727_ _00524_ VDD VSS MUX2_X1
X_13733_ net124 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[61\]
+ _07727_ _00525_ VDD VSS MUX2_X1
X_13734_ net125 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[62\]
+ _07727_ _00526_ VDD VSS MUX2_X1
X_13735_ net126 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[63\]
+ _07727_ _00527_ VDD VSS MUX2_X1
X_13736_ net127 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[6\]
+ _07721_ _00528_ VDD VSS MUX2_X1
X_13737_ net128 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[7\]
+ _07721_ _00529_ VDD VSS MUX2_X1
X_13738_ net129 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[8\]
+ _07721_ _00530_ VDD VSS MUX2_X1
X_13739_ net130 dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[9\]
+ _07721_ _00531_ VDD VSS MUX2_X1
X_13740_ _10586_ _07711_ _07728_ VDD VSS NAND2_X1
X_13741_ _07728_ _07729_ VDD VSS BUF_X4
X_13742_ _07729_ _07730_ VDD VSS BUF_X4
X_13743_ net67 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[0\]
+ _07730_ _00532_ VDD VSS MUX2_X1
X_13744_ net68 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[10\]
+ _07730_ _00533_ VDD VSS MUX2_X1
X_13745_ net69 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[11\]
+ _07730_ _00534_ VDD VSS MUX2_X1
X_13746_ net70 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[12\]
+ _07730_ _00535_ VDD VSS MUX2_X1
X_13747_ net71 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[13\]
+ _07730_ _00536_ VDD VSS MUX2_X1
X_13748_ net72 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[14\]
+ _07730_ _00537_ VDD VSS MUX2_X1
X_13749_ net73 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[15\]
+ _07730_ _00538_ VDD VSS MUX2_X1
X_13750_ net74 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[16\]
+ _07730_ _00539_ VDD VSS MUX2_X1
X_13751_ net75 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[17\]
+ _07730_ _00540_ VDD VSS MUX2_X1
X_13752_ net76 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[18\]
+ _07730_ _00541_ VDD VSS MUX2_X1
X_13753_ _07729_ _07731_ VDD VSS BUF_X4
X_13754_ net77 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[19\]
+ _07731_ _00542_ VDD VSS MUX2_X1
X_13755_ net78 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[1\]
+ _07731_ _00543_ VDD VSS MUX2_X1
X_13756_ net79 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[20\]
+ _07731_ _00544_ VDD VSS MUX2_X1
X_13757_ net80 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[21\]
+ _07731_ _00545_ VDD VSS MUX2_X1
X_13758_ net81 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[22\]
+ _07731_ _00546_ VDD VSS MUX2_X1
X_13759_ net82 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[23\]
+ _07731_ _00547_ VDD VSS MUX2_X1
X_13760_ net83 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[24\]
+ _07731_ _00548_ VDD VSS MUX2_X1
X_13761_ net84 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[25\]
+ _07731_ _00549_ VDD VSS MUX2_X1
X_13762_ net85 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[26\]
+ _07731_ _00550_ VDD VSS MUX2_X1
X_13763_ net86 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[27\]
+ _07731_ _00551_ VDD VSS MUX2_X1
X_13764_ _07729_ _07732_ VDD VSS BUF_X4
X_13765_ net87 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[28\]
+ _07732_ _00552_ VDD VSS MUX2_X1
X_13766_ net88 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[29\]
+ _07732_ _00553_ VDD VSS MUX2_X1
X_13767_ net89 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[2\]
+ _07732_ _00554_ VDD VSS MUX2_X1
X_13768_ net90 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[30\]
+ _07732_ _00555_ VDD VSS MUX2_X1
X_13769_ net91 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[31\]
+ _07732_ _00556_ VDD VSS MUX2_X1
X_13770_ net92 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[32\]
+ _07732_ _00557_ VDD VSS MUX2_X1
X_13771_ net93 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[33\]
+ _07732_ _00558_ VDD VSS MUX2_X1
X_13772_ net94 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[34\]
+ _07732_ _00559_ VDD VSS MUX2_X1
X_13773_ net95 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[35\]
+ _07732_ _00560_ VDD VSS MUX2_X1
X_13774_ net96 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[36\]
+ _07732_ _00561_ VDD VSS MUX2_X1
X_13775_ _07729_ _07733_ VDD VSS BUF_X4
X_13776_ net97 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[37\]
+ _07733_ _00562_ VDD VSS MUX2_X1
X_13777_ net98 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[38\]
+ _07733_ _00563_ VDD VSS MUX2_X1
X_13778_ net99 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[39\]
+ _07733_ _00564_ VDD VSS MUX2_X1
X_13779_ net100 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[3\]
+ _07733_ _00565_ VDD VSS MUX2_X1
X_13780_ net101 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[40\]
+ _07733_ _00566_ VDD VSS MUX2_X1
X_13781_ net102 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[41\]
+ _07733_ _00567_ VDD VSS MUX2_X1
X_13782_ net103 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[42\]
+ _07733_ _00568_ VDD VSS MUX2_X1
X_13783_ net104 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[43\]
+ _07733_ _00569_ VDD VSS MUX2_X1
X_13784_ net105 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[44\]
+ _07733_ _00570_ VDD VSS MUX2_X1
X_13785_ net106 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[45\]
+ _07733_ _00571_ VDD VSS MUX2_X1
X_13786_ _07729_ _07734_ VDD VSS BUF_X4
X_13787_ net107 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[46\]
+ _07734_ _00572_ VDD VSS MUX2_X1
X_13788_ net108 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[47\]
+ _07734_ _00573_ VDD VSS MUX2_X1
X_13789_ net109 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[48\]
+ _07734_ _00574_ VDD VSS MUX2_X1
X_13790_ net110 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[49\]
+ _07734_ _00575_ VDD VSS MUX2_X1
X_13791_ net111 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[4\]
+ _07734_ _00576_ VDD VSS MUX2_X1
X_13792_ net112 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[50\]
+ _07734_ _00577_ VDD VSS MUX2_X1
X_13793_ net113 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[51\]
+ _07734_ _00578_ VDD VSS MUX2_X1
X_13794_ net114 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[52\]
+ _07734_ _00579_ VDD VSS MUX2_X1
X_13795_ net115 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[53\]
+ _07734_ _00580_ VDD VSS MUX2_X1
X_13796_ net116 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[54\]
+ _07734_ _00581_ VDD VSS MUX2_X1
X_13797_ _07729_ _07735_ VDD VSS BUF_X4
X_13798_ net117 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[55\]
+ _07735_ _00582_ VDD VSS MUX2_X1
X_13799_ net118 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[56\]
+ _07735_ _00583_ VDD VSS MUX2_X1
X_13800_ net119 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[57\]
+ _07735_ _00584_ VDD VSS MUX2_X1
X_13801_ net120 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[58\]
+ _07735_ _00585_ VDD VSS MUX2_X1
X_13802_ net121 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[59\]
+ _07735_ _00586_ VDD VSS MUX2_X1
X_13803_ net122 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[5\]
+ _07735_ _00587_ VDD VSS MUX2_X1
X_13804_ net123 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[60\]
+ _07735_ _00588_ VDD VSS MUX2_X1
X_13805_ net124 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[61\]
+ _07735_ _00589_ VDD VSS MUX2_X1
X_13806_ net125 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[62\]
+ _07735_ _00590_ VDD VSS MUX2_X1
X_13807_ net126 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[63\]
+ _07735_ _00591_ VDD VSS MUX2_X1
X_13808_ net127 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[6\]
+ _07729_ _00592_ VDD VSS MUX2_X1
X_13809_ net128 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[7\]
+ _07729_ _00593_ VDD VSS MUX2_X1
X_13810_ net129 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[8\]
+ _07729_ _00594_ VDD VSS MUX2_X1
X_13811_ net130 dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[9\]
+ _07729_ _00595_ VDD VSS MUX2_X1
X_13812_ _10590_ _07711_ _07736_ VDD VSS NAND2_X1
X_13813_ _07736_ _07737_ VDD VSS BUF_X4
X_13814_ _07737_ _07738_ VDD VSS BUF_X4
X_13815_ net67 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[0\]
+ _07738_ _00596_ VDD VSS MUX2_X1
X_13816_ net68 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[10\]
+ _07738_ _00597_ VDD VSS MUX2_X1
X_13817_ net69 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[11\]
+ _07738_ _00598_ VDD VSS MUX2_X1
X_13818_ net70 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[12\]
+ _07738_ _00599_ VDD VSS MUX2_X1
X_13819_ net71 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[13\]
+ _07738_ _00600_ VDD VSS MUX2_X1
X_13820_ net72 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[14\]
+ _07738_ _00601_ VDD VSS MUX2_X1
X_13821_ net73 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[15\]
+ _07738_ _00602_ VDD VSS MUX2_X1
X_13822_ net74 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[16\]
+ _07738_ _00603_ VDD VSS MUX2_X1
X_13823_ net75 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[17\]
+ _07738_ _00604_ VDD VSS MUX2_X1
X_13824_ net76 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[18\]
+ _07738_ _00605_ VDD VSS MUX2_X1
X_13825_ _07737_ _07739_ VDD VSS BUF_X4
X_13826_ net77 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[19\]
+ _07739_ _00606_ VDD VSS MUX2_X1
X_13827_ net78 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[1\]
+ _07739_ _00607_ VDD VSS MUX2_X1
X_13828_ net79 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[20\]
+ _07739_ _00608_ VDD VSS MUX2_X1
X_13829_ net80 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[21\]
+ _07739_ _00609_ VDD VSS MUX2_X1
X_13830_ net81 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[22\]
+ _07739_ _00610_ VDD VSS MUX2_X1
X_13831_ net82 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[23\]
+ _07739_ _00611_ VDD VSS MUX2_X1
X_13832_ net83 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[24\]
+ _07739_ _00612_ VDD VSS MUX2_X1
X_13833_ net84 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[25\]
+ _07739_ _00613_ VDD VSS MUX2_X1
X_13834_ net85 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[26\]
+ _07739_ _00614_ VDD VSS MUX2_X1
X_13835_ net86 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[27\]
+ _07739_ _00615_ VDD VSS MUX2_X1
X_13836_ _07737_ _07740_ VDD VSS BUF_X4
X_13837_ net87 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[28\]
+ _07740_ _00616_ VDD VSS MUX2_X1
X_13838_ net88 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[29\]
+ _07740_ _00617_ VDD VSS MUX2_X1
X_13839_ net89 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[2\]
+ _07740_ _00618_ VDD VSS MUX2_X1
X_13840_ net90 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[30\]
+ _07740_ _00619_ VDD VSS MUX2_X1
X_13841_ net91 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[31\]
+ _07740_ _00620_ VDD VSS MUX2_X1
X_13842_ net92 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[32\]
+ _07740_ _00621_ VDD VSS MUX2_X1
X_13843_ net93 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[33\]
+ _07740_ _00622_ VDD VSS MUX2_X1
X_13844_ net94 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[34\]
+ _07740_ _00623_ VDD VSS MUX2_X1
X_13845_ net95 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[35\]
+ _07740_ _00624_ VDD VSS MUX2_X1
X_13846_ net96 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[36\]
+ _07740_ _00625_ VDD VSS MUX2_X1
X_13847_ _07737_ _07741_ VDD VSS BUF_X4
X_13848_ net97 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[37\]
+ _07741_ _00626_ VDD VSS MUX2_X1
X_13849_ net98 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[38\]
+ _07741_ _00627_ VDD VSS MUX2_X1
X_13850_ net99 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[39\]
+ _07741_ _00628_ VDD VSS MUX2_X1
X_13851_ net100 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[3\]
+ _07741_ _00629_ VDD VSS MUX2_X1
X_13852_ net101 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[40\]
+ _07741_ _00630_ VDD VSS MUX2_X1
X_13853_ net102 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[41\]
+ _07741_ _00631_ VDD VSS MUX2_X1
X_13854_ net103 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[42\]
+ _07741_ _00632_ VDD VSS MUX2_X1
X_13855_ net104 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[43\]
+ _07741_ _00633_ VDD VSS MUX2_X1
X_13856_ net105 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[44\]
+ _07741_ _00634_ VDD VSS MUX2_X1
X_13857_ net106 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[45\]
+ _07741_ _00635_ VDD VSS MUX2_X1
X_13858_ _07737_ _07742_ VDD VSS BUF_X4
X_13859_ net107 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[46\]
+ _07742_ _00636_ VDD VSS MUX2_X1
X_13860_ net108 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[47\]
+ _07742_ _00637_ VDD VSS MUX2_X1
X_13861_ net109 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[48\]
+ _07742_ _00638_ VDD VSS MUX2_X1
X_13862_ net110 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[49\]
+ _07742_ _00639_ VDD VSS MUX2_X1
X_13863_ net111 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[4\]
+ _07742_ _00640_ VDD VSS MUX2_X1
X_13864_ net112 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[50\]
+ _07742_ _00641_ VDD VSS MUX2_X1
X_13865_ net113 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[51\]
+ _07742_ _00642_ VDD VSS MUX2_X1
X_13866_ net114 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[52\]
+ _07742_ _00643_ VDD VSS MUX2_X1
X_13867_ net115 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[53\]
+ _07742_ _00644_ VDD VSS MUX2_X1
X_13868_ net116 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[54\]
+ _07742_ _00645_ VDD VSS MUX2_X1
X_13869_ _07737_ _07743_ VDD VSS BUF_X4
X_13870_ net117 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[55\]
+ _07743_ _00646_ VDD VSS MUX2_X1
X_13871_ net118 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[56\]
+ _07743_ _00647_ VDD VSS MUX2_X1
X_13872_ net119 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[57\]
+ _07743_ _00648_ VDD VSS MUX2_X1
X_13873_ net120 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[58\]
+ _07743_ _00649_ VDD VSS MUX2_X1
X_13874_ net121 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[59\]
+ _07743_ _00650_ VDD VSS MUX2_X1
X_13875_ net122 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[5\]
+ _07743_ _00651_ VDD VSS MUX2_X1
X_13876_ net123 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[60\]
+ _07743_ _00652_ VDD VSS MUX2_X1
X_13877_ net124 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[61\]
+ _07743_ _00653_ VDD VSS MUX2_X1
X_13878_ net125 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[62\]
+ _07743_ _00654_ VDD VSS MUX2_X1
X_13879_ net126 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[63\]
+ _07743_ _00655_ VDD VSS MUX2_X1
X_13880_ net127 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[6\]
+ _07737_ _00656_ VDD VSS MUX2_X1
X_13881_ net128 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[7\]
+ _07737_ _00657_ VDD VSS MUX2_X1
X_13882_ net129 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[8\]
+ _07737_ _00658_ VDD VSS MUX2_X1
X_13883_ net130 dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[9\]
+ _07737_ _00659_ VDD VSS MUX2_X1
X_13884_ dataIn_P[0] _07744_ VDD VSS BUF_X1
X_13885_ _07744_ _07745_ VDD VSS BUF_X2
X_13886_ dynamic_node_top.proc_input.NIB.tail_ptr_f\[3\] _07746_
+ VDD VSS BUF_X2
X_13887_ dynamic_node_top.proc_input.NIB.tail_ptr_f\[2\] _07747_
+ VDD VSS BUF_X2
X_13888_ _10594_ _07677_ _07748_ VDD VSS NAND2_X1
X_13889_ _06540_ _07746_ _07747_ _07748_ _07749_ VDD VSS NOR4_X2
X_13890_ _07749_ _07750_ VDD VSS BUF_X4
X_13891_ _07750_ _07751_ VDD VSS CLKBUF_X3
X_13892_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[0\]
+ _07745_ _07751_ _00687_ VDD VSS MUX2_X1
X_13893_ dataIn_P[10] _07752_ VDD VSS CLKBUF_X2
X_13894_ _07752_ _07753_ VDD VSS BUF_X2
X_13895_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[10\]
+ _07753_ _07751_ _00688_ VDD VSS MUX2_X1
X_13896_ dataIn_P[11] _07754_ VDD VSS CLKBUF_X2
X_13897_ _07754_ _07755_ VDD VSS BUF_X2
X_13898_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[11\]
+ _07755_ _07751_ _00689_ VDD VSS MUX2_X1
X_13899_ dataIn_P[12] _07756_ VDD VSS CLKBUF_X2
X_13900_ _07756_ _07757_ VDD VSS BUF_X2
X_13901_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[12\]
+ _07757_ _07751_ _00690_ VDD VSS MUX2_X1
X_13902_ dataIn_P[13] _07758_ VDD VSS CLKBUF_X2
X_13903_ _07758_ _07759_ VDD VSS BUF_X2
X_13904_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[13\]
+ _07759_ _07751_ _00691_ VDD VSS MUX2_X1
X_13905_ dataIn_P[14] _07760_ VDD VSS CLKBUF_X2
X_13906_ _07760_ _07761_ VDD VSS BUF_X2
X_13907_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[14\]
+ _07761_ _07751_ _00692_ VDD VSS MUX2_X1
X_13908_ dataIn_P[15] _07762_ VDD VSS CLKBUF_X2
X_13909_ _07762_ _07763_ VDD VSS BUF_X2
X_13910_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[15\]
+ _07763_ _07751_ _00693_ VDD VSS MUX2_X1
X_13911_ dataIn_P[16] _07764_ VDD VSS CLKBUF_X2
X_13912_ _07764_ _07765_ VDD VSS BUF_X2
X_13913_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[16\]
+ _07765_ _07751_ _00694_ VDD VSS MUX2_X1
X_13914_ dataIn_P[17] _07766_ VDD VSS CLKBUF_X2
X_13915_ _07766_ _07767_ VDD VSS BUF_X2
X_13916_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[17\]
+ _07767_ _07751_ _00695_ VDD VSS MUX2_X1
X_13917_ dataIn_P[18] _07768_ VDD VSS CLKBUF_X2
X_13918_ _07768_ _07769_ VDD VSS BUF_X2
X_13919_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[18\]
+ _07769_ _07751_ _00696_ VDD VSS MUX2_X1
X_13920_ dataIn_P[19] _07770_ VDD VSS BUF_X1
X_13921_ _07770_ _07771_ VDD VSS CLKBUF_X2
X_13922_ _07750_ _07772_ VDD VSS BUF_X4
X_13923_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[19\]
+ _07771_ _07772_ _00697_ VDD VSS MUX2_X1
X_13924_ dataIn_P[1] _07773_ VDD VSS BUF_X1
X_13925_ _07773_ _07774_ VDD VSS CLKBUF_X2
X_13926_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[1\]
+ _07774_ _07772_ _00698_ VDD VSS MUX2_X1
X_13927_ dataIn_P[20] _07775_ VDD VSS BUF_X1
X_13928_ _07775_ _07776_ VDD VSS BUF_X2
X_13929_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[20\]
+ _07776_ _07772_ _00699_ VDD VSS MUX2_X1
X_13930_ dataIn_P[21] _07777_ VDD VSS CLKBUF_X2
X_13931_ _07777_ _07778_ VDD VSS BUF_X2
X_13932_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[21\]
+ _07778_ _07772_ _00700_ VDD VSS MUX2_X1
X_13933_ dataIn_P[22] _07779_ VDD VSS BUF_X1
X_13934_ _07779_ _07780_ VDD VSS BUF_X2
X_13935_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[22\]
+ _07780_ _07772_ _00701_ VDD VSS MUX2_X1
X_13936_ dataIn_P[23] _07781_ VDD VSS CLKBUF_X2
X_13937_ _07781_ _07782_ VDD VSS CLKBUF_X2
X_13938_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[23\]
+ _07782_ _07772_ _00702_ VDD VSS MUX2_X1
X_13939_ dataIn_P[24] _07783_ VDD VSS BUF_X1
X_13940_ _07783_ _07784_ VDD VSS CLKBUF_X2
X_13941_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[24\]
+ _07784_ _07772_ _00703_ VDD VSS MUX2_X1
X_13942_ dataIn_P[25] _07785_ VDD VSS BUF_X1
X_13943_ _07785_ _07786_ VDD VSS BUF_X2
X_13944_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[25\]
+ _07786_ _07772_ _00704_ VDD VSS MUX2_X1
X_13945_ dataIn_P[26] _07787_ VDD VSS BUF_X1
X_13946_ _07787_ _07788_ VDD VSS BUF_X2
X_13947_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[26\]
+ _07788_ _07772_ _00705_ VDD VSS MUX2_X1
X_13948_ dataIn_P[27] _07789_ VDD VSS BUF_X1
X_13949_ _07789_ _07790_ VDD VSS BUF_X2
X_13950_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[27\]
+ _07790_ _07772_ _00706_ VDD VSS MUX2_X1
X_13951_ dataIn_P[28] _07791_ VDD VSS BUF_X1
X_13952_ _07791_ _07792_ VDD VSS CLKBUF_X2
X_13953_ _07750_ _07793_ VDD VSS BUF_X4
X_13954_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[28\]
+ _07792_ _07793_ _00707_ VDD VSS MUX2_X1
X_13955_ dataIn_P[29] _07794_ VDD VSS BUF_X1
X_13956_ _07794_ _07795_ VDD VSS BUF_X2
X_13957_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[29\]
+ _07795_ _07793_ _00708_ VDD VSS MUX2_X1
X_13958_ dataIn_P[2] _07796_ VDD VSS BUF_X1
X_13959_ _07796_ _07797_ VDD VSS BUF_X2
X_13960_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[2\]
+ _07797_ _07793_ _00709_ VDD VSS MUX2_X1
X_13961_ dataIn_P[30] _07798_ VDD VSS BUF_X1
X_13962_ _07798_ _07799_ VDD VSS CLKBUF_X2
X_13963_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[30\]
+ _07799_ _07793_ _00710_ VDD VSS MUX2_X1
X_13964_ dataIn_P[31] _07800_ VDD VSS BUF_X1
X_13965_ _07800_ _07801_ VDD VSS BUF_X2
X_13966_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[31\]
+ _07801_ _07793_ _00711_ VDD VSS MUX2_X1
X_13967_ dataIn_P[32] _07802_ VDD VSS BUF_X1
X_13968_ _07802_ _07803_ VDD VSS CLKBUF_X2
X_13969_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[32\]
+ _07803_ _07793_ _00712_ VDD VSS MUX2_X1
X_13970_ dataIn_P[33] _07804_ VDD VSS BUF_X1
X_13971_ _07804_ _07805_ VDD VSS CLKBUF_X2
X_13972_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[33\]
+ _07805_ _07793_ _00713_ VDD VSS MUX2_X1
X_13973_ dataIn_P[34] _07806_ VDD VSS BUF_X1
X_13974_ _07806_ _07807_ VDD VSS BUF_X2
X_13975_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[34\]
+ _07807_ _07793_ _00714_ VDD VSS MUX2_X1
X_13976_ dataIn_P[35] _07808_ VDD VSS CLKBUF_X2
X_13977_ _07808_ _07809_ VDD VSS BUF_X2
X_13978_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[35\]
+ _07809_ _07793_ _00715_ VDD VSS MUX2_X1
X_13979_ dataIn_P[36] _07810_ VDD VSS BUF_X1
X_13980_ _07810_ _07811_ VDD VSS BUF_X2
X_13981_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[36\]
+ _07811_ _07793_ _00716_ VDD VSS MUX2_X1
X_13982_ dataIn_P[37] _07812_ VDD VSS BUF_X1
X_13983_ _07812_ _07813_ VDD VSS BUF_X2
X_13984_ _07750_ _07814_ VDD VSS BUF_X4
X_13985_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[37\]
+ _07813_ _07814_ _00717_ VDD VSS MUX2_X1
X_13986_ dataIn_P[38] _07815_ VDD VSS BUF_X1
X_13987_ _07815_ _07816_ VDD VSS BUF_X2
X_13988_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[38\]
+ _07816_ _07814_ _00718_ VDD VSS MUX2_X1
X_13989_ dataIn_P[39] _07817_ VDD VSS BUF_X1
X_13990_ _07817_ _07818_ VDD VSS BUF_X2
X_13991_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[39\]
+ _07818_ _07814_ _00719_ VDD VSS MUX2_X1
X_13992_ dataIn_P[3] _07819_ VDD VSS BUF_X1
X_13993_ _07819_ _07820_ VDD VSS CLKBUF_X2
X_13994_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[3\]
+ _07820_ _07814_ _00720_ VDD VSS MUX2_X1
X_13995_ dataIn_P[40] _07821_ VDD VSS BUF_X1
X_13996_ _07821_ _07822_ VDD VSS BUF_X2
X_13997_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[40\]
+ _07822_ _07814_ _00721_ VDD VSS MUX2_X1
X_13998_ dataIn_P[41] _07823_ VDD VSS CLKBUF_X2
X_13999_ _07823_ _07824_ VDD VSS BUF_X2
X_14000_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[41\]
+ _07824_ _07814_ _00722_ VDD VSS MUX2_X1
X_14001_ dataIn_P[42] _07825_ VDD VSS CLKBUF_X2
X_14002_ _07825_ _07826_ VDD VSS BUF_X2
X_14003_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[42\]
+ _07826_ _07814_ _00723_ VDD VSS MUX2_X1
X_14004_ dataIn_P[43] _07827_ VDD VSS BUF_X1
X_14005_ _07827_ _07828_ VDD VSS BUF_X2
X_14006_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[43\]
+ _07828_ _07814_ _00724_ VDD VSS MUX2_X1
X_14007_ dataIn_P[44] _07829_ VDD VSS BUF_X1
X_14008_ _07829_ _07830_ VDD VSS BUF_X2
X_14009_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[44\]
+ _07830_ _07814_ _00725_ VDD VSS MUX2_X1
X_14010_ dataIn_P[45] _07831_ VDD VSS BUF_X1
X_14011_ _07831_ _07832_ VDD VSS BUF_X2
X_14012_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[45\]
+ _07832_ _07814_ _00726_ VDD VSS MUX2_X1
X_14013_ dataIn_P[46] _07833_ VDD VSS BUF_X1
X_14014_ _07833_ _07834_ VDD VSS CLKBUF_X2
X_14015_ _07750_ _07835_ VDD VSS BUF_X4
X_14016_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[46\]
+ _07834_ _07835_ _00727_ VDD VSS MUX2_X1
X_14017_ dataIn_P[47] _07836_ VDD VSS CLKBUF_X2
X_14018_ _07836_ _07837_ VDD VSS BUF_X2
X_14019_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[47\]
+ _07837_ _07835_ _00728_ VDD VSS MUX2_X1
X_14020_ dataIn_P[48] _07838_ VDD VSS BUF_X1
X_14021_ _07838_ _07839_ VDD VSS BUF_X2
X_14022_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[48\]
+ _07839_ _07835_ _00729_ VDD VSS MUX2_X1
X_14023_ dataIn_P[49] _07840_ VDD VSS BUF_X1
X_14024_ _07840_ _07841_ VDD VSS BUF_X2
X_14025_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[49\]
+ _07841_ _07835_ _00730_ VDD VSS MUX2_X1
X_14026_ dataIn_P[4] _07842_ VDD VSS BUF_X1
X_14027_ _07842_ _07843_ VDD VSS BUF_X2
X_14028_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[4\]
+ _07843_ _07835_ _00731_ VDD VSS MUX2_X1
X_14029_ dataIn_P[50] _07844_ VDD VSS CLKBUF_X2
X_14030_ _07844_ _07845_ VDD VSS BUF_X2
X_14031_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[50\]
+ _07845_ _07835_ _00732_ VDD VSS MUX2_X1
X_14032_ dataIn_P[51] _07846_ VDD VSS CLKBUF_X2
X_14033_ _07846_ _07847_ VDD VSS BUF_X2
X_14034_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[51\]
+ _07847_ _07835_ _00733_ VDD VSS MUX2_X1
X_14035_ dataIn_P[52] _07848_ VDD VSS CLKBUF_X2
X_14036_ _07848_ _07849_ VDD VSS BUF_X2
X_14037_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[52\]
+ _07849_ _07835_ _00734_ VDD VSS MUX2_X1
X_14038_ dataIn_P[53] _07850_ VDD VSS CLKBUF_X2
X_14039_ _07850_ _07851_ VDD VSS BUF_X2
X_14040_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[53\]
+ _07851_ _07835_ _00735_ VDD VSS MUX2_X1
X_14041_ dataIn_P[54] _07852_ VDD VSS BUF_X1
X_14042_ _07852_ _07853_ VDD VSS BUF_X2
X_14043_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[54\]
+ _07853_ _07835_ _00736_ VDD VSS MUX2_X1
X_14044_ dataIn_P[55] _07854_ VDD VSS BUF_X1
X_14045_ _07854_ _07855_ VDD VSS BUF_X2
X_14046_ _07750_ _07856_ VDD VSS BUF_X4
X_14047_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[55\]
+ _07855_ _07856_ _00737_ VDD VSS MUX2_X1
X_14048_ dataIn_P[56] _07857_ VDD VSS BUF_X1
X_14049_ _07857_ _07858_ VDD VSS BUF_X2
X_14050_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[56\]
+ _07858_ _07856_ _00738_ VDD VSS MUX2_X1
X_14051_ dataIn_P[57] _07859_ VDD VSS BUF_X1
X_14052_ _07859_ _07860_ VDD VSS BUF_X2
X_14053_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[57\]
+ _07860_ _07856_ _00739_ VDD VSS MUX2_X1
X_14054_ dataIn_P[58] _07861_ VDD VSS CLKBUF_X2
X_14055_ _07861_ _07862_ VDD VSS BUF_X2
X_14056_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[58\]
+ _07862_ _07856_ _00740_ VDD VSS MUX2_X1
X_14057_ dataIn_P[59] _07863_ VDD VSS CLKBUF_X2
X_14058_ _07863_ _07864_ VDD VSS BUF_X2
X_14059_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[59\]
+ _07864_ _07856_ _00741_ VDD VSS MUX2_X1
X_14060_ dataIn_P[5] _07865_ VDD VSS BUF_X1
X_14061_ _07865_ _07866_ VDD VSS BUF_X2
X_14062_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[5\]
+ _07866_ _07856_ _00742_ VDD VSS MUX2_X1
X_14063_ dataIn_P[60] _07867_ VDD VSS CLKBUF_X2
X_14064_ _07867_ _07868_ VDD VSS BUF_X2
X_14065_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[60\]
+ _07868_ _07856_ _00743_ VDD VSS MUX2_X1
X_14066_ dataIn_P[61] _07869_ VDD VSS BUF_X1
X_14067_ _07869_ _07870_ VDD VSS BUF_X2
X_14068_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[61\]
+ _07870_ _07856_ _00744_ VDD VSS MUX2_X1
X_14069_ dataIn_P[62] _07871_ VDD VSS BUF_X1
X_14070_ _07871_ _07872_ VDD VSS BUF_X2
X_14071_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[62\]
+ _07872_ _07856_ _00745_ VDD VSS MUX2_X1
X_14072_ dataIn_P[63] _07873_ VDD VSS BUF_X1
X_14073_ _07873_ _07874_ VDD VSS BUF_X2
X_14074_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[63\]
+ _07874_ _07856_ _00746_ VDD VSS MUX2_X1
X_14075_ dataIn_P[6] _07875_ VDD VSS BUF_X1
X_14076_ _07875_ _07876_ VDD VSS BUF_X2
X_14077_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[6\]
+ _07876_ _07750_ _00747_ VDD VSS MUX2_X1
X_14078_ dataIn_P[7] _07877_ VDD VSS BUF_X1
X_14079_ _07877_ _07878_ VDD VSS BUF_X2
X_14080_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[7\]
+ _07878_ _07750_ _00748_ VDD VSS MUX2_X1
X_14081_ dataIn_P[8] _07879_ VDD VSS BUF_X1
X_14082_ _07879_ _07880_ VDD VSS BUF_X2
X_14083_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[8\]
+ _07880_ _07750_ _00749_ VDD VSS MUX2_X1
X_14084_ dataIn_P[9] _07881_ VDD VSS CLKBUF_X2
X_14085_ _07881_ _07882_ VDD VSS BUF_X2
X_14086_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[9\]
+ _07882_ _07750_ _00750_ VDD VSS MUX2_X1
X_14087_ _07747_ _07883_ VDD VSS INV_X1
X_14088_ _07883_ _07677_ _07884_ VDD VSS NAND2_X1
X_14089_ _06581_ _07746_ _07885_ VDD VSS NAND2_X1
X_14090_ _07884_ _07885_ _07886_ VDD VSS NOR2_X1
X_14091_ _10595_ _07886_ _07887_ VDD VSS NAND2_X1
X_14092_ _07887_ _07888_ VDD VSS BUF_X4
X_14093_ _07888_ _07889_ VDD VSS CLKBUF_X3
X_14094_ _07745_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[0\]
+ _07889_ _00751_ VDD VSS MUX2_X1
X_14095_ _07753_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[10\]
+ _07889_ _00752_ VDD VSS MUX2_X1
X_14096_ _07755_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[11\]
+ _07889_ _00753_ VDD VSS MUX2_X1
X_14097_ _07757_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[12\]
+ _07889_ _00754_ VDD VSS MUX2_X1
X_14098_ _07759_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[13\]
+ _07889_ _00755_ VDD VSS MUX2_X1
X_14099_ _07761_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[14\]
+ _07889_ _00756_ VDD VSS MUX2_X1
X_14100_ _07763_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[15\]
+ _07889_ _00757_ VDD VSS MUX2_X1
X_14101_ _07765_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[16\]
+ _07889_ _00758_ VDD VSS MUX2_X1
X_14102_ _07767_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[17\]
+ _07889_ _00759_ VDD VSS MUX2_X1
X_14103_ _07769_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[18\]
+ _07889_ _00760_ VDD VSS MUX2_X1
X_14104_ _07888_ _07890_ VDD VSS BUF_X4
X_14105_ _07771_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[19\]
+ _07890_ _00761_ VDD VSS MUX2_X1
X_14106_ _07774_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[1\]
+ _07890_ _00762_ VDD VSS MUX2_X1
X_14107_ _07776_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[20\]
+ _07890_ _00763_ VDD VSS MUX2_X1
X_14108_ _07778_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[21\]
+ _07890_ _00764_ VDD VSS MUX2_X1
X_14109_ _07780_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[22\]
+ _07890_ _00765_ VDD VSS MUX2_X1
X_14110_ _07782_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[23\]
+ _07890_ _00766_ VDD VSS MUX2_X1
X_14111_ _07784_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[24\]
+ _07890_ _00767_ VDD VSS MUX2_X1
X_14112_ _07786_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[25\]
+ _07890_ _00768_ VDD VSS MUX2_X1
X_14113_ _07788_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[26\]
+ _07890_ _00769_ VDD VSS MUX2_X1
X_14114_ _07790_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[27\]
+ _07890_ _00770_ VDD VSS MUX2_X1
X_14115_ _07888_ _07891_ VDD VSS BUF_X4
X_14116_ _07792_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[28\]
+ _07891_ _00771_ VDD VSS MUX2_X1
X_14117_ _07795_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[29\]
+ _07891_ _00772_ VDD VSS MUX2_X1
X_14118_ _07797_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[2\]
+ _07891_ _00773_ VDD VSS MUX2_X1
X_14119_ _07799_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[30\]
+ _07891_ _00774_ VDD VSS MUX2_X1
X_14120_ _07801_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[31\]
+ _07891_ _00775_ VDD VSS MUX2_X1
X_14121_ _07803_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[32\]
+ _07891_ _00776_ VDD VSS MUX2_X1
X_14122_ _07805_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[33\]
+ _07891_ _00777_ VDD VSS MUX2_X1
X_14123_ _07807_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[34\]
+ _07891_ _00778_ VDD VSS MUX2_X1
X_14124_ _07809_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[35\]
+ _07891_ _00779_ VDD VSS MUX2_X1
X_14125_ _07811_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[36\]
+ _07891_ _00780_ VDD VSS MUX2_X1
X_14126_ _07888_ _07892_ VDD VSS BUF_X4
X_14127_ _07813_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[37\]
+ _07892_ _00781_ VDD VSS MUX2_X1
X_14128_ _07816_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[38\]
+ _07892_ _00782_ VDD VSS MUX2_X1
X_14129_ _07818_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[39\]
+ _07892_ _00783_ VDD VSS MUX2_X1
X_14130_ _07820_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[3\]
+ _07892_ _00784_ VDD VSS MUX2_X1
X_14131_ _07822_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[40\]
+ _07892_ _00785_ VDD VSS MUX2_X1
X_14132_ _07824_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[41\]
+ _07892_ _00786_ VDD VSS MUX2_X1
X_14133_ _07826_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[42\]
+ _07892_ _00787_ VDD VSS MUX2_X1
X_14134_ _07828_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[43\]
+ _07892_ _00788_ VDD VSS MUX2_X1
X_14135_ _07830_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[44\]
+ _07892_ _00789_ VDD VSS MUX2_X1
X_14136_ _07832_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[45\]
+ _07892_ _00790_ VDD VSS MUX2_X1
X_14137_ _07888_ _07893_ VDD VSS BUF_X4
X_14138_ _07834_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[46\]
+ _07893_ _00791_ VDD VSS MUX2_X1
X_14139_ _07837_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[47\]
+ _07893_ _00792_ VDD VSS MUX2_X1
X_14140_ _07839_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[48\]
+ _07893_ _00793_ VDD VSS MUX2_X1
X_14141_ _07841_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[49\]
+ _07893_ _00794_ VDD VSS MUX2_X1
X_14142_ _07843_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[4\]
+ _07893_ _00795_ VDD VSS MUX2_X1
X_14143_ _07845_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[50\]
+ _07893_ _00796_ VDD VSS MUX2_X1
X_14144_ _07847_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[51\]
+ _07893_ _00797_ VDD VSS MUX2_X1
X_14145_ _07849_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[52\]
+ _07893_ _00798_ VDD VSS MUX2_X1
X_14146_ _07851_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[53\]
+ _07893_ _00799_ VDD VSS MUX2_X1
X_14147_ _07853_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[54\]
+ _07893_ _00800_ VDD VSS MUX2_X1
X_14148_ _07888_ _07894_ VDD VSS BUF_X4
X_14149_ _07855_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[55\]
+ _07894_ _00801_ VDD VSS MUX2_X1
X_14150_ _07858_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[56\]
+ _07894_ _00802_ VDD VSS MUX2_X1
X_14151_ _07860_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[57\]
+ _07894_ _00803_ VDD VSS MUX2_X1
X_14152_ _07862_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[58\]
+ _07894_ _00804_ VDD VSS MUX2_X1
X_14153_ _07864_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[59\]
+ _07894_ _00805_ VDD VSS MUX2_X1
X_14154_ _07866_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[5\]
+ _07894_ _00806_ VDD VSS MUX2_X1
X_14155_ _07868_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[60\]
+ _07894_ _00807_ VDD VSS MUX2_X1
X_14156_ _07870_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[61\]
+ _07894_ _00808_ VDD VSS MUX2_X1
X_14157_ _07872_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[62\]
+ _07894_ _00809_ VDD VSS MUX2_X1
X_14158_ _07874_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[63\]
+ _07894_ _00810_ VDD VSS MUX2_X1
X_14159_ _07876_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[6\]
+ _07888_ _00811_ VDD VSS MUX2_X1
X_14160_ _07878_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[7\]
+ _07888_ _00812_ VDD VSS MUX2_X1
X_14161_ _07880_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[8\]
+ _07888_ _00813_ VDD VSS MUX2_X1
X_14162_ _07882_ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[9\]
+ _07888_ _00814_ VDD VSS MUX2_X1
X_14163_ _10599_ _07895_ VDD VSS BUF_X1
X_14164_ _07895_ _07886_ _07896_ VDD VSS NAND2_X1
X_14165_ _07896_ _07897_ VDD VSS BUF_X4
X_14166_ _07897_ _07898_ VDD VSS CLKBUF_X3
X_14167_ _07745_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[0\]
+ _07898_ _00815_ VDD VSS MUX2_X1
X_14168_ _07753_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[10\]
+ _07898_ _00816_ VDD VSS MUX2_X1
X_14169_ _07755_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[11\]
+ _07898_ _00817_ VDD VSS MUX2_X1
X_14170_ _07757_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[12\]
+ _07898_ _00818_ VDD VSS MUX2_X1
X_14171_ _07759_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[13\]
+ _07898_ _00819_ VDD VSS MUX2_X1
X_14172_ _07761_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[14\]
+ _07898_ _00820_ VDD VSS MUX2_X1
X_14173_ _07763_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[15\]
+ _07898_ _00821_ VDD VSS MUX2_X1
X_14174_ _07765_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[16\]
+ _07898_ _00822_ VDD VSS MUX2_X1
X_14175_ _07767_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[17\]
+ _07898_ _00823_ VDD VSS MUX2_X1
X_14176_ _07769_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[18\]
+ _07898_ _00824_ VDD VSS MUX2_X1
X_14177_ _07897_ _07899_ VDD VSS BUF_X4
X_14178_ _07771_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[19\]
+ _07899_ _00825_ VDD VSS MUX2_X1
X_14179_ _07774_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[1\]
+ _07899_ _00826_ VDD VSS MUX2_X1
X_14180_ _07776_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[20\]
+ _07899_ _00827_ VDD VSS MUX2_X1
X_14181_ _07778_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[21\]
+ _07899_ _00828_ VDD VSS MUX2_X1
X_14182_ _07780_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[22\]
+ _07899_ _00829_ VDD VSS MUX2_X1
X_14183_ _07782_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[23\]
+ _07899_ _00830_ VDD VSS MUX2_X1
X_14184_ _07784_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[24\]
+ _07899_ _00831_ VDD VSS MUX2_X1
X_14185_ _07786_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[25\]
+ _07899_ _00832_ VDD VSS MUX2_X1
X_14186_ _07788_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[26\]
+ _07899_ _00833_ VDD VSS MUX2_X1
X_14187_ _07790_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[27\]
+ _07899_ _00834_ VDD VSS MUX2_X1
X_14188_ _07897_ _07900_ VDD VSS BUF_X4
X_14189_ _07792_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[28\]
+ _07900_ _00835_ VDD VSS MUX2_X1
X_14190_ _07795_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[29\]
+ _07900_ _00836_ VDD VSS MUX2_X1
X_14191_ _07797_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[2\]
+ _07900_ _00837_ VDD VSS MUX2_X1
X_14192_ _07799_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[30\]
+ _07900_ _00838_ VDD VSS MUX2_X1
X_14193_ _07801_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[31\]
+ _07900_ _00839_ VDD VSS MUX2_X1
X_14194_ _07803_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[32\]
+ _07900_ _00840_ VDD VSS MUX2_X1
X_14195_ _07805_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[33\]
+ _07900_ _00841_ VDD VSS MUX2_X1
X_14196_ _07807_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[34\]
+ _07900_ _00842_ VDD VSS MUX2_X1
X_14197_ _07809_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[35\]
+ _07900_ _00843_ VDD VSS MUX2_X1
X_14198_ _07811_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[36\]
+ _07900_ _00844_ VDD VSS MUX2_X1
X_14199_ _07897_ _07901_ VDD VSS BUF_X4
X_14200_ _07813_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[37\]
+ _07901_ _00845_ VDD VSS MUX2_X1
X_14201_ _07816_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[38\]
+ _07901_ _00846_ VDD VSS MUX2_X1
X_14202_ _07818_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[39\]
+ _07901_ _00847_ VDD VSS MUX2_X1
X_14203_ _07820_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[3\]
+ _07901_ _00848_ VDD VSS MUX2_X1
X_14204_ _07822_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[40\]
+ _07901_ _00849_ VDD VSS MUX2_X1
X_14205_ _07824_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[41\]
+ _07901_ _00850_ VDD VSS MUX2_X1
X_14206_ _07826_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[42\]
+ _07901_ _00851_ VDD VSS MUX2_X1
X_14207_ _07828_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[43\]
+ _07901_ _00852_ VDD VSS MUX2_X1
X_14208_ _07830_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[44\]
+ _07901_ _00853_ VDD VSS MUX2_X1
X_14209_ _07832_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[45\]
+ _07901_ _00854_ VDD VSS MUX2_X1
X_14210_ _07897_ _07902_ VDD VSS BUF_X4
X_14211_ _07834_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[46\]
+ _07902_ _00855_ VDD VSS MUX2_X1
X_14212_ _07837_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[47\]
+ _07902_ _00856_ VDD VSS MUX2_X1
X_14213_ _07839_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[48\]
+ _07902_ _00857_ VDD VSS MUX2_X1
X_14214_ _07841_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[49\]
+ _07902_ _00858_ VDD VSS MUX2_X1
X_14215_ _07843_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[4\]
+ _07902_ _00859_ VDD VSS MUX2_X1
X_14216_ _07845_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[50\]
+ _07902_ _00860_ VDD VSS MUX2_X1
X_14217_ _07847_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[51\]
+ _07902_ _00861_ VDD VSS MUX2_X1
X_14218_ _07849_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[52\]
+ _07902_ _00862_ VDD VSS MUX2_X1
X_14219_ _07851_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[53\]
+ _07902_ _00863_ VDD VSS MUX2_X1
X_14220_ _07853_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[54\]
+ _07902_ _00864_ VDD VSS MUX2_X1
X_14221_ _07897_ _07903_ VDD VSS BUF_X4
X_14222_ _07855_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[55\]
+ _07903_ _00865_ VDD VSS MUX2_X1
X_14223_ _07858_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[56\]
+ _07903_ _00866_ VDD VSS MUX2_X1
X_14224_ _07860_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[57\]
+ _07903_ _00867_ VDD VSS MUX2_X1
X_14225_ _07862_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[58\]
+ _07903_ _00868_ VDD VSS MUX2_X1
X_14226_ _07864_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[59\]
+ _07903_ _00869_ VDD VSS MUX2_X1
X_14227_ _07866_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[5\]
+ _07903_ _00870_ VDD VSS MUX2_X1
X_14228_ _07868_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[60\]
+ _07903_ _00871_ VDD VSS MUX2_X1
X_14229_ _07870_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[61\]
+ _07903_ _00872_ VDD VSS MUX2_X1
X_14230_ _07872_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[62\]
+ _07903_ _00873_ VDD VSS MUX2_X1
X_14231_ _07874_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[63\]
+ _07903_ _00874_ VDD VSS MUX2_X1
X_14232_ _07876_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[6\]
+ _07897_ _00875_ VDD VSS MUX2_X1
X_14233_ _07878_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[7\]
+ _07897_ _00876_ VDD VSS MUX2_X1
X_14234_ _07880_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[8\]
+ _07897_ _00877_ VDD VSS MUX2_X1
X_14235_ _07882_ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[9\]
+ _07897_ _00878_ VDD VSS MUX2_X1
X_14236_ _07747_ _10594_ _07677_ _07904_ VDD VSS NAND3_X1
X_14237_ _07885_ _07904_ _07905_ VDD VSS NOR2_X1
X_14238_ _07905_ _07906_ VDD VSS BUF_X4
X_14239_ _07906_ _07907_ VDD VSS BUF_X4
X_14240_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[0\]
+ _07745_ _07907_ _00879_ VDD VSS MUX2_X1
X_14241_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[10\]
+ _07753_ _07907_ _00880_ VDD VSS MUX2_X1
X_14242_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[11\]
+ _07755_ _07907_ _00881_ VDD VSS MUX2_X1
X_14243_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[12\]
+ _07757_ _07907_ _00882_ VDD VSS MUX2_X1
X_14244_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[13\]
+ _07759_ _07907_ _00883_ VDD VSS MUX2_X1
X_14245_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[14\]
+ _07761_ _07907_ _00884_ VDD VSS MUX2_X1
X_14246_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[15\]
+ _07763_ _07907_ _00885_ VDD VSS MUX2_X1
X_14247_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[16\]
+ _07765_ _07907_ _00886_ VDD VSS MUX2_X1
X_14248_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[17\]
+ _07767_ _07907_ _00887_ VDD VSS MUX2_X1
X_14249_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[18\]
+ _07769_ _07907_ _00888_ VDD VSS MUX2_X1
X_14250_ _07906_ _07908_ VDD VSS BUF_X4
X_14251_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[19\]
+ _07771_ _07908_ _00889_ VDD VSS MUX2_X1
X_14252_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[1\]
+ _07774_ _07908_ _00890_ VDD VSS MUX2_X1
X_14253_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[20\]
+ _07776_ _07908_ _00891_ VDD VSS MUX2_X1
X_14254_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[21\]
+ _07778_ _07908_ _00892_ VDD VSS MUX2_X1
X_14255_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[22\]
+ _07780_ _07908_ _00893_ VDD VSS MUX2_X1
X_14256_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[23\]
+ _07782_ _07908_ _00894_ VDD VSS MUX2_X1
X_14257_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[24\]
+ _07784_ _07908_ _00895_ VDD VSS MUX2_X1
X_14258_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[25\]
+ _07786_ _07908_ _00896_ VDD VSS MUX2_X1
X_14259_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[26\]
+ _07788_ _07908_ _00897_ VDD VSS MUX2_X1
X_14260_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[27\]
+ _07790_ _07908_ _00898_ VDD VSS MUX2_X1
X_14261_ _07906_ _07909_ VDD VSS BUF_X4
X_14262_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[28\]
+ _07792_ _07909_ _00899_ VDD VSS MUX2_X1
X_14263_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[29\]
+ _07795_ _07909_ _00900_ VDD VSS MUX2_X1
X_14264_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[2\]
+ _07797_ _07909_ _00901_ VDD VSS MUX2_X1
X_14265_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[30\]
+ _07799_ _07909_ _00902_ VDD VSS MUX2_X1
X_14266_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[31\]
+ _07801_ _07909_ _00903_ VDD VSS MUX2_X1
X_14267_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[32\]
+ _07803_ _07909_ _00904_ VDD VSS MUX2_X1
X_14268_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[33\]
+ _07805_ _07909_ _00905_ VDD VSS MUX2_X1
X_14269_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[34\]
+ _07807_ _07909_ _00906_ VDD VSS MUX2_X1
X_14270_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[35\]
+ _07809_ _07909_ _00907_ VDD VSS MUX2_X1
X_14271_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[36\]
+ _07811_ _07909_ _00908_ VDD VSS MUX2_X1
X_14272_ _07906_ _07910_ VDD VSS BUF_X4
X_14273_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[37\]
+ _07813_ _07910_ _00909_ VDD VSS MUX2_X1
X_14274_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[38\]
+ _07816_ _07910_ _00910_ VDD VSS MUX2_X1
X_14275_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[39\]
+ _07818_ _07910_ _00911_ VDD VSS MUX2_X1
X_14276_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[3\]
+ _07820_ _07910_ _00912_ VDD VSS MUX2_X1
X_14277_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[40\]
+ _07822_ _07910_ _00913_ VDD VSS MUX2_X1
X_14278_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[41\]
+ _07824_ _07910_ _00914_ VDD VSS MUX2_X1
X_14279_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[42\]
+ _07826_ _07910_ _00915_ VDD VSS MUX2_X1
X_14280_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[43\]
+ _07828_ _07910_ _00916_ VDD VSS MUX2_X1
X_14281_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[44\]
+ _07830_ _07910_ _00917_ VDD VSS MUX2_X1
X_14282_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[45\]
+ _07832_ _07910_ _00918_ VDD VSS MUX2_X1
X_14283_ _07906_ _07911_ VDD VSS BUF_X4
X_14284_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[46\]
+ _07834_ _07911_ _00919_ VDD VSS MUX2_X1
X_14285_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[47\]
+ _07837_ _07911_ _00920_ VDD VSS MUX2_X1
X_14286_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[48\]
+ _07839_ _07911_ _00921_ VDD VSS MUX2_X1
X_14287_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[49\]
+ _07841_ _07911_ _00922_ VDD VSS MUX2_X1
X_14288_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[4\]
+ _07843_ _07911_ _00923_ VDD VSS MUX2_X1
X_14289_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[50\]
+ _07845_ _07911_ _00924_ VDD VSS MUX2_X1
X_14290_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[51\]
+ _07847_ _07911_ _00925_ VDD VSS MUX2_X1
X_14291_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[52\]
+ _07849_ _07911_ _00926_ VDD VSS MUX2_X1
X_14292_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[53\]
+ _07851_ _07911_ _00927_ VDD VSS MUX2_X1
X_14293_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[54\]
+ _07853_ _07911_ _00928_ VDD VSS MUX2_X1
X_14294_ _07906_ _07912_ VDD VSS BUF_X4
X_14295_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[55\]
+ _07855_ _07912_ _00929_ VDD VSS MUX2_X1
X_14296_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[56\]
+ _07858_ _07912_ _00930_ VDD VSS MUX2_X1
X_14297_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[57\]
+ _07860_ _07912_ _00931_ VDD VSS MUX2_X1
X_14298_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[58\]
+ _07862_ _07912_ _00932_ VDD VSS MUX2_X1
X_14299_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[59\]
+ _07864_ _07912_ _00933_ VDD VSS MUX2_X1
X_14300_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[5\]
+ _07866_ _07912_ _00934_ VDD VSS MUX2_X1
X_14301_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[60\]
+ _07868_ _07912_ _00935_ VDD VSS MUX2_X1
X_14302_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[61\]
+ _07870_ _07912_ _00936_ VDD VSS MUX2_X1
X_14303_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[62\]
+ _07872_ _07912_ _00937_ VDD VSS MUX2_X1
X_14304_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[63\]
+ _07874_ _07912_ _00938_ VDD VSS MUX2_X1
X_14305_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[6\]
+ _07876_ _07906_ _00939_ VDD VSS MUX2_X1
X_14306_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[7\]
+ _07878_ _07906_ _00940_ VDD VSS MUX2_X1
X_14307_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[8\]
+ _07880_ _07906_ _00941_ VDD VSS MUX2_X1
X_14308_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[9\]
+ _07882_ _07906_ _00942_ VDD VSS MUX2_X1
X_14309_ _07747_ _07677_ _07913_ VDD VSS NAND2_X1
X_14310_ _07885_ _07913_ _07914_ VDD VSS NOR2_X1
X_14311_ _10597_ _07914_ _07915_ VDD VSS NAND2_X1
X_14312_ _07915_ _07916_ VDD VSS BUF_X4
X_14313_ _07916_ _07917_ VDD VSS BUF_X4
X_14314_ _07745_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[0\]
+ _07917_ _00943_ VDD VSS MUX2_X1
X_14315_ _07753_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[10\]
+ _07917_ _00944_ VDD VSS MUX2_X1
X_14316_ _07755_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[11\]
+ _07917_ _00945_ VDD VSS MUX2_X1
X_14317_ _07757_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[12\]
+ _07917_ _00946_ VDD VSS MUX2_X1
X_14318_ _07759_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[13\]
+ _07917_ _00947_ VDD VSS MUX2_X1
X_14319_ _07761_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[14\]
+ _07917_ _00948_ VDD VSS MUX2_X1
X_14320_ _07763_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[15\]
+ _07917_ _00949_ VDD VSS MUX2_X1
X_14321_ _07765_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[16\]
+ _07917_ _00950_ VDD VSS MUX2_X1
X_14322_ _07767_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[17\]
+ _07917_ _00951_ VDD VSS MUX2_X1
X_14323_ _07769_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[18\]
+ _07917_ _00952_ VDD VSS MUX2_X1
X_14324_ _07916_ _07918_ VDD VSS BUF_X4
X_14325_ _07771_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[19\]
+ _07918_ _00953_ VDD VSS MUX2_X1
X_14326_ _07774_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[1\]
+ _07918_ _00954_ VDD VSS MUX2_X1
X_14327_ _07776_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[20\]
+ _07918_ _00955_ VDD VSS MUX2_X1
X_14328_ _07778_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[21\]
+ _07918_ _00956_ VDD VSS MUX2_X1
X_14329_ _07780_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[22\]
+ _07918_ _00957_ VDD VSS MUX2_X1
X_14330_ _07782_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[23\]
+ _07918_ _00958_ VDD VSS MUX2_X1
X_14331_ _07784_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[24\]
+ _07918_ _00959_ VDD VSS MUX2_X1
X_14332_ _07786_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[25\]
+ _07918_ _00960_ VDD VSS MUX2_X1
X_14333_ _07788_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[26\]
+ _07918_ _00961_ VDD VSS MUX2_X1
X_14334_ _07790_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[27\]
+ _07918_ _00962_ VDD VSS MUX2_X1
X_14335_ _07916_ _07919_ VDD VSS BUF_X4
X_14336_ _07792_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[28\]
+ _07919_ _00963_ VDD VSS MUX2_X1
X_14337_ _07795_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[29\]
+ _07919_ _00964_ VDD VSS MUX2_X1
X_14338_ _07797_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[2\]
+ _07919_ _00965_ VDD VSS MUX2_X1
X_14339_ _07799_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[30\]
+ _07919_ _00966_ VDD VSS MUX2_X1
X_14340_ _07801_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[31\]
+ _07919_ _00967_ VDD VSS MUX2_X1
X_14341_ _07803_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[32\]
+ _07919_ _00968_ VDD VSS MUX2_X1
X_14342_ _07805_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[33\]
+ _07919_ _00969_ VDD VSS MUX2_X1
X_14343_ _07807_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[34\]
+ _07919_ _00970_ VDD VSS MUX2_X1
X_14344_ _07809_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[35\]
+ _07919_ _00971_ VDD VSS MUX2_X1
X_14345_ _07811_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[36\]
+ _07919_ _00972_ VDD VSS MUX2_X1
X_14346_ _07916_ _07920_ VDD VSS BUF_X4
X_14347_ _07813_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[37\]
+ _07920_ _00973_ VDD VSS MUX2_X1
X_14348_ _07816_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[38\]
+ _07920_ _00974_ VDD VSS MUX2_X1
X_14349_ _07818_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[39\]
+ _07920_ _00975_ VDD VSS MUX2_X1
X_14350_ _07820_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[3\]
+ _07920_ _00976_ VDD VSS MUX2_X1
X_14351_ _07822_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[40\]
+ _07920_ _00977_ VDD VSS MUX2_X1
X_14352_ _07824_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[41\]
+ _07920_ _00978_ VDD VSS MUX2_X1
X_14353_ _07826_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[42\]
+ _07920_ _00979_ VDD VSS MUX2_X1
X_14354_ _07828_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[43\]
+ _07920_ _00980_ VDD VSS MUX2_X1
X_14355_ _07830_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[44\]
+ _07920_ _00981_ VDD VSS MUX2_X1
X_14356_ _07832_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[45\]
+ _07920_ _00982_ VDD VSS MUX2_X1
X_14357_ _07916_ _07921_ VDD VSS BUF_X4
X_14358_ _07834_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[46\]
+ _07921_ _00983_ VDD VSS MUX2_X1
X_14359_ _07837_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[47\]
+ _07921_ _00984_ VDD VSS MUX2_X1
X_14360_ _07839_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[48\]
+ _07921_ _00985_ VDD VSS MUX2_X1
X_14361_ _07841_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[49\]
+ _07921_ _00986_ VDD VSS MUX2_X1
X_14362_ _07843_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[4\]
+ _07921_ _00987_ VDD VSS MUX2_X1
X_14363_ _07845_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[50\]
+ _07921_ _00988_ VDD VSS MUX2_X1
X_14364_ _07847_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[51\]
+ _07921_ _00989_ VDD VSS MUX2_X1
X_14365_ _07849_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[52\]
+ _07921_ _00990_ VDD VSS MUX2_X1
X_14366_ _07851_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[53\]
+ _07921_ _00991_ VDD VSS MUX2_X1
X_14367_ _07853_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[54\]
+ _07921_ _00992_ VDD VSS MUX2_X1
X_14368_ _07916_ _07922_ VDD VSS BUF_X4
X_14369_ _07855_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[55\]
+ _07922_ _00993_ VDD VSS MUX2_X1
X_14370_ _07858_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[56\]
+ _07922_ _00994_ VDD VSS MUX2_X1
X_14371_ _07860_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[57\]
+ _07922_ _00995_ VDD VSS MUX2_X1
X_14372_ _07862_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[58\]
+ _07922_ _00996_ VDD VSS MUX2_X1
X_14373_ _07864_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[59\]
+ _07922_ _00997_ VDD VSS MUX2_X1
X_14374_ _07866_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[5\]
+ _07922_ _00998_ VDD VSS MUX2_X1
X_14375_ _07868_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[60\]
+ _07922_ _00999_ VDD VSS MUX2_X1
X_14376_ _07870_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[61\]
+ _07922_ _01000_ VDD VSS MUX2_X1
X_14377_ _07872_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[62\]
+ _07922_ _01001_ VDD VSS MUX2_X1
X_14378_ _07874_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[63\]
+ _07922_ _01002_ VDD VSS MUX2_X1
X_14379_ _07876_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[6\]
+ _07916_ _01003_ VDD VSS MUX2_X1
X_14380_ _07878_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[7\]
+ _07916_ _01004_ VDD VSS MUX2_X1
X_14381_ _07880_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[8\]
+ _07916_ _01005_ VDD VSS MUX2_X1
X_14382_ _07882_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[9\]
+ _07916_ _01006_ VDD VSS MUX2_X1
X_14383_ _10595_ _07914_ _07923_ VDD VSS NAND2_X1
X_14384_ _07923_ _07924_ VDD VSS BUF_X4
X_14385_ _07924_ _07925_ VDD VSS BUF_X4
X_14386_ _07745_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[0\]
+ _07925_ _01007_ VDD VSS MUX2_X1
X_14387_ _07753_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[10\]
+ _07925_ _01008_ VDD VSS MUX2_X1
X_14388_ _07755_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[11\]
+ _07925_ _01009_ VDD VSS MUX2_X1
X_14389_ _07757_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[12\]
+ _07925_ _01010_ VDD VSS MUX2_X1
X_14390_ _07759_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[13\]
+ _07925_ _01011_ VDD VSS MUX2_X1
X_14391_ _07761_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[14\]
+ _07925_ _01012_ VDD VSS MUX2_X1
X_14392_ _07763_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[15\]
+ _07925_ _01013_ VDD VSS MUX2_X1
X_14393_ _07765_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[16\]
+ _07925_ _01014_ VDD VSS MUX2_X1
X_14394_ _07767_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[17\]
+ _07925_ _01015_ VDD VSS MUX2_X1
X_14395_ _07769_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[18\]
+ _07925_ _01016_ VDD VSS MUX2_X1
X_14396_ _07924_ _07926_ VDD VSS BUF_X4
X_14397_ _07771_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[19\]
+ _07926_ _01017_ VDD VSS MUX2_X1
X_14398_ _07774_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[1\]
+ _07926_ _01018_ VDD VSS MUX2_X1
X_14399_ _07776_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[20\]
+ _07926_ _01019_ VDD VSS MUX2_X1
X_14400_ _07778_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[21\]
+ _07926_ _01020_ VDD VSS MUX2_X1
X_14401_ _07780_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[22\]
+ _07926_ _01021_ VDD VSS MUX2_X1
X_14402_ _07782_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[23\]
+ _07926_ _01022_ VDD VSS MUX2_X1
X_14403_ _07784_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[24\]
+ _07926_ _01023_ VDD VSS MUX2_X1
X_14404_ _07786_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[25\]
+ _07926_ _01024_ VDD VSS MUX2_X1
X_14405_ _07788_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[26\]
+ _07926_ _01025_ VDD VSS MUX2_X1
X_14406_ _07790_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[27\]
+ _07926_ _01026_ VDD VSS MUX2_X1
X_14407_ _07924_ _07927_ VDD VSS BUF_X4
X_14408_ _07792_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[28\]
+ _07927_ _01027_ VDD VSS MUX2_X1
X_14409_ _07795_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[29\]
+ _07927_ _01028_ VDD VSS MUX2_X1
X_14410_ _07797_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[2\]
+ _07927_ _01029_ VDD VSS MUX2_X1
X_14411_ _07799_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[30\]
+ _07927_ _01030_ VDD VSS MUX2_X1
X_14412_ _07801_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[31\]
+ _07927_ _01031_ VDD VSS MUX2_X1
X_14413_ _07803_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[32\]
+ _07927_ _01032_ VDD VSS MUX2_X1
X_14414_ _07805_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[33\]
+ _07927_ _01033_ VDD VSS MUX2_X1
X_14415_ _07807_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[34\]
+ _07927_ _01034_ VDD VSS MUX2_X1
X_14416_ _07809_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[35\]
+ _07927_ _01035_ VDD VSS MUX2_X1
X_14417_ _07811_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[36\]
+ _07927_ _01036_ VDD VSS MUX2_X1
X_14418_ _07924_ _07928_ VDD VSS BUF_X4
X_14419_ _07813_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[37\]
+ _07928_ _01037_ VDD VSS MUX2_X1
X_14420_ _07816_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[38\]
+ _07928_ _01038_ VDD VSS MUX2_X1
X_14421_ _07818_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[39\]
+ _07928_ _01039_ VDD VSS MUX2_X1
X_14422_ _07820_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[3\]
+ _07928_ _01040_ VDD VSS MUX2_X1
X_14423_ _07822_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[40\]
+ _07928_ _01041_ VDD VSS MUX2_X1
X_14424_ _07824_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[41\]
+ _07928_ _01042_ VDD VSS MUX2_X1
X_14425_ _07826_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[42\]
+ _07928_ _01043_ VDD VSS MUX2_X1
X_14426_ _07828_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[43\]
+ _07928_ _01044_ VDD VSS MUX2_X1
X_14427_ _07830_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[44\]
+ _07928_ _01045_ VDD VSS MUX2_X1
X_14428_ _07832_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[45\]
+ _07928_ _01046_ VDD VSS MUX2_X1
X_14429_ _07924_ _07929_ VDD VSS BUF_X4
X_14430_ _07834_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[46\]
+ _07929_ _01047_ VDD VSS MUX2_X1
X_14431_ _07837_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[47\]
+ _07929_ _01048_ VDD VSS MUX2_X1
X_14432_ _07839_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[48\]
+ _07929_ _01049_ VDD VSS MUX2_X1
X_14433_ _07841_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[49\]
+ _07929_ _01050_ VDD VSS MUX2_X1
X_14434_ _07843_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[4\]
+ _07929_ _01051_ VDD VSS MUX2_X1
X_14435_ _07845_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[50\]
+ _07929_ _01052_ VDD VSS MUX2_X1
X_14436_ _07847_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[51\]
+ _07929_ _01053_ VDD VSS MUX2_X1
X_14437_ _07849_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[52\]
+ _07929_ _01054_ VDD VSS MUX2_X1
X_14438_ _07851_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[53\]
+ _07929_ _01055_ VDD VSS MUX2_X1
X_14439_ _07853_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[54\]
+ _07929_ _01056_ VDD VSS MUX2_X1
X_14440_ _07924_ _07930_ VDD VSS BUF_X4
X_14441_ _07855_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[55\]
+ _07930_ _01057_ VDD VSS MUX2_X1
X_14442_ _07858_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[56\]
+ _07930_ _01058_ VDD VSS MUX2_X1
X_14443_ _07860_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[57\]
+ _07930_ _01059_ VDD VSS MUX2_X1
X_14444_ _07862_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[58\]
+ _07930_ _01060_ VDD VSS MUX2_X1
X_14445_ _07864_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[59\]
+ _07930_ _01061_ VDD VSS MUX2_X1
X_14446_ _07866_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[5\]
+ _07930_ _01062_ VDD VSS MUX2_X1
X_14447_ _07868_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[60\]
+ _07930_ _01063_ VDD VSS MUX2_X1
X_14448_ _07870_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[61\]
+ _07930_ _01064_ VDD VSS MUX2_X1
X_14449_ _07872_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[62\]
+ _07930_ _01065_ VDD VSS MUX2_X1
X_14450_ _07874_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[63\]
+ _07930_ _01066_ VDD VSS MUX2_X1
X_14451_ _07876_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[6\]
+ _07924_ _01067_ VDD VSS MUX2_X1
X_14452_ _07878_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[7\]
+ _07924_ _01068_ VDD VSS MUX2_X1
X_14453_ _07880_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[8\]
+ _07924_ _01069_ VDD VSS MUX2_X1
X_14454_ _07882_ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[9\]
+ _07924_ _01070_ VDD VSS MUX2_X1
X_14455_ _07895_ _07914_ _07931_ VDD VSS NAND2_X1
X_14456_ _07931_ _07932_ VDD VSS BUF_X4
X_14457_ _07932_ _07933_ VDD VSS BUF_X4
X_14458_ _07745_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[0\]
+ _07933_ _01071_ VDD VSS MUX2_X1
X_14459_ _07753_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[10\]
+ _07933_ _01072_ VDD VSS MUX2_X1
X_14460_ _07755_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[11\]
+ _07933_ _01073_ VDD VSS MUX2_X1
X_14461_ _07757_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[12\]
+ _07933_ _01074_ VDD VSS MUX2_X1
X_14462_ _07759_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[13\]
+ _07933_ _01075_ VDD VSS MUX2_X1
X_14463_ _07761_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[14\]
+ _07933_ _01076_ VDD VSS MUX2_X1
X_14464_ _07763_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[15\]
+ _07933_ _01077_ VDD VSS MUX2_X1
X_14465_ _07765_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[16\]
+ _07933_ _01078_ VDD VSS MUX2_X1
X_14466_ _07767_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[17\]
+ _07933_ _01079_ VDD VSS MUX2_X1
X_14467_ _07769_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[18\]
+ _07933_ _01080_ VDD VSS MUX2_X1
X_14468_ _07932_ _07934_ VDD VSS BUF_X4
X_14469_ _07771_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[19\]
+ _07934_ _01081_ VDD VSS MUX2_X1
X_14470_ _07774_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[1\]
+ _07934_ _01082_ VDD VSS MUX2_X1
X_14471_ _07776_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[20\]
+ _07934_ _01083_ VDD VSS MUX2_X1
X_14472_ _07778_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[21\]
+ _07934_ _01084_ VDD VSS MUX2_X1
X_14473_ _07780_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[22\]
+ _07934_ _01085_ VDD VSS MUX2_X1
X_14474_ _07782_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[23\]
+ _07934_ _01086_ VDD VSS MUX2_X1
X_14475_ _07784_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[24\]
+ _07934_ _01087_ VDD VSS MUX2_X1
X_14476_ _07786_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[25\]
+ _07934_ _01088_ VDD VSS MUX2_X1
X_14477_ _07788_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[26\]
+ _07934_ _01089_ VDD VSS MUX2_X1
X_14478_ _07790_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[27\]
+ _07934_ _01090_ VDD VSS MUX2_X1
X_14479_ _07932_ _07935_ VDD VSS BUF_X4
X_14480_ _07792_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[28\]
+ _07935_ _01091_ VDD VSS MUX2_X1
X_14481_ _07795_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[29\]
+ _07935_ _01092_ VDD VSS MUX2_X1
X_14482_ _07797_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[2\]
+ _07935_ _01093_ VDD VSS MUX2_X1
X_14483_ _07799_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[30\]
+ _07935_ _01094_ VDD VSS MUX2_X1
X_14484_ _07801_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[31\]
+ _07935_ _01095_ VDD VSS MUX2_X1
X_14485_ _07803_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[32\]
+ _07935_ _01096_ VDD VSS MUX2_X1
X_14486_ _07805_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[33\]
+ _07935_ _01097_ VDD VSS MUX2_X1
X_14487_ _07807_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[34\]
+ _07935_ _01098_ VDD VSS MUX2_X1
X_14488_ _07809_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[35\]
+ _07935_ _01099_ VDD VSS MUX2_X1
X_14489_ _07811_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[36\]
+ _07935_ _01100_ VDD VSS MUX2_X1
X_14490_ _07932_ _07936_ VDD VSS BUF_X4
X_14491_ _07813_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[37\]
+ _07936_ _01101_ VDD VSS MUX2_X1
X_14492_ _07816_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[38\]
+ _07936_ _01102_ VDD VSS MUX2_X1
X_14493_ _07818_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[39\]
+ _07936_ _01103_ VDD VSS MUX2_X1
X_14494_ _07820_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[3\]
+ _07936_ _01104_ VDD VSS MUX2_X1
X_14495_ _07822_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[40\]
+ _07936_ _01105_ VDD VSS MUX2_X1
X_14496_ _07824_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[41\]
+ _07936_ _01106_ VDD VSS MUX2_X1
X_14497_ _07826_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[42\]
+ _07936_ _01107_ VDD VSS MUX2_X1
X_14498_ _07828_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[43\]
+ _07936_ _01108_ VDD VSS MUX2_X1
X_14499_ _07830_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[44\]
+ _07936_ _01109_ VDD VSS MUX2_X1
X_14500_ _07832_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[45\]
+ _07936_ _01110_ VDD VSS MUX2_X1
X_14501_ _07932_ _07937_ VDD VSS BUF_X4
X_14502_ _07834_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[46\]
+ _07937_ _01111_ VDD VSS MUX2_X1
X_14503_ _07837_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[47\]
+ _07937_ _01112_ VDD VSS MUX2_X1
X_14504_ _07839_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[48\]
+ _07937_ _01113_ VDD VSS MUX2_X1
X_14505_ _07841_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[49\]
+ _07937_ _01114_ VDD VSS MUX2_X1
X_14506_ _07843_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[4\]
+ _07937_ _01115_ VDD VSS MUX2_X1
X_14507_ _07845_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[50\]
+ _07937_ _01116_ VDD VSS MUX2_X1
X_14508_ _07847_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[51\]
+ _07937_ _01117_ VDD VSS MUX2_X1
X_14509_ _07849_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[52\]
+ _07937_ _01118_ VDD VSS MUX2_X1
X_14510_ _07851_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[53\]
+ _07937_ _01119_ VDD VSS MUX2_X1
X_14511_ _07853_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[54\]
+ _07937_ _01120_ VDD VSS MUX2_X1
X_14512_ _07932_ _07938_ VDD VSS BUF_X4
X_14513_ _07855_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[55\]
+ _07938_ _01121_ VDD VSS MUX2_X1
X_14514_ _07858_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[56\]
+ _07938_ _01122_ VDD VSS MUX2_X1
X_14515_ _07860_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[57\]
+ _07938_ _01123_ VDD VSS MUX2_X1
X_14516_ _07862_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[58\]
+ _07938_ _01124_ VDD VSS MUX2_X1
X_14517_ _07864_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[59\]
+ _07938_ _01125_ VDD VSS MUX2_X1
X_14518_ _07866_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[5\]
+ _07938_ _01126_ VDD VSS MUX2_X1
X_14519_ _07868_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[60\]
+ _07938_ _01127_ VDD VSS MUX2_X1
X_14520_ _07870_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[61\]
+ _07938_ _01128_ VDD VSS MUX2_X1
X_14521_ _07872_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[62\]
+ _07938_ _01129_ VDD VSS MUX2_X1
X_14522_ _07874_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[63\]
+ _07938_ _01130_ VDD VSS MUX2_X1
X_14523_ _07876_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[6\]
+ _07932_ _01131_ VDD VSS MUX2_X1
X_14524_ _07878_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[7\]
+ _07932_ _01132_ VDD VSS MUX2_X1
X_14525_ _07880_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[8\]
+ _07932_ _01133_ VDD VSS MUX2_X1
X_14526_ _07882_ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[9\]
+ _07932_ _01134_ VDD VSS MUX2_X1
X_14527_ _06540_ _07746_ _07884_ _07939_ VDD VSS NOR3_X2
X_14528_ _10597_ _07939_ _07940_ VDD VSS NAND2_X1
X_14529_ _07940_ _07941_ VDD VSS BUF_X4
X_14530_ _07941_ _07942_ VDD VSS CLKBUF_X3
X_14531_ _07745_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[0\]
+ _07942_ _01135_ VDD VSS MUX2_X1
X_14532_ _07753_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[10\]
+ _07942_ _01136_ VDD VSS MUX2_X1
X_14533_ _07755_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[11\]
+ _07942_ _01137_ VDD VSS MUX2_X1
X_14534_ _07757_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[12\]
+ _07942_ _01138_ VDD VSS MUX2_X1
X_14535_ _07759_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[13\]
+ _07942_ _01139_ VDD VSS MUX2_X1
X_14536_ _07761_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[14\]
+ _07942_ _01140_ VDD VSS MUX2_X1
X_14537_ _07763_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[15\]
+ _07942_ _01141_ VDD VSS MUX2_X1
X_14538_ _07765_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[16\]
+ _07942_ _01142_ VDD VSS MUX2_X1
X_14539_ _07767_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[17\]
+ _07942_ _01143_ VDD VSS MUX2_X1
X_14540_ _07769_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[18\]
+ _07942_ _01144_ VDD VSS MUX2_X1
X_14541_ _07941_ _07943_ VDD VSS BUF_X4
X_14542_ _07771_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[19\]
+ _07943_ _01145_ VDD VSS MUX2_X1
X_14543_ _07774_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[1\]
+ _07943_ _01146_ VDD VSS MUX2_X1
X_14544_ _07776_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[20\]
+ _07943_ _01147_ VDD VSS MUX2_X1
X_14545_ _07778_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[21\]
+ _07943_ _01148_ VDD VSS MUX2_X1
X_14546_ _07780_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[22\]
+ _07943_ _01149_ VDD VSS MUX2_X1
X_14547_ _07782_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[23\]
+ _07943_ _01150_ VDD VSS MUX2_X1
X_14548_ _07784_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[24\]
+ _07943_ _01151_ VDD VSS MUX2_X1
X_14549_ _07786_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[25\]
+ _07943_ _01152_ VDD VSS MUX2_X1
X_14550_ _07788_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[26\]
+ _07943_ _01153_ VDD VSS MUX2_X1
X_14551_ _07790_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[27\]
+ _07943_ _01154_ VDD VSS MUX2_X1
X_14552_ _07941_ _07944_ VDD VSS BUF_X4
X_14553_ _07792_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[28\]
+ _07944_ _01155_ VDD VSS MUX2_X1
X_14554_ _07795_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[29\]
+ _07944_ _01156_ VDD VSS MUX2_X1
X_14555_ _07797_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[2\]
+ _07944_ _01157_ VDD VSS MUX2_X1
X_14556_ _07799_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[30\]
+ _07944_ _01158_ VDD VSS MUX2_X1
X_14557_ _07801_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[31\]
+ _07944_ _01159_ VDD VSS MUX2_X1
X_14558_ _07803_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[32\]
+ _07944_ _01160_ VDD VSS MUX2_X1
X_14559_ _07805_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[33\]
+ _07944_ _01161_ VDD VSS MUX2_X1
X_14560_ _07807_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[34\]
+ _07944_ _01162_ VDD VSS MUX2_X1
X_14561_ _07809_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[35\]
+ _07944_ _01163_ VDD VSS MUX2_X1
X_14562_ _07811_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[36\]
+ _07944_ _01164_ VDD VSS MUX2_X1
X_14563_ _07941_ _07945_ VDD VSS BUF_X4
X_14564_ _07813_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[37\]
+ _07945_ _01165_ VDD VSS MUX2_X1
X_14565_ _07816_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[38\]
+ _07945_ _01166_ VDD VSS MUX2_X1
X_14566_ _07818_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[39\]
+ _07945_ _01167_ VDD VSS MUX2_X1
X_14567_ _07820_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[3\]
+ _07945_ _01168_ VDD VSS MUX2_X1
X_14568_ _07822_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[40\]
+ _07945_ _01169_ VDD VSS MUX2_X1
X_14569_ _07824_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[41\]
+ _07945_ _01170_ VDD VSS MUX2_X1
X_14570_ _07826_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[42\]
+ _07945_ _01171_ VDD VSS MUX2_X1
X_14571_ _07828_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[43\]
+ _07945_ _01172_ VDD VSS MUX2_X1
X_14572_ _07830_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[44\]
+ _07945_ _01173_ VDD VSS MUX2_X1
X_14573_ _07832_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[45\]
+ _07945_ _01174_ VDD VSS MUX2_X1
X_14574_ _07941_ _07946_ VDD VSS BUF_X4
X_14575_ _07834_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[46\]
+ _07946_ _01175_ VDD VSS MUX2_X1
X_14576_ _07837_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[47\]
+ _07946_ _01176_ VDD VSS MUX2_X1
X_14577_ _07839_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[48\]
+ _07946_ _01177_ VDD VSS MUX2_X1
X_14578_ _07841_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[49\]
+ _07946_ _01178_ VDD VSS MUX2_X1
X_14579_ _07843_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[4\]
+ _07946_ _01179_ VDD VSS MUX2_X1
X_14580_ _07845_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[50\]
+ _07946_ _01180_ VDD VSS MUX2_X1
X_14581_ _07847_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[51\]
+ _07946_ _01181_ VDD VSS MUX2_X1
X_14582_ _07849_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[52\]
+ _07946_ _01182_ VDD VSS MUX2_X1
X_14583_ _07851_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[53\]
+ _07946_ _01183_ VDD VSS MUX2_X1
X_14584_ _07853_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[54\]
+ _07946_ _01184_ VDD VSS MUX2_X1
X_14585_ _07941_ _07947_ VDD VSS BUF_X4
X_14586_ _07855_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[55\]
+ _07947_ _01185_ VDD VSS MUX2_X1
X_14587_ _07858_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[56\]
+ _07947_ _01186_ VDD VSS MUX2_X1
X_14588_ _07860_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[57\]
+ _07947_ _01187_ VDD VSS MUX2_X1
X_14589_ _07862_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[58\]
+ _07947_ _01188_ VDD VSS MUX2_X1
X_14590_ _07864_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[59\]
+ _07947_ _01189_ VDD VSS MUX2_X1
X_14591_ _07866_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[5\]
+ _07947_ _01190_ VDD VSS MUX2_X1
X_14592_ _07868_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[60\]
+ _07947_ _01191_ VDD VSS MUX2_X1
X_14593_ _07870_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[61\]
+ _07947_ _01192_ VDD VSS MUX2_X1
X_14594_ _07872_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[62\]
+ _07947_ _01193_ VDD VSS MUX2_X1
X_14595_ _07874_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[63\]
+ _07947_ _01194_ VDD VSS MUX2_X1
X_14596_ _07876_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[6\]
+ _07941_ _01195_ VDD VSS MUX2_X1
X_14597_ _07878_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[7\]
+ _07941_ _01196_ VDD VSS MUX2_X1
X_14598_ _07880_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[8\]
+ _07941_ _01197_ VDD VSS MUX2_X1
X_14599_ _07882_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[9\]
+ _07941_ _01198_ VDD VSS MUX2_X1
X_14600_ _10595_ _07939_ _07948_ VDD VSS NAND2_X1
X_14601_ _07948_ _07949_ VDD VSS BUF_X4
X_14602_ _07949_ _07950_ VDD VSS CLKBUF_X3
X_14603_ _07744_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[0\]
+ _07950_ _01199_ VDD VSS MUX2_X1
X_14604_ _07752_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[10\]
+ _07950_ _01200_ VDD VSS MUX2_X1
X_14605_ _07754_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[11\]
+ _07950_ _01201_ VDD VSS MUX2_X1
X_14606_ _07756_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[12\]
+ _07950_ _01202_ VDD VSS MUX2_X1
X_14607_ _07758_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[13\]
+ _07950_ _01203_ VDD VSS MUX2_X1
X_14608_ _07760_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[14\]
+ _07950_ _01204_ VDD VSS MUX2_X1
X_14609_ _07762_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[15\]
+ _07950_ _01205_ VDD VSS MUX2_X1
X_14610_ _07764_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[16\]
+ _07950_ _01206_ VDD VSS MUX2_X1
X_14611_ _07766_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[17\]
+ _07950_ _01207_ VDD VSS MUX2_X1
X_14612_ _07768_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[18\]
+ _07950_ _01208_ VDD VSS MUX2_X1
X_14613_ _07949_ _07951_ VDD VSS BUF_X4
X_14614_ _07770_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[19\]
+ _07951_ _01209_ VDD VSS MUX2_X1
X_14615_ _07773_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[1\]
+ _07951_ _01210_ VDD VSS MUX2_X1
X_14616_ _07775_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[20\]
+ _07951_ _01211_ VDD VSS MUX2_X1
X_14617_ _07777_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[21\]
+ _07951_ _01212_ VDD VSS MUX2_X1
X_14618_ _07779_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[22\]
+ _07951_ _01213_ VDD VSS MUX2_X1
X_14619_ _07781_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[23\]
+ _07951_ _01214_ VDD VSS MUX2_X1
X_14620_ _07783_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[24\]
+ _07951_ _01215_ VDD VSS MUX2_X1
X_14621_ _07785_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[25\]
+ _07951_ _01216_ VDD VSS MUX2_X1
X_14622_ _07787_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[26\]
+ _07951_ _01217_ VDD VSS MUX2_X1
X_14623_ _07789_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[27\]
+ _07951_ _01218_ VDD VSS MUX2_X1
X_14624_ _07949_ _07952_ VDD VSS BUF_X4
X_14625_ _07791_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[28\]
+ _07952_ _01219_ VDD VSS MUX2_X1
X_14626_ _07794_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[29\]
+ _07952_ _01220_ VDD VSS MUX2_X1
X_14627_ _07796_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[2\]
+ _07952_ _01221_ VDD VSS MUX2_X1
X_14628_ _07798_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[30\]
+ _07952_ _01222_ VDD VSS MUX2_X1
X_14629_ _07800_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[31\]
+ _07952_ _01223_ VDD VSS MUX2_X1
X_14630_ _07802_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[32\]
+ _07952_ _01224_ VDD VSS MUX2_X1
X_14631_ _07804_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[33\]
+ _07952_ _01225_ VDD VSS MUX2_X1
X_14632_ _07806_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[34\]
+ _07952_ _01226_ VDD VSS MUX2_X1
X_14633_ _07808_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[35\]
+ _07952_ _01227_ VDD VSS MUX2_X1
X_14634_ _07810_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[36\]
+ _07952_ _01228_ VDD VSS MUX2_X1
X_14635_ _07949_ _07953_ VDD VSS BUF_X4
X_14636_ _07812_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[37\]
+ _07953_ _01229_ VDD VSS MUX2_X1
X_14637_ _07815_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[38\]
+ _07953_ _01230_ VDD VSS MUX2_X1
X_14638_ _07817_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[39\]
+ _07953_ _01231_ VDD VSS MUX2_X1
X_14639_ _07819_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[3\]
+ _07953_ _01232_ VDD VSS MUX2_X1
X_14640_ _07821_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[40\]
+ _07953_ _01233_ VDD VSS MUX2_X1
X_14641_ _07823_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[41\]
+ _07953_ _01234_ VDD VSS MUX2_X1
X_14642_ _07825_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[42\]
+ _07953_ _01235_ VDD VSS MUX2_X1
X_14643_ _07827_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[43\]
+ _07953_ _01236_ VDD VSS MUX2_X1
X_14644_ _07829_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[44\]
+ _07953_ _01237_ VDD VSS MUX2_X1
X_14645_ _07831_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[45\]
+ _07953_ _01238_ VDD VSS MUX2_X1
X_14646_ _07949_ _07954_ VDD VSS BUF_X4
X_14647_ _07833_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[46\]
+ _07954_ _01239_ VDD VSS MUX2_X1
X_14648_ _07836_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[47\]
+ _07954_ _01240_ VDD VSS MUX2_X1
X_14649_ _07838_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[48\]
+ _07954_ _01241_ VDD VSS MUX2_X1
X_14650_ _07840_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[49\]
+ _07954_ _01242_ VDD VSS MUX2_X1
X_14651_ _07842_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[4\]
+ _07954_ _01243_ VDD VSS MUX2_X1
X_14652_ _07844_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[50\]
+ _07954_ _01244_ VDD VSS MUX2_X1
X_14653_ _07846_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[51\]
+ _07954_ _01245_ VDD VSS MUX2_X1
X_14654_ _07848_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[52\]
+ _07954_ _01246_ VDD VSS MUX2_X1
X_14655_ _07850_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[53\]
+ _07954_ _01247_ VDD VSS MUX2_X1
X_14656_ _07852_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[54\]
+ _07954_ _01248_ VDD VSS MUX2_X1
X_14657_ _07949_ _07955_ VDD VSS BUF_X4
X_14658_ _07854_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[55\]
+ _07955_ _01249_ VDD VSS MUX2_X1
X_14659_ _07857_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[56\]
+ _07955_ _01250_ VDD VSS MUX2_X1
X_14660_ _07859_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[57\]
+ _07955_ _01251_ VDD VSS MUX2_X1
X_14661_ _07861_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[58\]
+ _07955_ _01252_ VDD VSS MUX2_X1
X_14662_ _07863_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[59\]
+ _07955_ _01253_ VDD VSS MUX2_X1
X_14663_ _07865_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[5\]
+ _07955_ _01254_ VDD VSS MUX2_X1
X_14664_ _07867_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[60\]
+ _07955_ _01255_ VDD VSS MUX2_X1
X_14665_ _07869_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[61\]
+ _07955_ _01256_ VDD VSS MUX2_X1
X_14666_ _07871_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[62\]
+ _07955_ _01257_ VDD VSS MUX2_X1
X_14667_ _07873_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[63\]
+ _07955_ _01258_ VDD VSS MUX2_X1
X_14668_ _07875_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[6\]
+ _07949_ _01259_ VDD VSS MUX2_X1
X_14669_ _07877_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[7\]
+ _07949_ _01260_ VDD VSS MUX2_X1
X_14670_ _07879_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[8\]
+ _07949_ _01261_ VDD VSS MUX2_X1
X_14671_ _07881_ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[9\]
+ _07949_ _01262_ VDD VSS MUX2_X1
X_14672_ _07895_ _07939_ _07956_ VDD VSS NAND2_X1
X_14673_ _07956_ _07957_ VDD VSS BUF_X4
X_14674_ _07957_ _07958_ VDD VSS CLKBUF_X3
X_14675_ _07744_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[0\]
+ _07958_ _01263_ VDD VSS MUX2_X1
X_14676_ _07752_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[10\]
+ _07958_ _01264_ VDD VSS MUX2_X1
X_14677_ _07754_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[11\]
+ _07958_ _01265_ VDD VSS MUX2_X1
X_14678_ _07756_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[12\]
+ _07958_ _01266_ VDD VSS MUX2_X1
X_14679_ _07758_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[13\]
+ _07958_ _01267_ VDD VSS MUX2_X1
X_14680_ _07760_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[14\]
+ _07958_ _01268_ VDD VSS MUX2_X1
X_14681_ _07762_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[15\]
+ _07958_ _01269_ VDD VSS MUX2_X1
X_14682_ _07764_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[16\]
+ _07958_ _01270_ VDD VSS MUX2_X1
X_14683_ _07766_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[17\]
+ _07958_ _01271_ VDD VSS MUX2_X1
X_14684_ _07768_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[18\]
+ _07958_ _01272_ VDD VSS MUX2_X1
X_14685_ _07957_ _07959_ VDD VSS BUF_X4
X_14686_ _07770_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[19\]
+ _07959_ _01273_ VDD VSS MUX2_X1
X_14687_ _07773_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[1\]
+ _07959_ _01274_ VDD VSS MUX2_X1
X_14688_ _07775_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[20\]
+ _07959_ _01275_ VDD VSS MUX2_X1
X_14689_ _07777_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[21\]
+ _07959_ _01276_ VDD VSS MUX2_X1
X_14690_ _07779_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[22\]
+ _07959_ _01277_ VDD VSS MUX2_X1
X_14691_ _07781_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[23\]
+ _07959_ _01278_ VDD VSS MUX2_X1
X_14692_ _07783_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[24\]
+ _07959_ _01279_ VDD VSS MUX2_X1
X_14693_ _07785_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[25\]
+ _07959_ _01280_ VDD VSS MUX2_X1
X_14694_ _07787_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[26\]
+ _07959_ _01281_ VDD VSS MUX2_X1
X_14695_ _07789_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[27\]
+ _07959_ _01282_ VDD VSS MUX2_X1
X_14696_ _07957_ _07960_ VDD VSS BUF_X4
X_14697_ _07791_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[28\]
+ _07960_ _01283_ VDD VSS MUX2_X1
X_14698_ _07794_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[29\]
+ _07960_ _01284_ VDD VSS MUX2_X1
X_14699_ _07796_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[2\]
+ _07960_ _01285_ VDD VSS MUX2_X1
X_14700_ _07798_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[30\]
+ _07960_ _01286_ VDD VSS MUX2_X1
X_14701_ _07800_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[31\]
+ _07960_ _01287_ VDD VSS MUX2_X1
X_14702_ _07802_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[32\]
+ _07960_ _01288_ VDD VSS MUX2_X1
X_14703_ _07804_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[33\]
+ _07960_ _01289_ VDD VSS MUX2_X1
X_14704_ _07806_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[34\]
+ _07960_ _01290_ VDD VSS MUX2_X1
X_14705_ _07808_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[35\]
+ _07960_ _01291_ VDD VSS MUX2_X1
X_14706_ _07810_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[36\]
+ _07960_ _01292_ VDD VSS MUX2_X1
X_14707_ _07957_ _07961_ VDD VSS BUF_X4
X_14708_ _07812_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[37\]
+ _07961_ _01293_ VDD VSS MUX2_X1
X_14709_ _07815_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[38\]
+ _07961_ _01294_ VDD VSS MUX2_X1
X_14710_ _07817_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[39\]
+ _07961_ _01295_ VDD VSS MUX2_X1
X_14711_ _07819_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[3\]
+ _07961_ _01296_ VDD VSS MUX2_X1
X_14712_ _07821_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[40\]
+ _07961_ _01297_ VDD VSS MUX2_X1
X_14713_ _07823_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[41\]
+ _07961_ _01298_ VDD VSS MUX2_X1
X_14714_ _07825_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[42\]
+ _07961_ _01299_ VDD VSS MUX2_X1
X_14715_ _07827_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[43\]
+ _07961_ _01300_ VDD VSS MUX2_X1
X_14716_ _07829_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[44\]
+ _07961_ _01301_ VDD VSS MUX2_X1
X_14717_ _07831_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[45\]
+ _07961_ _01302_ VDD VSS MUX2_X1
X_14718_ _07957_ _07962_ VDD VSS BUF_X4
X_14719_ _07833_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[46\]
+ _07962_ _01303_ VDD VSS MUX2_X1
X_14720_ _07836_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[47\]
+ _07962_ _01304_ VDD VSS MUX2_X1
X_14721_ _07838_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[48\]
+ _07962_ _01305_ VDD VSS MUX2_X1
X_14722_ _07840_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[49\]
+ _07962_ _01306_ VDD VSS MUX2_X1
X_14723_ _07842_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[4\]
+ _07962_ _01307_ VDD VSS MUX2_X1
X_14724_ _07844_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[50\]
+ _07962_ _01308_ VDD VSS MUX2_X1
X_14725_ _07846_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[51\]
+ _07962_ _01309_ VDD VSS MUX2_X1
X_14726_ _07848_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[52\]
+ _07962_ _01310_ VDD VSS MUX2_X1
X_14727_ _07850_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[53\]
+ _07962_ _01311_ VDD VSS MUX2_X1
X_14728_ _07852_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[54\]
+ _07962_ _01312_ VDD VSS MUX2_X1
X_14729_ _07957_ _07963_ VDD VSS BUF_X4
X_14730_ _07854_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[55\]
+ _07963_ _01313_ VDD VSS MUX2_X1
X_14731_ _07857_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[56\]
+ _07963_ _01314_ VDD VSS MUX2_X1
X_14732_ _07859_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[57\]
+ _07963_ _01315_ VDD VSS MUX2_X1
X_14733_ _07861_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[58\]
+ _07963_ _01316_ VDD VSS MUX2_X1
X_14734_ _07863_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[59\]
+ _07963_ _01317_ VDD VSS MUX2_X1
X_14735_ _07865_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[5\]
+ _07963_ _01318_ VDD VSS MUX2_X1
X_14736_ _07867_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[60\]
+ _07963_ _01319_ VDD VSS MUX2_X1
X_14737_ _07869_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[61\]
+ _07963_ _01320_ VDD VSS MUX2_X1
X_14738_ _07871_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[62\]
+ _07963_ _01321_ VDD VSS MUX2_X1
X_14739_ _07873_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[63\]
+ _07963_ _01322_ VDD VSS MUX2_X1
X_14740_ _07875_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[6\]
+ _07957_ _01323_ VDD VSS MUX2_X1
X_14741_ _07877_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[7\]
+ _07957_ _01324_ VDD VSS MUX2_X1
X_14742_ _07879_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[8\]
+ _07957_ _01325_ VDD VSS MUX2_X1
X_14743_ _07881_ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[9\]
+ _07957_ _01326_ VDD VSS MUX2_X1
X_14744_ _06540_ _07746_ _07904_ _07964_ VDD VSS NOR3_X1
X_14745_ _07964_ _07965_ VDD VSS BUF_X4
X_14746_ _07965_ _07966_ VDD VSS CLKBUF_X3
X_14747_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[0\]
+ _07745_ _07966_ _01327_ VDD VSS MUX2_X1
X_14748_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[10\]
+ _07753_ _07966_ _01328_ VDD VSS MUX2_X1
X_14749_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[11\]
+ _07755_ _07966_ _01329_ VDD VSS MUX2_X1
X_14750_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[12\]
+ _07757_ _07966_ _01330_ VDD VSS MUX2_X1
X_14751_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[13\]
+ _07759_ _07966_ _01331_ VDD VSS MUX2_X1
X_14752_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[14\]
+ _07761_ _07966_ _01332_ VDD VSS MUX2_X1
X_14753_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[15\]
+ _07763_ _07966_ _01333_ VDD VSS MUX2_X1
X_14754_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[16\]
+ _07765_ _07966_ _01334_ VDD VSS MUX2_X1
X_14755_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[17\]
+ _07767_ _07966_ _01335_ VDD VSS MUX2_X1
X_14756_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[18\]
+ _07769_ _07966_ _01336_ VDD VSS MUX2_X1
X_14757_ _07965_ _07967_ VDD VSS BUF_X4
X_14758_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[19\]
+ _07771_ _07967_ _01337_ VDD VSS MUX2_X1
X_14759_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[1\]
+ _07774_ _07967_ _01338_ VDD VSS MUX2_X1
X_14760_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[20\]
+ _07776_ _07967_ _01339_ VDD VSS MUX2_X1
X_14761_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[21\]
+ _07778_ _07967_ _01340_ VDD VSS MUX2_X1
X_14762_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[22\]
+ _07780_ _07967_ _01341_ VDD VSS MUX2_X1
X_14763_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[23\]
+ _07782_ _07967_ _01342_ VDD VSS MUX2_X1
X_14764_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[24\]
+ _07784_ _07967_ _01343_ VDD VSS MUX2_X1
X_14765_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[25\]
+ _07786_ _07967_ _01344_ VDD VSS MUX2_X1
X_14766_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[26\]
+ _07788_ _07967_ _01345_ VDD VSS MUX2_X1
X_14767_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[27\]
+ _07790_ _07967_ _01346_ VDD VSS MUX2_X1
X_14768_ _07965_ _07968_ VDD VSS BUF_X4
X_14769_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[28\]
+ _07792_ _07968_ _01347_ VDD VSS MUX2_X1
X_14770_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[29\]
+ _07795_ _07968_ _01348_ VDD VSS MUX2_X1
X_14771_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[2\]
+ _07797_ _07968_ _01349_ VDD VSS MUX2_X1
X_14772_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[30\]
+ _07799_ _07968_ _01350_ VDD VSS MUX2_X1
X_14773_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[31\]
+ _07801_ _07968_ _01351_ VDD VSS MUX2_X1
X_14774_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[32\]
+ _07803_ _07968_ _01352_ VDD VSS MUX2_X1
X_14775_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[33\]
+ _07805_ _07968_ _01353_ VDD VSS MUX2_X1
X_14776_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[34\]
+ _07807_ _07968_ _01354_ VDD VSS MUX2_X1
X_14777_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[35\]
+ _07809_ _07968_ _01355_ VDD VSS MUX2_X1
X_14778_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[36\]
+ _07811_ _07968_ _01356_ VDD VSS MUX2_X1
X_14779_ _07965_ _07969_ VDD VSS BUF_X4
X_14780_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[37\]
+ _07813_ _07969_ _01357_ VDD VSS MUX2_X1
X_14781_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[38\]
+ _07816_ _07969_ _01358_ VDD VSS MUX2_X1
X_14782_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[39\]
+ _07818_ _07969_ _01359_ VDD VSS MUX2_X1
X_14783_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[3\]
+ _07820_ _07969_ _01360_ VDD VSS MUX2_X1
X_14784_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[40\]
+ _07822_ _07969_ _01361_ VDD VSS MUX2_X1
X_14785_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[41\]
+ _07824_ _07969_ _01362_ VDD VSS MUX2_X1
X_14786_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[42\]
+ _07826_ _07969_ _01363_ VDD VSS MUX2_X1
X_14787_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[43\]
+ _07828_ _07969_ _01364_ VDD VSS MUX2_X1
X_14788_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[44\]
+ _07830_ _07969_ _01365_ VDD VSS MUX2_X1
X_14789_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[45\]
+ _07832_ _07969_ _01366_ VDD VSS MUX2_X1
X_14790_ _07965_ _07970_ VDD VSS BUF_X4
X_14791_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[46\]
+ _07834_ _07970_ _01367_ VDD VSS MUX2_X1
X_14792_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[47\]
+ _07837_ _07970_ _01368_ VDD VSS MUX2_X1
X_14793_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[48\]
+ _07839_ _07970_ _01369_ VDD VSS MUX2_X1
X_14794_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[49\]
+ _07841_ _07970_ _01370_ VDD VSS MUX2_X1
X_14795_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[4\]
+ _07843_ _07970_ _01371_ VDD VSS MUX2_X1
X_14796_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[50\]
+ _07845_ _07970_ _01372_ VDD VSS MUX2_X1
X_14797_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[51\]
+ _07847_ _07970_ _01373_ VDD VSS MUX2_X1
X_14798_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[52\]
+ _07849_ _07970_ _01374_ VDD VSS MUX2_X1
X_14799_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[53\]
+ _07851_ _07970_ _01375_ VDD VSS MUX2_X1
X_14800_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[54\]
+ _07853_ _07970_ _01376_ VDD VSS MUX2_X1
X_14801_ _07965_ _07971_ VDD VSS BUF_X4
X_14802_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[55\]
+ _07855_ _07971_ _01377_ VDD VSS MUX2_X1
X_14803_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[56\]
+ _07858_ _07971_ _01378_ VDD VSS MUX2_X1
X_14804_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[57\]
+ _07860_ _07971_ _01379_ VDD VSS MUX2_X1
X_14805_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[58\]
+ _07862_ _07971_ _01380_ VDD VSS MUX2_X1
X_14806_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[59\]
+ _07864_ _07971_ _01381_ VDD VSS MUX2_X1
X_14807_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[5\]
+ _07866_ _07971_ _01382_ VDD VSS MUX2_X1
X_14808_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[60\]
+ _07868_ _07971_ _01383_ VDD VSS MUX2_X1
X_14809_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[61\]
+ _07870_ _07971_ _01384_ VDD VSS MUX2_X1
X_14810_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[62\]
+ _07872_ _07971_ _01385_ VDD VSS MUX2_X1
X_14811_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[63\]
+ _07874_ _07971_ _01386_ VDD VSS MUX2_X1
X_14812_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[6\]
+ _07876_ _07965_ _01387_ VDD VSS MUX2_X1
X_14813_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[7\]
+ _07878_ _07965_ _01388_ VDD VSS MUX2_X1
X_14814_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[8\]
+ _07880_ _07965_ _01389_ VDD VSS MUX2_X1
X_14815_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[9\]
+ _07882_ _07965_ _01390_ VDD VSS MUX2_X1
X_14816_ _06539_ _07746_ _07913_ _07972_ VDD VSS NOR3_X2
X_14817_ _10597_ _07972_ _07973_ VDD VSS NAND2_X1
X_14818_ _07973_ _07974_ VDD VSS BUF_X4
X_14819_ _07974_ _07975_ VDD VSS CLKBUF_X3
X_14820_ _07744_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[0\]
+ _07975_ _01391_ VDD VSS MUX2_X1
X_14821_ _07752_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[10\]
+ _07975_ _01392_ VDD VSS MUX2_X1
X_14822_ _07754_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[11\]
+ _07975_ _01393_ VDD VSS MUX2_X1
X_14823_ _07756_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[12\]
+ _07975_ _01394_ VDD VSS MUX2_X1
X_14824_ _07758_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[13\]
+ _07975_ _01395_ VDD VSS MUX2_X1
X_14825_ _07760_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[14\]
+ _07975_ _01396_ VDD VSS MUX2_X1
X_14826_ _07762_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[15\]
+ _07975_ _01397_ VDD VSS MUX2_X1
X_14827_ _07764_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[16\]
+ _07975_ _01398_ VDD VSS MUX2_X1
X_14828_ _07766_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[17\]
+ _07975_ _01399_ VDD VSS MUX2_X1
X_14829_ _07768_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[18\]
+ _07975_ _01400_ VDD VSS MUX2_X1
X_14830_ _07974_ _07976_ VDD VSS BUF_X4
X_14831_ _07770_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[19\]
+ _07976_ _01401_ VDD VSS MUX2_X1
X_14832_ _07773_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[1\]
+ _07976_ _01402_ VDD VSS MUX2_X1
X_14833_ _07775_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[20\]
+ _07976_ _01403_ VDD VSS MUX2_X1
X_14834_ _07777_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[21\]
+ _07976_ _01404_ VDD VSS MUX2_X1
X_14835_ _07779_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[22\]
+ _07976_ _01405_ VDD VSS MUX2_X1
X_14836_ _07781_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[23\]
+ _07976_ _01406_ VDD VSS MUX2_X1
X_14837_ _07783_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[24\]
+ _07976_ _01407_ VDD VSS MUX2_X1
X_14838_ _07785_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[25\]
+ _07976_ _01408_ VDD VSS MUX2_X1
X_14839_ _07787_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[26\]
+ _07976_ _01409_ VDD VSS MUX2_X1
X_14840_ _07789_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[27\]
+ _07976_ _01410_ VDD VSS MUX2_X1
X_14841_ _07974_ _07977_ VDD VSS BUF_X4
X_14842_ _07791_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[28\]
+ _07977_ _01411_ VDD VSS MUX2_X1
X_14843_ _07794_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[29\]
+ _07977_ _01412_ VDD VSS MUX2_X1
X_14844_ _07796_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[2\]
+ _07977_ _01413_ VDD VSS MUX2_X1
X_14845_ _07798_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[30\]
+ _07977_ _01414_ VDD VSS MUX2_X1
X_14846_ _07800_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[31\]
+ _07977_ _01415_ VDD VSS MUX2_X1
X_14847_ _07802_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[32\]
+ _07977_ _01416_ VDD VSS MUX2_X1
X_14848_ _07804_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[33\]
+ _07977_ _01417_ VDD VSS MUX2_X1
X_14849_ _07806_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[34\]
+ _07977_ _01418_ VDD VSS MUX2_X1
X_14850_ _07808_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[35\]
+ _07977_ _01419_ VDD VSS MUX2_X1
X_14851_ _07810_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[36\]
+ _07977_ _01420_ VDD VSS MUX2_X1
X_14852_ _07974_ _07978_ VDD VSS BUF_X4
X_14853_ _07812_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[37\]
+ _07978_ _01421_ VDD VSS MUX2_X1
X_14854_ _07815_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[38\]
+ _07978_ _01422_ VDD VSS MUX2_X1
X_14855_ _07817_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[39\]
+ _07978_ _01423_ VDD VSS MUX2_X1
X_14856_ _07819_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[3\]
+ _07978_ _01424_ VDD VSS MUX2_X1
X_14857_ _07821_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[40\]
+ _07978_ _01425_ VDD VSS MUX2_X1
X_14858_ _07823_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[41\]
+ _07978_ _01426_ VDD VSS MUX2_X1
X_14859_ _07825_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[42\]
+ _07978_ _01427_ VDD VSS MUX2_X1
X_14860_ _07827_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[43\]
+ _07978_ _01428_ VDD VSS MUX2_X1
X_14861_ _07829_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[44\]
+ _07978_ _01429_ VDD VSS MUX2_X1
X_14862_ _07831_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[45\]
+ _07978_ _01430_ VDD VSS MUX2_X1
X_14863_ _07974_ _07979_ VDD VSS BUF_X4
X_14864_ _07833_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[46\]
+ _07979_ _01431_ VDD VSS MUX2_X1
X_14865_ _07836_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[47\]
+ _07979_ _01432_ VDD VSS MUX2_X1
X_14866_ _07838_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[48\]
+ _07979_ _01433_ VDD VSS MUX2_X1
X_14867_ _07840_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[49\]
+ _07979_ _01434_ VDD VSS MUX2_X1
X_14868_ _07842_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[4\]
+ _07979_ _01435_ VDD VSS MUX2_X1
X_14869_ _07844_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[50\]
+ _07979_ _01436_ VDD VSS MUX2_X1
X_14870_ _07846_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[51\]
+ _07979_ _01437_ VDD VSS MUX2_X1
X_14871_ _07848_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[52\]
+ _07979_ _01438_ VDD VSS MUX2_X1
X_14872_ _07850_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[53\]
+ _07979_ _01439_ VDD VSS MUX2_X1
X_14873_ _07852_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[54\]
+ _07979_ _01440_ VDD VSS MUX2_X1
X_14874_ _07974_ _07980_ VDD VSS BUF_X4
X_14875_ _07854_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[55\]
+ _07980_ _01441_ VDD VSS MUX2_X1
X_14876_ _07857_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[56\]
+ _07980_ _01442_ VDD VSS MUX2_X1
X_14877_ _07859_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[57\]
+ _07980_ _01443_ VDD VSS MUX2_X1
X_14878_ _07861_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[58\]
+ _07980_ _01444_ VDD VSS MUX2_X1
X_14879_ _07863_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[59\]
+ _07980_ _01445_ VDD VSS MUX2_X1
X_14880_ _07865_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[5\]
+ _07980_ _01446_ VDD VSS MUX2_X1
X_14881_ _07867_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[60\]
+ _07980_ _01447_ VDD VSS MUX2_X1
X_14882_ _07869_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[61\]
+ _07980_ _01448_ VDD VSS MUX2_X1
X_14883_ _07871_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[62\]
+ _07980_ _01449_ VDD VSS MUX2_X1
X_14884_ _07873_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[63\]
+ _07980_ _01450_ VDD VSS MUX2_X1
X_14885_ _07875_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[6\]
+ _07974_ _01451_ VDD VSS MUX2_X1
X_14886_ _07877_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[7\]
+ _07974_ _01452_ VDD VSS MUX2_X1
X_14887_ _07879_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[8\]
+ _07974_ _01453_ VDD VSS MUX2_X1
X_14888_ _07881_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[9\]
+ _07974_ _01454_ VDD VSS MUX2_X1
X_14889_ _10595_ _07972_ _07981_ VDD VSS NAND2_X1
X_14890_ _07981_ _07982_ VDD VSS BUF_X4
X_14891_ _07982_ _07983_ VDD VSS CLKBUF_X3
X_14892_ _07744_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[0\]
+ _07983_ _01455_ VDD VSS MUX2_X1
X_14893_ _07752_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[10\]
+ _07983_ _01456_ VDD VSS MUX2_X1
X_14894_ _07754_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[11\]
+ _07983_ _01457_ VDD VSS MUX2_X1
X_14895_ _07756_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[12\]
+ _07983_ _01458_ VDD VSS MUX2_X1
X_14896_ _07758_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[13\]
+ _07983_ _01459_ VDD VSS MUX2_X1
X_14897_ _07760_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[14\]
+ _07983_ _01460_ VDD VSS MUX2_X1
X_14898_ _07762_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[15\]
+ _07983_ _01461_ VDD VSS MUX2_X1
X_14899_ _07764_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[16\]
+ _07983_ _01462_ VDD VSS MUX2_X1
X_14900_ _07766_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[17\]
+ _07983_ _01463_ VDD VSS MUX2_X1
X_14901_ _07768_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[18\]
+ _07983_ _01464_ VDD VSS MUX2_X1
X_14902_ _07982_ _07984_ VDD VSS BUF_X4
X_14903_ _07770_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[19\]
+ _07984_ _01465_ VDD VSS MUX2_X1
X_14904_ _07773_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[1\]
+ _07984_ _01466_ VDD VSS MUX2_X1
X_14905_ _07775_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[20\]
+ _07984_ _01467_ VDD VSS MUX2_X1
X_14906_ _07777_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[21\]
+ _07984_ _01468_ VDD VSS MUX2_X1
X_14907_ _07779_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[22\]
+ _07984_ _01469_ VDD VSS MUX2_X1
X_14908_ _07781_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[23\]
+ _07984_ _01470_ VDD VSS MUX2_X1
X_14909_ _07783_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[24\]
+ _07984_ _01471_ VDD VSS MUX2_X1
X_14910_ _07785_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[25\]
+ _07984_ _01472_ VDD VSS MUX2_X1
X_14911_ _07787_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[26\]
+ _07984_ _01473_ VDD VSS MUX2_X1
X_14912_ _07789_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[27\]
+ _07984_ _01474_ VDD VSS MUX2_X1
X_14913_ _07982_ _07985_ VDD VSS BUF_X4
X_14914_ _07791_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[28\]
+ _07985_ _01475_ VDD VSS MUX2_X1
X_14915_ _07794_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[29\]
+ _07985_ _01476_ VDD VSS MUX2_X1
X_14916_ _07796_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[2\]
+ _07985_ _01477_ VDD VSS MUX2_X1
X_14917_ _07798_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[30\]
+ _07985_ _01478_ VDD VSS MUX2_X1
X_14918_ _07800_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[31\]
+ _07985_ _01479_ VDD VSS MUX2_X1
X_14919_ _07802_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[32\]
+ _07985_ _01480_ VDD VSS MUX2_X1
X_14920_ _07804_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[33\]
+ _07985_ _01481_ VDD VSS MUX2_X1
X_14921_ _07806_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[34\]
+ _07985_ _01482_ VDD VSS MUX2_X1
X_14922_ _07808_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[35\]
+ _07985_ _01483_ VDD VSS MUX2_X1
X_14923_ _07810_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[36\]
+ _07985_ _01484_ VDD VSS MUX2_X1
X_14924_ _07982_ _07986_ VDD VSS BUF_X4
X_14925_ _07812_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[37\]
+ _07986_ _01485_ VDD VSS MUX2_X1
X_14926_ _07815_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[38\]
+ _07986_ _01486_ VDD VSS MUX2_X1
X_14927_ _07817_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[39\]
+ _07986_ _01487_ VDD VSS MUX2_X1
X_14928_ _07819_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[3\]
+ _07986_ _01488_ VDD VSS MUX2_X1
X_14929_ _07821_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[40\]
+ _07986_ _01489_ VDD VSS MUX2_X1
X_14930_ _07823_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[41\]
+ _07986_ _01490_ VDD VSS MUX2_X1
X_14931_ _07825_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[42\]
+ _07986_ _01491_ VDD VSS MUX2_X1
X_14932_ _07827_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[43\]
+ _07986_ _01492_ VDD VSS MUX2_X1
X_14933_ _07829_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[44\]
+ _07986_ _01493_ VDD VSS MUX2_X1
X_14934_ _07831_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[45\]
+ _07986_ _01494_ VDD VSS MUX2_X1
X_14935_ _07982_ _07987_ VDD VSS BUF_X4
X_14936_ _07833_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[46\]
+ _07987_ _01495_ VDD VSS MUX2_X1
X_14937_ _07836_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[47\]
+ _07987_ _01496_ VDD VSS MUX2_X1
X_14938_ _07838_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[48\]
+ _07987_ _01497_ VDD VSS MUX2_X1
X_14939_ _07840_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[49\]
+ _07987_ _01498_ VDD VSS MUX2_X1
X_14940_ _07842_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[4\]
+ _07987_ _01499_ VDD VSS MUX2_X1
X_14941_ _07844_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[50\]
+ _07987_ _01500_ VDD VSS MUX2_X1
X_14942_ _07846_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[51\]
+ _07987_ _01501_ VDD VSS MUX2_X1
X_14943_ _07848_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[52\]
+ _07987_ _01502_ VDD VSS MUX2_X1
X_14944_ _07850_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[53\]
+ _07987_ _01503_ VDD VSS MUX2_X1
X_14945_ _07852_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[54\]
+ _07987_ _01504_ VDD VSS MUX2_X1
X_14946_ _07982_ _07988_ VDD VSS BUF_X4
X_14947_ _07854_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[55\]
+ _07988_ _01505_ VDD VSS MUX2_X1
X_14948_ _07857_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[56\]
+ _07988_ _01506_ VDD VSS MUX2_X1
X_14949_ _07859_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[57\]
+ _07988_ _01507_ VDD VSS MUX2_X1
X_14950_ _07861_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[58\]
+ _07988_ _01508_ VDD VSS MUX2_X1
X_14951_ _07863_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[59\]
+ _07988_ _01509_ VDD VSS MUX2_X1
X_14952_ _07865_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[5\]
+ _07988_ _01510_ VDD VSS MUX2_X1
X_14953_ _07867_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[60\]
+ _07988_ _01511_ VDD VSS MUX2_X1
X_14954_ _07869_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[61\]
+ _07988_ _01512_ VDD VSS MUX2_X1
X_14955_ _07871_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[62\]
+ _07988_ _01513_ VDD VSS MUX2_X1
X_14956_ _07873_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[63\]
+ _07988_ _01514_ VDD VSS MUX2_X1
X_14957_ _07875_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[6\]
+ _07982_ _01515_ VDD VSS MUX2_X1
X_14958_ _07877_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[7\]
+ _07982_ _01516_ VDD VSS MUX2_X1
X_14959_ _07879_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[8\]
+ _07982_ _01517_ VDD VSS MUX2_X1
X_14960_ _07881_ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[9\]
+ _07982_ _01518_ VDD VSS MUX2_X1
X_14961_ _07895_ _07972_ _07989_ VDD VSS NAND2_X1
X_14962_ _07989_ _07990_ VDD VSS BUF_X4
X_14963_ _07990_ _07991_ VDD VSS CLKBUF_X3
X_14964_ _07744_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[0\]
+ _07991_ _01519_ VDD VSS MUX2_X1
X_14965_ _07752_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[10\]
+ _07991_ _01520_ VDD VSS MUX2_X1
X_14966_ _07754_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[11\]
+ _07991_ _01521_ VDD VSS MUX2_X1
X_14967_ _07756_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[12\]
+ _07991_ _01522_ VDD VSS MUX2_X1
X_14968_ _07758_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[13\]
+ _07991_ _01523_ VDD VSS MUX2_X1
X_14969_ _07760_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[14\]
+ _07991_ _01524_ VDD VSS MUX2_X1
X_14970_ _07762_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[15\]
+ _07991_ _01525_ VDD VSS MUX2_X1
X_14971_ _07764_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[16\]
+ _07991_ _01526_ VDD VSS MUX2_X1
X_14972_ _07766_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[17\]
+ _07991_ _01527_ VDD VSS MUX2_X1
X_14973_ _07768_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[18\]
+ _07991_ _01528_ VDD VSS MUX2_X1
X_14974_ _07990_ _07992_ VDD VSS BUF_X4
X_14975_ _07770_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[19\]
+ _07992_ _01529_ VDD VSS MUX2_X1
X_14976_ _07773_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[1\]
+ _07992_ _01530_ VDD VSS MUX2_X1
X_14977_ _07775_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[20\]
+ _07992_ _01531_ VDD VSS MUX2_X1
X_14978_ _07777_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[21\]
+ _07992_ _01532_ VDD VSS MUX2_X1
X_14979_ _07779_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[22\]
+ _07992_ _01533_ VDD VSS MUX2_X1
X_14980_ _07781_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[23\]
+ _07992_ _01534_ VDD VSS MUX2_X1
X_14981_ _07783_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[24\]
+ _07992_ _01535_ VDD VSS MUX2_X1
X_14982_ _07785_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[25\]
+ _07992_ _01536_ VDD VSS MUX2_X1
X_14983_ _07787_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[26\]
+ _07992_ _01537_ VDD VSS MUX2_X1
X_14984_ _07789_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[27\]
+ _07992_ _01538_ VDD VSS MUX2_X1
X_14985_ _07990_ _02296_ VDD VSS BUF_X4
X_14986_ _07791_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[28\]
+ _02296_ _01539_ VDD VSS MUX2_X1
X_14987_ _07794_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[29\]
+ _02296_ _01540_ VDD VSS MUX2_X1
X_14988_ _07796_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[2\]
+ _02296_ _01541_ VDD VSS MUX2_X1
X_14989_ _07798_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[30\]
+ _02296_ _01542_ VDD VSS MUX2_X1
X_14990_ _07800_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[31\]
+ _02296_ _01543_ VDD VSS MUX2_X1
X_14991_ _07802_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[32\]
+ _02296_ _01544_ VDD VSS MUX2_X1
X_14992_ _07804_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[33\]
+ _02296_ _01545_ VDD VSS MUX2_X1
X_14993_ _07806_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[34\]
+ _02296_ _01546_ VDD VSS MUX2_X1
X_14994_ _07808_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[35\]
+ _02296_ _01547_ VDD VSS MUX2_X1
X_14995_ _07810_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[36\]
+ _02296_ _01548_ VDD VSS MUX2_X1
X_14996_ _07990_ _02297_ VDD VSS BUF_X4
X_14997_ _07812_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[37\]
+ _02297_ _01549_ VDD VSS MUX2_X1
X_14998_ _07815_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[38\]
+ _02297_ _01550_ VDD VSS MUX2_X1
X_14999_ _07817_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[39\]
+ _02297_ _01551_ VDD VSS MUX2_X1
X_15000_ _07819_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[3\]
+ _02297_ _01552_ VDD VSS MUX2_X1
X_15001_ _07821_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[40\]
+ _02297_ _01553_ VDD VSS MUX2_X1
X_15002_ _07823_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[41\]
+ _02297_ _01554_ VDD VSS MUX2_X1
X_15003_ _07825_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[42\]
+ _02297_ _01555_ VDD VSS MUX2_X1
X_15004_ _07827_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[43\]
+ _02297_ _01556_ VDD VSS MUX2_X1
X_15005_ _07829_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[44\]
+ _02297_ _01557_ VDD VSS MUX2_X1
X_15006_ _07831_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[45\]
+ _02297_ _01558_ VDD VSS MUX2_X1
X_15007_ _07990_ _02298_ VDD VSS BUF_X4
X_15008_ _07833_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[46\]
+ _02298_ _01559_ VDD VSS MUX2_X1
X_15009_ _07836_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[47\]
+ _02298_ _01560_ VDD VSS MUX2_X1
X_15010_ _07838_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[48\]
+ _02298_ _01561_ VDD VSS MUX2_X1
X_15011_ _07840_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[49\]
+ _02298_ _01562_ VDD VSS MUX2_X1
X_15012_ _07842_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[4\]
+ _02298_ _01563_ VDD VSS MUX2_X1
X_15013_ _07844_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[50\]
+ _02298_ _01564_ VDD VSS MUX2_X1
X_15014_ _07846_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[51\]
+ _02298_ _01565_ VDD VSS MUX2_X1
X_15015_ _07848_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[52\]
+ _02298_ _01566_ VDD VSS MUX2_X1
X_15016_ _07850_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[53\]
+ _02298_ _01567_ VDD VSS MUX2_X1
X_15017_ _07852_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[54\]
+ _02298_ _01568_ VDD VSS MUX2_X1
X_15018_ _07990_ _02299_ VDD VSS BUF_X4
X_15019_ _07854_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[55\]
+ _02299_ _01569_ VDD VSS MUX2_X1
X_15020_ _07857_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[56\]
+ _02299_ _01570_ VDD VSS MUX2_X1
X_15021_ _07859_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[57\]
+ _02299_ _01571_ VDD VSS MUX2_X1
X_15022_ _07861_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[58\]
+ _02299_ _01572_ VDD VSS MUX2_X1
X_15023_ _07863_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[59\]
+ _02299_ _01573_ VDD VSS MUX2_X1
X_15024_ _07865_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[5\]
+ _02299_ _01574_ VDD VSS MUX2_X1
X_15025_ _07867_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[60\]
+ _02299_ _01575_ VDD VSS MUX2_X1
X_15026_ _07869_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[61\]
+ _02299_ _01576_ VDD VSS MUX2_X1
X_15027_ _07871_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[62\]
+ _02299_ _01577_ VDD VSS MUX2_X1
X_15028_ _07873_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[63\]
+ _02299_ _01578_ VDD VSS MUX2_X1
X_15029_ _07875_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[6\]
+ _07990_ _01579_ VDD VSS MUX2_X1
X_15030_ _07877_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[7\]
+ _07990_ _01580_ VDD VSS MUX2_X1
X_15031_ _07879_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[8\]
+ _07990_ _01581_ VDD VSS MUX2_X1
X_15032_ _07881_ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[9\]
+ _07990_ _01582_ VDD VSS MUX2_X1
X_15033_ _07747_ _07748_ _07885_ _02300_ VDD VSS NOR3_X1
X_15034_ _02300_ _02301_ VDD VSS BUF_X4
X_15035_ _02301_ _02302_ VDD VSS CLKBUF_X3
X_15036_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[0\]
+ _07745_ _02302_ _01583_ VDD VSS MUX2_X1
X_15037_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[10\]
+ _07753_ _02302_ _01584_ VDD VSS MUX2_X1
X_15038_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[11\]
+ _07755_ _02302_ _01585_ VDD VSS MUX2_X1
X_15039_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[12\]
+ _07757_ _02302_ _01586_ VDD VSS MUX2_X1
X_15040_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[13\]
+ _07759_ _02302_ _01587_ VDD VSS MUX2_X1
X_15041_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[14\]
+ _07761_ _02302_ _01588_ VDD VSS MUX2_X1
X_15042_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[15\]
+ _07763_ _02302_ _01589_ VDD VSS MUX2_X1
X_15043_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[16\]
+ _07765_ _02302_ _01590_ VDD VSS MUX2_X1
X_15044_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[17\]
+ _07767_ _02302_ _01591_ VDD VSS MUX2_X1
X_15045_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[18\]
+ _07769_ _02302_ _01592_ VDD VSS MUX2_X1
X_15046_ _02301_ _02303_ VDD VSS BUF_X4
X_15047_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[19\]
+ _07771_ _02303_ _01593_ VDD VSS MUX2_X1
X_15048_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[1\]
+ _07774_ _02303_ _01594_ VDD VSS MUX2_X1
X_15049_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[20\]
+ _07776_ _02303_ _01595_ VDD VSS MUX2_X1
X_15050_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[21\]
+ _07778_ _02303_ _01596_ VDD VSS MUX2_X1
X_15051_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[22\]
+ _07780_ _02303_ _01597_ VDD VSS MUX2_X1
X_15052_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[23\]
+ _07782_ _02303_ _01598_ VDD VSS MUX2_X1
X_15053_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[24\]
+ _07784_ _02303_ _01599_ VDD VSS MUX2_X1
X_15054_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[25\]
+ _07786_ _02303_ _01600_ VDD VSS MUX2_X1
X_15055_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[26\]
+ _07788_ _02303_ _01601_ VDD VSS MUX2_X1
X_15056_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[27\]
+ _07790_ _02303_ _01602_ VDD VSS MUX2_X1
X_15057_ _02301_ _02304_ VDD VSS BUF_X4
X_15058_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[28\]
+ _07792_ _02304_ _01603_ VDD VSS MUX2_X1
X_15059_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[29\]
+ _07795_ _02304_ _01604_ VDD VSS MUX2_X1
X_15060_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[2\]
+ _07797_ _02304_ _01605_ VDD VSS MUX2_X1
X_15061_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[30\]
+ _07799_ _02304_ _01606_ VDD VSS MUX2_X1
X_15062_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[31\]
+ _07801_ _02304_ _01607_ VDD VSS MUX2_X1
X_15063_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[32\]
+ _07803_ _02304_ _01608_ VDD VSS MUX2_X1
X_15064_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[33\]
+ _07805_ _02304_ _01609_ VDD VSS MUX2_X1
X_15065_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[34\]
+ _07807_ _02304_ _01610_ VDD VSS MUX2_X1
X_15066_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[35\]
+ _07809_ _02304_ _01611_ VDD VSS MUX2_X1
X_15067_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[36\]
+ _07811_ _02304_ _01612_ VDD VSS MUX2_X1
X_15068_ _02301_ _02305_ VDD VSS BUF_X4
X_15069_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[37\]
+ _07813_ _02305_ _01613_ VDD VSS MUX2_X1
X_15070_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[38\]
+ _07816_ _02305_ _01614_ VDD VSS MUX2_X1
X_15071_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[39\]
+ _07818_ _02305_ _01615_ VDD VSS MUX2_X1
X_15072_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[3\]
+ _07820_ _02305_ _01616_ VDD VSS MUX2_X1
X_15073_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[40\]
+ _07822_ _02305_ _01617_ VDD VSS MUX2_X1
X_15074_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[41\]
+ _07824_ _02305_ _01618_ VDD VSS MUX2_X1
X_15075_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[42\]
+ _07826_ _02305_ _01619_ VDD VSS MUX2_X1
X_15076_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[43\]
+ _07828_ _02305_ _01620_ VDD VSS MUX2_X1
X_15077_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[44\]
+ _07830_ _02305_ _01621_ VDD VSS MUX2_X1
X_15078_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[45\]
+ _07832_ _02305_ _01622_ VDD VSS MUX2_X1
X_15079_ _02301_ _02306_ VDD VSS BUF_X4
X_15080_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[46\]
+ _07834_ _02306_ _01623_ VDD VSS MUX2_X1
X_15081_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[47\]
+ _07837_ _02306_ _01624_ VDD VSS MUX2_X1
X_15082_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[48\]
+ _07839_ _02306_ _01625_ VDD VSS MUX2_X1
X_15083_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[49\]
+ _07841_ _02306_ _01626_ VDD VSS MUX2_X1
X_15084_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[4\]
+ _07843_ _02306_ _01627_ VDD VSS MUX2_X1
X_15085_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[50\]
+ _07845_ _02306_ _01628_ VDD VSS MUX2_X1
X_15086_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[51\]
+ _07847_ _02306_ _01629_ VDD VSS MUX2_X1
X_15087_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[52\]
+ _07849_ _02306_ _01630_ VDD VSS MUX2_X1
X_15088_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[53\]
+ _07851_ _02306_ _01631_ VDD VSS MUX2_X1
X_15089_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[54\]
+ _07853_ _02306_ _01632_ VDD VSS MUX2_X1
X_15090_ _02301_ _02307_ VDD VSS BUF_X4
X_15091_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[55\]
+ _07855_ _02307_ _01633_ VDD VSS MUX2_X1
X_15092_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[56\]
+ _07858_ _02307_ _01634_ VDD VSS MUX2_X1
X_15093_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[57\]
+ _07860_ _02307_ _01635_ VDD VSS MUX2_X1
X_15094_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[58\]
+ _07862_ _02307_ _01636_ VDD VSS MUX2_X1
X_15095_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[59\]
+ _07864_ _02307_ _01637_ VDD VSS MUX2_X1
X_15096_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[5\]
+ _07866_ _02307_ _01638_ VDD VSS MUX2_X1
X_15097_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[60\]
+ _07868_ _02307_ _01639_ VDD VSS MUX2_X1
X_15098_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[61\]
+ _07870_ _02307_ _01640_ VDD VSS MUX2_X1
X_15099_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[62\]
+ _07872_ _02307_ _01641_ VDD VSS MUX2_X1
X_15100_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[63\]
+ _07874_ _02307_ _01642_ VDD VSS MUX2_X1
X_15101_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[6\]
+ _07876_ _02301_ _01643_ VDD VSS MUX2_X1
X_15102_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[7\]
+ _07878_ _02301_ _01644_ VDD VSS MUX2_X1
X_15103_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[8\]
+ _07880_ _02301_ _01645_ VDD VSS MUX2_X1
X_15104_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[9\]
+ _07882_ _02301_ _01646_ VDD VSS MUX2_X1
X_15105_ _10597_ _07886_ _02308_ VDD VSS NAND2_X1
X_15106_ _02308_ _02309_ VDD VSS BUF_X4
X_15107_ _02309_ _02310_ VDD VSS CLKBUF_X3
X_15108_ _07744_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[0\]
+ _02310_ _01647_ VDD VSS MUX2_X1
X_15109_ _07752_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[10\]
+ _02310_ _01648_ VDD VSS MUX2_X1
X_15110_ _07754_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[11\]
+ _02310_ _01649_ VDD VSS MUX2_X1
X_15111_ _07756_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[12\]
+ _02310_ _01650_ VDD VSS MUX2_X1
X_15112_ _07758_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[13\]
+ _02310_ _01651_ VDD VSS MUX2_X1
X_15113_ _07760_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[14\]
+ _02310_ _01652_ VDD VSS MUX2_X1
X_15114_ _07762_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[15\]
+ _02310_ _01653_ VDD VSS MUX2_X1
X_15115_ _07764_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[16\]
+ _02310_ _01654_ VDD VSS MUX2_X1
X_15116_ _07766_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[17\]
+ _02310_ _01655_ VDD VSS MUX2_X1
X_15117_ _07768_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[18\]
+ _02310_ _01656_ VDD VSS MUX2_X1
X_15118_ _02309_ _02311_ VDD VSS BUF_X4
X_15119_ _07770_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[19\]
+ _02311_ _01657_ VDD VSS MUX2_X1
X_15120_ _07773_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[1\]
+ _02311_ _01658_ VDD VSS MUX2_X1
X_15121_ _07775_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[20\]
+ _02311_ _01659_ VDD VSS MUX2_X1
X_15122_ _07777_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[21\]
+ _02311_ _01660_ VDD VSS MUX2_X1
X_15123_ _07779_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[22\]
+ _02311_ _01661_ VDD VSS MUX2_X1
X_15124_ _07781_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[23\]
+ _02311_ _01662_ VDD VSS MUX2_X1
X_15125_ _07783_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[24\]
+ _02311_ _01663_ VDD VSS MUX2_X1
X_15126_ _07785_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[25\]
+ _02311_ _01664_ VDD VSS MUX2_X1
X_15127_ _07787_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[26\]
+ _02311_ _01665_ VDD VSS MUX2_X1
X_15128_ _07789_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[27\]
+ _02311_ _01666_ VDD VSS MUX2_X1
X_15129_ _02309_ _02312_ VDD VSS BUF_X4
X_15130_ _07791_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[28\]
+ _02312_ _01667_ VDD VSS MUX2_X1
X_15131_ _07794_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[29\]
+ _02312_ _01668_ VDD VSS MUX2_X1
X_15132_ _07796_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[2\]
+ _02312_ _01669_ VDD VSS MUX2_X1
X_15133_ _07798_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[30\]
+ _02312_ _01670_ VDD VSS MUX2_X1
X_15134_ _07800_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[31\]
+ _02312_ _01671_ VDD VSS MUX2_X1
X_15135_ _07802_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[32\]
+ _02312_ _01672_ VDD VSS MUX2_X1
X_15136_ _07804_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[33\]
+ _02312_ _01673_ VDD VSS MUX2_X1
X_15137_ _07806_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[34\]
+ _02312_ _01674_ VDD VSS MUX2_X1
X_15138_ _07808_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[35\]
+ _02312_ _01675_ VDD VSS MUX2_X1
X_15139_ _07810_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[36\]
+ _02312_ _01676_ VDD VSS MUX2_X1
X_15140_ _02309_ _02313_ VDD VSS BUF_X4
X_15141_ _07812_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[37\]
+ _02313_ _01677_ VDD VSS MUX2_X1
X_15142_ _07815_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[38\]
+ _02313_ _01678_ VDD VSS MUX2_X1
X_15143_ _07817_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[39\]
+ _02313_ _01679_ VDD VSS MUX2_X1
X_15144_ _07819_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[3\]
+ _02313_ _01680_ VDD VSS MUX2_X1
X_15145_ _07821_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[40\]
+ _02313_ _01681_ VDD VSS MUX2_X1
X_15146_ _07823_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[41\]
+ _02313_ _01682_ VDD VSS MUX2_X1
X_15147_ _07825_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[42\]
+ _02313_ _01683_ VDD VSS MUX2_X1
X_15148_ _07827_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[43\]
+ _02313_ _01684_ VDD VSS MUX2_X1
X_15149_ _07829_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[44\]
+ _02313_ _01685_ VDD VSS MUX2_X1
X_15150_ _07831_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[45\]
+ _02313_ _01686_ VDD VSS MUX2_X1
X_15151_ _02309_ _02314_ VDD VSS BUF_X4
X_15152_ _07833_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[46\]
+ _02314_ _01687_ VDD VSS MUX2_X1
X_15153_ _07836_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[47\]
+ _02314_ _01688_ VDD VSS MUX2_X1
X_15154_ _07838_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[48\]
+ _02314_ _01689_ VDD VSS MUX2_X1
X_15155_ _07840_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[49\]
+ _02314_ _01690_ VDD VSS MUX2_X1
X_15156_ _07842_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[4\]
+ _02314_ _01691_ VDD VSS MUX2_X1
X_15157_ _07844_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[50\]
+ _02314_ _01692_ VDD VSS MUX2_X1
X_15158_ _07846_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[51\]
+ _02314_ _01693_ VDD VSS MUX2_X1
X_15159_ _07848_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[52\]
+ _02314_ _01694_ VDD VSS MUX2_X1
X_15160_ _07850_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[53\]
+ _02314_ _01695_ VDD VSS MUX2_X1
X_15161_ _07852_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[54\]
+ _02314_ _01696_ VDD VSS MUX2_X1
X_15162_ _02309_ _02315_ VDD VSS BUF_X4
X_15163_ _07854_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[55\]
+ _02315_ _01697_ VDD VSS MUX2_X1
X_15164_ _07857_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[56\]
+ _02315_ _01698_ VDD VSS MUX2_X1
X_15165_ _07859_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[57\]
+ _02315_ _01699_ VDD VSS MUX2_X1
X_15166_ _07861_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[58\]
+ _02315_ _01700_ VDD VSS MUX2_X1
X_15167_ _07863_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[59\]
+ _02315_ _01701_ VDD VSS MUX2_X1
X_15168_ _07865_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[5\]
+ _02315_ _01702_ VDD VSS MUX2_X1
X_15169_ _07867_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[60\]
+ _02315_ _01703_ VDD VSS MUX2_X1
X_15170_ _07869_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[61\]
+ _02315_ _01704_ VDD VSS MUX2_X1
X_15171_ _07871_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[62\]
+ _02315_ _01705_ VDD VSS MUX2_X1
X_15172_ _07873_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[63\]
+ _02315_ _01706_ VDD VSS MUX2_X1
X_15173_ _07875_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[6\]
+ _02309_ _01707_ VDD VSS MUX2_X1
X_15174_ _07877_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[7\]
+ _02309_ _01708_ VDD VSS MUX2_X1
X_15175_ _07879_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[8\]
+ _02309_ _01709_ VDD VSS MUX2_X1
X_15176_ _07881_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[9\]
+ _02309_ _01710_ VDD VSS MUX2_X1
X_15177_ _06540_ _10463_ _02316_ VDD VSS NOR2_X4
X_15178_ _10602_ _02316_ _02317_ VDD VSS NAND2_X1
X_15179_ _02317_ _02318_ VDD VSS BUF_X4
X_15180_ _02318_ _02319_ VDD VSS CLKBUF_X3
X_15181_ net131 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[0\]
+ _02319_ _01738_ VDD VSS MUX2_X1
X_15182_ net132 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[10\]
+ _02319_ _01739_ VDD VSS MUX2_X1
X_15183_ net133 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[11\]
+ _02319_ _01740_ VDD VSS MUX2_X1
X_15184_ net134 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[12\]
+ _02319_ _01741_ VDD VSS MUX2_X1
X_15185_ net135 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[13\]
+ _02319_ _01742_ VDD VSS MUX2_X1
X_15186_ net136 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[14\]
+ _02319_ _01743_ VDD VSS MUX2_X1
X_15187_ net137 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[15\]
+ _02319_ _01744_ VDD VSS MUX2_X1
X_15188_ net138 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[16\]
+ _02319_ _01745_ VDD VSS MUX2_X1
X_15189_ net139 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[17\]
+ _02319_ _01746_ VDD VSS MUX2_X1
X_15190_ net140 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[18\]
+ _02319_ _01747_ VDD VSS MUX2_X1
X_15191_ _02318_ _02320_ VDD VSS BUF_X4
X_15192_ net141 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[19\]
+ _02320_ _01748_ VDD VSS MUX2_X1
X_15193_ net142 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[1\]
+ _02320_ _01749_ VDD VSS MUX2_X1
X_15194_ net143 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[20\]
+ _02320_ _01750_ VDD VSS MUX2_X1
X_15195_ net144 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[21\]
+ _02320_ _01751_ VDD VSS MUX2_X1
X_15196_ net145 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[22\]
+ _02320_ _01752_ VDD VSS MUX2_X1
X_15197_ net146 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[23\]
+ _02320_ _01753_ VDD VSS MUX2_X1
X_15198_ net147 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[24\]
+ _02320_ _01754_ VDD VSS MUX2_X1
X_15199_ net148 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[25\]
+ _02320_ _01755_ VDD VSS MUX2_X1
X_15200_ net149 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[26\]
+ _02320_ _01756_ VDD VSS MUX2_X1
X_15201_ net150 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[27\]
+ _02320_ _01757_ VDD VSS MUX2_X1
X_15202_ _02318_ _02321_ VDD VSS BUF_X4
X_15203_ net151 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[28\]
+ _02321_ _01758_ VDD VSS MUX2_X1
X_15204_ net152 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[29\]
+ _02321_ _01759_ VDD VSS MUX2_X1
X_15205_ net153 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[2\]
+ _02321_ _01760_ VDD VSS MUX2_X1
X_15206_ net154 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[30\]
+ _02321_ _01761_ VDD VSS MUX2_X1
X_15207_ net155 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[31\]
+ _02321_ _01762_ VDD VSS MUX2_X1
X_15208_ net156 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[32\]
+ _02321_ _01763_ VDD VSS MUX2_X1
X_15209_ net157 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[33\]
+ _02321_ _01764_ VDD VSS MUX2_X1
X_15210_ net158 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[34\]
+ _02321_ _01765_ VDD VSS MUX2_X1
X_15211_ net159 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[35\]
+ _02321_ _01766_ VDD VSS MUX2_X1
X_15212_ net160 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[36\]
+ _02321_ _01767_ VDD VSS MUX2_X1
X_15213_ _02318_ _02322_ VDD VSS BUF_X4
X_15214_ net161 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[37\]
+ _02322_ _01768_ VDD VSS MUX2_X1
X_15215_ net162 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[38\]
+ _02322_ _01769_ VDD VSS MUX2_X1
X_15216_ net163 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[39\]
+ _02322_ _01770_ VDD VSS MUX2_X1
X_15217_ net164 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[3\]
+ _02322_ _01771_ VDD VSS MUX2_X1
X_15218_ net165 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[40\]
+ _02322_ _01772_ VDD VSS MUX2_X1
X_15219_ net166 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[41\]
+ _02322_ _01773_ VDD VSS MUX2_X1
X_15220_ net167 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[42\]
+ _02322_ _01774_ VDD VSS MUX2_X1
X_15221_ net168 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[43\]
+ _02322_ _01775_ VDD VSS MUX2_X1
X_15222_ net169 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[44\]
+ _02322_ _01776_ VDD VSS MUX2_X1
X_15223_ net170 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[45\]
+ _02322_ _01777_ VDD VSS MUX2_X1
X_15224_ _02318_ _02323_ VDD VSS BUF_X4
X_15225_ net171 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[46\]
+ _02323_ _01778_ VDD VSS MUX2_X1
X_15226_ net172 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[47\]
+ _02323_ _01779_ VDD VSS MUX2_X1
X_15227_ net173 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[48\]
+ _02323_ _01780_ VDD VSS MUX2_X1
X_15228_ net174 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[49\]
+ _02323_ _01781_ VDD VSS MUX2_X1
X_15229_ net175 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[4\]
+ _02323_ _01782_ VDD VSS MUX2_X1
X_15230_ net176 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[50\]
+ _02323_ _01783_ VDD VSS MUX2_X1
X_15231_ net177 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[51\]
+ _02323_ _01784_ VDD VSS MUX2_X1
X_15232_ net178 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[52\]
+ _02323_ _01785_ VDD VSS MUX2_X1
X_15233_ net179 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[53\]
+ _02323_ _01786_ VDD VSS MUX2_X1
X_15234_ net180 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[54\]
+ _02323_ _01787_ VDD VSS MUX2_X1
X_15235_ _02318_ _02324_ VDD VSS BUF_X4
X_15236_ net181 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[55\]
+ _02324_ _01788_ VDD VSS MUX2_X1
X_15237_ net182 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[56\]
+ _02324_ _01789_ VDD VSS MUX2_X1
X_15238_ net183 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[57\]
+ _02324_ _01790_ VDD VSS MUX2_X1
X_15239_ net184 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[58\]
+ _02324_ _01791_ VDD VSS MUX2_X1
X_15240_ net185 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[59\]
+ _02324_ _01792_ VDD VSS MUX2_X1
X_15241_ net186 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[5\]
+ _02324_ _01793_ VDD VSS MUX2_X1
X_15242_ net187 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[60\]
+ _02324_ _01794_ VDD VSS MUX2_X1
X_15243_ net188 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[61\]
+ _02324_ _01795_ VDD VSS MUX2_X1
X_15244_ net189 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[62\]
+ _02324_ _01796_ VDD VSS MUX2_X1
X_15245_ net190 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[63\]
+ _02324_ _01797_ VDD VSS MUX2_X1
X_15246_ net191 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[6\]
+ _02318_ _01798_ VDD VSS MUX2_X1
X_15247_ net192 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[7\]
+ _02318_ _01799_ VDD VSS MUX2_X1
X_15248_ net193 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[8\]
+ _02318_ _01800_ VDD VSS MUX2_X1
X_15249_ net194 dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[9\]
+ _02318_ _01801_ VDD VSS MUX2_X1
X_15250_ _10605_ _02316_ _02325_ VDD VSS NAND2_X1
X_15251_ _02325_ _02326_ VDD VSS BUF_X4
X_15252_ _02326_ _02327_ VDD VSS CLKBUF_X3
X_15253_ net131 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[0\]
+ _02327_ _01802_ VDD VSS MUX2_X1
X_15254_ net132 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[10\]
+ _02327_ _01803_ VDD VSS MUX2_X1
X_15255_ net133 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[11\]
+ _02327_ _01804_ VDD VSS MUX2_X1
X_15256_ net134 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[12\]
+ _02327_ _01805_ VDD VSS MUX2_X1
X_15257_ net135 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[13\]
+ _02327_ _01806_ VDD VSS MUX2_X1
X_15258_ net136 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[14\]
+ _02327_ _01807_ VDD VSS MUX2_X1
X_15259_ net137 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[15\]
+ _02327_ _01808_ VDD VSS MUX2_X1
X_15260_ net138 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[16\]
+ _02327_ _01809_ VDD VSS MUX2_X1
X_15261_ net139 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[17\]
+ _02327_ _01810_ VDD VSS MUX2_X1
X_15262_ net140 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[18\]
+ _02327_ _01811_ VDD VSS MUX2_X1
X_15263_ _02326_ _02328_ VDD VSS CLKBUF_X3
X_15264_ net141 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[19\]
+ _02328_ _01812_ VDD VSS MUX2_X1
X_15265_ net142 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[1\]
+ _02328_ _01813_ VDD VSS MUX2_X1
X_15266_ net143 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[20\]
+ _02328_ _01814_ VDD VSS MUX2_X1
X_15267_ net144 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[21\]
+ _02328_ _01815_ VDD VSS MUX2_X1
X_15268_ net145 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[22\]
+ _02328_ _01816_ VDD VSS MUX2_X1
X_15269_ net146 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[23\]
+ _02328_ _01817_ VDD VSS MUX2_X1
X_15270_ net147 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[24\]
+ _02328_ _01818_ VDD VSS MUX2_X1
X_15271_ net148 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[25\]
+ _02328_ _01819_ VDD VSS MUX2_X1
X_15272_ net149 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[26\]
+ _02328_ _01820_ VDD VSS MUX2_X1
X_15273_ net150 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[27\]
+ _02328_ _01821_ VDD VSS MUX2_X1
X_15274_ _02326_ _02329_ VDD VSS BUF_X4
X_15275_ net151 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[28\]
+ _02329_ _01822_ VDD VSS MUX2_X1
X_15276_ net152 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[29\]
+ _02329_ _01823_ VDD VSS MUX2_X1
X_15277_ net153 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[2\]
+ _02329_ _01824_ VDD VSS MUX2_X1
X_15278_ net154 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[30\]
+ _02329_ _01825_ VDD VSS MUX2_X1
X_15279_ net155 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[31\]
+ _02329_ _01826_ VDD VSS MUX2_X1
X_15280_ net156 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[32\]
+ _02329_ _01827_ VDD VSS MUX2_X1
X_15281_ net157 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[33\]
+ _02329_ _01828_ VDD VSS MUX2_X1
X_15282_ net158 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[34\]
+ _02329_ _01829_ VDD VSS MUX2_X1
X_15283_ net159 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[35\]
+ _02329_ _01830_ VDD VSS MUX2_X1
X_15284_ net160 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[36\]
+ _02329_ _01831_ VDD VSS MUX2_X1
X_15285_ _02326_ _02330_ VDD VSS BUF_X4
X_15286_ net161 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[37\]
+ _02330_ _01832_ VDD VSS MUX2_X1
X_15287_ net162 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[38\]
+ _02330_ _01833_ VDD VSS MUX2_X1
X_15288_ net163 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[39\]
+ _02330_ _01834_ VDD VSS MUX2_X1
X_15289_ net164 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[3\]
+ _02330_ _01835_ VDD VSS MUX2_X1
X_15290_ net165 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[40\]
+ _02330_ _01836_ VDD VSS MUX2_X1
X_15291_ net166 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[41\]
+ _02330_ _01837_ VDD VSS MUX2_X1
X_15292_ net167 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[42\]
+ _02330_ _01838_ VDD VSS MUX2_X1
X_15293_ net168 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[43\]
+ _02330_ _01839_ VDD VSS MUX2_X1
X_15294_ net169 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[44\]
+ _02330_ _01840_ VDD VSS MUX2_X1
X_15295_ net170 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[45\]
+ _02330_ _01841_ VDD VSS MUX2_X1
X_15296_ _02326_ _02331_ VDD VSS BUF_X4
X_15297_ net171 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[46\]
+ _02331_ _01842_ VDD VSS MUX2_X1
X_15298_ net172 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[47\]
+ _02331_ _01843_ VDD VSS MUX2_X1
X_15299_ net173 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[48\]
+ _02331_ _01844_ VDD VSS MUX2_X1
X_15300_ net174 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[49\]
+ _02331_ _01845_ VDD VSS MUX2_X1
X_15301_ net175 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[4\]
+ _02331_ _01846_ VDD VSS MUX2_X1
X_15302_ net176 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[50\]
+ _02331_ _01847_ VDD VSS MUX2_X1
X_15303_ net177 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[51\]
+ _02331_ _01848_ VDD VSS MUX2_X1
X_15304_ net178 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[52\]
+ _02331_ _01849_ VDD VSS MUX2_X1
X_15305_ net179 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[53\]
+ _02331_ _01850_ VDD VSS MUX2_X1
X_15306_ net180 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[54\]
+ _02331_ _01851_ VDD VSS MUX2_X1
X_15307_ _02326_ _02332_ VDD VSS BUF_X4
X_15308_ net181 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[55\]
+ _02332_ _01852_ VDD VSS MUX2_X1
X_15309_ net182 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[56\]
+ _02332_ _01853_ VDD VSS MUX2_X1
X_15310_ net183 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[57\]
+ _02332_ _01854_ VDD VSS MUX2_X1
X_15311_ net184 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[58\]
+ _02332_ _01855_ VDD VSS MUX2_X1
X_15312_ net185 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[59\]
+ _02332_ _01856_ VDD VSS MUX2_X1
X_15313_ net186 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[5\]
+ _02332_ _01857_ VDD VSS MUX2_X1
X_15314_ net187 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[60\]
+ _02332_ _01858_ VDD VSS MUX2_X1
X_15315_ net188 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[61\]
+ _02332_ _01859_ VDD VSS MUX2_X1
X_15316_ net189 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[62\]
+ _02332_ _01860_ VDD VSS MUX2_X1
X_15317_ net190 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[63\]
+ _02332_ _01861_ VDD VSS MUX2_X1
X_15318_ net191 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[6\]
+ _02326_ _01862_ VDD VSS MUX2_X1
X_15319_ net192 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[7\]
+ _02326_ _01863_ VDD VSS MUX2_X1
X_15320_ net193 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[8\]
+ _02326_ _01864_ VDD VSS MUX2_X1
X_15321_ net194 dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[9\]
+ _02326_ _01865_ VDD VSS MUX2_X1
X_15322_ _10603_ _02316_ _02333_ VDD VSS NAND2_X1
X_15323_ _02333_ _02334_ VDD VSS BUF_X4
X_15324_ _02334_ _02335_ VDD VSS CLKBUF_X3
X_15325_ net131 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[0\]
+ _02335_ _01866_ VDD VSS MUX2_X1
X_15326_ net132 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[10\]
+ _02335_ _01867_ VDD VSS MUX2_X1
X_15327_ net133 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[11\]
+ _02335_ _01868_ VDD VSS MUX2_X1
X_15328_ net134 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[12\]
+ _02335_ _01869_ VDD VSS MUX2_X1
X_15329_ net135 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[13\]
+ _02335_ _01870_ VDD VSS MUX2_X1
X_15330_ net136 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[14\]
+ _02335_ _01871_ VDD VSS MUX2_X1
X_15331_ net137 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[15\]
+ _02335_ _01872_ VDD VSS MUX2_X1
X_15332_ net138 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[16\]
+ _02335_ _01873_ VDD VSS MUX2_X1
X_15333_ net139 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[17\]
+ _02335_ _01874_ VDD VSS MUX2_X1
X_15334_ net140 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[18\]
+ _02335_ _01875_ VDD VSS MUX2_X1
X_15335_ _02334_ _02336_ VDD VSS BUF_X4
X_15336_ net141 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[19\]
+ _02336_ _01876_ VDD VSS MUX2_X1
X_15337_ net142 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[1\]
+ _02336_ _01877_ VDD VSS MUX2_X1
X_15338_ net143 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[20\]
+ _02336_ _01878_ VDD VSS MUX2_X1
X_15339_ net144 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[21\]
+ _02336_ _01879_ VDD VSS MUX2_X1
X_15340_ net145 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[22\]
+ _02336_ _01880_ VDD VSS MUX2_X1
X_15341_ net146 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[23\]
+ _02336_ _01881_ VDD VSS MUX2_X1
X_15342_ net147 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[24\]
+ _02336_ _01882_ VDD VSS MUX2_X1
X_15343_ net148 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[25\]
+ _02336_ _01883_ VDD VSS MUX2_X1
X_15344_ net149 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[26\]
+ _02336_ _01884_ VDD VSS MUX2_X1
X_15345_ net150 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[27\]
+ _02336_ _01885_ VDD VSS MUX2_X1
X_15346_ _02334_ _02337_ VDD VSS BUF_X4
X_15347_ net151 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[28\]
+ _02337_ _01886_ VDD VSS MUX2_X1
X_15348_ net152 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[29\]
+ _02337_ _01887_ VDD VSS MUX2_X1
X_15349_ net153 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[2\]
+ _02337_ _01888_ VDD VSS MUX2_X1
X_15350_ net154 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[30\]
+ _02337_ _01889_ VDD VSS MUX2_X1
X_15351_ net155 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[31\]
+ _02337_ _01890_ VDD VSS MUX2_X1
X_15352_ net156 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[32\]
+ _02337_ _01891_ VDD VSS MUX2_X1
X_15353_ net157 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[33\]
+ _02337_ _01892_ VDD VSS MUX2_X1
X_15354_ net158 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[34\]
+ _02337_ _01893_ VDD VSS MUX2_X1
X_15355_ net159 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[35\]
+ _02337_ _01894_ VDD VSS MUX2_X1
X_15356_ net160 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[36\]
+ _02337_ _01895_ VDD VSS MUX2_X1
X_15357_ _02334_ _02338_ VDD VSS BUF_X4
X_15358_ net161 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[37\]
+ _02338_ _01896_ VDD VSS MUX2_X1
X_15359_ net162 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[38\]
+ _02338_ _01897_ VDD VSS MUX2_X1
X_15360_ net163 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[39\]
+ _02338_ _01898_ VDD VSS MUX2_X1
X_15361_ net164 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[3\]
+ _02338_ _01899_ VDD VSS MUX2_X1
X_15362_ net165 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[40\]
+ _02338_ _01900_ VDD VSS MUX2_X1
X_15363_ net166 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[41\]
+ _02338_ _01901_ VDD VSS MUX2_X1
X_15364_ net167 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[42\]
+ _02338_ _01902_ VDD VSS MUX2_X1
X_15365_ net168 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[43\]
+ _02338_ _01903_ VDD VSS MUX2_X1
X_15366_ net169 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[44\]
+ _02338_ _01904_ VDD VSS MUX2_X1
X_15367_ net170 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[45\]
+ _02338_ _01905_ VDD VSS MUX2_X1
X_15368_ _02334_ _02339_ VDD VSS BUF_X4
X_15369_ net171 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[46\]
+ _02339_ _01906_ VDD VSS MUX2_X1
X_15370_ net172 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[47\]
+ _02339_ _01907_ VDD VSS MUX2_X1
X_15371_ net173 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[48\]
+ _02339_ _01908_ VDD VSS MUX2_X1
X_15372_ net174 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[49\]
+ _02339_ _01909_ VDD VSS MUX2_X1
X_15373_ net175 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[4\]
+ _02339_ _01910_ VDD VSS MUX2_X1
X_15374_ net176 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[50\]
+ _02339_ _01911_ VDD VSS MUX2_X1
X_15375_ net177 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[51\]
+ _02339_ _01912_ VDD VSS MUX2_X1
X_15376_ net178 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[52\]
+ _02339_ _01913_ VDD VSS MUX2_X1
X_15377_ net179 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[53\]
+ _02339_ _01914_ VDD VSS MUX2_X1
X_15378_ net180 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[54\]
+ _02339_ _01915_ VDD VSS MUX2_X1
X_15379_ _02334_ _02340_ VDD VSS BUF_X4
X_15380_ net181 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[55\]
+ _02340_ _01916_ VDD VSS MUX2_X1
X_15381_ net182 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[56\]
+ _02340_ _01917_ VDD VSS MUX2_X1
X_15382_ net183 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[57\]
+ _02340_ _01918_ VDD VSS MUX2_X1
X_15383_ net184 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[58\]
+ _02340_ _01919_ VDD VSS MUX2_X1
X_15384_ net185 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[59\]
+ _02340_ _01920_ VDD VSS MUX2_X1
X_15385_ net186 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[5\]
+ _02340_ _01921_ VDD VSS MUX2_X1
X_15386_ net187 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[60\]
+ _02340_ _01922_ VDD VSS MUX2_X1
X_15387_ net188 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[61\]
+ _02340_ _01923_ VDD VSS MUX2_X1
X_15388_ net189 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[62\]
+ _02340_ _01924_ VDD VSS MUX2_X1
X_15389_ net190 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[63\]
+ _02340_ _01925_ VDD VSS MUX2_X1
X_15390_ net191 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[6\]
+ _02334_ _01926_ VDD VSS MUX2_X1
X_15391_ net192 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[7\]
+ _02334_ _01927_ VDD VSS MUX2_X1
X_15392_ net193 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[8\]
+ _02334_ _01928_ VDD VSS MUX2_X1
X_15393_ net194 dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[9\]
+ _02334_ _01929_ VDD VSS MUX2_X1
X_15394_ _10607_ _02316_ _02341_ VDD VSS NAND2_X1
X_15395_ _02341_ _02342_ VDD VSS BUF_X4
X_15396_ _02342_ _02343_ VDD VSS CLKBUF_X3
X_15397_ net131 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[0\]
+ _02343_ _01930_ VDD VSS MUX2_X1
X_15398_ net132 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[10\]
+ _02343_ _01931_ VDD VSS MUX2_X1
X_15399_ net133 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[11\]
+ _02343_ _01932_ VDD VSS MUX2_X1
X_15400_ net134 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[12\]
+ _02343_ _01933_ VDD VSS MUX2_X1
X_15401_ net135 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[13\]
+ _02343_ _01934_ VDD VSS MUX2_X1
X_15402_ net136 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[14\]
+ _02343_ _01935_ VDD VSS MUX2_X1
X_15403_ net137 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[15\]
+ _02343_ _01936_ VDD VSS MUX2_X1
X_15404_ net138 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[16\]
+ _02343_ _01937_ VDD VSS MUX2_X1
X_15405_ net139 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[17\]
+ _02343_ _01938_ VDD VSS MUX2_X1
X_15406_ net140 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[18\]
+ _02343_ _01939_ VDD VSS MUX2_X1
X_15407_ _02342_ _02344_ VDD VSS CLKBUF_X3
X_15408_ net141 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[19\]
+ _02344_ _01940_ VDD VSS MUX2_X1
X_15409_ net142 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[1\]
+ _02344_ _01941_ VDD VSS MUX2_X1
X_15410_ net143 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[20\]
+ _02344_ _01942_ VDD VSS MUX2_X1
X_15411_ net144 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[21\]
+ _02344_ _01943_ VDD VSS MUX2_X1
X_15412_ net145 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[22\]
+ _02344_ _01944_ VDD VSS MUX2_X1
X_15413_ net146 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[23\]
+ _02344_ _01945_ VDD VSS MUX2_X1
X_15414_ net147 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[24\]
+ _02344_ _01946_ VDD VSS MUX2_X1
X_15415_ net148 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[25\]
+ _02344_ _01947_ VDD VSS MUX2_X1
X_15416_ net149 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[26\]
+ _02344_ _01948_ VDD VSS MUX2_X1
X_15417_ net150 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[27\]
+ _02344_ _01949_ VDD VSS MUX2_X1
X_15418_ _02342_ _02345_ VDD VSS BUF_X4
X_15419_ net151 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[28\]
+ _02345_ _01950_ VDD VSS MUX2_X1
X_15420_ net152 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[29\]
+ _02345_ _01951_ VDD VSS MUX2_X1
X_15421_ net153 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[2\]
+ _02345_ _01952_ VDD VSS MUX2_X1
X_15422_ net154 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[30\]
+ _02345_ _01953_ VDD VSS MUX2_X1
X_15423_ net155 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[31\]
+ _02345_ _01954_ VDD VSS MUX2_X1
X_15424_ net156 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[32\]
+ _02345_ _01955_ VDD VSS MUX2_X1
X_15425_ net157 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[33\]
+ _02345_ _01956_ VDD VSS MUX2_X1
X_15426_ net158 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[34\]
+ _02345_ _01957_ VDD VSS MUX2_X1
X_15427_ net159 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[35\]
+ _02345_ _01958_ VDD VSS MUX2_X1
X_15428_ net160 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[36\]
+ _02345_ _01959_ VDD VSS MUX2_X1
X_15429_ _02342_ _02346_ VDD VSS BUF_X4
X_15430_ net161 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[37\]
+ _02346_ _01960_ VDD VSS MUX2_X1
X_15431_ net162 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[38\]
+ _02346_ _01961_ VDD VSS MUX2_X1
X_15432_ net163 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[39\]
+ _02346_ _01962_ VDD VSS MUX2_X1
X_15433_ net164 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[3\]
+ _02346_ _01963_ VDD VSS MUX2_X1
X_15434_ net165 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[40\]
+ _02346_ _01964_ VDD VSS MUX2_X1
X_15435_ net166 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[41\]
+ _02346_ _01965_ VDD VSS MUX2_X1
X_15436_ net167 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[42\]
+ _02346_ _01966_ VDD VSS MUX2_X1
X_15437_ net168 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[43\]
+ _02346_ _01967_ VDD VSS MUX2_X1
X_15438_ net169 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[44\]
+ _02346_ _01968_ VDD VSS MUX2_X1
X_15439_ net170 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[45\]
+ _02346_ _01969_ VDD VSS MUX2_X1
X_15440_ _02342_ _02347_ VDD VSS BUF_X4
X_15441_ net171 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[46\]
+ _02347_ _01970_ VDD VSS MUX2_X1
X_15442_ net172 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[47\]
+ _02347_ _01971_ VDD VSS MUX2_X1
X_15443_ net173 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[48\]
+ _02347_ _01972_ VDD VSS MUX2_X1
X_15444_ net174 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[49\]
+ _02347_ _01973_ VDD VSS MUX2_X1
X_15445_ net175 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[4\]
+ _02347_ _01974_ VDD VSS MUX2_X1
X_15446_ net176 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[50\]
+ _02347_ _01975_ VDD VSS MUX2_X1
X_15447_ net177 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[51\]
+ _02347_ _01976_ VDD VSS MUX2_X1
X_15448_ net178 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[52\]
+ _02347_ _01977_ VDD VSS MUX2_X1
X_15449_ net179 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[53\]
+ _02347_ _01978_ VDD VSS MUX2_X1
X_15450_ net180 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[54\]
+ _02347_ _01979_ VDD VSS MUX2_X1
X_15451_ _02342_ _02348_ VDD VSS BUF_X4
X_15452_ net181 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[55\]
+ _02348_ _01980_ VDD VSS MUX2_X1
X_15453_ net182 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[56\]
+ _02348_ _01981_ VDD VSS MUX2_X1
X_15454_ net183 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[57\]
+ _02348_ _01982_ VDD VSS MUX2_X1
X_15455_ net184 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[58\]
+ _02348_ _01983_ VDD VSS MUX2_X1
X_15456_ net185 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[59\]
+ _02348_ _01984_ VDD VSS MUX2_X1
X_15457_ net186 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[5\]
+ _02348_ _01985_ VDD VSS MUX2_X1
X_15458_ net187 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[60\]
+ _02348_ _01986_ VDD VSS MUX2_X1
X_15459_ net188 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[61\]
+ _02348_ _01987_ VDD VSS MUX2_X1
X_15460_ net189 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[62\]
+ _02348_ _01988_ VDD VSS MUX2_X1
X_15461_ net190 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[63\]
+ _02348_ _01989_ VDD VSS MUX2_X1
X_15462_ net191 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[6\]
+ _02342_ _01990_ VDD VSS MUX2_X1
X_15463_ net192 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[7\]
+ _02342_ _01991_ VDD VSS MUX2_X1
X_15464_ net193 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[8\]
+ _02342_ _01992_ VDD VSS MUX2_X1
X_15465_ net194 dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[9\]
+ _02342_ _01993_ VDD VSS MUX2_X1
X_15466_ _06540_ _10497_ _02349_ VDD VSS NOR2_X2
X_15467_ _10610_ _02349_ _02350_ VDD VSS NAND2_X1
X_15468_ _02350_ _02351_ VDD VSS BUF_X4
X_15469_ _02351_ _02352_ VDD VSS BUF_X4
X_15470_ net195 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[0\]
+ _02352_ _02019_ VDD VSS MUX2_X1
X_15471_ net196 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[10\]
+ _02352_ _02020_ VDD VSS MUX2_X1
X_15472_ net197 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[11\]
+ _02352_ _02021_ VDD VSS MUX2_X1
X_15473_ net198 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[12\]
+ _02352_ _02022_ VDD VSS MUX2_X1
X_15474_ net199 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[13\]
+ _02352_ _02023_ VDD VSS MUX2_X1
X_15475_ net200 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[14\]
+ _02352_ _02024_ VDD VSS MUX2_X1
X_15476_ net201 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[15\]
+ _02352_ _02025_ VDD VSS MUX2_X1
X_15477_ net202 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[16\]
+ _02352_ _02026_ VDD VSS MUX2_X1
X_15478_ net203 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[17\]
+ _02352_ _02027_ VDD VSS MUX2_X1
X_15479_ net204 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[18\]
+ _02352_ _02028_ VDD VSS MUX2_X1
X_15480_ _02351_ _02353_ VDD VSS BUF_X4
X_15481_ net205 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[19\]
+ _02353_ _02029_ VDD VSS MUX2_X1
X_15482_ net206 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[1\]
+ _02353_ _02030_ VDD VSS MUX2_X1
X_15483_ net207 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[20\]
+ _02353_ _02031_ VDD VSS MUX2_X1
X_15484_ net208 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[21\]
+ _02353_ _02032_ VDD VSS MUX2_X1
X_15485_ net209 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[22\]
+ _02353_ _02033_ VDD VSS MUX2_X1
X_15486_ net210 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[23\]
+ _02353_ _02034_ VDD VSS MUX2_X1
X_15487_ net211 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[24\]
+ _02353_ _02035_ VDD VSS MUX2_X1
X_15488_ net212 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[25\]
+ _02353_ _02036_ VDD VSS MUX2_X1
X_15489_ net213 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[26\]
+ _02353_ _02037_ VDD VSS MUX2_X1
X_15490_ net214 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[27\]
+ _02353_ _02038_ VDD VSS MUX2_X1
X_15491_ _02351_ _02354_ VDD VSS BUF_X4
X_15492_ net215 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[28\]
+ _02354_ _02039_ VDD VSS MUX2_X1
X_15493_ net216 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[29\]
+ _02354_ _02040_ VDD VSS MUX2_X1
X_15494_ net217 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[2\]
+ _02354_ _02041_ VDD VSS MUX2_X1
X_15495_ net218 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[30\]
+ _02354_ _02042_ VDD VSS MUX2_X1
X_15496_ net219 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[31\]
+ _02354_ _02043_ VDD VSS MUX2_X1
X_15497_ net220 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[32\]
+ _02354_ _02044_ VDD VSS MUX2_X1
X_15498_ net221 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[33\]
+ _02354_ _02045_ VDD VSS MUX2_X1
X_15499_ net222 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[34\]
+ _02354_ _02046_ VDD VSS MUX2_X1
X_15500_ net223 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[35\]
+ _02354_ _02047_ VDD VSS MUX2_X1
X_15501_ net224 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[36\]
+ _02354_ _02048_ VDD VSS MUX2_X1
X_15502_ _02351_ _02355_ VDD VSS BUF_X4
X_15503_ net225 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[37\]
+ _02355_ _02049_ VDD VSS MUX2_X1
X_15504_ net226 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[38\]
+ _02355_ _02050_ VDD VSS MUX2_X1
X_15505_ net227 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[39\]
+ _02355_ _02051_ VDD VSS MUX2_X1
X_15506_ net228 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[3\]
+ _02355_ _02052_ VDD VSS MUX2_X1
X_15507_ net229 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[40\]
+ _02355_ _02053_ VDD VSS MUX2_X1
X_15508_ net230 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[41\]
+ _02355_ _02054_ VDD VSS MUX2_X1
X_15509_ net231 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[42\]
+ _02355_ _02055_ VDD VSS MUX2_X1
X_15510_ net232 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[43\]
+ _02355_ _02056_ VDD VSS MUX2_X1
X_15511_ net233 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[44\]
+ _02355_ _02057_ VDD VSS MUX2_X1
X_15512_ net234 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[45\]
+ _02355_ _02058_ VDD VSS MUX2_X1
X_15513_ _02351_ _02356_ VDD VSS BUF_X4
X_15514_ net235 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[46\]
+ _02356_ _02059_ VDD VSS MUX2_X1
X_15515_ net236 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[47\]
+ _02356_ _02060_ VDD VSS MUX2_X1
X_15516_ net237 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[48\]
+ _02356_ _02061_ VDD VSS MUX2_X1
X_15517_ net238 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[49\]
+ _02356_ _02062_ VDD VSS MUX2_X1
X_15518_ net239 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[4\]
+ _02356_ _02063_ VDD VSS MUX2_X1
X_15519_ net240 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[50\]
+ _02356_ _02064_ VDD VSS MUX2_X1
X_15520_ net241 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[51\]
+ _02356_ _02065_ VDD VSS MUX2_X1
X_15521_ net242 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[52\]
+ _02356_ _02066_ VDD VSS MUX2_X1
X_15522_ net243 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[53\]
+ _02356_ _02067_ VDD VSS MUX2_X1
X_15523_ net244 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[54\]
+ _02356_ _02068_ VDD VSS MUX2_X1
X_15524_ _02351_ _02357_ VDD VSS BUF_X4
X_15525_ net245 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[55\]
+ _02357_ _02069_ VDD VSS MUX2_X1
X_15526_ net246 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[56\]
+ _02357_ _02070_ VDD VSS MUX2_X1
X_15527_ net247 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[57\]
+ _02357_ _02071_ VDD VSS MUX2_X1
X_15528_ net248 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[58\]
+ _02357_ _02072_ VDD VSS MUX2_X1
X_15529_ net249 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[59\]
+ _02357_ _02073_ VDD VSS MUX2_X1
X_15530_ net250 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[5\]
+ _02357_ _02074_ VDD VSS MUX2_X1
X_15531_ net251 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[60\]
+ _02357_ _02075_ VDD VSS MUX2_X1
X_15532_ net252 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[61\]
+ _02357_ _02076_ VDD VSS MUX2_X1
X_15533_ net253 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[62\]
+ _02357_ _02077_ VDD VSS MUX2_X1
X_15534_ net254 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[63\]
+ _02357_ _02078_ VDD VSS MUX2_X1
X_15535_ net255 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[6\]
+ _02351_ _02079_ VDD VSS MUX2_X1
X_15536_ net256 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[7\]
+ _02351_ _02080_ VDD VSS MUX2_X1
X_15537_ net257 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[8\]
+ _02351_ _02081_ VDD VSS MUX2_X1
X_15538_ net258 dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[9\]
+ _02351_ _02082_ VDD VSS MUX2_X1
X_15539_ _10613_ _02349_ _02358_ VDD VSS NAND2_X1
X_15540_ _02358_ _02359_ VDD VSS BUF_X4
X_15541_ _02359_ _02360_ VDD VSS BUF_X4
X_15542_ net195 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[0\]
+ _02360_ _02083_ VDD VSS MUX2_X1
X_15543_ net196 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[10\]
+ _02360_ _02084_ VDD VSS MUX2_X1
X_15544_ net197 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[11\]
+ _02360_ _02085_ VDD VSS MUX2_X1
X_15545_ net198 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[12\]
+ _02360_ _02086_ VDD VSS MUX2_X1
X_15546_ net199 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[13\]
+ _02360_ _02087_ VDD VSS MUX2_X1
X_15547_ net200 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[14\]
+ _02360_ _02088_ VDD VSS MUX2_X1
X_15548_ net201 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[15\]
+ _02360_ _02089_ VDD VSS MUX2_X1
X_15549_ net202 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[16\]
+ _02360_ _02090_ VDD VSS MUX2_X1
X_15550_ net203 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[17\]
+ _02360_ _02091_ VDD VSS MUX2_X1
X_15551_ net204 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[18\]
+ _02360_ _02092_ VDD VSS MUX2_X1
X_15552_ _02359_ _02361_ VDD VSS BUF_X4
X_15553_ net205 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[19\]
+ _02361_ _02093_ VDD VSS MUX2_X1
X_15554_ net206 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[1\]
+ _02361_ _02094_ VDD VSS MUX2_X1
X_15555_ net207 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[20\]
+ _02361_ _02095_ VDD VSS MUX2_X1
X_15556_ net208 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[21\]
+ _02361_ _02096_ VDD VSS MUX2_X1
X_15557_ net209 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[22\]
+ _02361_ _02097_ VDD VSS MUX2_X1
X_15558_ net210 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[23\]
+ _02361_ _02098_ VDD VSS MUX2_X1
X_15559_ net211 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[24\]
+ _02361_ _02099_ VDD VSS MUX2_X1
X_15560_ net212 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[25\]
+ _02361_ _02100_ VDD VSS MUX2_X1
X_15561_ net213 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[26\]
+ _02361_ _02101_ VDD VSS MUX2_X1
X_15562_ net214 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[27\]
+ _02361_ _02102_ VDD VSS MUX2_X1
X_15563_ _02359_ _02362_ VDD VSS BUF_X4
X_15564_ net215 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[28\]
+ _02362_ _02103_ VDD VSS MUX2_X1
X_15565_ net216 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[29\]
+ _02362_ _02104_ VDD VSS MUX2_X1
X_15566_ net217 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[2\]
+ _02362_ _02105_ VDD VSS MUX2_X1
X_15567_ net218 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[30\]
+ _02362_ _02106_ VDD VSS MUX2_X1
X_15568_ net219 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[31\]
+ _02362_ _02107_ VDD VSS MUX2_X1
X_15569_ net220 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[32\]
+ _02362_ _02108_ VDD VSS MUX2_X1
X_15570_ net221 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[33\]
+ _02362_ _02109_ VDD VSS MUX2_X1
X_15571_ net222 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[34\]
+ _02362_ _02110_ VDD VSS MUX2_X1
X_15572_ net223 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[35\]
+ _02362_ _02111_ VDD VSS MUX2_X1
X_15573_ net224 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[36\]
+ _02362_ _02112_ VDD VSS MUX2_X1
X_15574_ _02359_ _02363_ VDD VSS BUF_X4
X_15575_ net225 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[37\]
+ _02363_ _02113_ VDD VSS MUX2_X1
X_15576_ net226 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[38\]
+ _02363_ _02114_ VDD VSS MUX2_X1
X_15577_ net227 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[39\]
+ _02363_ _02115_ VDD VSS MUX2_X1
X_15578_ net228 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[3\]
+ _02363_ _02116_ VDD VSS MUX2_X1
X_15579_ net229 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[40\]
+ _02363_ _02117_ VDD VSS MUX2_X1
X_15580_ net230 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[41\]
+ _02363_ _02118_ VDD VSS MUX2_X1
X_15581_ net231 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[42\]
+ _02363_ _02119_ VDD VSS MUX2_X1
X_15582_ net232 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[43\]
+ _02363_ _02120_ VDD VSS MUX2_X1
X_15583_ net233 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[44\]
+ _02363_ _02121_ VDD VSS MUX2_X1
X_15584_ net234 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[45\]
+ _02363_ _02122_ VDD VSS MUX2_X1
X_15585_ _02359_ _02364_ VDD VSS BUF_X4
X_15586_ net235 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[46\]
+ _02364_ _02123_ VDD VSS MUX2_X1
X_15587_ net236 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[47\]
+ _02364_ _02124_ VDD VSS MUX2_X1
X_15588_ net237 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[48\]
+ _02364_ _02125_ VDD VSS MUX2_X1
X_15589_ net238 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[49\]
+ _02364_ _02126_ VDD VSS MUX2_X1
X_15590_ net239 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[4\]
+ _02364_ _02127_ VDD VSS MUX2_X1
X_15591_ net240 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[50\]
+ _02364_ _02128_ VDD VSS MUX2_X1
X_15592_ net241 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[51\]
+ _02364_ _02129_ VDD VSS MUX2_X1
X_15593_ net242 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[52\]
+ _02364_ _02130_ VDD VSS MUX2_X1
X_15594_ net243 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[53\]
+ _02364_ _02131_ VDD VSS MUX2_X1
X_15595_ net244 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[54\]
+ _02364_ _02132_ VDD VSS MUX2_X1
X_15596_ _02359_ _02365_ VDD VSS BUF_X4
X_15597_ net245 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[55\]
+ _02365_ _02133_ VDD VSS MUX2_X1
X_15598_ net246 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[56\]
+ _02365_ _02134_ VDD VSS MUX2_X1
X_15599_ net247 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[57\]
+ _02365_ _02135_ VDD VSS MUX2_X1
X_15600_ net248 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[58\]
+ _02365_ _02136_ VDD VSS MUX2_X1
X_15601_ net249 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[59\]
+ _02365_ _02137_ VDD VSS MUX2_X1
X_15602_ net250 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[5\]
+ _02365_ _02138_ VDD VSS MUX2_X1
X_15603_ net251 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[60\]
+ _02365_ _02139_ VDD VSS MUX2_X1
X_15604_ net252 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[61\]
+ _02365_ _02140_ VDD VSS MUX2_X1
X_15605_ net253 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[62\]
+ _02365_ _02141_ VDD VSS MUX2_X1
X_15606_ net254 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[63\]
+ _02365_ _02142_ VDD VSS MUX2_X1
X_15607_ net255 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[6\]
+ _02359_ _02143_ VDD VSS MUX2_X1
X_15608_ net256 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[7\]
+ _02359_ _02144_ VDD VSS MUX2_X1
X_15609_ net257 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[8\]
+ _02359_ _02145_ VDD VSS MUX2_X1
X_15610_ net258 dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[9\]
+ _02359_ _02146_ VDD VSS MUX2_X1
X_15611_ _10611_ _02349_ _02366_ VDD VSS NAND2_X1
X_15612_ _02366_ _02367_ VDD VSS BUF_X4
X_15613_ _02367_ _02368_ VDD VSS BUF_X4
X_15614_ net195 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[0\]
+ _02368_ _02147_ VDD VSS MUX2_X1
X_15615_ net196 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[10\]
+ _02368_ _02148_ VDD VSS MUX2_X1
X_15616_ net197 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[11\]
+ _02368_ _02149_ VDD VSS MUX2_X1
X_15617_ net198 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[12\]
+ _02368_ _02150_ VDD VSS MUX2_X1
X_15618_ net199 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[13\]
+ _02368_ _02151_ VDD VSS MUX2_X1
X_15619_ net200 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[14\]
+ _02368_ _02152_ VDD VSS MUX2_X1
X_15620_ net201 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[15\]
+ _02368_ _02153_ VDD VSS MUX2_X1
X_15621_ net202 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[16\]
+ _02368_ _02154_ VDD VSS MUX2_X1
X_15622_ net203 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[17\]
+ _02368_ _02155_ VDD VSS MUX2_X1
X_15623_ net204 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[18\]
+ _02368_ _02156_ VDD VSS MUX2_X1
X_15624_ _02367_ _02369_ VDD VSS BUF_X4
X_15625_ net205 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[19\]
+ _02369_ _02157_ VDD VSS MUX2_X1
X_15626_ net206 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[1\]
+ _02369_ _02158_ VDD VSS MUX2_X1
X_15627_ net207 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[20\]
+ _02369_ _02159_ VDD VSS MUX2_X1
X_15628_ net208 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[21\]
+ _02369_ _02160_ VDD VSS MUX2_X1
X_15629_ net209 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[22\]
+ _02369_ _02161_ VDD VSS MUX2_X1
X_15630_ net210 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[23\]
+ _02369_ _02162_ VDD VSS MUX2_X1
X_15631_ net211 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[24\]
+ _02369_ _02163_ VDD VSS MUX2_X1
X_15632_ net212 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[25\]
+ _02369_ _02164_ VDD VSS MUX2_X1
X_15633_ net213 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[26\]
+ _02369_ _02165_ VDD VSS MUX2_X1
X_15634_ net214 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[27\]
+ _02369_ _02166_ VDD VSS MUX2_X1
X_15635_ _02367_ _02370_ VDD VSS BUF_X4
X_15636_ net215 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[28\]
+ _02370_ _02167_ VDD VSS MUX2_X1
X_15637_ net216 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[29\]
+ _02370_ _02168_ VDD VSS MUX2_X1
X_15638_ net217 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[2\]
+ _02370_ _02169_ VDD VSS MUX2_X1
X_15639_ net218 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[30\]
+ _02370_ _02170_ VDD VSS MUX2_X1
X_15640_ net219 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[31\]
+ _02370_ _02171_ VDD VSS MUX2_X1
X_15641_ net220 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[32\]
+ _02370_ _02172_ VDD VSS MUX2_X1
X_15642_ net221 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[33\]
+ _02370_ _02173_ VDD VSS MUX2_X1
X_15643_ net222 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[34\]
+ _02370_ _02174_ VDD VSS MUX2_X1
X_15644_ net223 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[35\]
+ _02370_ _02175_ VDD VSS MUX2_X1
X_15645_ net224 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[36\]
+ _02370_ _02176_ VDD VSS MUX2_X1
X_15646_ _02367_ _02371_ VDD VSS BUF_X4
X_15647_ net225 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[37\]
+ _02371_ _02177_ VDD VSS MUX2_X1
X_15648_ net226 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[38\]
+ _02371_ _02178_ VDD VSS MUX2_X1
X_15649_ net227 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[39\]
+ _02371_ _02179_ VDD VSS MUX2_X1
X_15650_ net228 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[3\]
+ _02371_ _02180_ VDD VSS MUX2_X1
X_15651_ net229 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[40\]
+ _02371_ _02181_ VDD VSS MUX2_X1
X_15652_ net230 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[41\]
+ _02371_ _02182_ VDD VSS MUX2_X1
X_15653_ net231 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[42\]
+ _02371_ _02183_ VDD VSS MUX2_X1
X_15654_ net232 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[43\]
+ _02371_ _02184_ VDD VSS MUX2_X1
X_15655_ net233 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[44\]
+ _02371_ _02185_ VDD VSS MUX2_X1
X_15656_ net234 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[45\]
+ _02371_ _02186_ VDD VSS MUX2_X1
X_15657_ _02367_ _02372_ VDD VSS BUF_X4
X_15658_ net235 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[46\]
+ _02372_ _02187_ VDD VSS MUX2_X1
X_15659_ net236 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[47\]
+ _02372_ _02188_ VDD VSS MUX2_X1
X_15660_ net237 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[48\]
+ _02372_ _02189_ VDD VSS MUX2_X1
X_15661_ net238 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[49\]
+ _02372_ _02190_ VDD VSS MUX2_X1
X_15662_ net239 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[4\]
+ _02372_ _02191_ VDD VSS MUX2_X1
X_15663_ net240 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[50\]
+ _02372_ _02192_ VDD VSS MUX2_X1
X_15664_ net241 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[51\]
+ _02372_ _02193_ VDD VSS MUX2_X1
X_15665_ net242 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[52\]
+ _02372_ _02194_ VDD VSS MUX2_X1
X_15666_ net243 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[53\]
+ _02372_ _02195_ VDD VSS MUX2_X1
X_15667_ net244 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[54\]
+ _02372_ _02196_ VDD VSS MUX2_X1
X_15668_ _02367_ _02373_ VDD VSS BUF_X4
X_15669_ net245 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[55\]
+ _02373_ _02197_ VDD VSS MUX2_X1
X_15670_ net246 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[56\]
+ _02373_ _02198_ VDD VSS MUX2_X1
X_15671_ net247 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[57\]
+ _02373_ _02199_ VDD VSS MUX2_X1
X_15672_ net248 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[58\]
+ _02373_ _02200_ VDD VSS MUX2_X1
X_15673_ net249 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[59\]
+ _02373_ _02201_ VDD VSS MUX2_X1
X_15674_ net250 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[5\]
+ _02373_ _02202_ VDD VSS MUX2_X1
X_15675_ net251 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[60\]
+ _02373_ _02203_ VDD VSS MUX2_X1
X_15676_ net252 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[61\]
+ _02373_ _02204_ VDD VSS MUX2_X1
X_15677_ net253 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[62\]
+ _02373_ _02205_ VDD VSS MUX2_X1
X_15678_ net254 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[63\]
+ _02373_ _02206_ VDD VSS MUX2_X1
X_15679_ net255 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[6\]
+ _02367_ _02207_ VDD VSS MUX2_X1
X_15680_ net256 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[7\]
+ _02367_ _02208_ VDD VSS MUX2_X1
X_15681_ net257 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[8\]
+ _02367_ _02209_ VDD VSS MUX2_X1
X_15682_ net258 dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[9\]
+ _02367_ _02210_ VDD VSS MUX2_X1
X_15683_ _10615_ _02349_ _02374_ VDD VSS NAND2_X1
X_15684_ _02374_ _02375_ VDD VSS BUF_X4
X_15685_ _02375_ _02376_ VDD VSS BUF_X4
X_15686_ net195 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[0\]
+ _02376_ _02211_ VDD VSS MUX2_X1
X_15687_ net196 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[10\]
+ _02376_ _02212_ VDD VSS MUX2_X1
X_15688_ net197 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[11\]
+ _02376_ _02213_ VDD VSS MUX2_X1
X_15689_ net198 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[12\]
+ _02376_ _02214_ VDD VSS MUX2_X1
X_15690_ net199 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[13\]
+ _02376_ _02215_ VDD VSS MUX2_X1
X_15691_ net200 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[14\]
+ _02376_ _02216_ VDD VSS MUX2_X1
X_15692_ net201 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[15\]
+ _02376_ _02217_ VDD VSS MUX2_X1
X_15693_ net202 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[16\]
+ _02376_ _02218_ VDD VSS MUX2_X1
X_15694_ net203 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[17\]
+ _02376_ _02219_ VDD VSS MUX2_X1
X_15695_ net204 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[18\]
+ _02376_ _02220_ VDD VSS MUX2_X1
X_15696_ _02375_ _02377_ VDD VSS BUF_X4
X_15697_ net205 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[19\]
+ _02377_ _02221_ VDD VSS MUX2_X1
X_15698_ net206 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[1\]
+ _02377_ _02222_ VDD VSS MUX2_X1
X_15699_ net207 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[20\]
+ _02377_ _02223_ VDD VSS MUX2_X1
X_15700_ net208 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[21\]
+ _02377_ _02224_ VDD VSS MUX2_X1
X_15701_ net209 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[22\]
+ _02377_ _02225_ VDD VSS MUX2_X1
X_15702_ net210 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[23\]
+ _02377_ _02226_ VDD VSS MUX2_X1
X_15703_ net211 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[24\]
+ _02377_ _02227_ VDD VSS MUX2_X1
X_15704_ net212 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[25\]
+ _02377_ _02228_ VDD VSS MUX2_X1
X_15705_ net213 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[26\]
+ _02377_ _02229_ VDD VSS MUX2_X1
X_15706_ net214 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[27\]
+ _02377_ _02230_ VDD VSS MUX2_X1
X_15707_ _02375_ _02378_ VDD VSS BUF_X4
X_15708_ net215 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[28\]
+ _02378_ _02231_ VDD VSS MUX2_X1
X_15709_ net216 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[29\]
+ _02378_ _02232_ VDD VSS MUX2_X1
X_15710_ net217 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[2\]
+ _02378_ _02233_ VDD VSS MUX2_X1
X_15711_ net218 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[30\]
+ _02378_ _02234_ VDD VSS MUX2_X1
X_15712_ net219 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[31\]
+ _02378_ _02235_ VDD VSS MUX2_X1
X_15713_ net220 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[32\]
+ _02378_ _02236_ VDD VSS MUX2_X1
X_15714_ net221 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[33\]
+ _02378_ _02237_ VDD VSS MUX2_X1
X_15715_ net222 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[34\]
+ _02378_ _02238_ VDD VSS MUX2_X1
X_15716_ net223 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[35\]
+ _02378_ _02239_ VDD VSS MUX2_X1
X_15717_ net224 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[36\]
+ _02378_ _02240_ VDD VSS MUX2_X1
X_15718_ _02375_ _02379_ VDD VSS CLKBUF_X3
X_15719_ net225 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[37\]
+ _02379_ _02241_ VDD VSS MUX2_X1
X_15720_ net226 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[38\]
+ _02379_ _02242_ VDD VSS MUX2_X1
X_15721_ net227 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[39\]
+ _02379_ _02243_ VDD VSS MUX2_X1
X_15722_ net228 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[3\]
+ _02379_ _02244_ VDD VSS MUX2_X1
X_15723_ net229 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[40\]
+ _02379_ _02245_ VDD VSS MUX2_X1
X_15724_ net230 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[41\]
+ _02379_ _02246_ VDD VSS MUX2_X1
X_15725_ net231 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[42\]
+ _02379_ _02247_ VDD VSS MUX2_X1
X_15726_ net232 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[43\]
+ _02379_ _02248_ VDD VSS MUX2_X1
X_15727_ net233 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[44\]
+ _02379_ _02249_ VDD VSS MUX2_X1
X_15728_ net234 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[45\]
+ _02379_ _02250_ VDD VSS MUX2_X1
X_15729_ _02375_ _02380_ VDD VSS BUF_X4
X_15730_ net235 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[46\]
+ _02380_ _02251_ VDD VSS MUX2_X1
X_15731_ net236 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[47\]
+ _02380_ _02252_ VDD VSS MUX2_X1
X_15732_ net237 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[48\]
+ _02380_ _02253_ VDD VSS MUX2_X1
X_15733_ net238 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[49\]
+ _02380_ _02254_ VDD VSS MUX2_X1
X_15734_ net239 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[4\]
+ _02380_ _02255_ VDD VSS MUX2_X1
X_15735_ net240 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[50\]
+ _02380_ _02256_ VDD VSS MUX2_X1
X_15736_ net241 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[51\]
+ _02380_ _02257_ VDD VSS MUX2_X1
X_15737_ net242 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[52\]
+ _02380_ _02258_ VDD VSS MUX2_X1
X_15738_ net243 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[53\]
+ _02380_ _02259_ VDD VSS MUX2_X1
X_15739_ net244 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[54\]
+ _02380_ _02260_ VDD VSS MUX2_X1
X_15740_ _02375_ _02381_ VDD VSS BUF_X4
X_15741_ net245 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[55\]
+ _02381_ _02261_ VDD VSS MUX2_X1
X_15742_ net246 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[56\]
+ _02381_ _02262_ VDD VSS MUX2_X1
X_15743_ net247 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[57\]
+ _02381_ _02263_ VDD VSS MUX2_X1
X_15744_ net248 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[58\]
+ _02381_ _02264_ VDD VSS MUX2_X1
X_15745_ net249 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[59\]
+ _02381_ _02265_ VDD VSS MUX2_X1
X_15746_ net250 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[5\]
+ _02381_ _02266_ VDD VSS MUX2_X1
X_15747_ net251 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[60\]
+ _02381_ _02267_ VDD VSS MUX2_X1
X_15748_ net252 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[61\]
+ _02381_ _02268_ VDD VSS MUX2_X1
X_15749_ net253 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[62\]
+ _02381_ _02269_ VDD VSS MUX2_X1
X_15750_ net254 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[63\]
+ _02381_ _02270_ VDD VSS MUX2_X1
X_15751_ net255 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[6\]
+ _02375_ _02271_ VDD VSS MUX2_X1
X_15752_ net256 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[7\]
+ _02375_ _02272_ VDD VSS MUX2_X1
X_15753_ net257 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[8\]
+ _02375_ _02273_ VDD VSS MUX2_X1
X_15754_ net258 dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[9\]
+ _02375_ _02274_ VDD VSS MUX2_X1
X_15755_ _06589_ _02382_ VDD VSS BUF_X4
X_15756_ _10499_ _10503_ _02383_ VDD VSS NOR2_X1
X_15757_ dynamic_node_top.west_input.NIB.head_ptr_next\[0\]
+ _02383_ _02384_ VDD VSS XOR2_X1
X_15758_ _02382_ _02384_ _00077_ VDD VSS NOR2_X1
X_15759_ dynamic_node_top.west_input.NIB.head_ptr_f\[0\] _02383_
+ _02385_ VDD VSS NAND2_X1
X_15760_ dynamic_node_top.west_input.NIB.head_ptr_f\[1\] _02385_
+ _02386_ VDD VSS XOR2_X2
X_15761_ _02382_ _02386_ _00078_ VDD VSS NOR2_X2
X_15762_ _10469_ _10465_ _02387_ VDD VSS NOR2_X4
X_15763_ dynamic_node_top.south_input.NIB.head_ptr_next\[0\]
+ _02387_ _02388_ VDD VSS XOR2_X1
X_15764_ _02382_ _02388_ _00079_ VDD VSS NOR2_X1
X_15765_ dynamic_node_top.south_input.NIB.head_ptr_f\[0\]
+ _02387_ _02389_ VDD VSS NAND2_X1
X_15766_ dynamic_node_top.south_input.NIB.head_ptr_f\[1\]
+ _02389_ _02390_ VDD VSS XOR2_X1
X_15767_ _02382_ _02390_ _00080_ VDD VSS NOR2_X1
X_15768_ _10507_ _10511_ _02391_ VDD VSS NOR2_X4
X_15769_ dynamic_node_top.east_input.NIB.head_ptr_next\[0\]
+ _02391_ _02392_ VDD VSS XOR2_X1
X_15770_ _02382_ _02392_ _00081_ VDD VSS NOR2_X1
X_15771_ dynamic_node_top.east_input.NIB.head_ptr_f\[0\] _02391_
+ _02393_ VDD VSS NAND2_X1
X_15772_ dynamic_node_top.east_input.NIB.head_ptr_f\[1\] _02393_
+ _02394_ VDD VSS XOR2_X1
X_15773_ _02382_ _02394_ _00082_ VDD VSS NOR2_X1
X_15774_ _10458_ _10169_ _02395_ VDD VSS NOR2_X4
X_15775_ dynamic_node_top.proc_input.NIB.head_ptr_next\[0\]
+ _02395_ _02396_ VDD VSS XOR2_X1
X_15776_ _02382_ _02396_ _00083_ VDD VSS NOR2_X1
X_15777_ dynamic_node_top.proc_input.NIB.head_ptr_f\[1\] dynamic_node_top.proc_input.NIB.head_ptr_next\[1\]
+ _02395_ _02397_ VDD VSS MUX2_X1
X_15778_ _06892_ _02397_ _00084_ VDD VSS AND2_X1
X_15779_ _10592_ _02395_ _02398_ VDD VSS NAND2_X1
X_15780_ dynamic_node_top.proc_input.NIB.head_ptr_f\[2\] _02398_
+ _02399_ VDD VSS XOR2_X1
X_15781_ _02382_ _02399_ _00085_ VDD VSS NOR2_X1
X_15782_ dynamic_node_top.proc_input.NIB.head_ptr_f\[2\] dynamic_node_top.proc_input.NIB.head_ptr_f\[1\]
+ dynamic_node_top.proc_input.NIB.head_ptr_f\[0\] _02395_ _02400_
+ VDD VSS NAND4_X1
X_15783_ dynamic_node_top.proc_input.NIB.head_ptr_f\[3\] _02400_
+ _02401_ VDD VSS XOR2_X1
X_15784_ _02382_ _02401_ _00086_ VDD VSS NOR2_X1
X_15785_ _10477_ _10473_ _02402_ VDD VSS NOR2_X2
X_15786_ dynamic_node_top.north_input.NIB.head_ptr_next\[0\]
+ _02402_ _02403_ VDD VSS XOR2_X1
X_15787_ _02382_ _02403_ _00087_ VDD VSS NOR2_X1
X_15788_ _06589_ _02404_ VDD VSS BUF_X4
X_15789_ dynamic_node_top.north_input.NIB.head_ptr_f\[0\]
+ _02402_ _02405_ VDD VSS NAND2_X1
X_15790_ dynamic_node_top.north_input.NIB.head_ptr_f\[1\]
+ _02405_ _02406_ VDD VSS XOR2_X2
X_15791_ _02404_ _02406_ _00088_ VDD VSS NOR2_X2
X_15792_ dynamic_node_top.east_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.east_input.NIB.elements_in_array_next\[0\]
+ _10508_ _02407_ VDD VSS MUX2_X1
X_15793_ _06892_ _02407_ _00089_ VDD VSS AND2_X1
X_15794_ _10164_ _10508_ _02408_ VDD VSS NAND2_X1
X_15795_ _02408_ _10508_ dynamic_node_top.east_input.NIB.elements_in_array_f\[1\]
+ _02409_ VDD VSS OAI21_X1
X_15796_ _02404_ _02409_ _00090_ VDD VSS NOR2_X1
X_15797_ _10511_ _10163_ _02410_ VDD VSS XNOR2_X1
X_15798_ _10508_ _02410_ _02411_ VDD VSS NAND2_X1
X_15799_ dynamic_node_top.east_input.NIB.elements_in_array_f\[2\]
+ _02411_ _02412_ VDD VSS XOR2_X1
X_15800_ _02404_ _02412_ _00091_ VDD VSS NOR2_X1
X_15801_ dynamic_node_top.east_input.NIB.head_ptr_f\[0\] dynamic_node_top.east_input.NIB.head_ptr_next\[0\]
+ _02391_ _02413_ VDD VSS MUX2_X1
X_15802_ _06892_ _02413_ _00092_ VDD VSS AND2_X1
X_15803_ _10509_ _10507_ _02414_ VDD VSS NOR2_X4
X_15804_ dynamic_node_top.east_input.NIB.tail_ptr_f\[0\] dynamic_node_top.east_input.NIB.tail_ptr_next\[0\]
+ _02414_ _02415_ VDD VSS MUX2_X1
X_15805_ _06892_ _02415_ _00349_ VDD VSS AND2_X1
X_15806_ dynamic_node_top.east_input.NIB.tail_ptr_f\[1\] dynamic_node_top.east_input.NIB.tail_ptr_next\[1\]
+ _02414_ _02416_ VDD VSS MUX2_X1
X_15807_ _06892_ _02416_ _00350_ VDD VSS AND2_X1
X_15808_ _06754_ _07211_ _00351_ VDD VSS AND2_X1
X_15809_ _05787_ dynamic_node_top.east_input.control.count_f\[1\]
+ _02417_ VDD VSS NOR2_X1
X_15810_ _02417_ _10441_ _05787_ _05488_ _05177_ _02418_ VDD
+ VSS AOI221_X2
X_15811_ _02418_ _05765_ _06787_ _02419_ VDD VSS AOI21_X1
X_15812_ _02404_ _02419_ _00352_ VDD VSS NOR2_X1
X_15813_ _06589_ _02420_ VDD VSS BUF_X4
X_15814_ _06793_ _05771_ _02421_ VDD VSS NOR2_X1
X_15815_ _07212_ _07213_ _02422_ VDD VSS XNOR2_X1
X_15816_ _06787_ _02422_ _02423_ VDD VSS NOR2_X1
X_15817_ _02420_ _02421_ _02423_ _00353_ VDD VSS NOR3_X1
X_15818_ _06793_ _05768_ _02424_ VDD VSS NOR2_X1
X_15819_ _06787_ _07219_ _02425_ VDD VSS NOR2_X1
X_15820_ _02420_ _02424_ _02425_ _00354_ VDD VSS NOR3_X1
X_15821_ _02420_ _05761_ _07216_ _00355_ VDD VSS NOR3_X1
X_15822_ _02404_ _07235_ _00356_ VDD VSS NOR2_X1
X_15823_ _02404_ _07232_ _00357_ VDD VSS NOR2_X1
X_15824_ _06892_ _07228_ _00358_ VDD VSS AND2_X1
X_15825_ _00351_ _02426_ VDD VSS INV_X1
X_15826_ _07224_ _07228_ _07236_ _02426_ _00359_ VDD VSS NOR4_X1
X_15827_ _02404_ _06599_ _00360_ VDD VSS NOR2_X1
X_15828_ _02404_ _10506_ _00361_ VDD VSS NOR2_X1
X_15829_ _00046_ _06721_ _02427_ VDD VSS NAND2_X1
X_15830_ _05307_ _06757_ _02428_ VDD VSS NAND2_X1
X_15831_ _02427_ _02428_ _06720_ _02429_ VDD VSS MUX2_X1
X_15832_ _00046_ _06756_ _02430_ VDD VSS NAND2_X1
X_15833_ _06545_ _06789_ _05500_ _02431_ VDD VSS NAND3_X1
X_15834_ _05304_ _06793_ _06567_ _02431_ _02432_ VDD VSS NOR4_X1
X_15835_ _06793_ _06839_ _02433_ VDD VSS NOR2_X1
X_15836_ _02432_ _02433_ _06567_ _02434_ VDD VSS AOI21_X1
X_15837_ _05306_ _06752_ _06765_ _02434_ _02435_ VDD VSS AND4_X1
X_15838_ _05184_ _06833_ _02435_ _02436_ VDD VSS NAND3_X1
X_15839_ _06755_ _02429_ _02430_ _02436_ _02437_ VDD VSS OAI211_X2
X_15840_ _06721_ _06833_ _05158_ _02438_ VDD VSS OAI21_X1
X_15841_ _02438_ _06745_ _05306_ _02439_ VDD VSS OAI21_X1
X_15842_ _00046_ _05184_ _02440_ VDD VSS NOR2_X1
X_15843_ _06714_ _06719_ _02440_ _02441_ VDD VSS AND3_X1
X_15844_ _05173_ _06736_ _06841_ _06724_ _06752_ _05167_ _02442_
+ VDD VSS OAI222_X2
X_15845_ _06757_ _06719_ _02443_ VDD VSS NOR2_X1
X_15846_ _06714_ _06765_ _05171_ _02444_ VDD VSS OAI21_X1
X_15847_ _06954_ _02444_ _06721_ _02445_ VDD VSS MUX2_X1
X_15848_ _02441_ _02442_ _02443_ _02445_ _02446_ VDD VSS NOR4_X1
X_15849_ _02437_ _02439_ _02446_ _00362_ VDD VSS AOI21_X1
X_15850_ _10432_ _02447_ VDD VSS BUF_X2
X_15851_ dynamic_node_top.east_output.space.count_f\[2\] _02447_
+ _02448_ VDD VSS NAND2_X1
X_15852_ _00057_ _02449_ VDD VSS BUF_X2
X_15853_ _02449_ _02447_ _02450_ VDD VSS NAND2_X1
X_15854_ _10566_ _02448_ _02450_ _10568_ _02451_ VDD VSS OAI22_X1
X_15855_ _10426_ _02452_ VDD VSS BUF_X1
X_15856_ _02452_ _10567_ _10565_ _02453_ VDD VSS NOR3_X1
X_15857_ _02453_ _10430_ _02452_ _02454_ VDD VSS AOI21_X1
X_15858_ _02447_ _02449_ dynamic_node_top.east_output.space.count_f\[2\]
+ _02455_ VDD VSS OAI21_X2
X_15859_ _02451_ _02454_ _02455_ _02456_ VDD VSS AOI21_X1
X_15860_ _02404_ _02456_ _00363_ VDD VSS NOR2_X1
X_15861_ _10428_ _02457_ VDD VSS CLKBUF_X2
X_15862_ _10433_ _02457_ _02449_ _02447_ _02458_ VDD VSS NAND4_X1
X_15863_ _10433_ _02459_ VDD VSS INV_X1
X_15864_ _10425_ _02459_ _02460_ VDD VSS NAND2_X1
X_15865_ _02458_ _02460_ _02448_ _02461_ VDD VSS OAI21_X1
X_15866_ _02457_ _02462_ VDD VSS INV_X1
X_15867_ _02460_ _02462_ _02459_ _02463_ VDD VSS OAI21_X1
X_15868_ _02463_ dynamic_node_top.east_output.space.count_f\[1\]
+ _02452_ _02464_ VDD VSS MUX2_X1
X_15869_ _10431_ _02465_ VDD VSS INV_X1
X_15870_ _10425_ _02448_ _02450_ _02457_ _02466_ VDD VSS OAI22_X2
X_15871_ _02461_ _02464_ _02455_ _02465_ _02466_ _02467_ VDD
+ VSS AOI221_X2
X_15872_ _02404_ _02467_ _00364_ VDD VSS NOR2_X1
X_15873_ _10425_ _10434_ _02468_ VDD VSS NAND2_X1
X_15874_ _02449_ _02468_ _02469_ VDD VSS XOR2_X1
X_15875_ _02452_ _02469_ _02447_ _02470_ VDD VSS MUX2_X1
X_15876_ dynamic_node_top.east_output.space.count_f\[2\] _02470_
+ _02471_ VDD VSS NAND2_X1
X_15877_ _02455_ _02472_ VDD VSS INV_X1
X_15878_ _02449_ _10436_ _02473_ VDD VSS XNOR2_X1
X_15879_ _02449_ _10434_ _02474_ VDD VSS XNOR2_X1
X_15880_ _02457_ _02473_ _02474_ _10425_ _02475_ VDD VSS AOI22_X1
X_15881_ _02452_ _02472_ _02475_ _02476_ VDD VSS OR3_X1
X_15882_ _02457_ _02449_ _10436_ _02447_ _02477_ VDD VSS NAND4_X1
X_15883_ _06754_ _02477_ _02478_ VDD VSS AND2_X1
X_15884_ _02471_ _02476_ _02478_ _00365_ VDD VSS NAND3_X1
X_15885_ _02467_ _02471_ _02476_ _02478_ _00367_ VDD VSS NAND4_X1
X_15886_ _02456_ _00367_ _00366_ VDD VSS NOR2_X1
X_15887_ _06589_ _02479_ VDD VSS CLKBUF_X3
X_15888_ _02479_ _05308_ _00368_ VDD VSS NOR2_X1
X_15889_ _06892_ net295 _00369_ VDD VSS AND2_X1
X_15890_ _06755_ _02480_ VDD VSS CLKBUF_X3
X_15891_ _02480_ net259 _00370_ VDD VSS AND2_X1
X_15892_ _02480_ net260 _00371_ VDD VSS AND2_X1
X_15893_ _02480_ net261 _00372_ VDD VSS AND2_X1
X_15894_ _02480_ net262 _00373_ VDD VSS AND2_X1
X_15895_ _02480_ net263 _00374_ VDD VSS AND2_X1
X_15896_ _02480_ net264 _00375_ VDD VSS AND2_X1
X_15897_ _02480_ net265 _00376_ VDD VSS AND2_X1
X_15898_ _02480_ net266 _00377_ VDD VSS AND2_X1
X_15899_ _02480_ net267 _00378_ VDD VSS AND2_X1
X_15900_ _02480_ net268 _00379_ VDD VSS AND2_X1
X_15901_ _06880_ _02481_ VDD VSS CLKBUF_X3
X_15902_ _02481_ net269 _00380_ VDD VSS AND2_X1
X_15903_ _02481_ net270 _00381_ VDD VSS AND2_X1
X_15904_ _02481_ net271 _00382_ VDD VSS AND2_X1
X_15905_ _02481_ net272 _00383_ VDD VSS AND2_X1
X_15906_ _02481_ net273 _00384_ VDD VSS AND2_X1
X_15907_ _02481_ net274 _00385_ VDD VSS AND2_X1
X_15908_ _02481_ net275 _00386_ VDD VSS AND2_X1
X_15909_ _02481_ net276 _00387_ VDD VSS AND2_X1
X_15910_ _02481_ net277 _00388_ VDD VSS AND2_X1
X_15911_ _02481_ net278 _00389_ VDD VSS AND2_X1
X_15912_ _06880_ _02482_ VDD VSS CLKBUF_X2
X_15913_ _02482_ net279 _00390_ VDD VSS AND2_X1
X_15914_ _02482_ net280 _00391_ VDD VSS AND2_X1
X_15915_ _02482_ net281 _00392_ VDD VSS AND2_X1
X_15916_ _02482_ net282 _00393_ VDD VSS AND2_X1
X_15917_ _02482_ net283 _00394_ VDD VSS AND2_X1
X_15918_ _02482_ net284 _00395_ VDD VSS AND2_X1
X_15919_ _02482_ net285 _00396_ VDD VSS AND2_X1
X_15920_ _02482_ net286 _00397_ VDD VSS AND2_X1
X_15921_ _02482_ net287 _00398_ VDD VSS AND2_X1
X_15922_ _02482_ net288 _00399_ VDD VSS AND2_X1
X_15923_ _06880_ _02483_ VDD VSS CLKBUF_X3
X_15924_ dynamic_node_top.north_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.north_input.NIB.elements_in_array_next\[0\]
+ _10474_ _02484_ VDD VSS MUX2_X1
X_15925_ _02483_ _02484_ _00400_ VDD VSS AND2_X1
X_15926_ _10167_ _10474_ _02485_ VDD VSS NAND2_X1
X_15927_ _02485_ _10474_ dynamic_node_top.north_input.NIB.elements_in_array_f\[1\]
+ _02486_ VDD VSS OAI21_X1
X_15928_ _02479_ _02486_ _00401_ VDD VSS NOR2_X1
X_15929_ _10477_ _10166_ _02487_ VDD VSS XNOR2_X1
X_15930_ _10474_ _02487_ _02488_ VDD VSS NAND2_X1
X_15931_ dynamic_node_top.north_input.NIB.elements_in_array_f\[2\]
+ _02488_ _02489_ VDD VSS XOR2_X1
X_15932_ _02479_ _02489_ _00402_ VDD VSS NOR2_X1
X_15933_ dynamic_node_top.north_input.NIB.head_ptr_f\[0\]
+ dynamic_node_top.north_input.NIB.head_ptr_next\[0\] _02402_
+ _02490_ VDD VSS MUX2_X1
X_15934_ _02483_ _02490_ _00403_ VDD VSS AND2_X1
X_15935_ _10473_ _10475_ _02491_ VDD VSS NOR2_X2
X_15936_ dynamic_node_top.north_input.NIB.tail_ptr_f\[0\]
+ dynamic_node_top.north_input.NIB.tail_ptr_next\[0\] _02491_
+ _02492_ VDD VSS MUX2_X1
X_15937_ _02483_ _02492_ _00660_ VDD VSS AND2_X1
X_15938_ dynamic_node_top.north_input.NIB.tail_ptr_f\[1\]
+ dynamic_node_top.north_input.NIB.tail_ptr_next\[1\] _02491_
+ _02493_ VDD VSS MUX2_X1
X_15939_ _02483_ _02493_ _00661_ VDD VSS AND2_X1
X_15940_ _02479_ _10472_ _00662_ VDD VSS NOR2_X1
X_15941_ _05846_ _02494_ VDD VSS INV_X2
X_15942_ _06909_ _02494_ _02495_ VDD VSS NOR2_X1
X_15943_ _02495_ _07087_ _06909_ _02496_ VDD VSS AOI21_X1
X_15944_ _02479_ _02496_ _00663_ VDD VSS NOR2_X1
X_15945_ _02483_ _07091_ _00664_ VDD VSS AND2_X1
X_15946_ _02483_ _07094_ _00665_ VDD VSS AND2_X1
X_15947_ _06755_ _06909_ _05829_ _02497_ VDD VSS OAI21_X1
X_15948_ _02497_ _07098_ _06909_ _00666_ VDD VSS AOI21_X1
X_15949_ _06909_ _05832_ _02498_ VDD VSS NOR2_X1
X_15950_ _02420_ _02498_ _07102_ _00667_ VDD VSS NOR3_X1
X_15951_ _02479_ _07118_ _00668_ VDD VSS NOR2_X1
X_15952_ _02479_ _07115_ _00669_ VDD VSS NOR2_X1
X_15953_ _02479_ _07111_ _00670_ VDD VSS NOR2_X1
X_15954_ _02420_ _02496_ _07119_ _00671_ VDD VSS NOR3_X1
X_15955_ _02479_ _06601_ _00672_ VDD VSS NOR2_X1
X_15956_ _05821_ _06510_ _06518_ _02499_ VDD VSS OR3_X1
X_15957_ _07021_ _06568_ _02499_ _06124_ _02500_ VDD VSS AOI22_X2
X_15958_ _06124_ _02501_ VDD VSS INV_X1
X_15959_ _06051_ _06084_ _02502_ VDD VSS AND2_X1
X_15960_ _06122_ _02501_ _02502_ net622 _02503_ VDD VSS AOI22_X2
X_15961_ _05757_ _06568_ _02504_ VDD VSS NOR2_X1
X_15962_ _06090_ _06120_ _02505_ VDD VSS NOR2_X1
X_15963_ _06580_ _02504_ _02505_ _02506_ VDD VSS NOR3_X2
X_15964_ _06124_ _02506_ _07038_ _05823_ _02507_ VDD VSS OAI211_X2
X_15965_ _07038_ _06578_ _02506_ _02508_ VDD VSS NAND3_X1
X_15966_ _02500_ _02503_ _02507_ _02508_ _02509_ VDD VSS AOI211_X2
X_15967_ _06122_ _02502_ _02510_ VDD VSS NAND2_X1
X_15968_ _06095_ net667 _02511_ VDD VSS NOR2_X1
X_15969_ _07038_ _07021_ _06585_ _02511_ _02512_ VDD VSS NAND4_X1
X_15970_ _02510_ _02512_ _02501_ _02513_ VDD VSS AOI21_X1
X_15971_ _06122_ _06124_ _02502_ _02514_ VDD VSS NOR3_X1
X_15972_ _06573_ _02509_ _02513_ _02514_ _00673_ VDD VSS NOR4_X1
X_15973_ _10543_ _02515_ VDD VSS BUF_X2
X_15974_ dynamic_node_top.north_output.space.count_f\[2\]
+ _02515_ _02516_ VDD VSS NAND2_X1
X_15975_ _00061_ _02517_ VDD VSS BUF_X2
X_15976_ _02517_ _02515_ _02518_ VDD VSS NAND2_X1
X_15977_ _10562_ _02516_ _02518_ _10564_ _02519_ VDD VSS OAI22_X1
X_15978_ _10537_ _02520_ VDD VSS BUF_X1
X_15979_ _02520_ _10563_ _10561_ _02521_ VDD VSS NOR3_X1
X_15980_ _02521_ _10541_ _02520_ _02522_ VDD VSS AOI21_X1
X_15981_ _02515_ _02517_ dynamic_node_top.north_output.space.count_f\[2\]
+ _02523_ VDD VSS OAI21_X2
X_15982_ _02519_ _02522_ _02523_ _02524_ VDD VSS AOI21_X1
X_15983_ _02479_ _02524_ _00674_ VDD VSS NOR2_X1
X_15984_ _06589_ _02525_ VDD VSS BUF_X4
X_15985_ _10539_ _02526_ VDD VSS CLKBUF_X2
X_15986_ _10544_ _02526_ _02517_ _02515_ _02527_ VDD VSS NAND4_X1
X_15987_ _10544_ _02528_ VDD VSS INV_X1
X_15988_ _10536_ _02528_ _02529_ VDD VSS NAND2_X1
X_15989_ _02527_ _02529_ _02516_ _02530_ VDD VSS OAI21_X1
X_15990_ _02526_ _02531_ VDD VSS INV_X1
X_15991_ _02529_ _02531_ _02528_ _02532_ VDD VSS OAI21_X1
X_15992_ _02532_ dynamic_node_top.north_output.space.count_f\[1\]
+ _02520_ _02533_ VDD VSS MUX2_X1
X_15993_ _10542_ _02534_ VDD VSS INV_X1
X_15994_ _10536_ _02516_ _02518_ _02526_ _02535_ VDD VSS OAI22_X2
X_15995_ _02530_ _02533_ _02523_ _02534_ _02535_ _02536_ VDD
+ VSS AOI221_X2
X_15996_ _02525_ _02536_ _00675_ VDD VSS NOR2_X1
X_15997_ _10536_ _10545_ _02537_ VDD VSS NAND2_X1
X_15998_ _02517_ _02537_ _02538_ VDD VSS XOR2_X1
X_15999_ _02520_ _02538_ _02515_ _02539_ VDD VSS MUX2_X1
X_16000_ dynamic_node_top.north_output.space.count_f\[2\]
+ _02539_ _02540_ VDD VSS NAND2_X1
X_16001_ _02523_ _02541_ VDD VSS INV_X1
X_16002_ _02517_ _10547_ _02542_ VDD VSS XNOR2_X1
X_16003_ _02517_ _10545_ _02543_ VDD VSS XNOR2_X1
X_16004_ _02526_ _02542_ _02543_ _10536_ _02544_ VDD VSS AOI22_X1
X_16005_ _02520_ _02541_ _02544_ _02545_ VDD VSS OR3_X1
X_16006_ _02526_ _02517_ _10547_ _02515_ _02546_ VDD VSS NAND4_X1
X_16007_ _06754_ _02546_ _02547_ VDD VSS AND2_X1
X_16008_ _02540_ _02545_ _02547_ _00676_ VDD VSS NAND3_X1
X_16009_ _02536_ _02540_ _02545_ _02547_ _00678_ VDD VSS NAND4_X1
X_16010_ _02524_ _00678_ _00677_ VDD VSS NOR2_X1
X_16011_ _06892_ net622 _00679_ VDD VSS AND2_X1
X_16012_ _02483_ net296 _00680_ VDD VSS AND2_X1
X_16013_ _10459_ _02548_ VDD VSS BUF_X2
X_16014_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.proc_input.NIB.elements_in_array_next\[0\]
+ _02548_ _02549_ VDD VSS MUX2_X1
X_16015_ _02483_ _02549_ _00681_ VDD VSS AND2_X1
X_16016_ _10171_ _02548_ _02550_ VDD VSS NAND2_X1
X_16017_ _02550_ _02548_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[1\]
+ _02551_ VDD VSS OAI21_X1
X_16018_ _02525_ _02551_ _00682_ VDD VSS NOR2_X1
X_16019_ _10170_ _10573_ _02552_ VDD VSS XNOR2_X1
X_16020_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[2\]
+ _02552_ _02548_ _02553_ VDD VSS MUX2_X1
X_16021_ _02483_ _02553_ _00683_ VDD VSS AND2_X1
X_16022_ _10572_ _02554_ VDD VSS INV_X1
X_16023_ _10570_ _10571_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[0\]
+ _02555_ VDD VSS AOI21_X1
X_16024_ _10573_ _02556_ VDD VSS INV_X1
X_16025_ _02554_ _02555_ _02556_ _02557_ VDD VSS OAI21_X1
X_16026_ _10575_ _02557_ _02558_ VDD VSS XOR2_X1
X_16027_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[3\]
+ _02558_ _02548_ _02559_ VDD VSS MUX2_X1
X_16028_ _02483_ _02559_ _00684_ VDD VSS AND2_X1
X_16029_ _02554_ _02556_ _10170_ _02560_ VDD VSS OAI21_X1
X_16030_ _10574_ _10575_ _02560_ _02561_ VDD VSS AOI21_X1
X_16031_ _10569_ _02561_ _02562_ VDD VSS XNOR2_X1
X_16032_ _02548_ _02562_ _02563_ VDD VSS NAND2_X1
X_16033_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[4\]
+ _02563_ _02564_ VDD VSS XOR2_X1
X_16034_ _02525_ _02564_ _00685_ VDD VSS NOR2_X1
X_16035_ _06880_ _02565_ VDD VSS BUF_X4
X_16036_ dynamic_node_top.proc_input.NIB.head_ptr_f\[0\] dynamic_node_top.proc_input.NIB.head_ptr_next\[0\]
+ _02395_ _02566_ VDD VSS MUX2_X1
X_16037_ _02565_ _02566_ _00686_ VDD VSS AND2_X1
X_16038_ _10461_ _10458_ _02567_ VDD VSS NOR2_X4
X_16039_ dynamic_node_top.proc_input.NIB.tail_ptr_f\[0\] dynamic_node_top.proc_input.NIB.tail_ptr_next\[0\]
+ _02567_ _02568_ VDD VSS MUX2_X1
X_16040_ _02565_ _02568_ _01711_ VDD VSS AND2_X1
X_16041_ dynamic_node_top.proc_input.NIB.tail_ptr_f\[1\] dynamic_node_top.proc_input.NIB.tail_ptr_next\[1\]
+ _02567_ _02569_ VDD VSS MUX2_X1
X_16042_ _02565_ _02569_ _01712_ VDD VSS AND2_X1
X_16043_ _07895_ _02567_ _02570_ VDD VSS NAND2_X1
X_16044_ _07883_ _02570_ _02571_ VDD VSS XNOR2_X1
X_16045_ _02525_ _02571_ _01713_ VDD VSS NOR2_X1
X_16046_ _07747_ dynamic_node_top.proc_input.NIB.tail_ptr_f\[1\]
+ dynamic_node_top.proc_input.NIB.tail_ptr_f\[0\] _02567_ _02572_
+ VDD VSS NAND4_X1
X_16047_ _07746_ _02572_ _02573_ VDD VSS XOR2_X1
X_16048_ _02525_ _02573_ _01714_ VDD VSS NOR2_X1
X_16049_ _02525_ _10456_ _01715_ VDD VSS NOR2_X1
X_16050_ _02525_ _07133_ _01716_ VDD VSS NOR2_X1
X_16051_ _02525_ _07157_ _01717_ VDD VSS NOR2_X1
X_16052_ _02525_ _07138_ _01718_ VDD VSS NOR2_X1
X_16053_ _02565_ _07151_ _01719_ VDD VSS AND2_X1
X_16054_ _02525_ _07159_ _01720_ VDD VSS NOR2_X1
X_16055_ _02565_ _07149_ _01721_ VDD VSS AND2_X1
X_16056_ _06589_ _02574_ VDD VSS BUF_X4
X_16057_ _02574_ _07142_ _01722_ VDD VSS NOR2_X1
X_16058_ _02574_ _07163_ _01723_ VDD VSS NOR2_X1
X_16059_ _02420_ _07133_ _07164_ _01724_ VDD VSS NOR3_X1
X_16060_ _02574_ _06050_ _01725_ VDD VSS NOR2_X1
X_16061_ _05697_ _06931_ _06938_ _02575_ VDD VSS OR3_X1
X_16062_ _06987_ _06975_ _06920_ _06948_ _02576_ VDD VSS NAND4_X1
X_16063_ _05610_ _06936_ _06937_ _02576_ _02577_ VDD VSS NOR4_X2
X_16064_ _05697_ _02577_ _06945_ _06944_ _02578_ VDD VSS OAI211_X2
X_16065_ _05697_ _06931_ _06938_ _02579_ VDD VSS NAND3_X1
X_16066_ _06755_ _02575_ _02578_ _02579_ _02580_ VDD VSS NAND4_X1
X_16067_ _06931_ _02581_ VDD VSS INV_X1
X_16068_ _02581_ net744 _06938_ _02582_ VDD VSS AOI21_X1
X_16069_ _05595_ _06931_ _02583_ VDD VSS NAND2_X1
X_16070_ _06934_ _06914_ _06926_ _02583_ _02584_ VDD VSS AOI22_X1
X_16071_ _06931_ _05696_ _05603_ _02585_ VDD VSS OAI21_X1
X_16072_ _02585_ _06914_ _06987_ _02586_ VDD VSS OAI21_X1
X_16073_ _02584_ _02586_ _02587_ VDD VSS NAND2_X1
X_16074_ _06787_ _06789_ _02588_ VDD VSS NAND2_X1
X_16075_ _06907_ _02589_ VDD VSS INV_X1
X_16076_ _06163_ _06740_ _06944_ _02588_ _02589_ _06905_ _02590_
+ VDD VSS OAI33_X1
X_16077_ _02582_ _02587_ _02581_ _02590_ _02591_ VDD VSS AOI211_X2
X_16078_ _05605_ _06908_ _02592_ VDD VSS OR2_X1
X_16079_ net744 _06938_ _02592_ _02593_ VDD VSS NAND3_X1
X_16080_ _06916_ _06944_ _06945_ _02594_ VDD VSS NOR3_X1
X_16081_ _07124_ _02593_ _02594_ _02595_ VDD VSS OAI21_X1
X_16082_ _02580_ _02591_ _02595_ _01726_ VDD VSS AOI21_X1
X_16083_ _10525_ _02596_ VDD VSS BUF_X2
X_16084_ dynamic_node_top.proc_output.space.count_f\[2\] _02596_
+ _02597_ VDD VSS NAND2_X1
X_16085_ _00060_ _02598_ VDD VSS BUF_X2
X_16086_ _02598_ _02596_ _02599_ VDD VSS NAND2_X1
X_16087_ _10554_ _02597_ _02599_ _10556_ _02600_ VDD VSS OAI22_X1
X_16088_ _10519_ _02601_ VDD VSS BUF_X1
X_16089_ _02601_ _10555_ _10553_ _02602_ VDD VSS NOR3_X1
X_16090_ _02602_ _10523_ _02601_ _02603_ VDD VSS AOI21_X1
X_16091_ _02596_ _02598_ dynamic_node_top.proc_output.space.count_f\[2\]
+ _02604_ VDD VSS OAI21_X2
X_16092_ _02600_ _02603_ _02604_ _02605_ VDD VSS AOI21_X1
X_16093_ _02574_ _02605_ _01727_ VDD VSS NOR2_X1
X_16094_ _10521_ _02606_ VDD VSS CLKBUF_X2
X_16095_ _10526_ _02606_ _02598_ _02596_ _02607_ VDD VSS NAND4_X1
X_16096_ _10526_ _02608_ VDD VSS INV_X1
X_16097_ _10518_ _02608_ _02609_ VDD VSS NAND2_X1
X_16098_ _02607_ _02609_ _02597_ _02610_ VDD VSS OAI21_X1
X_16099_ _02606_ _02611_ VDD VSS INV_X1
X_16100_ _02609_ _02611_ _02608_ _02612_ VDD VSS OAI21_X1
X_16101_ _02612_ dynamic_node_top.proc_output.space.count_f\[1\]
+ _02601_ _02613_ VDD VSS MUX2_X1
X_16102_ _10524_ _02614_ VDD VSS INV_X1
X_16103_ _10518_ _02597_ _02599_ _02606_ _02615_ VDD VSS OAI22_X2
X_16104_ _02610_ _02613_ _02604_ _02614_ _02615_ _02616_ VDD
+ VSS AOI221_X2
X_16105_ _02574_ _02616_ _01728_ VDD VSS NOR2_X1
X_16106_ _10518_ _10527_ _02617_ VDD VSS NAND2_X1
X_16107_ _02598_ _02617_ _02618_ VDD VSS XOR2_X1
X_16108_ _02601_ _02618_ _02596_ _02619_ VDD VSS MUX2_X1
X_16109_ dynamic_node_top.proc_output.space.count_f\[2\] _02619_
+ _02620_ VDD VSS NAND2_X1
X_16110_ _02604_ _02621_ VDD VSS INV_X1
X_16111_ _02598_ _10529_ _02622_ VDD VSS XNOR2_X1
X_16112_ _02598_ _10527_ _02623_ VDD VSS XNOR2_X1
X_16113_ _02606_ _02622_ _02623_ _10518_ _02624_ VDD VSS AOI22_X1
X_16114_ _02601_ _02621_ _02624_ _02625_ VDD VSS OR3_X1
X_16115_ _02606_ _02598_ _10529_ _02596_ _02626_ VDD VSS NAND4_X1
X_16116_ _06754_ _02626_ _02627_ VDD VSS AND2_X1
X_16117_ _02620_ _02625_ _02627_ _01729_ VDD VSS NAND3_X1
X_16118_ _02616_ _02620_ _02625_ _02627_ _01731_ VDD VSS NAND4_X1
X_16119_ _02605_ _01731_ _01730_ VDD VSS NOR2_X1
X_16120_ _02565_ net744 _01732_ VDD VSS AND2_X1
X_16121_ _02565_ net297 _01733_ VDD VSS AND2_X1
X_16122_ dynamic_node_top.south_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.south_input.NIB.elements_in_array_next\[0\]
+ _10466_ _02628_ VDD VSS MUX2_X1
X_16123_ _02565_ _02628_ _01734_ VDD VSS AND2_X1
X_16124_ _10174_ _10466_ _02629_ VDD VSS NAND2_X1
X_16125_ _02629_ _10466_ dynamic_node_top.south_input.NIB.elements_in_array_f\[1\]
+ _02630_ VDD VSS OAI21_X1
X_16126_ _02574_ _02630_ _01735_ VDD VSS NOR2_X1
X_16127_ _10469_ _10173_ _02631_ VDD VSS XNOR2_X1
X_16128_ _10466_ _02631_ _02632_ VDD VSS NAND2_X1
X_16129_ dynamic_node_top.south_input.NIB.elements_in_array_f\[2\]
+ _02632_ _02633_ VDD VSS XOR2_X1
X_16130_ _02574_ _02633_ _01736_ VDD VSS NOR2_X1
X_16131_ dynamic_node_top.south_input.NIB.head_ptr_f\[0\]
+ dynamic_node_top.south_input.NIB.head_ptr_next\[0\] _02387_
+ _02634_ VDD VSS MUX2_X1
X_16132_ _02565_ _02634_ _01737_ VDD VSS AND2_X1
X_16133_ _10465_ _10467_ _02635_ VDD VSS NOR2_X4
X_16134_ dynamic_node_top.south_input.NIB.tail_ptr_f\[0\]
+ dynamic_node_top.south_input.NIB.tail_ptr_next\[0\] _02635_
+ _02636_ VDD VSS MUX2_X1
X_16135_ _02565_ _02636_ _01994_ VDD VSS AND2_X1
X_16136_ _06880_ _02637_ VDD VSS BUF_X4
X_16137_ dynamic_node_top.south_input.NIB.tail_ptr_f\[1\]
+ dynamic_node_top.south_input.NIB.tail_ptr_next\[1\] _02635_
+ _02638_ VDD VSS MUX2_X1
X_16138_ _02637_ _02638_ _01995_ VDD VSS AND2_X1
X_16139_ _02574_ _10464_ _01996_ VDD VSS NOR2_X1
X_16140_ _06754_ _07173_ _01997_ VDD VSS AND2_X1
X_16141_ _06052_ dynamic_node_top.south_input.control.count_f\[1\]
+ _02639_ VDD VSS NOR2_X1
X_16142_ _02639_ _10516_ _06052_ dynamic_node_top.south_input.control.header_last_temp
+ _05170_ _02640_ VDD VSS AOI221_X1
X_16143_ _02640_ _06060_ _06103_ _02641_ VDD VSS AOI21_X1
X_16144_ _02574_ _02641_ _01998_ VDD VSS NOR2_X1
X_16145_ _06103_ _06064_ _02642_ VDD VSS NAND2_X1
X_16146_ _07175_ _07176_ _02643_ VDD VSS XNOR2_X1
X_16147_ _06096_ _02643_ _02644_ VDD VSS NAND2_X1
X_16148_ _06573_ _02642_ _02644_ _01999_ VDD VSS AOI21_X1
X_16149_ _06096_ _06067_ _02645_ VDD VSS NOR2_X1
X_16150_ _06103_ _07182_ _02646_ VDD VSS NOR2_X1
X_16151_ _02420_ _02645_ _02646_ _02000_ VDD VSS NOR3_X1
X_16152_ _06057_ _02647_ VDD VSS INV_X1
X_16153_ _06573_ _02647_ _07179_ _02001_ VDD VSS NOR3_X1
X_16154_ _02574_ _07198_ _02002_ VDD VSS NOR2_X1
X_16155_ _06589_ _02648_ VDD VSS BUF_X4
X_16156_ _02648_ _07195_ _02003_ VDD VSS NOR2_X1
X_16157_ _02637_ _07191_ _02004_ VDD VSS AND2_X1
X_16158_ _01997_ _02649_ VDD VSS INV_X1
X_16159_ _07187_ _07191_ _07199_ _02649_ _02005_ VDD VSS NOR4_X1
X_16160_ _02648_ _06083_ _02006_ VDD VSS NOR2_X1
X_16161_ _05454_ _06812_ _02650_ VDD VSS AND2_X1
X_16162_ _06818_ _02650_ _02651_ VDD VSS NAND2_X1
X_16163_ _05454_ _06812_ _06818_ _02652_ VDD VSS OR3_X1
X_16164_ _06880_ _02651_ _02652_ _02653_ VDD VSS NAND3_X1
X_16165_ _06865_ _06802_ _06828_ _06881_ _02654_ VDD VSS OR4_X1
X_16166_ _05454_ _05344_ _06856_ _06818_ _02655_ VDD VSS NAND4_X1
X_16167_ _02654_ _02655_ _02656_ VDD VSS NOR2_X1
X_16168_ _05454_ _06813_ _05344_ _06818_ _02657_ VDD VSS AOI22_X1
X_16169_ _05452_ _02650_ _02658_ VDD VSS NAND2_X1
X_16170_ _02658_ _06851_ _06806_ _05338_ net680 _02659_ VDD
+ VSS OAI221_X1
X_16171_ _05330_ _06613_ _06801_ _02660_ VDD VSS NOR3_X1
X_16172_ _02657_ _02659_ _02660_ _02661_ VDD VSS NOR3_X1
X_16173_ _06812_ _06798_ _05331_ _06876_ _05329_ _02662_ VDD
+ VSS OAI221_X1
X_16174_ _02662_ _02654_ _06856_ _02663_ VDD VSS OAI21_X1
X_16175_ _02653_ _02656_ _02661_ _02663_ _02007_ VDD VSS AOI211_X2
X_16176_ _10491_ _02664_ VDD VSS BUF_X2
X_16177_ dynamic_node_top.south_output.space.count_f\[2\]
+ _02664_ _02665_ VDD VSS NAND2_X1
X_16178_ _00059_ _02666_ VDD VSS BUF_X2
X_16179_ _02666_ _02664_ _02667_ VDD VSS NAND2_X1
X_16180_ _10558_ _02665_ _02667_ _10560_ _02668_ VDD VSS OAI22_X1
X_16181_ _10485_ _02669_ VDD VSS BUF_X1
X_16182_ _02669_ _10559_ _10557_ _02670_ VDD VSS NOR3_X1
X_16183_ _02670_ _10489_ _02669_ _02671_ VDD VSS AOI21_X1
X_16184_ _02664_ _02666_ dynamic_node_top.south_output.space.count_f\[2\]
+ _02672_ VDD VSS OAI21_X2
X_16185_ _02668_ _02671_ _02672_ _02673_ VDD VSS AOI21_X1
X_16186_ _02648_ _02673_ _02008_ VDD VSS NOR2_X1
X_16187_ _10487_ _02674_ VDD VSS CLKBUF_X2
X_16188_ _10492_ _02674_ _02666_ _02664_ _02675_ VDD VSS NAND4_X1
X_16189_ _10492_ _02676_ VDD VSS INV_X1
X_16190_ _10484_ _02676_ _02677_ VDD VSS NAND2_X1
X_16191_ _02675_ _02677_ _02665_ _02678_ VDD VSS OAI21_X1
X_16192_ _02674_ _02679_ VDD VSS INV_X1
X_16193_ _02677_ _02679_ _02676_ _02680_ VDD VSS OAI21_X1
X_16194_ _02680_ dynamic_node_top.south_output.space.count_f\[1\]
+ _02669_ _02681_ VDD VSS MUX2_X1
X_16195_ _10490_ _02682_ VDD VSS INV_X1
X_16196_ _10484_ _02665_ _02667_ _02674_ _02683_ VDD VSS OAI22_X2
X_16197_ _02678_ _02681_ _02672_ _02682_ _02683_ _02684_ VDD
+ VSS AOI221_X2
X_16198_ _02648_ _02684_ _02009_ VDD VSS NOR2_X1
X_16199_ _10484_ _10493_ _02685_ VDD VSS NAND2_X1
X_16200_ _02666_ _02685_ _02686_ VDD VSS XOR2_X1
X_16201_ _02669_ _02686_ _02664_ _02687_ VDD VSS MUX2_X1
X_16202_ dynamic_node_top.south_output.space.count_f\[2\]
+ _02687_ _02688_ VDD VSS NAND2_X1
X_16203_ _02672_ _02689_ VDD VSS INV_X1
X_16204_ _02666_ _10495_ _02690_ VDD VSS XNOR2_X1
X_16205_ _02666_ _10493_ _02691_ VDD VSS XNOR2_X1
X_16206_ _02674_ _02690_ _02691_ _10484_ _02692_ VDD VSS AOI22_X1
X_16207_ _02669_ _02689_ _02692_ _02693_ VDD VSS OR3_X1
X_16208_ _02674_ _02666_ _10495_ _02664_ _02694_ VDD VSS NAND4_X1
X_16209_ _06754_ _02694_ _02695_ VDD VSS AND2_X1
X_16210_ _02688_ _02693_ _02695_ _02010_ VDD VSS NAND3_X1
X_16211_ _02684_ _02688_ _02693_ _02695_ _02012_ VDD VSS NAND4_X1
X_16212_ _02673_ _02012_ _02011_ VDD VSS NOR2_X1
X_16213_ _02637_ net1 _02013_ VDD VSS AND2_X1
X_16214_ _02637_ net298 _02014_ VDD VSS AND2_X1
X_16215_ dynamic_node_top.west_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.west_input.NIB.elements_in_array_next\[0\]
+ _10500_ _02696_ VDD VSS MUX2_X1
X_16216_ _02637_ _02696_ _02015_ VDD VSS AND2_X1
X_16217_ _10177_ _10500_ _02697_ VDD VSS NAND2_X1
X_16218_ _02697_ _10500_ dynamic_node_top.west_input.NIB.elements_in_array_f\[1\]
+ _02698_ VDD VSS OAI21_X1
X_16219_ _02648_ _02698_ _02016_ VDD VSS NOR2_X1
X_16220_ _10503_ _10176_ _02699_ VDD VSS XNOR2_X1
X_16221_ _10500_ _02699_ _02700_ VDD VSS NAND2_X1
X_16222_ dynamic_node_top.west_input.NIB.elements_in_array_f\[2\]
+ _02700_ _02701_ VDD VSS XOR2_X1
X_16223_ _02648_ _02701_ _02017_ VDD VSS NOR2_X1
X_16224_ dynamic_node_top.west_input.NIB.head_ptr_f\[0\] dynamic_node_top.west_input.NIB.head_ptr_next\[0\]
+ _02383_ _02702_ VDD VSS MUX2_X1
X_16225_ _02637_ _02702_ _02018_ VDD VSS AND2_X1
X_16226_ _10501_ _10499_ _02703_ VDD VSS NOR2_X2
X_16227_ dynamic_node_top.west_input.NIB.tail_ptr_f\[0\] dynamic_node_top.west_input.NIB.tail_ptr_next\[0\]
+ _02703_ _02704_ VDD VSS MUX2_X1
X_16228_ _02637_ _02704_ _02275_ VDD VSS AND2_X1
X_16229_ dynamic_node_top.west_input.NIB.tail_ptr_f\[1\] dynamic_node_top.west_input.NIB.tail_ptr_next\[1\]
+ _02703_ _02705_ VDD VSS MUX2_X1
X_16230_ _02637_ _02705_ _02276_ VDD VSS AND2_X1
X_16231_ _02648_ _10498_ _02277_ VDD VSS NOR2_X1
X_16232_ _06754_ _07048_ _02278_ VDD VSS AND2_X1
X_16233_ _05818_ dynamic_node_top.west_input.control.count_f\[1\]
+ _02706_ VDD VSS NOR2_X1
X_16234_ _02706_ _10482_ _05818_ dynamic_node_top.west_input.control.header_last_temp
+ _05175_ _02707_ VDD VSS AOI221_X1
X_16235_ _02707_ _05796_ _06701_ _02708_ VDD VSS AOI21_X1
X_16236_ _02648_ _02708_ _02279_ VDD VSS NOR2_X1
X_16237_ _06613_ _05799_ _02709_ VDD VSS NOR2_X1
X_16238_ _07049_ _07050_ _02710_ VDD VSS XNOR2_X1
X_16239_ _06701_ _02710_ _02711_ VDD VSS NOR2_X1
X_16240_ _06573_ _02709_ _02711_ _02280_ VDD VSS NOR3_X1
X_16241_ _06613_ _05802_ _02712_ VDD VSS NOR2_X1
X_16242_ _06701_ _07056_ _02713_ VDD VSS NOR2_X1
X_16243_ _06573_ _02712_ _02713_ _02281_ VDD VSS NOR3_X1
X_16244_ _06573_ _05793_ _07053_ _02282_ VDD VSS NOR3_X1
X_16245_ _02648_ _07072_ _02283_ VDD VSS NOR2_X1
X_16246_ _02648_ _07069_ _02284_ VDD VSS NOR2_X1
X_16247_ _02637_ _07065_ _02285_ VDD VSS AND2_X1
X_16248_ _02278_ _02714_ VDD VSS INV_X1
X_16249_ _07061_ _07065_ _07073_ _02714_ _02286_ VDD VSS NOR4_X1
X_16250_ _02420_ _06713_ _02287_ VDD VSS NOR2_X1
X_16251_ _06755_ dynamic_node_top.west_output.control.planned_f
+ _06605_ _02715_ VDD VSS NAND3_X1
X_16252_ _05487_ _05590_ _06605_ _02716_ VDD VSS OR3_X1
X_16253_ _06618_ _06697_ _06778_ _02716_ _02717_ VDD VSS NOR4_X1
X_16254_ _00052_ _06581_ _02718_ VDD VSS NAND2_X1
X_16255_ dynamic_node_top.west_output.control.planned_f _02717_
+ _02718_ _02719_ VDD VSS OR3_X1
X_16256_ _06609_ _05185_ _06615_ _06617_ _02720_ VDD VSS AOI211_X2
X_16257_ _05478_ _06636_ _06659_ _05470_ _05481_ _05590_ _02721_
+ VDD VSS OAI222_X2
X_16258_ _02720_ _02721_ _02722_ VDD VSS OR2_X1
X_16259_ dynamic_node_top.west_output.control.planned_f _06687_
+ _05484_ _02723_ VDD VSS OAI21_X1
X_16260_ _06707_ _06636_ _06687_ _06690_ _02724_ VDD VSS NAND4_X2
X_16261_ _02722_ _02723_ _02724_ _02725_ VDD VSS AOI21_X1
X_16262_ _00052_ _06572_ _06605_ _02726_ VDD VSS OR3_X1
X_16263_ _05487_ _02722_ _02723_ _02724_ _02727_ VDD VSS AOI211_X2
X_16264_ _02715_ _02719_ _02725_ _02726_ _02727_ _02288_ VDD
+ VSS OAI221_X1
X_16265_ _10450_ _02728_ VDD VSS BUF_X2
X_16266_ dynamic_node_top.west_output.space.count_f\[2\] _02728_
+ _02729_ VDD VSS NAND2_X1
X_16267_ _00058_ _02730_ VDD VSS BUF_X2
X_16268_ _02730_ _02728_ _02731_ VDD VSS NAND2_X1
X_16269_ _10550_ _02729_ _02731_ _10552_ _02732_ VDD VSS OAI22_X1
X_16270_ _10444_ _02733_ VDD VSS BUF_X1
X_16271_ _02733_ _10551_ _10549_ _02734_ VDD VSS NOR3_X1
X_16272_ _02734_ _10448_ _02733_ _02735_ VDD VSS AOI21_X1
X_16273_ _02728_ _02730_ dynamic_node_top.west_output.space.count_f\[2\]
+ _02736_ VDD VSS OAI21_X2
X_16274_ _02732_ _02735_ _02736_ _02737_ VDD VSS AOI21_X1
X_16275_ _02420_ _02737_ _02289_ VDD VSS NOR2_X1
X_16276_ _10446_ _02738_ VDD VSS CLKBUF_X2
X_16277_ _10451_ _02738_ _02730_ _02728_ _02739_ VDD VSS NAND4_X1
X_16278_ _10451_ _02740_ VDD VSS INV_X1
X_16279_ _10443_ _02740_ _02741_ VDD VSS NAND2_X1
X_16280_ _02739_ _02741_ _02729_ _02742_ VDD VSS OAI21_X1
X_16281_ _02738_ _02743_ VDD VSS INV_X1
X_16282_ _02741_ _02743_ _02740_ _02744_ VDD VSS OAI21_X1
X_16283_ _02744_ dynamic_node_top.west_output.space.count_f\[1\]
+ _02733_ _02745_ VDD VSS MUX2_X1
X_16284_ _10449_ _02746_ VDD VSS INV_X1
X_16285_ _10443_ _02729_ _02731_ _02738_ _02747_ VDD VSS OAI22_X2
X_16286_ _02742_ _02745_ _02736_ _02746_ _02747_ _02748_ VDD
+ VSS AOI221_X2
X_16287_ _02420_ _02748_ _02290_ VDD VSS NOR2_X1
X_16288_ _10443_ _10452_ _02749_ VDD VSS NAND2_X1
X_16289_ _02730_ _02749_ _02750_ VDD VSS XOR2_X1
X_16290_ _02733_ _02750_ _02728_ _02751_ VDD VSS MUX2_X1
X_16291_ dynamic_node_top.west_output.space.count_f\[2\] _02751_
+ _02752_ VDD VSS NAND2_X1
X_16292_ _02736_ _02753_ VDD VSS INV_X1
X_16293_ _02730_ _10454_ _02754_ VDD VSS XNOR2_X1
X_16294_ _02730_ _10452_ _02755_ VDD VSS XNOR2_X1
X_16295_ _02738_ _02754_ _02755_ _10443_ _02756_ VDD VSS AOI22_X1
X_16296_ _02733_ _02753_ _02756_ _02757_ VDD VSS OR3_X1
X_16297_ _02738_ _02730_ _10454_ _02728_ _02758_ VDD VSS NAND4_X1
X_16298_ _06754_ _02758_ _02759_ VDD VSS AND2_X1
X_16299_ _02752_ _02757_ _02759_ _02291_ VDD VSS NAND3_X1
X_16300_ _02748_ _02752_ _02757_ _02759_ _02293_ VDD VSS NAND4_X1
X_16301_ _02737_ _02293_ _02292_ VDD VSS NOR2_X1
X_16302_ _02637_ net756 _02294_ VDD VSS AND2_X1
X_16303_ _06755_ net299 _02295_ VDD VSS AND2_X1
X_16304_ _05163_ _02760_ VDD VSS BUF_X4
X_16305_ _06960_ _02761_ VDD VSS BUF_X4
X_16306_ _05468_ _02762_ VDD VSS BUF_X2
X_16307_ _07286_ _02763_ VDD VSS BUF_X4
X_16308_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[0\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[0\] _02763_
+ _02764_ VDD VSS MUX2_X1
X_16309_ _02762_ _02764_ _02765_ VDD VSS OR2_X1
X_16310_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[0\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[0\] _07523_
+ _02766_ VDD VSS MUX2_X1
X_16311_ _07525_ _02767_ VDD VSS BUF_X8
X_16312_ _02765_ _02766_ _02767_ _02768_ VDD VSS OAI21_X4
X_16313_ _07244_ _02769_ VDD VSS BUF_X8
X_16314_ net743 _02770_ VDD VSS BUF_X4
X_16315_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[0\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[0\]
+ _02770_ _02771_ VDD VSS MUX2_X1
X_16316_ _02771_ _02772_ VDD VSS INV_X1
X_16317_ _02769_ _02772_ _02773_ VDD VSS NAND2_X1
X_16318_ net745 _02774_ VDD VSS BUF_X4
X_16319_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[0\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[0\]
+ _02774_ _02775_ VDD VSS MUX2_X1
X_16320_ _07244_ _02776_ VDD VSS BUF_X4
X_16321_ _02773_ _02775_ _02776_ _02777_ VDD VSS OAI21_X4
X_16322_ _00074_ _02778_ VDD VSS BUF_X4
X_16323_ _02778_ _02779_ VDD VSS BUF_X4
X_16324_ _02779_ _02780_ VDD VSS BUF_X4
X_16325_ _02761_ _02768_ _02777_ _02780_ _02781_ VDD VSS OAI22_X1
X_16326_ _05156_ _02782_ VDD VSS BUF_X4
X_16327_ _02782_ _02783_ VDD VSS BUF_X4
X_16328_ _07268_ _02784_ VDD VSS BUF_X2
X_16329_ _07273_ _02785_ VDD VSS BUF_X4
X_16330_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[0\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[0\] _02785_
+ _02786_ VDD VSS MUX2_X1
X_16331_ _02784_ _02786_ _02787_ VDD VSS OR2_X1
X_16332_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[0\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[0\] _07440_
+ _02788_ VDD VSS MUX2_X1
X_16333_ _07445_ _02789_ VDD VSS BUF_X8
X_16334_ _02787_ _02788_ _02789_ _02790_ VDD VSS OAI21_X4
X_16335_ _05321_ _02791_ VDD VSS CLKBUF_X3
X_16336_ _05314_ _02792_ VDD VSS BUF_X4
X_16337_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[0\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[0\]
+ _02792_ _02793_ VDD VSS MUX2_X1
X_16338_ _02791_ _02793_ _02794_ VDD VSS OR2_X1
X_16339_ _05315_ _02795_ VDD VSS BUF_X4
X_16340_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[0\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[0\]
+ _02795_ _02796_ VDD VSS MUX2_X1
X_16341_ _05326_ _02797_ VDD VSS BUF_X8
X_16342_ _02794_ _02796_ _02797_ _02798_ VDD VSS OAI21_X4
X_16343_ _00075_ _02799_ VDD VSS BUF_X4
X_16344_ _02799_ _02800_ VDD VSS BUF_X4
X_16345_ _02800_ _02801_ VDD VSS BUF_X4
X_16346_ _02783_ _02790_ _02798_ _02801_ _02802_ VDD VSS OAI22_X1
X_16347_ _00076_ _02803_ VDD VSS BUF_X4
X_16348_ _02803_ _02804_ VDD VSS CLKBUF_X3
X_16349_ _05977_ _02805_ VDD VSS BUF_X8
X_16350_ _07130_ _02806_ VDD VSS BUF_X4
X_16351_ _05702_ _02807_ VDD VSS BUF_X8
X_16352_ _02807_ _02808_ VDD VSS BUF_X4
X_16353_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[0\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[0\]
+ _02808_ _02809_ VDD VSS MUX2_X1
X_16354_ _02807_ _02810_ VDD VSS BUF_X4
X_16355_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[0\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[0\]
+ _02810_ _02811_ VDD VSS MUX2_X1
X_16356_ _05710_ _02812_ VDD VSS BUF_X4
X_16357_ _02809_ _02811_ _02812_ _02813_ VDD VSS MUX2_X1
X_16358_ _02806_ _02813_ _02814_ VDD VSS NAND2_X1
X_16359_ _05720_ _02815_ VDD VSS BUF_X4
X_16360_ _02807_ _02816_ VDD VSS BUF_X4
X_16361_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[0\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[0\] _02816_
+ _02817_ VDD VSS MUX2_X1
X_16362_ _02807_ _02818_ VDD VSS BUF_X4
X_16363_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[0\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[0\] _02818_
+ _02819_ VDD VSS MUX2_X1
X_16364_ _05710_ _02820_ VDD VSS BUF_X4
X_16365_ _02817_ _02819_ _02820_ _02821_ VDD VSS MUX2_X1
X_16366_ _02815_ _02821_ _02822_ VDD VSS NAND2_X1
X_16367_ _02805_ _02814_ _02822_ _02823_ VDD VSS NAND3_X2
X_16368_ _05702_ _02824_ VDD VSS BUF_X4
X_16369_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[0\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[0\]
+ _02824_ _02825_ VDD VSS MUX2_X1
X_16370_ _05702_ _02826_ VDD VSS BUF_X4
X_16371_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[0\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[0\]
+ _02826_ _02827_ VDD VSS MUX2_X1
X_16372_ _05709_ _02828_ VDD VSS BUF_X4
X_16373_ _02825_ _02827_ _02828_ _02829_ VDD VSS MUX2_X1
X_16374_ _05702_ _02830_ VDD VSS BUF_X4
X_16375_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[0\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[0\] _02830_
+ _02831_ VDD VSS MUX2_X1
X_16376_ _02807_ _02832_ VDD VSS BUF_X8
X_16377_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[0\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[0\] _02832_
+ _02833_ VDD VSS MUX2_X1
X_16378_ _05709_ _02834_ VDD VSS BUF_X4
X_16379_ _02831_ _02833_ _02834_ _02835_ VDD VSS MUX2_X1
X_16380_ _05720_ _02836_ VDD VSS BUF_X4
X_16381_ _02829_ _02835_ _02836_ _02837_ VDD VSS MUX2_X1
X_16382_ _05977_ _02838_ VDD VSS BUF_X4
X_16383_ _02838_ _02839_ VDD VSS BUF_X8
X_16384_ _02823_ _02837_ _02839_ _02840_ VDD VSS OAI21_X4
X_16385_ _02804_ _02840_ _02841_ VDD VSS NOR2_X1
X_16386_ _02781_ _02802_ _02841_ _02842_ VDD VSS NOR3_X1
X_16387_ _02760_ _02842_ net300 VDD VSS NOR2_X2
X_16388_ _05163_ _02843_ VDD VSS BUF_X8
X_16389_ _02779_ _02844_ VDD VSS BUF_X4
X_16390_ _07244_ _02845_ VDD VSS BUF_X4
X_16391_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[10\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[10\]
+ _07246_ _02846_ VDD VSS MUX2_X1
X_16392_ _02846_ _02847_ VDD VSS INV_X1
X_16393_ _02845_ _02847_ _02848_ VDD VSS NAND2_X1
X_16394_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[10\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[10\]
+ _07250_ _02849_ VDD VSS MUX2_X1
X_16395_ _02848_ _02849_ _07244_ _02850_ VDD VSS OAI21_X4
X_16396_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[10\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[10\]
+ _07520_ _02851_ VDD VSS MUX2_X1
X_16397_ _07519_ _02851_ _02852_ VDD VSS OR2_X1
X_16398_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[10\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[10\]
+ _07523_ _02853_ VDD VSS MUX2_X1
X_16399_ _02852_ _02853_ _07526_ _02854_ VDD VSS OAI21_X4
X_16400_ _06960_ _02855_ VDD VSS BUF_X4
X_16401_ _02844_ _02850_ _02854_ _02855_ _02856_ VDD VSS OAI22_X1
X_16402_ _02782_ _02857_ VDD VSS BUF_X4
X_16403_ _07268_ _02858_ VDD VSS BUF_X2
X_16404_ _07273_ _02859_ VDD VSS BUF_X4
X_16405_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[10\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[10\]
+ _02859_ _02860_ VDD VSS MUX2_X1
X_16406_ _02858_ _02860_ _02861_ VDD VSS OR2_X1
X_16407_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[10\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[10\]
+ _07443_ _02862_ VDD VSS MUX2_X1
X_16408_ _07445_ _02863_ VDD VSS BUF_X8
X_16409_ _02861_ _02862_ _02863_ _02864_ VDD VSS OAI21_X4
X_16410_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[10\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[10\]
+ _07494_ _02865_ VDD VSS MUX2_X1
X_16411_ _07493_ _02865_ _02866_ VDD VSS OR2_X1
X_16412_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[10\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[10\]
+ _07497_ _02867_ VDD VSS MUX2_X1
X_16413_ _02866_ _02867_ _07499_ _02868_ VDD VSS OAI21_X2
X_16414_ _02800_ _02869_ VDD VSS BUF_X4
X_16415_ _02857_ _02864_ _02868_ _02869_ _02870_ VDD VSS OAI22_X1
X_16416_ _02856_ _02870_ _02871_ VDD VSS NOR2_X1
X_16417_ _02803_ _02872_ VDD VSS INV_X1
X_16418_ _02872_ _02873_ VDD VSS CLKBUF_X3
X_16419_ _02873_ _02874_ VDD VSS BUF_X4
X_16420_ _02807_ _02875_ VDD VSS BUF_X4
X_16421_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[10\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[10\]
+ _02875_ _02876_ VDD VSS MUX2_X1
X_16422_ _02807_ _02877_ VDD VSS BUF_X4
X_16423_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[10\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[10\]
+ _02877_ _02878_ VDD VSS MUX2_X1
X_16424_ _05710_ _02879_ VDD VSS BUF_X4
X_16425_ _02876_ _02878_ _02879_ _02880_ VDD VSS MUX2_X1
X_16426_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[10\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[10\]
+ _02877_ _02881_ VDD VSS MUX2_X1
X_16427_ _05703_ _02882_ VDD VSS BUF_X4
X_16428_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[10\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[10\]
+ _02882_ _02883_ VDD VSS MUX2_X1
X_16429_ _02881_ _02883_ _02879_ _02884_ VDD VSS MUX2_X1
X_16430_ _05720_ _02885_ VDD VSS BUF_X4
X_16431_ _02880_ _02884_ _02885_ _02886_ VDD VSS MUX2_X1
X_16432_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[10\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[10\]
+ _02882_ _02887_ VDD VSS MUX2_X1
X_16433_ _05703_ _02888_ VDD VSS BUF_X4
X_16434_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[10\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[10\]
+ _02888_ _02889_ VDD VSS MUX2_X1
X_16435_ _05710_ _02890_ VDD VSS BUF_X4
X_16436_ _02887_ _02889_ _02890_ _02891_ VDD VSS MUX2_X1
X_16437_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[10\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[10\]
+ _02888_ _02892_ VDD VSS MUX2_X1
X_16438_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[10\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[10\]
+ _02888_ _02893_ VDD VSS MUX2_X1
X_16439_ _02892_ _02893_ _05711_ _02894_ VDD VSS MUX2_X1
X_16440_ _02891_ _02894_ _05721_ _02895_ VDD VSS MUX2_X1
X_16441_ _02886_ _02895_ _07393_ _02896_ VDD VSS MUX2_X2
X_16442_ _02874_ _02896_ _02897_ VDD VSS NAND2_X1
X_16443_ _02843_ _02871_ _02897_ net301 VDD VSS AOI21_X2
X_16444_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[11\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[11\]
+ _02763_ _02898_ VDD VSS MUX2_X1
X_16445_ _07519_ _02898_ _02899_ VDD VSS OR2_X1
X_16446_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[11\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[11\]
+ _07523_ _02900_ VDD VSS MUX2_X1
X_16447_ _02899_ _02900_ _07526_ _02901_ VDD VSS OAI21_X4
X_16448_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[11\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[11\]
+ _02859_ _02902_ VDD VSS MUX2_X1
X_16449_ _02858_ _02902_ _02903_ VDD VSS OR2_X1
X_16450_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[11\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[11\]
+ _07443_ _02904_ VDD VSS MUX2_X1
X_16451_ _02903_ _02904_ _07446_ _02905_ VDD VSS OAI21_X4
X_16452_ _02782_ _02906_ VDD VSS BUF_X4
X_16453_ _02761_ _02901_ _02905_ _02906_ _02907_ VDD VSS OAI22_X2
X_16454_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[11\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[11\]
+ _07246_ _02908_ VDD VSS MUX2_X1
X_16455_ _02908_ _02909_ VDD VSS INV_X1
X_16456_ _02845_ _02909_ _02910_ VDD VSS NAND2_X1
X_16457_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[11\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[11\]
+ _07250_ _02911_ VDD VSS MUX2_X1
X_16458_ _02910_ _02911_ _07244_ _02912_ VDD VSS OAI21_X4
X_16459_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[11\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[11\]
+ _02792_ _02913_ VDD VSS MUX2_X1
X_16460_ _07493_ _02913_ _02914_ VDD VSS OR2_X1
X_16461_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[11\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[11\]
+ _07497_ _02915_ VDD VSS MUX2_X1
X_16462_ _02914_ _02915_ _07499_ _02916_ VDD VSS OAI21_X4
X_16463_ _02844_ _02912_ _02916_ _02869_ _02917_ VDD VSS OAI22_X2
X_16464_ _02907_ _02917_ _02918_ VDD VSS NOR2_X2
X_16465_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[11\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[11\]
+ _02810_ _02919_ VDD VSS MUX2_X1
X_16466_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[11\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[11\]
+ _02877_ _02920_ VDD VSS MUX2_X1
X_16467_ _02919_ _02920_ _02879_ _02921_ VDD VSS MUX2_X1
X_16468_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[11\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[11\]
+ _02877_ _02922_ VDD VSS MUX2_X1
X_16469_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[11\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[11\]
+ _02882_ _02923_ VDD VSS MUX2_X1
X_16470_ _02922_ _02923_ _02879_ _02924_ VDD VSS MUX2_X1
X_16471_ _02921_ _02924_ _02885_ _02925_ VDD VSS MUX2_X1
X_16472_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[11\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[11\]
+ _02882_ _02926_ VDD VSS MUX2_X1
X_16473_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[11\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[11\]
+ _02888_ _02927_ VDD VSS MUX2_X1
X_16474_ _02926_ _02927_ _02890_ _02928_ VDD VSS MUX2_X1
X_16475_ _05703_ _02929_ VDD VSS BUF_X4
X_16476_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[11\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[11\]
+ _02929_ _02930_ VDD VSS MUX2_X1
X_16477_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[11\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[11\]
+ _02888_ _02931_ VDD VSS MUX2_X1
X_16478_ _02930_ _02931_ _05711_ _02932_ VDD VSS MUX2_X1
X_16479_ _02928_ _02932_ _02885_ _02933_ VDD VSS MUX2_X1
X_16480_ _02925_ _02933_ _07393_ _02934_ VDD VSS MUX2_X2
X_16481_ _02874_ _02934_ _02935_ VDD VSS NAND2_X1
X_16482_ _02843_ _02918_ _02935_ net302 VDD VSS AOI21_X4
X_16483_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[12\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[12\]
+ _02763_ _02936_ VDD VSS MUX2_X1
X_16484_ _02762_ _02936_ _02937_ VDD VSS OR2_X1
X_16485_ net721 _02938_ VDD VSS BUF_X4
X_16486_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[12\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[12\]
+ _02938_ _02939_ VDD VSS MUX2_X1
X_16487_ _02937_ _02939_ _02767_ _02940_ VDD VSS OAI21_X4
X_16488_ _07244_ _02941_ VDD VSS BUF_X4
X_16489_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[12\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[12\]
+ _02770_ _02942_ VDD VSS MUX2_X1
X_16490_ _02942_ _02943_ VDD VSS INV_X1
X_16491_ _02941_ _02943_ _02944_ VDD VSS NAND2_X1
X_16492_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[12\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[12\]
+ _02774_ _02945_ VDD VSS MUX2_X1
X_16493_ _02944_ _02945_ _02769_ _02946_ VDD VSS OAI21_X4
X_16494_ _02761_ _02940_ _02946_ _02780_ _02947_ VDD VSS OAI22_X1
X_16495_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[12\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[12\]
+ _02785_ _02948_ VDD VSS MUX2_X1
X_16496_ _02784_ _02948_ _02949_ VDD VSS OR2_X1
X_16497_ _05147_ _02950_ VDD VSS BUF_X4
X_16498_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[12\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[12\]
+ _02950_ _02951_ VDD VSS MUX2_X1
X_16499_ _02949_ _02951_ _02789_ _02952_ VDD VSS OAI21_X4
X_16500_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[12\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[12\]
+ _02792_ _02953_ VDD VSS MUX2_X1
X_16501_ _02791_ _02953_ _02954_ VDD VSS OR2_X1
X_16502_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[12\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[12\]
+ _02795_ _02955_ VDD VSS MUX2_X1
X_16503_ _02954_ _02955_ _02797_ _02956_ VDD VSS OAI21_X4
X_16504_ _02783_ _02952_ _02956_ _02801_ _02957_ VDD VSS OAI22_X1
X_16505_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[12\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[12\]
+ _02808_ _02958_ VDD VSS MUX2_X1
X_16506_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[12\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[12\]
+ _02810_ _02959_ VDD VSS MUX2_X1
X_16507_ _02958_ _02959_ _02812_ _02960_ VDD VSS MUX2_X1
X_16508_ _02806_ _02960_ _02961_ VDD VSS NAND2_X1
X_16509_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[12\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[12\]
+ _02816_ _02962_ VDD VSS MUX2_X1
X_16510_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[12\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[12\]
+ _02818_ _02963_ VDD VSS MUX2_X1
X_16511_ _02962_ _02963_ _02820_ _02964_ VDD VSS MUX2_X1
X_16512_ _02815_ _02964_ _02965_ VDD VSS NAND2_X1
X_16513_ _02805_ _02961_ _02965_ _02966_ VDD VSS NAND3_X2
X_16514_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[12\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[12\]
+ _02824_ _02967_ VDD VSS MUX2_X1
X_16515_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[12\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[12\]
+ _02826_ _02968_ VDD VSS MUX2_X1
X_16516_ _02967_ _02968_ _02828_ _02969_ VDD VSS MUX2_X1
X_16517_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[12\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[12\]
+ _02830_ _02970_ VDD VSS MUX2_X1
X_16518_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[12\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[12\]
+ _02832_ _02971_ VDD VSS MUX2_X1
X_16519_ _02970_ _02971_ _02834_ _02972_ VDD VSS MUX2_X1
X_16520_ _02969_ _02972_ _02836_ _02973_ VDD VSS MUX2_X1
X_16521_ _02966_ _02973_ _02839_ _02974_ VDD VSS OAI21_X4
X_16522_ _02804_ _02974_ _02975_ VDD VSS NOR2_X1
X_16523_ _02947_ _02957_ _02975_ _02976_ VDD VSS NOR3_X1
X_16524_ _02760_ _02976_ net303 VDD VSS NOR2_X2
X_16525_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[13\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[13\]
+ _02770_ _02977_ VDD VSS MUX2_X1
X_16526_ _02977_ _02978_ VDD VSS INV_X1
X_16527_ _02845_ _02978_ _02979_ VDD VSS NAND2_X1
X_16528_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[13\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[13\]
+ _07250_ _02980_ VDD VSS MUX2_X1
X_16529_ _02979_ _02980_ _07244_ _02981_ VDD VSS OAI21_X4
X_16530_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[13\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[13\]
+ _07520_ _02982_ VDD VSS MUX2_X1
X_16531_ _07519_ _02982_ _02983_ VDD VSS OR2_X1
X_16532_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[13\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[13\]
+ _07523_ _02984_ VDD VSS MUX2_X1
X_16533_ _02983_ _02984_ _07526_ _02985_ VDD VSS OAI21_X4
X_16534_ _02844_ _02981_ _02985_ _02855_ _02986_ VDD VSS OAI22_X1
X_16535_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[13\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[13\]
+ _02859_ _02987_ VDD VSS MUX2_X1
X_16536_ _02858_ _02987_ _02988_ VDD VSS OR2_X1
X_16537_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[13\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[13\]
+ _07443_ _02989_ VDD VSS MUX2_X1
X_16538_ _02988_ _02989_ _02863_ _02990_ VDD VSS OAI21_X4
X_16539_ _05321_ _02991_ VDD VSS CLKBUF_X3
X_16540_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[13\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[13\]
+ _02792_ _02992_ VDD VSS MUX2_X1
X_16541_ _02991_ _02992_ _02993_ VDD VSS OR2_X1
X_16542_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[13\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[13\]
+ _07497_ _02994_ VDD VSS MUX2_X1
X_16543_ _07499_ _02995_ VDD VSS BUF_X8
X_16544_ _02993_ _02994_ _02995_ _02996_ VDD VSS OAI21_X2
X_16545_ _02857_ _02990_ _02996_ _02869_ _02997_ VDD VSS OAI22_X1
X_16546_ _02986_ _02997_ _02998_ VDD VSS NOR2_X1
X_16547_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[13\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[13\]
+ _02810_ _02999_ VDD VSS MUX2_X1
X_16548_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[13\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[13\]
+ _02877_ _03000_ VDD VSS MUX2_X1
X_16549_ _02999_ _03000_ _02879_ _03001_ VDD VSS MUX2_X1
X_16550_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[13\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[13\]
+ _02875_ _03002_ VDD VSS MUX2_X1
X_16551_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[13\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[13\]
+ _02882_ _03003_ VDD VSS MUX2_X1
X_16552_ _03002_ _03003_ _02879_ _03004_ VDD VSS MUX2_X1
X_16553_ _03001_ _03004_ _02885_ _03005_ VDD VSS MUX2_X1
X_16554_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[13\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[13\]
+ _02877_ _03006_ VDD VSS MUX2_X1
X_16555_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[13\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[13\]
+ _02929_ _03007_ VDD VSS MUX2_X1
X_16556_ _03006_ _03007_ _02890_ _03008_ VDD VSS MUX2_X1
X_16557_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[13\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[13\]
+ _02929_ _03009_ VDD VSS MUX2_X1
X_16558_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[13\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[13\]
+ _02888_ _03010_ VDD VSS MUX2_X1
X_16559_ _03009_ _03010_ _05711_ _03011_ VDD VSS MUX2_X1
X_16560_ _03008_ _03011_ _02885_ _03012_ VDD VSS MUX2_X1
X_16561_ _03005_ _03012_ _07393_ _03013_ VDD VSS MUX2_X2
X_16562_ _02874_ _03013_ _03014_ VDD VSS NAND2_X1
X_16563_ _02843_ _02998_ _03014_ net304 VDD VSS AOI21_X2
X_16564_ _06960_ _03015_ VDD VSS CLKBUF_X3
X_16565_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[14\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[14\]
+ _02763_ _03016_ VDD VSS MUX2_X1
X_16566_ _02762_ _03016_ _03017_ VDD VSS OR2_X1
X_16567_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[14\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[14\]
+ _02938_ _03018_ VDD VSS MUX2_X1
X_16568_ _03017_ _03018_ _02767_ _03019_ VDD VSS OAI21_X4
X_16569_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[14\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[14\]
+ _02770_ _03020_ VDD VSS MUX2_X1
X_16570_ _03020_ _03021_ VDD VSS INV_X1
X_16571_ _02769_ _03021_ _03022_ VDD VSS NAND2_X1
X_16572_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[14\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[14\]
+ _02774_ _03023_ VDD VSS MUX2_X1
X_16573_ _03022_ _03023_ _02776_ _03024_ VDD VSS OAI21_X4
X_16574_ _02778_ _03025_ VDD VSS BUF_X4
X_16575_ _03015_ _03019_ _03024_ _03025_ _03026_ VDD VSS OAI22_X1
X_16576_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[14\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[14\]
+ _02785_ _03027_ VDD VSS MUX2_X1
X_16577_ _02784_ _03027_ _03028_ VDD VSS OR2_X1
X_16578_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[14\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[14\]
+ _07440_ _03029_ VDD VSS MUX2_X1
X_16579_ _03028_ _03029_ _02789_ _03030_ VDD VSS OAI21_X4
X_16580_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[14\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[14\]
+ _02792_ _03031_ VDD VSS MUX2_X1
X_16581_ _02791_ _03031_ _03032_ VDD VSS OR2_X1
X_16582_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[14\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[14\]
+ _02795_ _03033_ VDD VSS MUX2_X1
X_16583_ _03032_ _03033_ _02797_ _03034_ VDD VSS OAI21_X4
X_16584_ _02783_ _03030_ _03034_ _02801_ _03035_ VDD VSS OAI22_X1
X_16585_ _05977_ _03036_ VDD VSS BUF_X4
X_16586_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[14\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[14\]
+ _02808_ _03037_ VDD VSS MUX2_X1
X_16587_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[14\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[14\]
+ _02810_ _03038_ VDD VSS MUX2_X1
X_16588_ _03037_ _03038_ _02812_ _03039_ VDD VSS MUX2_X1
X_16589_ _02806_ _03039_ _03040_ VDD VSS NAND2_X1
X_16590_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[14\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[14\]
+ _02816_ _03041_ VDD VSS MUX2_X1
X_16591_ _02807_ _03042_ VDD VSS BUF_X4
X_16592_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[14\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[14\]
+ _03042_ _03043_ VDD VSS MUX2_X1
X_16593_ _03041_ _03043_ _02820_ _03044_ VDD VSS MUX2_X1
X_16594_ _02815_ _03044_ _03045_ VDD VSS NAND2_X1
X_16595_ _03036_ _03040_ _03045_ _03046_ VDD VSS NAND3_X2
X_16596_ _05702_ _03047_ VDD VSS BUF_X4
X_16597_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[14\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[14\]
+ _03047_ _03048_ VDD VSS MUX2_X1
X_16598_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[14\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[14\]
+ _02826_ _03049_ VDD VSS MUX2_X1
X_16599_ _03048_ _03049_ _02828_ _03050_ VDD VSS MUX2_X1
X_16600_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[14\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[14\]
+ _02830_ _03051_ VDD VSS MUX2_X1
X_16601_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[14\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[14\]
+ _02832_ _03052_ VDD VSS MUX2_X1
X_16602_ _03051_ _03052_ _02834_ _03053_ VDD VSS MUX2_X1
X_16603_ _03050_ _03053_ _02836_ _03054_ VDD VSS MUX2_X1
X_16604_ _03046_ _03054_ _02839_ _03055_ VDD VSS OAI21_X4
X_16605_ _02804_ _03055_ _03056_ VDD VSS NOR2_X1
X_16606_ _03026_ _03035_ _03056_ _03057_ VDD VSS NOR3_X1
X_16607_ _02760_ _03057_ net305 VDD VSS NOR2_X2
X_16608_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[15\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[15\]
+ _02763_ _03058_ VDD VSS MUX2_X1
X_16609_ _02762_ _03058_ _03059_ VDD VSS OR2_X1
X_16610_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[15\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[15\]
+ _02938_ _03060_ VDD VSS MUX2_X1
X_16611_ _03059_ _03060_ _02767_ _03061_ VDD VSS OAI21_X4
X_16612_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[15\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[15\]
+ _02859_ _03062_ VDD VSS MUX2_X1
X_16613_ _02858_ _03062_ _03063_ VDD VSS OR2_X1
X_16614_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[15\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[15\]
+ _02950_ _03064_ VDD VSS MUX2_X1
X_16615_ _03063_ _03064_ _02863_ _03065_ VDD VSS OAI21_X4
X_16616_ _02782_ _03066_ VDD VSS BUF_X4
X_16617_ _03015_ _03061_ _03065_ _03066_ _03067_ VDD VSS OAI22_X1
X_16618_ net743 _03068_ VDD VSS BUF_X4
X_16619_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[15\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[15\]
+ _03068_ _03069_ VDD VSS MUX2_X1
X_16620_ _03069_ _03070_ VDD VSS INV_X1
X_16621_ _02941_ _03070_ _03071_ VDD VSS NAND2_X1
X_16622_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[15\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[15\]
+ _07246_ _03072_ VDD VSS MUX2_X1
X_16623_ _03071_ _03072_ _02769_ _03073_ VDD VSS OAI21_X4
X_16624_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[15\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[15\]
+ _02792_ _03074_ VDD VSS MUX2_X1
X_16625_ _02791_ _03074_ _03075_ VDD VSS OR2_X1
X_16626_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[15\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[15\]
+ _02795_ _03076_ VDD VSS MUX2_X1
X_16627_ _03075_ _03076_ _02797_ _03077_ VDD VSS OAI21_X4
X_16628_ _02780_ _03073_ _03077_ _02801_ _03078_ VDD VSS OAI22_X1
X_16629_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[15\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[15\]
+ _02808_ _03079_ VDD VSS MUX2_X1
X_16630_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[15\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[15\]
+ _02810_ _03080_ VDD VSS MUX2_X1
X_16631_ _03079_ _03080_ _02812_ _03081_ VDD VSS MUX2_X1
X_16632_ _02806_ _03081_ _03082_ VDD VSS NAND2_X1
X_16633_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[15\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[15\]
+ _02816_ _03083_ VDD VSS MUX2_X1
X_16634_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[15\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[15\]
+ _03042_ _03084_ VDD VSS MUX2_X1
X_16635_ _03083_ _03084_ _02820_ _03085_ VDD VSS MUX2_X1
X_16636_ _02815_ _03085_ _03086_ VDD VSS NAND2_X1
X_16637_ _03036_ _03082_ _03086_ _03087_ VDD VSS NAND3_X2
X_16638_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[15\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[15\]
+ _03047_ _03088_ VDD VSS MUX2_X1
X_16639_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[15\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[15\]
+ _02826_ _03089_ VDD VSS MUX2_X1
X_16640_ _03088_ _03089_ _02828_ _03090_ VDD VSS MUX2_X1
X_16641_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[15\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[15\]
+ _02830_ _03091_ VDD VSS MUX2_X1
X_16642_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[15\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[15\]
+ _02832_ _03092_ VDD VSS MUX2_X1
X_16643_ _03091_ _03092_ _02834_ _03093_ VDD VSS MUX2_X1
X_16644_ _03090_ _03093_ _02836_ _03094_ VDD VSS MUX2_X1
X_16645_ _03087_ _03094_ _02839_ _03095_ VDD VSS OAI21_X4
X_16646_ _02804_ _03095_ _03096_ VDD VSS NOR2_X1
X_16647_ _03067_ _03078_ _03096_ _03097_ VDD VSS NOR3_X1
X_16648_ _02760_ _03097_ net306 VDD VSS NOR2_X1
X_16649_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[16\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[16\]
+ _02770_ _03098_ VDD VSS MUX2_X1
X_16650_ _03098_ _03099_ VDD VSS INV_X1
X_16651_ _02845_ _03099_ _03100_ VDD VSS NAND2_X1
X_16652_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[16\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[16\]
+ _07250_ _03101_ VDD VSS MUX2_X1
X_16653_ _03100_ _03101_ _07244_ _03102_ VDD VSS OAI21_X4
X_16654_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[16\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[16\]
+ _02859_ _03103_ VDD VSS MUX2_X1
X_16655_ _02858_ _03103_ _03104_ VDD VSS OR2_X1
X_16656_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[16\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[16\]
+ _07443_ _03105_ VDD VSS MUX2_X1
X_16657_ _03104_ _03105_ _07446_ _03106_ VDD VSS OAI21_X4
X_16658_ _02844_ _03102_ _03106_ _02906_ _03107_ VDD VSS OAI22_X1
X_16659_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[16\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[16\]
+ _07520_ _03108_ VDD VSS MUX2_X1
X_16660_ _07519_ _03108_ _03109_ VDD VSS OR2_X1
X_16661_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[16\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[16\]
+ _07523_ _03110_ VDD VSS MUX2_X1
X_16662_ _03109_ _03110_ _07526_ _03111_ VDD VSS OAI21_X4
X_16663_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[16\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[16\]
+ _02792_ _03112_ VDD VSS MUX2_X1
X_16664_ _02991_ _03112_ _03113_ VDD VSS OR2_X1
X_16665_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[16\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[16\]
+ _07497_ _03114_ VDD VSS MUX2_X1
X_16666_ _03113_ _03114_ _02995_ _03115_ VDD VSS OAI21_X2
X_16667_ _02761_ _03111_ _03115_ _02869_ _03116_ VDD VSS OAI22_X1
X_16668_ _03107_ _03116_ _03117_ VDD VSS NOR2_X1
X_16669_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[16\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[16\]
+ _02810_ _03118_ VDD VSS MUX2_X1
X_16670_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[16\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[16\]
+ _02875_ _03119_ VDD VSS MUX2_X1
X_16671_ _03118_ _03119_ _02812_ _03120_ VDD VSS MUX2_X1
X_16672_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[16\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[16\]
+ _02875_ _03121_ VDD VSS MUX2_X1
X_16673_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[16\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[16\]
+ _02882_ _03122_ VDD VSS MUX2_X1
X_16674_ _03121_ _03122_ _02879_ _03123_ VDD VSS MUX2_X1
X_16675_ _03120_ _03123_ _02885_ _03124_ VDD VSS MUX2_X1
X_16676_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[16\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[16\]
+ _02877_ _03125_ VDD VSS MUX2_X1
X_16677_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[16\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[16\]
+ _02929_ _03126_ VDD VSS MUX2_X1
X_16678_ _03125_ _03126_ _02890_ _03127_ VDD VSS MUX2_X1
X_16679_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[16\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[16\]
+ _02929_ _03128_ VDD VSS MUX2_X1
X_16680_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[16\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[16\]
+ _02888_ _03129_ VDD VSS MUX2_X1
X_16681_ _03128_ _03129_ _05711_ _03130_ VDD VSS MUX2_X1
X_16682_ _03127_ _03130_ _02885_ _03131_ VDD VSS MUX2_X1
X_16683_ _03124_ _03131_ _07393_ _03132_ VDD VSS MUX2_X2
X_16684_ _02874_ _03132_ _03133_ VDD VSS NAND2_X1
X_16685_ _02843_ _03117_ _03133_ net307 VDD VSS AOI21_X2
X_16686_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[17\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[17\]
+ _02763_ _03134_ VDD VSS MUX2_X1
X_16687_ _02762_ _03134_ _03135_ VDD VSS OR2_X1
X_16688_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[17\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[17\]
+ _07523_ _03136_ VDD VSS MUX2_X1
X_16689_ _03135_ _03136_ _02767_ _03137_ VDD VSS OAI21_X4
X_16690_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[17\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[17\]
+ _07440_ _03138_ VDD VSS MUX2_X1
X_16691_ _07439_ _03138_ _03139_ VDD VSS OR2_X1
X_16692_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[17\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[17\]
+ _07443_ _03140_ VDD VSS MUX2_X1
X_16693_ _03139_ _03140_ _07446_ _03141_ VDD VSS OAI21_X4
X_16694_ _02761_ _03137_ _03141_ _02906_ _03142_ VDD VSS OAI22_X2
X_16695_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[17\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[17\]
+ _07246_ _03143_ VDD VSS MUX2_X1
X_16696_ _03143_ _03144_ VDD VSS INV_X1
X_16697_ _02845_ _03144_ _03145_ VDD VSS NAND2_X1
X_16698_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[17\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[17\]
+ _07250_ _03146_ VDD VSS MUX2_X1
X_16699_ _03145_ _03146_ _07244_ _03147_ VDD VSS OAI21_X4
X_16700_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[17\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[17\]
+ _02792_ _03148_ VDD VSS MUX2_X1
X_16701_ _02991_ _03148_ _03149_ VDD VSS OR2_X1
X_16702_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[17\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[17\]
+ _07497_ _03150_ VDD VSS MUX2_X1
X_16703_ _03149_ _03150_ _02995_ _03151_ VDD VSS OAI21_X4
X_16704_ _02844_ _03147_ _03151_ _02869_ _03152_ VDD VSS OAI22_X2
X_16705_ _03142_ _03152_ _03153_ VDD VSS NOR2_X2
X_16706_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[17\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[17\]
+ _02810_ _03154_ VDD VSS MUX2_X1
X_16707_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[17\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[17\]
+ _02875_ _03155_ VDD VSS MUX2_X1
X_16708_ _03154_ _03155_ _02812_ _03156_ VDD VSS MUX2_X1
X_16709_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[17\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[17\]
+ _02875_ _03157_ VDD VSS MUX2_X1
X_16710_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[17\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[17\]
+ _02882_ _03158_ VDD VSS MUX2_X1
X_16711_ _03157_ _03158_ _02879_ _03159_ VDD VSS MUX2_X1
X_16712_ _03156_ _03159_ _02836_ _03160_ VDD VSS MUX2_X1
X_16713_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[17\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[17\]
+ _02877_ _03161_ VDD VSS MUX2_X1
X_16714_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[17\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[17\]
+ _02929_ _03162_ VDD VSS MUX2_X1
X_16715_ _03161_ _03162_ _02890_ _03163_ VDD VSS MUX2_X1
X_16716_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[17\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[17\]
+ _02929_ _03164_ VDD VSS MUX2_X1
X_16717_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[17\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[17\]
+ _02888_ _03165_ VDD VSS MUX2_X1
X_16718_ _03164_ _03165_ _02890_ _03166_ VDD VSS MUX2_X1
X_16719_ _03163_ _03166_ _02885_ _03167_ VDD VSS MUX2_X1
X_16720_ _03160_ _03167_ _07393_ _03168_ VDD VSS MUX2_X2
X_16721_ _02874_ _03168_ _03169_ VDD VSS NAND2_X1
X_16722_ _02843_ _03153_ _03169_ net308 VDD VSS AOI21_X4
X_16723_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[18\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[18\]
+ _02763_ _03170_ VDD VSS MUX2_X1
X_16724_ _02762_ _03170_ _03171_ VDD VSS OR2_X1
X_16725_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[18\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[18\]
+ _02938_ _03172_ VDD VSS MUX2_X1
X_16726_ _03171_ _03172_ _02767_ _03173_ VDD VSS OAI21_X4
X_16727_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[18\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[18\]
+ _03068_ _03174_ VDD VSS MUX2_X1
X_16728_ _03174_ _03175_ VDD VSS INV_X1
X_16729_ _02941_ _03175_ _03176_ VDD VSS NAND2_X1
X_16730_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[18\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[18\]
+ _02774_ _03177_ VDD VSS MUX2_X1
X_16731_ _03176_ _03177_ _02769_ _03178_ VDD VSS OAI21_X4
X_16732_ _03015_ _03173_ _03178_ _03025_ _03179_ VDD VSS OAI22_X1
X_16733_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[18\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[18\]
+ _02785_ _03180_ VDD VSS MUX2_X1
X_16734_ _02784_ _03180_ _03181_ VDD VSS OR2_X1
X_16735_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[18\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[18\]
+ _02950_ _03182_ VDD VSS MUX2_X1
X_16736_ _03181_ _03182_ _02789_ _03183_ VDD VSS OAI21_X4
X_16737_ _05314_ _03184_ VDD VSS BUF_X4
X_16738_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[18\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[18\]
+ _03184_ _03185_ VDD VSS MUX2_X1
X_16739_ _02791_ _03185_ _03186_ VDD VSS OR2_X1
X_16740_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[18\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[18\]
+ _02795_ _03187_ VDD VSS MUX2_X1
X_16741_ _03186_ _03187_ _02797_ _03188_ VDD VSS OAI21_X4
X_16742_ _02783_ _03183_ _03188_ _02801_ _03189_ VDD VSS OAI22_X1
X_16743_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[18\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[18\]
+ _02808_ _03190_ VDD VSS MUX2_X1
X_16744_ _02807_ _03191_ VDD VSS BUF_X4
X_16745_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[18\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[18\]
+ _03191_ _03192_ VDD VSS MUX2_X1
X_16746_ _03190_ _03192_ _02812_ _03193_ VDD VSS MUX2_X1
X_16747_ _02806_ _03193_ _03194_ VDD VSS NAND2_X1
X_16748_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[18\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[18\]
+ _02816_ _03195_ VDD VSS MUX2_X1
X_16749_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[18\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[18\]
+ _03042_ _03196_ VDD VSS MUX2_X1
X_16750_ _03195_ _03196_ _02820_ _03197_ VDD VSS MUX2_X1
X_16751_ _02815_ _03197_ _03198_ VDD VSS NAND2_X1
X_16752_ _03036_ _03194_ _03198_ _03199_ VDD VSS NAND3_X2
X_16753_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[18\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[18\]
+ _03047_ _03200_ VDD VSS MUX2_X1
X_16754_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[18\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[18\]
+ _02826_ _03201_ VDD VSS MUX2_X1
X_16755_ _03200_ _03201_ _02828_ _03202_ VDD VSS MUX2_X1
X_16756_ _05702_ _03203_ VDD VSS BUF_X4
X_16757_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[18\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[18\]
+ _03203_ _03204_ VDD VSS MUX2_X1
X_16758_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[18\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[18\]
+ _02832_ _03205_ VDD VSS MUX2_X1
X_16759_ _05709_ _03206_ VDD VSS BUF_X4
X_16760_ _03204_ _03205_ _03206_ _03207_ VDD VSS MUX2_X1
X_16761_ _03202_ _03207_ _02836_ _03208_ VDD VSS MUX2_X1
X_16762_ _03199_ _03208_ _02839_ _03209_ VDD VSS OAI21_X4
X_16763_ _02804_ _03209_ _03210_ VDD VSS NOR2_X1
X_16764_ _03179_ _03189_ _03210_ _03211_ VDD VSS NOR3_X1
X_16765_ _02760_ _03211_ net309 VDD VSS NOR2_X1
X_16766_ _02800_ _03212_ VDD VSS BUF_X4
X_16767_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[19\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[19\]
+ _07494_ _03213_ VDD VSS MUX2_X1
X_16768_ _07493_ _03213_ _03214_ VDD VSS OR2_X1
X_16769_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[19\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[19\]
+ _07497_ _03215_ VDD VSS MUX2_X1
X_16770_ _03214_ _03215_ _07499_ _03216_ VDD VSS OAI21_X4
X_16771_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[19\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[19\]
+ _02859_ _03217_ VDD VSS MUX2_X1
X_16772_ _02858_ _03217_ _03218_ VDD VSS OR2_X1
X_16773_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[19\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[19\]
+ _07443_ _03219_ VDD VSS MUX2_X1
X_16774_ _03218_ _03219_ _02863_ _03220_ VDD VSS OAI21_X4
X_16775_ _03212_ _03216_ _03220_ _02782_ _03221_ VDD VSS OAI22_X2
X_16776_ _05468_ _03222_ VDD VSS BUF_X2
X_16777_ _07286_ _03223_ VDD VSS BUF_X4
X_16778_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[19\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[19\]
+ _03223_ _03224_ VDD VSS MUX2_X1
X_16779_ _03222_ _03224_ _03225_ VDD VSS OR2_X1
X_16780_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[19\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[19\]
+ _07520_ _03226_ VDD VSS MUX2_X1
X_16781_ _07290_ _03227_ VDD VSS BUF_X8
X_16782_ _03225_ _03226_ _03227_ _03228_ VDD VSS OAI21_X4
X_16783_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[19\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[19\]
+ _03068_ _03229_ VDD VSS MUX2_X1
X_16784_ _03229_ _03230_ VDD VSS INV_X1
X_16785_ _07244_ _03230_ _03231_ VDD VSS NAND2_X1
X_16786_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[19\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[19\]
+ _07246_ _03232_ VDD VSS MUX2_X1
X_16787_ _05127_ _03233_ VDD VSS BUF_X8
X_16788_ _03231_ _03232_ _03233_ _03234_ VDD VSS OAI21_X4
X_16789_ _02778_ _03235_ VDD VSS BUF_X4
X_16790_ _02855_ _03228_ _03234_ _03235_ _03236_ VDD VSS OAI22_X2
X_16791_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[19\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[19\]
+ _02808_ _03237_ VDD VSS MUX2_X1
X_16792_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[19\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[19\]
+ _03191_ _03238_ VDD VSS MUX2_X1
X_16793_ _03237_ _03238_ _02812_ _03239_ VDD VSS MUX2_X1
X_16794_ _02806_ _03239_ _03240_ VDD VSS NAND2_X1
X_16795_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[19\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[19\]
+ _02816_ _03241_ VDD VSS MUX2_X1
X_16796_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[19\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[19\]
+ _03042_ _03242_ VDD VSS MUX2_X1
X_16797_ _03241_ _03242_ _02820_ _03243_ VDD VSS MUX2_X1
X_16798_ _02815_ _03243_ _03244_ VDD VSS NAND2_X1
X_16799_ _03036_ _03240_ _03244_ _03245_ VDD VSS NAND3_X2
X_16800_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[19\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[19\]
+ _03047_ _03246_ VDD VSS MUX2_X1
X_16801_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[19\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[19\]
+ _02826_ _03247_ VDD VSS MUX2_X1
X_16802_ _03246_ _03247_ _02828_ _03248_ VDD VSS MUX2_X1
X_16803_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[19\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[19\]
+ _03203_ _03249_ VDD VSS MUX2_X1
X_16804_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[19\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[19\]
+ _02832_ _03250_ VDD VSS MUX2_X1
X_16805_ _03249_ _03250_ _03206_ _03251_ VDD VSS MUX2_X1
X_16806_ _03248_ _03251_ _02836_ _03252_ VDD VSS MUX2_X1
X_16807_ _03245_ _03252_ _02839_ _03253_ VDD VSS OAI21_X4
X_16808_ _02804_ _03253_ _03254_ VDD VSS NOR2_X1
X_16809_ _03221_ _03236_ _03254_ _03255_ VDD VSS NOR3_X2
X_16810_ _02760_ _03255_ net310 VDD VSS NOR2_X2
X_16811_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[1\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[1\] _02763_
+ _03256_ VDD VSS MUX2_X1
X_16812_ _02762_ _03256_ _03257_ VDD VSS OR2_X1
X_16813_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[1\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[1\] _02938_
+ _03258_ VDD VSS MUX2_X1
X_16814_ _03257_ _03258_ _02767_ _03259_ VDD VSS OAI21_X4
X_16815_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[1\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[1\]
+ _03068_ _03260_ VDD VSS MUX2_X1
X_16816_ _03260_ _03261_ VDD VSS INV_X1
X_16817_ _02769_ _03261_ _03262_ VDD VSS NAND2_X1
X_16818_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[1\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[1\]
+ _02774_ _03263_ VDD VSS MUX2_X1
X_16819_ _03262_ _03263_ _02776_ _03264_ VDD VSS OAI21_X4
X_16820_ _03015_ _03259_ _03264_ _03025_ _03265_ VDD VSS OAI22_X1
X_16821_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[1\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[1\] _02785_
+ _03266_ VDD VSS MUX2_X1
X_16822_ _02784_ _03266_ _03267_ VDD VSS OR2_X1
X_16823_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[1\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[1\] _07440_
+ _03268_ VDD VSS MUX2_X1
X_16824_ _03267_ _03268_ _02789_ _03269_ VDD VSS OAI21_X4
X_16825_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[1\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[1\]
+ _03184_ _03270_ VDD VSS MUX2_X1
X_16826_ _02791_ _03270_ _03271_ VDD VSS OR2_X1
X_16827_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[1\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[1\]
+ _02795_ _03272_ VDD VSS MUX2_X1
X_16828_ _03271_ _03272_ _02797_ _03273_ VDD VSS OAI21_X4
X_16829_ _02783_ _03269_ _03273_ _02801_ _03274_ VDD VSS OAI22_X1
X_16830_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[1\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[1\]
+ _02808_ _03275_ VDD VSS MUX2_X1
X_16831_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[1\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[1\]
+ _03191_ _03276_ VDD VSS MUX2_X1
X_16832_ _05710_ _03277_ VDD VSS BUF_X4
X_16833_ _03275_ _03276_ _03277_ _03278_ VDD VSS MUX2_X1
X_16834_ _02806_ _03278_ _03279_ VDD VSS NAND2_X1
X_16835_ _02807_ _03280_ VDD VSS BUF_X4
X_16836_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[1\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[1\] _03280_
+ _03281_ VDD VSS MUX2_X1
X_16837_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[1\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[1\] _03042_
+ _03282_ VDD VSS MUX2_X1
X_16838_ _03281_ _03282_ _02820_ _03283_ VDD VSS MUX2_X1
X_16839_ _02815_ _03283_ _03284_ VDD VSS NAND2_X1
X_16840_ _03036_ _03279_ _03284_ _03285_ VDD VSS NAND3_X2
X_16841_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[1\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[1\]
+ _03047_ _03286_ VDD VSS MUX2_X1
X_16842_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[1\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[1\]
+ _02826_ _03287_ VDD VSS MUX2_X1
X_16843_ _03286_ _03287_ _02828_ _03288_ VDD VSS MUX2_X1
X_16844_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[1\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[1\] _03203_
+ _03289_ VDD VSS MUX2_X1
X_16845_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[1\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[1\] _02832_
+ _03290_ VDD VSS MUX2_X1
X_16846_ _03289_ _03290_ _03206_ _03291_ VDD VSS MUX2_X1
X_16847_ _05720_ _03292_ VDD VSS BUF_X4
X_16848_ _03288_ _03291_ _03292_ _03293_ VDD VSS MUX2_X1
X_16849_ _03285_ _03293_ _02839_ _03294_ VDD VSS OAI21_X4
X_16850_ _02804_ _03294_ _03295_ VDD VSS NOR2_X1
X_16851_ _03265_ _03274_ _03295_ _03296_ VDD VSS NOR3_X1
X_16852_ _02760_ _03296_ net311 VDD VSS NOR2_X1
X_16853_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[20\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[20\]
+ _02770_ _03297_ VDD VSS MUX2_X1
X_16854_ _03297_ _03298_ VDD VSS INV_X1
X_16855_ _02845_ _03298_ _03299_ VDD VSS NAND2_X1
X_16856_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[20\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[20\]
+ _07250_ _03300_ VDD VSS MUX2_X1
X_16857_ _03299_ _03300_ _07244_ _03301_ VDD VSS OAI21_X4
X_16858_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[20\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[20\]
+ _07440_ _03302_ VDD VSS MUX2_X1
X_16859_ _07439_ _03302_ _03303_ VDD VSS OR2_X1
X_16860_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[20\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[20\]
+ _07443_ _03304_ VDD VSS MUX2_X1
X_16861_ _03303_ _03304_ _07446_ _03305_ VDD VSS OAI21_X4
X_16862_ _02844_ _03301_ _03305_ _02906_ _03306_ VDD VSS OAI22_X1
X_16863_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[20\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[20\]
+ _02763_ _03307_ VDD VSS MUX2_X1
X_16864_ _07519_ _03307_ _03308_ VDD VSS OR2_X1
X_16865_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[20\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[20\]
+ _07523_ _03309_ VDD VSS MUX2_X1
X_16866_ _03308_ _03309_ _07526_ _03310_ VDD VSS OAI21_X4
X_16867_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[20\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[20\]
+ _02792_ _03311_ VDD VSS MUX2_X1
X_16868_ _02991_ _03311_ _03312_ VDD VSS OR2_X1
X_16869_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[20\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[20\]
+ _07497_ _03313_ VDD VSS MUX2_X1
X_16870_ _03312_ _03313_ _02995_ _03314_ VDD VSS OAI21_X4
X_16871_ _02761_ _03310_ _03314_ _02801_ _03315_ VDD VSS OAI22_X1
X_16872_ _03306_ _03315_ _03316_ VDD VSS NOR2_X1
X_16873_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[20\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[20\]
+ _02810_ _03317_ VDD VSS MUX2_X1
X_16874_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[20\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[20\]
+ _02875_ _03318_ VDD VSS MUX2_X1
X_16875_ _03317_ _03318_ _02812_ _03319_ VDD VSS MUX2_X1
X_16876_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[20\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[20\]
+ _02875_ _03320_ VDD VSS MUX2_X1
X_16877_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[20\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[20\]
+ _02882_ _03321_ VDD VSS MUX2_X1
X_16878_ _03320_ _03321_ _02879_ _03322_ VDD VSS MUX2_X1
X_16879_ _03319_ _03322_ _02836_ _03323_ VDD VSS MUX2_X1
X_16880_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[20\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[20\]
+ _02877_ _03324_ VDD VSS MUX2_X1
X_16881_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[20\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[20\]
+ _02929_ _03325_ VDD VSS MUX2_X1
X_16882_ _03324_ _03325_ _02890_ _03326_ VDD VSS MUX2_X1
X_16883_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[20\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[20\]
+ _02929_ _03327_ VDD VSS MUX2_X1
X_16884_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[20\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[20\]
+ _02888_ _03328_ VDD VSS MUX2_X1
X_16885_ _03327_ _03328_ _02890_ _03329_ VDD VSS MUX2_X1
X_16886_ _03326_ _03329_ _02885_ _03330_ VDD VSS MUX2_X1
X_16887_ _03323_ _03330_ _07393_ _03331_ VDD VSS MUX2_X2
X_16888_ _02874_ _03331_ _03332_ VDD VSS NAND2_X1
X_16889_ _02843_ _03316_ _03332_ net312 VDD VSS AOI21_X2
X_16890_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[21\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[21\]
+ _03223_ _03333_ VDD VSS MUX2_X1
X_16891_ _02762_ _03333_ _03334_ VDD VSS OR2_X1
X_16892_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[21\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[21\]
+ _02938_ _03335_ VDD VSS MUX2_X1
X_16893_ _03334_ _03335_ _02767_ _03336_ VDD VSS OAI21_X4
X_16894_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[21\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[21\]
+ _03068_ _03337_ VDD VSS MUX2_X1
X_16895_ _03337_ _03338_ VDD VSS INV_X1
X_16896_ _02941_ _03338_ _03339_ VDD VSS NAND2_X1
X_16897_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[21\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[21\]
+ _02774_ _03340_ VDD VSS MUX2_X1
X_16898_ _03339_ _03340_ _02769_ _03341_ VDD VSS OAI21_X4
X_16899_ _03015_ _03336_ _03341_ _03025_ _03342_ VDD VSS OAI22_X1
X_16900_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[21\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[21\]
+ _02785_ _03343_ VDD VSS MUX2_X1
X_16901_ _02784_ _03343_ _03344_ VDD VSS OR2_X1
X_16902_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[21\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[21\]
+ _02950_ _03345_ VDD VSS MUX2_X1
X_16903_ _03344_ _03345_ _02789_ _03346_ VDD VSS OAI21_X4
X_16904_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[21\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[21\]
+ _03184_ _03347_ VDD VSS MUX2_X1
X_16905_ _02791_ _03347_ _03348_ VDD VSS OR2_X1
X_16906_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[21\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[21\]
+ _02795_ _03349_ VDD VSS MUX2_X1
X_16907_ _03348_ _03349_ _02797_ _03350_ VDD VSS OAI21_X4
X_16908_ _02800_ _03351_ VDD VSS CLKBUF_X3
X_16909_ _02783_ _03346_ _03350_ _03351_ _03352_ VDD VSS OAI22_X1
X_16910_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[21\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[21\]
+ _02808_ _03353_ VDD VSS MUX2_X1
X_16911_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[21\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[21\]
+ _03191_ _03354_ VDD VSS MUX2_X1
X_16912_ _03353_ _03354_ _03277_ _03355_ VDD VSS MUX2_X1
X_16913_ _02806_ _03355_ _03356_ VDD VSS NAND2_X1
X_16914_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[21\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[21\]
+ _03280_ _03357_ VDD VSS MUX2_X1
X_16915_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[21\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[21\]
+ _03042_ _03358_ VDD VSS MUX2_X1
X_16916_ _03357_ _03358_ _02820_ _03359_ VDD VSS MUX2_X1
X_16917_ _02815_ _03359_ _03360_ VDD VSS NAND2_X1
X_16918_ _03036_ _03356_ _03360_ _03361_ VDD VSS NAND3_X2
X_16919_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[21\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[21\]
+ _03047_ _03362_ VDD VSS MUX2_X1
X_16920_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[21\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[21\]
+ _02826_ _03363_ VDD VSS MUX2_X1
X_16921_ _03362_ _03363_ _02828_ _03364_ VDD VSS MUX2_X1
X_16922_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[21\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[21\]
+ _03203_ _03365_ VDD VSS MUX2_X1
X_16923_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[21\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[21\]
+ _02832_ _03366_ VDD VSS MUX2_X1
X_16924_ _03365_ _03366_ _03206_ _03367_ VDD VSS MUX2_X1
X_16925_ _03364_ _03367_ _03292_ _03368_ VDD VSS MUX2_X1
X_16926_ _03361_ _03368_ _02839_ _03369_ VDD VSS OAI21_X4
X_16927_ _02804_ _03369_ _03370_ VDD VSS NOR2_X1
X_16928_ _03342_ _03352_ _03370_ _03371_ VDD VSS NOR3_X1
X_16929_ _02760_ _03371_ net313 VDD VSS NOR2_X1
X_16930_ _02778_ _03372_ VDD VSS INV_X4
X_16931_ _06996_ _05775_ _06080_ _03372_ _03373_ VDD VSS AOI22_X1
X_16932_ _05815_ _03374_ VDD VSS INV_X2
X_16933_ _03373_ _02494_ _03351_ _03066_ _03374_ _03375_ VDD
+ VSS OAI221_X1
X_16934_ _02872_ _03376_ VDD VSS BUF_X4
X_16935_ _03375_ _07132_ _03376_ _03377_ VDD VSS AOI21_X1
X_16936_ _02760_ _03377_ net314 VDD VSS NOR2_X1
X_16937_ _02799_ _03378_ VDD VSS INV_X2
X_16938_ _03378_ _03379_ VDD VSS BUF_X4
X_16939_ _05157_ _03380_ VDD VSS BUF_X4
X_16940_ _03379_ _05849_ _05796_ _03380_ _03381_ VDD VSS AOI22_X1
X_16941_ _06060_ _03382_ VDD VSS INV_X2
X_16942_ _05765_ _03383_ VDD VSS INV_X2
X_16943_ _03381_ _03382_ _02779_ _02855_ _03383_ _03384_ VDD
+ VSS OAI221_X1
X_16944_ _03384_ _07156_ _03376_ _03385_ VDD VSS AOI21_X1
X_16945_ _02760_ _03385_ net315 VDD VSS NOR2_X1
X_16946_ _05163_ _03386_ VDD VSS CLKBUF_X3
X_16947_ _03379_ _05839_ _05799_ _05157_ _03387_ VDD VSS AOI22_X1
X_16948_ _06064_ _03388_ VDD VSS INV_X1
X_16949_ _05771_ _03389_ VDD VSS INV_X2
X_16950_ _03387_ _03388_ _02779_ _02855_ _03389_ _03390_ VDD
+ VSS OAI221_X1
X_16951_ _03390_ _05956_ _03376_ _03391_ VDD VSS AOI21_X1
X_16952_ _03386_ _03391_ net316 VDD VSS NOR2_X1
X_16953_ _03379_ _05829_ _05802_ _05157_ _03392_ VDD VSS AOI22_X1
X_16954_ _06067_ _03393_ VDD VSS INV_X1
X_16955_ _06960_ _03394_ VDD VSS BUF_X4
X_16956_ _05768_ _03395_ VDD VSS INV_X1
X_16957_ _03392_ _03393_ _02779_ _03394_ _03395_ _03396_ VDD
+ VSS OAI221_X1
X_16958_ _03396_ _05902_ _03376_ _03397_ VDD VSS AOI21_X1
X_16959_ _03386_ _03397_ net317 VDD VSS NOR2_X1
X_16960_ _03379_ _05832_ _05792_ _05157_ _03398_ VDD VSS AOI22_X1
X_16961_ _06056_ _03399_ VDD VSS INV_X1
X_16962_ _05760_ _03400_ VDD VSS INV_X1
X_16963_ _03398_ _03399_ _02779_ _03394_ _03400_ _03401_ VDD
+ VSS OAI221_X1
X_16964_ _05922_ _05932_ _03402_ VDD VSS OR2_X1
X_16965_ _03402_ _05918_ _07337_ _03403_ VDD VSS OAI21_X4
X_16966_ _03401_ _03403_ _03376_ _03404_ VDD VSS AOI21_X1
X_16967_ _03386_ _03404_ net318 VDD VSS NOR2_X1
X_16968_ _06959_ _07233_ _07196_ _02778_ _03405_ VDD VSS OAI22_X2
X_16969_ _03405_ _05836_ _03379_ _03380_ _05809_ _03406_ VDD
+ VSS AOI221_X2
X_16970_ _02874_ _05972_ _03407_ VDD VSS NAND2_X1
X_16971_ _02843_ _03406_ _03407_ net319 VDD VSS AOI21_X2
X_16972_ _06959_ _07229_ _07192_ _02778_ _03408_ VDD VSS OAI22_X2
X_16973_ _03408_ _05843_ _03379_ _03380_ _05806_ _03409_ VDD
+ VSS AOI221_X2
X_16974_ _02874_ _06008_ _03410_ VDD VSS NAND2_X1
X_16975_ _02843_ _03409_ _03410_ net320 VDD VSS AOI21_X2
X_16976_ _06724_ _05778_ _06071_ _03372_ _03411_ VDD VSS AOI22_X1
X_16977_ _05812_ _03412_ VDD VSS INV_X2
X_16978_ _03411_ _07105_ _03351_ _03066_ _03412_ _03413_ VDD
+ VSS OAI221_X1
X_16979_ _03413_ _05993_ _03376_ _03414_ VDD VSS AOI21_X1
X_16980_ _03386_ _03414_ net321 VDD VSS NOR2_X1
X_16981_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[2\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[2\] _03223_
+ _03415_ VDD VSS MUX2_X1
X_16982_ _02762_ _03415_ _03416_ VDD VSS OR2_X1
X_16983_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[2\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[2\] _02938_
+ _03417_ VDD VSS MUX2_X1
X_16984_ _03416_ _03417_ _02767_ _03418_ VDD VSS OAI21_X4
X_16985_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[2\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[2\] _02859_
+ _03419_ VDD VSS MUX2_X1
X_16986_ _02858_ _03419_ _03420_ VDD VSS OR2_X1
X_16987_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[2\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[2\] _02950_
+ _03421_ VDD VSS MUX2_X1
X_16988_ _03420_ _03421_ _02789_ _03422_ VDD VSS OAI21_X4
X_16989_ _03015_ _03418_ _03422_ _02782_ _03423_ VDD VSS OAI22_X1
X_16990_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[2\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[2\]
+ _03068_ _03424_ VDD VSS MUX2_X1
X_16991_ _03424_ _03425_ VDD VSS INV_X1
X_16992_ _02941_ _03425_ _03426_ VDD VSS NAND2_X1
X_16993_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[2\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[2\]
+ _07246_ _03427_ VDD VSS MUX2_X1
X_16994_ _03426_ _03427_ _02769_ _03428_ VDD VSS OAI21_X4
X_16995_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[2\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[2\]
+ _03184_ _03429_ VDD VSS MUX2_X1
X_16996_ _07488_ _03429_ _03430_ VDD VSS OR2_X1
X_16997_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[2\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[2\]
+ _02795_ _03431_ VDD VSS MUX2_X1
X_16998_ _03430_ _03431_ _07499_ _03432_ VDD VSS OAI21_X4
X_16999_ _02780_ _03428_ _03432_ _03351_ _03433_ VDD VSS OAI22_X1
X_17000_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[2\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[2\]
+ _02818_ _03434_ VDD VSS MUX2_X1
X_17001_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[2\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[2\]
+ _03191_ _03435_ VDD VSS MUX2_X1
X_17002_ _03434_ _03435_ _03277_ _03436_ VDD VSS MUX2_X1
X_17003_ _02806_ _03436_ _03437_ VDD VSS NAND2_X1
X_17004_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[2\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[2\] _03280_
+ _03438_ VDD VSS MUX2_X1
X_17005_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[2\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[2\] _03042_
+ _03439_ VDD VSS MUX2_X1
X_17006_ _03438_ _03439_ _02820_ _03440_ VDD VSS MUX2_X1
X_17007_ _02815_ _03440_ _03441_ VDD VSS NAND2_X1
X_17008_ _03036_ _03437_ _03441_ _03442_ VDD VSS NAND3_X2
X_17009_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[2\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[2\]
+ _03047_ _03443_ VDD VSS MUX2_X1
X_17010_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[2\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[2\]
+ _02824_ _03444_ VDD VSS MUX2_X1
X_17011_ _03443_ _03444_ _07336_ _03445_ VDD VSS MUX2_X1
X_17012_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[2\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[2\] _03203_
+ _03446_ VDD VSS MUX2_X1
X_17013_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[2\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[2\] _02832_
+ _03447_ VDD VSS MUX2_X1
X_17014_ _03446_ _03447_ _03206_ _03448_ VDD VSS MUX2_X1
X_17015_ _03445_ _03448_ _03292_ _03449_ VDD VSS MUX2_X1
X_17016_ _03442_ _02805_ _03449_ _03450_ VDD VSS OAI21_X4
X_17017_ _02804_ _03450_ _03451_ VDD VSS NOR2_X1
X_17018_ _03423_ _03433_ _03451_ _03452_ VDD VSS NOR3_X1
X_17019_ _03386_ _03452_ net322 VDD VSS NOR2_X1
X_17020_ _03379_ _06524_ _05492_ _06724_ _03453_ VDD VSS AOI22_X2
X_17021_ _03453_ _06099_ _02779_ _03066_ _05274_ _03454_ VDD
+ VSS OAI221_X2
X_17022_ _03454_ _06179_ _03376_ _03455_ VDD VSS AOI21_X1
X_17023_ _03386_ _03455_ net323 VDD VSS NOR2_X1
X_17024_ _03380_ _06514_ _06100_ _03372_ _03456_ VDD VSS AOI22_X1
X_17025_ _03456_ _05376_ _02800_ _03394_ _06789_ _03457_ VDD
+ VSS OAI221_X1
X_17026_ _03457_ _06146_ _03376_ _03458_ VDD VSS AOI21_X1
X_17027_ _03386_ _03458_ net324 VDD VSS NOR2_X1
X_17028_ _02782_ _06513_ _06098_ _02778_ _03459_ VDD VSS OAI22_X2
X_17029_ _03459_ _05370_ _03379_ _06996_ _05500_ _03460_ VDD
+ VSS AOI221_X2
X_17030_ _02874_ _06163_ _03461_ VDD VSS NAND2_X1
X_17031_ _02843_ _03460_ _03461_ net325 VDD VSS AOI21_X2
X_17032_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[33\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[33\]
+ _03223_ _03462_ VDD VSS MUX2_X1
X_17033_ _02762_ _03462_ _03463_ VDD VSS OR2_X1
X_17034_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[33\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[33\]
+ _02938_ _03464_ VDD VSS MUX2_X1
X_17035_ _03463_ _03464_ _02767_ _03465_ VDD VSS OAI21_X4
X_17036_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[33\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[33\]
+ _02770_ _03466_ VDD VSS MUX2_X1
X_17037_ _03466_ _03467_ VDD VSS INV_X1
X_17038_ _02776_ _03467_ _03468_ VDD VSS NAND2_X1
X_17039_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[33\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[33\]
+ _02774_ _03469_ VDD VSS MUX2_X1
X_17040_ _07244_ _03470_ VDD VSS BUF_X8
X_17041_ _03468_ _03469_ _03470_ _03471_ VDD VSS OAI21_X4
X_17042_ _03015_ _03465_ _03471_ _03025_ _03472_ VDD VSS OAI22_X1
X_17043_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[33\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[33\]
+ _02785_ _03473_ VDD VSS MUX2_X1
X_17044_ _05153_ _03473_ _03474_ VDD VSS OR2_X1
X_17045_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[33\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[33\]
+ _07440_ _03475_ VDD VSS MUX2_X1
X_17046_ _03474_ _03475_ _07445_ _03476_ VDD VSS OAI21_X4
X_17047_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[33\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[33\]
+ _03184_ _03477_ VDD VSS MUX2_X1
X_17048_ _07488_ _03477_ _03478_ VDD VSS OR2_X1
X_17049_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[33\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[33\]
+ _02795_ _03479_ VDD VSS MUX2_X1
X_17050_ _03478_ _03479_ _07499_ _03480_ VDD VSS OAI21_X4
X_17051_ _02783_ _03476_ _03480_ _03351_ _03481_ VDD VSS OAI22_X1
X_17052_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[33\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[33\]
+ _02818_ _03482_ VDD VSS MUX2_X1
X_17053_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[33\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[33\]
+ _03191_ _03483_ VDD VSS MUX2_X1
X_17054_ _03482_ _03483_ _03277_ _03484_ VDD VSS MUX2_X1
X_17055_ _02806_ _03484_ _03485_ VDD VSS NAND2_X1
X_17056_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[33\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[33\]
+ _03280_ _03486_ VDD VSS MUX2_X1
X_17057_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[33\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[33\]
+ _03042_ _03487_ VDD VSS MUX2_X1
X_17058_ _03486_ _03487_ _02820_ _03488_ VDD VSS MUX2_X1
X_17059_ _07391_ _03488_ _03489_ VDD VSS NAND2_X1
X_17060_ _03036_ _03485_ _03489_ _03490_ VDD VSS NAND3_X2
X_17061_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[33\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[33\]
+ _03047_ _03491_ VDD VSS MUX2_X1
X_17062_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[33\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[33\]
+ _02824_ _03492_ VDD VSS MUX2_X1
X_17063_ _03491_ _03492_ _07336_ _03493_ VDD VSS MUX2_X1
X_17064_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[33\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[33\]
+ _03203_ _03494_ VDD VSS MUX2_X1
X_17065_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[33\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[33\]
+ _02832_ _03495_ VDD VSS MUX2_X1
X_17066_ _03494_ _03495_ _03206_ _03496_ VDD VSS MUX2_X1
X_17067_ _03493_ _03496_ _03292_ _03497_ VDD VSS MUX2_X1
X_17068_ _03490_ _03497_ _02805_ _03498_ VDD VSS OAI21_X4
X_17069_ _02804_ _03498_ _03499_ VDD VSS NOR2_X1
X_17070_ _03472_ _03481_ _03499_ _03500_ VDD VSS NOR3_X1
X_17071_ _03386_ _03500_ net326 VDD VSS NOR2_X1
X_17072_ _05163_ _03501_ VDD VSS BUF_X8
X_17073_ _10252_ _03502_ VDD VSS INV_X2
X_17074_ _05156_ _03502_ _05327_ _02800_ _03503_ VDD VSS OAI22_X2
X_17075_ _03503_ _10225_ _03372_ _06996_ _10348_ _03504_ VDD
+ VSS AOI221_X2
X_17076_ _02874_ _10417_ _03505_ VDD VSS NAND2_X1
X_17077_ _03501_ _03504_ _03505_ net327 VDD VSS AOI21_X4
X_17078_ _06724_ _07302_ net694 _03378_ _03506_ VDD VSS AOI22_X1
X_17079_ _03506_ _10221_ _02779_ _03066_ _10255_ _03507_ VDD
+ VSS OAI221_X1
X_17080_ _03507_ _07676_ _02873_ _03508_ VDD VSS AOI21_X1
X_17081_ _03386_ _03508_ net328 VDD VSS NOR2_X1
X_17082_ _05156_ _10261_ _10315_ _02799_ _03509_ VDD VSS OAI22_X2
X_17083_ _10357_ _03510_ VDD VSS INV_X1
X_17084_ _03509_ _07434_ _03372_ _06996_ _03510_ _03511_ VDD
+ VSS AOI221_X2
X_17085_ _02873_ _03512_ VDD VSS CLKBUF_X3
X_17086_ _03512_ _07661_ _03513_ VDD VSS NAND2_X1
X_17087_ _03501_ _03511_ _03513_ net329 VDD VSS AOI21_X4
X_17088_ _03372_ net742 _07305_ _06724_ _03514_ VDD VSS AOI22_X1
X_17089_ _03514_ _10312_ _02800_ _03066_ _10258_ _03515_ VDD
+ VSS OAI221_X1
X_17090_ _03515_ _07409_ _02873_ _03516_ VDD VSS AOI21_X1
X_17091_ _03386_ _03516_ net330 VDD VSS NOR2_X1
X_17092_ _05156_ _10273_ net697 _02799_ _03517_ VDD VSS OAI22_X2
X_17093_ _10369_ _03518_ VDD VSS INV_X1
X_17094_ _03517_ net674 _03372_ _06996_ _03518_ _03519_ VDD
+ VSS AOI221_X2
X_17095_ _03512_ _07646_ _03520_ VDD VSS NAND2_X1
X_17096_ _03501_ _03519_ _03520_ net331 VDD VSS AOI21_X4
X_17097_ _05156_ _10270_ _10209_ _02778_ _03521_ VDD VSS OAI22_X2
X_17098_ _10366_ _03522_ VDD VSS INV_X1
X_17099_ _03521_ net665 _03379_ _06996_ _03522_ _03523_ VDD
+ VSS AOI221_X2
X_17100_ _03512_ _07631_ _03524_ VDD VSS NAND2_X1
X_17101_ _03501_ _03523_ _03524_ net332 VDD VSS AOI21_X2
X_17102_ _05163_ _03525_ VDD VSS BUF_X4
X_17103_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[3\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[3\]
+ _02770_ _03526_ VDD VSS MUX2_X1
X_17104_ _03526_ _03527_ VDD VSS INV_X1
X_17105_ _03470_ _03527_ _03528_ VDD VSS NAND2_X1
X_17106_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[3\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[3\]
+ _07250_ _03529_ VDD VSS MUX2_X1
X_17107_ _03528_ _03529_ _02845_ _03530_ VDD VSS OAI21_X4
X_17108_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[3\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[3\] _02859_
+ _03531_ VDD VSS MUX2_X1
X_17109_ _02858_ _03531_ _03532_ VDD VSS OR2_X1
X_17110_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[3\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[3\] _02950_
+ _03533_ VDD VSS MUX2_X1
X_17111_ _03532_ _03533_ _02863_ _03534_ VDD VSS OAI21_X4
X_17112_ _02780_ _03530_ _03534_ _02782_ _03535_ VDD VSS OAI22_X1
X_17113_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[3\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[3\] _03223_
+ _03536_ VDD VSS MUX2_X1
X_17114_ _03222_ _03536_ _03537_ VDD VSS OR2_X1
X_17115_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[3\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[3\] _07520_
+ _03538_ VDD VSS MUX2_X1
X_17116_ _03537_ _03538_ _03227_ _03539_ VDD VSS OAI21_X4
X_17117_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[3\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[3\]
+ _03184_ _03540_ VDD VSS MUX2_X1
X_17118_ _07488_ _03540_ _03541_ VDD VSS OR2_X1
X_17119_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[3\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[3\]
+ _07494_ _03542_ VDD VSS MUX2_X1
X_17120_ _03541_ _03542_ _07499_ _03543_ VDD VSS OAI21_X4
X_17121_ _02855_ _03539_ _03543_ _03351_ _03544_ VDD VSS OAI22_X1
X_17122_ _02803_ _03545_ VDD VSS CLKBUF_X3
X_17123_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[3\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[3\]
+ _02818_ _03546_ VDD VSS MUX2_X1
X_17124_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[3\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[3\]
+ _03191_ _03547_ VDD VSS MUX2_X1
X_17125_ _03546_ _03547_ _03277_ _03548_ VDD VSS MUX2_X1
X_17126_ _07130_ _03548_ _03549_ VDD VSS NAND2_X1
X_17127_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[3\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[3\] _03280_
+ _03550_ VDD VSS MUX2_X1
X_17128_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[3\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[3\] _03042_
+ _03551_ VDD VSS MUX2_X1
X_17129_ _03550_ _03551_ _02834_ _03552_ VDD VSS MUX2_X1
X_17130_ _07391_ _03552_ _03553_ VDD VSS NAND2_X1
X_17131_ _03036_ _03549_ _03553_ _03554_ VDD VSS NAND3_X2
X_17132_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[3\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[3\]
+ _03047_ _03555_ VDD VSS MUX2_X1
X_17133_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[3\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[3\]
+ _02824_ _03556_ VDD VSS MUX2_X1
X_17134_ _03555_ _03556_ _07336_ _03557_ VDD VSS MUX2_X1
X_17135_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[3\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[3\] _03203_
+ _03558_ VDD VSS MUX2_X1
X_17136_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[3\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[3\] _02830_
+ _03559_ VDD VSS MUX2_X1
X_17137_ _03558_ _03559_ _03206_ _03560_ VDD VSS MUX2_X1
X_17138_ _03557_ _03560_ _03292_ _03561_ VDD VSS MUX2_X1
X_17139_ _03554_ _03561_ _02805_ _03562_ VDD VSS OAI21_X4
X_17140_ _03545_ _03562_ _03563_ VDD VSS NOR2_X1
X_17141_ _03535_ _03544_ _03563_ _03564_ VDD VSS NOR3_X1
X_17142_ _03525_ _03564_ net333 VDD VSS NOR2_X2
X_17143_ _02778_ _10206_ _10303_ _02799_ _03565_ VDD VSS OAI22_X2
X_17144_ _10363_ _03566_ VDD VSS INV_X1
X_17145_ _03565_ _07473_ _03380_ _06996_ _03566_ _03567_ VDD
+ VSS AOI221_X2
X_17146_ _03512_ _07616_ _03568_ VDD VSS NAND2_X1
X_17147_ _03501_ _03567_ _03568_ net334 VDD VSS AOI21_X2
X_17148_ _02857_ net640 net632 _03212_ _03569_ VDD VSS OAI22_X2
X_17149_ _02844_ net650 net713 _02855_ _03570_ VDD VSS OAI22_X2
X_17150_ _03569_ _03570_ _03571_ VDD VSS NOR2_X2
X_17151_ _03512_ _07394_ _03572_ VDD VSS NAND2_X1
X_17152_ _03501_ _03571_ _03572_ net335 VDD VSS AOI21_X4
X_17153_ _03380_ _10249_ _10276_ _03378_ _03573_ VDD VSS AOI22_X1
X_17154_ _10345_ _03574_ VDD VSS INV_X1
X_17155_ _03573_ net685 _02779_ _03394_ _03574_ _03575_ VDD
+ VSS OAI221_X1
X_17156_ _03575_ _10372_ _02873_ _03576_ VDD VSS AOI21_X1
X_17157_ _03525_ _03576_ net336 VDD VSS NOR2_X2
X_17158_ _10342_ _03577_ VDD VSS INV_X1
X_17159_ _10279_ _03578_ VDD VSS INV_X1
X_17160_ _06724_ _03577_ _03578_ _03378_ _03579_ VDD VSS AOI22_X1
X_17161_ _03579_ net644 _02779_ _03066_ _10246_ _03580_ VDD
+ VSS OAI221_X1
X_17162_ _03580_ _07556_ _02873_ _03581_ VDD VSS AOI21_X1
X_17163_ _03525_ _03581_ net337 VDD VSS NOR2_X2
X_17164_ _02778_ net645 net723 _06959_ _03582_ VDD VSS OAI22_X2
X_17165_ _10243_ _03583_ VDD VSS INV_X2
X_17166_ _03582_ net690 _03378_ _03380_ _03583_ _03584_ VDD
+ VSS AOI221_X2
X_17167_ _03512_ _07571_ _03585_ VDD VSS NAND2_X1
X_17168_ _03501_ _03584_ _03585_ net338 VDD VSS AOI21_X4
X_17169_ _10240_ _03586_ VDD VSS INV_X1
X_17170_ _03380_ _03586_ _07296_ _06724_ _03587_ VDD VSS AOI22_X1
X_17171_ _03587_ _10285_ _02800_ _02780_ _10185_ _03588_ VDD
+ VSS OAI221_X1
X_17172_ _03588_ _07342_ _02873_ _03589_ VDD VSS AOI21_X1
X_17173_ _03525_ _03589_ net339 VDD VSS NOR2_X1
X_17174_ _10237_ _03590_ VDD VSS INV_X2
X_17175_ _06724_ net651 _03590_ _05157_ _03591_ VDD VSS AOI22_X1
X_17176_ _03591_ _10288_ _02800_ _02780_ net648 _03592_ VDD
+ VSS OAI221_X1
X_17177_ _03592_ _07376_ _02873_ _03593_ VDD VSS AOI21_X1
X_17178_ _03525_ _03593_ net340 VDD VSS NOR2_X1
X_17179_ _02844_ _10197_ _10234_ _02906_ _03594_ VDD VSS OAI22_X1
X_17180_ _02761_ net704 _10291_ _02801_ _03595_ VDD VSS OAI22_X1
X_17181_ _03594_ _03595_ _03596_ VDD VSS NOR2_X1
X_17182_ _03512_ _07361_ _03597_ VDD VSS NAND2_X1
X_17183_ _03501_ _03596_ _03597_ net341 VDD VSS AOI21_X2
X_17184_ _05156_ _10231_ _10294_ _02799_ _03598_ VDD VSS OAI22_X2
X_17185_ _10327_ _03599_ VDD VSS INV_X2
X_17186_ _03598_ net754 _03372_ _06996_ _03599_ _03600_ VDD
+ VSS AOI221_X2
X_17187_ _03512_ _07601_ _03601_ VDD VSS NAND2_X1
X_17188_ _03501_ _03600_ _03601_ net342 VDD VSS AOI21_X4
X_17189_ _02857_ net731 _10297_ _03212_ _03602_ VDD VSS OAI22_X1
X_17190_ _02844_ _10191_ net670 _02855_ _03603_ VDD VSS OAI22_X1
X_17191_ _03602_ _03603_ _03604_ VDD VSS NOR2_X1
X_17192_ _03512_ _07586_ _03605_ VDD VSS NAND2_X1
X_17193_ _03501_ _03604_ _03605_ net343 VDD VSS AOI21_X2
X_17194_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[4\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[4\]
+ _02770_ _03606_ VDD VSS MUX2_X1
X_17195_ _03606_ _03607_ VDD VSS INV_X1
X_17196_ _02845_ _03607_ _03608_ VDD VSS NAND2_X1
X_17197_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[4\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[4\]
+ _07250_ _03609_ VDD VSS MUX2_X1
X_17198_ _03608_ _03609_ _02845_ _03610_ VDD VSS OAI21_X4
X_17199_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[4\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[4\] _07440_
+ _03611_ VDD VSS MUX2_X1
X_17200_ _07439_ _03611_ _03612_ VDD VSS OR2_X1
X_17201_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[4\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[4\] _07443_
+ _03613_ VDD VSS MUX2_X1
X_17202_ _03612_ _03613_ _07446_ _03614_ VDD VSS OAI21_X4
X_17203_ _02844_ _03610_ _03614_ _02906_ _03615_ VDD VSS OAI22_X2
X_17204_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[4\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[4\] _02763_
+ _03616_ VDD VSS MUX2_X1
X_17205_ _07519_ _03616_ _03617_ VDD VSS OR2_X1
X_17206_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[4\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[4\] _07523_
+ _03618_ VDD VSS MUX2_X1
X_17207_ _03617_ _03618_ _07526_ _03619_ VDD VSS OAI21_X4
X_17208_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[4\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[4\]
+ _02792_ _03620_ VDD VSS MUX2_X1
X_17209_ _02991_ _03620_ _03621_ VDD VSS OR2_X1
X_17210_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[4\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[4\]
+ _02795_ _03622_ VDD VSS MUX2_X1
X_17211_ _03621_ _03622_ _02995_ _03623_ VDD VSS OAI21_X4
X_17212_ _02761_ _03619_ _03623_ _02801_ _03624_ VDD VSS OAI22_X2
X_17213_ _03615_ _03624_ _03625_ VDD VSS NOR2_X2
X_17214_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[4\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[4\]
+ _02810_ _03626_ VDD VSS MUX2_X1
X_17215_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[4\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[4\]
+ _02875_ _03627_ VDD VSS MUX2_X1
X_17216_ _03626_ _03627_ _02812_ _03628_ VDD VSS MUX2_X1
X_17217_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[4\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[4\] _02875_
+ _03629_ VDD VSS MUX2_X1
X_17218_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[4\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[4\] _02882_
+ _03630_ VDD VSS MUX2_X1
X_17219_ _03629_ _03630_ _02879_ _03631_ VDD VSS MUX2_X1
X_17220_ _03628_ _03631_ _02836_ _03632_ VDD VSS MUX2_X1
X_17221_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[4\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[4\]
+ _02877_ _03633_ VDD VSS MUX2_X1
X_17222_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[4\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[4\]
+ _02929_ _03634_ VDD VSS MUX2_X1
X_17223_ _03633_ _03634_ _02890_ _03635_ VDD VSS MUX2_X1
X_17224_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[4\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[4\] _02882_
+ _03636_ VDD VSS MUX2_X1
X_17225_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[4\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[4\] _02888_
+ _03637_ VDD VSS MUX2_X1
X_17226_ _03636_ _03637_ _02890_ _03638_ VDD VSS MUX2_X1
X_17227_ _03635_ _03638_ _02885_ _03639_ VDD VSS MUX2_X1
X_17228_ _03632_ _03639_ _07393_ _03640_ VDD VSS MUX2_X2
X_17229_ _03512_ _03640_ _03641_ VDD VSS NAND2_X1
X_17230_ _05163_ _03625_ _03641_ net344 VDD VSS AOI21_X4
X_17231_ _07445_ _05248_ _03642_ VDD VSS OR2_X1
X_17232_ _03642_ _05249_ _07439_ _03643_ VDD VSS OAI21_X4
X_17233_ _05682_ _03644_ VDD VSS INV_X1
X_17234_ _02776_ _03644_ _03645_ VDD VSS NAND2_X1
X_17235_ _03645_ _05681_ _03470_ _03646_ VDD VSS OAI21_X4
X_17236_ _02857_ _03643_ _03646_ _03025_ _03647_ VDD VSS OAI22_X1
X_17237_ _02791_ _05429_ _03648_ VDD VSS OR2_X1
X_17238_ _03648_ _05430_ _02797_ _03649_ VDD VSS OAI21_X4
X_17239_ _05465_ _05549_ _03650_ VDD VSS OR2_X1
X_17240_ _03650_ _05551_ _07525_ _03651_ VDD VSS OAI21_X4
X_17241_ _03212_ _03649_ _03651_ _06960_ _03652_ VDD VSS OAI22_X1
X_17242_ _02838_ _06448_ _03653_ VDD VSS AND2_X1
X_17243_ _06272_ _06462_ _02836_ _03654_ VDD VSS MUX2_X1
X_17244_ _03653_ _03654_ _05738_ _03655_ VDD VSS AOI21_X4
X_17245_ _03545_ _03655_ _03656_ VDD VSS NOR2_X1
X_17246_ _03647_ _03652_ _03656_ _03657_ VDD VSS NOR3_X1
X_17247_ _03525_ _03657_ net345 VDD VSS NOR2_X2
X_17248_ _03380_ _05189_ _05649_ _03372_ _03658_ VDD VSS AOI22_X1
X_17249_ _07488_ _05412_ _03659_ VDD VSS OR2_X1
X_17250_ _03659_ _05413_ _07499_ _03660_ VDD VSS OAI21_X4
X_17251_ _05465_ _05530_ _03661_ VDD VSS OR2_X1
X_17252_ _03661_ _05531_ _07525_ _03662_ VDD VSS OAI21_X4
X_17253_ _03658_ _03660_ _02800_ _03394_ _03662_ _03663_ VDD
+ VSS OAI221_X1
X_17254_ _03663_ _06249_ _02873_ _03664_ VDD VSS AOI21_X1
X_17255_ _03525_ _03664_ net346 VDD VSS NOR2_X1
X_17256_ _05153_ _05258_ _03665_ VDD VSS AND2_X1
X_17257_ _03665_ _05259_ _07446_ _03666_ VDD VSS AOI21_X4
X_17258_ _05653_ _03667_ VDD VSS INV_X1
X_17259_ _02776_ _03667_ _03668_ VDD VSS NAND2_X1
X_17260_ _03668_ _05652_ _03470_ _03669_ VDD VSS OAI21_X4
X_17261_ _02857_ _03666_ _03669_ _03025_ _03670_ VDD VSS OAI22_X1
X_17262_ _02991_ _05416_ _03671_ VDD VSS OR2_X1
X_17263_ _03671_ _05417_ _02995_ _03672_ VDD VSS OAI21_X4
X_17264_ _05465_ _05584_ _03673_ VDD VSS OR2_X1
X_17265_ _03673_ _05585_ _07525_ _03674_ VDD VSS OAI21_X4
X_17266_ _03212_ _03672_ _03674_ _06960_ _03675_ VDD VSS OAI22_X1
X_17267_ _05737_ _06428_ _03676_ VDD VSS AND2_X1
X_17268_ _03676_ _06283_ _02839_ _03677_ VDD VSS AOI21_X4
X_17269_ _03545_ _03677_ _03678_ VDD VSS NOR2_X1
X_17270_ _03670_ _03675_ _03678_ _03679_ VDD VSS NOR3_X1
X_17271_ _03525_ _03679_ net347 VDD VSS NOR2_X2
X_17272_ _05153_ _05243_ _03680_ VDD VSS AND2_X1
X_17273_ _03680_ _05244_ _07446_ _03681_ VDD VSS AOI21_X4
X_17274_ _03222_ _05580_ _03682_ VDD VSS OR2_X1
X_17275_ _03682_ _05581_ _03227_ _03683_ VDD VSS OAI21_X4
X_17276_ _02857_ _03681_ _03683_ _03394_ _03684_ VDD VSS OAI22_X1
X_17277_ _02991_ _05446_ _03685_ VDD VSS OR2_X1
X_17278_ _03685_ _05447_ _02995_ _03686_ VDD VSS OAI21_X4
X_17279_ _05642_ _03687_ VDD VSS INV_X1
X_17280_ _03233_ _03687_ _03688_ VDD VSS NAND2_X1
X_17281_ _03688_ _05641_ _02941_ _03689_ VDD VSS OAI21_X4
X_17282_ _02869_ _03686_ _03689_ _03235_ _03690_ VDD VSS OAI22_X1
X_17283_ _05922_ _06322_ _03691_ VDD VSS OR2_X1
X_17284_ _03691_ _06329_ _07337_ _03692_ VDD VSS OAI21_X4
X_17285_ _03545_ _03692_ _03693_ VDD VSS NOR2_X1
X_17286_ _03684_ _03690_ _03693_ _03694_ VDD VSS NOR3_X1
X_17287_ _03525_ _03694_ net348 VDD VSS NOR2_X2
X_17288_ _07445_ _05253_ _03695_ VDD VSS OR2_X1
X_17289_ _03695_ _05254_ _07439_ _03696_ VDD VSS OAI21_X4
X_17290_ _05665_ _03697_ VDD VSS INV_X1
X_17291_ _02776_ _03697_ _03698_ VDD VSS NAND2_X1
X_17292_ _03698_ _05664_ _03470_ _03699_ VDD VSS OAI21_X4
X_17293_ _02906_ _03696_ _03699_ _03025_ _03700_ VDD VSS OAI22_X2
X_17294_ _02991_ _05407_ _03701_ VDD VSS OR2_X1
X_17295_ _03701_ _05409_ _02995_ _03702_ VDD VSS OAI21_X4
X_17296_ _05465_ _05558_ _03703_ VDD VSS OR2_X1
X_17297_ _03703_ _05559_ _07525_ _03704_ VDD VSS OAI21_X4
X_17298_ _02869_ _03702_ _03704_ _06960_ _03705_ VDD VSS OAI22_X2
X_17299_ _05738_ _06268_ _03706_ VDD VSS NAND2_X1
X_17300_ _03706_ _06488_ _05738_ _03707_ VDD VSS OAI21_X4
X_17301_ _03545_ _03707_ _03708_ VDD VSS NOR2_X1
X_17302_ _03700_ _03705_ _03708_ _03709_ VDD VSS NOR3_X2
X_17303_ _03525_ _03709_ net349 VDD VSS NOR2_X4
X_17304_ _05163_ _03710_ VDD VSS BUF_X4
X_17305_ _02791_ _05420_ _03711_ VDD VSS OR2_X1
X_17306_ _03711_ _05421_ _02797_ _03712_ VDD VSS OAI21_X4
X_17307_ _05465_ _05571_ _03713_ VDD VSS OR2_X1
X_17308_ _03713_ _05572_ _07525_ _03714_ VDD VSS OAI21_X2
X_17309_ _03212_ _03712_ _03714_ _03394_ _03715_ VDD VSS OAI22_X1
X_17310_ _05153_ _05210_ _03716_ VDD VSS AND2_X1
X_17311_ _03716_ _05212_ _02863_ _03717_ VDD VSS AOI21_X4
X_17312_ _05687_ _03718_ VDD VSS INV_X1
X_17313_ _07244_ _03718_ _03719_ VDD VSS NAND2_X1
X_17314_ _03719_ _05686_ _03233_ _03720_ VDD VSS OAI21_X4
X_17315_ _02783_ _03717_ _03720_ _03235_ _03721_ VDD VSS OAI22_X1
X_17316_ _02838_ _06397_ _03722_ VDD VSS AND2_X1
X_17317_ _03722_ _06477_ _05738_ _03723_ VDD VSS AOI21_X4
X_17318_ _03545_ _03723_ _03724_ VDD VSS NOR2_X1
X_17319_ _03715_ _03721_ _03724_ _03725_ VDD VSS NOR3_X1
X_17320_ _03710_ _03725_ net350 VDD VSS NOR2_X2
X_17321_ _07519_ _05545_ _03726_ VDD VSS OR2_X1
X_17322_ _03726_ _05546_ _07526_ _03727_ VDD VSS OAI21_X4
X_17323_ _05657_ _03728_ VDD VSS INV_X1
X_17324_ _03470_ _03728_ _03729_ VDD VSS NAND2_X1
X_17325_ _03729_ _05656_ _03470_ _03730_ VDD VSS OAI21_X4
X_17326_ _02761_ _03727_ _03730_ _02780_ _03731_ VDD VSS OAI22_X1
X_17327_ _07445_ _05205_ _03732_ VDD VSS OR2_X1
X_17328_ _03732_ _05206_ _07439_ _03733_ VDD VSS OAI21_X2
X_17329_ _07493_ _05398_ _03734_ VDD VSS OR2_X1
X_17330_ _03734_ _05399_ _07499_ _03735_ VDD VSS OAI21_X4
X_17331_ _02857_ _03733_ _03735_ _02801_ _03736_ VDD VSS OAI22_X1
X_17332_ _03731_ _03736_ _03737_ VDD VSS NOR2_X1
X_17333_ _06340_ _06347_ _03738_ VDD VSS NOR2_X4
X_17334_ _03376_ _03738_ _03739_ VDD VSS NAND2_X1
X_17335_ _05163_ _03737_ _03739_ net351 VDD VSS AOI21_X4
X_17336_ _07493_ _05442_ _03740_ VDD VSS OR2_X1
X_17337_ _03740_ _05443_ _07499_ _03741_ VDD VSS OAI21_X4
X_17338_ _03222_ _05535_ _03742_ VDD VSS OR2_X1
X_17339_ _03742_ _05537_ _03227_ _03743_ VDD VSS OAI21_X4
X_17340_ _03212_ _03741_ _03743_ _03394_ _03744_ VDD VSS OAI22_X1
X_17341_ _05153_ _05232_ _03745_ VDD VSS AND2_X1
X_17342_ _03745_ _05233_ _02863_ _03746_ VDD VSS AOI21_X4
X_17343_ _05670_ _03747_ VDD VSS INV_X1
X_17344_ _03233_ _03747_ _03748_ VDD VSS NAND2_X1
X_17345_ _03748_ _05669_ _03233_ _03749_ VDD VSS OAI21_X4
X_17346_ _02783_ _03746_ _03749_ _03235_ _03750_ VDD VSS OAI22_X1
X_17347_ _05737_ _06294_ _03751_ VDD VSS AND2_X1
X_17348_ _03751_ _06304_ _02839_ _03752_ VDD VSS AOI21_X4
X_17349_ _03545_ _03752_ _03753_ VDD VSS NOR2_X1
X_17350_ _03744_ _03750_ _03753_ _03754_ VDD VSS NOR3_X1
X_17351_ _03710_ _03754_ net352 VDD VSS NOR2_X2
X_17352_ _07445_ _05216_ _03755_ VDD VSS OR2_X1
X_17353_ _03755_ _05217_ _07439_ _03756_ VDD VSS OAI21_X4
X_17354_ _05691_ _03757_ VDD VSS INV_X1
X_17355_ _02776_ _03757_ _03758_ VDD VSS NAND2_X1
X_17356_ _03758_ _05690_ _03470_ _03759_ VDD VSS OAI21_X4
X_17357_ _02906_ _03756_ _03759_ _03025_ _03760_ VDD VSS OAI22_X1
X_17358_ _02991_ _05394_ _03761_ VDD VSS OR2_X1
X_17359_ _03761_ _05395_ _02995_ _03762_ VDD VSS OAI21_X2
X_17360_ _05465_ _05526_ _03763_ VDD VSS OR2_X1
X_17361_ _03763_ _05527_ _07525_ _03764_ VDD VSS OAI21_X4
X_17362_ _02869_ _03762_ _03764_ _06960_ _03765_ VDD VSS OAI22_X1
X_17363_ _02838_ _06436_ _03766_ VDD VSS OR2_X1
X_17364_ _03766_ _06456_ _05738_ _03767_ VDD VSS OAI21_X4
X_17365_ _03545_ _03767_ _03768_ VDD VSS NOR2_X1
X_17366_ _03760_ _03765_ _03768_ _03769_ VDD VSS NOR3_X1
X_17367_ _03710_ _03769_ net353 VDD VSS NOR2_X2
X_17368_ _07493_ _05390_ _03770_ VDD VSS OR2_X1
X_17369_ _03770_ _05391_ _07499_ _03771_ VDD VSS OAI21_X2
X_17370_ _03222_ _05567_ _03772_ VDD VSS OR2_X1
X_17371_ _03772_ _05568_ _03227_ _03773_ VDD VSS OAI21_X4
X_17372_ _03212_ _03771_ _03773_ _03394_ _03774_ VDD VSS OAI22_X1
X_17373_ _05153_ _05227_ _03775_ VDD VSS AND2_X1
X_17374_ _03775_ _05228_ _02863_ _03776_ VDD VSS AOI21_X4
X_17375_ _05674_ _03777_ VDD VSS INV_X1
X_17376_ _03233_ _03777_ _03778_ VDD VSS NAND2_X1
X_17377_ _03778_ _05673_ _03233_ _03779_ VDD VSS OAI21_X4
X_17378_ _02783_ _03776_ _03779_ _03235_ _03780_ VDD VSS OAI22_X1
X_17379_ _02838_ _06417_ _03781_ VDD VSS OR2_X1
X_17380_ _03781_ _06387_ _05738_ _03782_ VDD VSS OAI21_X4
X_17381_ _03545_ _03782_ _03783_ VDD VSS NOR2_X1
X_17382_ _03774_ _03780_ _03783_ _03784_ VDD VSS NOR3_X1
X_17383_ _03710_ _03784_ net354 VDD VSS NOR2_X2
X_17384_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[5\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[5\] _03223_
+ _03785_ VDD VSS MUX2_X1
X_17385_ _03222_ _03785_ _03786_ VDD VSS OR2_X1
X_17386_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[5\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[5\] _02938_
+ _03787_ VDD VSS MUX2_X1
X_17387_ _03786_ _03787_ _03227_ _03788_ VDD VSS OAI21_X4
X_17388_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[5\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[5\]
+ _03068_ _03789_ VDD VSS MUX2_X1
X_17389_ _03789_ _03790_ VDD VSS INV_X1
X_17390_ _02941_ _03790_ _03791_ VDD VSS NAND2_X1
X_17391_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[5\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[5\]
+ _07246_ _03792_ VDD VSS MUX2_X1
X_17392_ _03791_ _03792_ _02769_ _03793_ VDD VSS OAI21_X4
X_17393_ _03015_ _03788_ _03793_ _03025_ _03794_ VDD VSS OAI22_X1
X_17394_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[5\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[5\] _02859_
+ _03795_ VDD VSS MUX2_X1
X_17395_ _02858_ _03795_ _03796_ VDD VSS OR2_X1
X_17396_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[5\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[5\] _02950_
+ _03797_ VDD VSS MUX2_X1
X_17397_ _03796_ _03797_ _02789_ _03798_ VDD VSS OAI21_X4
X_17398_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[5\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[5\]
+ _03184_ _03799_ VDD VSS MUX2_X1
X_17399_ _07488_ _03799_ _03800_ VDD VSS OR2_X1
X_17400_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[5\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[5\]
+ _07494_ _03801_ VDD VSS MUX2_X1
X_17401_ _03800_ _03801_ _07499_ _03802_ VDD VSS OAI21_X4
X_17402_ _03066_ _03798_ _03802_ _03351_ _03803_ VDD VSS OAI22_X1
X_17403_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[5\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[5\]
+ _02818_ _03804_ VDD VSS MUX2_X1
X_17404_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[5\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[5\]
+ _03191_ _03805_ VDD VSS MUX2_X1
X_17405_ _03804_ _03805_ _03277_ _03806_ VDD VSS MUX2_X1
X_17406_ _07130_ _03806_ _03807_ VDD VSS NAND2_X1
X_17407_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[5\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[5\] _03280_
+ _03808_ VDD VSS MUX2_X1
X_17408_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[5\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[5\] _03042_
+ _03809_ VDD VSS MUX2_X1
X_17409_ _03808_ _03809_ _02834_ _03810_ VDD VSS MUX2_X1
X_17410_ _07391_ _03810_ _03811_ VDD VSS NAND2_X1
X_17411_ _03036_ _03807_ _03811_ _03812_ VDD VSS NAND3_X2
X_17412_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[5\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[5\]
+ _03047_ _03813_ VDD VSS MUX2_X1
X_17413_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[5\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[5\]
+ _02824_ _03814_ VDD VSS MUX2_X1
X_17414_ _03813_ _03814_ _07336_ _03815_ VDD VSS MUX2_X1
X_17415_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[5\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[5\] _03203_
+ _03816_ VDD VSS MUX2_X1
X_17416_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[5\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[5\] _02830_
+ _03817_ VDD VSS MUX2_X1
X_17417_ _03816_ _03817_ _03206_ _03818_ VDD VSS MUX2_X1
X_17418_ _03815_ _03818_ _03292_ _03819_ VDD VSS MUX2_X1
X_17419_ _03812_ _03819_ _02805_ _03820_ VDD VSS OAI21_X4
X_17420_ _03545_ _03820_ _03821_ VDD VSS NOR2_X1
X_17421_ _03794_ _03803_ _03821_ _03822_ VDD VSS NOR3_X1
X_17422_ _03710_ _03822_ net355 VDD VSS NOR2_X2
X_17423_ _02857_ _05160_ _03823_ VDD VSS NAND2_X1
X_17424_ _03379_ _05427_ _05556_ _06996_ _03824_ VDD VSS AOI22_X1
X_17425_ _03380_ _05194_ _05639_ _03372_ _03825_ VDD VSS AOI22_X1
X_17426_ _06307_ _06466_ _05737_ _03826_ VDD VSS MUX2_X1
X_17427_ _06258_ _03826_ _02815_ _03827_ VDD VSS MUX2_X2
X_17428_ _02873_ _03827_ _03828_ VDD VSS NAND2_X1
X_17429_ _03824_ _03825_ _03828_ _03829_ VDD VSS NAND3_X1
X_17430_ _03823_ _03829_ net356 VDD VSS AND2_X1
X_17431_ _05153_ _05237_ _03830_ VDD VSS AND2_X1
X_17432_ _03830_ _05238_ _02863_ _03831_ VDD VSS AOI21_X4
X_17433_ _03222_ _05563_ _03832_ VDD VSS OR2_X1
X_17434_ _03832_ _05564_ _03227_ _03833_ VDD VSS OAI21_X4
X_17435_ _02906_ _03831_ _03833_ _03394_ _03834_ VDD VSS OAI22_X1
X_17436_ _02791_ _05437_ _03835_ VDD VSS OR2_X1
X_17437_ _03835_ _05438_ _02797_ _03836_ VDD VSS OAI21_X2
X_17438_ _05678_ _03837_ VDD VSS INV_X1
X_17439_ _07244_ _03837_ _03838_ VDD VSS NAND2_X1
X_17440_ _03838_ _05677_ _03233_ _03839_ VDD VSS OAI21_X4
X_17441_ _02869_ _03836_ _03839_ _03235_ _03840_ VDD VSS OAI22_X1
X_17442_ _06370_ _06374_ _05946_ _03841_ VDD VSS MUX2_X1
X_17443_ _02838_ _03841_ _03842_ VDD VSS NAND2_X1
X_17444_ _06400_ _06404_ _05946_ _03843_ VDD VSS MUX2_X1
X_17445_ _05737_ _03843_ _03844_ VDD VSS NAND2_X1
X_17446_ _05922_ _03842_ _03844_ _03845_ VDD VSS NAND3_X1
X_17447_ _06372_ _06375_ _07384_ _03846_ VDD VSS MUX2_X1
X_17448_ _06402_ _06405_ _07384_ _03847_ VDD VSS MUX2_X1
X_17449_ _03846_ _03847_ _05737_ _03848_ VDD VSS MUX2_X1
X_17450_ _03845_ _03848_ _05922_ _03849_ VDD VSS OAI21_X4
X_17451_ _02803_ _03849_ _03850_ VDD VSS NOR2_X1
X_17452_ _03834_ _03840_ _03850_ _03851_ VDD VSS NOR3_X1
X_17453_ _03710_ _03851_ net357 VDD VSS NOR2_X2
X_17454_ _02784_ _05198_ _03852_ VDD VSS AND2_X1
X_17455_ _03852_ _05199_ _07446_ _03853_ VDD VSS AOI21_X4
X_17456_ _07493_ _05433_ _03854_ VDD VSS OR2_X1
X_17457_ _03854_ _05434_ _07499_ _03855_ VDD VSS OAI21_X4
X_17458_ _02857_ _03853_ _03855_ _03212_ _03856_ VDD VSS OAI22_X1
X_17459_ _07519_ _05540_ _03857_ VDD VSS OR2_X1
X_17460_ _03857_ _05541_ _07526_ _03858_ VDD VSS OAI21_X4
X_17461_ _05661_ _03859_ VDD VSS INV_X1
X_17462_ _02776_ _03859_ _03860_ VDD VSS NAND2_X1
X_17463_ _03860_ _05660_ _03470_ _03861_ VDD VSS OAI21_X4
X_17464_ _02761_ _03858_ _03861_ _02780_ _03862_ VDD VSS OAI22_X1
X_17465_ _03856_ _03862_ _03863_ VDD VSS NOR2_X1
X_17466_ _06357_ _06365_ _03864_ VDD VSS NOR2_X4
X_17467_ _03376_ _03864_ _03865_ VDD VSS NAND2_X1
X_17468_ _05163_ _03863_ _03865_ net358 VDD VSS AOI21_X2
X_17469_ _07445_ _05222_ _03866_ VDD VSS OR2_X1
X_17470_ _03866_ _05223_ _07439_ _03867_ VDD VSS OAI21_X4
X_17471_ _05465_ _05575_ _03868_ VDD VSS OR2_X1
X_17472_ _03868_ _05576_ _07525_ _03869_ VDD VSS OAI21_X2
X_17473_ _02906_ _03867_ _03869_ _06960_ _03870_ VDD VSS OAI22_X1
X_17474_ _02991_ _05402_ _03871_ VDD VSS OR2_X1
X_17475_ _03871_ _05403_ _02995_ _03872_ VDD VSS OAI21_X2
X_17476_ _05634_ _03873_ VDD VSS INV_X1
X_17477_ _03233_ _03873_ _03874_ VDD VSS NAND2_X1
X_17478_ _03874_ _05633_ _02941_ _03875_ VDD VSS OAI21_X4
X_17479_ _02869_ _03872_ _03875_ _03235_ _03876_ VDD VSS OAI22_X1
X_17480_ _02803_ _06229_ _03877_ VDD VSS NOR2_X1
X_17481_ _03870_ _03876_ _03877_ _03878_ VDD VSS NOR3_X1
X_17482_ _03710_ _03878_ net359 VDD VSS NOR2_X2
X_17483_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[6\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[6\] _03223_
+ _03879_ VDD VSS MUX2_X1
X_17484_ _03222_ _03879_ _03880_ VDD VSS OR2_X1
X_17485_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[6\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[6\] _02938_
+ _03881_ VDD VSS MUX2_X1
X_17486_ _03880_ _03881_ _03227_ _03882_ VDD VSS OAI21_X4
X_17487_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[6\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[6\]
+ _03068_ _03883_ VDD VSS MUX2_X1
X_17488_ _03883_ _03884_ VDD VSS INV_X1
X_17489_ _02941_ _03884_ _03885_ VDD VSS NAND2_X1
X_17490_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[6\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[6\]
+ _02774_ _03886_ VDD VSS MUX2_X1
X_17491_ _03885_ _03886_ _02769_ _03887_ VDD VSS OAI21_X4
X_17492_ _03015_ _03882_ _03887_ _03235_ _03888_ VDD VSS OAI22_X1
X_17493_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[6\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[6\] _02785_
+ _03889_ VDD VSS MUX2_X1
X_17494_ _02784_ _03889_ _03890_ VDD VSS OR2_X1
X_17495_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[6\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[6\] _02950_
+ _03891_ VDD VSS MUX2_X1
X_17496_ _03890_ _03891_ _02789_ _03892_ VDD VSS OAI21_X4
X_17497_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[6\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[6\]
+ _03184_ _03893_ VDD VSS MUX2_X1
X_17498_ _07488_ _03893_ _03894_ VDD VSS OR2_X1
X_17499_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[6\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[6\]
+ _07494_ _03895_ VDD VSS MUX2_X1
X_17500_ _03894_ _03895_ _07499_ _03896_ VDD VSS OAI21_X4
X_17501_ _03066_ _03892_ _03896_ _03351_ _03897_ VDD VSS OAI22_X1
X_17502_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[6\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[6\]
+ _02818_ _03898_ VDD VSS MUX2_X1
X_17503_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[6\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[6\]
+ _03191_ _03899_ VDD VSS MUX2_X1
X_17504_ _03898_ _03899_ _03277_ _03900_ VDD VSS MUX2_X1
X_17505_ _07130_ _03900_ _03901_ VDD VSS NAND2_X1
X_17506_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[6\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[6\] _03280_
+ _03902_ VDD VSS MUX2_X1
X_17507_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[6\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[6\] _02816_
+ _03903_ VDD VSS MUX2_X1
X_17508_ _03902_ _03903_ _02834_ _03904_ VDD VSS MUX2_X1
X_17509_ _07391_ _03904_ _03905_ VDD VSS NAND2_X1
X_17510_ _02838_ _03901_ _03905_ _03906_ VDD VSS NAND3_X2
X_17511_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[6\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[6\]
+ _07325_ _03907_ VDD VSS MUX2_X1
X_17512_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[6\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[6\]
+ _02824_ _03908_ VDD VSS MUX2_X1
X_17513_ _03907_ _03908_ _07336_ _03909_ VDD VSS MUX2_X1
X_17514_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[6\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[6\] _03203_
+ _03910_ VDD VSS MUX2_X1
X_17515_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[6\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[6\] _02830_
+ _03911_ VDD VSS MUX2_X1
X_17516_ _03910_ _03911_ _03206_ _03912_ VDD VSS MUX2_X1
X_17517_ _03909_ _03912_ _03292_ _03913_ VDD VSS MUX2_X1
X_17518_ _03906_ _03913_ _02805_ _03914_ VDD VSS OAI21_X4
X_17519_ _02803_ _03914_ _03915_ VDD VSS NOR2_X1
X_17520_ _03888_ _03897_ _03915_ _03916_ VDD VSS NOR3_X1
X_17521_ _03710_ _03916_ net360 VDD VSS NOR2_X2
X_17522_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[7\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[7\] _03223_
+ _03917_ VDD VSS MUX2_X1
X_17523_ _03222_ _03917_ _03918_ VDD VSS OR2_X1
X_17524_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[7\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[7\] _07520_
+ _03919_ VDD VSS MUX2_X1
X_17525_ _03918_ _03919_ _03227_ _03920_ VDD VSS OAI21_X4
X_17526_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[7\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[7\]
+ _03068_ _03921_ VDD VSS MUX2_X1
X_17527_ _03921_ _03922_ VDD VSS INV_X1
X_17528_ _02941_ _03922_ _03923_ VDD VSS NAND2_X1
X_17529_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[7\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[7\]
+ _02774_ _03924_ VDD VSS MUX2_X1
X_17530_ _03923_ _03924_ _02776_ _03925_ VDD VSS OAI21_X4
X_17531_ _03015_ _03920_ _03925_ _03235_ _03926_ VDD VSS OAI22_X1
X_17532_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[7\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[7\] _02785_
+ _03927_ VDD VSS MUX2_X1
X_17533_ _02784_ _03927_ _03928_ VDD VSS OR2_X1
X_17534_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[7\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[7\] _07440_
+ _03929_ VDD VSS MUX2_X1
X_17535_ _03928_ _03929_ _07445_ _03930_ VDD VSS OAI21_X4
X_17536_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[7\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[7\]
+ _03184_ _03931_ VDD VSS MUX2_X1
X_17537_ _07488_ _03931_ _03932_ VDD VSS OR2_X1
X_17538_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[7\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[7\]
+ _07494_ _03933_ VDD VSS MUX2_X1
X_17539_ _03932_ _03933_ _07499_ _03934_ VDD VSS OAI21_X4
X_17540_ _03066_ _03930_ _03934_ _03351_ _03935_ VDD VSS OAI22_X1
X_17541_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[7\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[7\]
+ _02818_ _03936_ VDD VSS MUX2_X1
X_17542_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[7\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[7\]
+ _03191_ _03937_ VDD VSS MUX2_X1
X_17543_ _03936_ _03937_ _03277_ _03938_ VDD VSS MUX2_X1
X_17544_ _07130_ _03938_ _03939_ VDD VSS NAND2_X1
X_17545_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[7\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[7\] _03280_
+ _03940_ VDD VSS MUX2_X1
X_17546_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[7\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[7\] _02816_
+ _03941_ VDD VSS MUX2_X1
X_17547_ _03940_ _03941_ _02834_ _03942_ VDD VSS MUX2_X1
X_17548_ _07391_ _03942_ _03943_ VDD VSS NAND2_X1
X_17549_ _02838_ _03939_ _03943_ _03944_ VDD VSS NAND3_X2
X_17550_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[7\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[7\]
+ _07325_ _03945_ VDD VSS MUX2_X1
X_17551_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[7\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[7\]
+ _02824_ _03946_ VDD VSS MUX2_X1
X_17552_ _03945_ _03946_ _07336_ _03947_ VDD VSS MUX2_X1
X_17553_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[7\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[7\] _03203_
+ _03948_ VDD VSS MUX2_X1
X_17554_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[7\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[7\] _02830_
+ _03949_ VDD VSS MUX2_X1
X_17555_ _03948_ _03949_ _03206_ _03950_ VDD VSS MUX2_X1
X_17556_ _03947_ _03950_ _03292_ _03951_ VDD VSS MUX2_X1
X_17557_ _03944_ _03951_ _02805_ _03952_ VDD VSS OAI21_X4
X_17558_ _02803_ _03952_ _03953_ VDD VSS NOR2_X1
X_17559_ _03926_ _03935_ _03953_ _03954_ VDD VSS NOR3_X1
X_17560_ _03710_ _03954_ net361 VDD VSS NOR2_X2
X_17561_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[8\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[8\]
+ _07494_ _03955_ VDD VSS MUX2_X1
X_17562_ _07493_ _03955_ _03956_ VDD VSS OR2_X1
X_17563_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[8\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[8\]
+ _07497_ _03957_ VDD VSS MUX2_X1
X_17564_ _03956_ _03957_ _07499_ _03958_ VDD VSS OAI21_X4
X_17565_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[8\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[8\] _02785_
+ _03959_ VDD VSS MUX2_X1
X_17566_ _02784_ _03959_ _03960_ VDD VSS OR2_X1
X_17567_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[8\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[8\] _02950_
+ _03961_ VDD VSS MUX2_X1
X_17568_ _03960_ _03961_ _02789_ _03962_ VDD VSS OAI21_X4
X_17569_ _03212_ _03958_ _03962_ _02782_ _03963_ VDD VSS OAI22_X1
X_17570_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[8\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[8\] _03223_
+ _03964_ VDD VSS MUX2_X1
X_17571_ _03222_ _03964_ _03965_ VDD VSS OR2_X1
X_17572_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[8\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[8\] _07520_
+ _03966_ VDD VSS MUX2_X1
X_17573_ _03965_ _03966_ _03227_ _03967_ VDD VSS OAI21_X4
X_17574_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[8\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[8\]
+ _03068_ _03968_ VDD VSS MUX2_X1
X_17575_ _03968_ _03969_ VDD VSS INV_X1
X_17576_ _07244_ _03969_ _03970_ VDD VSS NAND2_X1
X_17577_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[8\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[8\]
+ _07246_ _03971_ VDD VSS MUX2_X1
X_17578_ _03970_ _03971_ _03233_ _03972_ VDD VSS OAI21_X4
X_17579_ _02855_ _03967_ _03972_ _03235_ _03973_ VDD VSS OAI22_X1
X_17580_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[8\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[8\]
+ _02818_ _03974_ VDD VSS MUX2_X1
X_17581_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[8\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[8\]
+ _02808_ _03975_ VDD VSS MUX2_X1
X_17582_ _03974_ _03975_ _03277_ _03976_ VDD VSS MUX2_X1
X_17583_ _07130_ _03976_ _03977_ VDD VSS NAND2_X1
X_17584_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[8\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[8\] _03280_
+ _03978_ VDD VSS MUX2_X1
X_17585_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[8\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[8\] _02816_
+ _03979_ VDD VSS MUX2_X1
X_17586_ _03978_ _03979_ _02834_ _03980_ VDD VSS MUX2_X1
X_17587_ _07391_ _03980_ _03981_ VDD VSS NAND2_X1
X_17588_ _02838_ _03977_ _03981_ _03982_ VDD VSS NAND3_X2
X_17589_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[8\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[8\]
+ _07325_ _03983_ VDD VSS MUX2_X1
X_17590_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[8\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[8\]
+ _02824_ _03984_ VDD VSS MUX2_X1
X_17591_ _03983_ _03984_ _07336_ _03985_ VDD VSS MUX2_X1
X_17592_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[8\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[8\] _02826_
+ _03986_ VDD VSS MUX2_X1
X_17593_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[8\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[8\] _02830_
+ _03987_ VDD VSS MUX2_X1
X_17594_ _03986_ _03987_ _02828_ _03988_ VDD VSS MUX2_X1
X_17595_ _03985_ _03988_ _03292_ _03989_ VDD VSS MUX2_X1
X_17596_ _03982_ _03989_ _02805_ _03990_ VDD VSS OAI21_X4
X_17597_ _02803_ _03990_ _03991_ VDD VSS NOR2_X1
X_17598_ _03963_ _03973_ _03991_ _03992_ VDD VSS NOR3_X1
X_17599_ _03710_ _03992_ net362 VDD VSS NOR2_X2
X_17600_ dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[9\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[9\]
+ _02770_ _03993_ VDD VSS MUX2_X1
X_17601_ _03993_ _03994_ VDD VSS INV_X1
X_17602_ _03470_ _03994_ _03995_ VDD VSS NAND2_X1
X_17603_ dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[9\]
+ dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[9\]
+ _02774_ _03996_ VDD VSS MUX2_X1
X_17604_ _03995_ _03996_ _02845_ _03997_ VDD VSS OAI21_X4
X_17605_ dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[9\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[9\] _02859_
+ _03998_ VDD VSS MUX2_X1
X_17606_ _02858_ _03998_ _03999_ VDD VSS OR2_X1
X_17607_ dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[9\]
+ dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[9\] _02950_
+ _04000_ VDD VSS MUX2_X1
X_17608_ _03999_ _04000_ _02863_ _04001_ VDD VSS OAI21_X4
X_17609_ _02780_ _03997_ _04001_ _02782_ _04002_ VDD VSS OAI22_X1
X_17610_ dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[9\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[9\] _03223_
+ _04003_ VDD VSS MUX2_X1
X_17611_ _05465_ _04003_ _04004_ VDD VSS OR2_X1
X_17612_ dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[9\]
+ dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[9\] _07520_
+ _04005_ VDD VSS MUX2_X1
X_17613_ _04004_ _04005_ _07525_ _04006_ VDD VSS OAI21_X4
X_17614_ dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[9\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[9\]
+ _03184_ _04007_ VDD VSS MUX2_X1
X_17615_ _07488_ _04007_ _04008_ VDD VSS OR2_X1
X_17616_ dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[9\]
+ dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[9\]
+ _07494_ _04009_ VDD VSS MUX2_X1
X_17617_ _04008_ _04009_ _07499_ _04010_ VDD VSS OAI21_X4
X_17618_ _02855_ _04006_ _04010_ _03351_ _04011_ VDD VSS OAI22_X1
X_17619_ dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[9\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[9\]
+ _02818_ _04012_ VDD VSS MUX2_X1
X_17620_ dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[9\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[9\]
+ _02808_ _04013_ VDD VSS MUX2_X1
X_17621_ _04012_ _04013_ _03277_ _04014_ VDD VSS MUX2_X1
X_17622_ _07130_ _04014_ _04015_ VDD VSS NAND2_X1
X_17623_ dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[9\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[9\] _03280_
+ _04016_ VDD VSS MUX2_X1
X_17624_ dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[9\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[9\] _02816_
+ _04017_ VDD VSS MUX2_X1
X_17625_ _04016_ _04017_ _02834_ _04018_ VDD VSS MUX2_X1
X_17626_ _07391_ _04018_ _04019_ VDD VSS NAND2_X1
X_17627_ _02838_ _04015_ _04019_ _04020_ VDD VSS NAND3_X2
X_17628_ dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[9\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[9\]
+ _07325_ _04021_ VDD VSS MUX2_X1
X_17629_ dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[9\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[9\]
+ _02824_ _04022_ VDD VSS MUX2_X1
X_17630_ _04021_ _04022_ _07336_ _04023_ VDD VSS MUX2_X1
X_17631_ dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[9\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[9\] _02826_
+ _04024_ VDD VSS MUX2_X1
X_17632_ dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[9\]
+ dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[9\] _02830_
+ _04025_ VDD VSS MUX2_X1
X_17633_ _04024_ _04025_ _02828_ _04026_ VDD VSS MUX2_X1
X_17634_ _04023_ _04026_ _03292_ _04027_ VDD VSS MUX2_X1
X_17635_ _04020_ _04027_ _02805_ _04028_ VDD VSS OAI21_X4
X_17636_ _02803_ _04028_ _04029_ VDD VSS NOR2_X1
X_17637_ _04002_ _04011_ _04029_ _04030_ VDD VSS NOR3_X1
X_17638_ _02843_ _04030_ net363 VDD VSS NOR2_X2
X_17639_ _06086_ _04031_ VDD VSS BUF_X4
X_17640_ _04031_ _04032_ VDD VSS BUF_X4
X_17641_ _00071_ _04033_ VDD VSS CLKBUF_X3
X_17642_ _04033_ _04034_ VDD VSS BUF_X4
X_17643_ _04034_ _04035_ VDD VSS BUF_X4
X_17644_ _06085_ _04036_ VDD VSS BUF_X4
X_17645_ _04035_ _02768_ _02777_ _04036_ _04037_ VDD VSS OAI22_X1
X_17646_ _00073_ _04038_ VDD VSS BUF_X4
X_17647_ _04038_ _04039_ VDD VSS BUF_X4
X_17648_ _07022_ _04040_ VDD VSS BUF_X4
X_17649_ _04040_ _04041_ VDD VSS CLKBUF_X3
X_17650_ _04039_ _02790_ _02798_ _04041_ _04042_ VDD VSS OAI22_X1
X_17651_ _00072_ _04043_ VDD VSS BUF_X4
X_17652_ _04043_ _04044_ VDD VSS CLKBUF_X3
X_17653_ _04044_ _02840_ _04045_ VDD VSS NOR2_X1
X_17654_ _04037_ _04042_ _04045_ _04046_ VDD VSS NOR3_X1
X_17655_ _04032_ _04046_ net364 VDD VSS NOR2_X2
X_17656_ _04031_ _04047_ VDD VSS BUF_X4
X_17657_ _04038_ _04048_ VDD VSS BUF_X4
X_17658_ _04048_ _04049_ VDD VSS BUF_X4
X_17659_ _04035_ _02854_ _02864_ _04049_ _04050_ VDD VSS OAI22_X1
X_17660_ _06085_ _04051_ VDD VSS BUF_X4
X_17661_ _04040_ _04052_ VDD VSS BUF_X4
X_17662_ _04051_ _02850_ _02868_ _04052_ _04053_ VDD VSS OAI22_X1
X_17663_ _04050_ _04053_ _04054_ VDD VSS NOR2_X1
X_17664_ _04043_ _04055_ VDD VSS INV_X1
X_17665_ _04055_ _04056_ VDD VSS BUF_X4
X_17666_ _04056_ _04057_ VDD VSS BUF_X4
X_17667_ _04057_ _02896_ _04058_ VDD VSS NAND2_X1
X_17668_ _04047_ _04054_ _04058_ net365 VDD VSS AOI21_X2
X_17669_ _04048_ _04059_ VDD VSS BUF_X4
X_17670_ _06085_ _04060_ VDD VSS BUF_X4
X_17671_ _04059_ _02905_ _02912_ _04060_ _04061_ VDD VSS OAI22_X2
X_17672_ _04035_ _02901_ _02916_ _04052_ _04062_ VDD VSS OAI22_X2
X_17673_ _04061_ _04062_ _04063_ VDD VSS NOR2_X2
X_17674_ _04057_ _02934_ _04064_ VDD VSS NAND2_X1
X_17675_ _04047_ _04063_ _04064_ net366 VDD VSS AOI21_X4
X_17676_ _04034_ _04065_ VDD VSS CLKBUF_X3
X_17677_ _04065_ _02940_ _02946_ _04036_ _04066_ VDD VSS OAI22_X1
X_17678_ _04039_ _02952_ _02956_ _04041_ _04067_ VDD VSS OAI22_X1
X_17679_ _04044_ _02974_ _04068_ VDD VSS NOR2_X1
X_17680_ _04066_ _04067_ _04068_ _04069_ VDD VSS NOR3_X1
X_17681_ _04032_ _04069_ net367 VDD VSS NOR2_X2
X_17682_ _04035_ _02985_ _02990_ _04049_ _04070_ VDD VSS OAI22_X1
X_17683_ _04051_ _02981_ _02996_ _04052_ _04071_ VDD VSS OAI22_X1
X_17684_ _04070_ _04071_ _04072_ VDD VSS NOR2_X1
X_17685_ _04057_ _03013_ _04073_ VDD VSS NAND2_X1
X_17686_ _04047_ _04072_ _04073_ net368 VDD VSS AOI21_X2
X_17687_ _04065_ _03019_ _03024_ _04036_ _04074_ VDD VSS OAI22_X1
X_17688_ _04039_ _03030_ _03034_ _04041_ _04075_ VDD VSS OAI22_X1
X_17689_ _04044_ _03055_ _04076_ VDD VSS NOR2_X1
X_17690_ _04074_ _04075_ _04076_ _04077_ VDD VSS NOR3_X1
X_17691_ _04032_ _04077_ net369 VDD VSS NOR2_X2
X_17692_ _04038_ _04078_ VDD VSS BUF_X4
X_17693_ _04065_ _03061_ _03065_ _04078_ _04079_ VDD VSS OAI22_X1
X_17694_ _04060_ _03073_ _03077_ _04041_ _04080_ VDD VSS OAI22_X1
X_17695_ _04044_ _03095_ _04081_ VDD VSS NOR2_X1
X_17696_ _04079_ _04080_ _04081_ _04082_ VDD VSS NOR3_X1
X_17697_ _04032_ _04082_ net370 VDD VSS NOR2_X1
X_17698_ _04031_ _04083_ VDD VSS BUF_X8
X_17699_ _04051_ _03102_ _03106_ _04049_ _04084_ VDD VSS OAI22_X1
X_17700_ _04035_ _03111_ _03115_ _04052_ _04085_ VDD VSS OAI22_X1
X_17701_ _04084_ _04085_ _04086_ VDD VSS NOR2_X1
X_17702_ _04057_ _03132_ _04087_ VDD VSS NAND2_X1
X_17703_ _04083_ _04086_ _04087_ net371 VDD VSS AOI21_X2
X_17704_ _04059_ _03141_ _03147_ _04060_ _04088_ VDD VSS OAI22_X2
X_17705_ _04035_ _03137_ _03151_ _04052_ _04089_ VDD VSS OAI22_X2
X_17706_ _04088_ _04089_ _04090_ VDD VSS NOR2_X2
X_17707_ _04057_ _03168_ _04091_ VDD VSS NAND2_X1
X_17708_ _04083_ _04090_ _04091_ net372 VDD VSS AOI21_X4
X_17709_ _04065_ _03173_ _03178_ _04036_ _04092_ VDD VSS OAI22_X1
X_17710_ _04039_ _03183_ _03188_ _04041_ _04093_ VDD VSS OAI22_X1
X_17711_ _04044_ _03209_ _04094_ VDD VSS NOR2_X1
X_17712_ _04092_ _04093_ _04094_ _04095_ VDD VSS NOR3_X1
X_17713_ _04032_ _04095_ net373 VDD VSS NOR2_X1
X_17714_ _04040_ _04096_ VDD VSS BUF_X4
X_17715_ _04096_ _03216_ _03220_ _04078_ _04097_ VDD VSS OAI22_X1
X_17716_ _04034_ _04098_ VDD VSS BUF_X4
X_17717_ _06085_ _04099_ VDD VSS CLKBUF_X3
X_17718_ _04098_ _03228_ _03234_ _04099_ _04100_ VDD VSS OAI22_X1
X_17719_ _04044_ _03253_ _04101_ VDD VSS NOR2_X1
X_17720_ _04097_ _04100_ _04101_ _04102_ VDD VSS NOR3_X1
X_17721_ _04032_ _04102_ net374 VDD VSS NOR2_X2
X_17722_ _04065_ _03259_ _03264_ _04036_ _04103_ VDD VSS OAI22_X1
X_17723_ _04039_ _03269_ _03273_ _04041_ _04104_ VDD VSS OAI22_X1
X_17724_ _04044_ _03294_ _04105_ VDD VSS NOR2_X1
X_17725_ _04103_ _04104_ _04105_ _04106_ VDD VSS NOR3_X1
X_17726_ _04032_ _04106_ net375 VDD VSS NOR2_X1
X_17727_ _04059_ _03305_ _03310_ _04098_ _04107_ VDD VSS OAI22_X2
X_17728_ _04051_ _03301_ _03314_ _04052_ _04108_ VDD VSS OAI22_X2
X_17729_ _04107_ _04108_ _04109_ VDD VSS NOR2_X2
X_17730_ _04057_ _03331_ _04110_ VDD VSS NAND2_X1
X_17731_ _04083_ _04109_ _04110_ net376 VDD VSS AOI21_X4
X_17732_ _04065_ _03336_ _03346_ _04078_ _04111_ VDD VSS OAI22_X1
X_17733_ _04060_ _03341_ _03350_ _04041_ _04112_ VDD VSS OAI22_X1
X_17734_ _04044_ _03369_ _04113_ VDD VSS NOR2_X1
X_17735_ _04111_ _04112_ _04113_ _04114_ VDD VSS NOR3_X1
X_17736_ _04032_ _04114_ net377 VDD VSS NOR2_X1
X_17737_ _04033_ _04115_ VDD VSS INV_X2
X_17738_ _06085_ _04116_ VDD VSS INV_X1
X_17739_ _04116_ _04117_ VDD VSS BUF_X4
X_17740_ _04115_ _05775_ _06080_ _04117_ _04118_ VDD VSS AOI22_X1
X_17741_ _04040_ _04119_ VDD VSS BUF_X4
X_17742_ _04118_ _03374_ _04048_ _04119_ _02494_ _04120_ VDD
+ VSS OAI221_X1
X_17743_ _04055_ _04121_ VDD VSS BUF_X4
X_17744_ _04120_ _07132_ _04121_ _04122_ VDD VSS AOI21_X1
X_17745_ _04032_ _04122_ net378 VDD VSS NOR2_X1
X_17746_ _04038_ _04123_ VDD VSS INV_X1
X_17747_ _04123_ _04124_ VDD VSS BUF_X4
X_17748_ _05754_ _05849_ _05796_ _04124_ _04125_ VDD VSS AOI22_X2
X_17749_ _04033_ _04126_ VDD VSS BUF_X4
X_17750_ _06085_ _04127_ VDD VSS CLKBUF_X3
X_17751_ _04125_ _03383_ _04126_ _04127_ _03382_ _04128_ VDD
+ VSS OAI221_X2
X_17752_ _04128_ _07156_ _04121_ _04129_ VDD VSS AOI21_X1
X_17753_ _04032_ _04129_ net379 VDD VSS NOR2_X1
X_17754_ _04031_ _04130_ VDD VSS CLKBUF_X3
X_17755_ _05754_ _05839_ _05799_ _04124_ _04131_ VDD VSS AOI22_X1
X_17756_ _04131_ _03389_ _04126_ _04127_ _03388_ _04132_ VDD
+ VSS OAI221_X1
X_17757_ _04132_ _05956_ _04121_ _04133_ VDD VSS AOI21_X1
X_17758_ _04130_ _04133_ net380 VDD VSS NOR2_X1
X_17759_ _05754_ _05829_ _05802_ _04124_ _04134_ VDD VSS AOI22_X1
X_17760_ _04134_ _03395_ _04126_ _04127_ _03393_ _04135_ VDD
+ VSS OAI221_X1
X_17761_ _04056_ _04136_ VDD VSS BUF_X4
X_17762_ _04135_ _05902_ _04136_ _04137_ VDD VSS AOI21_X1
X_17763_ _04130_ _04137_ net381 VDD VSS NOR2_X1
X_17764_ _05754_ _05832_ _05792_ _04123_ _04138_ VDD VSS AOI22_X1
X_17765_ _04138_ _03400_ _04126_ _04127_ _03399_ _04139_ VDD
+ VSS OAI221_X1
X_17766_ _04139_ _03403_ _04136_ _04140_ VDD VSS AOI21_X1
X_17767_ _04130_ _04140_ net382 VDD VSS NOR2_X1
X_17768_ _05754_ _05836_ _05809_ _04123_ _04141_ VDD VSS AOI22_X1
X_17769_ _04141_ _07233_ _04126_ _04127_ _07196_ _04142_ VDD
+ VSS OAI221_X1
X_17770_ _04142_ _05972_ _04136_ _04143_ VDD VSS AOI21_X1
X_17771_ _04130_ _04143_ net383 VDD VSS NOR2_X1
X_17772_ _05754_ _05843_ _05806_ _04123_ _04144_ VDD VSS AOI22_X1
X_17773_ _04144_ _07229_ _04126_ _04127_ _07192_ _04145_ VDD
+ VSS OAI221_X1
X_17774_ _04145_ _06008_ _04136_ _04146_ VDD VSS AOI21_X1
X_17775_ _04130_ _04146_ net384 VDD VSS NOR2_X1
X_17776_ _04115_ _05778_ _06071_ _04117_ _04147_ VDD VSS AOI22_X1
X_17777_ _04147_ _03412_ _04048_ _04119_ _07105_ _04148_ VDD
+ VSS OAI221_X1
X_17778_ _04148_ _05993_ _04136_ _04149_ VDD VSS AOI21_X1
X_17779_ _04130_ _04149_ net385 VDD VSS NOR2_X1
X_17780_ _04065_ _03418_ _03422_ _04078_ _04150_ VDD VSS OAI22_X1
X_17781_ _04060_ _03428_ _03432_ _04041_ _04151_ VDD VSS OAI22_X1
X_17782_ _04044_ _03450_ _04152_ VDD VSS NOR2_X1
X_17783_ _04150_ _04151_ _04152_ _04153_ VDD VSS NOR3_X1
X_17784_ _04130_ _04153_ net386 VDD VSS NOR2_X1
X_17785_ _06575_ _06524_ _05492_ _04115_ _04154_ VDD VSS AOI22_X1
X_17786_ _04154_ _05274_ _04048_ _04127_ _06099_ _04155_ VDD
+ VSS OAI221_X1
X_17787_ _04155_ _06179_ _04136_ _04156_ VDD VSS AOI21_X1
X_17788_ _04130_ _04156_ net387 VDD VSS NOR2_X1
X_17789_ _04124_ _06514_ _06100_ _04117_ _04157_ VDD VSS AOI22_X1
X_17790_ _04157_ _06789_ _04126_ _04119_ _05376_ _04158_ VDD
+ VSS OAI221_X1
X_17791_ _04158_ _06146_ _04136_ _04159_ VDD VSS AOI21_X1
X_17792_ _04130_ _04159_ net388 VDD VSS NOR2_X1
X_17793_ _06575_ _05370_ _05613_ _04117_ _04160_ VDD VSS AOI22_X2
X_17794_ _04160_ _06513_ _04048_ _04098_ _06548_ _04161_ VDD
+ VSS OAI221_X2
X_17795_ _04161_ _06163_ _04136_ _04162_ VDD VSS AOI21_X1
X_17796_ _04130_ _04162_ net389 VDD VSS NOR2_X1
X_17797_ _04031_ _04163_ VDD VSS BUF_X4
X_17798_ _04065_ _03465_ _03471_ _04036_ _04164_ VDD VSS OAI22_X1
X_17799_ _04039_ _03476_ _03480_ _04040_ _04165_ VDD VSS OAI22_X1
X_17800_ _04044_ _03498_ _04166_ VDD VSS NOR2_X1
X_17801_ _04164_ _04165_ _04166_ _04167_ VDD VSS NOR3_X1
X_17802_ _04163_ _04167_ net390 VDD VSS NOR2_X1
X_17803_ _04117_ _10225_ _10348_ _04115_ _04168_ VDD VSS AOI22_X1
X_17804_ _04168_ _03502_ _04048_ _04119_ _05327_ _04169_ VDD
+ VSS OAI221_X1
X_17805_ _04169_ _10417_ _04136_ _04170_ VDD VSS AOI21_X1
X_17806_ _04163_ _04170_ net391 VDD VSS NOR2_X1
X_17807_ _04115_ _07302_ net694 _06575_ _04171_ VDD VSS AOI22_X1
X_17808_ _04171_ _10255_ _04048_ _04127_ _10221_ _04172_ VDD
+ VSS OAI221_X1
X_17809_ _04172_ _07676_ _04136_ _04173_ VDD VSS AOI21_X1
X_17810_ _04163_ _04173_ net392 VDD VSS NOR2_X2
X_17811_ _04038_ _10261_ _10357_ _04033_ _04174_ VDD VSS OAI22_X2
X_17812_ _10315_ _04175_ VDD VSS INV_X1
X_17813_ _04174_ _07434_ _04117_ _05754_ _04175_ _04176_ VDD
+ VSS AOI221_X2
X_17814_ _04057_ _07661_ _04177_ VDD VSS NAND2_X1
X_17815_ _04083_ _04176_ _04177_ net393 VDD VSS AOI21_X2
X_17816_ _04038_ _10258_ _10354_ _04033_ _04178_ VDD VSS OAI22_X2
X_17817_ _10312_ _04179_ VDD VSS INV_X1
X_17818_ _04178_ net742 _04117_ _05754_ _04179_ _04180_ VDD
+ VSS AOI221_X2
X_17819_ _04057_ _07409_ _04181_ VDD VSS NAND2_X1
X_17820_ _04083_ _04180_ _04181_ net394 VDD VSS AOI21_X2
X_17821_ _04038_ _10273_ net697 _07022_ _04182_ VDD VSS OAI22_X2
X_17822_ _04182_ _03518_ _04115_ _04117_ net675 _04183_ VDD
+ VSS AOI221_X2
X_17823_ _04057_ _07646_ _04184_ VDD VSS NAND2_X1
X_17824_ _04083_ _04183_ _04184_ net395 VDD VSS AOI21_X2
X_17825_ _04124_ _07279_ net664 _06575_ _04185_ VDD VSS AOI22_X1
X_17826_ _04185_ _10366_ _04034_ _04127_ _10209_ _04186_ VDD
+ VSS OAI221_X1
X_17827_ _04186_ _07631_ _04056_ _04187_ VDD VSS AOI21_X1
X_17828_ _04163_ _04187_ net396 VDD VSS NOR2_X1
X_17829_ _04060_ _03530_ _03534_ _04078_ _04188_ VDD VSS OAI22_X1
X_17830_ _04098_ _03539_ _03543_ _04040_ _04189_ VDD VSS OAI22_X1
X_17831_ _04043_ _04190_ VDD VSS CLKBUF_X3
X_17832_ _04190_ _03562_ _04191_ VDD VSS NOR2_X1
X_17833_ _04188_ _04189_ _04191_ _04192_ VDD VSS NOR3_X1
X_17834_ _04163_ _04192_ net397 VDD VSS NOR2_X2
X_17835_ _04124_ _07473_ _07506_ _06575_ _04193_ VDD VSS AOI22_X1
X_17836_ _04193_ _10363_ _04034_ _04127_ _10206_ _04194_ VDD
+ VSS OAI221_X1
X_17837_ _04194_ _07616_ _04056_ _04195_ VDD VSS AOI21_X1
X_17838_ _04163_ _04195_ net398 VDD VSS NOR2_X1
X_17839_ _04059_ net640 net632 _04096_ _04196_ VDD VSS OAI22_X1
X_17840_ _04051_ net650 net713 _04098_ _04197_ VDD VSS OAI22_X1
X_17841_ _04196_ _04197_ _04198_ VDD VSS NOR2_X1
X_17842_ _04057_ _07394_ _04199_ VDD VSS NAND2_X1
X_17843_ _04083_ _04198_ _04199_ net399 VDD VSS AOI21_X2
X_17844_ _04124_ _10249_ _10276_ _06575_ _04200_ VDD VSS AOI22_X1
X_17845_ _04200_ _03574_ _04034_ _04036_ net685 _04201_ VDD
+ VSS OAI221_X1
X_17846_ _04201_ _10372_ _04056_ _04202_ VDD VSS AOI21_X1
X_17847_ _04163_ _04202_ net400 VDD VSS NOR2_X1
X_17848_ _04035_ _10342_ net771 _04049_ _04203_ VDD VSS OAI22_X1
X_17849_ _04051_ net643 _10279_ _04119_ _04204_ VDD VSS OAI22_X1
X_17850_ _04203_ _04204_ _04205_ VDD VSS NOR2_X1
X_17851_ _04121_ _07556_ _04206_ VDD VSS NAND2_X1
X_17852_ _04083_ _04205_ _04206_ net401 VDD VSS AOI21_X2
X_17853_ _04124_ _03583_ net688 _06575_ _04207_ VDD VSS AOI22_X1
X_17854_ _04207_ net723 _04034_ _04036_ net646 _04208_ VDD
+ VSS OAI221_X1
X_17855_ _04208_ _07571_ _04056_ _04209_ VDD VSS AOI21_X1
X_17856_ _04163_ _04209_ net402 VDD VSS NOR2_X2
X_17857_ _10185_ _04210_ VDD VSS INV_X2
X_17858_ _10285_ _04211_ VDD VSS INV_X1
X_17859_ _04117_ _04210_ _04211_ _06575_ _04212_ VDD VSS AOI22_X1
X_17860_ _04034_ _04213_ VDD VSS BUF_X4
X_17861_ _04212_ _10240_ _04048_ _04213_ _10336_ _04214_ VDD
+ VSS OAI221_X1
X_17862_ _04214_ _07342_ _04056_ _04215_ VDD VSS AOI21_X1
X_17863_ _04163_ _04215_ net403 VDD VSS NOR2_X1
X_17864_ _04051_ net647 _10237_ _04049_ _04216_ VDD VSS OAI22_X1
X_17865_ _04035_ _10333_ _10288_ _04119_ _04217_ VDD VSS OAI22_X1
X_17866_ _04216_ _04217_ _04218_ VDD VSS NOR2_X1
X_17867_ _04121_ _07376_ _04219_ VDD VSS NAND2_X1
X_17868_ _04083_ _04218_ _04219_ net404 VDD VSS AOI21_X2
X_17869_ net686 _04220_ VDD VSS INV_X2
X_17870_ _04117_ _04220_ _07489_ _06575_ _04221_ VDD VSS AOI22_X1
X_17871_ _04221_ net732 _04048_ _04213_ net703 _04222_ VDD
+ VSS OAI221_X1
X_17872_ _04222_ _07361_ _04056_ _04223_ VDD VSS AOI21_X1
X_17873_ _04163_ _04223_ net405 VDD VSS NOR2_X1
X_17874_ _04059_ net751 _10327_ _04098_ _04224_ VDD VSS OAI22_X1
X_17875_ _04051_ _10194_ _10294_ _04119_ _04225_ VDD VSS OAI22_X1
X_17876_ _04224_ _04225_ _04226_ VDD VSS NOR2_X1
X_17877_ _04121_ _07601_ _04227_ VDD VSS NAND2_X1
X_17878_ _04083_ _04226_ _04227_ net406 VDD VSS AOI21_X2
X_17879_ _04051_ _10191_ net670 _04098_ _04228_ VDD VSS OAI22_X1
X_17880_ _04059_ _10228_ _10297_ _04119_ _04229_ VDD VSS OAI22_X1
X_17881_ _04228_ _04229_ _04230_ VDD VSS NOR2_X1
X_17882_ _04121_ _07586_ _04231_ VDD VSS NAND2_X1
X_17883_ _04031_ _04230_ _04231_ net407 VDD VSS AOI21_X4
X_17884_ _04059_ _03614_ _03619_ _04098_ _04232_ VDD VSS OAI22_X1
X_17885_ _04051_ _03610_ _03623_ _04119_ _04233_ VDD VSS OAI22_X1
X_17886_ _04232_ _04233_ _04234_ VDD VSS NOR2_X1
X_17887_ _04121_ _03640_ _04235_ VDD VSS NAND2_X1
X_17888_ _04031_ _04234_ _04235_ net408 VDD VSS AOI21_X2
X_17889_ _04031_ _04236_ VDD VSS BUF_X4
X_17890_ _04059_ _03643_ _03646_ _04036_ _04237_ VDD VSS OAI22_X1
X_17891_ _04096_ _03649_ _03651_ _04213_ _04238_ VDD VSS OAI22_X1
X_17892_ _04190_ _03655_ _04239_ VDD VSS NOR2_X1
X_17893_ _04237_ _04238_ _04239_ _04240_ VDD VSS NOR3_X1
X_17894_ _04236_ _04240_ net409 VDD VSS NOR2_X2
X_17895_ _04124_ _05189_ _05649_ _04116_ _04241_ VDD VSS AOI22_X1
X_17896_ _04241_ _03662_ _04034_ _04041_ _03660_ _04242_ VDD
+ VSS OAI221_X1
X_17897_ _04242_ _06249_ _04056_ _04243_ VDD VSS AOI21_X1
X_17898_ _04236_ _04243_ net410 VDD VSS NOR2_X1
X_17899_ _04049_ _03666_ _03669_ _04036_ _04244_ VDD VSS OAI22_X1
X_17900_ _04096_ _03672_ _03674_ _04213_ _04245_ VDD VSS OAI22_X1
X_17901_ _04190_ _03677_ _04246_ VDD VSS NOR2_X1
X_17902_ _04244_ _04245_ _04246_ _04247_ VDD VSS NOR3_X1
X_17903_ _04236_ _04247_ net411 VDD VSS NOR2_X2
X_17904_ _04049_ _03681_ _03683_ _04213_ _04248_ VDD VSS OAI22_X1
X_17905_ _04052_ _03686_ _03689_ _04099_ _04249_ VDD VSS OAI22_X1
X_17906_ _04190_ _03692_ _04250_ VDD VSS NOR2_X1
X_17907_ _04248_ _04249_ _04250_ _04251_ VDD VSS NOR3_X1
X_17908_ _04236_ _04251_ net412 VDD VSS NOR2_X2
X_17909_ _04049_ _03696_ _03699_ _04099_ _04252_ VDD VSS OAI22_X1
X_17910_ _04052_ _03702_ _03704_ _04126_ _04253_ VDD VSS OAI22_X1
X_17911_ _04190_ _03707_ _04254_ VDD VSS NOR2_X1
X_17912_ _04252_ _04253_ _04254_ _04255_ VDD VSS NOR3_X1
X_17913_ _04236_ _04255_ net413 VDD VSS NOR2_X2
X_17914_ _04096_ _03712_ _03714_ _04213_ _04256_ VDD VSS OAI22_X1
X_17915_ _04039_ _03717_ _03720_ _04099_ _04257_ VDD VSS OAI22_X1
X_17916_ _04190_ _03723_ _04258_ VDD VSS NOR2_X1
X_17917_ _04256_ _04257_ _04258_ _04259_ VDD VSS NOR3_X1
X_17918_ _04236_ _04259_ net414 VDD VSS NOR2_X2
X_17919_ _04035_ _03727_ _03730_ _04060_ _04260_ VDD VSS OAI22_X1
X_17920_ _04059_ _03733_ _03735_ _04119_ _04261_ VDD VSS OAI22_X1
X_17921_ _04260_ _04261_ _04262_ VDD VSS NOR2_X1
X_17922_ _04121_ _03738_ _04263_ VDD VSS NAND2_X1
X_17923_ _04031_ _04262_ _04263_ net415 VDD VSS AOI21_X2
X_17924_ _04096_ _03741_ _03743_ _04213_ _04264_ VDD VSS OAI22_X1
X_17925_ _04039_ _03746_ _03749_ _04099_ _04265_ VDD VSS OAI22_X1
X_17926_ _04190_ _03752_ _04266_ VDD VSS NOR2_X1
X_17927_ _04264_ _04265_ _04266_ _04267_ VDD VSS NOR3_X1
X_17928_ _04236_ _04267_ net416 VDD VSS NOR2_X2
X_17929_ _04049_ _03756_ _03759_ _04099_ _04268_ VDD VSS OAI22_X1
X_17930_ _04052_ _03762_ _03764_ _04126_ _04269_ VDD VSS OAI22_X1
X_17931_ _04190_ _03767_ _04270_ VDD VSS NOR2_X1
X_17932_ _04268_ _04269_ _04270_ _04271_ VDD VSS NOR3_X1
X_17933_ _04236_ _04271_ net417 VDD VSS NOR2_X2
X_17934_ _04096_ _03771_ _03773_ _04213_ _04272_ VDD VSS OAI22_X1
X_17935_ _04039_ _03776_ _03779_ _04099_ _04273_ VDD VSS OAI22_X1
X_17936_ _04190_ _03782_ _04274_ VDD VSS NOR2_X1
X_17937_ _04272_ _04273_ _04274_ _04275_ VDD VSS NOR3_X1
X_17938_ _04236_ _04275_ net418 VDD VSS NOR2_X2
X_17939_ _04065_ _03788_ _03798_ _04078_ _04276_ VDD VSS OAI22_X1
X_17940_ _04060_ _03793_ _03802_ _04040_ _04277_ VDD VSS OAI22_X1
X_17941_ _04190_ _03820_ _04278_ VDD VSS NOR2_X1
X_17942_ _04276_ _04277_ _04278_ _04279_ VDD VSS NOR3_X1
X_17943_ _04236_ _04279_ net419 VDD VSS NOR2_X2
X_17944_ _04124_ _05194_ _05639_ _04116_ _04280_ VDD VSS AOI22_X1
X_17945_ _05556_ _04281_ VDD VSS INV_X1
X_17946_ _05427_ _04282_ VDD VSS INV_X1
X_17947_ _04280_ _04281_ _04034_ _04041_ _04282_ _04283_ VDD
+ VSS OAI221_X1
X_17948_ _04283_ _03827_ _04056_ _04284_ VDD VSS AOI21_X1
X_17949_ _04047_ _04284_ net420 VDD VSS NOR2_X2
X_17950_ _04096_ _03836_ _03833_ _04213_ _04285_ VDD VSS OAI22_X1
X_17951_ _04039_ _03831_ _03839_ _06085_ _04286_ VDD VSS OAI22_X1
X_17952_ _04043_ _03849_ _04287_ VDD VSS NOR2_X1
X_17953_ _04285_ _04286_ _04287_ _04288_ VDD VSS NOR3_X1
X_17954_ _04047_ _04288_ net421 VDD VSS NOR2_X2
X_17955_ _04059_ _03853_ _03855_ _04096_ _04289_ VDD VSS OAI22_X1
X_17956_ _04035_ _03858_ _03861_ _04060_ _04290_ VDD VSS OAI22_X1
X_17957_ _04289_ _04290_ _04291_ VDD VSS NOR2_X1
X_17958_ _04121_ _03864_ _04292_ VDD VSS NAND2_X1
X_17959_ _04031_ _04291_ _04292_ net422 VDD VSS AOI21_X4
X_17960_ _04049_ _03867_ _03875_ _04099_ _04293_ VDD VSS OAI22_X1
X_17961_ _04052_ _03872_ _03869_ _04126_ _04294_ VDD VSS OAI22_X1
X_17962_ _04043_ _06229_ _04295_ VDD VSS NOR2_X1
X_17963_ _04293_ _04294_ _04295_ _04296_ VDD VSS NOR3_X1
X_17964_ _04047_ _04296_ net423 VDD VSS NOR2_X2
X_17965_ _04065_ _03882_ _03887_ _04099_ _04297_ VDD VSS OAI22_X1
X_17966_ _04078_ _03892_ _03896_ _04040_ _04298_ VDD VSS OAI22_X1
X_17967_ _04043_ _03914_ _04299_ VDD VSS NOR2_X1
X_17968_ _04297_ _04298_ _04299_ _04300_ VDD VSS NOR3_X1
X_17969_ _04047_ _04300_ net424 VDD VSS NOR2_X2
X_17970_ _04098_ _03920_ _03925_ _04099_ _04301_ VDD VSS OAI22_X1
X_17971_ _04078_ _03930_ _03934_ _04040_ _04302_ VDD VSS OAI22_X1
X_17972_ _04043_ _03952_ _04303_ VDD VSS NOR2_X1
X_17973_ _04301_ _04302_ _04303_ _04304_ VDD VSS NOR3_X1
X_17974_ _04047_ _04304_ net425 VDD VSS NOR2_X2
X_17975_ _04096_ _03958_ _03967_ _04213_ _04305_ VDD VSS OAI22_X2
X_17976_ _04078_ _03962_ _03972_ _06085_ _04306_ VDD VSS OAI22_X2
X_17977_ _04043_ _03990_ _04307_ VDD VSS NOR2_X1
X_17978_ _04305_ _04306_ _04307_ _04308_ VDD VSS NOR3_X2
X_17979_ _04047_ _04308_ net426 VDD VSS NOR2_X2
X_17980_ _04060_ _03997_ _04001_ _04078_ _04309_ VDD VSS OAI22_X1
X_17981_ _04098_ _04006_ _04010_ _04040_ _04310_ VDD VSS OAI22_X1
X_17982_ _04043_ _04028_ _04311_ VDD VSS NOR2_X1
X_17983_ _04309_ _04310_ _04311_ _04312_ VDD VSS NOR3_X1
X_17984_ _04047_ _04312_ net427 VDD VSS NOR2_X2
X_17985_ _05599_ _04313_ VDD VSS BUF_X4
X_17986_ _04313_ _04314_ VDD VSS BUF_X4
X_17987_ _00065_ _04315_ VDD VSS BUF_X4
X_17988_ _04315_ _04316_ VDD VSS BUF_X4
X_17989_ _04316_ _04317_ VDD VSS BUF_X4
X_17990_ _05592_ _04318_ VDD VSS BUF_X4
X_17991_ _04318_ _04319_ VDD VSS BUF_X4
X_17992_ _04317_ _02768_ _02777_ _04319_ _04320_ VDD VSS OAI22_X1
X_17993_ _00067_ _04321_ VDD VSS BUF_X4
X_17994_ _04321_ _04322_ VDD VSS BUF_X4
X_17995_ _04322_ _04323_ VDD VSS BUF_X4
X_17996_ _00066_ _04324_ VDD VSS BUF_X4
X_17997_ _04324_ _04325_ VDD VSS BUF_X4
X_17998_ _04323_ _02790_ _02798_ _04325_ _04326_ VDD VSS OAI22_X1
X_17999_ _07082_ _04327_ VDD VSS CLKBUF_X3
X_18000_ _04327_ _02840_ _04328_ VDD VSS NOR2_X1
X_18001_ _04320_ _04326_ _04328_ _04329_ VDD VSS NOR3_X1
X_18002_ _04314_ _04329_ net428 VDD VSS NOR2_X2
X_18003_ _04313_ _04330_ VDD VSS BUF_X4
X_18004_ _04318_ _04331_ VDD VSS BUF_X4
X_18005_ _04315_ _04332_ VDD VSS BUF_X4
X_18006_ _04331_ _02850_ _02854_ _04332_ _04333_ VDD VSS OAI22_X1
X_18007_ _04322_ _04334_ VDD VSS BUF_X4
X_18008_ _04324_ _04335_ VDD VSS BUF_X4
X_18009_ _04334_ _02864_ _02868_ _04335_ _04336_ VDD VSS OAI22_X1
X_18010_ _04333_ _04336_ _04337_ VDD VSS NOR2_X1
X_18011_ _06977_ _02896_ _04338_ VDD VSS NAND2_X1
X_18012_ _04330_ _04337_ _04338_ net429 VDD VSS AOI21_X2
X_18013_ _04317_ _02901_ _02905_ _04323_ _04339_ VDD VSS OAI22_X1
X_18014_ _04331_ _02912_ _02916_ _04335_ _04340_ VDD VSS OAI22_X1
X_18015_ _04339_ _04340_ _04341_ VDD VSS NOR2_X1
X_18016_ _06977_ _02934_ _04342_ VDD VSS NAND2_X1
X_18017_ _04330_ _04341_ _04342_ net430 VDD VSS AOI21_X2
X_18018_ _04322_ _04343_ VDD VSS BUF_X4
X_18019_ _04317_ _02940_ _02952_ _04343_ _04344_ VDD VSS OAI22_X2
X_18020_ _04318_ _04345_ VDD VSS BUF_X4
X_18021_ _04345_ _02946_ _02956_ _04325_ _04346_ VDD VSS OAI22_X2
X_18022_ _04327_ _02974_ _04347_ VDD VSS NOR2_X1
X_18023_ _04344_ _04346_ _04347_ _04348_ VDD VSS NOR3_X2
X_18024_ _04314_ _04348_ net431 VDD VSS NOR2_X2
X_18025_ _04331_ _02981_ _02985_ _04332_ _04349_ VDD VSS OAI22_X1
X_18026_ _04334_ _02990_ _02996_ _04335_ _04350_ VDD VSS OAI22_X1
X_18027_ _04349_ _04350_ _04351_ VDD VSS NOR2_X1
X_18028_ _06977_ _03013_ _04352_ VDD VSS NAND2_X1
X_18029_ _04330_ _04351_ _04352_ net432 VDD VSS AOI21_X2
X_18030_ _04315_ _04353_ VDD VSS CLKBUF_X3
X_18031_ _04318_ _04354_ VDD VSS BUF_X4
X_18032_ _04353_ _03019_ _03024_ _04354_ _04355_ VDD VSS OAI22_X1
X_18033_ _04323_ _03030_ _03034_ _04325_ _04356_ VDD VSS OAI22_X1
X_18034_ _04327_ _03055_ _04357_ VDD VSS NOR2_X1
X_18035_ _04355_ _04356_ _04357_ _04358_ VDD VSS NOR3_X1
X_18036_ _04314_ _04358_ net433 VDD VSS NOR2_X2
X_18037_ _04353_ _03061_ _03073_ _04354_ _04359_ VDD VSS OAI22_X1
X_18038_ _04343_ _03065_ _03077_ _04325_ _04360_ VDD VSS OAI22_X1
X_18039_ _04327_ _03095_ _04361_ VDD VSS NOR2_X1
X_18040_ _04359_ _04360_ _04361_ _04362_ VDD VSS NOR3_X1
X_18041_ _04314_ _04362_ net434 VDD VSS NOR2_X2
X_18042_ _04331_ _03102_ _03106_ _04323_ _04363_ VDD VSS OAI22_X1
X_18043_ _04317_ _03111_ _03115_ _04335_ _04364_ VDD VSS OAI22_X1
X_18044_ _04363_ _04364_ _04365_ VDD VSS NOR2_X1
X_18045_ _06977_ _03132_ _04366_ VDD VSS NAND2_X1
X_18046_ _04330_ _04365_ _04366_ net435 VDD VSS AOI21_X2
X_18047_ _04317_ _03137_ _03141_ _04323_ _04367_ VDD VSS OAI22_X2
X_18048_ _04331_ _03147_ _03151_ _04335_ _04368_ VDD VSS OAI22_X2
X_18049_ _04367_ _04368_ _04369_ VDD VSS NOR2_X2
X_18050_ _06977_ _03168_ _04370_ VDD VSS NAND2_X1
X_18051_ _04330_ _04369_ _04370_ net436 VDD VSS AOI21_X4
X_18052_ _04353_ _03173_ _03183_ _04343_ _04371_ VDD VSS OAI22_X1
X_18053_ _04324_ _04372_ VDD VSS CLKBUF_X3
X_18054_ _04345_ _03178_ _03188_ _04372_ _04373_ VDD VSS OAI22_X1
X_18055_ _04327_ _03209_ _04374_ VDD VSS NOR2_X1
X_18056_ _04371_ _04373_ _04374_ _04375_ VDD VSS NOR3_X1
X_18057_ _04314_ _04375_ net437 VDD VSS NOR2_X1
X_18058_ _04324_ _04376_ VDD VSS BUF_X4
X_18059_ _04376_ _03216_ _03220_ _04343_ _04377_ VDD VSS OAI22_X2
X_18060_ _04332_ _03228_ _03234_ _04318_ _04378_ VDD VSS OAI22_X2
X_18061_ _04327_ _03253_ _04379_ VDD VSS NOR2_X1
X_18062_ _04377_ _04378_ _04379_ _04380_ VDD VSS NOR3_X2
X_18063_ _04314_ _04380_ net438 VDD VSS NOR2_X2
X_18064_ _04353_ _03259_ _03264_ _04354_ _04381_ VDD VSS OAI22_X1
X_18065_ _04343_ _03269_ _03273_ _04372_ _04382_ VDD VSS OAI22_X1
X_18066_ _04327_ _03294_ _04383_ VDD VSS NOR2_X1
X_18067_ _04381_ _04382_ _04383_ _04384_ VDD VSS NOR3_X1
X_18068_ _04314_ _04384_ net439 VDD VSS NOR2_X1
X_18069_ _04331_ _03301_ _03305_ _04323_ _04385_ VDD VSS OAI22_X1
X_18070_ _04317_ _03310_ _03314_ _04335_ _04386_ VDD VSS OAI22_X1
X_18071_ _04385_ _04386_ _04387_ VDD VSS NOR2_X1
X_18072_ _06977_ _03331_ _04388_ VDD VSS NAND2_X1
X_18073_ _04330_ _04387_ _04388_ net440 VDD VSS AOI21_X2
X_18074_ _04321_ _04389_ VDD VSS BUF_X4
X_18075_ _04353_ _03336_ _03346_ _04389_ _04390_ VDD VSS OAI22_X1
X_18076_ _04345_ _03341_ _03350_ _04372_ _04391_ VDD VSS OAI22_X1
X_18077_ _04327_ _03369_ _04392_ VDD VSS NOR2_X1
X_18078_ _04390_ _04391_ _04392_ _04393_ VDD VSS NOR3_X1
X_18079_ _04314_ _04393_ net441 VDD VSS NOR2_X1
X_18080_ _04315_ _04394_ VDD VSS INV_X4
X_18081_ _05593_ _04395_ VDD VSS BUF_X4
X_18082_ _04394_ _05775_ _06080_ _04395_ _04396_ VDD VSS AOI22_X1
X_18083_ _04396_ _03374_ _04389_ _04325_ _02494_ _04397_ VDD
+ VSS OAI221_X1
X_18084_ _06916_ _04398_ VDD VSS BUF_X4
X_18085_ _04397_ _07132_ _04398_ _04399_ VDD VSS AOI21_X1
X_18086_ _04314_ _04399_ net442 VDD VSS NOR2_X1
X_18087_ _00066_ _04400_ VDD VSS INV_X4
X_18088_ _04400_ _04401_ VDD VSS BUF_X4
X_18089_ _04321_ _04402_ VDD VSS INV_X1
X_18090_ _04402_ _04403_ VDD VSS BUF_X4
X_18091_ _04401_ _05849_ _05796_ _04403_ _04404_ VDD VSS AOI22_X1
X_18092_ _04404_ _03383_ _04316_ _04319_ _03382_ _04405_ VDD
+ VSS OAI221_X1
X_18093_ _04405_ _07156_ _04398_ _04406_ VDD VSS AOI21_X1
X_18094_ _04314_ _04406_ net443 VDD VSS NOR2_X1
X_18095_ _04313_ _04407_ VDD VSS BUF_X4
X_18096_ _04401_ _05839_ _05799_ _04403_ _04408_ VDD VSS AOI22_X1
X_18097_ _04408_ _03389_ _04316_ _04319_ _03388_ _04409_ VDD
+ VSS OAI221_X1
X_18098_ _04409_ _05956_ _04398_ _04410_ VDD VSS AOI21_X1
X_18099_ _04407_ _04410_ net444 VDD VSS NOR2_X1
X_18100_ _04401_ _05829_ _05802_ _04402_ _04411_ VDD VSS AOI22_X1
X_18101_ _04411_ _03395_ _04316_ _04319_ _03393_ _04412_ VDD
+ VSS OAI221_X1
X_18102_ _04412_ _05902_ _04398_ _04413_ VDD VSS AOI21_X1
X_18103_ _04407_ _04413_ net445 VDD VSS NOR2_X1
X_18104_ _04401_ _05832_ _05792_ _04402_ _04414_ VDD VSS AOI22_X1
X_18105_ _04414_ _03400_ _04316_ _04319_ _03399_ _04415_ VDD
+ VSS OAI221_X1
X_18106_ _04415_ _03403_ _04398_ _04416_ VDD VSS AOI21_X1
X_18107_ _04407_ _04416_ net446 VDD VSS NOR2_X1
X_18108_ _04401_ _05836_ _05809_ _04402_ _04417_ VDD VSS AOI22_X1
X_18109_ _04417_ _07233_ _04316_ _04319_ _07196_ _04418_ VDD
+ VSS OAI221_X1
X_18110_ _04418_ _05972_ _04398_ _04419_ VDD VSS AOI21_X1
X_18111_ _04407_ _04419_ net447 VDD VSS NOR2_X1
X_18112_ _04401_ _05843_ _05806_ _04402_ _04420_ VDD VSS AOI22_X1
X_18113_ _04420_ _07229_ _04316_ _04319_ _07192_ _04421_ VDD
+ VSS OAI221_X1
X_18114_ _04421_ _06008_ _04398_ _04422_ VDD VSS AOI21_X1
X_18115_ _04407_ _04422_ net448 VDD VSS NOR2_X1
X_18116_ _04394_ _05778_ _06071_ _04395_ _04423_ VDD VSS AOI22_X2
X_18117_ _04423_ _03412_ _04389_ _04325_ _07105_ _04424_ VDD
+ VSS OAI221_X2
X_18118_ _04424_ _05993_ _04398_ _04425_ VDD VSS AOI21_X1
X_18119_ _04407_ _04425_ net449 VDD VSS NOR2_X1
X_18120_ _04353_ _03418_ _03422_ _04389_ _04426_ VDD VSS OAI22_X1
X_18121_ _04345_ _03428_ _03432_ _04372_ _04427_ VDD VSS OAI22_X1
X_18122_ _04327_ _03450_ _04428_ VDD VSS NOR2_X1
X_18123_ _04426_ _04427_ _04428_ _04429_ VDD VSS NOR3_X1
X_18124_ _04407_ _04429_ net450 VDD VSS NOR2_X1
X_18125_ _04401_ _06524_ _05492_ _04394_ _04430_ VDD VSS AOI22_X1
X_18126_ _04430_ _05274_ _04389_ _04319_ _06099_ _04431_ VDD
+ VSS OAI221_X1
X_18127_ _06916_ _04432_ VDD VSS BUF_X4
X_18128_ _04431_ _06179_ _04432_ _04433_ VDD VSS AOI21_X1
X_18129_ _04407_ _04433_ net451 VDD VSS NOR2_X1
X_18130_ _04403_ _06514_ _06100_ _05593_ _04434_ VDD VSS AOI22_X2
X_18131_ _04434_ _05376_ _04324_ _04332_ _06789_ _04435_ VDD
+ VSS OAI221_X2
X_18132_ _04435_ _06146_ _04432_ _04436_ VDD VSS AOI21_X2
X_18133_ _04407_ _04436_ net452 VDD VSS NOR2_X2
X_18134_ _04401_ _05370_ _05500_ _04394_ _04437_ VDD VSS AOI22_X1
X_18135_ _04437_ _06513_ _04322_ _04319_ _06098_ _04438_ VDD
+ VSS OAI221_X1
X_18136_ _04438_ _06163_ _04432_ _04439_ VDD VSS AOI21_X1
X_18137_ _04407_ _04439_ net453 VDD VSS NOR2_X1
X_18138_ _04313_ _04440_ VDD VSS BUF_X4
X_18139_ _04353_ _03465_ _03471_ _04354_ _04441_ VDD VSS OAI22_X1
X_18140_ _04343_ _03476_ _03480_ _04372_ _04442_ VDD VSS OAI22_X1
X_18141_ _04327_ _03498_ _04443_ VDD VSS NOR2_X1
X_18142_ _04441_ _04442_ _04443_ _04444_ VDD VSS NOR3_X1
X_18143_ _04440_ _04444_ net454 VDD VSS NOR2_X1
X_18144_ _04395_ _10225_ _10321_ _04400_ _04445_ VDD VSS AOI22_X1
X_18145_ _10348_ _04446_ VDD VSS INV_X1
X_18146_ _04445_ _03502_ _04322_ _04332_ _04446_ _04447_ VDD
+ VSS OAI221_X1
X_18147_ _04447_ _10417_ _04432_ _04448_ VDD VSS AOI21_X1
X_18148_ _04440_ _04448_ net455 VDD VSS NOR2_X2
X_18149_ _04315_ _10351_ _10255_ _04321_ _04449_ VDD VSS OAI22_X2
X_18150_ _10221_ _04450_ VDD VSS INV_X1
X_18151_ _04449_ net694 _04400_ _04395_ _04450_ _04451_ VDD
+ VSS AOI221_X2
X_18152_ _06977_ _07676_ _04452_ VDD VSS NAND2_X1
X_18153_ _04330_ _04451_ _04452_ net456 VDD VSS AOI21_X2
X_18154_ _04313_ _04453_ VDD VSS BUF_X8
X_18155_ _04322_ _10261_ _10357_ _04315_ _04454_ VDD VSS OAI22_X2
X_18156_ _04454_ _04175_ _04400_ _04395_ _07434_ _04455_ VDD
+ VSS AOI221_X2
X_18157_ _06977_ _07661_ _04456_ VDD VSS NAND2_X1
X_18158_ _04453_ _04455_ _04456_ net457 VDD VSS AOI21_X2
X_18159_ _04395_ net742 _07305_ _04394_ _04457_ VDD VSS AOI22_X1
X_18160_ _04457_ _10258_ _04322_ _04325_ _10312_ _04458_ VDD
+ VSS OAI221_X1
X_18161_ _04458_ _07409_ _04432_ _04459_ VDD VSS AOI21_X1
X_18162_ _04440_ _04459_ net458 VDD VSS NOR2_X2
X_18163_ _04403_ _07282_ net673 _05593_ _04460_ VDD VSS AOI22_X1
X_18164_ _04315_ _04461_ VDD VSS BUF_X4
X_18165_ _04460_ net697 _04324_ _04461_ _10369_ _04462_ VDD
+ VSS OAI221_X1
X_18166_ _04462_ _07646_ _04432_ _04463_ VDD VSS AOI21_X1
X_18167_ _04440_ _04463_ net459 VDD VSS NOR2_X2
X_18168_ _04322_ _10270_ _10209_ _05592_ _04464_ VDD VSS OAI22_X2
X_18169_ _04464_ net665 _04400_ _04394_ _03522_ _04465_ VDD
+ VSS AOI221_X2
X_18170_ _06977_ _07631_ _04466_ VDD VSS NAND2_X1
X_18171_ _04453_ _04465_ _04466_ net460 VDD VSS AOI21_X2
X_18172_ _04331_ _03530_ _03534_ _04389_ _04467_ VDD VSS OAI22_X1
X_18173_ _04332_ _03539_ _03543_ _04372_ _04468_ VDD VSS OAI22_X1
X_18174_ _07082_ _04469_ VDD VSS CLKBUF_X3
X_18175_ _04469_ _03562_ _04470_ VDD VSS NOR2_X1
X_18176_ _04467_ _04468_ _04470_ _04471_ VDD VSS NOR3_X1
X_18177_ _04440_ _04471_ net461 VDD VSS NOR2_X2
X_18178_ _04403_ _07473_ _07506_ _04400_ _04472_ VDD VSS AOI22_X1
X_18179_ _04472_ _10363_ _04316_ _04319_ _10206_ _04473_ VDD
+ VSS OAI221_X1
X_18180_ _04473_ _07616_ _04432_ _04474_ VDD VSS AOI21_X1
X_18181_ _04440_ _04474_ net462 VDD VSS NOR2_X1
X_18182_ _04334_ net640 net713 _04332_ _04475_ VDD VSS OAI22_X1
X_18183_ _04331_ net650 net632 _04335_ _04476_ VDD VSS OAI22_X1
X_18184_ _04475_ _04476_ _04477_ VDD VSS NOR2_X1
X_18185_ _06916_ _04478_ VDD VSS CLKBUF_X3
X_18186_ _04478_ _07394_ _04479_ VDD VSS NAND2_X1
X_18187_ _04453_ _04477_ _04479_ net463 VDD VSS AOI21_X2
X_18188_ _04403_ _10249_ _10345_ _04394_ _04480_ VDD VSS AOI22_X1
X_18189_ _04395_ _10179_ _10276_ _04401_ _04481_ VDD VSS AOI22_X1
X_18190_ _04480_ _04481_ _04482_ VDD VSS NAND2_X1
X_18191_ _04482_ _10372_ _04432_ _04483_ VDD VSS AOI21_X1
X_18192_ _04440_ _04483_ net464 VDD VSS NOR2_X2
X_18193_ _05592_ net643 _10246_ _04321_ _04484_ VDD VSS OAI22_X2
X_18194_ _04484_ _03578_ _04400_ _04394_ _03577_ _04485_ VDD
+ VSS AOI221_X2
X_18195_ _04478_ _07556_ _04486_ VDD VSS NAND2_X1
X_18196_ _04453_ _04485_ _04486_ net465 VDD VSS AOI21_X4
X_18197_ _05592_ net645 net723 _04315_ _04487_ VDD VSS OAI22_X2
X_18198_ _04487_ _03583_ _04403_ _04401_ net690 _04488_ VDD
+ VSS AOI221_X2
X_18199_ _04478_ _07571_ _04489_ VDD VSS NAND2_X1
X_18200_ _04453_ _04488_ _04489_ net466 VDD VSS AOI21_X4
X_18201_ _04322_ _10240_ _10336_ _04315_ _04490_ VDD VSS OAI22_X2
X_18202_ _04490_ _04211_ _04400_ _04395_ _04210_ _04491_ VDD
+ VSS AOI221_X2
X_18203_ _04478_ _07342_ _04492_ VDD VSS NAND2_X1
X_18204_ _04453_ _04491_ _04492_ net467 VDD VSS AOI21_X4
X_18205_ _05592_ net647 _10288_ _04324_ _04493_ VDD VSS OAI22_X2
X_18206_ _04493_ _03590_ _04403_ _04394_ net652 _04494_ VDD
+ VSS AOI221_X2
X_18207_ _04478_ _07376_ _04495_ VDD VSS NAND2_X1
X_18208_ _04453_ _04494_ _04495_ net468 VDD VSS AOI21_X2
X_18209_ _04315_ net703 net732 _04321_ _04496_ VDD VSS OAI22_X2
X_18210_ _04496_ _07489_ _04400_ _04395_ _04220_ _04497_ VDD
+ VSS AOI221_X2
X_18211_ _04478_ _07361_ _04498_ VDD VSS NAND2_X1
X_18212_ _04453_ _04497_ _04498_ net469 VDD VSS AOI21_X4
X_18213_ _04322_ net750 _10294_ _04324_ _04499_ VDD VSS OAI22_X2
X_18214_ _04499_ _03599_ _04394_ _04395_ net752 _04500_ VDD
+ VSS AOI221_X2
X_18215_ _04478_ _07601_ _04501_ VDD VSS NAND2_X1
X_18216_ _04453_ _04500_ _04501_ net470 VDD VSS AOI21_X2
X_18217_ _04334_ _10228_ net671 _04332_ _04502_ VDD VSS OAI22_X1
X_18218_ _04331_ _10191_ _10297_ _04325_ _04503_ VDD VSS OAI22_X1
X_18219_ _04502_ _04503_ _04504_ VDD VSS NOR2_X1
X_18220_ _04478_ _07586_ _04505_ VDD VSS NAND2_X1
X_18221_ _04453_ _04504_ _04505_ net471 VDD VSS AOI21_X2
X_18222_ _04331_ _03610_ _03614_ _04323_ _04506_ VDD VSS OAI22_X1
X_18223_ _04317_ _03619_ _03623_ _04325_ _04507_ VDD VSS OAI22_X1
X_18224_ _04506_ _04507_ _04508_ VDD VSS NOR2_X1
X_18225_ _04478_ _03640_ _04509_ VDD VSS NAND2_X1
X_18226_ _04313_ _04508_ _04509_ net472 VDD VSS AOI21_X2
X_18227_ _04334_ _03643_ _03646_ _04354_ _04510_ VDD VSS OAI22_X1
X_18228_ _04376_ _03649_ _03651_ _04461_ _04511_ VDD VSS OAI22_X1
X_18229_ _04469_ _03655_ _04512_ VDD VSS NOR2_X1
X_18230_ _04510_ _04511_ _04512_ _04513_ VDD VSS NOR3_X1
X_18231_ _04440_ _04513_ net473 VDD VSS NOR2_X1
X_18232_ _04403_ _05189_ _05649_ _05593_ _04514_ VDD VSS AOI22_X1
X_18233_ _04514_ _03660_ _04324_ _04461_ _03662_ _04515_ VDD
+ VSS OAI221_X1
X_18234_ _04515_ _06249_ _04432_ _04516_ VDD VSS AOI21_X1
X_18235_ _04440_ _04516_ net474 VDD VSS NOR2_X2
X_18236_ _04334_ _03666_ _03669_ _04354_ _04517_ VDD VSS OAI22_X1
X_18237_ _04376_ _03672_ _03674_ _04461_ _04518_ VDD VSS OAI22_X1
X_18238_ _04469_ _03677_ _04519_ VDD VSS NOR2_X1
X_18239_ _04517_ _04518_ _04519_ _04520_ VDD VSS NOR3_X1
X_18240_ _04440_ _04520_ net475 VDD VSS NOR2_X1
X_18241_ _04334_ _03681_ _03686_ _04376_ _04521_ VDD VSS OAI22_X2
X_18242_ _04317_ _03683_ _03689_ _04345_ _04522_ VDD VSS OAI22_X2
X_18243_ _04521_ _04522_ _04523_ VDD VSS NOR2_X2
X_18244_ _04478_ _06330_ _04524_ VDD VSS NAND2_X1
X_18245_ _04313_ _04523_ _04524_ net476 VDD VSS AOI21_X4
X_18246_ _04313_ _04525_ VDD VSS BUF_X4
X_18247_ _04334_ _03696_ _03699_ _04354_ _04526_ VDD VSS OAI22_X2
X_18248_ _04376_ _03702_ _03704_ _04461_ _04527_ VDD VSS OAI22_X2
X_18249_ _04469_ _03707_ _04528_ VDD VSS NOR2_X1
X_18250_ _04526_ _04527_ _04528_ _04529_ VDD VSS NOR3_X2
X_18251_ _04525_ _04529_ net477 VDD VSS NOR2_X4
X_18252_ _04323_ _03717_ _03720_ _04354_ _04530_ VDD VSS OAI22_X1
X_18253_ _04335_ _03712_ _03714_ _04461_ _04531_ VDD VSS OAI22_X1
X_18254_ _04469_ _03723_ _04532_ VDD VSS NOR2_X1
X_18255_ _04530_ _04531_ _04532_ _04533_ VDD VSS NOR3_X1
X_18256_ _04525_ _04533_ net478 VDD VSS NOR2_X2
X_18257_ _04317_ _03727_ _03730_ _04345_ _04534_ VDD VSS OAI22_X1
X_18258_ _04334_ _03733_ _03735_ _04325_ _04535_ VDD VSS OAI22_X1
X_18259_ _04534_ _04535_ _04536_ VDD VSS NOR2_X1
X_18260_ _04398_ _03738_ _04537_ VDD VSS NAND2_X1
X_18261_ _04313_ _04536_ _04537_ net479 VDD VSS AOI21_X2
X_18262_ _04376_ _03741_ _03743_ _04461_ _04538_ VDD VSS OAI22_X1
X_18263_ _04343_ _03746_ _03749_ _04318_ _04539_ VDD VSS OAI22_X1
X_18264_ _04469_ _03752_ _04540_ VDD VSS NOR2_X1
X_18265_ _04538_ _04539_ _04540_ _04541_ VDD VSS NOR3_X1
X_18266_ _04525_ _04541_ net480 VDD VSS NOR2_X2
X_18267_ _04323_ _03756_ _03759_ _04354_ _04542_ VDD VSS OAI22_X1
X_18268_ _04335_ _03762_ _03764_ _04316_ _04543_ VDD VSS OAI22_X1
X_18269_ _04469_ _03767_ _04544_ VDD VSS NOR2_X1
X_18270_ _04542_ _04543_ _04544_ _04545_ VDD VSS NOR3_X1
X_18271_ _04525_ _04545_ net481 VDD VSS NOR2_X2
X_18272_ _04376_ _03771_ _03773_ _04461_ _04546_ VDD VSS OAI22_X1
X_18273_ _04343_ _03776_ _03779_ _04318_ _04547_ VDD VSS OAI22_X1
X_18274_ _04469_ _03782_ _04548_ VDD VSS NOR2_X1
X_18275_ _04546_ _04547_ _04548_ _04549_ VDD VSS NOR3_X1
X_18276_ _04525_ _04549_ net482 VDD VSS NOR2_X2
X_18277_ _04353_ _03788_ _03798_ _04389_ _04550_ VDD VSS OAI22_X1
X_18278_ _04345_ _03793_ _03802_ _04372_ _04551_ VDD VSS OAI22_X1
X_18279_ _04469_ _03820_ _04552_ VDD VSS NOR2_X1
X_18280_ _04550_ _04551_ _04552_ _04553_ VDD VSS NOR3_X1
X_18281_ _04525_ _04553_ net483 VDD VSS NOR2_X2
X_18282_ _04403_ _05194_ _05639_ _05593_ _04554_ VDD VSS AOI22_X1
X_18283_ _04554_ _04282_ _04324_ _04461_ _04281_ _04555_ VDD
+ VSS OAI221_X1
X_18284_ _04555_ _03827_ _04432_ _04556_ VDD VSS AOI21_X1
X_18285_ _04525_ _04556_ net484 VDD VSS NOR2_X1
X_18286_ _04376_ _03836_ _03833_ _04461_ _04557_ VDD VSS OAI22_X1
X_18287_ _04343_ _03831_ _03839_ _04318_ _04558_ VDD VSS OAI22_X1
X_18288_ _04469_ _03849_ _04559_ VDD VSS NOR2_X1
X_18289_ _04557_ _04558_ _04559_ _04560_ VDD VSS NOR3_X1
X_18290_ _04525_ _04560_ net485 VDD VSS NOR2_X2
X_18291_ _04334_ _03853_ _03855_ _04376_ _04561_ VDD VSS OAI22_X1
X_18292_ _04317_ _03858_ _03861_ _04345_ _04562_ VDD VSS OAI22_X1
X_18293_ _04561_ _04562_ _04563_ VDD VSS NOR2_X1
X_18294_ _04398_ _03864_ _04564_ VDD VSS NAND2_X1
X_18295_ _04313_ _04563_ _04564_ net486 VDD VSS AOI21_X2
X_18296_ _04323_ _03867_ _03875_ _04354_ _04565_ VDD VSS OAI22_X1
X_18297_ _04335_ _03872_ _03869_ _04316_ _04566_ VDD VSS OAI22_X1
X_18298_ _07082_ _06229_ _04567_ VDD VSS NOR2_X1
X_18299_ _04565_ _04566_ _04567_ _04568_ VDD VSS NOR3_X1
X_18300_ _04525_ _04568_ net487 VDD VSS NOR2_X2
X_18301_ _04353_ _03882_ _03892_ _04389_ _04569_ VDD VSS OAI22_X1
X_18302_ _04345_ _03887_ _03896_ _04372_ _04570_ VDD VSS OAI22_X1
X_18303_ _07082_ _03914_ _04571_ VDD VSS NOR2_X1
X_18304_ _04569_ _04570_ _04571_ _04572_ VDD VSS NOR3_X1
X_18305_ _04525_ _04572_ net488 VDD VSS NOR2_X2
X_18306_ _04353_ _03920_ _03925_ _04318_ _04573_ VDD VSS OAI22_X1
X_18307_ _04343_ _03930_ _03934_ _04372_ _04574_ VDD VSS OAI22_X1
X_18308_ _07082_ _03952_ _04575_ VDD VSS NOR2_X1
X_18309_ _04573_ _04574_ _04575_ _04576_ VDD VSS NOR3_X1
X_18310_ _04330_ _04576_ net489 VDD VSS NOR2_X2
X_18311_ _04376_ _03958_ _03962_ _04389_ _04577_ VDD VSS OAI22_X1
X_18312_ _04332_ _03967_ _03972_ _04318_ _04578_ VDD VSS OAI22_X1
X_18313_ _07082_ _03990_ _04579_ VDD VSS NOR2_X1
X_18314_ _04577_ _04578_ _04579_ _04580_ VDD VSS NOR3_X1
X_18315_ _04330_ _04580_ net490 VDD VSS NOR2_X2
X_18316_ _04345_ _03997_ _04001_ _04389_ _04581_ VDD VSS OAI22_X1
X_18317_ _04332_ _04006_ _04010_ _04372_ _04582_ VDD VSS OAI22_X1
X_18318_ _07082_ _04028_ _04583_ VDD VSS NOR2_X1
X_18319_ _04581_ _04582_ _04583_ _04584_ VDD VSS NOR3_X1
X_18320_ _04330_ _04584_ net491 VDD VSS NOR2_X2
X_18321_ _05334_ _04585_ VDD VSS BUF_X8
X_18322_ _04585_ _04586_ VDD VSS BUF_X4
X_18323_ _00070_ _04587_ VDD VSS BUF_X4
X_18324_ _04587_ _04588_ VDD VSS BUF_X4
X_18325_ _04588_ _04589_ VDD VSS BUF_X4
X_18326_ _00069_ _04590_ VDD VSS BUF_X4
X_18327_ _04590_ _04591_ VDD VSS BUF_X4
X_18328_ _04591_ _04592_ VDD VSS BUF_X4
X_18329_ _04589_ _02768_ _02790_ _04592_ _04593_ VDD VSS OAI22_X1
X_18330_ _05328_ _04594_ VDD VSS BUF_X4
X_18331_ _04594_ _04595_ VDD VSS BUF_X4
X_18332_ _06860_ _02777_ _02798_ _04595_ _04596_ VDD VSS OAI22_X1
X_18333_ _00068_ _04597_ VDD VSS BUF_X4
X_18334_ _04597_ _04598_ VDD VSS CLKBUF_X3
X_18335_ _04598_ _02840_ _04599_ VDD VSS NOR2_X1
X_18336_ _04593_ _04596_ _04599_ _04600_ VDD VSS NOR3_X1
X_18337_ _04586_ _04600_ net492 VDD VSS NOR2_X2
X_18338_ _04585_ _04601_ VDD VSS BUF_X4
X_18339_ _06859_ _04602_ VDD VSS BUF_X4
X_18340_ _04588_ _04603_ VDD VSS BUF_X4
X_18341_ _04602_ _02850_ _02854_ _04603_ _04604_ VDD VSS OAI22_X1
X_18342_ _04591_ _04605_ VDD VSS BUF_X4
X_18343_ _04594_ _04606_ VDD VSS BUF_X4
X_18344_ _04605_ _02864_ _02868_ _04606_ _04607_ VDD VSS OAI22_X1
X_18345_ _04604_ _04607_ _04608_ VDD VSS NOR2_X1
X_18346_ _04597_ _04609_ VDD VSS INV_X1
X_18347_ _04609_ _04610_ VDD VSS BUF_X4
X_18348_ _04610_ _04611_ VDD VSS BUF_X4
X_18349_ _04611_ _02896_ _04612_ VDD VSS NAND2_X1
X_18350_ _04601_ _04608_ _04612_ net493 VDD VSS AOI21_X2
X_18351_ _04605_ _02905_ _02912_ _06860_ _04613_ VDD VSS OAI22_X1
X_18352_ _04589_ _02901_ _02916_ _04606_ _04614_ VDD VSS OAI22_X1
X_18353_ _04613_ _04614_ _04615_ VDD VSS NOR2_X1
X_18354_ _04611_ _02934_ _04616_ VDD VSS NAND2_X1
X_18355_ _04601_ _04615_ _04616_ net494 VDD VSS AOI21_X2
X_18356_ _06858_ _04617_ VDD VSS BUF_X4
X_18357_ _04589_ _02940_ _02946_ _04617_ _04618_ VDD VSS OAI22_X2
X_18358_ _04591_ _04619_ VDD VSS BUF_X4
X_18359_ _04619_ _02952_ _02956_ _04595_ _04620_ VDD VSS OAI22_X2
X_18360_ _04598_ _02974_ _04621_ VDD VSS NOR2_X1
X_18361_ _04618_ _04620_ _04621_ _04622_ VDD VSS NOR3_X2
X_18362_ _04586_ _04622_ net495 VDD VSS NOR2_X2
X_18363_ _04602_ _02981_ _02985_ _04603_ _04623_ VDD VSS OAI22_X1
X_18364_ _04605_ _02990_ _02996_ _04606_ _04624_ VDD VSS OAI22_X1
X_18365_ _04623_ _04624_ _04625_ VDD VSS NOR2_X1
X_18366_ _04611_ _03013_ _04626_ VDD VSS NAND2_X1
X_18367_ _04601_ _04625_ _04626_ net496 VDD VSS AOI21_X2
X_18368_ _04589_ _03019_ _03030_ _04592_ _04627_ VDD VSS OAI22_X1
X_18369_ _06860_ _03024_ _03034_ _04595_ _04628_ VDD VSS OAI22_X1
X_18370_ _04598_ _03055_ _04629_ VDD VSS NOR2_X1
X_18371_ _04627_ _04628_ _04629_ _04630_ VDD VSS NOR3_X1
X_18372_ _04586_ _04630_ net497 VDD VSS NOR2_X2
X_18373_ _04589_ _03061_ _03065_ _04592_ _04631_ VDD VSS OAI22_X1
X_18374_ _06860_ _03073_ _03077_ _04595_ _04632_ VDD VSS OAI22_X1
X_18375_ _04598_ _03095_ _04633_ VDD VSS NOR2_X1
X_18376_ _04631_ _04632_ _04633_ _04634_ VDD VSS NOR3_X1
X_18377_ _04586_ _04634_ net498 VDD VSS NOR2_X2
X_18378_ _04588_ _04635_ VDD VSS BUF_X4
X_18379_ _04605_ _03106_ _03111_ _04635_ _04636_ VDD VSS OAI22_X1
X_18380_ _04602_ _03102_ _03115_ _04606_ _04637_ VDD VSS OAI22_X1
X_18381_ _04636_ _04637_ _04638_ VDD VSS NOR2_X1
X_18382_ _04611_ _03132_ _04639_ VDD VSS NAND2_X1
X_18383_ _04601_ _04638_ _04639_ net499 VDD VSS AOI21_X2
X_18384_ _04589_ _03137_ _03141_ _04619_ _04640_ VDD VSS OAI22_X1
X_18385_ _04602_ _03147_ _03151_ _04606_ _04641_ VDD VSS OAI22_X1
X_18386_ _04640_ _04641_ _04642_ VDD VSS NOR2_X1
X_18387_ _04611_ _03168_ _04643_ VDD VSS NAND2_X1
X_18388_ _04601_ _04642_ _04643_ net500 VDD VSS AOI21_X2
X_18389_ _04603_ _03173_ _03178_ _04617_ _04644_ VDD VSS OAI22_X1
X_18390_ _04619_ _03183_ _03188_ _04595_ _04645_ VDD VSS OAI22_X1
X_18391_ _04598_ _03209_ _04646_ VDD VSS NOR2_X1
X_18392_ _04644_ _04645_ _04646_ _04647_ VDD VSS NOR3_X1
X_18393_ _04586_ _04647_ net501 VDD VSS NOR2_X1
X_18394_ _04594_ _04648_ VDD VSS BUF_X4
X_18395_ _04590_ _04649_ VDD VSS BUF_X4
X_18396_ _04648_ _03216_ _03220_ _04649_ _04650_ VDD VSS OAI22_X1
X_18397_ _04635_ _03228_ _03234_ _06859_ _04651_ VDD VSS OAI22_X1
X_18398_ _04598_ _03253_ _04652_ VDD VSS NOR2_X1
X_18399_ _04650_ _04651_ _04652_ _04653_ VDD VSS NOR3_X1
X_18400_ _04586_ _04653_ net502 VDD VSS NOR2_X2
X_18401_ _04603_ _03259_ _03269_ _04649_ _04654_ VDD VSS OAI22_X1
X_18402_ _06860_ _03264_ _03273_ _04595_ _04655_ VDD VSS OAI22_X1
X_18403_ _04598_ _03294_ _04656_ VDD VSS NOR2_X1
X_18404_ _04654_ _04655_ _04656_ _04657_ VDD VSS NOR3_X1
X_18405_ _04586_ _04657_ net503 VDD VSS NOR2_X1
X_18406_ _04602_ _03301_ _03305_ _04619_ _04658_ VDD VSS OAI22_X1
X_18407_ _04589_ _03310_ _03314_ _04606_ _04659_ VDD VSS OAI22_X1
X_18408_ _04658_ _04659_ _04660_ VDD VSS NOR2_X1
X_18409_ _04611_ _03331_ _04661_ VDD VSS NAND2_X1
X_18410_ _04601_ _04660_ _04661_ net504 VDD VSS AOI21_X2
X_18411_ _04603_ _03336_ _03341_ _04617_ _04662_ VDD VSS OAI22_X1
X_18412_ _04592_ _03346_ _03350_ _04595_ _04663_ VDD VSS OAI22_X1
X_18413_ _04598_ _03369_ _04664_ VDD VSS NOR2_X1
X_18414_ _04662_ _04663_ _04664_ _04665_ VDD VSS NOR3_X1
X_18415_ _04586_ _04665_ net505 VDD VSS NOR2_X1
X_18416_ _04587_ _04666_ VDD VSS INV_X1
X_18417_ _04666_ _04667_ VDD VSS BUF_X4
X_18418_ _04667_ _05775_ _06080_ _06806_ _04668_ VDD VSS AOI22_X1
X_18419_ _04594_ _04669_ VDD VSS BUF_X4
X_18420_ _04668_ _03374_ _04649_ _04669_ _02494_ _04670_ VDD
+ VSS OAI221_X1
X_18421_ _04609_ _04671_ VDD VSS CLKBUF_X3
X_18422_ _04670_ _07132_ _04671_ _04672_ VDD VSS AOI21_X1
X_18423_ _04586_ _04672_ net506 VDD VSS NOR2_X1
X_18424_ _05328_ _04673_ VDD VSS INV_X2
X_18425_ _04673_ _04674_ VDD VSS BUF_X4
X_18426_ _04590_ _04675_ VDD VSS INV_X1
X_18427_ _04675_ _04676_ VDD VSS BUF_X4
X_18428_ _04674_ _05849_ _05796_ _04676_ _04677_ VDD VSS AOI22_X1
X_18429_ _04587_ _04678_ VDD VSS BUF_X4
X_18430_ _06858_ _04679_ VDD VSS BUF_X4
X_18431_ _04677_ _03383_ _04678_ _04679_ _03382_ _04680_ VDD
+ VSS OAI221_X1
X_18432_ _04680_ _07156_ _04671_ _04681_ VDD VSS AOI21_X1
X_18433_ _04586_ _04681_ net507 VDD VSS NOR2_X1
X_18434_ _04585_ _04682_ VDD VSS BUF_X4
X_18435_ _04674_ _05839_ _05799_ _04676_ _04683_ VDD VSS AOI22_X2
X_18436_ _04683_ _03389_ _04678_ _04679_ _03388_ _04684_ VDD
+ VSS OAI221_X2
X_18437_ _04684_ _05956_ _04671_ _04685_ VDD VSS AOI21_X1
X_18438_ _04682_ _04685_ net508 VDD VSS NOR2_X1
X_18439_ _04674_ _05829_ _05802_ _04676_ _04686_ VDD VSS AOI22_X1
X_18440_ _04686_ _03395_ _04678_ _04679_ _03393_ _04687_ VDD
+ VSS OAI221_X1
X_18441_ _04687_ _05902_ _04671_ _04688_ VDD VSS AOI21_X1
X_18442_ _04682_ _04688_ net509 VDD VSS NOR2_X1
X_18443_ _04674_ _05832_ _05792_ _04675_ _04689_ VDD VSS AOI22_X1
X_18444_ _04689_ _03400_ _04588_ _04679_ _03399_ _04690_ VDD
+ VSS OAI221_X1
X_18445_ _04690_ _03403_ _04671_ _04691_ VDD VSS AOI21_X1
X_18446_ _04682_ _04691_ net510 VDD VSS NOR2_X1
X_18447_ _04674_ _05836_ _05809_ _04675_ _04692_ VDD VSS AOI22_X1
X_18448_ _04692_ _07233_ _04588_ _04679_ _07196_ _04693_ VDD
+ VSS OAI221_X1
X_18449_ _04693_ _05972_ _04671_ _04694_ VDD VSS AOI21_X1
X_18450_ _04682_ _04694_ net511 VDD VSS NOR2_X2
X_18451_ _04674_ _05843_ _05806_ _04675_ _04695_ VDD VSS AOI22_X1
X_18452_ _04695_ _07229_ _04588_ _04679_ _07192_ _04696_ VDD
+ VSS OAI221_X1
X_18453_ _04696_ _06008_ _04671_ _04697_ VDD VSS AOI21_X1
X_18454_ _04682_ _04697_ net512 VDD VSS NOR2_X1
X_18455_ _04667_ _05778_ _06071_ _06806_ _04698_ VDD VSS AOI22_X2
X_18456_ _04698_ _03412_ _04649_ _04669_ _07105_ _04699_ VDD
+ VSS OAI221_X2
X_18457_ _04699_ _05993_ _04671_ _04700_ VDD VSS AOI21_X2
X_18458_ _04682_ _04700_ net513 VDD VSS NOR2_X2
X_18459_ _04603_ _03418_ _03422_ _04649_ _04701_ VDD VSS OAI22_X1
X_18460_ _06860_ _03428_ _03432_ _04595_ _04702_ VDD VSS OAI22_X1
X_18461_ _04598_ _03450_ _04703_ VDD VSS NOR2_X1
X_18462_ _04701_ _04702_ _04703_ _04704_ VDD VSS NOR3_X1
X_18463_ _04682_ _04704_ net514 VDD VSS NOR2_X1
X_18464_ _04674_ _06524_ _05492_ _04667_ _04705_ VDD VSS AOI22_X1
X_18465_ _04705_ _05274_ _04649_ _04679_ _06099_ _04706_ VDD
+ VSS OAI221_X1
X_18466_ _04706_ _06179_ _04671_ _04707_ VDD VSS AOI21_X1
X_18467_ _04682_ _04707_ net515 VDD VSS NOR2_X1
X_18468_ _04585_ _04708_ VDD VSS BUF_X4
X_18469_ _04594_ _05376_ _06789_ _04587_ _04709_ VDD VSS OAI22_X2
X_18470_ _04709_ _06514_ _04676_ _06807_ _06100_ _04710_ VDD
+ VSS AOI221_X2
X_18471_ _04611_ _06146_ _04711_ VDD VSS NAND2_X1
X_18472_ _04708_ _04710_ _04711_ net516 VDD VSS AOI21_X2
X_18473_ _04674_ _05370_ _05500_ _04667_ _04712_ VDD VSS AOI22_X1
X_18474_ _04712_ _06513_ _04591_ _04679_ _06098_ _04713_ VDD
+ VSS OAI221_X1
X_18475_ _04713_ _06163_ _04671_ _04714_ VDD VSS AOI21_X1
X_18476_ _04682_ _04714_ net517 VDD VSS NOR2_X1
X_18477_ _04603_ _03465_ _03471_ _04617_ _04715_ VDD VSS OAI22_X1
X_18478_ _04592_ _03476_ _03480_ _04595_ _04716_ VDD VSS OAI22_X1
X_18479_ _04598_ _03498_ _04717_ VDD VSS NOR2_X1
X_18480_ _04715_ _04716_ _04717_ _04718_ VDD VSS NOR3_X1
X_18481_ _04682_ _04718_ net518 VDD VSS NOR2_X1
X_18482_ _04591_ _03502_ _05327_ _05328_ _04719_ VDD VSS OAI22_X2
X_18483_ _04719_ _10348_ _04667_ _06807_ _10225_ _04720_ VDD
+ VSS AOI221_X2
X_18484_ _04611_ _10417_ _04721_ VDD VSS NAND2_X1
X_18485_ _04708_ _04720_ _04721_ net519 VDD VSS AOI21_X4
X_18486_ _04587_ _10351_ _10255_ _04590_ _04722_ VDD VSS OAI22_X2
X_18487_ _04722_ net694 _04674_ _06807_ _04450_ _04723_ VDD
+ VSS AOI221_X2
X_18488_ _04611_ _07676_ _04724_ VDD VSS NAND2_X1
X_18489_ _04708_ _04723_ _04724_ net520 VDD VSS AOI21_X2
X_18490_ _04585_ _04725_ VDD VSS BUF_X4
X_18491_ _06807_ _07434_ _03510_ _04667_ _04726_ VDD VSS AOI22_X1
X_18492_ _04726_ _10261_ _04591_ _04669_ _10315_ _04727_ VDD
+ VSS OAI221_X1
X_18493_ _04727_ _07661_ _04610_ _04728_ VDD VSS AOI21_X1
X_18494_ _04725_ _04728_ net521 VDD VSS NOR2_X1
X_18495_ _06807_ _07267_ _07305_ _04666_ _04729_ VDD VSS AOI22_X1
X_18496_ _04729_ _10258_ _04591_ _04669_ _10312_ _04730_ VDD
+ VSS OAI221_X1
X_18497_ _04730_ _07409_ _04610_ _04731_ VDD VSS AOI21_X1
X_18498_ _04725_ _04731_ net522 VDD VSS NOR2_X2
X_18499_ _04676_ _07282_ _07431_ _06806_ _04732_ VDD VSS AOI22_X1
X_18500_ _04732_ _10369_ _04588_ _04669_ net697 _04733_ VDD
+ VSS OAI221_X1
X_18501_ _04733_ _07646_ _04610_ _04734_ VDD VSS AOI21_X1
X_18502_ _04725_ _04734_ net523 VDD VSS NOR2_X1
X_18503_ _04591_ _10270_ _10209_ _06858_ _04735_ VDD VSS OAI22_X2
X_18504_ _04735_ _03522_ _04667_ _04674_ net665 _04736_ VDD
+ VSS AOI221_X2
X_18505_ _04611_ _07631_ _04737_ VDD VSS NAND2_X1
X_18506_ _04708_ _04736_ _04737_ net524 VDD VSS AOI21_X2
X_18507_ _04602_ _03530_ _03539_ _04635_ _04738_ VDD VSS OAI22_X1
X_18508_ _04592_ _03534_ _03543_ _04594_ _04739_ VDD VSS OAI22_X1
X_18509_ _04597_ _04740_ VDD VSS CLKBUF_X3
X_18510_ _04740_ _03562_ _04741_ VDD VSS NOR2_X1
X_18511_ _04738_ _04739_ _04741_ _04742_ VDD VSS NOR3_X1
X_18512_ _04725_ _04742_ net525 VDD VSS NOR2_X2
X_18513_ _06858_ _10206_ _10303_ _05328_ _04743_ VDD VSS OAI22_X2
X_18514_ _04743_ _03566_ _04667_ _04676_ _07473_ _04744_ VDD
+ VSS AOI221_X2
X_18515_ _04610_ _04745_ VDD VSS BUF_X4
X_18516_ _04745_ _07616_ _04746_ VDD VSS NAND2_X1
X_18517_ _04708_ _04744_ _04746_ net526 VDD VSS AOI21_X4
X_18518_ _04605_ net640 net713 _04635_ _04747_ VDD VSS OAI22_X2
X_18519_ _04602_ net650 net632 _04606_ _04748_ VDD VSS OAI22_X2
X_18520_ _04747_ _04748_ _04749_ VDD VSS NOR2_X2
X_18521_ _04745_ _07394_ _04750_ VDD VSS NAND2_X1
X_18522_ _04708_ _04749_ _04750_ net527 VDD VSS AOI21_X4
X_18523_ _04676_ _10249_ _10276_ _04673_ _04751_ VDD VSS AOI22_X1
X_18524_ _04751_ _03574_ _04588_ _04679_ net685 _04752_ VDD
+ VSS OAI221_X1
X_18525_ _04752_ _10372_ _04610_ _04753_ VDD VSS AOI21_X1
X_18526_ _04725_ _04753_ net528 VDD VSS NOR2_X1
X_18527_ _04587_ _10342_ _10279_ _05328_ _04754_ VDD VSS OAI22_X1
X_18528_ _04754_ _04755_ VDD VSS INV_X1
X_18529_ _04755_ net771 _04591_ _04617_ net643 _04756_ VDD
+ VSS OAI221_X1
X_18530_ _04756_ _07556_ _04610_ _04757_ VDD VSS AOI21_X1
X_18531_ _04725_ _04757_ net529 VDD VSS NOR2_X1
X_18532_ _04590_ _10243_ net723 _04587_ _04758_ VDD VSS OAI22_X2
X_18533_ net645 _04759_ VDD VSS INV_X1
X_18534_ _04758_ net690 _04673_ _06807_ _04759_ _04760_ VDD
+ VSS AOI221_X2
X_18535_ _04745_ _07571_ _04761_ VDD VSS NAND2_X1
X_18536_ _04708_ _04760_ _04761_ net530 VDD VSS AOI21_X2
X_18537_ _04590_ _10240_ _10285_ _05328_ _04762_ VDD VSS OAI22_X2
X_18538_ _04762_ _07296_ _04667_ _06807_ _04210_ _04763_ VDD
+ VSS AOI221_X2
X_18539_ _04745_ _07342_ _04764_ VDD VSS NAND2_X1
X_18540_ _04708_ _04763_ _04764_ net531 VDD VSS AOI21_X2
X_18541_ _06858_ net647 _10288_ _05328_ _04765_ VDD VSS OAI22_X2
X_18542_ _04765_ net651 _04667_ _04676_ _03590_ _04766_ VDD
+ VSS AOI221_X2
X_18543_ _04745_ _07376_ _04767_ VDD VSS NAND2_X1
X_18544_ _04708_ _04766_ _04767_ net532 VDD VSS AOI21_X2
X_18545_ _04587_ net703 _10234_ _04590_ _04768_ VDD VSS OAI22_X2
X_18546_ _04768_ _07489_ _04673_ _06807_ _04220_ _04769_ VDD
+ VSS AOI221_X2
X_18547_ _04745_ _07361_ _04770_ VDD VSS NAND2_X1
X_18548_ _04708_ _04769_ _04770_ net533 VDD VSS AOI21_X2
X_18549_ _06806_ net752 _03599_ _04666_ _04771_ VDD VSS AOI22_X1
X_18550_ _04771_ net750 _04591_ _04669_ _10294_ _04772_ VDD
+ VSS OAI221_X1
X_18551_ _04772_ _07601_ _04610_ _04773_ VDD VSS AOI21_X1
X_18552_ _04725_ _04773_ net534 VDD VSS NOR2_X2
X_18553_ _04605_ net731 net670 _04635_ _04774_ VDD VSS OAI22_X1
X_18554_ _04602_ _10191_ _10297_ _04669_ _04775_ VDD VSS OAI22_X1
X_18555_ _04774_ _04775_ _04776_ VDD VSS NOR2_X1
X_18556_ _04745_ _07586_ _04777_ VDD VSS NAND2_X1
X_18557_ _04585_ _04776_ _04777_ net535 VDD VSS AOI21_X4
X_18558_ _04602_ _03610_ _03614_ _04619_ _04778_ VDD VSS OAI22_X1
X_18559_ _04589_ _03619_ _03623_ _04669_ _04779_ VDD VSS OAI22_X1
X_18560_ _04778_ _04779_ _04780_ VDD VSS NOR2_X1
X_18561_ _04745_ _03640_ _04781_ VDD VSS NAND2_X1
X_18562_ _04585_ _04780_ _04781_ net536 VDD VSS AOI21_X4
X_18563_ _04605_ _03643_ _03646_ _04617_ _04782_ VDD VSS OAI22_X2
X_18564_ _04648_ _03649_ _03651_ _04678_ _04783_ VDD VSS OAI22_X2
X_18565_ _04740_ _03655_ _04784_ VDD VSS NOR2_X1
X_18566_ _04782_ _04783_ _04784_ _04785_ VDD VSS NOR3_X2
X_18567_ _04725_ _04785_ net537 VDD VSS NOR2_X4
X_18568_ _04676_ _05189_ _05649_ _06806_ _04786_ VDD VSS AOI22_X1
X_18569_ _04786_ _03662_ _04588_ _04669_ _03660_ _04787_ VDD
+ VSS OAI221_X1
X_18570_ _04787_ _06249_ _04610_ _04788_ VDD VSS AOI21_X1
X_18571_ _04725_ _04788_ net538 VDD VSS NOR2_X2
X_18572_ _04605_ _03666_ _03669_ _04617_ _04789_ VDD VSS OAI22_X2
X_18573_ _04648_ _03672_ _03674_ _04678_ _04790_ VDD VSS OAI22_X2
X_18574_ _04740_ _03677_ _04791_ VDD VSS NOR2_X1
X_18575_ _04789_ _04790_ _04791_ _04792_ VDD VSS NOR3_X2
X_18576_ _04725_ _04792_ net539 VDD VSS NOR2_X4
X_18577_ _04585_ _04793_ VDD VSS BUF_X4
X_18578_ _04619_ _03681_ _03683_ _04635_ _04794_ VDD VSS OAI22_X2
X_18579_ _04648_ _03686_ _03689_ _06859_ _04795_ VDD VSS OAI22_X2
X_18580_ _04740_ _03692_ _04796_ VDD VSS NOR2_X1
X_18581_ _04794_ _04795_ _04796_ _04797_ VDD VSS NOR3_X2
X_18582_ _04793_ _04797_ net540 VDD VSS NOR2_X2
X_18583_ _04619_ _03696_ _03699_ _04617_ _04798_ VDD VSS OAI22_X2
X_18584_ _04648_ _03702_ _03704_ _04678_ _04799_ VDD VSS OAI22_X2
X_18585_ _04740_ _03707_ _04800_ VDD VSS NOR2_X1
X_18586_ _04798_ _04799_ _04800_ _04801_ VDD VSS NOR3_X2
X_18587_ _04793_ _04801_ net541 VDD VSS NOR2_X2
X_18588_ _04619_ _03717_ _03720_ _04617_ _04802_ VDD VSS OAI22_X1
X_18589_ _04606_ _03712_ _03714_ _04678_ _04803_ VDD VSS OAI22_X1
X_18590_ _04740_ _03723_ _04804_ VDD VSS NOR2_X1
X_18591_ _04802_ _04803_ _04804_ _04805_ VDD VSS NOR3_X1
X_18592_ _04793_ _04805_ net542 VDD VSS NOR2_X2
X_18593_ _04589_ _03727_ _03730_ _06860_ _04806_ VDD VSS OAI22_X1
X_18594_ _04605_ _03733_ _03735_ _04669_ _04807_ VDD VSS OAI22_X1
X_18595_ _04806_ _04807_ _04808_ VDD VSS NOR2_X1
X_18596_ _04745_ _03738_ _04809_ VDD VSS NAND2_X1
X_18597_ _04585_ _04808_ _04809_ net543 VDD VSS AOI21_X4
X_18598_ _04648_ _03741_ _03743_ _04635_ _04810_ VDD VSS OAI22_X2
X_18599_ _04592_ _03746_ _03749_ _06859_ _04811_ VDD VSS OAI22_X2
X_18600_ _04740_ _03752_ _04812_ VDD VSS NOR2_X1
X_18601_ _04810_ _04811_ _04812_ _04813_ VDD VSS NOR3_X2
X_18602_ _04793_ _04813_ net544 VDD VSS NOR2_X2
X_18603_ _04619_ _03756_ _03759_ _04617_ _04814_ VDD VSS OAI22_X1
X_18604_ _04606_ _03762_ _03764_ _04678_ _04815_ VDD VSS OAI22_X1
X_18605_ _04740_ _03767_ _04816_ VDD VSS NOR2_X1
X_18606_ _04814_ _04815_ _04816_ _04817_ VDD VSS NOR3_X1
X_18607_ _04793_ _04817_ net545 VDD VSS NOR2_X2
X_18608_ _04648_ _03771_ _03773_ _04635_ _04818_ VDD VSS OAI22_X1
X_18609_ _04592_ _03776_ _03779_ _06859_ _04819_ VDD VSS OAI22_X1
X_18610_ _04740_ _03782_ _04820_ VDD VSS NOR2_X1
X_18611_ _04818_ _04819_ _04820_ _04821_ VDD VSS NOR3_X1
X_18612_ _04793_ _04821_ net546 VDD VSS NOR2_X2
X_18613_ _04603_ _03788_ _03798_ _04649_ _04822_ VDD VSS OAI22_X2
X_18614_ _06860_ _03793_ _03802_ _04594_ _04823_ VDD VSS OAI22_X2
X_18615_ _04740_ _03820_ _04824_ VDD VSS NOR2_X1
X_18616_ _04822_ _04823_ _04824_ _04825_ VDD VSS NOR3_X2
X_18617_ _04793_ _04825_ net547 VDD VSS NOR2_X2
X_18618_ _04676_ _05194_ _05639_ _06806_ _04826_ VDD VSS AOI22_X2
X_18619_ _04826_ _04281_ _04588_ _04595_ _04282_ _04827_ VDD
+ VSS OAI221_X2
X_18620_ _04827_ _03827_ _04610_ _04828_ VDD VSS AOI21_X2
X_18621_ _04793_ _04828_ net548 VDD VSS NOR2_X2
X_18622_ _04648_ _03836_ _03833_ _04678_ _04829_ VDD VSS OAI22_X2
X_18623_ _04592_ _03831_ _03839_ _06859_ _04830_ VDD VSS OAI22_X2
X_18624_ _04597_ _03849_ _04831_ VDD VSS NOR2_X1
X_18625_ _04829_ _04830_ _04831_ _04832_ VDD VSS NOR3_X2
X_18626_ _04793_ _04832_ net549 VDD VSS NOR2_X2
X_18627_ _04605_ _03853_ _03855_ _04648_ _04833_ VDD VSS OAI22_X2
X_18628_ _04589_ _03858_ _03861_ _04679_ _04834_ VDD VSS OAI22_X2
X_18629_ _04833_ _04834_ _04835_ VDD VSS NOR2_X2
X_18630_ _04745_ _03864_ _04836_ VDD VSS NAND2_X1
X_18631_ _04585_ _04835_ _04836_ net550 VDD VSS AOI21_X4
X_18632_ _04619_ _03867_ _03869_ _04678_ _04837_ VDD VSS OAI22_X1
X_18633_ _04606_ _03872_ _03875_ _06859_ _04838_ VDD VSS OAI22_X1
X_18634_ _04597_ _06229_ _04839_ VDD VSS NOR2_X1
X_18635_ _04837_ _04838_ _04839_ _04840_ VDD VSS NOR3_X1
X_18636_ _04793_ _04840_ net551 VDD VSS NOR2_X2
X_18637_ _04603_ _03882_ _03887_ _06859_ _04841_ VDD VSS OAI22_X2
X_18638_ _04592_ _03892_ _03896_ _04594_ _04842_ VDD VSS OAI22_X2
X_18639_ _04597_ _03914_ _04843_ VDD VSS NOR2_X1
X_18640_ _04841_ _04842_ _04843_ _04844_ VDD VSS NOR3_X2
X_18641_ _04601_ _04844_ net552 VDD VSS NOR2_X2
X_18642_ _04603_ _03920_ _03930_ _04649_ _04845_ VDD VSS OAI22_X2
X_18643_ _06860_ _03925_ _03934_ _04594_ _04846_ VDD VSS OAI22_X2
X_18644_ _04597_ _03952_ _04847_ VDD VSS NOR2_X1
X_18645_ _04845_ _04846_ _04847_ _04848_ VDD VSS NOR3_X2
X_18646_ _04601_ _04848_ net553 VDD VSS NOR2_X2
X_18647_ _04648_ _03958_ _03962_ _04649_ _04849_ VDD VSS OAI22_X2
X_18648_ _04635_ _03967_ _03972_ _06859_ _04850_ VDD VSS OAI22_X2
X_18649_ _04597_ _03990_ _04851_ VDD VSS NOR2_X1
X_18650_ _04849_ _04850_ _04851_ _04852_ VDD VSS NOR3_X2
X_18651_ _04601_ _04852_ net554 VDD VSS NOR2_X2
X_18652_ _04602_ _03997_ _04001_ _04649_ _04853_ VDD VSS OAI22_X2
X_18653_ _04635_ _04006_ _04010_ _04594_ _04854_ VDD VSS OAI22_X2
X_18654_ _04597_ _04028_ _04855_ VDD VSS NOR2_X1
X_18655_ _04853_ _04854_ _04855_ _04856_ VDD VSS NOR3_X2
X_18656_ _04601_ _04856_ net555 VDD VSS NOR2_X2
X_18657_ _05474_ _04857_ VDD VSS BUF_X8
X_18658_ _04857_ _04858_ VDD VSS BUF_X4
X_18659_ _00051_ _04859_ VDD VSS BUF_X4
X_18660_ _04859_ _04860_ VDD VSS BUF_X4
X_18661_ _00064_ _04861_ VDD VSS BUF_X4
X_18662_ _04861_ _04862_ VDD VSS BUF_X4
X_18663_ _04862_ _04863_ VDD VSS BUF_X4
X_18664_ _04860_ _02768_ _02777_ _04863_ _04864_ VDD VSS OAI22_X1
X_18665_ _06611_ _04865_ VDD VSS BUF_X4
X_18666_ _00062_ _04866_ VDD VSS BUF_X2
X_18667_ _04866_ _04867_ VDD VSS BUF_X4
X_18668_ _04867_ _04868_ VDD VSS BUF_X4
X_18669_ _04865_ _02790_ _02798_ _04868_ _04869_ VDD VSS OAI22_X1
X_18670_ _00063_ _04870_ VDD VSS BUF_X4
X_18671_ _04870_ _04871_ VDD VSS CLKBUF_X3
X_18672_ _04871_ _02840_ _04872_ VDD VSS NOR2_X1
X_18673_ _04864_ _04869_ _04872_ _04873_ VDD VSS NOR3_X1
X_18674_ _04858_ _04873_ net556 VDD VSS NOR2_X2
X_18675_ _04857_ _04874_ VDD VSS BUF_X4
X_18676_ _04862_ _04875_ VDD VSS BUF_X4
X_18677_ _04859_ _04876_ VDD VSS BUF_X4
X_18678_ _04875_ _02850_ _02854_ _04876_ _04877_ VDD VSS OAI22_X1
X_18679_ _04867_ _04878_ VDD VSS CLKBUF_X3
X_18680_ _06699_ _02864_ _02868_ _04878_ _04879_ VDD VSS OAI22_X1
X_18681_ _04877_ _04879_ _04880_ VDD VSS NOR2_X1
X_18682_ _04870_ _04881_ VDD VSS INV_X1
X_18683_ _04881_ _04882_ VDD VSS CLKBUF_X3
X_18684_ _04882_ _04883_ VDD VSS BUF_X4
X_18685_ _04883_ _02896_ _04884_ VDD VSS NAND2_X1
X_18686_ _04874_ _04880_ _04884_ net557 VDD VSS AOI21_X2
X_18687_ _04860_ _02901_ _02905_ _06612_ _04885_ VDD VSS OAI22_X1
X_18688_ _04875_ _02912_ _02916_ _04878_ _04886_ VDD VSS OAI22_X1
X_18689_ _04885_ _04886_ _04887_ VDD VSS NOR2_X1
X_18690_ _04883_ _02934_ _04888_ VDD VSS NAND2_X1
X_18691_ _04874_ _04887_ _04888_ net558 VDD VSS AOI21_X2
X_18692_ _04860_ _02940_ _02946_ _04863_ _04889_ VDD VSS OAI22_X1
X_18693_ _04865_ _02952_ _02956_ _04868_ _04890_ VDD VSS OAI22_X1
X_18694_ _04871_ _02974_ _04891_ VDD VSS NOR2_X1
X_18695_ _04889_ _04890_ _04891_ _04892_ VDD VSS NOR3_X1
X_18696_ _04858_ _04892_ net559 VDD VSS NOR2_X2
X_18697_ _04875_ _02981_ _02985_ _04876_ _04893_ VDD VSS OAI22_X1
X_18698_ _06699_ _02990_ _02996_ _04878_ _04894_ VDD VSS OAI22_X1
X_18699_ _04893_ _04894_ _04895_ VDD VSS NOR2_X1
X_18700_ _04883_ _03013_ _04896_ VDD VSS NAND2_X1
X_18701_ _04874_ _04895_ _04896_ net560 VDD VSS AOI21_X2
X_18702_ _04860_ _03019_ _03024_ _04863_ _04897_ VDD VSS OAI22_X1
X_18703_ _04865_ _03030_ _03034_ _04868_ _04898_ VDD VSS OAI22_X1
X_18704_ _04871_ _03055_ _04899_ VDD VSS NOR2_X1
X_18705_ _04897_ _04898_ _04899_ _04900_ VDD VSS NOR3_X1
X_18706_ _04858_ _04900_ net561 VDD VSS NOR2_X2
X_18707_ _04860_ _03061_ _03065_ _06611_ _04901_ VDD VSS OAI22_X1
X_18708_ _04863_ _03073_ _03077_ _04868_ _04902_ VDD VSS OAI22_X1
X_18709_ _04871_ _03095_ _04903_ VDD VSS NOR2_X1
X_18710_ _04901_ _04902_ _04903_ _04904_ VDD VSS NOR3_X1
X_18711_ _04858_ _04904_ net562 VDD VSS NOR2_X2
X_18712_ _04859_ _04905_ VDD VSS BUF_X4
X_18713_ _06699_ _03106_ _03111_ _04905_ _04906_ VDD VSS OAI22_X1
X_18714_ _04875_ _03102_ _03115_ _04878_ _04907_ VDD VSS OAI22_X1
X_18715_ _04906_ _04907_ _04908_ VDD VSS NOR2_X1
X_18716_ _04883_ _03132_ _04909_ VDD VSS NAND2_X1
X_18717_ _04874_ _04908_ _04909_ net563 VDD VSS AOI21_X2
X_18718_ _04860_ _03137_ _03141_ _06612_ _04910_ VDD VSS OAI22_X1
X_18719_ _04875_ _03147_ _03151_ _04878_ _04911_ VDD VSS OAI22_X1
X_18720_ _04910_ _04911_ _04912_ VDD VSS NOR2_X1
X_18721_ _04883_ _03168_ _04913_ VDD VSS NAND2_X1
X_18722_ _04874_ _04912_ _04913_ net564 VDD VSS AOI21_X2
X_18723_ _04876_ _03173_ _03178_ _04863_ _04914_ VDD VSS OAI22_X1
X_18724_ _04865_ _03183_ _03188_ _04868_ _04915_ VDD VSS OAI22_X1
X_18725_ _04871_ _03209_ _04916_ VDD VSS NOR2_X1
X_18726_ _04914_ _04915_ _04916_ _04917_ VDD VSS NOR3_X1
X_18727_ _04858_ _04917_ net565 VDD VSS NOR2_X1
X_18728_ _04867_ _04918_ VDD VSS CLKBUF_X3
X_18729_ _04918_ _03216_ _03220_ _06611_ _04919_ VDD VSS OAI22_X1
X_18730_ _04861_ _04920_ VDD VSS BUF_X4
X_18731_ _04905_ _03228_ _03234_ _04920_ _04921_ VDD VSS OAI22_X1
X_18732_ _04871_ _03253_ _04922_ VDD VSS NOR2_X1
X_18733_ _04919_ _04921_ _04922_ _04923_ VDD VSS NOR3_X1
X_18734_ _04858_ _04923_ net566 VDD VSS NOR2_X1
X_18735_ _04876_ _03259_ _03264_ _04863_ _04924_ VDD VSS OAI22_X1
X_18736_ _04865_ _03269_ _03273_ _04868_ _04925_ VDD VSS OAI22_X1
X_18737_ _04871_ _03294_ _04926_ VDD VSS NOR2_X1
X_18738_ _04924_ _04925_ _04926_ _04927_ VDD VSS NOR3_X1
X_18739_ _04858_ _04927_ net567 VDD VSS NOR2_X1
X_18740_ _04875_ _03301_ _03305_ _06612_ _04928_ VDD VSS OAI22_X1
X_18741_ _04860_ _03310_ _03314_ _04878_ _04929_ VDD VSS OAI22_X1
X_18742_ _04928_ _04929_ _04930_ VDD VSS NOR2_X1
X_18743_ _04883_ _03331_ _04931_ VDD VSS NAND2_X1
X_18744_ _04874_ _04930_ _04931_ net568 VDD VSS AOI21_X2
X_18745_ _04876_ _03336_ _03341_ _04863_ _04932_ VDD VSS OAI22_X1
X_18746_ _04865_ _03346_ _03350_ _04868_ _04933_ VDD VSS OAI22_X1
X_18747_ _04871_ _03369_ _04934_ VDD VSS NOR2_X1
X_18748_ _04932_ _04933_ _04934_ _04935_ VDD VSS NOR3_X1
X_18749_ _04858_ _04935_ net569 VDD VSS NOR2_X1
X_18750_ _04861_ _04936_ VDD VSS INV_X2
X_18751_ _04936_ _04937_ VDD VSS BUF_X4
X_18752_ _05469_ _05775_ _06080_ _04937_ _04938_ VDD VSS AOI22_X1
X_18753_ _04867_ _04939_ VDD VSS BUF_X4
X_18754_ _04938_ _02494_ _04939_ _06691_ _03374_ _04940_ VDD
+ VSS OAI221_X1
X_18755_ _04881_ _04941_ VDD VSS BUF_X2
X_18756_ _04940_ _07132_ _04941_ _04942_ VDD VSS AOI21_X1
X_18757_ _04858_ _04942_ net570 VDD VSS NOR2_X2
X_18758_ _04866_ _04943_ VDD VSS INV_X4
X_18759_ _04943_ _04944_ VDD VSS BUF_X4
X_18760_ _04944_ _05849_ _05796_ _06609_ _04945_ VDD VSS AOI22_X2
X_18761_ _04945_ _03382_ _04920_ _04905_ _03383_ _04946_ VDD
+ VSS OAI221_X2
X_18762_ _04946_ _07156_ _04941_ _04947_ VDD VSS AOI21_X1
X_18763_ _04858_ _04947_ net571 VDD VSS NOR2_X1
X_18764_ _04857_ _04948_ VDD VSS BUF_X2
X_18765_ _04944_ _05839_ _05799_ _06609_ _04949_ VDD VSS AOI22_X1
X_18766_ _04949_ _03388_ _04920_ _04905_ _03389_ _04950_ VDD
+ VSS OAI221_X1
X_18767_ _04950_ _05956_ _04941_ _04951_ VDD VSS AOI21_X1
X_18768_ _04948_ _04951_ net572 VDD VSS NOR2_X1
X_18769_ _04944_ _05829_ _05802_ _06609_ _04952_ VDD VSS AOI22_X1
X_18770_ _04952_ _03393_ _04920_ _04905_ _03395_ _04953_ VDD
+ VSS OAI221_X1
X_18771_ _04953_ _05902_ _04941_ _04954_ VDD VSS AOI21_X1
X_18772_ _04948_ _04954_ net573 VDD VSS NOR2_X1
X_18773_ _04944_ _05832_ _05792_ _06609_ _04955_ VDD VSS AOI22_X1
X_18774_ _04955_ _03399_ _04862_ _04905_ _03400_ _04956_ VDD
+ VSS OAI221_X1
X_18775_ _04956_ _03403_ _04941_ _04957_ VDD VSS AOI21_X1
X_18776_ _04948_ _04957_ net574 VDD VSS NOR2_X1
X_18777_ _04944_ _05836_ _05809_ _06609_ _04958_ VDD VSS AOI22_X1
X_18778_ _04859_ _04959_ VDD VSS BUF_X4
X_18779_ _04958_ _07196_ _04862_ _04959_ _07233_ _04960_ VDD
+ VSS OAI221_X1
X_18780_ _04960_ _05972_ _04941_ _04961_ VDD VSS AOI21_X1
X_18781_ _04948_ _04961_ net575 VDD VSS NOR2_X1
X_18782_ _04944_ _05843_ _05806_ _06609_ _04962_ VDD VSS AOI22_X1
X_18783_ _04962_ _07192_ _04862_ _04959_ _07229_ _04963_ VDD
+ VSS OAI221_X1
X_18784_ _04963_ _06008_ _04941_ _04964_ VDD VSS AOI21_X1
X_18785_ _04948_ _04964_ net576 VDD VSS NOR2_X1
X_18786_ _05469_ _05778_ _06071_ _04937_ _04965_ VDD VSS AOI22_X1
X_18787_ _04965_ _07105_ _04939_ _06691_ _03412_ _04966_ VDD
+ VSS OAI221_X1
X_18788_ _04966_ _05993_ _04941_ _04967_ VDD VSS AOI21_X1
X_18789_ _04948_ _04967_ net577 VDD VSS NOR2_X1
X_18790_ _04861_ _04968_ VDD VSS BUF_X4
X_18791_ _04876_ _03418_ _03428_ _04968_ _04969_ VDD VSS OAI22_X2
X_18792_ _04865_ _03422_ _03432_ _04939_ _04970_ VDD VSS OAI22_X2
X_18793_ _04871_ _03450_ _04971_ VDD VSS NOR2_X1
X_18794_ _04971_ _04970_ _04969_ _04972_ VDD VSS NOR3_X2
X_18795_ _04948_ _04972_ net578 VDD VSS NOR2_X1
X_18796_ _04943_ _06524_ _05492_ _05469_ _04973_ VDD VSS AOI22_X2
X_18797_ _04973_ _06099_ _04862_ _06691_ _05274_ _04974_ VDD
+ VSS OAI221_X2
X_18798_ _04974_ _06179_ _04941_ _04975_ VDD VSS AOI21_X1
X_18799_ _04948_ _04975_ net579 VDD VSS NOR2_X1
X_18800_ _07015_ _06514_ _06100_ _04937_ _04976_ VDD VSS AOI22_X1
X_18801_ _04976_ _05376_ _04939_ _04959_ _06789_ _04977_ VDD
+ VSS OAI221_X1
X_18802_ _04977_ _06146_ _04941_ _04978_ VDD VSS AOI21_X1
X_18803_ _04948_ _04978_ net580 VDD VSS NOR2_X1
X_18804_ _04943_ _05370_ _05500_ _05469_ _04979_ VDD VSS AOI22_X2
X_18805_ _04979_ _06098_ _04862_ _06611_ _06513_ _04980_ VDD
+ VSS OAI221_X2
X_18806_ _04980_ _06163_ _04882_ _04981_ VDD VSS AOI21_X1
X_18807_ _04948_ _04981_ net581 VDD VSS NOR2_X1
X_18808_ _04857_ _04982_ VDD VSS BUF_X4
X_18809_ _04876_ _03465_ _03471_ _04968_ _04983_ VDD VSS OAI22_X1
X_18810_ _04865_ _03476_ _03480_ _04939_ _04984_ VDD VSS OAI22_X1
X_18811_ _04871_ _03498_ _04985_ VDD VSS NOR2_X1
X_18812_ _04983_ _04984_ _04985_ _04986_ VDD VSS NOR3_X1
X_18813_ _04982_ _04986_ net582 VDD VSS NOR2_X1
X_18814_ _04937_ _10225_ _10348_ _05469_ _04987_ VDD VSS AOI22_X1
X_18815_ _04987_ _05327_ _04867_ _06611_ _03502_ _04988_ VDD
+ VSS OAI221_X1
X_18816_ _04988_ _10417_ _04882_ _04989_ VDD VSS AOI21_X1
X_18817_ _04982_ _04989_ net583 VDD VSS NOR2_X2
X_18818_ _04857_ _04990_ VDD VSS BUF_X4
X_18819_ _04859_ _10351_ _10255_ _06610_ _04991_ VDD VSS OAI22_X2
X_18820_ _04991_ _04450_ _04937_ _04944_ net694 _04992_ VDD
+ VSS AOI221_X2
X_18821_ _04883_ _07676_ _04993_ VDD VSS NAND2_X1
X_18822_ _04990_ _04992_ _04993_ net584 VDD VSS AOI21_X2
X_18823_ _06610_ _10261_ _10315_ _04867_ _04994_ VDD VSS OAI22_X2
X_18824_ _04994_ _07434_ _04937_ _05469_ _03510_ _04995_ VDD
+ VSS AOI221_X2
X_18825_ _04883_ _07661_ _04996_ VDD VSS NAND2_X1
X_18826_ _04990_ _04995_ _04996_ net585 VDD VSS AOI21_X2
X_18827_ _06610_ _10258_ _10354_ _04859_ _04997_ VDD VSS OAI22_X2
X_18828_ _04997_ _07267_ _04937_ _04944_ _04179_ _04998_ VDD
+ VSS AOI221_X2
X_18829_ _04883_ _07409_ _04999_ VDD VSS NAND2_X1
X_18830_ _04990_ _04998_ _04999_ net586 VDD VSS AOI21_X2
X_18831_ _07015_ _07282_ net673 _04936_ _05000_ VDD VSS AOI22_X2
X_18832_ _05000_ net697 _04867_ _04959_ _10369_ _05001_ VDD
+ VSS OAI221_X2
X_18833_ _05001_ _07646_ _04882_ _05002_ VDD VSS AOI21_X1
X_18834_ _04982_ _05002_ net587 VDD VSS NOR2_X2
X_18835_ _07015_ _07279_ net664 _04943_ _05003_ VDD VSS AOI22_X2
X_18836_ _05003_ _10209_ _04862_ _04959_ _10366_ _05004_ VDD
+ VSS OAI221_X2
X_18837_ _05004_ _07631_ _04882_ _05005_ VDD VSS AOI21_X1
X_18838_ _04982_ _05005_ net588 VDD VSS NOR2_X1
X_18839_ _04875_ _03530_ _03534_ _06611_ _05006_ VDD VSS OAI22_X1
X_18840_ _04905_ _03539_ _03543_ _04939_ _05007_ VDD VSS OAI22_X1
X_18841_ _04870_ _05008_ VDD VSS CLKBUF_X3
X_18842_ _05008_ _03562_ _05009_ VDD VSS NOR2_X1
X_18843_ _05006_ _05007_ _05009_ _05010_ VDD VSS NOR3_X1
X_18844_ _04982_ _05010_ net589 VDD VSS NOR2_X2
X_18845_ _07015_ _07473_ _07506_ _04943_ _05011_ VDD VSS AOI22_X1
X_18846_ _05011_ _10206_ _04862_ _04959_ _10363_ _05012_ VDD
+ VSS OAI221_X1
X_18847_ _05012_ _07616_ _04882_ _05013_ VDD VSS AOI21_X1
X_18848_ _04982_ _05013_ net590 VDD VSS NOR2_X2
X_18849_ _06699_ net640 net713 _04905_ _05014_ VDD VSS OAI22_X1
X_18850_ _04875_ net650 net632 _04868_ _05015_ VDD VSS OAI22_X2
X_18851_ _05014_ _05015_ _05016_ VDD VSS NOR2_X1
X_18852_ _04883_ _07394_ _05017_ VDD VSS NAND2_X1
X_18853_ _04990_ _05016_ _05017_ net591 VDD VSS AOI21_X2
X_18854_ _07015_ _10249_ _10276_ _04943_ _05018_ VDD VSS AOI22_X1
X_18855_ _05018_ net685 _04862_ _04959_ _03574_ _05019_ VDD
+ VSS OAI221_X1
X_18856_ _05019_ _10372_ _04882_ _05020_ VDD VSS AOI21_X1
X_18857_ _04982_ _05020_ net592 VDD VSS NOR2_X2
X_18858_ _04861_ net642 _10246_ _06610_ _05021_ VDD VSS OAI22_X2
X_18859_ _05021_ _03578_ _04943_ _05469_ _03577_ _05022_ VDD
+ VSS AOI221_X2
X_18860_ _04882_ _05023_ VDD VSS CLKBUF_X3
X_18861_ _05023_ _07556_ _05024_ VDD VSS NAND2_X1
X_18862_ _04990_ _05022_ _05024_ net593 VDD VSS AOI21_X2
X_18863_ _04861_ net645 net723 _04859_ _05025_ VDD VSS OAI22_X2
X_18864_ _05025_ net689 _04943_ _07015_ _03583_ _05026_ VDD
+ VSS AOI221_X2
X_18865_ _05023_ _07571_ _05027_ VDD VSS NAND2_X1
X_18866_ _04990_ _05026_ _05027_ net594 VDD VSS AOI21_X2
X_18867_ _06610_ _10240_ _10336_ _04859_ _05028_ VDD VSS OAI22_X2
X_18868_ _05028_ _04210_ _04937_ _04944_ _04211_ _05029_ VDD
+ VSS AOI221_X2
X_18869_ _05023_ _07342_ _05030_ VDD VSS NAND2_X1
X_18870_ _04990_ _05029_ _05030_ net595 VDD VSS AOI21_X2
X_18871_ _04861_ net647 _10288_ _04867_ _05031_ VDD VSS OAI22_X2
X_18872_ _05031_ net651 _05469_ _07015_ _03590_ _05032_ VDD
+ VSS AOI221_X2
X_18873_ _05023_ _07376_ _05033_ VDD VSS NAND2_X1
X_18874_ _04990_ _05032_ _05033_ net596 VDD VSS AOI21_X2
X_18875_ _04859_ net703 _10234_ _06610_ _05034_ VDD VSS OAI22_X2
X_18876_ _05034_ _04220_ _04937_ _04944_ _07489_ _05035_ VDD
+ VSS AOI221_X2
X_18877_ _05023_ _07361_ _05036_ VDD VSS NAND2_X1
X_18878_ _04990_ _05035_ _05036_ net597 VDD VSS AOI21_X2
X_18879_ _06610_ net730 _10294_ _04866_ _05037_ VDD VSS OAI22_X2
X_18880_ _05037_ net753 _04937_ _05469_ _03599_ _05038_ VDD
+ VSS AOI221_X2
X_18881_ _05023_ _07601_ _05039_ VDD VSS NAND2_X1
X_18882_ _04990_ _05038_ _05039_ net598 VDD VSS AOI21_X2
X_18883_ _06699_ net731 net670 _04905_ _05040_ VDD VSS OAI22_X1
X_18884_ _04875_ _10191_ _10297_ _04868_ _05041_ VDD VSS OAI22_X1
X_18885_ _05040_ _05041_ _05042_ VDD VSS NOR2_X1
X_18886_ _05023_ _07586_ _05043_ VDD VSS NAND2_X1
X_18887_ _04857_ _05042_ _05043_ net599 VDD VSS AOI21_X4
X_18888_ _04875_ _03610_ _03614_ _04865_ _05044_ VDD VSS OAI22_X2
X_18889_ _04860_ _03619_ _03623_ _04868_ _05045_ VDD VSS OAI22_X2
X_18890_ _05044_ _05045_ _05046_ VDD VSS NOR2_X2
X_18891_ _05023_ _03640_ _05047_ VDD VSS NAND2_X1
X_18892_ _04857_ _05046_ _05047_ net600 VDD VSS AOI21_X4
X_18893_ _06699_ _03643_ _03646_ _04968_ _05048_ VDD VSS OAI22_X1
X_18894_ _04859_ _05049_ VDD VSS CLKBUF_X3
X_18895_ _04918_ _03649_ _03651_ _05049_ _05050_ VDD VSS OAI22_X1
X_18896_ _05008_ _03655_ _05051_ VDD VSS NOR2_X1
X_18897_ _05048_ _05050_ _05051_ _05052_ VDD VSS NOR3_X1
X_18898_ _04982_ _05052_ net601 VDD VSS NOR2_X2
X_18899_ _07015_ _05189_ _05649_ _04936_ _05053_ VDD VSS AOI22_X2
X_18900_ _05053_ _03660_ _04867_ _04959_ _03662_ _05054_ VDD
+ VSS OAI221_X2
X_18901_ _05054_ _06249_ _04882_ _05055_ VDD VSS AOI21_X1
X_18902_ _04982_ _05055_ net602 VDD VSS NOR2_X2
X_18903_ _06699_ _03666_ _03669_ _04968_ _05056_ VDD VSS OAI22_X1
X_18904_ _04918_ _03672_ _03674_ _05049_ _05057_ VDD VSS OAI22_X1
X_18905_ _05008_ _03677_ _05058_ VDD VSS NOR2_X1
X_18906_ _05056_ _05057_ _05058_ _05059_ VDD VSS NOR3_X1
X_18907_ _04982_ _05059_ net603 VDD VSS NOR2_X2
X_18908_ _04857_ _05060_ VDD VSS BUF_X4
X_18909_ _06612_ _03681_ _03683_ _04959_ _05061_ VDD VSS OAI22_X1
X_18910_ _04918_ _03686_ _03689_ _04920_ _05062_ VDD VSS OAI22_X1
X_18911_ _05008_ _03692_ _05063_ VDD VSS NOR2_X1
X_18912_ _05061_ _05062_ _05063_ _05064_ VDD VSS NOR3_X1
X_18913_ _05060_ _05064_ net604 VDD VSS NOR2_X2
X_18914_ _06612_ _03696_ _03699_ _04968_ _05065_ VDD VSS OAI22_X1
X_18915_ _04878_ _03702_ _03704_ _05049_ _05066_ VDD VSS OAI22_X1
X_18916_ _05008_ _03707_ _05067_ VDD VSS NOR2_X1
X_18917_ _05065_ _05066_ _05067_ _05068_ VDD VSS NOR3_X1
X_18918_ _05060_ _05068_ net605 VDD VSS NOR2_X2
X_18919_ _06612_ _03717_ _03720_ _04968_ _05069_ VDD VSS OAI22_X1
X_18920_ _04878_ _03712_ _03714_ _05049_ _05070_ VDD VSS OAI22_X1
X_18921_ _05008_ _03723_ _05071_ VDD VSS NOR2_X1
X_18922_ _05069_ _05070_ _05071_ _05072_ VDD VSS NOR3_X1
X_18923_ _05060_ _05072_ net606 VDD VSS NOR2_X2
X_18924_ _06699_ _03733_ _03735_ _04918_ _05073_ VDD VSS OAI22_X1
X_18925_ _04860_ _03727_ _03730_ _04863_ _05074_ VDD VSS OAI22_X1
X_18926_ _05073_ _05074_ _05075_ VDD VSS NOR2_X1
X_18927_ _05023_ _03738_ _05076_ VDD VSS NAND2_X1
X_18928_ _04857_ _05075_ _05076_ net607 VDD VSS AOI21_X4
X_18929_ _04918_ _03741_ _03743_ _05049_ _05077_ VDD VSS OAI22_X1
X_18930_ _04865_ _03746_ _03749_ _04920_ _05078_ VDD VSS OAI22_X1
X_18931_ _05008_ _03752_ _05079_ VDD VSS NOR2_X1
X_18932_ _05077_ _05078_ _05079_ _05080_ VDD VSS NOR3_X1
X_18933_ _05060_ _05080_ net608 VDD VSS NOR2_X2
X_18934_ _06612_ _03756_ _03759_ _04968_ _05081_ VDD VSS OAI22_X1
X_18935_ _04878_ _03762_ _03764_ _05049_ _05082_ VDD VSS OAI22_X1
X_18936_ _05008_ _03767_ _05083_ VDD VSS NOR2_X1
X_18937_ _05081_ _05082_ _05083_ _05084_ VDD VSS NOR3_X1
X_18938_ _05060_ _05084_ net609 VDD VSS NOR2_X2
X_18939_ _04918_ _03771_ _03773_ _05049_ _05085_ VDD VSS OAI22_X1
X_18940_ _06691_ _03776_ _03779_ _04920_ _05086_ VDD VSS OAI22_X1
X_18941_ _05008_ _03782_ _05087_ VDD VSS NOR2_X1
X_18942_ _05085_ _05086_ _05087_ _05088_ VDD VSS NOR3_X1
X_18943_ _05060_ _05088_ net610 VDD VSS NOR2_X2
X_18944_ _04876_ _03788_ _03793_ _04968_ _05089_ VDD VSS OAI22_X1
X_18945_ _06691_ _03798_ _03802_ _04939_ _05090_ VDD VSS OAI22_X1
X_18946_ _05008_ _03820_ _05091_ VDD VSS NOR2_X1
X_18947_ _05089_ _05090_ _05091_ _05092_ VDD VSS NOR3_X1
X_18948_ _05060_ _05092_ net611 VDD VSS NOR2_X2
X_18949_ _07015_ _05194_ _05639_ _04936_ _05093_ VDD VSS AOI22_X2
X_18950_ _05093_ _04282_ _04867_ _04959_ _04281_ _05094_ VDD
+ VSS OAI221_X2
X_18951_ _05094_ _03827_ _04882_ _05095_ VDD VSS AOI21_X1
X_18952_ _05060_ _05095_ net612 VDD VSS NOR2_X2
X_18953_ _04918_ _03836_ _03833_ _05049_ _05096_ VDD VSS OAI22_X1
X_18954_ _06691_ _03831_ _03839_ _04920_ _05097_ VDD VSS OAI22_X1
X_18955_ _04870_ _03849_ _05098_ VDD VSS NOR2_X1
X_18956_ _05096_ _05097_ _05098_ _05099_ VDD VSS NOR3_X1
X_18957_ _05060_ _05099_ net613 VDD VSS NOR2_X2
X_18958_ _06699_ _03853_ _03855_ _04918_ _05100_ VDD VSS OAI22_X2
X_18959_ _04860_ _03858_ _03861_ _04863_ _05101_ VDD VSS OAI22_X2
X_18960_ _05100_ _05101_ _05102_ VDD VSS NOR2_X2
X_18961_ _05023_ _03864_ _05103_ VDD VSS NAND2_X1
X_18962_ _04857_ _05102_ _05103_ net614 VDD VSS AOI21_X4
X_18963_ _06612_ _03867_ _03875_ _04968_ _05104_ VDD VSS OAI22_X1
X_18964_ _04878_ _03872_ _03869_ _05049_ _05105_ VDD VSS OAI22_X1
X_18965_ _04870_ _06229_ _05106_ VDD VSS NOR2_X1
X_18966_ _05104_ _05105_ _05106_ _05107_ VDD VSS NOR3_X1
X_18967_ _05060_ _05107_ net615 VDD VSS NOR2_X2
X_18968_ _04876_ _03882_ _03887_ _04968_ _05108_ VDD VSS OAI22_X1
X_18969_ _06691_ _03892_ _03896_ _04939_ _05109_ VDD VSS OAI22_X1
X_18970_ _04870_ _03914_ _05110_ VDD VSS NOR2_X1
X_18971_ _05108_ _05109_ _05110_ _05111_ VDD VSS NOR3_X1
X_18972_ _04874_ _05111_ net616 VDD VSS NOR2_X1
X_18973_ _04876_ _03920_ _03925_ _04920_ _05112_ VDD VSS OAI22_X1
X_18974_ _06691_ _03930_ _03934_ _04939_ _05113_ VDD VSS OAI22_X1
X_18975_ _04870_ _03952_ _05114_ VDD VSS NOR2_X1
X_18976_ _05112_ _05113_ _05114_ _05115_ VDD VSS NOR3_X1
X_18977_ _04874_ _05115_ net617 VDD VSS NOR2_X1
X_18978_ _04918_ _03958_ _03967_ _05049_ _05116_ VDD VSS OAI22_X1
X_18979_ _06691_ _03962_ _03972_ _04920_ _05117_ VDD VSS OAI22_X1
X_18980_ _04870_ _03990_ _05118_ VDD VSS NOR2_X1
X_18981_ _05116_ _05117_ _05118_ _05119_ VDD VSS NOR3_X1
X_18982_ _04874_ _05119_ net618 VDD VSS NOR2_X1
X_18983_ _04863_ _03997_ _04001_ _06611_ _05120_ VDD VSS OAI22_X1
X_18984_ _04905_ _04006_ _04010_ _04939_ _05121_ VDD VSS OAI22_X1
X_18985_ _04870_ _04028_ _05122_ VDD VSS NOR2_X1
X_18986_ _05120_ _05121_ _05122_ _05123_ VDD VSS NOR3_X1
X_18987_ _04874_ _05123_ net619 VDD VSS NOR2_X1
X_18988_ dynamic_node_top.east_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.east_input.NIB.elements_in_array_f\[1\] _10162_
+ _10163_ _10164_ VDD VSS FA_X1
X_18989_ dynamic_node_top.north_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.north_input.NIB.elements_in_array_f\[1\]
+ _10165_ _10166_ _10167_ VDD VSS FA_X1
X_18990_ dynamic_node_top.proc_input.NIB.elements_in_array_next\[0\]
+ _10168_ _10169_ _10170_ _10171_ VDD VSS FA_X1
X_18991_ dynamic_node_top.south_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.south_input.NIB.elements_in_array_f\[1\]
+ _10172_ _10173_ _10174_ VDD VSS FA_X1
X_18992_ dynamic_node_top.west_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.west_input.NIB.elements_in_array_f\[1\] _10175_
+ _10176_ _10177_ VDD VSS FA_X1
X_18993_ _10178_ _10179_ _10180_ _10181_ VDD VSS HA_X1
X_18994_ _10182_ dynamic_node_top.east_input.control.my_loc_x_in\[1\]
+ _10183_ _10184_ VDD VSS HA_X1
X_18995_ dynamic_node_top.east_input.control.my_loc_x_in\[3\]
+ _10185_ _10186_ _10187_ VDD VSS HA_X1
X_18996_ _10188_ dynamic_node_top.east_input.control.my_loc_x_in\[2\]
+ _10189_ _10190_ VDD VSS HA_X1
X_18997_ dynamic_node_top.east_input.control.my_loc_x_in\[7\]
+ _10191_ _10192_ _10193_ VDD VSS HA_X1
X_18998_ dynamic_node_top.east_input.control.my_loc_x_in\[6\]
+ _10194_ _10195_ _10196_ VDD VSS HA_X1
X_18999_ dynamic_node_top.east_input.control.my_loc_x_in\[5\]
+ _10197_ _10198_ _10199_ VDD VSS HA_X1
X_19000_ dynamic_node_top.east_input.control.my_loc_x_in\[4\]
+ _10200_ _10201_ _10202_ VDD VSS HA_X1
X_19001_ _10203_ dynamic_node_top.east_input.control.my_loc_y_in\[7\]
+ _10204_ _10205_ VDD VSS HA_X1
X_19002_ dynamic_node_top.east_input.control.my_loc_y_in\[6\]
+ _10206_ _10207_ _10208_ VDD VSS HA_X1
X_19003_ dynamic_node_top.east_input.control.my_loc_y_in\[5\]
+ _10209_ _10210_ _10211_ VDD VSS HA_X1
X_19004_ dynamic_node_top.east_input.control.my_loc_y_in\[4\]
+ _10212_ _10213_ _10214_ VDD VSS HA_X1
X_19005_ dynamic_node_top.east_input.control.my_loc_y_in\[3\]
+ _10215_ _10216_ _10217_ VDD VSS HA_X1
X_19006_ dynamic_node_top.east_input.control.my_loc_y_in\[2\]
+ _10218_ _10219_ _10220_ VDD VSS HA_X1
X_19007_ dynamic_node_top.east_input.control.my_loc_y_in\[1\]
+ _10221_ _10222_ _10223_ VDD VSS HA_X1
X_19008_ _10224_ _10225_ _10226_ _10227_ VDD VSS HA_X1
X_19009_ dynamic_node_top.east_input.control.my_loc_x_in\[7\]
+ _10228_ _10229_ _10230_ VDD VSS HA_X1
X_19010_ dynamic_node_top.east_input.control.my_loc_x_in\[6\]
+ _10231_ _10232_ _10233_ VDD VSS HA_X1
X_19011_ dynamic_node_top.east_input.control.my_loc_x_in\[5\]
+ _10234_ _10235_ _10236_ VDD VSS HA_X1
X_19012_ dynamic_node_top.east_input.control.my_loc_x_in\[4\]
+ _10237_ _10238_ _10239_ VDD VSS HA_X1
X_19013_ dynamic_node_top.east_input.control.my_loc_x_in\[3\]
+ _10240_ _10241_ _10242_ VDD VSS HA_X1
X_19014_ dynamic_node_top.east_input.control.my_loc_x_in\[2\]
+ _10243_ _10244_ _10245_ VDD VSS HA_X1
X_19015_ dynamic_node_top.east_input.control.my_loc_x_in\[1\]
+ _10246_ _10247_ _10248_ VDD VSS HA_X1
X_19016_ _10178_ _10249_ _10250_ _10251_ VDD VSS HA_X1
X_19017_ _10224_ _10252_ _10253_ _10254_ VDD VSS HA_X1
X_19018_ dynamic_node_top.east_input.control.my_loc_y_in\[1\]
+ _10255_ _10256_ _10257_ VDD VSS HA_X1
X_19019_ dynamic_node_top.east_input.control.my_loc_y_in\[3\]
+ _10258_ _10259_ _10260_ VDD VSS HA_X1
X_19020_ dynamic_node_top.east_input.control.my_loc_y_in\[2\]
+ _10261_ _10262_ _10263_ VDD VSS HA_X1
X_19021_ dynamic_node_top.east_input.control.my_loc_y_in\[7\]
+ _10264_ _10265_ _10266_ VDD VSS HA_X1
X_19022_ dynamic_node_top.east_input.control.my_loc_y_in\[6\]
+ _10267_ _10268_ _10269_ VDD VSS HA_X1
X_19023_ dynamic_node_top.east_input.control.my_loc_y_in\[5\]
+ _10270_ _10271_ _10272_ VDD VSS HA_X1
X_19024_ dynamic_node_top.east_input.control.my_loc_y_in\[4\]
+ _10273_ _10274_ _10275_ VDD VSS HA_X1
X_19025_ _10178_ _10276_ _10277_ _10278_ VDD VSS HA_X1
X_19026_ dynamic_node_top.east_input.control.my_loc_x_in\[1\]
+ _10279_ _10280_ _10281_ VDD VSS HA_X1
X_19027_ dynamic_node_top.east_input.control.my_loc_x_in\[2\]
+ _10282_ _10283_ _10284_ VDD VSS HA_X1
X_19028_ dynamic_node_top.east_input.control.my_loc_x_in\[3\]
+ _10285_ _10286_ _10287_ VDD VSS HA_X1
X_19029_ dynamic_node_top.east_input.control.my_loc_x_in\[4\]
+ _10288_ _10289_ _10290_ VDD VSS HA_X1
X_19030_ dynamic_node_top.east_input.control.my_loc_x_in\[5\]
+ _10291_ _10292_ _10293_ VDD VSS HA_X1
X_19031_ dynamic_node_top.east_input.control.my_loc_x_in\[6\]
+ _10294_ _10295_ _10296_ VDD VSS HA_X1
X_19032_ dynamic_node_top.east_input.control.my_loc_x_in\[7\]
+ _10297_ _10298_ _10299_ VDD VSS HA_X1
X_19033_ dynamic_node_top.east_input.control.my_loc_y_in\[7\]
+ _10300_ _10301_ _10302_ VDD VSS HA_X1
X_19034_ dynamic_node_top.east_input.control.my_loc_y_in\[6\]
+ _10303_ _10304_ _10305_ VDD VSS HA_X1
X_19035_ dynamic_node_top.east_input.control.my_loc_y_in\[5\]
+ _10306_ _10307_ _10308_ VDD VSS HA_X1
X_19036_ dynamic_node_top.east_input.control.my_loc_y_in\[4\]
+ _10309_ _10310_ _10311_ VDD VSS HA_X1
X_19037_ dynamic_node_top.east_input.control.my_loc_y_in\[3\]
+ _10312_ _10313_ _10314_ VDD VSS HA_X1
X_19038_ dynamic_node_top.east_input.control.my_loc_y_in\[2\]
+ _10315_ _10316_ _10317_ VDD VSS HA_X1
X_19039_ dynamic_node_top.east_input.control.my_loc_y_in\[1\]
+ _10318_ _10319_ _10320_ VDD VSS HA_X1
X_19040_ _10224_ _10321_ _10322_ _10323_ VDD VSS HA_X1
X_19041_ dynamic_node_top.east_input.control.my_loc_x_in\[7\]
+ _10324_ _10325_ _10326_ VDD VSS HA_X1
X_19042_ dynamic_node_top.east_input.control.my_loc_x_in\[6\]
+ _10327_ _10328_ _10329_ VDD VSS HA_X1
X_19043_ _10330_ dynamic_node_top.east_input.control.my_loc_x_in\[5\]
+ _10331_ _10332_ VDD VSS HA_X1
X_19044_ dynamic_node_top.east_input.control.my_loc_x_in\[4\]
+ _10333_ _10334_ _10335_ VDD VSS HA_X1
X_19045_ dynamic_node_top.east_input.control.my_loc_x_in\[3\]
+ _10336_ _10337_ _10338_ VDD VSS HA_X1
X_19046_ _10339_ dynamic_node_top.east_input.control.my_loc_x_in\[2\]
+ _10340_ _10341_ VDD VSS HA_X1
X_19047_ dynamic_node_top.east_input.control.my_loc_x_in\[1\]
+ _10342_ _10343_ _10344_ VDD VSS HA_X1
X_19048_ _10178_ _10345_ _10346_ _10347_ VDD VSS HA_X1
X_19049_ _10224_ _10348_ _10349_ _10350_ VDD VSS HA_X1
X_19050_ dynamic_node_top.east_input.control.my_loc_y_in\[1\]
+ _10351_ _10352_ _10353_ VDD VSS HA_X1
X_19051_ dynamic_node_top.east_input.control.my_loc_y_in\[3\]
+ _10354_ _10355_ _10356_ VDD VSS HA_X1
X_19052_ dynamic_node_top.east_input.control.my_loc_y_in\[2\]
+ _10357_ _10358_ _10359_ VDD VSS HA_X1
X_19053_ _10360_ dynamic_node_top.east_input.control.my_loc_y_in\[7\]
+ _10361_ _10362_ VDD VSS HA_X1
X_19054_ dynamic_node_top.east_input.control.my_loc_y_in\[6\]
+ _10363_ _10364_ _10365_ VDD VSS HA_X1
X_19055_ dynamic_node_top.east_input.control.my_loc_y_in\[5\]
+ _10366_ _10367_ _10368_ VDD VSS HA_X1
X_19056_ dynamic_node_top.east_input.control.my_loc_y_in\[4\]
+ _10369_ _10370_ _10371_ VDD VSS HA_X1
X_19057_ _10178_ _10372_ _10373_ _10374_ VDD VSS HA_X1
X_19058_ dynamic_node_top.east_input.control.my_loc_x_in\[1\]
+ _10375_ _10376_ _10377_ VDD VSS HA_X1
X_19059_ dynamic_node_top.east_input.control.my_loc_x_in\[3\]
+ _10378_ _10379_ _10380_ VDD VSS HA_X1
X_19060_ dynamic_node_top.east_input.control.my_loc_x_in\[2\]
+ _10381_ _10382_ _10383_ VDD VSS HA_X1
X_19061_ dynamic_node_top.east_input.control.my_loc_x_in\[7\]
+ _10384_ _10385_ _10386_ VDD VSS HA_X1
X_19062_ dynamic_node_top.east_input.control.my_loc_x_in\[6\]
+ _10387_ _10388_ _10389_ VDD VSS HA_X1
X_19063_ dynamic_node_top.east_input.control.my_loc_x_in\[5\]
+ _10390_ _10391_ _10392_ VDD VSS HA_X1
X_19064_ dynamic_node_top.east_input.control.my_loc_x_in\[4\]
+ _10393_ _10394_ _10395_ VDD VSS HA_X1
X_19065_ dynamic_node_top.east_input.control.my_loc_y_in\[7\]
+ _10396_ _10397_ _10398_ VDD VSS HA_X1
X_19066_ dynamic_node_top.east_input.control.my_loc_y_in\[6\]
+ _10399_ _10400_ _10401_ VDD VSS HA_X1
X_19067_ dynamic_node_top.east_input.control.my_loc_y_in\[5\]
+ _10402_ _10403_ _10404_ VDD VSS HA_X1
X_19068_ dynamic_node_top.east_input.control.my_loc_y_in\[4\]
+ _10405_ _10406_ _10407_ VDD VSS HA_X1
X_19069_ dynamic_node_top.east_input.control.my_loc_y_in\[3\]
+ _10408_ _10409_ _10410_ VDD VSS HA_X1
X_19070_ dynamic_node_top.east_input.control.my_loc_y_in\[2\]
+ _10411_ _10412_ _10413_ VDD VSS HA_X1
X_19071_ dynamic_node_top.east_input.control.my_loc_y_in\[1\]
+ _10414_ _10415_ _10416_ VDD VSS HA_X1
X_19072_ _10224_ _10417_ _10418_ _10419_ VDD VSS HA_X1
X_19073_ _10420_ _10421_ _10422_ _10423_ VDD VSS HA_X1
X_19074_ _10424_ dynamic_node_top.east_output.space.valid_f
+ _10425_ _10426_ VDD VSS HA_X1
X_19075_ dynamic_node_top.east_output.space.yummy_f _10427_
+ _10428_ _10429_ VDD VSS HA_X1
X_19076_ _10430_ _10431_ _10432_ _10433_ VDD VSS HA_X1
X_19077_ _10430_ _10431_ _10434_ _10435_ VDD VSS HA_X1
X_19078_ dynamic_node_top.east_output.space.count_f\[0\] dynamic_node_top.east_output.space.count_f\[1\]
+ _10436_ _10437_ VDD VSS HA_X1
X_19079_ _10438_ _10439_ _10440_ _10441_ VDD VSS HA_X1
X_19080_ _10442_ dynamic_node_top.west_output.space.valid_f
+ _10443_ _10444_ VDD VSS HA_X1
X_19081_ dynamic_node_top.west_output.space.yummy_f _10445_
+ _10446_ _10447_ VDD VSS HA_X1
X_19082_ _10448_ _10449_ _10450_ _10451_ VDD VSS HA_X1
X_19083_ _10448_ _10449_ _10452_ _10453_ VDD VSS HA_X1
X_19084_ dynamic_node_top.west_output.space.count_f\[0\] dynamic_node_top.west_output.space.count_f\[1\]
+ _10454_ _10455_ VDD VSS HA_X1
X_19085_ _10456_ _10457_ _10458_ _10459_ VDD VSS HA_X1
X_19086_ _10456_ net292 _10169_ _10460_ VDD VSS HA_X1
X_19087_ net620 _10457_ _10461_ _10462_ VDD VSS HA_X1
X_19088_ _10463_ _10464_ _10465_ _10466_ VDD VSS HA_X1
X_19089_ _10463_ dynamic_node_top.south_input.NIB.thanks_in
+ _10467_ _10468_ VDD VSS HA_X1
X_19090_ net293 _10464_ _10469_ _10470_ VDD VSS HA_X1
X_19091_ _10471_ _10472_ _10473_ _10474_ VDD VSS HA_X1
X_19092_ _10471_ dynamic_node_top.north_input.NIB.thanks_in
+ _10475_ _10476_ VDD VSS HA_X1
X_19093_ net291 _10472_ _10477_ _10478_ VDD VSS HA_X1
X_19094_ _10479_ _10480_ _10481_ _10482_ VDD VSS HA_X1
X_19095_ _10483_ dynamic_node_top.south_output.space.valid_f
+ _10484_ _10485_ VDD VSS HA_X1
X_19096_ dynamic_node_top.south_output.space.yummy_f _10486_
+ _10487_ _10488_ VDD VSS HA_X1
X_19097_ _10489_ _10490_ _10491_ _10492_ VDD VSS HA_X1
X_19098_ _10489_ _10490_ _10493_ _10494_ VDD VSS HA_X1
X_19099_ dynamic_node_top.south_output.space.count_f\[0\]
+ dynamic_node_top.south_output.space.count_f\[1\] _10495_ _10496_
+ VDD VSS HA_X1
X_19100_ _10497_ _10498_ _10499_ _10500_ VDD VSS HA_X1
X_19101_ _10497_ dynamic_node_top.west_input.NIB.thanks_in
+ _10501_ _10502_ VDD VSS HA_X1
X_19102_ net294 _10498_ _10503_ _10504_ VDD VSS HA_X1
X_19103_ _10505_ _10506_ _10507_ _10508_ VDD VSS HA_X1
X_19104_ _10505_ dynamic_node_top.east_input.NIB.thanks_in
+ _10509_ _10510_ VDD VSS HA_X1
X_19105_ net290 _10506_ _10511_ _10512_ VDD VSS HA_X1
X_19106_ _10513_ _10514_ _10515_ _10516_ VDD VSS HA_X1
X_19107_ _10517_ dynamic_node_top.proc_output.space.valid_f
+ _10518_ _10519_ VDD VSS HA_X1
X_19108_ dynamic_node_top.proc_output.space.yummy_f _10520_
+ _10521_ _10522_ VDD VSS HA_X1
X_19109_ _10523_ _10524_ _10525_ _10526_ VDD VSS HA_X1
X_19110_ _10523_ _10524_ _10527_ _10528_ VDD VSS HA_X1
X_19111_ dynamic_node_top.proc_output.space.count_f\[0\] dynamic_node_top.proc_output.space.count_f\[1\]
+ _10529_ _10530_ VDD VSS HA_X1
X_19112_ _10531_ _10532_ _10533_ _10534_ VDD VSS HA_X1
X_19113_ _10535_ dynamic_node_top.north_output.space.valid_f
+ _10536_ _10537_ VDD VSS HA_X1
X_19114_ dynamic_node_top.north_output.space.yummy_f _10538_
+ _10539_ _10540_ VDD VSS HA_X1
X_19115_ _10541_ _10542_ _10543_ _10544_ VDD VSS HA_X1
X_19116_ _10541_ _10542_ _10545_ _10546_ VDD VSS HA_X1
X_19117_ dynamic_node_top.north_output.space.count_f\[0\]
+ dynamic_node_top.north_output.space.count_f\[1\] _10547_ _10548_
+ VDD VSS HA_X1
X_19118_ _10448_ _10443_ _10549_ _10550_ VDD VSS HA_X1
X_19119_ _10448_ _10446_ _10551_ _10552_ VDD VSS HA_X1
X_19120_ _10523_ _10518_ _10553_ _10554_ VDD VSS HA_X1
X_19121_ _10523_ _10521_ _10555_ _10556_ VDD VSS HA_X1
X_19122_ _10489_ _10484_ _10557_ _10558_ VDD VSS HA_X1
X_19123_ _10489_ _10487_ _10559_ _10560_ VDD VSS HA_X1
X_19124_ _10541_ _10536_ _10561_ _10562_ VDD VSS HA_X1
X_19125_ _10541_ _10539_ _10563_ _10564_ VDD VSS HA_X1
X_19126_ _10430_ _10425_ _10565_ _10566_ VDD VSS HA_X1
X_19127_ _10430_ _10428_ _10567_ _10568_ VDD VSS HA_X1
X_19128_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[1\]
+ _10569_ _10570_ _10571_ VDD VSS HA_X1
X_19129_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[2\]
+ _10569_ _10572_ _10573_ VDD VSS HA_X1
X_19130_ dynamic_node_top.proc_input.NIB.elements_in_array_f\[3\]
+ _10569_ _10574_ _10575_ VDD VSS HA_X1
X_19131_ dynamic_node_top.east_input.NIB.tail_ptr_next\[0\]
+ _10576_ _10577_ dynamic_node_top.east_input.NIB.tail_ptr_next\[1\]
+ VDD VSS HA_X1
X_19132_ dynamic_node_top.east_input.NIB.tail_ptr_next\[0\]
+ dynamic_node_top.east_input.NIB.tail_ptr_f\[1\] _10578_ _10579_
+ VDD VSS HA_X1
X_19133_ dynamic_node_top.east_input.NIB.tail_ptr_f\[0\] _10576_
+ _10580_ _10581_ VDD VSS HA_X1
X_19134_ dynamic_node_top.east_input.NIB.tail_ptr_f\[0\] dynamic_node_top.east_input.NIB.tail_ptr_f\[1\]
+ _10582_ _10583_ VDD VSS HA_X1
X_19135_ dynamic_node_top.north_input.NIB.tail_ptr_next\[0\]
+ _10584_ _10585_ dynamic_node_top.north_input.NIB.tail_ptr_next\[1\]
+ VDD VSS HA_X1
X_19136_ dynamic_node_top.north_input.NIB.tail_ptr_next\[0\]
+ dynamic_node_top.north_input.NIB.tail_ptr_f\[1\] _10586_ _10587_
+ VDD VSS HA_X1
X_19137_ dynamic_node_top.north_input.NIB.tail_ptr_f\[0\]
+ _10584_ _10588_ _10589_ VDD VSS HA_X1
X_19138_ dynamic_node_top.north_input.NIB.tail_ptr_f\[0\]
+ dynamic_node_top.north_input.NIB.tail_ptr_f\[1\] _10590_ _10591_
+ VDD VSS HA_X1
X_19139_ dynamic_node_top.proc_input.NIB.head_ptr_f\[0\] dynamic_node_top.proc_input.NIB.head_ptr_f\[1\]
+ _10592_ dynamic_node_top.proc_input.NIB.head_ptr_next\[1\]
+ VDD VSS HA_X1
X_19140_ dynamic_node_top.proc_input.NIB.tail_ptr_next\[0\]
+ _10593_ _10594_ dynamic_node_top.proc_input.NIB.tail_ptr_next\[1\]
+ VDD VSS HA_X1
X_19141_ dynamic_node_top.proc_input.NIB.tail_ptr_next\[0\]
+ dynamic_node_top.proc_input.NIB.tail_ptr_f\[1\] _10595_ _10596_
+ VDD VSS HA_X1
X_19142_ dynamic_node_top.proc_input.NIB.tail_ptr_f\[0\] _10593_
+ _10597_ _10598_ VDD VSS HA_X1
X_19143_ dynamic_node_top.proc_input.NIB.tail_ptr_f\[0\] dynamic_node_top.proc_input.NIB.tail_ptr_f\[1\]
+ _10599_ _10600_ VDD VSS HA_X1
X_19144_ dynamic_node_top.south_input.NIB.tail_ptr_next\[0\]
+ _10601_ _10602_ dynamic_node_top.south_input.NIB.tail_ptr_next\[1\]
+ VDD VSS HA_X1
X_19145_ dynamic_node_top.south_input.NIB.tail_ptr_next\[0\]
+ dynamic_node_top.south_input.NIB.tail_ptr_f\[1\] _10603_ _10604_
+ VDD VSS HA_X1
X_19146_ dynamic_node_top.south_input.NIB.tail_ptr_f\[0\]
+ _10601_ _10605_ _10606_ VDD VSS HA_X1
X_19147_ dynamic_node_top.south_input.NIB.tail_ptr_f\[0\]
+ dynamic_node_top.south_input.NIB.tail_ptr_f\[1\] _10607_ _10608_
+ VDD VSS HA_X1
X_19148_ dynamic_node_top.west_input.NIB.tail_ptr_next\[0\]
+ _10609_ _10610_ dynamic_node_top.west_input.NIB.tail_ptr_next\[1\]
+ VDD VSS HA_X1
X_19149_ dynamic_node_top.west_input.NIB.tail_ptr_next\[0\]
+ dynamic_node_top.west_input.NIB.tail_ptr_f\[1\] _10611_ _10612_
+ VDD VSS HA_X1
X_19150_ dynamic_node_top.west_input.NIB.tail_ptr_f\[0\] _10609_
+ _10613_ _10614_ VDD VSS HA_X1
X_19151_ dynamic_node_top.west_input.NIB.tail_ptr_f\[0\] dynamic_node_top.west_input.NIB.tail_ptr_f\[1\]
+ _10615_ _10616_ VDD VSS HA_X1
X_19152_ _00077_ clknet_leaf_175_clk _00015_ _10149_ VDD VSS
+ DFF_X1
X_19153_ _00078_ clknet_leaf_193_clk _00016_ _10148_ VDD VSS
+ DFF_X1
X_19154_ _00079_ clknet_leaf_287_clk _00013_ _10147_ VDD VSS
+ DFF_X1
X_19155_ _00080_ clknet_leaf_293_clk _00014_ _10146_ VDD VSS
+ DFF_X2
X_19156_ _00081_ clknet_leaf_291_clk _00005_ _10145_ VDD VSS
+ DFF_X1
X_19157_ _00082_ clknet_leaf_291_clk _00006_ _10144_ VDD VSS
+ DFF_X1
X_19158_ _00083_ clknet_leaf_128_clk _00009_ _10143_ VDD VSS
+ DFF_X1
X_19159_ _00084_ clknet_leaf_125_clk _00010_ _10142_ VDD VSS
+ DFF_X1
X_19160_ _00085_ clknet_leaf_128_clk _00011_ _10141_ VDD VSS
+ DFF_X1
X_19161_ _00086_ clknet_leaf_128_clk _00012_ _10140_ VDD VSS
+ DFF_X1
X_19162_ _00087_ clknet_leaf_144_clk _00007_ _10139_ VDD VSS
+ DFF_X1
X_19163_ _00088_ clknet_leaf_198_clk _00008_ _10150_ VDD VSS
+ DFF_X1
Xdynamic_node_top.REG_reset_fin.q$_DFF_P_ net289 clknet_leaf_108_clk
+ dynamic_node_top.REG_reset_fin.q _00056_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.elements_in_array_f\[0\]$_SDFFE_PP0N_
+ _00089_ clknet_leaf_175_clk dynamic_node_top.east_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.east_input.NIB.elements_in_array_next\[0\]
+ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.elements_in_array_f\[1\]$_SDFFE_PP0N_
+ _00090_ clknet_leaf_175_clk dynamic_node_top.east_input.NIB.elements_in_array_f\[1\]
+ _10138_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.elements_in_array_f\[2\]$_SDFFE_PP0N_
+ _00091_ clknet_leaf_167_clk dynamic_node_top.east_input.NIB.elements_in_array_f\[2\]
+ _10137_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.head_ptr_f\[0\]$_SDFFE_PP0N_
+ _00092_ clknet_leaf_291_clk dynamic_node_top.east_input.NIB.head_ptr_f\[0\]
+ dynamic_node_top.east_input.NIB.head_ptr_next\[0\] VDD VSS
+ DFF_X1
Xdynamic_node_top.east_input.NIB.head_ptr_f\[1\]$_SDFFE_PP0N_
+ _00082_ clknet_leaf_291_clk dynamic_node_top.east_input.NIB.head_ptr_f\[1\]
+ _10136_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[0\]$_DFFE_PP_
+ _00093_ clknet_leaf_246_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[0\]
+ _10135_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[10\]$_DFFE_PP_
+ _00094_ clknet_leaf_238_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[10\]
+ _10134_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[11\]$_DFFE_PP_
+ _00095_ clknet_leaf_245_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[11\]
+ _10133_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[12\]$_DFFE_PP_
+ _00096_ clknet_leaf_243_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[12\]
+ _10132_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[13\]$_DFFE_PP_
+ _00097_ clknet_leaf_237_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[13\]
+ _10131_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[14\]$_DFFE_PP_
+ _00098_ clknet_leaf_245_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[14\]
+ _10130_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[15\]$_DFFE_PP_
+ _00099_ clknet_leaf_246_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[15\]
+ _10129_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[16\]$_DFFE_PP_
+ _00100_ clknet_leaf_237_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[16\]
+ _10128_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[17\]$_DFFE_PP_
+ _00101_ clknet_leaf_244_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[17\]
+ _10127_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[18\]$_DFFE_PP_
+ _00102_ clknet_leaf_243_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[18\]
+ _10126_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[19\]$_DFFE_PP_
+ _00103_ clknet_leaf_238_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[19\]
+ _10125_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[1\]$_DFFE_PP_
+ _00104_ clknet_leaf_242_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[1\]
+ _10124_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[20\]$_DFFE_PP_
+ _00105_ clknet_leaf_238_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[20\]
+ _10123_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[21\]$_DFFE_PP_
+ _00106_ clknet_leaf_239_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[21\]
+ _10122_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[22\]$_DFFE_PP_
+ _00107_ clknet_leaf_241_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[22\]
+ _10121_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[23\]$_DFFE_PP_
+ _00108_ clknet_leaf_227_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[23\]
+ _10120_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[24\]$_DFFE_PP_
+ _00109_ clknet_leaf_241_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[24\]
+ _10119_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[25\]$_DFFE_PP_
+ _00110_ clknet_leaf_226_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[25\]
+ _10118_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[26\]$_DFFE_PP_
+ _00111_ clknet_leaf_240_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[26\]
+ _10117_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[27\]$_DFFE_PP_
+ _00112_ clknet_leaf_242_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[27\]
+ _10116_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[28\]$_DFFE_PP_
+ _00113_ clknet_leaf_230_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[28\]
+ _10115_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[29\]$_DFFE_PP_
+ _00114_ clknet_leaf_227_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[29\]
+ _10114_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[2\]$_DFFE_PP_
+ _00115_ clknet_leaf_228_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[2\]
+ _10113_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[30\]$_DFFE_PP_
+ _00116_ clknet_leaf_230_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[30\]
+ _10112_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[31\]$_DFFE_PP_
+ _00117_ clknet_leaf_221_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[31\]
+ _10111_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[32\]$_DFFE_PP_
+ _00118_ clknet_leaf_222_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[32\]
+ _10110_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[33\]$_DFFE_PP_
+ _00119_ clknet_leaf_239_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[33\]
+ _10109_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[34\]$_DFFE_PP_
+ _00120_ clknet_leaf_213_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[34\]
+ _10108_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[35\]$_DFFE_PP_
+ _00121_ clknet_leaf_222_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[35\]
+ _10107_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[36\]$_DFFE_PP_
+ _00122_ clknet_leaf_230_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[36\]
+ _10106_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[37\]$_DFFE_PP_
+ _00123_ clknet_leaf_212_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[37\]
+ _10105_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[38\]$_DFFE_PP_
+ _00124_ clknet_leaf_232_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[38\]
+ _10104_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[39\]$_DFFE_PP_
+ _00125_ clknet_leaf_230_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[39\]
+ _10103_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[3\]$_DFFE_PP_
+ _00126_ clknet_leaf_236_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[3\]
+ _10102_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[40\]$_DFFE_PP_
+ _00127_ clknet_leaf_209_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[40\]
+ _10101_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[41\]$_DFFE_PP_
+ _00128_ clknet_leaf_233_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[41\]
+ _10100_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[42\]$_DFFE_PP_
+ _00129_ clknet_leaf_208_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[42\]
+ _10099_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[43\]$_DFFE_PP_
+ _00130_ clknet_leaf_208_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[43\]
+ _10098_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[44\]$_DFFE_PP_
+ _00131_ clknet_leaf_209_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[44\]
+ _10097_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[45\]$_DFFE_PP_
+ _00132_ clknet_leaf_210_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[45\]
+ _10096_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[46\]$_DFFE_PP_
+ _00133_ clknet_leaf_207_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[46\]
+ _10095_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[47\]$_DFFE_PP_
+ _00134_ clknet_leaf_233_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[47\]
+ _10094_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[48\]$_DFFE_PP_
+ _00135_ clknet_leaf_232_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[48\]
+ _10093_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[49\]$_DFFE_PP_
+ _00136_ clknet_leaf_233_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[49\]
+ _10092_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[4\]$_DFFE_PP_
+ _00137_ clknet_leaf_235_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[4\]
+ _10091_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[50\]$_DFFE_PP_
+ _00138_ clknet_leaf_289_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[50\]
+ _10090_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[51\]$_DFFE_PP_
+ _00139_ clknet_leaf_234_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[51\]
+ _10089_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[52\]$_DFFE_PP_
+ _00140_ clknet_leaf_288_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[52\]
+ _10088_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[53\]$_DFFE_PP_
+ _00141_ clknet_leaf_261_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[53\]
+ _10087_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[54\]$_DFFE_PP_
+ _00142_ clknet_leaf_207_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[54\]
+ _10086_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[55\]$_DFFE_PP_
+ _00143_ clknet_leaf_287_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[55\]
+ _10085_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[56\]$_DFFE_PP_
+ _00144_ clknet_leaf_262_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[56\]
+ _10084_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[57\]$_DFFE_PP_
+ _00145_ clknet_leaf_260_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[57\]
+ _10083_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[58\]$_DFFE_PP_
+ _00146_ clknet_leaf_234_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[58\]
+ _10082_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[59\]$_DFFE_PP_
+ _00147_ clknet_leaf_286_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[59\]
+ _10081_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[5\]$_DFFE_PP_
+ _00148_ clknet_leaf_260_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[5\]
+ _10080_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[60\]$_DFFE_PP_
+ _00149_ clknet_leaf_287_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[60\]
+ _10079_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[61\]$_DFFE_PP_
+ _00150_ clknet_leaf_288_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[61\]
+ _10078_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[62\]$_DFFE_PP_
+ _00151_ clknet_leaf_262_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[62\]
+ _10077_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[63\]$_DFFE_PP_
+ _00152_ clknet_leaf_290_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[63\]
+ _10076_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[6\]$_DFFE_PP_
+ _00153_ clknet_leaf_237_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[6\]
+ _10075_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[7\]$_DFFE_PP_
+ _00154_ clknet_leaf_237_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[7\]
+ _10074_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[8\]$_DFFE_PP_
+ _00155_ clknet_leaf_258_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[8\]
+ _10073_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[0\]\[9\]$_DFFE_PP_
+ _00156_ clknet_leaf_260_clk dynamic_node_top.east_input.NIB.storage_data_f\[0\]\[9\]
+ _10072_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[0\]$_DFFE_PP_
+ _00157_ clknet_leaf_244_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[0\]
+ _10071_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[10\]$_DFFE_PP_
+ _00158_ clknet_leaf_244_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[10\]
+ _10070_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[11\]$_DFFE_PP_
+ _00159_ clknet_leaf_257_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[11\]
+ _10069_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[12\]$_DFFE_PP_
+ _00160_ clknet_leaf_242_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[12\]
+ _10068_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[13\]$_DFFE_PP_
+ _00161_ clknet_leaf_245_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[13\]
+ _10067_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[14\]$_DFFE_PP_
+ _00162_ clknet_leaf_245_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[14\]
+ _10066_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[15\]$_DFFE_PP_
+ _00163_ clknet_leaf_244_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[15\]
+ _10065_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[16\]$_DFFE_PP_
+ _00164_ clknet_leaf_237_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[16\]
+ _10064_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[17\]$_DFFE_PP_
+ _00165_ clknet_leaf_244_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[17\]
+ _10063_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[18\]$_DFFE_PP_
+ _00166_ clknet_leaf_243_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[18\]
+ _10062_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[19\]$_DFFE_PP_
+ _00167_ clknet_leaf_238_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[19\]
+ _10061_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[1\]$_DFFE_PP_
+ _00168_ clknet_leaf_240_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[1\]
+ _10060_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[20\]$_DFFE_PP_
+ _00169_ clknet_leaf_240_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[20\]
+ _10059_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[21\]$_DFFE_PP_
+ _00170_ clknet_leaf_239_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[21\]
+ _10058_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[22\]$_DFFE_PP_
+ _00171_ clknet_leaf_241_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[22\]
+ _10057_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[23\]$_DFFE_PP_
+ _00172_ clknet_leaf_227_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[23\]
+ _10056_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[24\]$_DFFE_PP_
+ _00173_ clknet_leaf_241_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[24\]
+ _10055_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[25\]$_DFFE_PP_
+ _00174_ clknet_leaf_226_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[25\]
+ _10054_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[26\]$_DFFE_PP_
+ _00175_ clknet_leaf_240_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[26\]
+ _10053_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[27\]$_DFFE_PP_
+ _00176_ clknet_leaf_241_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[27\]
+ _10052_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[28\]$_DFFE_PP_
+ _00177_ clknet_leaf_229_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[28\]
+ _10051_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[29\]$_DFFE_PP_
+ _00178_ clknet_leaf_227_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[29\]
+ _10050_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[2\]$_DFFE_PP_
+ _00179_ clknet_leaf_229_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[2\]
+ _10049_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[30\]$_DFFE_PP_
+ _00180_ clknet_leaf_229_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[30\]
+ _10048_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[31\]$_DFFE_PP_
+ _00181_ clknet_leaf_221_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[31\]
+ _10047_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[32\]$_DFFE_PP_
+ _00182_ clknet_leaf_222_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[32\]
+ _10046_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[33\]$_DFFE_PP_
+ _00183_ clknet_leaf_228_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[33\]
+ _10045_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[34\]$_DFFE_PP_
+ _00184_ clknet_leaf_213_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[34\]
+ _10044_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[35\]$_DFFE_PP_
+ _00185_ clknet_leaf_222_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[35\]
+ _10043_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[36\]$_DFFE_PP_
+ _00186_ clknet_leaf_231_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[36\]
+ _10042_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[37\]$_DFFE_PP_
+ _00187_ clknet_leaf_212_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[37\]
+ _10041_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[38\]$_DFFE_PP_
+ _00188_ clknet_leaf_231_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[38\]
+ _10040_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[39\]$_DFFE_PP_
+ _00189_ clknet_leaf_231_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[39\]
+ _10039_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[3\]$_DFFE_PP_
+ _00190_ clknet_leaf_229_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[3\]
+ _10038_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[40\]$_DFFE_PP_
+ _00191_ clknet_leaf_212_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[40\]
+ _10037_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[41\]$_DFFE_PP_
+ _00192_ clknet_leaf_232_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[41\]
+ _10036_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[42\]$_DFFE_PP_
+ _00193_ clknet_leaf_208_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[42\]
+ _10035_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[43\]$_DFFE_PP_
+ _00194_ clknet_leaf_208_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[43\]
+ _10034_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[44\]$_DFFE_PP_
+ _00195_ clknet_leaf_210_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[44\]
+ _10033_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[45\]$_DFFE_PP_
+ _00196_ clknet_leaf_212_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[45\]
+ _10032_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[46\]$_DFFE_PP_
+ _00197_ clknet_leaf_207_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[46\]
+ _10031_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[47\]$_DFFE_PP_
+ _00198_ clknet_leaf_208_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[47\]
+ _10030_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[48\]$_DFFE_PP_
+ _00199_ clknet_leaf_233_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[48\]
+ _10029_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[49\]$_DFFE_PP_
+ _00200_ clknet_leaf_233_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[49\]
+ _10028_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[4\]$_DFFE_PP_
+ _00201_ clknet_leaf_235_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[4\]
+ _10027_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[50\]$_DFFE_PP_
+ _00202_ clknet_leaf_289_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[50\]
+ _10026_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[51\]$_DFFE_PP_
+ _00203_ clknet_leaf_234_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[51\]
+ _10025_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[52\]$_DFFE_PP_
+ _00204_ clknet_leaf_288_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[52\]
+ _10024_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[53\]$_DFFE_PP_
+ _00205_ clknet_leaf_289_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[53\]
+ _10023_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[54\]$_DFFE_PP_
+ _00206_ clknet_leaf_289_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[54\]
+ _10022_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[55\]$_DFFE_PP_
+ _00207_ clknet_leaf_290_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[55\]
+ _10021_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[56\]$_DFFE_PP_
+ _00208_ clknet_leaf_262_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[56\]
+ _10020_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[57\]$_DFFE_PP_
+ _00209_ clknet_leaf_261_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[57\]
+ _10019_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[58\]$_DFFE_PP_
+ _00210_ clknet_leaf_234_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[58\]
+ _10018_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[59\]$_DFFE_PP_
+ _00211_ clknet_leaf_286_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[59\]
+ _10017_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[5\]$_DFFE_PP_
+ _00212_ clknet_leaf_260_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[5\]
+ _10016_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[60\]$_DFFE_PP_
+ _00213_ clknet_leaf_287_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[60\]
+ _10015_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[61\]$_DFFE_PP_
+ _00214_ clknet_leaf_288_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[61\]
+ _10014_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[62\]$_DFFE_PP_
+ _00215_ clknet_leaf_261_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[62\]
+ _10013_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[63\]$_DFFE_PP_
+ _00216_ clknet_leaf_290_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[63\]
+ _10012_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[6\]$_DFFE_PP_
+ _00217_ clknet_leaf_236_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[6\]
+ _10011_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[7\]$_DFFE_PP_
+ _00218_ clknet_leaf_257_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[7\]
+ _10010_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[8\]$_DFFE_PP_
+ _00219_ clknet_leaf_258_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[8\]
+ _10009_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[1\]\[9\]$_DFFE_PP_
+ _00220_ clknet_leaf_260_clk dynamic_node_top.east_input.NIB.storage_data_f\[1\]\[9\]
+ _10008_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[0\]$_DFFE_PP_
+ _00221_ clknet_leaf_246_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[0\]
+ _10007_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[10\]$_DFFE_PP_
+ _00222_ clknet_leaf_238_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[10\]
+ _10006_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[11\]$_DFFE_PP_
+ _00223_ clknet_leaf_257_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[11\]
+ _10005_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[12\]$_DFFE_PP_
+ _00224_ clknet_leaf_243_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[12\]
+ _10004_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[13\]$_DFFE_PP_
+ _00225_ clknet_leaf_238_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[13\]
+ _10003_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[14\]$_DFFE_PP_
+ _00226_ clknet_leaf_245_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[14\]
+ _10002_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[15\]$_DFFE_PP_
+ _00227_ clknet_leaf_246_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[15\]
+ _10001_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[16\]$_DFFE_PP_
+ _00228_ clknet_leaf_236_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[16\]
+ _10000_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[17\]$_DFFE_PP_
+ _00229_ clknet_leaf_244_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[17\]
+ _09999_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[18\]$_DFFE_PP_
+ _00230_ clknet_leaf_243_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[18\]
+ _09998_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[19\]$_DFFE_PP_
+ _00231_ clknet_leaf_239_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[19\]
+ _09997_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[1\]$_DFFE_PP_
+ _00232_ clknet_leaf_242_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[1\]
+ _09996_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[20\]$_DFFE_PP_
+ _00233_ clknet_leaf_240_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[20\]
+ _09995_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[21\]$_DFFE_PP_
+ _00234_ clknet_leaf_239_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[21\]
+ _09994_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[22\]$_DFFE_PP_
+ _00235_ clknet_leaf_242_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[22\]
+ _09993_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[23\]$_DFFE_PP_
+ _00236_ clknet_leaf_226_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[23\]
+ _09992_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[24\]$_DFFE_PP_
+ _00237_ clknet_leaf_241_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[24\]
+ _09991_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[25\]$_DFFE_PP_
+ _00238_ clknet_leaf_226_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[25\]
+ _09990_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[26\]$_DFFE_PP_
+ _00239_ clknet_leaf_240_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[26\]
+ _09989_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[27\]$_DFFE_PP_
+ _00240_ clknet_leaf_242_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[27\]
+ _09988_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[28\]$_DFFE_PP_
+ _00241_ clknet_leaf_229_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[28\]
+ _09987_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[29\]$_DFFE_PP_
+ _00242_ clknet_leaf_227_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[29\]
+ _09986_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[2\]$_DFFE_PP_
+ _00243_ clknet_leaf_228_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[2\]
+ _09985_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[30\]$_DFFE_PP_
+ _00244_ clknet_leaf_230_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[30\]
+ _09984_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[31\]$_DFFE_PP_
+ _00245_ clknet_leaf_213_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[31\]
+ _09983_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[32\]$_DFFE_PP_
+ _00246_ clknet_leaf_221_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[32\]
+ _09982_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[33\]$_DFFE_PP_
+ _00247_ clknet_leaf_228_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[33\]
+ _09981_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[34\]$_DFFE_PP_
+ _00248_ clknet_leaf_213_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[34\]
+ _09980_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[35\]$_DFFE_PP_
+ _00249_ clknet_leaf_222_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[35\]
+ _09979_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[36\]$_DFFE_PP_
+ _00250_ clknet_leaf_230_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[36\]
+ _09978_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[37\]$_DFFE_PP_
+ _00251_ clknet_leaf_212_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[37\]
+ _09977_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[38\]$_DFFE_PP_
+ _00252_ clknet_leaf_232_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[38\]
+ _09976_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[39\]$_DFFE_PP_
+ _00253_ clknet_leaf_230_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[39\]
+ _09975_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[3\]$_DFFE_PP_
+ _00254_ clknet_leaf_239_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[3\]
+ _09974_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[40\]$_DFFE_PP_
+ _00255_ clknet_leaf_209_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[40\]
+ _09973_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[41\]$_DFFE_PP_
+ _00256_ clknet_leaf_235_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[41\]
+ _09972_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[42\]$_DFFE_PP_
+ _00257_ clknet_leaf_208_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[42\]
+ _09971_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[43\]$_DFFE_PP_
+ _00258_ clknet_leaf_231_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[43\]
+ _09970_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[44\]$_DFFE_PP_
+ _00259_ clknet_leaf_209_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[44\]
+ _09969_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[45\]$_DFFE_PP_
+ _00260_ clknet_leaf_209_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[45\]
+ _09968_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[46\]$_DFFE_PP_
+ _00261_ clknet_leaf_207_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[46\]
+ _09967_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[47\]$_DFFE_PP_
+ _00262_ clknet_leaf_233_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[47\]
+ _09966_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[48\]$_DFFE_PP_
+ _00263_ clknet_leaf_232_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[48\]
+ _09965_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[49\]$_DFFE_PP_
+ _00264_ clknet_leaf_233_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[49\]
+ _09964_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[4\]$_DFFE_PP_
+ _00265_ clknet_leaf_235_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[4\]
+ _09963_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[50\]$_DFFE_PP_
+ _00266_ clknet_leaf_289_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[50\]
+ _09962_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[51\]$_DFFE_PP_
+ _00267_ clknet_leaf_234_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[51\]
+ _09961_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[52\]$_DFFE_PP_
+ _00268_ clknet_leaf_288_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[52\]
+ _09960_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[53\]$_DFFE_PP_
+ _00269_ clknet_leaf_261_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[53\]
+ _09959_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[54\]$_DFFE_PP_
+ _00270_ clknet_leaf_207_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[54\]
+ _09958_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[55\]$_DFFE_PP_
+ _00271_ clknet_leaf_287_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[55\]
+ _09957_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[56\]$_DFFE_PP_
+ _00272_ clknet_leaf_262_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[56\]
+ _09956_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[57\]$_DFFE_PP_
+ _00273_ clknet_leaf_261_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[57\]
+ _09955_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[58\]$_DFFE_PP_
+ _00274_ clknet_leaf_235_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[58\]
+ _09954_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[59\]$_DFFE_PP_
+ _00275_ clknet_leaf_286_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[59\]
+ _09953_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[5\]$_DFFE_PP_
+ _00276_ clknet_leaf_260_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[5\]
+ _09952_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[60\]$_DFFE_PP_
+ _00277_ clknet_leaf_287_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[60\]
+ _09951_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[61\]$_DFFE_PP_
+ _00278_ clknet_leaf_286_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[61\]
+ _09950_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[62\]$_DFFE_PP_
+ _00279_ clknet_leaf_262_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[62\]
+ _09949_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[63\]$_DFFE_PP_
+ _00280_ clknet_leaf_290_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[63\]
+ _09948_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[6\]$_DFFE_PP_
+ _00281_ clknet_leaf_236_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[6\]
+ _09947_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[7\]$_DFFE_PP_
+ _00282_ clknet_leaf_258_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[7\]
+ _09946_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[8\]$_DFFE_PP_
+ _00283_ clknet_leaf_258_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[8\]
+ _09945_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[2\]\[9\]$_DFFE_PP_
+ _00284_ clknet_leaf_258_clk dynamic_node_top.east_input.NIB.storage_data_f\[2\]\[9\]
+ _09944_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[0\]$_DFFE_PP_
+ _00285_ clknet_leaf_245_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[0\]
+ _09943_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[10\]$_DFFE_PP_
+ _00286_ clknet_leaf_238_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[10\]
+ _09942_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[11\]$_DFFE_PP_
+ _00287_ clknet_leaf_257_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[11\]
+ _09941_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[12\]$_DFFE_PP_
+ _00288_ clknet_leaf_243_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[12\]
+ _09940_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[13\]$_DFFE_PP_
+ _00289_ clknet_leaf_245_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[13\]
+ _09939_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[14\]$_DFFE_PP_
+ _00290_ clknet_leaf_245_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[14\]
+ _09938_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[15\]$_DFFE_PP_
+ _00291_ clknet_leaf_244_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[15\]
+ _09937_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[16\]$_DFFE_PP_
+ _00292_ clknet_leaf_237_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[16\]
+ _09936_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[17\]$_DFFE_PP_
+ _00293_ clknet_leaf_244_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[17\]
+ _09935_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[18\]$_DFFE_PP_
+ _00294_ clknet_leaf_243_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[18\]
+ _09934_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[19\]$_DFFE_PP_
+ _00295_ clknet_leaf_238_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[19\]
+ _09933_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[1\]$_DFFE_PP_
+ _00296_ clknet_leaf_242_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[1\]
+ _09932_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[20\]$_DFFE_PP_
+ _00297_ clknet_leaf_242_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[20\]
+ _09931_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[21\]$_DFFE_PP_
+ _00298_ clknet_leaf_239_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[21\]
+ _09930_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[22\]$_DFFE_PP_
+ _00299_ clknet_leaf_240_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[22\]
+ _09929_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[23\]$_DFFE_PP_
+ _00300_ clknet_leaf_227_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[23\]
+ _09928_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[24\]$_DFFE_PP_
+ _00301_ clknet_leaf_226_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[24\]
+ _09927_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[25\]$_DFFE_PP_
+ _00302_ clknet_leaf_226_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[25\]
+ _09926_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[26\]$_DFFE_PP_
+ _00303_ clknet_leaf_241_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[26\]
+ _09925_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[27\]$_DFFE_PP_
+ _00304_ clknet_leaf_241_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[27\]
+ _09924_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[28\]$_DFFE_PP_
+ _00305_ clknet_leaf_227_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[28\]
+ _09923_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[29\]$_DFFE_PP_
+ _00306_ clknet_leaf_225_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[29\]
+ _09922_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[2\]$_DFFE_PP_
+ _00307_ clknet_leaf_227_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[2\]
+ _09921_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[30\]$_DFFE_PP_
+ _00308_ clknet_leaf_229_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[30\]
+ _09920_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[31\]$_DFFE_PP_
+ _00309_ clknet_leaf_221_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[31\]
+ _09919_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[32\]$_DFFE_PP_
+ _00310_ clknet_leaf_222_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[32\]
+ _09918_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[33\]$_DFFE_PP_
+ _00311_ clknet_leaf_228_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[33\]
+ _09917_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[34\]$_DFFE_PP_
+ _00312_ clknet_leaf_213_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[34\]
+ _09916_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[35\]$_DFFE_PP_
+ _00313_ clknet_leaf_222_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[35\]
+ _09915_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[36\]$_DFFE_PP_
+ _00314_ clknet_leaf_231_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[36\]
+ _09914_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[37\]$_DFFE_PP_
+ _00315_ clknet_leaf_213_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[37\]
+ _09913_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[38\]$_DFFE_PP_
+ _00316_ clknet_leaf_231_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[38\]
+ _09912_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[39\]$_DFFE_PP_
+ _00317_ clknet_leaf_209_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[39\]
+ _09911_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[3\]$_DFFE_PP_
+ _00318_ clknet_leaf_228_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[3\]
+ _09910_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[40\]$_DFFE_PP_
+ _00319_ clknet_leaf_212_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[40\]
+ _09909_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[41\]$_DFFE_PP_
+ _00320_ clknet_leaf_232_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[41\]
+ _09908_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[42\]$_DFFE_PP_
+ _00321_ clknet_leaf_231_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[42\]
+ _09907_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[43\]$_DFFE_PP_
+ _00322_ clknet_leaf_208_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[43\]
+ _09906_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[44\]$_DFFE_PP_
+ _00323_ clknet_leaf_209_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[44\]
+ _09905_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[45\]$_DFFE_PP_
+ _00324_ clknet_leaf_210_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[45\]
+ _09904_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[46\]$_DFFE_PP_
+ _00325_ clknet_leaf_207_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[46\]
+ _09903_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[47\]$_DFFE_PP_
+ _00326_ clknet_leaf_207_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[47\]
+ _09902_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[48\]$_DFFE_PP_
+ _00327_ clknet_leaf_232_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[48\]
+ _09901_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[49\]$_DFFE_PP_
+ _00328_ clknet_leaf_233_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[49\]
+ _09900_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[4\]$_DFFE_PP_
+ _00329_ clknet_leaf_235_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[4\]
+ _09899_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[50\]$_DFFE_PP_
+ _00330_ clknet_leaf_289_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[50\]
+ _09898_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[51\]$_DFFE_PP_
+ _00331_ clknet_leaf_234_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[51\]
+ _09897_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[52\]$_DFFE_PP_
+ _00332_ clknet_leaf_288_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[52\]
+ _09896_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[53\]$_DFFE_PP_
+ _00333_ clknet_leaf_261_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[53\]
+ _09895_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[54\]$_DFFE_PP_
+ _00334_ clknet_leaf_289_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[54\]
+ _09894_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[55\]$_DFFE_PP_
+ _00335_ clknet_leaf_290_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[55\]
+ _09893_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[56\]$_DFFE_PP_
+ _00336_ clknet_leaf_262_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[56\]
+ _09892_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[57\]$_DFFE_PP_
+ _00337_ clknet_leaf_261_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[57\]
+ _09891_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[58\]$_DFFE_PP_
+ _00338_ clknet_leaf_234_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[58\]
+ _09890_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[59\]$_DFFE_PP_
+ _00339_ clknet_leaf_286_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[59\]
+ _09889_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[5\]$_DFFE_PP_
+ _00340_ clknet_leaf_260_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[5\]
+ _09888_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[60\]$_DFFE_PP_
+ _00341_ clknet_leaf_287_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[60\]
+ _09887_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[61\]$_DFFE_PP_
+ _00342_ clknet_leaf_288_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[61\]
+ _09886_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[62\]$_DFFE_PP_
+ _00343_ clknet_leaf_261_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[62\]
+ _09885_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[63\]$_DFFE_PP_
+ _00344_ clknet_leaf_290_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[63\]
+ _09884_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[6\]$_DFFE_PP_
+ _00345_ clknet_leaf_236_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[6\]
+ _09883_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[7\]$_DFFE_PP_
+ _00346_ clknet_leaf_257_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[7\]
+ _09882_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[8\]$_DFFE_PP_
+ _00347_ clknet_leaf_258_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[8\]
+ _09881_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.storage_data_f\[3\]\[9\]$_DFFE_PP_
+ _00348_ clknet_leaf_260_clk dynamic_node_top.east_input.NIB.storage_data_f\[3\]\[9\]
+ _09880_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.NIB.tail_ptr_f\[0\]$_SDFFE_PP0N_
+ _00349_ clknet_leaf_236_clk dynamic_node_top.east_input.NIB.tail_ptr_f\[0\]
+ dynamic_node_top.east_input.NIB.tail_ptr_next\[0\] VDD VSS
+ DFF_X1
Xdynamic_node_top.east_input.NIB.tail_ptr_f\[1\]$_SDFFE_PP0N_
+ _00350_ clknet_leaf_236_clk dynamic_node_top.east_input.NIB.tail_ptr_f\[1\]
+ _10576_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.count_f\[0\]$_SDFF_PP0_
+ _00351_ clknet_leaf_177_clk dynamic_node_top.east_input.control.count_f\[0\]
+ _10438_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.count_f\[1\]$_SDFF_PP0_
+ _00352_ clknet_leaf_177_clk dynamic_node_top.east_input.control.count_f\[1\]
+ _10439_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.count_f\[2\]$_SDFF_PP0_
+ _00353_ clknet_leaf_174_clk dynamic_node_top.east_input.control.count_f\[2\]
+ _09879_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.count_f\[3\]$_SDFF_PP0_
+ _00354_ clknet_leaf_174_clk dynamic_node_top.east_input.control.count_f\[3\]
+ _09878_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.count_f\[4\]$_SDFF_PP0_
+ _00355_ clknet_leaf_174_clk dynamic_node_top.east_input.control.count_f\[4\]
+ _09877_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.count_f\[5\]$_SDFF_PP0_
+ _00356_ clknet_leaf_174_clk dynamic_node_top.east_input.control.count_f\[5\]
+ _09876_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.count_f\[6\]$_SDFF_PP0_
+ _00357_ clknet_leaf_173_clk dynamic_node_top.east_input.control.count_f\[6\]
+ _09875_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.count_f\[7\]$_SDFF_PP0_
+ _00358_ clknet_leaf_174_clk dynamic_node_top.east_input.control.count_f\[7\]
+ _09874_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.count_one_f$_SDFF_PP0_
+ _00359_ clknet_leaf_176_clk dynamic_node_top.east_input.control.count_one_f
+ _10151_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.header_temp$_DFF_P_ _00000_
+ clknet_leaf_176_clk dynamic_node_top.east_input.control.header_last_temp
+ _09873_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.tail_last_f$_SDFF_PP0_
+ _00360_ clknet_leaf_176_clk dynamic_node_top.east_input.control.tail_last_f
+ _09872_ VDD VSS DFF_X1
Xdynamic_node_top.east_input.control.thanks_all_f$_SDFF_PP0_
+ _00361_ clknet_leaf_175_clk net626 _10152_ VDD VSS DFF_X1
Xdynamic_node_top.east_output.control.current_route_f\[0\]$_DFF_P_
+ _00037_ clknet_leaf_159_clk dynamic_node_top.east_output.control.current_route_f\[0\]
+ _00045_ VDD VSS DFF_X1
Xdynamic_node_top.east_output.control.current_route_f\[1\]$_DFF_P_
+ _00038_ clknet_leaf_160_clk dynamic_node_top.east_output.control.current_route_f\[1\]
+ _00044_ VDD VSS DFF_X1
Xdynamic_node_top.east_output.control.current_route_f\[2\]$_DFF_P_
+ _00039_ clknet_leaf_159_clk dynamic_node_top.east_output.control.current_route_f\[2\]
+ _00075_ VDD VSS DFF_X1
Xdynamic_node_top.east_output.control.current_route_f\[3\]$_DFF_P_
+ _00040_ clknet_leaf_159_clk dynamic_node_top.east_output.control.current_route_f\[3\]
+ _00076_ VDD VSS DFF_X1
Xdynamic_node_top.east_output.control.current_route_f\[4\]$_DFF_P_
+ _00041_ clknet_leaf_159_clk dynamic_node_top.east_output.control.current_route_f\[4\]
+ _00074_ VDD VSS DFF_X1
Xdynamic_node_top.east_output.control.planned_f$_SDFF_PP0_
+ _00362_ clknet_leaf_160_clk dynamic_node_top.east_output.control.planned_f
+ _00046_ VDD VSS DFF_X2
Xdynamic_node_top.east_output.space.count_f\[0\]$_SDFF_PP0_
+ _00363_ clknet_leaf_156_clk dynamic_node_top.east_output.space.count_f\[0\]
+ _10430_ VDD VSS DFF_X2
Xdynamic_node_top.east_output.space.count_f\[1\]$_SDFF_PP0_
+ _00364_ clknet_leaf_156_clk dynamic_node_top.east_output.space.count_f\[1\]
+ _10431_ VDD VSS DFF_X2
Xdynamic_node_top.east_output.space.count_f\[2\]$_SDFF_PP1_
+ _00365_ clknet_leaf_163_clk dynamic_node_top.east_output.space.count_f\[2\]
+ _00057_ VDD VSS DFF_X1
Xdynamic_node_top.east_output.space.is_one_f$_SDFF_PP0_ _00366_
+ clknet_leaf_156_clk dynamic_node_top.east_output.space.is_one_f
+ _09871_ VDD VSS DFF_X1
Xdynamic_node_top.east_output.space.is_two_or_more_f$_SDFF_PP1_
+ _00367_ clknet_leaf_156_clk dynamic_node_top.east_output.space.is_two_or_more_f
+ _09870_ VDD VSS DFF_X1
Xdynamic_node_top.east_output.space.valid_f$_SDFF_PP0_ _00368_
+ clknet_leaf_156_clk dynamic_node_top.east_output.space.valid_f
+ _10427_ VDD VSS DFF_X1
Xdynamic_node_top.east_output.space.yummy_f$_SDFF_PP0_ _00369_
+ clknet_leaf_156_clk dynamic_node_top.east_output.space.yummy_f
+ _10424_ VDD VSS DFF_X1
Xdynamic_node_top.myChipID_f\[0\]$_SDFF_PP0_ _00370_ clknet_leaf_13_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[0\] _09869_
+ VDD VSS DFF_X2
Xdynamic_node_top.myChipID_f\[10\]$_SDFF_PP0_ _00371_ clknet_leaf_13_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[10\] _09868_
+ VDD VSS DFF_X2
Xdynamic_node_top.myChipID_f\[11\]$_SDFF_PP0_ _00372_ clknet_leaf_12_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[11\] _09867_
+ VDD VSS DFF_X1
Xdynamic_node_top.myChipID_f\[12\]$_SDFF_PP0_ _00373_ clknet_leaf_12_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[12\] _09866_
+ VDD VSS DFF_X2
Xdynamic_node_top.myChipID_f\[13\]$_SDFF_PP0_ _00374_ clknet_leaf_309_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[13\] _09865_
+ VDD VSS DFF_X1
Xdynamic_node_top.myChipID_f\[1\]$_SDFF_PP0_ _00375_ clknet_leaf_14_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[1\] _09864_
+ VDD VSS DFF_X1
Xdynamic_node_top.myChipID_f\[2\]$_SDFF_PP0_ _00376_ clknet_leaf_12_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[2\] _09863_
+ VDD VSS DFF_X1
Xdynamic_node_top.myChipID_f\[3\]$_SDFF_PP0_ _00377_ clknet_leaf_14_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[3\] _09862_
+ VDD VSS DFF_X1
Xdynamic_node_top.myChipID_f\[4\]$_SDFF_PP0_ _00378_ clknet_leaf_12_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[4\] _09861_
+ VDD VSS DFF_X2
Xdynamic_node_top.myChipID_f\[5\]$_SDFF_PP0_ _00379_ clknet_leaf_13_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[5\] _09860_
+ VDD VSS DFF_X1
Xdynamic_node_top.myChipID_f\[6\]$_SDFF_PP0_ _00380_ clknet_leaf_48_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[6\] _09859_
+ VDD VSS DFF_X1
Xdynamic_node_top.myChipID_f\[7\]$_SDFF_PP0_ _00381_ clknet_leaf_47_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[7\] _09858_
+ VDD VSS DFF_X1
Xdynamic_node_top.myChipID_f\[8\]$_SDFF_PP0_ _00382_ clknet_leaf_47_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[8\] _09857_
+ VDD VSS DFF_X1
Xdynamic_node_top.myChipID_f\[9\]$_SDFF_PP0_ _00383_ clknet_leaf_205_clk
+ dynamic_node_top.east_input.control.my_chip_id_in\[9\] _09856_
+ VDD VSS DFF_X1
Xdynamic_node_top.myLocX_f\[0\]$_SDFF_PP0_ _00384_ clknet_leaf_139_clk
+ dynamic_node_top.east_input.control.my_loc_x_in\[0\] _10178_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocX_f\[1\]$_SDFF_PP0_ _00385_ clknet_leaf_138_clk
+ dynamic_node_top.east_input.control.my_loc_x_in\[1\] _09855_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocX_f\[2\]$_SDFF_PP0_ _00386_ clknet_leaf_145_clk
+ dynamic_node_top.east_input.control.my_loc_x_in\[2\] _09854_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocX_f\[3\]$_SDFF_PP0_ _00387_ clknet_leaf_138_clk
+ dynamic_node_top.east_input.control.my_loc_x_in\[3\] _09853_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocX_f\[4\]$_SDFF_PP0_ _00388_ clknet_leaf_144_clk
+ dynamic_node_top.east_input.control.my_loc_x_in\[4\] _09852_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocX_f\[5\]$_SDFF_PP0_ _00389_ clknet_leaf_144_clk
+ dynamic_node_top.east_input.control.my_loc_x_in\[5\] _09851_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocX_f\[6\]$_SDFF_PP0_ _00390_ clknet_leaf_164_clk
+ dynamic_node_top.east_input.control.my_loc_x_in\[6\] _09850_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocX_f\[7\]$_SDFF_PP0_ _00391_ clknet_leaf_164_clk
+ dynamic_node_top.east_input.control.my_loc_x_in\[7\] _09849_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocY_f\[0\]$_SDFF_PP0_ _00392_ clknet_leaf_176_clk
+ dynamic_node_top.east_input.control.my_loc_y_in\[0\] _10224_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocY_f\[1\]$_SDFF_PP0_ _00393_ clknet_leaf_164_clk
+ dynamic_node_top.east_input.control.my_loc_y_in\[1\] _09848_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocY_f\[2\]$_SDFF_PP0_ _00394_ clknet_leaf_162_clk
+ dynamic_node_top.east_input.control.my_loc_y_in\[2\] _09847_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocY_f\[3\]$_SDFF_PP0_ _00395_ clknet_leaf_162_clk
+ dynamic_node_top.east_input.control.my_loc_y_in\[3\] _09846_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocY_f\[4\]$_SDFF_PP0_ _00396_ clknet_leaf_162_clk
+ dynamic_node_top.east_input.control.my_loc_y_in\[4\] _09845_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocY_f\[5\]$_SDFF_PP0_ _00397_ clknet_leaf_176_clk
+ dynamic_node_top.east_input.control.my_loc_y_in\[5\] _09844_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocY_f\[6\]$_SDFF_PP0_ _00398_ clknet_leaf_161_clk
+ dynamic_node_top.east_input.control.my_loc_y_in\[6\] _09843_
+ VDD VSS DFF_X2
Xdynamic_node_top.myLocY_f\[7\]$_SDFF_PP0_ _00399_ clknet_leaf_176_clk
+ dynamic_node_top.east_input.control.my_loc_y_in\[7\] _09842_
+ VDD VSS DFF_X2
Xdynamic_node_top.north_input.NIB.elements_in_array_f\[0\]$_SDFFE_PP0N_
+ _00400_ clknet_leaf_153_clk dynamic_node_top.north_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.north_input.NIB.elements_in_array_next\[0\]
+ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.elements_in_array_f\[1\]$_SDFFE_PP0N_
+ _00401_ clknet_leaf_152_clk dynamic_node_top.north_input.NIB.elements_in_array_f\[1\]
+ _09841_ VDD VSS DFF_X2
Xdynamic_node_top.north_input.NIB.elements_in_array_f\[2\]$_SDFFE_PP0N_
+ _00402_ clknet_leaf_152_clk dynamic_node_top.north_input.NIB.elements_in_array_f\[2\]
+ _09840_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.head_ptr_f\[0\]$_SDFFE_PP0N_
+ _00403_ clknet_leaf_143_clk dynamic_node_top.north_input.NIB.head_ptr_f\[0\]
+ dynamic_node_top.north_input.NIB.head_ptr_next\[0\] VDD VSS
+ DFF_X1
Xdynamic_node_top.north_input.NIB.head_ptr_f\[1\]$_SDFFE_PP0N_
+ _00088_ clknet_leaf_144_clk dynamic_node_top.north_input.NIB.head_ptr_f\[1\]
+ _09839_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[0\]$_DFFE_PP_
+ _00404_ clknet_leaf_293_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[0\]
+ _09838_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[10\]$_DFFE_PP_
+ _00405_ clknet_leaf_298_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[10\]
+ _09837_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[11\]$_DFFE_PP_
+ _00406_ clknet_leaf_298_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[11\]
+ _09836_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[12\]$_DFFE_PP_
+ _00407_ clknet_leaf_292_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[12\]
+ _09835_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[13\]$_DFFE_PP_
+ _00408_ clknet_leaf_297_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[13\]
+ _09834_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[14\]$_DFFE_PP_
+ _00409_ clknet_leaf_295_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[14\]
+ _09833_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[15\]$_DFFE_PP_
+ _00410_ clknet_leaf_295_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[15\]
+ _09832_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[16\]$_DFFE_PP_
+ _00411_ clknet_leaf_297_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[16\]
+ _09831_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[17\]$_DFFE_PP_
+ _00412_ clknet_leaf_295_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[17\]
+ _09830_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[18\]$_DFFE_PP_
+ _00413_ clknet_leaf_296_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[18\]
+ _09829_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[19\]$_DFFE_PP_
+ _00414_ clknet_leaf_198_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[19\]
+ _09828_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[1\]$_DFFE_PP_
+ _00415_ clknet_leaf_139_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[1\]
+ _09827_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[20\]$_DFFE_PP_
+ _00416_ clknet_leaf_133_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[20\]
+ _09826_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[21\]$_DFFE_PP_
+ _00417_ clknet_leaf_139_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[21\]
+ _09825_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[22\]$_DFFE_PP_
+ _00418_ clknet_leaf_152_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[22\]
+ _09824_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[23\]$_DFFE_PP_
+ _00419_ clknet_leaf_151_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[23\]
+ _09823_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[24\]$_DFFE_PP_
+ _00420_ clknet_leaf_151_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[24\]
+ _09822_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[25\]$_DFFE_PP_
+ _00421_ clknet_leaf_152_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[25\]
+ _09821_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[26\]$_DFFE_PP_
+ _00422_ clknet_leaf_150_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[26\]
+ _09820_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[27\]$_DFFE_PP_
+ _00423_ clknet_leaf_150_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[27\]
+ _09819_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[28\]$_DFFE_PP_
+ _00424_ clknet_leaf_147_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[28\]
+ _09818_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[29\]$_DFFE_PP_
+ _00425_ clknet_leaf_146_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[29\]
+ _09817_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[2\]$_DFFE_PP_
+ _00426_ clknet_leaf_138_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[2\]
+ _09816_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[30\]$_DFFE_PP_
+ _00427_ clknet_leaf_147_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[30\]
+ _09815_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[31\]$_DFFE_PP_
+ _00428_ clknet_leaf_144_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[31\]
+ _09814_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[32\]$_DFFE_PP_
+ _00429_ clknet_leaf_145_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[32\]
+ _09813_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[33\]$_DFFE_PP_
+ _00430_ clknet_leaf_138_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[33\]
+ _09812_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[34\]$_DFFE_PP_
+ _00431_ clknet_leaf_137_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[34\]
+ _09811_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[35\]$_DFFE_PP_
+ _00432_ clknet_leaf_137_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[35\]
+ _09810_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[36\]$_DFFE_PP_
+ _00433_ clknet_leaf_145_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[36\]
+ _09809_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[37\]$_DFFE_PP_
+ _00434_ clknet_leaf_123_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[37\]
+ _09808_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[38\]$_DFFE_PP_
+ _00435_ clknet_leaf_123_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[38\]
+ _09807_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[39\]$_DFFE_PP_
+ _00436_ clknet_leaf_122_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[39\]
+ _09806_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[3\]$_DFFE_PP_
+ _00437_ clknet_leaf_136_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[3\]
+ _09805_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[40\]$_DFFE_PP_
+ _00438_ clknet_leaf_109_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[40\]
+ _09804_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[41\]$_DFFE_PP_
+ _00439_ clknet_leaf_136_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[41\]
+ _09803_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[42\]$_DFFE_PP_
+ _00440_ clknet_leaf_124_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[42\]
+ _09802_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[43\]$_DFFE_PP_
+ _00441_ clknet_leaf_125_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[43\]
+ _09801_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[44\]$_DFFE_PP_
+ _00442_ clknet_leaf_122_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[44\]
+ _09800_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[45\]$_DFFE_PP_
+ _00443_ clknet_leaf_136_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[45\]
+ _09799_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[46\]$_DFFE_PP_
+ _00444_ clknet_leaf_129_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[46\]
+ _09798_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[47\]$_DFFE_PP_
+ _00445_ clknet_leaf_133_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[47\]
+ _09797_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[48\]$_DFFE_PP_
+ _00446_ clknet_leaf_129_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[48\]
+ _09796_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[49\]$_DFFE_PP_
+ _00447_ clknet_leaf_197_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[49\]
+ _09795_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[4\]$_DFFE_PP_
+ _00448_ clknet_leaf_131_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[4\]
+ _09794_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[50\]$_DFFE_PP_
+ _00449_ clknet_leaf_197_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[50\]
+ _09793_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[51\]$_DFFE_PP_
+ _00450_ clknet_leaf_133_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[51\]
+ _09792_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[52\]$_DFFE_PP_
+ _00451_ clknet_leaf_132_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[52\]
+ _09791_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[53\]$_DFFE_PP_
+ _00452_ clknet_leaf_200_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[53\]
+ _09790_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[54\]$_DFFE_PP_
+ _00453_ clknet_leaf_197_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[54\]
+ _09789_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[55\]$_DFFE_PP_
+ _00454_ clknet_leaf_200_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[55\]
+ _09788_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[56\]$_DFFE_PP_
+ _00455_ clknet_leaf_299_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[56\]
+ _09787_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[57\]$_DFFE_PP_
+ _00456_ clknet_leaf_202_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[57\]
+ _09786_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[58\]$_DFFE_PP_
+ _00457_ clknet_leaf_204_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[58\]
+ _09785_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[59\]$_DFFE_PP_
+ _00458_ clknet_leaf_205_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[59\]
+ _09784_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[5\]$_DFFE_PP_
+ _00459_ clknet_leaf_203_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[5\]
+ _09783_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[60\]$_DFFE_PP_
+ _00460_ clknet_leaf_199_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[60\]
+ _09782_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[61\]$_DFFE_PP_
+ _00461_ clknet_leaf_203_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[61\]
+ _09781_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[62\]$_DFFE_PP_
+ _00462_ clknet_leaf_196_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[62\]
+ _09780_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[63\]$_DFFE_PP_
+ _00463_ clknet_leaf_299_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[63\]
+ _09779_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[6\]$_DFFE_PP_
+ _00464_ clknet_leaf_301_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[6\]
+ _09778_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[7\]$_DFFE_PP_
+ _00465_ clknet_leaf_201_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[7\]
+ _09777_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[8\]$_DFFE_PP_
+ _00466_ clknet_leaf_299_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[8\]
+ _09776_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[0\]\[9\]$_DFFE_PP_
+ _00467_ clknet_leaf_200_clk dynamic_node_top.north_input.NIB.storage_data_f\[0\]\[9\]
+ _09775_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[0\]$_DFFE_PP_
+ _00468_ clknet_leaf_295_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[0\]
+ _09774_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[10\]$_DFFE_PP_
+ _00469_ clknet_leaf_298_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[10\]
+ _09773_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[11\]$_DFFE_PP_
+ _00470_ clknet_leaf_298_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[11\]
+ _09772_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[12\]$_DFFE_PP_
+ _00471_ clknet_leaf_292_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[12\]
+ _09771_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[13\]$_DFFE_PP_
+ _00472_ clknet_leaf_291_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[13\]
+ _09770_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[14\]$_DFFE_PP_
+ _00473_ clknet_leaf_296_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[14\]
+ _09769_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[15\]$_DFFE_PP_
+ _00474_ clknet_leaf_295_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[15\]
+ _09768_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[16\]$_DFFE_PP_
+ _00475_ clknet_leaf_291_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[16\]
+ _09767_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[17\]$_DFFE_PP_
+ _00476_ clknet_leaf_297_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[17\]
+ _09766_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[18\]$_DFFE_PP_
+ _00477_ clknet_leaf_296_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[18\]
+ _09765_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[19\]$_DFFE_PP_
+ _00478_ clknet_leaf_134_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[19\]
+ _09764_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[1\]$_DFFE_PP_
+ _00479_ clknet_leaf_134_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[1\]
+ _09763_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[20\]$_DFFE_PP_
+ _00480_ clknet_leaf_134_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[20\]
+ _09762_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[21\]$_DFFE_PP_
+ _00481_ clknet_leaf_139_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[21\]
+ _09761_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[22\]$_DFFE_PP_
+ _00482_ clknet_leaf_149_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[22\]
+ _09760_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[23\]$_DFFE_PP_
+ _00483_ clknet_leaf_151_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[23\]
+ _09759_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[24\]$_DFFE_PP_
+ _00484_ clknet_leaf_149_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[24\]
+ _09758_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[25\]$_DFFE_PP_
+ _00485_ clknet_leaf_149_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[25\]
+ _09757_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[26\]$_DFFE_PP_
+ _00486_ clknet_leaf_149_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[26\]
+ _09756_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[27\]$_DFFE_PP_
+ _00487_ clknet_leaf_150_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[27\]
+ _09755_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[28\]$_DFFE_PP_
+ _00488_ clknet_leaf_147_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[28\]
+ _09754_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[29\]$_DFFE_PP_
+ _00489_ clknet_leaf_146_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[29\]
+ _09753_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[2\]$_DFFE_PP_
+ _00490_ clknet_leaf_135_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[2\]
+ _09752_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[30\]$_DFFE_PP_
+ _00491_ clknet_leaf_147_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[30\]
+ _09751_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[31\]$_DFFE_PP_
+ _00492_ clknet_leaf_144_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[31\]
+ _09750_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[32\]$_DFFE_PP_
+ _00493_ clknet_leaf_146_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[32\]
+ _09749_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[33\]$_DFFE_PP_
+ _00494_ clknet_leaf_136_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[33\]
+ _09748_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[34\]$_DFFE_PP_
+ _00495_ clknet_leaf_137_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[34\]
+ _09747_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[35\]$_DFFE_PP_
+ _00496_ clknet_leaf_137_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[35\]
+ _09746_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[36\]$_DFFE_PP_
+ _00497_ clknet_leaf_138_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[36\]
+ _09745_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[37\]$_DFFE_PP_
+ _00498_ clknet_leaf_122_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[37\]
+ _09744_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[38\]$_DFFE_PP_
+ _00499_ clknet_leaf_123_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[38\]
+ _09743_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[39\]$_DFFE_PP_
+ _00500_ clknet_leaf_122_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[39\]
+ _09742_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[3\]$_DFFE_PP_
+ _00501_ clknet_leaf_136_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[3\]
+ _09741_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[40\]$_DFFE_PP_
+ _00502_ clknet_leaf_110_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[40\]
+ _09740_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[41\]$_DFFE_PP_
+ _00503_ clknet_leaf_135_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[41\]
+ _09739_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[42\]$_DFFE_PP_
+ _00504_ clknet_leaf_126_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[42\]
+ _09738_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[43\]$_DFFE_PP_
+ _00505_ clknet_leaf_125_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[43\]
+ _09737_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[44\]$_DFFE_PP_
+ _00506_ clknet_leaf_124_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[44\]
+ _09736_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[45\]$_DFFE_PP_
+ _00507_ clknet_leaf_123_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[45\]
+ _09735_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[46\]$_DFFE_PP_
+ _00508_ clknet_leaf_132_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[46\]
+ _09734_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[47\]$_DFFE_PP_
+ _00509_ clknet_leaf_133_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[47\]
+ _09733_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[48\]$_DFFE_PP_
+ _00510_ clknet_leaf_132_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[48\]
+ _09732_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[49\]$_DFFE_PP_
+ _00511_ clknet_leaf_198_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[49\]
+ _09731_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[4\]$_DFFE_PP_
+ _00512_ clknet_leaf_131_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[4\]
+ _09730_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[50\]$_DFFE_PP_
+ _00513_ clknet_leaf_197_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[50\]
+ _09729_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[51\]$_DFFE_PP_
+ _00514_ clknet_leaf_198_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[51\]
+ _09728_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[52\]$_DFFE_PP_
+ _00515_ clknet_leaf_131_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[52\]
+ _09727_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[53\]$_DFFE_PP_
+ _00516_ clknet_leaf_199_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[53\]
+ _09726_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[54\]$_DFFE_PP_
+ _00517_ clknet_leaf_199_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[54\]
+ _09725_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[55\]$_DFFE_PP_
+ _00518_ clknet_leaf_201_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[55\]
+ _09724_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[56\]$_DFFE_PP_
+ _00519_ clknet_leaf_202_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[56\]
+ _09723_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[57\]$_DFFE_PP_
+ _00520_ clknet_leaf_202_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[57\]
+ _09722_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[58\]$_DFFE_PP_
+ _00521_ clknet_leaf_204_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[58\]
+ _09721_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[59\]$_DFFE_PP_
+ _00522_ clknet_leaf_205_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[59\]
+ _09720_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[5\]$_DFFE_PP_
+ _00523_ clknet_leaf_203_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[5\]
+ _09719_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[60\]$_DFFE_PP_
+ _00524_ clknet_leaf_203_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[60\]
+ _09718_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[61\]$_DFFE_PP_
+ _00525_ clknet_leaf_206_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[61\]
+ _09717_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[62\]$_DFFE_PP_
+ _00526_ clknet_leaf_206_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[62\]
+ _09716_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[63\]$_DFFE_PP_
+ _00527_ clknet_leaf_204_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[63\]
+ _09715_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[6\]$_DFFE_PP_
+ _00528_ clknet_leaf_300_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[6\]
+ _09714_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[7\]$_DFFE_PP_
+ _00529_ clknet_leaf_201_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[7\]
+ _09713_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[8\]$_DFFE_PP_
+ _00530_ clknet_leaf_300_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[8\]
+ _09712_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[1\]\[9\]$_DFFE_PP_
+ _00531_ clknet_leaf_201_clk dynamic_node_top.north_input.NIB.storage_data_f\[1\]\[9\]
+ _09711_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[0\]$_DFFE_PP_
+ _00532_ clknet_leaf_293_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[0\]
+ _09710_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[10\]$_DFFE_PP_
+ _00533_ clknet_leaf_298_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[10\]
+ _09709_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[11\]$_DFFE_PP_
+ _00534_ clknet_leaf_298_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[11\]
+ _09708_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[12\]$_DFFE_PP_
+ _00535_ clknet_leaf_292_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[12\]
+ _09707_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[13\]$_DFFE_PP_
+ _00536_ clknet_leaf_297_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[13\]
+ _09706_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[14\]$_DFFE_PP_
+ _00537_ clknet_leaf_295_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[14\]
+ _09705_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[15\]$_DFFE_PP_
+ _00538_ clknet_leaf_295_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[15\]
+ _09704_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[16\]$_DFFE_PP_
+ _00539_ clknet_leaf_292_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[16\]
+ _09703_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[17\]$_DFFE_PP_
+ _00540_ clknet_leaf_297_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[17\]
+ _09702_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[18\]$_DFFE_PP_
+ _00541_ clknet_leaf_297_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[18\]
+ _09701_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[19\]$_DFFE_PP_
+ _00542_ clknet_leaf_198_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[19\]
+ _09700_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[1\]$_DFFE_PP_
+ _00543_ clknet_leaf_140_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[1\]
+ _09699_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[20\]$_DFFE_PP_
+ _00544_ clknet_leaf_134_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[20\]
+ _09698_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[21\]$_DFFE_PP_
+ _00545_ clknet_leaf_139_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[21\]
+ _09697_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[22\]$_DFFE_PP_
+ _00546_ clknet_leaf_151_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[22\]
+ _09696_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[23\]$_DFFE_PP_
+ _00547_ clknet_leaf_151_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[23\]
+ _09695_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[24\]$_DFFE_PP_
+ _00548_ clknet_leaf_151_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[24\]
+ _09694_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[25\]$_DFFE_PP_
+ _00549_ clknet_leaf_153_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[25\]
+ _09693_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[26\]$_DFFE_PP_
+ _00550_ clknet_leaf_150_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[26\]
+ _09692_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[27\]$_DFFE_PP_
+ _00551_ clknet_leaf_150_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[27\]
+ _09691_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[28\]$_DFFE_PP_
+ _00552_ clknet_leaf_147_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[28\]
+ _09690_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[29\]$_DFFE_PP_
+ _00553_ clknet_leaf_146_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[29\]
+ _09689_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[2\]$_DFFE_PP_
+ _00554_ clknet_leaf_138_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[2\]
+ _09688_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[30\]$_DFFE_PP_
+ _00555_ clknet_leaf_147_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[30\]
+ _09687_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[31\]$_DFFE_PP_
+ _00556_ clknet_leaf_144_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[31\]
+ _09686_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[32\]$_DFFE_PP_
+ _00557_ clknet_leaf_146_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[32\]
+ _09685_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[33\]$_DFFE_PP_
+ _00558_ clknet_leaf_138_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[33\]
+ _09684_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[34\]$_DFFE_PP_
+ _00559_ clknet_leaf_137_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[34\]
+ _09683_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[35\]$_DFFE_PP_
+ _00560_ clknet_leaf_137_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[35\]
+ _09682_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[36\]$_DFFE_PP_
+ _00561_ clknet_leaf_145_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[36\]
+ _09681_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[37\]$_DFFE_PP_
+ _00562_ clknet_leaf_122_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[37\]
+ _09680_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[38\]$_DFFE_PP_
+ _00563_ clknet_leaf_123_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[38\]
+ _09679_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[39\]$_DFFE_PP_
+ _00564_ clknet_leaf_122_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[39\]
+ _09678_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[3\]$_DFFE_PP_
+ _00565_ clknet_leaf_135_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[3\]
+ _09677_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[40\]$_DFFE_PP_
+ _00566_ clknet_leaf_109_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[40\]
+ _09676_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[41\]$_DFFE_PP_
+ _00567_ clknet_leaf_135_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[41\]
+ _09675_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[42\]$_DFFE_PP_
+ _00568_ clknet_leaf_125_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[42\]
+ _09674_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[43\]$_DFFE_PP_
+ _00569_ clknet_leaf_125_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[43\]
+ _09673_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[44\]$_DFFE_PP_
+ _00570_ clknet_leaf_124_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[44\]
+ _09672_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[45\]$_DFFE_PP_
+ _00571_ clknet_leaf_136_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[45\]
+ _09671_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[46\]$_DFFE_PP_
+ _00572_ clknet_leaf_132_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[46\]
+ _09670_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[47\]$_DFFE_PP_
+ _00573_ clknet_leaf_133_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[47\]
+ _09669_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[48\]$_DFFE_PP_
+ _00574_ clknet_leaf_132_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[48\]
+ _09668_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[49\]$_DFFE_PP_
+ _00575_ clknet_leaf_197_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[49\]
+ _09667_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[4\]$_DFFE_PP_
+ _00576_ clknet_leaf_131_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[4\]
+ _09666_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[50\]$_DFFE_PP_
+ _00577_ clknet_leaf_197_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[50\]
+ _09665_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[51\]$_DFFE_PP_
+ _00578_ clknet_leaf_199_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[51\]
+ _09664_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[52\]$_DFFE_PP_
+ _00579_ clknet_leaf_133_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[52\]
+ _09663_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[53\]$_DFFE_PP_
+ _00580_ clknet_leaf_200_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[53\]
+ _09662_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[54\]$_DFFE_PP_
+ _00581_ clknet_leaf_196_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[54\]
+ _09661_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[55\]$_DFFE_PP_
+ _00582_ clknet_leaf_200_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[55\]
+ _09660_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[56\]$_DFFE_PP_
+ _00583_ clknet_leaf_299_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[56\]
+ _09659_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[57\]$_DFFE_PP_
+ _00584_ clknet_leaf_202_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[57\]
+ _09658_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[58\]$_DFFE_PP_
+ _00585_ clknet_leaf_204_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[58\]
+ _09657_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[59\]$_DFFE_PP_
+ _00586_ clknet_leaf_205_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[59\]
+ _09656_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[5\]$_DFFE_PP_
+ _00587_ clknet_leaf_203_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[5\]
+ _09655_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[60\]$_DFFE_PP_
+ _00588_ clknet_leaf_199_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[60\]
+ _09654_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[61\]$_DFFE_PP_
+ _00589_ clknet_leaf_203_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[61\]
+ _09653_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[62\]$_DFFE_PP_
+ _00590_ clknet_leaf_196_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[62\]
+ _09652_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[63\]$_DFFE_PP_
+ _00591_ clknet_leaf_299_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[63\]
+ _09651_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[6\]$_DFFE_PP_
+ _00592_ clknet_leaf_301_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[6\]
+ _09650_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[7\]$_DFFE_PP_
+ _00593_ clknet_leaf_201_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[7\]
+ _09649_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[8\]$_DFFE_PP_
+ _00594_ clknet_leaf_299_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[8\]
+ _09648_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[2\]\[9\]$_DFFE_PP_
+ _00595_ clknet_leaf_200_clk dynamic_node_top.north_input.NIB.storage_data_f\[2\]\[9\]
+ _09647_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[0\]$_DFFE_PP_
+ _00596_ clknet_leaf_297_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[0\]
+ _09646_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[10\]$_DFFE_PP_
+ _00597_ clknet_leaf_298_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[10\]
+ _09645_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[11\]$_DFFE_PP_
+ _00598_ clknet_leaf_205_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[11\]
+ _09644_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[12\]$_DFFE_PP_
+ _00599_ clknet_leaf_292_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[12\]
+ _09643_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[13\]$_DFFE_PP_
+ _00600_ clknet_leaf_291_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[13\]
+ _09642_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[14\]$_DFFE_PP_
+ _00601_ clknet_leaf_296_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[14\]
+ _09641_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[15\]$_DFFE_PP_
+ _00602_ clknet_leaf_295_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[15\]
+ _09640_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[16\]$_DFFE_PP_
+ _00603_ clknet_leaf_291_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[16\]
+ _09639_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[17\]$_DFFE_PP_
+ _00604_ clknet_leaf_297_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[17\]
+ _09638_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[18\]$_DFFE_PP_
+ _00605_ clknet_leaf_296_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[18\]
+ _09637_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[19\]$_DFFE_PP_
+ _00606_ clknet_leaf_134_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[19\]
+ _09636_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[1\]$_DFFE_PP_
+ _00607_ clknet_leaf_134_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[1\]
+ _09635_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[20\]$_DFFE_PP_
+ _00608_ clknet_leaf_134_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[20\]
+ _09634_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[21\]$_DFFE_PP_
+ _00609_ clknet_leaf_139_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[21\]
+ _09633_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[22\]$_DFFE_PP_
+ _00610_ clknet_leaf_149_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[22\]
+ _09632_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[23\]$_DFFE_PP_
+ _00611_ clknet_leaf_150_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[23\]
+ _09631_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[24\]$_DFFE_PP_
+ _00612_ clknet_leaf_149_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[24\]
+ _09630_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[25\]$_DFFE_PP_
+ _00613_ clknet_leaf_149_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[25\]
+ _09629_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[26\]$_DFFE_PP_
+ _00614_ clknet_leaf_148_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[26\]
+ _09628_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[27\]$_DFFE_PP_
+ _00615_ clknet_leaf_146_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[27\]
+ _09627_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[28\]$_DFFE_PP_
+ _00616_ clknet_leaf_148_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[28\]
+ _09626_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[29\]$_DFFE_PP_
+ _00617_ clknet_leaf_146_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[29\]
+ _09625_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[2\]$_DFFE_PP_
+ _00618_ clknet_leaf_135_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[2\]
+ _09624_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[30\]$_DFFE_PP_
+ _00619_ clknet_leaf_147_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[30\]
+ _09623_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[31\]$_DFFE_PP_
+ _00620_ clknet_leaf_144_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[31\]
+ _09622_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[32\]$_DFFE_PP_
+ _00621_ clknet_leaf_146_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[32\]
+ _09621_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[33\]$_DFFE_PP_
+ _00622_ clknet_leaf_135_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[33\]
+ _09620_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[34\]$_DFFE_PP_
+ _00623_ clknet_leaf_137_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[34\]
+ _09619_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[35\]$_DFFE_PP_
+ _00624_ clknet_leaf_137_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[35\]
+ _09618_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[36\]$_DFFE_PP_
+ _00625_ clknet_leaf_138_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[36\]
+ _09617_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[37\]$_DFFE_PP_
+ _00626_ clknet_leaf_123_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[37\]
+ _09616_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[38\]$_DFFE_PP_
+ _00627_ clknet_leaf_123_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[38\]
+ _09615_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[39\]$_DFFE_PP_
+ _00628_ clknet_leaf_122_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[39\]
+ _09614_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[3\]$_DFFE_PP_
+ _00629_ clknet_leaf_136_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[3\]
+ _09613_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[40\]$_DFFE_PP_
+ _00630_ clknet_leaf_110_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[40\]
+ _09612_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[41\]$_DFFE_PP_
+ _00631_ clknet_leaf_135_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[41\]
+ _09611_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[42\]$_DFFE_PP_
+ _00632_ clknet_leaf_124_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[42\]
+ _09610_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[43\]$_DFFE_PP_
+ _00633_ clknet_leaf_125_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[43\]
+ _09609_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[44\]$_DFFE_PP_
+ _00634_ clknet_leaf_124_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[44\]
+ _09608_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[45\]$_DFFE_PP_
+ _00635_ clknet_leaf_124_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[45\]
+ _09607_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[46\]$_DFFE_PP_
+ _00636_ clknet_leaf_132_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[46\]
+ _09606_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[47\]$_DFFE_PP_
+ _00637_ clknet_leaf_133_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[47\]
+ _09605_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[48\]$_DFFE_PP_
+ _00638_ clknet_leaf_132_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[48\]
+ _09604_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[49\]$_DFFE_PP_
+ _00639_ clknet_leaf_198_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[49\]
+ _09603_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[4\]$_DFFE_PP_
+ _00640_ clknet_leaf_131_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[4\]
+ _09602_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[50\]$_DFFE_PP_
+ _00641_ clknet_leaf_197_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[50\]
+ _09601_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[51\]$_DFFE_PP_
+ _00642_ clknet_leaf_198_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[51\]
+ _09600_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[52\]$_DFFE_PP_
+ _00643_ clknet_leaf_200_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[52\]
+ _09599_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[53\]$_DFFE_PP_
+ _00644_ clknet_leaf_199_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[53\]
+ _09598_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[54\]$_DFFE_PP_
+ _00645_ clknet_leaf_197_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[54\]
+ _09597_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[55\]$_DFFE_PP_
+ _00646_ clknet_leaf_202_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[55\]
+ _09596_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[56\]$_DFFE_PP_
+ _00647_ clknet_leaf_299_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[56\]
+ _09595_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[57\]$_DFFE_PP_
+ _00648_ clknet_leaf_202_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[57\]
+ _09594_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[58\]$_DFFE_PP_
+ _00649_ clknet_leaf_204_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[58\]
+ _09593_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[59\]$_DFFE_PP_
+ _00650_ clknet_leaf_205_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[59\]
+ _09592_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[5\]$_DFFE_PP_
+ _00651_ clknet_leaf_205_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[5\]
+ _09591_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[60\]$_DFFE_PP_
+ _00652_ clknet_leaf_203_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[60\]
+ _09590_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[61\]$_DFFE_PP_
+ _00653_ clknet_leaf_206_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[61\]
+ _09589_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[62\]$_DFFE_PP_
+ _00654_ clknet_leaf_206_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[62\]
+ _09588_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[63\]$_DFFE_PP_
+ _00655_ clknet_leaf_204_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[63\]
+ _09587_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[6\]$_DFFE_PP_
+ _00656_ clknet_leaf_300_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[6\]
+ _09586_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[7\]$_DFFE_PP_
+ _00657_ clknet_leaf_202_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[7\]
+ _09585_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[8\]$_DFFE_PP_
+ _00658_ clknet_leaf_299_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[8\]
+ _09584_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.storage_data_f\[3\]\[9\]$_DFFE_PP_
+ _00659_ clknet_leaf_200_clk dynamic_node_top.north_input.NIB.storage_data_f\[3\]\[9\]
+ _09583_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.tail_ptr_f\[0\]$_SDFFE_PP0N_
+ _00660_ clknet_leaf_145_clk dynamic_node_top.north_input.NIB.tail_ptr_f\[0\]
+ dynamic_node_top.north_input.NIB.tail_ptr_next\[0\] VDD VSS
+ DFF_X1
Xdynamic_node_top.north_input.NIB.tail_ptr_f\[1\]$_SDFFE_PP0N_
+ _00661_ clknet_leaf_145_clk dynamic_node_top.north_input.NIB.tail_ptr_f\[1\]
+ _10584_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.NIB.yummy_out_f$_SDFF_PP0_ _00662_
+ clknet_leaf_152_clk net627 _09582_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.count_f\[0\]$_SDFF_PP0_
+ _00663_ clknet_leaf_153_clk dynamic_node_top.north_input.control.count_f\[0\]
+ _10420_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.count_f\[1\]$_SDFF_PP0_
+ _00664_ clknet_leaf_153_clk dynamic_node_top.north_input.control.count_f\[1\]
+ _10421_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.count_f\[2\]$_SDFF_PP0_
+ _00665_ clknet_leaf_153_clk dynamic_node_top.north_input.control.count_f\[2\]
+ _09581_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.count_f\[3\]$_SDFF_PP0_
+ _00666_ clknet_leaf_153_clk dynamic_node_top.north_input.control.count_f\[3\]
+ _09580_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.count_f\[4\]$_SDFF_PP0_
+ _00667_ clknet_leaf_148_clk dynamic_node_top.north_input.control.count_f\[4\]
+ _09579_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.count_f\[5\]$_SDFF_PP0_
+ _00668_ clknet_leaf_148_clk dynamic_node_top.north_input.control.count_f\[5\]
+ _09578_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.count_f\[6\]$_SDFF_PP0_
+ _00669_ clknet_leaf_148_clk dynamic_node_top.north_input.control.count_f\[6\]
+ _09577_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.count_f\[7\]$_SDFF_PP0_
+ _00670_ clknet_leaf_148_clk dynamic_node_top.north_input.control.count_f\[7\]
+ _09576_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.count_one_f$_SDFF_PP0_
+ _00671_ clknet_leaf_158_clk dynamic_node_top.north_input.control.count_one_f
+ _10153_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.header_temp$_DFF_P_
+ _00001_ clknet_leaf_143_clk dynamic_node_top.north_input.control.header_last_temp
+ _09575_ VDD VSS DFF_X1
Xdynamic_node_top.north_input.control.tail_last_f$_SDFF_PP0_
+ _00672_ clknet_leaf_153_clk dynamic_node_top.north_input.control.tail_last_f
+ _10154_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.control.current_route_f\[0\]$_DFF_P_
+ _00017_ clknet_leaf_158_clk dynamic_node_top.north_output.control.current_route_f\[0\]
+ _00042_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.control.current_route_f\[1\]$_DFF_P_
+ _00018_ clknet_leaf_157_clk dynamic_node_top.north_output.control.current_route_f\[1\]
+ _10155_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.control.current_route_f\[2\]$_DFF_P_
+ _00019_ clknet_leaf_154_clk dynamic_node_top.north_output.control.current_route_f\[2\]
+ _00072_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.control.current_route_f\[3\]$_DFF_P_
+ _00020_ clknet_leaf_157_clk dynamic_node_top.north_output.control.current_route_f\[3\]
+ _00073_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.control.current_route_f\[4\]$_DFF_P_
+ _00021_ clknet_leaf_157_clk dynamic_node_top.north_output.control.current_route_f\[4\]
+ _00071_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.control.planned_f$_SDFF_PP0_
+ _00673_ clknet_leaf_154_clk dynamic_node_top.north_output.control.planned_f
+ _00043_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.space.count_f\[0\]$_SDFF_PP0_
+ _00674_ clknet_leaf_152_clk dynamic_node_top.north_output.space.count_f\[0\]
+ _10541_ VDD VSS DFF_X2
Xdynamic_node_top.north_output.space.count_f\[1\]$_SDFF_PP0_
+ _00675_ clknet_leaf_152_clk dynamic_node_top.north_output.space.count_f\[1\]
+ _10542_ VDD VSS DFF_X2
Xdynamic_node_top.north_output.space.count_f\[2\]$_SDFF_PP1_
+ _00676_ clknet_leaf_155_clk dynamic_node_top.north_output.space.count_f\[2\]
+ _00061_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.space.is_one_f$_SDFF_PP0_ _00677_
+ clknet_leaf_154_clk dynamic_node_top.north_output.space.is_one_f
+ _09574_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.space.is_two_or_more_f$_SDFF_PP1_
+ _00678_ clknet_leaf_154_clk dynamic_node_top.north_output.space.is_two_or_more_f
+ _09573_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.space.valid_f$_SDFF_PP0_ _00679_
+ clknet_leaf_154_clk dynamic_node_top.north_output.space.valid_f
+ _10538_ VDD VSS DFF_X1
Xdynamic_node_top.north_output.space.yummy_f$_SDFF_PP0_ _00680_
+ clknet_leaf_154_clk dynamic_node_top.north_output.space.yummy_f
+ _10535_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.elements_in_array_f\[0\]$_SDFFE_PP0N_
+ _00681_ clknet_leaf_108_clk dynamic_node_top.proc_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.proc_input.NIB.elements_in_array_next\[0\]
+ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.elements_in_array_f\[1\]$_SDFFE_PP0N_
+ _00682_ clknet_leaf_108_clk dynamic_node_top.proc_input.NIB.elements_in_array_f\[1\]
+ _10168_ VDD VSS DFF_X2
Xdynamic_node_top.proc_input.NIB.elements_in_array_f\[2\]$_SDFFE_PP0N_
+ _00683_ clknet_leaf_108_clk dynamic_node_top.proc_input.NIB.elements_in_array_f\[2\]
+ _09572_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.elements_in_array_f\[3\]$_SDFFE_PP0N_
+ _00684_ clknet_leaf_108_clk dynamic_node_top.proc_input.NIB.elements_in_array_f\[3\]
+ _09571_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.elements_in_array_f\[4\]$_SDFFE_PP0N_
+ _00685_ clknet_leaf_109_clk dynamic_node_top.proc_input.NIB.elements_in_array_f\[4\]
+ _09570_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.head_ptr_f\[0\]$_SDFFE_PP0N_
+ _00686_ clknet_leaf_125_clk dynamic_node_top.proc_input.NIB.head_ptr_f\[0\]
+ dynamic_node_top.proc_input.NIB.head_ptr_next\[0\] VDD VSS
+ DFF_X1
Xdynamic_node_top.proc_input.NIB.head_ptr_f\[1\]$_SDFFE_PP0N_
+ _00084_ clknet_leaf_125_clk dynamic_node_top.proc_input.NIB.head_ptr_f\[1\]
+ _09569_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.head_ptr_f\[2\]$_SDFFE_PP0N_
+ _00085_ clknet_leaf_128_clk dynamic_node_top.proc_input.NIB.head_ptr_f\[2\]
+ _09568_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.head_ptr_f\[3\]$_SDFFE_PP0N_
+ _00086_ clknet_leaf_128_clk dynamic_node_top.proc_input.NIB.head_ptr_f\[3\]
+ _09567_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[0\]$_DFFE_PP_
+ _00687_ clknet_leaf_16_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[0\]
+ _09566_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[10\]$_DFFE_PP_
+ _00688_ clknet_leaf_11_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[10\]
+ _09565_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[11\]$_DFFE_PP_
+ _00689_ clknet_leaf_324_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[11\]
+ _09564_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[12\]$_DFFE_PP_
+ _00690_ clknet_leaf_15_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[12\]
+ _09563_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[13\]$_DFFE_PP_
+ _00691_ clknet_leaf_0_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[13\]
+ _09562_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[14\]$_DFFE_PP_
+ _00692_ clknet_leaf_11_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[14\]
+ _09561_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[15\]$_DFFE_PP_
+ _00693_ clknet_leaf_9_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[15\]
+ _09560_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[16\]$_DFFE_PP_
+ _00694_ clknet_leaf_326_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[16\]
+ _09559_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[17\]$_DFFE_PP_
+ _00695_ clknet_leaf_327_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[17\]
+ _09558_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[18\]$_DFFE_PP_
+ _00696_ clknet_leaf_15_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[18\]
+ _09557_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[19\]$_DFFE_PP_
+ _00697_ clknet_leaf_33_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[19\]
+ _09556_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[1\]$_DFFE_PP_
+ _00698_ clknet_leaf_33_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[1\]
+ _09555_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[20\]$_DFFE_PP_
+ _00699_ clknet_leaf_322_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[20\]
+ _09554_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[21\]$_DFFE_PP_
+ _00700_ clknet_leaf_28_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[21\]
+ _09553_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[22\]$_DFFE_PP_
+ _00701_ clknet_leaf_314_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[22\]
+ _09552_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[23\]$_DFFE_PP_
+ _00702_ clknet_leaf_310_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[23\]
+ _09551_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[24\]$_DFFE_PP_
+ _00703_ clknet_leaf_317_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[24\]
+ _09550_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[25\]$_DFFE_PP_
+ _00704_ clknet_leaf_311_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[25\]
+ _09549_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[26\]$_DFFE_PP_
+ _00705_ clknet_leaf_37_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[26\]
+ _09548_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[27\]$_DFFE_PP_
+ _00706_ clknet_leaf_318_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[27\]
+ _09547_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[28\]$_DFFE_PP_
+ _00707_ clknet_leaf_26_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[28\]
+ _09546_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[29\]$_DFFE_PP_
+ _00708_ clknet_leaf_70_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[29\]
+ _09545_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[2\]$_DFFE_PP_
+ _00709_ clknet_leaf_19_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[2\]
+ _09544_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[30\]$_DFFE_PP_
+ _00710_ clknet_leaf_74_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[30\]
+ _09543_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[31\]$_DFFE_PP_
+ _00711_ clknet_leaf_68_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[31\]
+ _09542_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[32\]$_DFFE_PP_
+ _00712_ clknet_leaf_65_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[32\]
+ _09541_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[33\]$_DFFE_PP_
+ _00713_ clknet_leaf_76_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[33\]
+ _09540_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[34\]$_DFFE_PP_
+ _00714_ clknet_leaf_80_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[34\]
+ _09539_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[35\]$_DFFE_PP_
+ _00715_ clknet_leaf_89_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[35\]
+ _09538_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[36\]$_DFFE_PP_
+ _00716_ clknet_leaf_64_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[36\]
+ _09537_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[37\]$_DFFE_PP_
+ _00717_ clknet_leaf_103_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[37\]
+ _09536_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[38\]$_DFFE_PP_
+ _00718_ clknet_leaf_95_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[38\]
+ _09535_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[39\]$_DFFE_PP_
+ _00719_ clknet_leaf_84_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[39\]
+ _09534_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[3\]$_DFFE_PP_
+ _00720_ clknet_leaf_77_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[3\]
+ _09533_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[40\]$_DFFE_PP_
+ _00721_ clknet_leaf_102_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[40\]
+ _09532_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[41\]$_DFFE_PP_
+ _00722_ clknet_leaf_94_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[41\]
+ _09531_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[42\]$_DFFE_PP_
+ _00723_ clknet_leaf_79_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[42\]
+ _09530_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[43\]$_DFFE_PP_
+ _00724_ clknet_leaf_100_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[43\]
+ _09529_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[44\]$_DFFE_PP_
+ _00725_ clknet_leaf_83_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[44\]
+ _09528_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[45\]$_DFFE_PP_
+ _00726_ clknet_leaf_101_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[45\]
+ _09527_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[46\]$_DFFE_PP_
+ _00727_ clknet_leaf_63_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[46\]
+ _09526_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[47\]$_DFFE_PP_
+ _00728_ clknet_leaf_107_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[47\]
+ _09525_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[48\]$_DFFE_PP_
+ _00729_ clknet_leaf_106_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[48\]
+ _09524_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[49\]$_DFFE_PP_
+ _00730_ clknet_leaf_112_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[49\]
+ _09523_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[4\]$_DFFE_PP_
+ _00731_ clknet_leaf_70_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[4\]
+ _09522_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[50\]$_DFFE_PP_
+ _00732_ clknet_leaf_127_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[50\]
+ _09521_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[51\]$_DFFE_PP_
+ _00733_ clknet_leaf_55_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[51\]
+ _09520_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[52\]$_DFFE_PP_
+ _00734_ clknet_leaf_52_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[52\]
+ _09519_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[53\]$_DFFE_PP_
+ _00735_ clknet_leaf_111_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[53\]
+ _09518_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[54\]$_DFFE_PP_
+ _00736_ clknet_leaf_119_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[54\]
+ _09517_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[55\]$_DFFE_PP_
+ _00737_ clknet_leaf_54_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[55\]
+ _09516_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[56\]$_DFFE_PP_
+ _00738_ clknet_leaf_296_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[56\]
+ _09515_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[57\]$_DFFE_PP_
+ _00739_ clknet_leaf_51_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[57\]
+ _09514_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[58\]$_DFFE_PP_
+ _00740_ clknet_leaf_130_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[58\]
+ _09513_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[59\]$_DFFE_PP_
+ _00741_ clknet_leaf_130_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[59\]
+ _09512_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[5\]$_DFFE_PP_
+ _00742_ clknet_leaf_41_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[5\]
+ _09511_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[60\]$_DFFE_PP_
+ _00743_ clknet_leaf_303_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[60\]
+ _09510_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[61\]$_DFFE_PP_
+ _00744_ clknet_leaf_46_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[61\]
+ _09509_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[62\]$_DFFE_PP_
+ _00745_ clknet_leaf_300_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[62\]
+ _09508_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[63\]$_DFFE_PP_
+ _00746_ clknet_leaf_306_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[63\]
+ _09507_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[6\]$_DFFE_PP_
+ _00747_ clknet_leaf_20_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[6\]
+ _09506_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[7\]$_DFFE_PP_
+ _00748_ clknet_leaf_20_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[7\]
+ _09505_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[8\]$_DFFE_PP_
+ _00749_ clknet_leaf_17_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[8\]
+ _09504_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[9\]$_DFFE_PP_
+ _00750_ clknet_leaf_17_clk dynamic_node_top.proc_input.NIB.storage_data_f\[0\]\[9\]
+ _09503_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[0\]$_DFFE_PP_
+ _00751_ clknet_leaf_30_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[0\]
+ _09502_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[10\]$_DFFE_PP_
+ _00752_ clknet_leaf_6_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[10\]
+ _09501_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[11\]$_DFFE_PP_
+ _00753_ clknet_leaf_1_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[11\]
+ _09500_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[12\]$_DFFE_PP_
+ _00754_ clknet_leaf_7_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[12\]
+ _09499_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[13\]$_DFFE_PP_
+ _00755_ clknet_leaf_1_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[13\]
+ _09498_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[14\]$_DFFE_PP_
+ _00756_ clknet_leaf_6_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[14\]
+ _09497_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[15\]$_DFFE_PP_
+ _00757_ clknet_leaf_7_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[15\]
+ _09496_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[16\]$_DFFE_PP_
+ _00758_ clknet_leaf_2_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[16\]
+ _09495_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[17\]$_DFFE_PP_
+ _00759_ clknet_leaf_2_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[17\]
+ _09494_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[18\]$_DFFE_PP_
+ _00760_ clknet_leaf_7_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[18\]
+ _09493_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[19\]$_DFFE_PP_
+ _00761_ clknet_leaf_34_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[19\]
+ _09492_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[1\]$_DFFE_PP_
+ _00762_ clknet_leaf_32_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[1\]
+ _09491_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[20\]$_DFFE_PP_
+ _00763_ clknet_leaf_4_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[20\]
+ _09490_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[21\]$_DFFE_PP_
+ _00764_ clknet_leaf_32_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[21\]
+ _09489_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[22\]$_DFFE_PP_
+ _00765_ clknet_leaf_309_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[22\]
+ _09488_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[23\]$_DFFE_PP_
+ _00766_ clknet_leaf_310_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[23\]
+ _09487_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[24\]$_DFFE_PP_
+ _00767_ clknet_leaf_316_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[24\]
+ _09486_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[25\]$_DFFE_PP_
+ _00768_ clknet_leaf_311_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[25\]
+ _09485_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[26\]$_DFFE_PP_
+ _00769_ clknet_leaf_312_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[26\]
+ _09484_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[27\]$_DFFE_PP_
+ _00770_ clknet_leaf_320_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[27\]
+ _09483_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[28\]$_DFFE_PP_
+ _00771_ clknet_leaf_42_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[28\]
+ _09482_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[29\]$_DFFE_PP_
+ _00772_ clknet_leaf_56_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[29\]
+ _09481_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[2\]$_DFFE_PP_
+ _00773_ clknet_leaf_21_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[2\]
+ _09480_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[30\]$_DFFE_PP_
+ _00774_ clknet_leaf_88_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[30\]
+ _09479_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[31\]$_DFFE_PP_
+ _00775_ clknet_leaf_65_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[31\]
+ _09478_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[32\]$_DFFE_PP_
+ _00776_ clknet_leaf_65_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[32\]
+ _09477_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[33\]$_DFFE_PP_
+ _00777_ clknet_leaf_75_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[33\]
+ _09476_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[34\]$_DFFE_PP_
+ _00778_ clknet_leaf_88_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[34\]
+ _09475_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[35\]$_DFFE_PP_
+ _00779_ clknet_leaf_89_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[35\]
+ _09474_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[36\]$_DFFE_PP_
+ _00780_ clknet_leaf_61_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[36\]
+ _09473_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[37\]$_DFFE_PP_
+ _00781_ clknet_leaf_94_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[37\]
+ _09472_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[38\]$_DFFE_PP_
+ _00782_ clknet_leaf_96_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[38\]
+ _09471_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[39\]$_DFFE_PP_
+ _00783_ clknet_leaf_86_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[39\]
+ _09470_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[3\]$_DFFE_PP_
+ _00784_ clknet_leaf_75_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[3\]
+ _09469_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[40\]$_DFFE_PP_
+ _00785_ clknet_leaf_96_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[40\]
+ _09468_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[41\]$_DFFE_PP_
+ _00786_ clknet_leaf_94_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[41\]
+ _09467_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[42\]$_DFFE_PP_
+ _00787_ clknet_leaf_79_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[42\]
+ _09466_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[43\]$_DFFE_PP_
+ _00788_ clknet_leaf_98_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[43\]
+ _09465_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[44\]$_DFFE_PP_
+ _00789_ clknet_leaf_81_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[44\]
+ _09464_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[45\]$_DFFE_PP_
+ _00790_ clknet_leaf_100_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[45\]
+ _09463_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[46\]$_DFFE_PP_
+ _00791_ clknet_leaf_62_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[46\]
+ _09462_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[47\]$_DFFE_PP_
+ _00792_ clknet_leaf_115_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[47\]
+ _09461_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[48\]$_DFFE_PP_
+ _00793_ clknet_leaf_115_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[48\]
+ _09460_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[49\]$_DFFE_PP_
+ _00794_ clknet_leaf_113_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[49\]
+ _09459_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[4\]$_DFFE_PP_
+ _00795_ clknet_leaf_56_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[4\]
+ _09458_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[50\]$_DFFE_PP_
+ _00796_ clknet_leaf_127_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[50\]
+ _09457_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[51\]$_DFFE_PP_
+ _00797_ clknet_leaf_53_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[51\]
+ _09456_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[52\]$_DFFE_PP_
+ _00798_ clknet_leaf_52_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[52\]
+ _09455_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[53\]$_DFFE_PP_
+ _00799_ clknet_leaf_111_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[53\]
+ _09454_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[54\]$_DFFE_PP_
+ _00800_ clknet_leaf_119_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[54\]
+ _09453_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[55\]$_DFFE_PP_
+ _00801_ clknet_leaf_51_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[55\]
+ _09452_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[56\]$_DFFE_PP_
+ _00802_ clknet_leaf_296_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[56\]
+ _09451_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[57\]$_DFFE_PP_
+ _00803_ clknet_leaf_51_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[57\]
+ _09450_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[58\]$_DFFE_PP_
+ _00804_ clknet_leaf_130_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[58\]
+ _09449_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[59\]$_DFFE_PP_
+ _00805_ clknet_leaf_130_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[59\]
+ _09448_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[5\]$_DFFE_PP_
+ _00806_ clknet_leaf_40_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[5\]
+ _09447_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[60\]$_DFFE_PP_
+ _00807_ clknet_leaf_307_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[60\]
+ _09446_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[61\]$_DFFE_PP_
+ _00808_ clknet_leaf_45_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[61\]
+ _09445_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[62\]$_DFFE_PP_
+ _00809_ clknet_leaf_303_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[62\]
+ _09444_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[63\]$_DFFE_PP_
+ _00810_ clknet_leaf_306_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[63\]
+ _09443_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[6\]$_DFFE_PP_
+ _00811_ clknet_leaf_24_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[6\]
+ _09442_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[7\]$_DFFE_PP_
+ _00812_ clknet_leaf_25_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[7\]
+ _09441_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[8\]$_DFFE_PP_
+ _00813_ clknet_leaf_30_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[8\]
+ _09440_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[9\]$_DFFE_PP_
+ _00814_ clknet_leaf_23_clk dynamic_node_top.proc_input.NIB.storage_data_f\[10\]\[9\]
+ _09439_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[0\]$_DFFE_PP_
+ _00815_ clknet_leaf_8_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[0\]
+ _09438_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[10\]$_DFFE_PP_
+ _00816_ clknet_leaf_10_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[10\]
+ _09437_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[11\]$_DFFE_PP_
+ _00817_ clknet_leaf_1_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[11\]
+ _09436_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[12\]$_DFFE_PP_
+ _00818_ clknet_leaf_8_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[12\]
+ _09435_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[13\]$_DFFE_PP_
+ _00819_ clknet_leaf_1_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[13\]
+ _09434_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[14\]$_DFFE_PP_
+ _00820_ clknet_leaf_10_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[14\]
+ _09433_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[15\]$_DFFE_PP_
+ _00821_ clknet_leaf_9_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[15\]
+ _09432_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[16\]$_DFFE_PP_
+ _00822_ clknet_leaf_2_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[16\]
+ _09431_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[17\]$_DFFE_PP_
+ _00823_ clknet_leaf_6_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[17\]
+ _09430_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[18\]$_DFFE_PP_
+ _00824_ clknet_leaf_8_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[18\]
+ _09429_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[19\]$_DFFE_PP_
+ _00825_ clknet_leaf_34_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[19\]
+ _09428_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[1\]$_DFFE_PP_
+ _00826_ clknet_leaf_35_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[1\]
+ _09427_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[20\]$_DFFE_PP_
+ _00827_ clknet_leaf_322_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[20\]
+ _09426_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[21\]$_DFFE_PP_
+ _00828_ clknet_leaf_32_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[21\]
+ _09425_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[22\]$_DFFE_PP_
+ _00829_ clknet_leaf_309_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[22\]
+ _09424_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[23\]$_DFFE_PP_
+ _00830_ clknet_leaf_320_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[23\]
+ _09423_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[24\]$_DFFE_PP_
+ _00831_ clknet_leaf_315_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[24\]
+ _09422_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[25\]$_DFFE_PP_
+ _00832_ clknet_leaf_311_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[25\]
+ _09421_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[26\]$_DFFE_PP_
+ _00833_ clknet_leaf_38_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[26\]
+ _09420_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[27\]$_DFFE_PP_
+ _00834_ clknet_leaf_320_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[27\]
+ _09419_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[28\]$_DFFE_PP_
+ _00835_ clknet_leaf_42_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[28\]
+ _09418_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[29\]$_DFFE_PP_
+ _00836_ clknet_leaf_55_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[29\]
+ _09417_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[2\]$_DFFE_PP_
+ _00837_ clknet_leaf_76_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[2\]
+ _09416_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[30\]$_DFFE_PP_
+ _00838_ clknet_leaf_73_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[30\]
+ _09415_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[31\]$_DFFE_PP_
+ _00839_ clknet_leaf_66_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[31\]
+ _09414_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[32\]$_DFFE_PP_
+ _00840_ clknet_leaf_64_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[32\]
+ _09413_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[33\]$_DFFE_PP_
+ _00841_ clknet_leaf_75_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[33\]
+ _09412_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[34\]$_DFFE_PP_
+ _00842_ clknet_leaf_88_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[34\]
+ _09411_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[35\]$_DFFE_PP_
+ _00843_ clknet_leaf_89_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[35\]
+ _09410_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[36\]$_DFFE_PP_
+ _00844_ clknet_leaf_63_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[36\]
+ _09409_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[37\]$_DFFE_PP_
+ _00845_ clknet_leaf_94_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[37\]
+ _09408_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[38\]$_DFFE_PP_
+ _00846_ clknet_leaf_95_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[38\]
+ _09407_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[39\]$_DFFE_PP_
+ _00847_ clknet_leaf_85_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[39\]
+ _09406_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[3\]$_DFFE_PP_
+ _00848_ clknet_leaf_74_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[3\]
+ _09405_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[40\]$_DFFE_PP_
+ _00849_ clknet_leaf_96_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[40\]
+ _09404_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[41\]$_DFFE_PP_
+ _00850_ clknet_leaf_93_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[41\]
+ _09403_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[42\]$_DFFE_PP_
+ _00851_ clknet_leaf_82_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[42\]
+ _09402_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[43\]$_DFFE_PP_
+ _00852_ clknet_leaf_99_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[43\]
+ _09401_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[44\]$_DFFE_PP_
+ _00853_ clknet_leaf_85_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[44\]
+ _09400_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[45\]$_DFFE_PP_
+ _00854_ clknet_leaf_101_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[45\]
+ _09399_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[46\]$_DFFE_PP_
+ _00855_ clknet_leaf_115_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[46\]
+ _09398_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[47\]$_DFFE_PP_
+ _00856_ clknet_leaf_106_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[47\]
+ _09397_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[48\]$_DFFE_PP_
+ _00857_ clknet_leaf_106_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[48\]
+ _09396_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[49\]$_DFFE_PP_
+ _00858_ clknet_leaf_113_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[49\]
+ _09395_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[4\]$_DFFE_PP_
+ _00859_ clknet_leaf_57_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[4\]
+ _09394_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[50\]$_DFFE_PP_
+ _00860_ clknet_leaf_52_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[50\]
+ _09393_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[51\]$_DFFE_PP_
+ _00861_ clknet_leaf_58_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[51\]
+ _09392_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[52\]$_DFFE_PP_
+ _00862_ clknet_leaf_52_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[52\]
+ _09391_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[53\]$_DFFE_PP_
+ _00863_ clknet_leaf_121_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[53\]
+ _09390_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[54\]$_DFFE_PP_
+ _00864_ clknet_leaf_120_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[54\]
+ _09389_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[55\]$_DFFE_PP_
+ _00865_ clknet_leaf_44_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[55\]
+ _09388_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[56\]$_DFFE_PP_
+ _00866_ clknet_leaf_304_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[56\]
+ _09387_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[57\]$_DFFE_PP_
+ _00867_ clknet_leaf_53_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[57\]
+ _09386_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[58\]$_DFFE_PP_
+ _00868_ clknet_leaf_130_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[58\]
+ _09385_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[59\]$_DFFE_PP_
+ _00869_ clknet_leaf_51_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[59\]
+ _09384_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[5\]$_DFFE_PP_
+ _00870_ clknet_leaf_40_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[5\]
+ _09383_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[60\]$_DFFE_PP_
+ _00871_ clknet_leaf_307_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[60\]
+ _09382_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[61\]$_DFFE_PP_
+ _00872_ clknet_leaf_39_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[61\]
+ _09381_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[62\]$_DFFE_PP_
+ _00873_ clknet_leaf_302_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[62\]
+ _09380_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[63\]$_DFFE_PP_
+ _00874_ clknet_leaf_305_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[63\]
+ _09379_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[6\]$_DFFE_PP_
+ _00875_ clknet_leaf_24_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[6\]
+ _09378_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[7\]$_DFFE_PP_
+ _00876_ clknet_leaf_25_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[7\]
+ _09377_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[8\]$_DFFE_PP_
+ _00877_ clknet_leaf_23_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[8\]
+ _09376_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[9\]$_DFFE_PP_
+ _00878_ clknet_leaf_24_clk dynamic_node_top.proc_input.NIB.storage_data_f\[11\]\[9\]
+ _09375_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[0\]$_DFFE_PP_
+ _00879_ clknet_leaf_30_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[0\]
+ _09374_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[10\]$_DFFE_PP_
+ _00880_ clknet_leaf_5_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[10\]
+ _09373_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[11\]$_DFFE_PP_
+ _00881_ clknet_leaf_323_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[11\]
+ _09372_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[12\]$_DFFE_PP_
+ _00882_ clknet_leaf_31_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[12\]
+ _09371_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[13\]$_DFFE_PP_
+ _00883_ clknet_leaf_323_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[13\]
+ _09370_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[14\]$_DFFE_PP_
+ _00884_ clknet_leaf_5_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[14\]
+ _09369_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[15\]$_DFFE_PP_
+ _00885_ clknet_leaf_33_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[15\]
+ _09368_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[16\]$_DFFE_PP_
+ _00886_ clknet_leaf_3_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[16\]
+ _09367_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[17\]$_DFFE_PP_
+ _00887_ clknet_leaf_2_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[17\]
+ _09366_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[18\]$_DFFE_PP_
+ _00888_ clknet_leaf_7_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[18\]
+ _09365_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[19\]$_DFFE_PP_
+ _00889_ clknet_leaf_315_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[19\]
+ _09364_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[1\]$_DFFE_PP_
+ _00890_ clknet_leaf_35_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[1\]
+ _09363_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[20\]$_DFFE_PP_
+ _00891_ clknet_leaf_316_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[20\]
+ _09362_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[21\]$_DFFE_PP_
+ _00892_ clknet_leaf_36_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[21\]
+ _09361_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[22\]$_DFFE_PP_
+ _00893_ clknet_leaf_309_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[22\]
+ _09360_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[23\]$_DFFE_PP_
+ _00894_ clknet_leaf_309_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[23\]
+ _09359_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[24\]$_DFFE_PP_
+ _00895_ clknet_leaf_316_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[24\]
+ _09358_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[25\]$_DFFE_PP_
+ _00896_ clknet_leaf_307_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[25\]
+ _09357_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[26\]$_DFFE_PP_
+ _00897_ clknet_leaf_313_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[26\]
+ _09356_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[27\]$_DFFE_PP_
+ _00898_ clknet_leaf_318_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[27\]
+ _09355_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[28\]$_DFFE_PP_
+ _00899_ clknet_leaf_42_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[28\]
+ _09354_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[29\]$_DFFE_PP_
+ _00900_ clknet_leaf_56_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[29\]
+ _09353_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[2\]$_DFFE_PP_
+ _00901_ clknet_leaf_25_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[2\]
+ _09352_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[30\]$_DFFE_PP_
+ _00902_ clknet_leaf_67_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[30\]
+ _09351_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[31\]$_DFFE_PP_
+ _00903_ clknet_leaf_65_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[31\]
+ _09350_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[32\]$_DFFE_PP_
+ _00904_ clknet_leaf_61_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[32\]
+ _09349_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[33\]$_DFFE_PP_
+ _00905_ clknet_leaf_72_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[33\]
+ _09348_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[34\]$_DFFE_PP_
+ _00906_ clknet_leaf_88_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[34\]
+ _09347_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[35\]$_DFFE_PP_
+ _00907_ clknet_leaf_90_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[35\]
+ _09346_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[36\]$_DFFE_PP_
+ _00908_ clknet_leaf_62_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[36\]
+ _09345_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[37\]$_DFFE_PP_
+ _00909_ clknet_leaf_90_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[37\]
+ _09344_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[38\]$_DFFE_PP_
+ _00910_ clknet_leaf_97_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[38\]
+ _09343_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[39\]$_DFFE_PP_
+ _00911_ clknet_leaf_86_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[39\]
+ _09342_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[3\]$_DFFE_PP_
+ _00912_ clknet_leaf_73_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[3\]
+ _09341_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[40\]$_DFFE_PP_
+ _00913_ clknet_leaf_98_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[40\]
+ _09340_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[41\]$_DFFE_PP_
+ _00914_ clknet_leaf_93_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[41\]
+ _09339_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[42\]$_DFFE_PP_
+ _00915_ clknet_leaf_80_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[42\]
+ _09338_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[43\]$_DFFE_PP_
+ _00916_ clknet_leaf_98_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[43\]
+ _09337_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[44\]$_DFFE_PP_
+ _00917_ clknet_leaf_87_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[44\]
+ _09336_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[45\]$_DFFE_PP_
+ _00918_ clknet_leaf_97_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[45\]
+ _09335_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[46\]$_DFFE_PP_
+ _00919_ clknet_leaf_116_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[46\]
+ _09334_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[47\]$_DFFE_PP_
+ _00920_ clknet_leaf_114_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[47\]
+ _09333_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[48\]$_DFFE_PP_
+ _00921_ clknet_leaf_115_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[48\]
+ _09332_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[49\]$_DFFE_PP_
+ _00922_ clknet_leaf_111_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[49\]
+ _09331_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[4\]$_DFFE_PP_
+ _00923_ clknet_leaf_57_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[4\]
+ _09330_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[50\]$_DFFE_PP_
+ _00924_ clknet_leaf_127_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[50\]
+ _09329_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[51\]$_DFFE_PP_
+ _00925_ clknet_leaf_60_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[51\]
+ _09328_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[52\]$_DFFE_PP_
+ _00926_ clknet_leaf_126_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[52\]
+ _09327_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[53\]$_DFFE_PP_
+ _00927_ clknet_leaf_121_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[53\]
+ _09326_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[54\]$_DFFE_PP_
+ _00928_ clknet_leaf_126_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[54\]
+ _09325_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[55\]$_DFFE_PP_
+ _00929_ clknet_leaf_44_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[55\]
+ _09324_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[56\]$_DFFE_PP_
+ _00930_ clknet_leaf_308_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[56\]
+ _09323_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[57\]$_DFFE_PP_
+ _00931_ clknet_leaf_43_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[57\]
+ _09322_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[58\]$_DFFE_PP_
+ _00932_ clknet_leaf_302_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[58\]
+ _09321_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[59\]$_DFFE_PP_
+ _00933_ clknet_leaf_49_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[59\]
+ _09320_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[5\]$_DFFE_PP_
+ _00934_ clknet_leaf_39_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[5\]
+ _09319_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[60\]$_DFFE_PP_
+ _00935_ clknet_leaf_307_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[60\]
+ _09318_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[61\]$_DFFE_PP_
+ _00936_ clknet_leaf_45_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[61\]
+ _09317_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[62\]$_DFFE_PP_
+ _00937_ clknet_leaf_301_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[62\]
+ _09316_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[63\]$_DFFE_PP_
+ _00938_ clknet_leaf_306_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[63\]
+ _09315_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[6\]$_DFFE_PP_
+ _00939_ clknet_leaf_24_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[6\]
+ _09314_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[7\]$_DFFE_PP_
+ _00940_ clknet_leaf_26_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[7\]
+ _09313_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[8\]$_DFFE_PP_
+ _00941_ clknet_leaf_29_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[8\]
+ _09312_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[9\]$_DFFE_PP_
+ _00942_ clknet_leaf_29_clk dynamic_node_top.proc_input.NIB.storage_data_f\[12\]\[9\]
+ _09311_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[0\]$_DFFE_PP_
+ _00943_ clknet_leaf_29_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[0\]
+ _09310_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[10\]$_DFFE_PP_
+ _00944_ clknet_leaf_4_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[10\]
+ _09309_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[11\]$_DFFE_PP_
+ _00945_ clknet_leaf_323_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[11\]
+ _09308_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[12\]$_DFFE_PP_
+ _00946_ clknet_leaf_31_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[12\]
+ _09307_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[13\]$_DFFE_PP_
+ _00947_ clknet_leaf_3_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[13\]
+ _09306_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[14\]$_DFFE_PP_
+ _00948_ clknet_leaf_5_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[14\]
+ _09305_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[15\]$_DFFE_PP_
+ _00949_ clknet_leaf_33_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[15\]
+ _09304_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[16\]$_DFFE_PP_
+ _00950_ clknet_leaf_3_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[16\]
+ _09303_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[17\]$_DFFE_PP_
+ _00951_ clknet_leaf_5_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[17\]
+ _09302_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[18\]$_DFFE_PP_
+ _00952_ clknet_leaf_7_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[18\]
+ _09301_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[19\]$_DFFE_PP_
+ _00953_ clknet_leaf_315_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[19\]
+ _09300_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[1\]$_DFFE_PP_
+ _00954_ clknet_leaf_37_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[1\]
+ _09299_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[20\]$_DFFE_PP_
+ _00955_ clknet_leaf_316_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[20\]
+ _09298_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[21\]$_DFFE_PP_
+ _00956_ clknet_leaf_36_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[21\]
+ _09297_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[22\]$_DFFE_PP_
+ _00957_ clknet_leaf_311_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[22\]
+ _09296_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[23\]$_DFFE_PP_
+ _00958_ clknet_leaf_310_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[23\]
+ _09295_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[24\]$_DFFE_PP_
+ _00959_ clknet_leaf_317_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[24\]
+ _09294_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[25\]$_DFFE_PP_
+ _00960_ clknet_leaf_312_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[25\]
+ _09293_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[26\]$_DFFE_PP_
+ _00961_ clknet_leaf_38_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[26\]
+ _09292_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[27\]$_DFFE_PP_
+ _00962_ clknet_leaf_318_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[27\]
+ _09291_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[28\]$_DFFE_PP_
+ _00963_ clknet_leaf_27_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[28\]
+ _09290_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[29\]$_DFFE_PP_
+ _00964_ clknet_leaf_42_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[29\]
+ _09289_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[2\]$_DFFE_PP_
+ _00965_ clknet_leaf_25_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[2\]
+ _09288_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[30\]$_DFFE_PP_
+ _00966_ clknet_leaf_67_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[30\]
+ _09287_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[31\]$_DFFE_PP_
+ _00967_ clknet_leaf_61_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[31\]
+ _09286_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[32\]$_DFFE_PP_
+ _00968_ clknet_leaf_61_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[32\]
+ _09285_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[33\]$_DFFE_PP_
+ _00969_ clknet_leaf_72_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[33\]
+ _09284_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[34\]$_DFFE_PP_
+ _00970_ clknet_leaf_66_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[34\]
+ _09283_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[35\]$_DFFE_PP_
+ _00971_ clknet_leaf_89_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[35\]
+ _09282_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[36\]$_DFFE_PP_
+ _00972_ clknet_leaf_62_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[36\]
+ _09281_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[37\]$_DFFE_PP_
+ _00973_ clknet_leaf_91_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[37\]
+ _09280_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[38\]$_DFFE_PP_
+ _00974_ clknet_leaf_97_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[38\]
+ _09279_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[39\]$_DFFE_PP_
+ _00975_ clknet_leaf_90_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[39\]
+ _09278_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[3\]$_DFFE_PP_
+ _00976_ clknet_leaf_73_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[3\]
+ _09277_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[40\]$_DFFE_PP_
+ _00977_ clknet_leaf_96_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[40\]
+ _09276_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[41\]$_DFFE_PP_
+ _00978_ clknet_leaf_92_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[41\]
+ _09275_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[42\]$_DFFE_PP_
+ _00979_ clknet_leaf_81_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[42\]
+ _09274_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[43\]$_DFFE_PP_
+ _00980_ clknet_leaf_98_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[43\]
+ _09273_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[44\]$_DFFE_PP_
+ _00981_ clknet_leaf_86_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[44\]
+ _09272_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[45\]$_DFFE_PP_
+ _00982_ clknet_leaf_90_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[45\]
+ _09271_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[46\]$_DFFE_PP_
+ _00983_ clknet_leaf_116_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[46\]
+ _09270_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[47\]$_DFFE_PP_
+ _00984_ clknet_leaf_114_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[47\]
+ _09269_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[48\]$_DFFE_PP_
+ _00985_ clknet_leaf_115_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[48\]
+ _09268_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[49\]$_DFFE_PP_
+ _00986_ clknet_leaf_113_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[49\]
+ _09267_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[4\]$_DFFE_PP_
+ _00987_ clknet_leaf_56_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[4\]
+ _09266_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[50\]$_DFFE_PP_
+ _00988_ clknet_leaf_127_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[50\]
+ _09265_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[51\]$_DFFE_PP_
+ _00989_ clknet_leaf_58_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[51\]
+ _09264_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[52\]$_DFFE_PP_
+ _00990_ clknet_leaf_126_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[52\]
+ _09263_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[53\]$_DFFE_PP_
+ _00991_ clknet_leaf_117_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[53\]
+ _09262_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[54\]$_DFFE_PP_
+ _00992_ clknet_leaf_120_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[54\]
+ _09261_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[55\]$_DFFE_PP_
+ _00993_ clknet_leaf_47_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[55\]
+ _09260_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[56\]$_DFFE_PP_
+ _00994_ clknet_leaf_300_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[56\]
+ _09259_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[57\]$_DFFE_PP_
+ _00995_ clknet_leaf_43_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[57\]
+ _09258_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[58\]$_DFFE_PP_
+ _00996_ clknet_leaf_201_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[58\]
+ _09257_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[59\]$_DFFE_PP_
+ _00997_ clknet_leaf_49_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[59\]
+ _09256_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[5\]$_DFFE_PP_
+ _00998_ clknet_leaf_39_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[5\]
+ _09255_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[60\]$_DFFE_PP_
+ _00999_ clknet_leaf_304_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[60\]
+ _09254_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[61\]$_DFFE_PP_
+ _01000_ clknet_leaf_45_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[61\]
+ _09253_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[62\]$_DFFE_PP_
+ _01001_ clknet_leaf_301_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[62\]
+ _09252_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[63\]$_DFFE_PP_
+ _01002_ clknet_leaf_305_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[63\]
+ _09251_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[6\]$_DFFE_PP_
+ _01003_ clknet_leaf_26_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[6\]
+ _09250_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[7\]$_DFFE_PP_
+ _01004_ clknet_leaf_25_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[7\]
+ _09249_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[8\]$_DFFE_PP_
+ _01005_ clknet_leaf_29_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[8\]
+ _09248_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[9\]$_DFFE_PP_
+ _01006_ clknet_leaf_28_clk dynamic_node_top.proc_input.NIB.storage_data_f\[13\]\[9\]
+ _09247_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[0\]$_DFFE_PP_
+ _01007_ clknet_leaf_30_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[0\]
+ _09246_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[10\]$_DFFE_PP_
+ _01008_ clknet_leaf_4_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[10\]
+ _09245_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[11\]$_DFFE_PP_
+ _01009_ clknet_leaf_323_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[11\]
+ _09244_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[12\]$_DFFE_PP_
+ _01010_ clknet_leaf_31_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[12\]
+ _09243_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[13\]$_DFFE_PP_
+ _01011_ clknet_leaf_323_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[13\]
+ _09242_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[14\]$_DFFE_PP_
+ _01012_ clknet_leaf_5_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[14\]
+ _09241_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[15\]$_DFFE_PP_
+ _01013_ clknet_leaf_33_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[15\]
+ _09240_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[16\]$_DFFE_PP_
+ _01014_ clknet_leaf_3_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[16\]
+ _09239_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[17\]$_DFFE_PP_
+ _01015_ clknet_leaf_2_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[17\]
+ _09238_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[18\]$_DFFE_PP_
+ _01016_ clknet_leaf_31_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[18\]
+ _09237_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[19\]$_DFFE_PP_
+ _01017_ clknet_leaf_315_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[19\]
+ _09236_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[1\]$_DFFE_PP_
+ _01018_ clknet_leaf_36_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[1\]
+ _09235_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[20\]$_DFFE_PP_
+ _01019_ clknet_leaf_322_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[20\]
+ _09234_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[21\]$_DFFE_PP_
+ _01020_ clknet_leaf_36_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[21\]
+ _09233_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[22\]$_DFFE_PP_
+ _01021_ clknet_leaf_309_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[22\]
+ _09232_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[23\]$_DFFE_PP_
+ _01022_ clknet_leaf_310_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[23\]
+ _09231_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[24\]$_DFFE_PP_
+ _01023_ clknet_leaf_315_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[24\]
+ _09230_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[25\]$_DFFE_PP_
+ _01024_ clknet_leaf_311_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[25\]
+ _09229_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[26\]$_DFFE_PP_
+ _01025_ clknet_leaf_313_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[26\]
+ _09228_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[27\]$_DFFE_PP_
+ _01026_ clknet_leaf_320_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[27\]
+ _09227_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[28\]$_DFFE_PP_
+ _01027_ clknet_leaf_42_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[28\]
+ _09226_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[29\]$_DFFE_PP_
+ _01028_ clknet_leaf_55_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[29\]
+ _09225_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[2\]$_DFFE_PP_
+ _01029_ clknet_leaf_25_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[2\]
+ _09224_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[30\]$_DFFE_PP_
+ _01030_ clknet_leaf_67_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[30\]
+ _09223_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[31\]$_DFFE_PP_
+ _01031_ clknet_leaf_65_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[31\]
+ _09222_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[32\]$_DFFE_PP_
+ _01032_ clknet_leaf_62_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[32\]
+ _09221_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[33\]$_DFFE_PP_
+ _01033_ clknet_leaf_72_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[33\]
+ _09220_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[34\]$_DFFE_PP_
+ _01034_ clknet_leaf_67_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[34\]
+ _09219_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[35\]$_DFFE_PP_
+ _01035_ clknet_leaf_91_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[35\]
+ _09218_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[36\]$_DFFE_PP_
+ _01036_ clknet_leaf_62_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[36\]
+ _09217_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[37\]$_DFFE_PP_
+ _01037_ clknet_leaf_90_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[37\]
+ _09216_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[38\]$_DFFE_PP_
+ _01038_ clknet_leaf_94_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[38\]
+ _09215_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[39\]$_DFFE_PP_
+ _01039_ clknet_leaf_86_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[39\]
+ _09214_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[3\]$_DFFE_PP_
+ _01040_ clknet_leaf_73_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[3\]
+ _09213_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[40\]$_DFFE_PP_
+ _01041_ clknet_leaf_97_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[40\]
+ _09212_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[41\]$_DFFE_PP_
+ _01042_ clknet_leaf_93_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[41\]
+ _09211_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[42\]$_DFFE_PP_
+ _01043_ clknet_leaf_80_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[42\]
+ _09210_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[43\]$_DFFE_PP_
+ _01044_ clknet_leaf_98_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[43\]
+ _09209_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[44\]$_DFFE_PP_
+ _01045_ clknet_leaf_87_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[44\]
+ _09208_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[45\]$_DFFE_PP_
+ _01046_ clknet_leaf_97_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[45\]
+ _09207_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[46\]$_DFFE_PP_
+ _01047_ clknet_leaf_116_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[46\]
+ _09206_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[47\]$_DFFE_PP_
+ _01048_ clknet_leaf_114_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[47\]
+ _09205_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[48\]$_DFFE_PP_
+ _01049_ clknet_leaf_113_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[48\]
+ _09204_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[49\]$_DFFE_PP_
+ _01050_ clknet_leaf_113_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[49\]
+ _09203_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[4\]$_DFFE_PP_
+ _01051_ clknet_leaf_57_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[4\]
+ _09202_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[50\]$_DFFE_PP_
+ _01052_ clknet_leaf_127_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[50\]
+ _09201_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[51\]$_DFFE_PP_
+ _01053_ clknet_leaf_58_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[51\]
+ _09200_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[52\]$_DFFE_PP_
+ _01054_ clknet_leaf_126_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[52\]
+ _09199_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[53\]$_DFFE_PP_
+ _01055_ clknet_leaf_121_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[53\]
+ _09198_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[54\]$_DFFE_PP_
+ _01056_ clknet_leaf_126_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[54\]
+ _09197_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[55\]$_DFFE_PP_
+ _01057_ clknet_leaf_44_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[55\]
+ _09196_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[56\]$_DFFE_PP_
+ _01058_ clknet_leaf_308_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[56\]
+ _09195_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[57\]$_DFFE_PP_
+ _01059_ clknet_leaf_42_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[57\]
+ _09194_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[58\]$_DFFE_PP_
+ _01060_ clknet_leaf_50_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[58\]
+ _09193_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[59\]$_DFFE_PP_
+ _01061_ clknet_leaf_49_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[59\]
+ _09192_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[5\]$_DFFE_PP_
+ _01062_ clknet_leaf_39_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[5\]
+ _09191_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[60\]$_DFFE_PP_
+ _01063_ clknet_leaf_307_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[60\]
+ _09190_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[61\]$_DFFE_PP_
+ _01064_ clknet_leaf_45_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[61\]
+ _09189_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[62\]$_DFFE_PP_
+ _01065_ clknet_leaf_302_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[62\]
+ _09188_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[63\]$_DFFE_PP_
+ _01066_ clknet_leaf_307_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[63\]
+ _09187_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[6\]$_DFFE_PP_
+ _01067_ clknet_leaf_24_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[6\]
+ _09186_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[7\]$_DFFE_PP_
+ _01068_ clknet_leaf_26_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[7\]
+ _09185_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[8\]$_DFFE_PP_
+ _01069_ clknet_leaf_29_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[8\]
+ _09184_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[9\]$_DFFE_PP_
+ _01070_ clknet_leaf_28_clk dynamic_node_top.proc_input.NIB.storage_data_f\[14\]\[9\]
+ _09183_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[0\]$_DFFE_PP_
+ _01071_ clknet_leaf_30_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[0\]
+ _09182_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[10\]$_DFFE_PP_
+ _01072_ clknet_leaf_4_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[10\]
+ _09181_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[11\]$_DFFE_PP_
+ _01073_ clknet_leaf_323_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[11\]
+ _09180_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[12\]$_DFFE_PP_
+ _01074_ clknet_leaf_31_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[12\]
+ _09179_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[13\]$_DFFE_PP_
+ _01075_ clknet_leaf_3_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[13\]
+ _09178_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[14\]$_DFFE_PP_
+ _01076_ clknet_leaf_5_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[14\]
+ _09177_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[15\]$_DFFE_PP_
+ _01077_ clknet_leaf_5_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[15\]
+ _09176_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[16\]$_DFFE_PP_
+ _01078_ clknet_leaf_3_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[16\]
+ _09175_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[17\]$_DFFE_PP_
+ _01079_ clknet_leaf_6_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[17\]
+ _09174_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[18\]$_DFFE_PP_
+ _01080_ clknet_leaf_31_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[18\]
+ _09173_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[19\]$_DFFE_PP_
+ _01081_ clknet_leaf_35_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[19\]
+ _09172_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[1\]$_DFFE_PP_
+ _01082_ clknet_leaf_35_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[1\]
+ _09171_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[20\]$_DFFE_PP_
+ _01083_ clknet_leaf_316_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[20\]
+ _09170_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[21\]$_DFFE_PP_
+ _01084_ clknet_leaf_40_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[21\]
+ _09169_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[22\]$_DFFE_PP_
+ _01085_ clknet_leaf_309_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[22\]
+ _09168_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[23\]$_DFFE_PP_
+ _01086_ clknet_leaf_320_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[23\]
+ _09167_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[24\]$_DFFE_PP_
+ _01087_ clknet_leaf_314_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[24\]
+ _09166_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[25\]$_DFFE_PP_
+ _01088_ clknet_leaf_312_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[25\]
+ _09165_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[26\]$_DFFE_PP_
+ _01089_ clknet_leaf_38_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[26\]
+ _09164_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[27\]$_DFFE_PP_
+ _01090_ clknet_leaf_320_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[27\]
+ _09163_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[28\]$_DFFE_PP_
+ _01091_ clknet_leaf_55_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[28\]
+ _09162_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[29\]$_DFFE_PP_
+ _01092_ clknet_leaf_55_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[29\]
+ _09161_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[2\]$_DFFE_PP_
+ _01093_ clknet_leaf_72_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[2\]
+ _09160_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[30\]$_DFFE_PP_
+ _01094_ clknet_leaf_67_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[30\]
+ _09159_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[31\]$_DFFE_PP_
+ _01095_ clknet_leaf_61_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[31\]
+ _09158_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[32\]$_DFFE_PP_
+ _01096_ clknet_leaf_60_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[32\]
+ _09157_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[33\]$_DFFE_PP_
+ _01097_ clknet_leaf_72_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[33\]
+ _09156_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[34\]$_DFFE_PP_
+ _01098_ clknet_leaf_88_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[34\]
+ _09155_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[35\]$_DFFE_PP_
+ _01099_ clknet_leaf_89_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[35\]
+ _09154_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[36\]$_DFFE_PP_
+ _01100_ clknet_leaf_62_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[36\]
+ _09153_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[37\]$_DFFE_PP_
+ _01101_ clknet_leaf_91_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[37\]
+ _09152_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[38\]$_DFFE_PP_
+ _01102_ clknet_leaf_97_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[38\]
+ _09151_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[39\]$_DFFE_PP_
+ _01103_ clknet_leaf_90_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[39\]
+ _09150_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[3\]$_DFFE_PP_
+ _01104_ clknet_leaf_73_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[3\]
+ _09149_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[40\]$_DFFE_PP_
+ _01105_ clknet_leaf_96_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[40\]
+ _09148_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[41\]$_DFFE_PP_
+ _01106_ clknet_leaf_92_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[41\]
+ _09147_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[42\]$_DFFE_PP_
+ _01107_ clknet_leaf_81_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[42\]
+ _09146_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[43\]$_DFFE_PP_
+ _01108_ clknet_leaf_98_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[43\]
+ _09145_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[44\]$_DFFE_PP_
+ _01109_ clknet_leaf_87_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[44\]
+ _09144_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[45\]$_DFFE_PP_
+ _01110_ clknet_leaf_90_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[45\]
+ _09143_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[46\]$_DFFE_PP_
+ _01111_ clknet_leaf_115_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[46\]
+ _09142_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[47\]$_DFFE_PP_
+ _01112_ clknet_leaf_114_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[47\]
+ _09141_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[48\]$_DFFE_PP_
+ _01113_ clknet_leaf_114_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[48\]
+ _09140_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[49\]$_DFFE_PP_
+ _01114_ clknet_leaf_113_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[49\]
+ _09139_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[4\]$_DFFE_PP_
+ _01115_ clknet_leaf_57_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[4\]
+ _09138_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[50\]$_DFFE_PP_
+ _01116_ clknet_leaf_127_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[50\]
+ _09137_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[51\]$_DFFE_PP_
+ _01117_ clknet_leaf_59_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[51\]
+ _09136_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[52\]$_DFFE_PP_
+ _01118_ clknet_leaf_126_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[52\]
+ _09135_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[53\]$_DFFE_PP_
+ _01119_ clknet_leaf_117_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[53\]
+ _09134_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[54\]$_DFFE_PP_
+ _01120_ clknet_leaf_121_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[54\]
+ _09133_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[55\]$_DFFE_PP_
+ _01121_ clknet_leaf_48_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[55\]
+ _09132_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[56\]$_DFFE_PP_
+ _01122_ clknet_leaf_304_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[56\]
+ _09131_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[57\]$_DFFE_PP_
+ _01123_ clknet_leaf_43_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[57\]
+ _09130_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[58\]$_DFFE_PP_
+ _01124_ clknet_leaf_201_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[58\]
+ _09129_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[59\]$_DFFE_PP_
+ _01125_ clknet_leaf_49_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[59\]
+ _09128_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[5\]$_DFFE_PP_
+ _01126_ clknet_leaf_41_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[5\]
+ _09127_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[60\]$_DFFE_PP_
+ _01127_ clknet_leaf_304_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[60\]
+ _09126_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[61\]$_DFFE_PP_
+ _01128_ clknet_leaf_45_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[61\]
+ _09125_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[62\]$_DFFE_PP_
+ _01129_ clknet_leaf_301_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[62\]
+ _09124_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[63\]$_DFFE_PP_
+ _01130_ clknet_leaf_305_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[63\]
+ _09123_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[6\]$_DFFE_PP_
+ _01131_ clknet_leaf_26_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[6\]
+ _09122_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[7\]$_DFFE_PP_
+ _01132_ clknet_leaf_26_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[7\]
+ _09121_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[8\]$_DFFE_PP_
+ _01133_ clknet_leaf_29_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[8\]
+ _09120_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[9\]$_DFFE_PP_
+ _01134_ clknet_leaf_28_clk dynamic_node_top.proc_input.NIB.storage_data_f\[15\]\[9\]
+ _09119_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[0\]$_DFFE_PP_
+ _01135_ clknet_leaf_16_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[0\]
+ _09118_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[10\]$_DFFE_PP_
+ _01136_ clknet_leaf_10_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[10\]
+ _09117_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[11\]$_DFFE_PP_
+ _01137_ clknet_leaf_0_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[11\]
+ _09116_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[12\]$_DFFE_PP_
+ _01138_ clknet_leaf_16_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[12\]
+ _09115_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[13\]$_DFFE_PP_
+ _01139_ clknet_leaf_0_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[13\]
+ _09114_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[14\]$_DFFE_PP_
+ _01140_ clknet_leaf_11_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[14\]
+ _09113_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[15\]$_DFFE_PP_
+ _01141_ clknet_leaf_9_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[15\]
+ _09112_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[16\]$_DFFE_PP_
+ _01142_ clknet_leaf_327_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[16\]
+ _09111_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[17\]$_DFFE_PP_
+ _01143_ clknet_leaf_327_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[17\]
+ _09110_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[18\]$_DFFE_PP_
+ _01144_ clknet_leaf_9_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[18\]
+ _09109_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[19\]$_DFFE_PP_
+ _01145_ clknet_leaf_34_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[19\]
+ _09108_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[1\]$_DFFE_PP_
+ _01146_ clknet_leaf_33_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[1\]
+ _09107_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[20\]$_DFFE_PP_
+ _01147_ clknet_leaf_322_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[20\]
+ _09106_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[21\]$_DFFE_PP_
+ _01148_ clknet_leaf_28_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[21\]
+ _09105_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[22\]$_DFFE_PP_
+ _01149_ clknet_leaf_313_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[22\]
+ _09104_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[23\]$_DFFE_PP_
+ _01150_ clknet_leaf_314_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[23\]
+ _09103_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[24\]$_DFFE_PP_
+ _01151_ clknet_leaf_317_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[24\]
+ _09102_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[25\]$_DFFE_PP_
+ _01152_ clknet_leaf_312_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[25\]
+ _09101_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[26\]$_DFFE_PP_
+ _01153_ clknet_leaf_38_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[26\]
+ _09100_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[27\]$_DFFE_PP_
+ _01154_ clknet_leaf_319_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[27\]
+ _09099_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[28\]$_DFFE_PP_
+ _01155_ clknet_leaf_27_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[28\]
+ _09098_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[29\]$_DFFE_PP_
+ _01156_ clknet_leaf_70_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[29\]
+ _09097_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[2\]$_DFFE_PP_
+ _01157_ clknet_leaf_20_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[2\]
+ _09096_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[30\]$_DFFE_PP_
+ _01158_ clknet_leaf_67_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[30\]
+ _09095_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[31\]$_DFFE_PP_
+ _01159_ clknet_leaf_68_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[31\]
+ _09094_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[32\]$_DFFE_PP_
+ _01160_ clknet_leaf_66_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[32\]
+ _09093_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[33\]$_DFFE_PP_
+ _01161_ clknet_leaf_76_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[33\]
+ _09092_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[34\]$_DFFE_PP_
+ _01162_ clknet_leaf_80_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[34\]
+ _09091_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[35\]$_DFFE_PP_
+ _01163_ clknet_leaf_88_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[35\]
+ _09090_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[36\]$_DFFE_PP_
+ _01164_ clknet_leaf_64_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[36\]
+ _09089_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[37\]$_DFFE_PP_
+ _01165_ clknet_leaf_104_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[37\]
+ _09088_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[38\]$_DFFE_PP_
+ _01166_ clknet_leaf_95_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[38\]
+ _09087_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[39\]$_DFFE_PP_
+ _01167_ clknet_leaf_85_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[39\]
+ _09086_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[3\]$_DFFE_PP_
+ _01168_ clknet_leaf_75_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[3\]
+ _09085_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[40\]$_DFFE_PP_
+ _01169_ clknet_leaf_102_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[40\]
+ _09084_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[41\]$_DFFE_PP_
+ _01170_ clknet_leaf_93_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[41\]
+ _09083_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[42\]$_DFFE_PP_
+ _01171_ clknet_leaf_79_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[42\]
+ _09082_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[43\]$_DFFE_PP_
+ _01172_ clknet_leaf_100_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[43\]
+ _09081_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[44\]$_DFFE_PP_
+ _01173_ clknet_leaf_83_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[44\]
+ _09080_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[45\]$_DFFE_PP_
+ _01174_ clknet_leaf_102_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[45\]
+ _09079_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[46\]$_DFFE_PP_
+ _01175_ clknet_leaf_63_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[46\]
+ _09078_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[47\]$_DFFE_PP_
+ _01176_ clknet_leaf_107_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[47\]
+ _09077_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[48\]$_DFFE_PP_
+ _01177_ clknet_leaf_107_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[48\]
+ _09076_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[49\]$_DFFE_PP_
+ _01178_ clknet_leaf_107_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[49\]
+ _09075_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[4\]$_DFFE_PP_
+ _01179_ clknet_leaf_69_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[4\]
+ _09074_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[50\]$_DFFE_PP_
+ _01180_ clknet_leaf_59_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[50\]
+ _09073_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[51\]$_DFFE_PP_
+ _01181_ clknet_leaf_60_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[51\]
+ _09072_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[52\]$_DFFE_PP_
+ _01182_ clknet_leaf_53_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[52\]
+ _09071_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[53\]$_DFFE_PP_
+ _01183_ clknet_leaf_116_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[53\]
+ _09070_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[54\]$_DFFE_PP_
+ _01184_ clknet_leaf_118_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[54\]
+ _09069_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[55\]$_DFFE_PP_
+ _01185_ clknet_leaf_48_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[55\]
+ _09068_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[56\]$_DFFE_PP_
+ _01186_ clknet_leaf_303_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[56\]
+ _09067_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[57\]$_DFFE_PP_
+ _01187_ clknet_leaf_54_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[57\]
+ _09066_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[58\]$_DFFE_PP_
+ _01188_ clknet_leaf_129_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[58\]
+ _09065_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[59\]$_DFFE_PP_
+ _01189_ clknet_leaf_129_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[59\]
+ _09064_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[5\]$_DFFE_PP_
+ _01190_ clknet_leaf_27_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[5\]
+ _09063_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[60\]$_DFFE_PP_
+ _01191_ clknet_leaf_47_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[60\]
+ _09062_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[61\]$_DFFE_PP_
+ _01192_ clknet_leaf_39_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[61\]
+ _09061_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[62\]$_DFFE_PP_
+ _01193_ clknet_leaf_303_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[62\]
+ _09060_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[63\]$_DFFE_PP_
+ _01194_ clknet_leaf_305_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[63\]
+ _09059_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[6\]$_DFFE_PP_
+ _01195_ clknet_leaf_22_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[6\]
+ _09058_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[7\]$_DFFE_PP_
+ _01196_ clknet_leaf_20_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[7\]
+ _09057_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[8\]$_DFFE_PP_
+ _01197_ clknet_leaf_17_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[8\]
+ _09056_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[9\]$_DFFE_PP_
+ _01198_ clknet_leaf_22_clk dynamic_node_top.proc_input.NIB.storage_data_f\[1\]\[9\]
+ _09055_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[0\]$_DFFE_PP_
+ _01199_ clknet_leaf_16_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[0\]
+ _09054_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[10\]$_DFFE_PP_
+ _01200_ clknet_leaf_10_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[10\]
+ _09053_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[11\]$_DFFE_PP_
+ _01201_ clknet_leaf_324_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[11\]
+ _09052_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[12\]$_DFFE_PP_
+ _01202_ clknet_leaf_16_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[12\]
+ _09051_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[13\]$_DFFE_PP_
+ _01203_ clknet_leaf_0_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[13\]
+ _09050_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[14\]$_DFFE_PP_
+ _01204_ clknet_leaf_11_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[14\]
+ _09049_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[15\]$_DFFE_PP_
+ _01205_ clknet_leaf_9_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[15\]
+ _09048_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[16\]$_DFFE_PP_
+ _01206_ clknet_leaf_0_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[16\]
+ _09047_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[17\]$_DFFE_PP_
+ _01207_ clknet_leaf_327_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[17\]
+ _09046_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[18\]$_DFFE_PP_
+ _01208_ clknet_leaf_15_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[18\]
+ _09045_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[19\]$_DFFE_PP_
+ _01209_ clknet_leaf_4_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[19\]
+ _09044_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[1\]$_DFFE_PP_
+ _01210_ clknet_leaf_33_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[1\]
+ _09043_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[20\]$_DFFE_PP_
+ _01211_ clknet_leaf_322_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[20\]
+ _09042_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[21\]$_DFFE_PP_
+ _01212_ clknet_leaf_28_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[21\]
+ _09041_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[22\]$_DFFE_PP_
+ _01213_ clknet_leaf_315_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[22\]
+ _09040_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[23\]$_DFFE_PP_
+ _01214_ clknet_leaf_314_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[23\]
+ _09039_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[24\]$_DFFE_PP_
+ _01215_ clknet_leaf_321_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[24\]
+ _09038_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[25\]$_DFFE_PP_
+ _01216_ clknet_leaf_313_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[25\]
+ _09037_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[26\]$_DFFE_PP_
+ _01217_ clknet_leaf_37_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[26\]
+ _09036_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[27\]$_DFFE_PP_
+ _01218_ clknet_leaf_319_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[27\]
+ _09035_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[28\]$_DFFE_PP_
+ _01219_ clknet_leaf_71_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[28\]
+ _09034_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[29\]$_DFFE_PP_
+ _01220_ clknet_leaf_70_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[29\]
+ _09033_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[2\]$_DFFE_PP_
+ _01221_ clknet_leaf_76_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[2\]
+ _09032_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[30\]$_DFFE_PP_
+ _01222_ clknet_leaf_73_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[30\]
+ _09031_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[31\]$_DFFE_PP_
+ _01223_ clknet_leaf_67_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[31\]
+ _09030_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[32\]$_DFFE_PP_
+ _01224_ clknet_leaf_65_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[32\]
+ _09029_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[33\]$_DFFE_PP_
+ _01225_ clknet_leaf_76_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[33\]
+ _09028_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[34\]$_DFFE_PP_
+ _01226_ clknet_leaf_81_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[34\]
+ _09027_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[35\]$_DFFE_PP_
+ _01227_ clknet_leaf_90_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[35\]
+ _09026_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[36\]$_DFFE_PP_
+ _01228_ clknet_leaf_63_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[36\]
+ _09025_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[37\]$_DFFE_PP_
+ _01229_ clknet_leaf_104_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[37\]
+ _09024_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[38\]$_DFFE_PP_
+ _01230_ clknet_leaf_95_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[38\]
+ _09023_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[39\]$_DFFE_PP_
+ _01231_ clknet_leaf_85_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[39\]
+ _09022_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[3\]$_DFFE_PP_
+ _01232_ clknet_leaf_80_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[3\]
+ _09021_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[40\]$_DFFE_PP_
+ _01233_ clknet_leaf_102_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[40\]
+ _09020_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[41\]$_DFFE_PP_
+ _01234_ clknet_leaf_94_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[41\]
+ _09019_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[42\]$_DFFE_PP_
+ _01235_ clknet_leaf_79_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[42\]
+ _09018_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[43\]$_DFFE_PP_
+ _01236_ clknet_leaf_100_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[43\]
+ _09017_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[44\]$_DFFE_PP_
+ _01237_ clknet_leaf_83_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[44\]
+ _09016_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[45\]$_DFFE_PP_
+ _01238_ clknet_leaf_101_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[45\]
+ _09015_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[46\]$_DFFE_PP_
+ _01239_ clknet_leaf_63_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[46\]
+ _09014_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[47\]$_DFFE_PP_
+ _01240_ clknet_leaf_107_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[47\]
+ _09013_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[48\]$_DFFE_PP_
+ _01241_ clknet_leaf_105_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[48\]
+ _09012_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[49\]$_DFFE_PP_
+ _01242_ clknet_leaf_112_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[49\]
+ _09011_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[4\]$_DFFE_PP_
+ _01243_ clknet_leaf_69_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[4\]
+ _09010_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[50\]$_DFFE_PP_
+ _01244_ clknet_leaf_52_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[50\]
+ _09009_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[51\]$_DFFE_PP_
+ _01245_ clknet_leaf_58_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[51\]
+ _09008_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[52\]$_DFFE_PP_
+ _01246_ clknet_leaf_52_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[52\]
+ _09007_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[53\]$_DFFE_PP_
+ _01247_ clknet_leaf_121_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[53\]
+ _09006_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[54\]$_DFFE_PP_
+ _01248_ clknet_leaf_119_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[54\]
+ _09005_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[55\]$_DFFE_PP_
+ _01249_ clknet_leaf_54_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[55\]
+ _09004_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[56\]$_DFFE_PP_
+ _01250_ clknet_leaf_308_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[56\]
+ _09003_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[57\]$_DFFE_PP_
+ _01251_ clknet_leaf_54_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[57\]
+ _09002_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[58\]$_DFFE_PP_
+ _01252_ clknet_leaf_130_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[58\]
+ _09001_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[59\]$_DFFE_PP_
+ _01253_ clknet_leaf_50_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[59\]
+ _09000_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[5\]$_DFFE_PP_
+ _01254_ clknet_leaf_27_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[5\]
+ _08999_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[60\]$_DFFE_PP_
+ _01255_ clknet_leaf_302_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[60\]
+ _08998_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[61\]$_DFFE_PP_
+ _01256_ clknet_leaf_38_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[61\]
+ _08997_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[62\]$_DFFE_PP_
+ _01257_ clknet_leaf_302_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[62\]
+ _08996_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[63\]$_DFFE_PP_
+ _01258_ clknet_leaf_306_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[63\]
+ _08995_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[6\]$_DFFE_PP_
+ _01259_ clknet_leaf_20_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[6\]
+ _08994_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[7\]$_DFFE_PP_
+ _01260_ clknet_leaf_20_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[7\]
+ _08993_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[8\]$_DFFE_PP_
+ _01261_ clknet_leaf_17_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[8\]
+ _08992_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[9\]$_DFFE_PP_
+ _01262_ clknet_leaf_17_clk dynamic_node_top.proc_input.NIB.storage_data_f\[2\]\[9\]
+ _08991_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[0\]$_DFFE_PP_
+ _01263_ clknet_leaf_16_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[0\]
+ _08990_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[10\]$_DFFE_PP_
+ _01264_ clknet_leaf_10_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[10\]
+ _08989_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[11\]$_DFFE_PP_
+ _01265_ clknet_leaf_324_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[11\]
+ _08988_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[12\]$_DFFE_PP_
+ _01266_ clknet_leaf_16_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[12\]
+ _08987_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[13\]$_DFFE_PP_
+ _01267_ clknet_leaf_1_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[13\]
+ _08986_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[14\]$_DFFE_PP_
+ _01268_ clknet_leaf_9_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[14\]
+ _08985_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[15\]$_DFFE_PP_
+ _01269_ clknet_leaf_8_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[15\]
+ _08984_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[16\]$_DFFE_PP_
+ _01270_ clknet_leaf_0_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[16\]
+ _08983_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[17\]$_DFFE_PP_
+ _01271_ clknet_leaf_327_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[17\]
+ _08982_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[18\]$_DFFE_PP_
+ _01272_ clknet_leaf_8_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[18\]
+ _08981_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[19\]$_DFFE_PP_
+ _01273_ clknet_leaf_4_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[19\]
+ _08980_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[1\]$_DFFE_PP_
+ _01274_ clknet_leaf_32_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[1\]
+ _08979_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[20\]$_DFFE_PP_
+ _01275_ clknet_leaf_323_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[20\]
+ _08978_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[21\]$_DFFE_PP_
+ _01276_ clknet_leaf_28_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[21\]
+ _08977_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[22\]$_DFFE_PP_
+ _01277_ clknet_leaf_315_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[22\]
+ _08976_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[23\]$_DFFE_PP_
+ _01278_ clknet_leaf_319_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[23\]
+ _08975_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[24\]$_DFFE_PP_
+ _01279_ clknet_leaf_321_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[24\]
+ _08974_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[25\]$_DFFE_PP_
+ _01280_ clknet_leaf_312_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[25\]
+ _08973_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[26\]$_DFFE_PP_
+ _01281_ clknet_leaf_38_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[26\]
+ _08972_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[27\]$_DFFE_PP_
+ _01282_ clknet_leaf_319_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[27\]
+ _08971_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[28\]$_DFFE_PP_
+ _01283_ clknet_leaf_71_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[28\]
+ _08970_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[29\]$_DFFE_PP_
+ _01284_ clknet_leaf_70_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[29\]
+ _08969_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[2\]$_DFFE_PP_
+ _01285_ clknet_leaf_76_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[2\]
+ _08968_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[30\]$_DFFE_PP_
+ _01286_ clknet_leaf_73_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[30\]
+ _08967_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[31\]$_DFFE_PP_
+ _01287_ clknet_leaf_68_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[31\]
+ _08966_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[32\]$_DFFE_PP_
+ _01288_ clknet_leaf_64_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[32\]
+ _08965_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[33\]$_DFFE_PP_
+ _01289_ clknet_leaf_76_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[33\]
+ _08964_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[34\]$_DFFE_PP_
+ _01290_ clknet_leaf_81_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[34\]
+ _08963_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[35\]$_DFFE_PP_
+ _01291_ clknet_leaf_89_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[35\]
+ _08962_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[36\]$_DFFE_PP_
+ _01292_ clknet_leaf_64_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[36\]
+ _08961_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[37\]$_DFFE_PP_
+ _01293_ clknet_leaf_104_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[37\]
+ _08960_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[38\]$_DFFE_PP_
+ _01294_ clknet_leaf_95_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[38\]
+ _08959_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[39\]$_DFFE_PP_
+ _01295_ clknet_leaf_85_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[39\]
+ _08958_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[3\]$_DFFE_PP_
+ _01296_ clknet_leaf_80_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[3\]
+ _08957_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[40\]$_DFFE_PP_
+ _01297_ clknet_leaf_102_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[40\]
+ _08956_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[41\]$_DFFE_PP_
+ _01298_ clknet_leaf_93_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[41\]
+ _08955_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[42\]$_DFFE_PP_
+ _01299_ clknet_leaf_79_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[42\]
+ _08954_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[43\]$_DFFE_PP_
+ _01300_ clknet_leaf_99_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[43\]
+ _08953_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[44\]$_DFFE_PP_
+ _01301_ clknet_leaf_83_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[44\]
+ _08952_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[45\]$_DFFE_PP_
+ _01302_ clknet_leaf_102_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[45\]
+ _08951_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[46\]$_DFFE_PP_
+ _01303_ clknet_leaf_63_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[46\]
+ _08950_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[47\]$_DFFE_PP_
+ _01304_ clknet_leaf_107_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[47\]
+ _08949_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[48\]$_DFFE_PP_
+ _01305_ clknet_leaf_107_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[48\]
+ _08948_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[49\]$_DFFE_PP_
+ _01306_ clknet_leaf_114_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[49\]
+ _08947_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[4\]$_DFFE_PP_
+ _01307_ clknet_leaf_57_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[4\]
+ _08946_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[50\]$_DFFE_PP_
+ _01308_ clknet_leaf_59_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[50\]
+ _08945_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[51\]$_DFFE_PP_
+ _01309_ clknet_leaf_58_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[51\]
+ _08944_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[52\]$_DFFE_PP_
+ _01310_ clknet_leaf_52_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[52\]
+ _08943_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[53\]$_DFFE_PP_
+ _01311_ clknet_leaf_117_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[53\]
+ _08942_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[54\]$_DFFE_PP_
+ _01312_ clknet_leaf_118_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[54\]
+ _08941_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[55\]$_DFFE_PP_
+ _01313_ clknet_leaf_44_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[55\]
+ _08940_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[56\]$_DFFE_PP_
+ _01314_ clknet_leaf_304_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[56\]
+ _08939_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[57\]$_DFFE_PP_
+ _01315_ clknet_leaf_53_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[57\]
+ _08938_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[58\]$_DFFE_PP_
+ _01316_ clknet_leaf_129_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[58\]
+ _08937_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[59\]$_DFFE_PP_
+ _01317_ clknet_leaf_52_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[59\]
+ _08936_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[5\]$_DFFE_PP_
+ _01318_ clknet_leaf_27_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[5\]
+ _08935_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[60\]$_DFFE_PP_
+ _01319_ clknet_leaf_47_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[60\]
+ _08934_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[61\]$_DFFE_PP_
+ _01320_ clknet_leaf_39_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[61\]
+ _08933_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[62\]$_DFFE_PP_
+ _01321_ clknet_leaf_303_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[62\]
+ _08932_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[63\]$_DFFE_PP_
+ _01322_ clknet_leaf_46_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[63\]
+ _08931_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[6\]$_DFFE_PP_
+ _01323_ clknet_leaf_22_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[6\]
+ _08930_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[7\]$_DFFE_PP_
+ _01324_ clknet_leaf_21_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[7\]
+ _08929_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[8\]$_DFFE_PP_
+ _01325_ clknet_leaf_22_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[8\]
+ _08928_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[9\]$_DFFE_PP_
+ _01326_ clknet_leaf_22_clk dynamic_node_top.proc_input.NIB.storage_data_f\[3\]\[9\]
+ _08927_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[0\]$_DFFE_PP_
+ _01327_ clknet_leaf_15_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[0\]
+ _08926_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[10\]$_DFFE_PP_
+ _01328_ clknet_leaf_11_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[10\]
+ _08925_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[11\]$_DFFE_PP_
+ _01329_ clknet_leaf_324_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[11\]
+ _08924_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[12\]$_DFFE_PP_
+ _01330_ clknet_leaf_15_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[12\]
+ _08923_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[13\]$_DFFE_PP_
+ _01331_ clknet_leaf_326_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[13\]
+ _08922_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[14\]$_DFFE_PP_
+ _01332_ clknet_leaf_11_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[14\]
+ _08921_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[15\]$_DFFE_PP_
+ _01333_ clknet_leaf_13_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[15\]
+ _08920_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[16\]$_DFFE_PP_
+ _01334_ clknet_leaf_326_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[16\]
+ _08919_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[17\]$_DFFE_PP_
+ _01335_ clknet_leaf_326_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[17\]
+ _08918_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[18\]$_DFFE_PP_
+ _01336_ clknet_leaf_15_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[18\]
+ _08917_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[19\]$_DFFE_PP_
+ _01337_ clknet_leaf_34_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[19\]
+ _08916_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[1\]$_DFFE_PP_
+ _01338_ clknet_leaf_35_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[1\]
+ _08915_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[20\]$_DFFE_PP_
+ _01339_ clknet_leaf_321_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[20\]
+ _08914_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[21\]$_DFFE_PP_
+ _01340_ clknet_leaf_36_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[21\]
+ _08913_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[22\]$_DFFE_PP_
+ _01341_ clknet_leaf_311_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[22\]
+ _08912_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[23\]$_DFFE_PP_
+ _01342_ clknet_leaf_310_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[23\]
+ _08911_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[24\]$_DFFE_PP_
+ _01343_ clknet_leaf_317_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[24\]
+ _08910_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[25\]$_DFFE_PP_
+ _01344_ clknet_leaf_312_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[25\]
+ _08909_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[26\]$_DFFE_PP_
+ _01345_ clknet_leaf_313_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[26\]
+ _08908_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[27\]$_DFFE_PP_
+ _01346_ clknet_leaf_318_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[27\]
+ _08907_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[28\]$_DFFE_PP_
+ _01347_ clknet_leaf_26_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[28\]
+ _08906_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[29\]$_DFFE_PP_
+ _01348_ clknet_leaf_71_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[29\]
+ _08905_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[2\]$_DFFE_PP_
+ _01349_ clknet_leaf_19_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[2\]
+ _08904_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[30\]$_DFFE_PP_
+ _01350_ clknet_leaf_80_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[30\]
+ _08903_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[31\]$_DFFE_PP_
+ _01351_ clknet_leaf_68_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[31\]
+ _08902_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[32\]$_DFFE_PP_
+ _01352_ clknet_leaf_66_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[32\]
+ _08901_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[33\]$_DFFE_PP_
+ _01353_ clknet_leaf_77_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[33\]
+ _08900_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[34\]$_DFFE_PP_
+ _01354_ clknet_leaf_81_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[34\]
+ _08899_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[35\]$_DFFE_PP_
+ _01355_ clknet_leaf_87_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[35\]
+ _08898_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[36\]$_DFFE_PP_
+ _01356_ clknet_leaf_66_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[36\]
+ _08897_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[37\]$_DFFE_PP_
+ _01357_ clknet_leaf_104_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[37\]
+ _08896_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[38\]$_DFFE_PP_
+ _01358_ clknet_leaf_95_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[38\]
+ _08895_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[39\]$_DFFE_PP_
+ _01359_ clknet_leaf_84_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[39\]
+ _08894_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[3\]$_DFFE_PP_
+ _01360_ clknet_leaf_78_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[3\]
+ _08893_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[40\]$_DFFE_PP_
+ _01361_ clknet_leaf_102_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[40\]
+ _08892_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[41\]$_DFFE_PP_
+ _01362_ clknet_leaf_92_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[41\]
+ _08891_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[42\]$_DFFE_PP_
+ _01363_ clknet_leaf_82_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[42\]
+ _08890_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[43\]$_DFFE_PP_
+ _01364_ clknet_leaf_99_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[43\]
+ _08889_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[44\]$_DFFE_PP_
+ _01365_ clknet_leaf_83_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[44\]
+ _08888_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[45\]$_DFFE_PP_
+ _01366_ clknet_leaf_100_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[45\]
+ _08887_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[46\]$_DFFE_PP_
+ _01367_ clknet_leaf_91_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[46\]
+ _08886_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[47\]$_DFFE_PP_
+ _01368_ clknet_leaf_106_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[47\]
+ _08885_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[48\]$_DFFE_PP_
+ _01369_ clknet_leaf_92_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[48\]
+ _08884_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[49\]$_DFFE_PP_
+ _01370_ clknet_leaf_112_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[49\]
+ _08883_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[4\]$_DFFE_PP_
+ _01371_ clknet_leaf_69_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[4\]
+ _08882_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[50\]$_DFFE_PP_
+ _01372_ clknet_leaf_119_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[50\]
+ _08881_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[51\]$_DFFE_PP_
+ _01373_ clknet_leaf_60_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[51\]
+ _08880_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[52\]$_DFFE_PP_
+ _01374_ clknet_leaf_119_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[52\]
+ _08879_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[53\]$_DFFE_PP_
+ _01375_ clknet_leaf_120_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[53\]
+ _08878_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[54\]$_DFFE_PP_
+ _01376_ clknet_leaf_120_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[54\]
+ _08877_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[55\]$_DFFE_PP_
+ _01377_ clknet_leaf_44_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[55\]
+ _08876_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[56\]$_DFFE_PP_
+ _01378_ clknet_leaf_308_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[56\]
+ _08875_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[57\]$_DFFE_PP_
+ _01379_ clknet_leaf_42_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[57\]
+ _08874_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[58\]$_DFFE_PP_
+ _01380_ clknet_leaf_49_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[58\]
+ _08873_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[59\]$_DFFE_PP_
+ _01381_ clknet_leaf_48_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[59\]
+ _08872_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[5\]$_DFFE_PP_
+ _01382_ clknet_leaf_41_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[5\]
+ _08871_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[60\]$_DFFE_PP_
+ _01383_ clknet_leaf_47_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[60\]
+ _08870_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[61\]$_DFFE_PP_
+ _01384_ clknet_leaf_44_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[61\]
+ _08869_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[62\]$_DFFE_PP_
+ _01385_ clknet_leaf_49_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[62\]
+ _08868_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[63\]$_DFFE_PP_
+ _01386_ clknet_leaf_307_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[63\]
+ _08867_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[6\]$_DFFE_PP_
+ _01387_ clknet_leaf_20_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[6\]
+ _08866_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[7\]$_DFFE_PP_
+ _01388_ clknet_leaf_19_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[7\]
+ _08865_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[8\]$_DFFE_PP_
+ _01389_ clknet_leaf_23_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[8\]
+ _08864_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[9\]$_DFFE_PP_
+ _01390_ clknet_leaf_22_clk dynamic_node_top.proc_input.NIB.storage_data_f\[4\]\[9\]
+ _08863_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[0\]$_DFFE_PP_
+ _01391_ clknet_leaf_18_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[0\]
+ _08862_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[10\]$_DFFE_PP_
+ _01392_ clknet_leaf_12_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[10\]
+ _08861_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[11\]$_DFFE_PP_
+ _01393_ clknet_leaf_324_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[11\]
+ _08860_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[12\]$_DFFE_PP_
+ _01394_ clknet_leaf_14_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[12\]
+ _08859_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[13\]$_DFFE_PP_
+ _01395_ clknet_leaf_325_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[13\]
+ _08858_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[14\]$_DFFE_PP_
+ _01396_ clknet_leaf_13_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[14\]
+ _08857_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[15\]$_DFFE_PP_
+ _01397_ clknet_leaf_14_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[15\]
+ _08856_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[16\]$_DFFE_PP_
+ _01398_ clknet_leaf_325_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[16\]
+ _08855_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[17\]$_DFFE_PP_
+ _01399_ clknet_leaf_325_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[17\]
+ _08854_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[18\]$_DFFE_PP_
+ _01400_ clknet_leaf_14_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[18\]
+ _08853_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[19\]$_DFFE_PP_
+ _01401_ clknet_leaf_316_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[19\]
+ _08852_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[1\]$_DFFE_PP_
+ _01402_ clknet_leaf_35_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[1\]
+ _08851_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[20\]$_DFFE_PP_
+ _01403_ clknet_leaf_321_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[20\]
+ _08850_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[21\]$_DFFE_PP_
+ _01404_ clknet_leaf_40_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[21\]
+ _08849_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[22\]$_DFFE_PP_
+ _01405_ clknet_leaf_313_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[22\]
+ _08848_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[23\]$_DFFE_PP_
+ _01406_ clknet_leaf_314_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[23\]
+ _08847_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[24\]$_DFFE_PP_
+ _01407_ clknet_leaf_317_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[24\]
+ _08846_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[25\]$_DFFE_PP_
+ _01408_ clknet_leaf_313_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[25\]
+ _08845_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[26\]$_DFFE_PP_
+ _01409_ clknet_leaf_38_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[26\]
+ _08844_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[27\]$_DFFE_PP_
+ _01410_ clknet_leaf_319_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[27\]
+ _08843_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[28\]$_DFFE_PP_
+ _01411_ clknet_leaf_26_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[28\]
+ _08842_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[29\]$_DFFE_PP_
+ _01412_ clknet_leaf_71_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[29\]
+ _08841_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[2\]$_DFFE_PP_
+ _01413_ clknet_leaf_77_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[2\]
+ _08840_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[30\]$_DFFE_PP_
+ _01414_ clknet_leaf_74_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[30\]
+ _08839_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[31\]$_DFFE_PP_
+ _01415_ clknet_leaf_68_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[31\]
+ _08838_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[32\]$_DFFE_PP_
+ _01416_ clknet_leaf_66_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[32\]
+ _08837_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[33\]$_DFFE_PP_
+ _01417_ clknet_leaf_77_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[33\]
+ _08836_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[34\]$_DFFE_PP_
+ _01418_ clknet_leaf_82_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[34\]
+ _08835_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[35\]$_DFFE_PP_
+ _01419_ clknet_leaf_87_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[35\]
+ _08834_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[36\]$_DFFE_PP_
+ _01420_ clknet_leaf_91_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[36\]
+ _08833_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[37\]$_DFFE_PP_
+ _01421_ clknet_leaf_104_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[37\]
+ _08832_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[38\]$_DFFE_PP_
+ _01422_ clknet_leaf_103_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[38\]
+ _08831_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[39\]$_DFFE_PP_
+ _01423_ clknet_leaf_84_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[39\]
+ _08830_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[3\]$_DFFE_PP_
+ _01424_ clknet_leaf_78_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[3\]
+ _08829_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[40\]$_DFFE_PP_
+ _01425_ clknet_leaf_103_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[40\]
+ _08828_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[41\]$_DFFE_PP_
+ _01426_ clknet_leaf_105_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[41\]
+ _08827_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[42\]$_DFFE_PP_
+ _01427_ clknet_leaf_82_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[42\]
+ _08826_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[43\]$_DFFE_PP_
+ _01428_ clknet_leaf_100_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[43\]
+ _08825_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[44\]$_DFFE_PP_
+ _01429_ clknet_leaf_84_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[44\]
+ _08824_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[45\]$_DFFE_PP_
+ _01430_ clknet_leaf_101_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[45\]
+ _08823_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[46\]$_DFFE_PP_
+ _01431_ clknet_leaf_91_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[46\]
+ _08822_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[47\]$_DFFE_PP_
+ _01432_ clknet_leaf_105_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[47\]
+ _08821_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[48\]$_DFFE_PP_
+ _01433_ clknet_leaf_105_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[48\]
+ _08820_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[49\]$_DFFE_PP_
+ _01434_ clknet_leaf_112_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[49\]
+ _08819_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[4\]$_DFFE_PP_
+ _01435_ clknet_leaf_69_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[4\]
+ _08818_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[50\]$_DFFE_PP_
+ _01436_ clknet_leaf_118_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[50\]
+ _08817_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[51\]$_DFFE_PP_
+ _01437_ clknet_leaf_58_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[51\]
+ _08816_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[52\]$_DFFE_PP_
+ _01438_ clknet_leaf_59_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[52\]
+ _08815_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[53\]$_DFFE_PP_
+ _01439_ clknet_leaf_116_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[53\]
+ _08814_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[54\]$_DFFE_PP_
+ _01440_ clknet_leaf_117_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[54\]
+ _08813_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[55\]$_DFFE_PP_
+ _01441_ clknet_leaf_43_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[55\]
+ _08812_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[56\]$_DFFE_PP_
+ _01442_ clknet_leaf_300_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[56\]
+ _08811_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[57\]$_DFFE_PP_
+ _01443_ clknet_leaf_54_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[57\]
+ _08810_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[58\]$_DFFE_PP_
+ _01444_ clknet_leaf_131_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[58\]
+ _08809_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[59\]$_DFFE_PP_
+ _01445_ clknet_leaf_50_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[59\]
+ _08808_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[5\]$_DFFE_PP_
+ _01446_ clknet_leaf_41_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[5\]
+ _08807_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[60\]$_DFFE_PP_
+ _01447_ clknet_leaf_47_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[60\]
+ _08806_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[61\]$_DFFE_PP_
+ _01448_ clknet_leaf_45_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[61\]
+ _08805_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[62\]$_DFFE_PP_
+ _01449_ clknet_leaf_48_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[62\]
+ _08804_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[63\]$_DFFE_PP_
+ _01450_ clknet_leaf_305_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[63\]
+ _08803_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[6\]$_DFFE_PP_
+ _01451_ clknet_leaf_19_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[6\]
+ _08802_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[7\]$_DFFE_PP_
+ _01452_ clknet_leaf_19_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[7\]
+ _08801_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[8\]$_DFFE_PP_
+ _01453_ clknet_leaf_18_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[8\]
+ _08800_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[9\]$_DFFE_PP_
+ _01454_ clknet_leaf_18_clk dynamic_node_top.proc_input.NIB.storage_data_f\[5\]\[9\]
+ _08799_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[0\]$_DFFE_PP_
+ _01455_ clknet_leaf_18_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[0\]
+ _08798_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[10\]$_DFFE_PP_
+ _01456_ clknet_leaf_11_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[10\]
+ _08797_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[11\]$_DFFE_PP_
+ _01457_ clknet_leaf_324_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[11\]
+ _08796_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[12\]$_DFFE_PP_
+ _01458_ clknet_leaf_15_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[12\]
+ _08795_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[13\]$_DFFE_PP_
+ _01459_ clknet_leaf_326_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[13\]
+ _08794_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[14\]$_DFFE_PP_
+ _01460_ clknet_leaf_11_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[14\]
+ _08793_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[15\]$_DFFE_PP_
+ _01461_ clknet_leaf_13_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[15\]
+ _08792_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[16\]$_DFFE_PP_
+ _01462_ clknet_leaf_326_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[16\]
+ _08791_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[17\]$_DFFE_PP_
+ _01463_ clknet_leaf_326_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[17\]
+ _08790_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[18\]$_DFFE_PP_
+ _01464_ clknet_leaf_15_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[18\]
+ _08789_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[19\]$_DFFE_PP_
+ _01465_ clknet_leaf_34_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[19\]
+ _08788_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[1\]$_DFFE_PP_
+ _01466_ clknet_leaf_35_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[1\]
+ _08787_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[20\]$_DFFE_PP_
+ _01467_ clknet_leaf_321_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[20\]
+ _08786_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[21\]$_DFFE_PP_
+ _01468_ clknet_leaf_36_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[21\]
+ _08785_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[22\]$_DFFE_PP_
+ _01469_ clknet_leaf_315_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[22\]
+ _08784_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[23\]$_DFFE_PP_
+ _01470_ clknet_leaf_314_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[23\]
+ _08783_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[24\]$_DFFE_PP_
+ _01471_ clknet_leaf_321_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[24\]
+ _08782_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[25\]$_DFFE_PP_
+ _01472_ clknet_leaf_311_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[25\]
+ _08781_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[26\]$_DFFE_PP_
+ _01473_ clknet_leaf_37_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[26\]
+ _08780_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[27\]$_DFFE_PP_
+ _01474_ clknet_leaf_318_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[27\]
+ _08779_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[28\]$_DFFE_PP_
+ _01475_ clknet_leaf_71_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[28\]
+ _08778_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[29\]$_DFFE_PP_
+ _01476_ clknet_leaf_71_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[29\]
+ _08777_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[2\]$_DFFE_PP_
+ _01477_ clknet_leaf_77_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[2\]
+ _08776_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[30\]$_DFFE_PP_
+ _01478_ clknet_leaf_74_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[30\]
+ _08775_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[31\]$_DFFE_PP_
+ _01479_ clknet_leaf_68_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[31\]
+ _08774_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[32\]$_DFFE_PP_
+ _01480_ clknet_leaf_66_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[32\]
+ _08773_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[33\]$_DFFE_PP_
+ _01481_ clknet_leaf_77_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[33\]
+ _08772_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[34\]$_DFFE_PP_
+ _01482_ clknet_leaf_81_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[34\]
+ _08771_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[35\]$_DFFE_PP_
+ _01483_ clknet_leaf_87_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[35\]
+ _08770_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[36\]$_DFFE_PP_
+ _01484_ clknet_leaf_66_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[36\]
+ _08769_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[37\]$_DFFE_PP_
+ _01485_ clknet_leaf_105_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[37\]
+ _08768_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[38\]$_DFFE_PP_
+ _01486_ clknet_leaf_95_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[38\]
+ _08767_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[39\]$_DFFE_PP_
+ _01487_ clknet_leaf_84_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[39\]
+ _08766_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[3\]$_DFFE_PP_
+ _01488_ clknet_leaf_78_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[3\]
+ _08765_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[40\]$_DFFE_PP_
+ _01489_ clknet_leaf_103_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[40\]
+ _08764_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[41\]$_DFFE_PP_
+ _01490_ clknet_leaf_105_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[41\]
+ _08763_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[42\]$_DFFE_PP_
+ _01491_ clknet_leaf_82_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[42\]
+ _08762_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[43\]$_DFFE_PP_
+ _01492_ clknet_leaf_99_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[43\]
+ _08761_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[44\]$_DFFE_PP_
+ _01493_ clknet_leaf_83_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[44\]
+ _08760_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[45\]$_DFFE_PP_
+ _01494_ clknet_leaf_101_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[45\]
+ _08759_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[46\]$_DFFE_PP_
+ _01495_ clknet_leaf_91_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[46\]
+ _08758_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[47\]$_DFFE_PP_
+ _01496_ clknet_leaf_106_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[47\]
+ _08757_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[48\]$_DFFE_PP_
+ _01497_ clknet_leaf_92_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[48\]
+ _08756_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[49\]$_DFFE_PP_
+ _01498_ clknet_leaf_112_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[49\]
+ _08755_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[4\]$_DFFE_PP_
+ _01499_ clknet_leaf_69_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[4\]
+ _08754_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[50\]$_DFFE_PP_
+ _01500_ clknet_leaf_119_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[50\]
+ _08753_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[51\]$_DFFE_PP_
+ _01501_ clknet_leaf_58_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[51\]
+ _08752_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[52\]$_DFFE_PP_
+ _01502_ clknet_leaf_119_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[52\]
+ _08751_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[53\]$_DFFE_PP_
+ _01503_ clknet_leaf_120_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[53\]
+ _08750_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[54\]$_DFFE_PP_
+ _01504_ clknet_leaf_120_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[54\]
+ _08749_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[55\]$_DFFE_PP_
+ _01505_ clknet_leaf_43_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[55\]
+ _08748_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[56\]$_DFFE_PP_
+ _01506_ clknet_leaf_308_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[56\]
+ _08747_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[57\]$_DFFE_PP_
+ _01507_ clknet_leaf_55_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[57\]
+ _08746_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[58\]$_DFFE_PP_
+ _01508_ clknet_leaf_50_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[58\]
+ _08745_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[59\]$_DFFE_PP_
+ _01509_ clknet_leaf_48_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[59\]
+ _08744_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[5\]$_DFFE_PP_
+ _01510_ clknet_leaf_41_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[5\]
+ _08743_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[60\]$_DFFE_PP_
+ _01511_ clknet_leaf_46_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[60\]
+ _08742_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[61\]$_DFFE_PP_
+ _01512_ clknet_leaf_43_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[61\]
+ _08741_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[62\]$_DFFE_PP_
+ _01513_ clknet_leaf_302_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[62\]
+ _08740_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[63\]$_DFFE_PP_
+ _01514_ clknet_leaf_306_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[63\]
+ _08739_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[6\]$_DFFE_PP_
+ _01515_ clknet_leaf_18_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[6\]
+ _08738_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[7\]$_DFFE_PP_
+ _01516_ clknet_leaf_19_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[7\]
+ _08737_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[8\]$_DFFE_PP_
+ _01517_ clknet_leaf_22_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[8\]
+ _08736_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[9\]$_DFFE_PP_
+ _01518_ clknet_leaf_21_clk dynamic_node_top.proc_input.NIB.storage_data_f\[6\]\[9\]
+ _08735_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[0\]$_DFFE_PP_
+ _01519_ clknet_leaf_18_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[0\]
+ _08734_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[10\]$_DFFE_PP_
+ _01520_ clknet_leaf_12_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[10\]
+ _08733_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[11\]$_DFFE_PP_
+ _01521_ clknet_leaf_325_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[11\]
+ _08732_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[12\]$_DFFE_PP_
+ _01522_ clknet_leaf_14_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[12\]
+ _08731_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[13\]$_DFFE_PP_
+ _01523_ clknet_leaf_325_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[13\]
+ _08730_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[14\]$_DFFE_PP_
+ _01524_ clknet_leaf_13_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[14\]
+ _08729_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[15\]$_DFFE_PP_
+ _01525_ clknet_leaf_14_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[15\]
+ _08728_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[16\]$_DFFE_PP_
+ _01526_ clknet_leaf_325_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[16\]
+ _08727_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[17\]$_DFFE_PP_
+ _01527_ clknet_leaf_12_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[17\]
+ _08726_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[18\]$_DFFE_PP_
+ _01528_ clknet_leaf_14_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[18\]
+ _08725_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[19\]$_DFFE_PP_
+ _01529_ clknet_leaf_316_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[19\]
+ _08724_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[1\]$_DFFE_PP_
+ _01530_ clknet_leaf_34_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[1\]
+ _08723_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[20\]$_DFFE_PP_
+ _01531_ clknet_leaf_321_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[20\]
+ _08722_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[21\]$_DFFE_PP_
+ _01532_ clknet_leaf_40_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[21\]
+ _08721_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[22\]$_DFFE_PP_
+ _01533_ clknet_leaf_313_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[22\]
+ _08720_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[23\]$_DFFE_PP_
+ _01534_ clknet_leaf_319_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[23\]
+ _08719_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[24\]$_DFFE_PP_
+ _01535_ clknet_leaf_317_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[24\]
+ _08718_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[25\]$_DFFE_PP_
+ _01536_ clknet_leaf_312_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[25\]
+ _08717_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[26\]$_DFFE_PP_
+ _01537_ clknet_leaf_37_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[26\]
+ _08716_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[27\]$_DFFE_PP_
+ _01538_ clknet_leaf_319_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[27\]
+ _08715_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[28\]$_DFFE_PP_
+ _01539_ clknet_leaf_72_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[28\]
+ _08714_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[29\]$_DFFE_PP_
+ _01540_ clknet_leaf_70_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[29\]
+ _08713_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[2\]$_DFFE_PP_
+ _01541_ clknet_leaf_77_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[2\]
+ _08712_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[30\]$_DFFE_PP_
+ _01542_ clknet_leaf_74_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[30\]
+ _08711_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[31\]$_DFFE_PP_
+ _01543_ clknet_leaf_68_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[31\]
+ _08710_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[32\]$_DFFE_PP_
+ _01544_ clknet_leaf_66_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[32\]
+ _08709_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[33\]$_DFFE_PP_
+ _01545_ clknet_leaf_78_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[33\]
+ _08708_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[34\]$_DFFE_PP_
+ _01546_ clknet_leaf_82_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[34\]
+ _08707_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[35\]$_DFFE_PP_
+ _01547_ clknet_leaf_87_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[35\]
+ _08706_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[36\]$_DFFE_PP_
+ _01548_ clknet_leaf_89_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[36\]
+ _08705_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[37\]$_DFFE_PP_
+ _01549_ clknet_leaf_104_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[37\]
+ _08704_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[38\]$_DFFE_PP_
+ _01550_ clknet_leaf_103_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[38\]
+ _08703_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[39\]$_DFFE_PP_
+ _01551_ clknet_leaf_84_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[39\]
+ _08702_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[3\]$_DFFE_PP_
+ _01552_ clknet_leaf_78_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[3\]
+ _08701_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[40\]$_DFFE_PP_
+ _01553_ clknet_leaf_103_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[40\]
+ _08700_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[41\]$_DFFE_PP_
+ _01554_ clknet_leaf_105_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[41\]
+ _08699_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[42\]$_DFFE_PP_
+ _01555_ clknet_leaf_83_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[42\]
+ _08698_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[43\]$_DFFE_PP_
+ _01556_ clknet_leaf_100_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[43\]
+ _08697_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[44\]$_DFFE_PP_
+ _01557_ clknet_leaf_84_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[44\]
+ _08696_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[45\]$_DFFE_PP_
+ _01558_ clknet_leaf_101_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[45\]
+ _08695_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[46\]$_DFFE_PP_
+ _01559_ clknet_leaf_92_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[46\]
+ _08694_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[47\]$_DFFE_PP_
+ _01560_ clknet_leaf_105_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[47\]
+ _08693_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[48\]$_DFFE_PP_
+ _01561_ clknet_leaf_105_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[48\]
+ _08692_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[49\]$_DFFE_PP_
+ _01562_ clknet_leaf_112_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[49\]
+ _08691_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[4\]$_DFFE_PP_
+ _01563_ clknet_leaf_69_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[4\]
+ _08690_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[50\]$_DFFE_PP_
+ _01564_ clknet_leaf_118_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[50\]
+ _08689_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[51\]$_DFFE_PP_
+ _01565_ clknet_leaf_59_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[51\]
+ _08688_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[52\]$_DFFE_PP_
+ _01566_ clknet_leaf_59_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[52\]
+ _08687_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[53\]$_DFFE_PP_
+ _01567_ clknet_leaf_116_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[53\]
+ _08686_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[54\]$_DFFE_PP_
+ _01568_ clknet_leaf_117_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[54\]
+ _08685_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[55\]$_DFFE_PP_
+ _01569_ clknet_leaf_44_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[55\]
+ _08684_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[56\]$_DFFE_PP_
+ _01570_ clknet_leaf_300_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[56\]
+ _08683_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[57\]$_DFFE_PP_
+ _01571_ clknet_leaf_54_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[57\]
+ _08682_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[58\]$_DFFE_PP_
+ _01572_ clknet_leaf_131_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[58\]
+ _08681_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[59\]$_DFFE_PP_
+ _01573_ clknet_leaf_50_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[59\]
+ _08680_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[5\]$_DFFE_PP_
+ _01574_ clknet_leaf_41_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[5\]
+ _08679_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[60\]$_DFFE_PP_
+ _01575_ clknet_leaf_46_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[60\]
+ _08678_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[61\]$_DFFE_PP_
+ _01576_ clknet_leaf_43_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[61\]
+ _08677_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[62\]$_DFFE_PP_
+ _01577_ clknet_leaf_49_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[62\]
+ _08676_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[63\]$_DFFE_PP_
+ _01578_ clknet_leaf_46_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[63\]
+ _08675_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[6\]$_DFFE_PP_
+ _01579_ clknet_leaf_19_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[6\]
+ _08674_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[7\]$_DFFE_PP_
+ _01580_ clknet_leaf_19_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[7\]
+ _08673_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[8\]$_DFFE_PP_
+ _01581_ clknet_leaf_17_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[8\]
+ _08672_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[9\]$_DFFE_PP_
+ _01582_ clknet_leaf_18_clk dynamic_node_top.proc_input.NIB.storage_data_f\[7\]\[9\]
+ _08671_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[0\]$_DFFE_PP_
+ _01583_ clknet_leaf_30_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[0\]
+ _08670_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[10\]$_DFFE_PP_
+ _01584_ clknet_leaf_6_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[10\]
+ _08669_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[11\]$_DFFE_PP_
+ _01585_ clknet_leaf_1_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[11\]
+ _08668_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[12\]$_DFFE_PP_
+ _01586_ clknet_leaf_7_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[12\]
+ _08667_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[13\]$_DFFE_PP_
+ _01587_ clknet_leaf_1_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[13\]
+ _08666_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[14\]$_DFFE_PP_
+ _01588_ clknet_leaf_6_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[14\]
+ _08665_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[15\]$_DFFE_PP_
+ _01589_ clknet_leaf_7_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[15\]
+ _08664_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[16\]$_DFFE_PP_
+ _01590_ clknet_leaf_2_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[16\]
+ _08663_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[17\]$_DFFE_PP_
+ _01591_ clknet_leaf_2_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[17\]
+ _08662_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[18\]$_DFFE_PP_
+ _01592_ clknet_leaf_7_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[18\]
+ _08661_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[19\]$_DFFE_PP_
+ _01593_ clknet_leaf_34_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[19\]
+ _08660_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[1\]$_DFFE_PP_
+ _01594_ clknet_leaf_32_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[1\]
+ _08659_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[20\]$_DFFE_PP_
+ _01595_ clknet_leaf_4_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[20\]
+ _08658_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[21\]$_DFFE_PP_
+ _01596_ clknet_leaf_32_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[21\]
+ _08657_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[22\]$_DFFE_PP_
+ _01597_ clknet_leaf_310_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[22\]
+ _08656_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[23\]$_DFFE_PP_
+ _01598_ clknet_leaf_309_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[23\]
+ _08655_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[24\]$_DFFE_PP_
+ _01599_ clknet_leaf_316_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[24\]
+ _08654_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[25\]$_DFFE_PP_
+ _01600_ clknet_leaf_306_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[25\]
+ _08653_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[26\]$_DFFE_PP_
+ _01601_ clknet_leaf_37_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[26\]
+ _08652_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[27\]$_DFFE_PP_
+ _01602_ clknet_leaf_318_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[27\]
+ _08651_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[28\]$_DFFE_PP_
+ _01603_ clknet_leaf_27_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[28\]
+ _08650_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[29\]$_DFFE_PP_
+ _01604_ clknet_leaf_56_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[29\]
+ _08649_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[2\]$_DFFE_PP_
+ _01605_ clknet_leaf_21_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[2\]
+ _08648_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[30\]$_DFFE_PP_
+ _01606_ clknet_leaf_74_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[30\]
+ _08647_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[31\]$_DFFE_PP_
+ _01607_ clknet_leaf_65_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[31\]
+ _08646_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[32\]$_DFFE_PP_
+ _01608_ clknet_leaf_61_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[32\]
+ _08645_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[33\]$_DFFE_PP_
+ _01609_ clknet_leaf_75_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[33\]
+ _08644_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[34\]$_DFFE_PP_
+ _01610_ clknet_leaf_88_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[34\]
+ _08643_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[35\]$_DFFE_PP_
+ _01611_ clknet_leaf_88_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[35\]
+ _08642_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[36\]$_DFFE_PP_
+ _01612_ clknet_leaf_61_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[36\]
+ _08641_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[37\]$_DFFE_PP_
+ _01613_ clknet_leaf_94_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[37\]
+ _08640_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[38\]$_DFFE_PP_
+ _01614_ clknet_leaf_97_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[38\]
+ _08639_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[39\]$_DFFE_PP_
+ _01615_ clknet_leaf_86_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[39\]
+ _08638_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[3\]$_DFFE_PP_
+ _01616_ clknet_leaf_75_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[3\]
+ _08637_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[40\]$_DFFE_PP_
+ _01617_ clknet_leaf_96_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[40\]
+ _08636_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[41\]$_DFFE_PP_
+ _01618_ clknet_leaf_93_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[41\]
+ _08635_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[42\]$_DFFE_PP_
+ _01619_ clknet_leaf_79_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[42\]
+ _08634_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[43\]$_DFFE_PP_
+ _01620_ clknet_leaf_99_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[43\]
+ _08633_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[44\]$_DFFE_PP_
+ _01621_ clknet_leaf_87_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[44\]
+ _08632_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[45\]$_DFFE_PP_
+ _01622_ clknet_leaf_99_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[45\]
+ _08631_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[46\]$_DFFE_PP_
+ _01623_ clknet_leaf_62_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[46\]
+ _08630_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[47\]$_DFFE_PP_
+ _01624_ clknet_leaf_106_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[47\]
+ _08629_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[48\]$_DFFE_PP_
+ _01625_ clknet_leaf_115_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[48\]
+ _08628_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[49\]$_DFFE_PP_
+ _01626_ clknet_leaf_113_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[49\]
+ _08627_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[4\]$_DFFE_PP_
+ _01627_ clknet_leaf_56_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[4\]
+ _08626_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[50\]$_DFFE_PP_
+ _01628_ clknet_leaf_127_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[50\]
+ _08625_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[51\]$_DFFE_PP_
+ _01629_ clknet_leaf_53_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[51\]
+ _08624_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[52\]$_DFFE_PP_
+ _01630_ clknet_leaf_127_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[52\]
+ _08623_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[53\]$_DFFE_PP_
+ _01631_ clknet_leaf_121_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[53\]
+ _08622_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[54\]$_DFFE_PP_
+ _01632_ clknet_leaf_120_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[54\]
+ _08621_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[55\]$_DFFE_PP_
+ _01633_ clknet_leaf_51_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[55\]
+ _08620_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[56\]$_DFFE_PP_
+ _01634_ clknet_leaf_308_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[56\]
+ _08619_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[57\]$_DFFE_PP_
+ _01635_ clknet_leaf_51_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[57\]
+ _08618_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[58\]$_DFFE_PP_
+ _01636_ clknet_leaf_130_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[58\]
+ _08617_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[59\]$_DFFE_PP_
+ _01637_ clknet_leaf_130_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[59\]
+ _08616_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[5\]$_DFFE_PP_
+ _01638_ clknet_leaf_40_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[5\]
+ _08615_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[60\]$_DFFE_PP_
+ _01639_ clknet_leaf_308_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[60\]
+ _08614_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[61\]$_DFFE_PP_
+ _01640_ clknet_leaf_46_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[61\]
+ _08613_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[62\]$_DFFE_PP_
+ _01641_ clknet_leaf_301_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[62\]
+ _08612_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[63\]$_DFFE_PP_
+ _01642_ clknet_leaf_306_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[63\]
+ _08611_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[6\]$_DFFE_PP_
+ _01643_ clknet_leaf_24_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[6\]
+ _08610_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[7\]$_DFFE_PP_
+ _01644_ clknet_leaf_24_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[7\]
+ _08609_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[8\]$_DFFE_PP_
+ _01645_ clknet_leaf_29_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[8\]
+ _08608_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[9\]$_DFFE_PP_
+ _01646_ clknet_leaf_23_clk dynamic_node_top.proc_input.NIB.storage_data_f\[8\]\[9\]
+ _08607_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[0\]$_DFFE_PP_
+ _01647_ clknet_leaf_16_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[0\]
+ _08606_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[10\]$_DFFE_PP_
+ _01648_ clknet_leaf_10_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[10\]
+ _08605_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[11\]$_DFFE_PP_
+ _01649_ clknet_leaf_0_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[11\]
+ _08604_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[12\]$_DFFE_PP_
+ _01650_ clknet_leaf_8_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[12\]
+ _08603_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[13\]$_DFFE_PP_
+ _01651_ clknet_leaf_0_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[13\]
+ _08602_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[14\]$_DFFE_PP_
+ _01652_ clknet_leaf_10_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[14\]
+ _08601_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[15\]$_DFFE_PP_
+ _01653_ clknet_leaf_9_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[15\]
+ _08600_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[16\]$_DFFE_PP_
+ _01654_ clknet_leaf_327_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[16\]
+ _08599_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[17\]$_DFFE_PP_
+ _01655_ clknet_leaf_327_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[17\]
+ _08598_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[18\]$_DFFE_PP_
+ _01656_ clknet_leaf_8_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[18\]
+ _08597_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[19\]$_DFFE_PP_
+ _01657_ clknet_leaf_34_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[19\]
+ _08596_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[1\]$_DFFE_PP_
+ _01658_ clknet_leaf_35_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[1\]
+ _08595_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[20\]$_DFFE_PP_
+ _01659_ clknet_leaf_322_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[20\]
+ _08594_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[21\]$_DFFE_PP_
+ _01660_ clknet_leaf_32_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[21\]
+ _08593_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[22\]$_DFFE_PP_
+ _01661_ clknet_leaf_314_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[22\]
+ _08592_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[23\]$_DFFE_PP_
+ _01662_ clknet_leaf_310_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[23\]
+ _08591_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[24\]$_DFFE_PP_
+ _01663_ clknet_leaf_317_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[24\]
+ _08590_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[25\]$_DFFE_PP_
+ _01664_ clknet_leaf_312_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[25\]
+ _08589_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[26\]$_DFFE_PP_
+ _01665_ clknet_leaf_38_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[26\]
+ _08588_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[27\]$_DFFE_PP_
+ _01666_ clknet_leaf_318_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[27\]
+ _08587_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[28\]$_DFFE_PP_
+ _01667_ clknet_leaf_27_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[28\]
+ _08586_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[29\]$_DFFE_PP_
+ _01668_ clknet_leaf_70_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[29\]
+ _08585_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[2\]$_DFFE_PP_
+ _01669_ clknet_leaf_21_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[2\]
+ _08584_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[30\]$_DFFE_PP_
+ _01670_ clknet_leaf_73_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[30\]
+ _08583_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[31\]$_DFFE_PP_
+ _01671_ clknet_leaf_68_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[31\]
+ _08582_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[32\]$_DFFE_PP_
+ _01672_ clknet_leaf_64_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[32\]
+ _08581_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[33\]$_DFFE_PP_
+ _01673_ clknet_leaf_75_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[33\]
+ _08580_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[34\]$_DFFE_PP_
+ _01674_ clknet_leaf_81_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[34\]
+ _08579_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[35\]$_DFFE_PP_
+ _01675_ clknet_leaf_87_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[35\]
+ _08578_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[36\]$_DFFE_PP_
+ _01676_ clknet_leaf_64_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[36\]
+ _08577_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[37\]$_DFFE_PP_
+ _01677_ clknet_leaf_104_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[37\]
+ _08576_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[38\]$_DFFE_PP_
+ _01678_ clknet_leaf_95_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[38\]
+ _08575_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[39\]$_DFFE_PP_
+ _01679_ clknet_leaf_85_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[39\]
+ _08574_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[3\]$_DFFE_PP_
+ _01680_ clknet_leaf_74_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[3\]
+ _08573_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[40\]$_DFFE_PP_
+ _01681_ clknet_leaf_96_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[40\]
+ _08572_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[41\]$_DFFE_PP_
+ _01682_ clknet_leaf_93_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[41\]
+ _08571_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[42\]$_DFFE_PP_
+ _01683_ clknet_leaf_79_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[42\]
+ _08570_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[43\]$_DFFE_PP_
+ _01684_ clknet_leaf_99_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[43\]
+ _08569_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[44\]$_DFFE_PP_
+ _01685_ clknet_leaf_85_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[44\]
+ _08568_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[45\]$_DFFE_PP_
+ _01686_ clknet_leaf_101_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[45\]
+ _08567_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[46\]$_DFFE_PP_
+ _01687_ clknet_leaf_63_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[46\]
+ _08566_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[47\]$_DFFE_PP_
+ _01688_ clknet_leaf_106_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[47\]
+ _08565_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[48\]$_DFFE_PP_
+ _01689_ clknet_leaf_106_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[48\]
+ _08564_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[49\]$_DFFE_PP_
+ _01690_ clknet_leaf_113_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[49\]
+ _08563_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[4\]$_DFFE_PP_
+ _01691_ clknet_leaf_69_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[4\]
+ _08562_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[50\]$_DFFE_PP_
+ _01692_ clknet_leaf_118_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[50\]
+ _08561_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[51\]$_DFFE_PP_
+ _01693_ clknet_leaf_118_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[51\]
+ _08560_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[52\]$_DFFE_PP_
+ _01694_ clknet_leaf_53_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[52\]
+ _08559_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[53\]$_DFFE_PP_
+ _01695_ clknet_leaf_117_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[53\]
+ _08558_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[54\]$_DFFE_PP_
+ _01696_ clknet_leaf_117_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[54\]
+ _08557_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[55\]$_DFFE_PP_
+ _01697_ clknet_leaf_54_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[55\]
+ _08556_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[56\]$_DFFE_PP_
+ _01698_ clknet_leaf_303_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[56\]
+ _08555_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[57\]$_DFFE_PP_
+ _01699_ clknet_leaf_53_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[57\]
+ _08554_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[58\]$_DFFE_PP_
+ _01700_ clknet_leaf_129_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[58\]
+ _08553_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[59\]$_DFFE_PP_
+ _01701_ clknet_leaf_128_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[59\]
+ _08552_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[5\]$_DFFE_PP_
+ _01702_ clknet_leaf_41_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[5\]
+ _08551_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[60\]$_DFFE_PP_
+ _01703_ clknet_leaf_304_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[60\]
+ _08550_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[61\]$_DFFE_PP_
+ _01704_ clknet_leaf_39_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[61\]
+ _08549_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[62\]$_DFFE_PP_
+ _01705_ clknet_leaf_303_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[62\]
+ _08548_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[63\]$_DFFE_PP_
+ _01706_ clknet_leaf_305_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[63\]
+ _08547_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[6\]$_DFFE_PP_
+ _01707_ clknet_leaf_21_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[6\]
+ _08546_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[7\]$_DFFE_PP_
+ _01708_ clknet_leaf_21_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[7\]
+ _08545_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[8\]$_DFFE_PP_
+ _01709_ clknet_leaf_23_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[8\]
+ _08544_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[9\]$_DFFE_PP_
+ _01710_ clknet_leaf_23_clk dynamic_node_top.proc_input.NIB.storage_data_f\[9\]\[9\]
+ _08543_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.tail_ptr_f\[0\]$_SDFFE_PP0N_
+ _01711_ clknet_leaf_57_clk dynamic_node_top.proc_input.NIB.tail_ptr_f\[0\]
+ dynamic_node_top.proc_input.NIB.tail_ptr_next\[0\] VDD VSS
+ DFF_X2
Xdynamic_node_top.proc_input.NIB.tail_ptr_f\[1\]$_SDFFE_PP0N_
+ _01712_ clknet_leaf_57_clk dynamic_node_top.proc_input.NIB.tail_ptr_f\[1\]
+ _10593_ VDD VSS DFF_X2
Xdynamic_node_top.proc_input.NIB.tail_ptr_f\[2\]$_SDFFE_PP0N_
+ _01713_ clknet_leaf_59_clk dynamic_node_top.proc_input.NIB.tail_ptr_f\[2\]
+ _08542_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.tail_ptr_f\[3\]$_SDFFE_PP0N_
+ _01714_ clknet_leaf_60_clk dynamic_node_top.proc_input.NIB.tail_ptr_f\[3\]
+ _08541_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.NIB.yummy_out_f$_SDFF_PP0_ _01715_
+ clknet_leaf_112_clk net628 _08540_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.control.count_f\[0\]$_SDFF_PP0_
+ _01716_ clknet_leaf_109_clk dynamic_node_top.proc_input.control.count_f\[0\]
+ _10531_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.control.count_f\[1\]$_SDFF_PP0_
+ _01717_ clknet_leaf_109_clk dynamic_node_top.proc_input.control.count_f\[1\]
+ _10532_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.control.count_f\[2\]$_SDFF_PP0_
+ _01718_ clknet_leaf_109_clk dynamic_node_top.proc_input.control.count_f\[2\]
+ _08539_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.control.count_f\[3\]$_SDFF_PP0_
+ _01719_ clknet_leaf_110_clk dynamic_node_top.proc_input.control.count_f\[3\]
+ _08538_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.control.count_f\[4\]$_SDFF_PP0_
+ _01720_ clknet_leaf_110_clk dynamic_node_top.proc_input.control.count_f\[4\]
+ _08537_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.control.count_f\[5\]$_SDFF_PP0_
+ _01721_ clknet_leaf_110_clk dynamic_node_top.proc_input.control.count_f\[5\]
+ _08536_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.control.count_f\[6\]$_SDFF_PP0_
+ _01722_ clknet_leaf_110_clk dynamic_node_top.proc_input.control.count_f\[6\]
+ _08535_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.control.count_f\[7\]$_SDFF_PP0_
+ _01723_ clknet_leaf_110_clk dynamic_node_top.proc_input.control.count_f\[7\]
+ _08534_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.control.count_one_f$_SDFF_PP0_
+ _01724_ clknet_leaf_111_clk dynamic_node_top.proc_input.control.count_one_f
+ _10156_ VDD VSS DFF_X1
Xdynamic_node_top.proc_input.control.header_temp$_DFF_P_ _00002_
+ clknet_leaf_109_clk dynamic_node_top.proc_input.control.header_last_temp
+ _08533_ VDD VSS DFF_X2
Xdynamic_node_top.proc_input.control.tail_last_f$_SDFF_PP0_
+ _01725_ clknet_leaf_111_clk dynamic_node_top.proc_input.control.tail_last_f
+ _10157_ VDD VSS DFF_X1
Xdynamic_node_top.proc_output.control.current_route_f\[0\]$_DFF_P_
+ _00022_ clknet_leaf_141_clk dynamic_node_top.proc_output.control.current_route_f\[0\]
+ _00054_ VDD VSS DFF_X1
Xdynamic_node_top.proc_output.control.current_route_f\[1\]$_DFF_P_
+ _00023_ clknet_leaf_159_clk dynamic_node_top.proc_output.control.current_route_f\[1\]
+ _00053_ VDD VSS DFF_X1
Xdynamic_node_top.proc_output.control.current_route_f\[2\]$_DFF_P_
+ _00024_ clknet_leaf_141_clk dynamic_node_top.proc_output.control.current_route_f\[2\]
+ _00066_ VDD VSS DFF_X2
Xdynamic_node_top.proc_output.control.current_route_f\[3\]$_DFF_P_
+ _00025_ clknet_leaf_141_clk dynamic_node_top.proc_output.control.current_route_f\[3\]
+ _00067_ VDD VSS DFF_X1
Xdynamic_node_top.proc_output.control.current_route_f\[4\]$_DFF_P_
+ _00026_ clknet_leaf_159_clk dynamic_node_top.proc_output.control.current_route_f\[4\]
+ _00065_ VDD VSS DFF_X2
Xdynamic_node_top.proc_output.control.planned_f$_SDFF_PP0_
+ _01726_ clknet_leaf_143_clk dynamic_node_top.proc_output.control.planned_f
+ _00055_ VDD VSS DFF_X1
Xdynamic_node_top.proc_output.space.count_f\[0\]$_SDFF_PP0_
+ _01727_ clknet_leaf_155_clk dynamic_node_top.proc_output.space.count_f\[0\]
+ _10523_ VDD VSS DFF_X2
Xdynamic_node_top.proc_output.space.count_f\[1\]$_SDFF_PP0_
+ _01728_ clknet_leaf_155_clk dynamic_node_top.proc_output.space.count_f\[1\]
+ _10524_ VDD VSS DFF_X2
Xdynamic_node_top.proc_output.space.count_f\[2\]$_SDFF_PP1_
+ _01729_ clknet_leaf_156_clk dynamic_node_top.proc_output.space.count_f\[2\]
+ _00060_ VDD VSS DFF_X1
Xdynamic_node_top.proc_output.space.is_one_f$_SDFF_PP0_ _01730_
+ clknet_leaf_155_clk dynamic_node_top.proc_output.space.is_one_f
+ _08532_ VDD VSS DFF_X1
Xdynamic_node_top.proc_output.space.is_two_or_more_f$_SDFF_PP1_
+ _01731_ clknet_leaf_155_clk dynamic_node_top.proc_output.space.is_two_or_more_f
+ _08531_ VDD VSS DFF_X1
Xdynamic_node_top.proc_output.space.valid_f$_SDFF_PP0_ _01732_
+ clknet_leaf_155_clk dynamic_node_top.proc_output.space.valid_f
+ _10520_ VDD VSS DFF_X1
Xdynamic_node_top.proc_output.space.yummy_f$_SDFF_PP0_ _01733_
+ clknet_leaf_155_clk dynamic_node_top.proc_output.space.yummy_f
+ _10517_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.elements_in_array_f\[0\]$_SDFFE_PP0N_
+ _01734_ clknet_leaf_148_clk dynamic_node_top.south_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.south_input.NIB.elements_in_array_next\[0\]
+ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.elements_in_array_f\[1\]$_SDFFE_PP0N_
+ _01735_ clknet_leaf_143_clk dynamic_node_top.south_input.NIB.elements_in_array_f\[1\]
+ _08530_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.elements_in_array_f\[2\]$_SDFFE_PP0N_
+ _01736_ clknet_leaf_148_clk dynamic_node_top.south_input.NIB.elements_in_array_f\[2\]
+ _08529_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.head_ptr_f\[0\]$_SDFFE_PP0N_
+ _01737_ clknet_leaf_292_clk dynamic_node_top.south_input.NIB.head_ptr_f\[0\]
+ dynamic_node_top.south_input.NIB.head_ptr_next\[0\] VDD VSS
+ DFF_X1
Xdynamic_node_top.south_input.NIB.head_ptr_f\[1\]$_SDFFE_PP0N_
+ _00080_ clknet_leaf_292_clk dynamic_node_top.south_input.NIB.head_ptr_f\[1\]
+ _08528_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[0\]$_DFFE_PP_
+ _01738_ clknet_leaf_271_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[0\]
+ _08527_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[10\]$_DFFE_PP_
+ _01739_ clknet_leaf_273_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[10\]
+ _08526_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[11\]$_DFFE_PP_
+ _01740_ clknet_leaf_272_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[11\]
+ _08525_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[12\]$_DFFE_PP_
+ _01741_ clknet_leaf_271_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[12\]
+ _08524_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[13\]$_DFFE_PP_
+ _01742_ clknet_leaf_271_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[13\]
+ _08523_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[14\]$_DFFE_PP_
+ _01743_ clknet_leaf_275_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[14\]
+ _08522_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[15\]$_DFFE_PP_
+ _01744_ clknet_leaf_274_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[15\]
+ _08521_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[16\]$_DFFE_PP_
+ _01745_ clknet_leaf_272_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[16\]
+ _08520_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[17\]$_DFFE_PP_
+ _01746_ clknet_leaf_272_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[17\]
+ _08519_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[18\]$_DFFE_PP_
+ _01747_ clknet_leaf_271_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[18\]
+ _08518_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[19\]$_DFFE_PP_
+ _01748_ clknet_leaf_270_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[19\]
+ _08517_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[1\]$_DFFE_PP_
+ _01749_ clknet_leaf_253_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[1\]
+ _08516_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[20\]$_DFFE_PP_
+ _01750_ clknet_leaf_268_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[20\]
+ _08515_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[21\]$_DFFE_PP_
+ _01751_ clknet_leaf_252_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[21\]
+ _08514_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[22\]$_DFFE_PP_
+ _01752_ clknet_leaf_247_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[22\]
+ _08513_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[23\]$_DFFE_PP_
+ _01753_ clknet_leaf_252_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[23\]
+ _08512_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[24\]$_DFFE_PP_
+ _01754_ clknet_leaf_251_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[24\]
+ _08511_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[25\]$_DFFE_PP_
+ _01755_ clknet_leaf_251_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[25\]
+ _08510_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[26\]$_DFFE_PP_
+ _01756_ clknet_leaf_269_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[26\]
+ _08509_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[27\]$_DFFE_PP_
+ _01757_ clknet_leaf_247_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[27\]
+ _08508_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[28\]$_DFFE_PP_
+ _01758_ clknet_leaf_249_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[28\]
+ _08507_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[29\]$_DFFE_PP_
+ _01759_ clknet_leaf_250_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[29\]
+ _08506_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[2\]$_DFFE_PP_
+ _01760_ clknet_leaf_254_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[2\]
+ _08505_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[30\]$_DFFE_PP_
+ _01761_ clknet_leaf_249_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[30\]
+ _08504_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[31\]$_DFFE_PP_
+ _01762_ clknet_leaf_248_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[31\]
+ _08503_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[32\]$_DFFE_PP_
+ _01763_ clknet_leaf_250_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[32\]
+ _08502_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[33\]$_DFFE_PP_
+ _01764_ clknet_leaf_254_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[33\]
+ _08501_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[34\]$_DFFE_PP_
+ _01765_ clknet_leaf_267_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[34\]
+ _08500_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[35\]$_DFFE_PP_
+ _01766_ clknet_leaf_257_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[35\]
+ _08499_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[36\]$_DFFE_PP_
+ _01767_ clknet_leaf_256_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[36\]
+ _08498_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[37\]$_DFFE_PP_
+ _01768_ clknet_leaf_255_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[37\]
+ _08497_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[38\]$_DFFE_PP_
+ _01769_ clknet_leaf_259_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[38\]
+ _08496_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[39\]$_DFFE_PP_
+ _01770_ clknet_leaf_264_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[39\]
+ _08495_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[3\]$_DFFE_PP_
+ _01771_ clknet_leaf_266_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[3\]
+ _08494_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[40\]$_DFFE_PP_
+ _01772_ clknet_leaf_263_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[40\]
+ _08493_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[41\]$_DFFE_PP_
+ _01773_ clknet_leaf_265_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[41\]
+ _08492_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[42\]$_DFFE_PP_
+ _01774_ clknet_leaf_267_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[42\]
+ _08491_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[43\]$_DFFE_PP_
+ _01775_ clknet_leaf_264_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[43\]
+ _08490_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[44\]$_DFFE_PP_
+ _01776_ clknet_leaf_262_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[44\]
+ _08489_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[45\]$_DFFE_PP_
+ _01777_ clknet_leaf_259_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[45\]
+ _08488_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[46\]$_DFFE_PP_
+ _01778_ clknet_leaf_285_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[46\]
+ _08487_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[47\]$_DFFE_PP_
+ _01779_ clknet_leaf_265_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[47\]
+ _08486_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[48\]$_DFFE_PP_
+ _01780_ clknet_leaf_285_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[48\]
+ _08485_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[49\]$_DFFE_PP_
+ _01781_ clknet_leaf_284_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[49\]
+ _08484_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[4\]$_DFFE_PP_
+ _01782_ clknet_leaf_273_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[4\]
+ _08483_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[50\]$_DFFE_PP_
+ _01783_ clknet_leaf_283_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[50\]
+ _08482_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[51\]$_DFFE_PP_
+ _01784_ clknet_leaf_284_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[51\]
+ _08481_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[52\]$_DFFE_PP_
+ _01785_ clknet_leaf_279_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[52\]
+ _08480_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[53\]$_DFFE_PP_
+ _01786_ clknet_leaf_284_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[53\]
+ _08479_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[54\]$_DFFE_PP_
+ _01787_ clknet_leaf_283_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[54\]
+ _08478_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[55\]$_DFFE_PP_
+ _01788_ clknet_leaf_281_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[55\]
+ _08477_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[56\]$_DFFE_PP_
+ _01789_ clknet_leaf_294_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[56\]
+ _08476_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[57\]$_DFFE_PP_
+ _01790_ clknet_leaf_293_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[57\]
+ _08475_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[58\]$_DFFE_PP_
+ _01791_ clknet_leaf_281_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[58\]
+ _08474_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[59\]$_DFFE_PP_
+ _01792_ clknet_leaf_282_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[59\]
+ _08473_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[5\]$_DFFE_PP_
+ _01793_ clknet_leaf_278_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[5\]
+ _08472_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[60\]$_DFFE_PP_
+ _01794_ clknet_leaf_280_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[60\]
+ _08471_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[61\]$_DFFE_PP_
+ _01795_ clknet_leaf_281_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[61\]
+ _08470_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[62\]$_DFFE_PP_
+ _01796_ clknet_leaf_281_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[62\]
+ _08469_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[63\]$_DFFE_PP_
+ _01797_ clknet_leaf_280_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[63\]
+ _08468_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[6\]$_DFFE_PP_
+ _01798_ clknet_leaf_270_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[6\]
+ _08467_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[7\]$_DFFE_PP_
+ _01799_ clknet_leaf_267_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[7\]
+ _08466_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[8\]$_DFFE_PP_
+ _01800_ clknet_leaf_278_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[8\]
+ _08465_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[0\]\[9\]$_DFFE_PP_
+ _01801_ clknet_leaf_268_clk dynamic_node_top.south_input.NIB.storage_data_f\[0\]\[9\]
+ _08464_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[0\]$_DFFE_PP_
+ _01802_ clknet_leaf_276_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[0\]
+ _08463_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[10\]$_DFFE_PP_
+ _01803_ clknet_leaf_277_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[10\]
+ _08462_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[11\]$_DFFE_PP_
+ _01804_ clknet_leaf_273_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[11\]
+ _08461_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[12\]$_DFFE_PP_
+ _01805_ clknet_leaf_275_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[12\]
+ _08460_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[13\]$_DFFE_PP_
+ _01806_ clknet_leaf_276_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[13\]
+ _08459_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[14\]$_DFFE_PP_
+ _01807_ clknet_leaf_276_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[14\]
+ _08458_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[15\]$_DFFE_PP_
+ _01808_ clknet_leaf_276_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[15\]
+ _08457_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[16\]$_DFFE_PP_
+ _01809_ clknet_leaf_274_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[16\]
+ _08456_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[17\]$_DFFE_PP_
+ _01810_ clknet_leaf_274_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[17\]
+ _08455_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[18\]$_DFFE_PP_
+ _01811_ clknet_leaf_275_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[18\]
+ _08454_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[19\]$_DFFE_PP_
+ _01812_ clknet_leaf_270_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[19\]
+ _08453_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[1\]$_DFFE_PP_
+ _01813_ clknet_leaf_253_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[1\]
+ _08452_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[20\]$_DFFE_PP_
+ _01814_ clknet_leaf_269_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[20\]
+ _08451_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[21\]$_DFFE_PP_
+ _01815_ clknet_leaf_252_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[21\]
+ _08450_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[22\]$_DFFE_PP_
+ _01816_ clknet_leaf_248_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[22\]
+ _08449_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[23\]$_DFFE_PP_
+ _01817_ clknet_leaf_252_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[23\]
+ _08448_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[24\]$_DFFE_PP_
+ _01818_ clknet_leaf_251_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[24\]
+ _08447_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[25\]$_DFFE_PP_
+ _01819_ clknet_leaf_251_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[25\]
+ _08446_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[26\]$_DFFE_PP_
+ _01820_ clknet_leaf_269_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[26\]
+ _08445_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[27\]$_DFFE_PP_
+ _01821_ clknet_leaf_247_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[27\]
+ _08444_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[28\]$_DFFE_PP_
+ _01822_ clknet_leaf_249_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[28\]
+ _08443_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[29\]$_DFFE_PP_
+ _01823_ clknet_leaf_250_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[29\]
+ _08442_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[2\]$_DFFE_PP_
+ _01824_ clknet_leaf_256_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[2\]
+ _08441_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[30\]$_DFFE_PP_
+ _01825_ clknet_leaf_249_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[30\]
+ _08440_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[31\]$_DFFE_PP_
+ _01826_ clknet_leaf_248_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[31\]
+ _08439_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[32\]$_DFFE_PP_
+ _01827_ clknet_leaf_254_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[32\]
+ _08438_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[33\]$_DFFE_PP_
+ _01828_ clknet_leaf_253_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[33\]
+ _08437_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[34\]$_DFFE_PP_
+ _01829_ clknet_leaf_267_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[34\]
+ _08436_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[35\]$_DFFE_PP_
+ _01830_ clknet_leaf_256_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[35\]
+ _08435_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[36\]$_DFFE_PP_
+ _01831_ clknet_leaf_256_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[36\]
+ _08434_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[37\]$_DFFE_PP_
+ _01832_ clknet_leaf_255_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[37\]
+ _08433_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[38\]$_DFFE_PP_
+ _01833_ clknet_leaf_255_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[38\]
+ _08432_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[39\]$_DFFE_PP_
+ _01834_ clknet_leaf_264_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[39\]
+ _08431_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[3\]$_DFFE_PP_
+ _01835_ clknet_leaf_272_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[3\]
+ _08430_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[40\]$_DFFE_PP_
+ _01836_ clknet_leaf_263_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[40\]
+ _08429_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[41\]$_DFFE_PP_
+ _01837_ clknet_leaf_266_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[41\]
+ _08428_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[42\]$_DFFE_PP_
+ _01838_ clknet_leaf_266_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[42\]
+ _08427_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[43\]$_DFFE_PP_
+ _01839_ clknet_leaf_263_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[43\]
+ _08426_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[44\]$_DFFE_PP_
+ _01840_ clknet_leaf_263_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[44\]
+ _08425_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[45\]$_DFFE_PP_
+ _01841_ clknet_leaf_259_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[45\]
+ _08424_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[46\]$_DFFE_PP_
+ _01842_ clknet_leaf_265_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[46\]
+ _08423_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[47\]$_DFFE_PP_
+ _01843_ clknet_leaf_265_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[47\]
+ _08422_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[48\]$_DFFE_PP_
+ _01844_ clknet_leaf_285_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[48\]
+ _08421_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[49\]$_DFFE_PP_
+ _01845_ clknet_leaf_278_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[49\]
+ _08420_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[4\]$_DFFE_PP_
+ _01846_ clknet_leaf_273_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[4\]
+ _08419_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[50\]$_DFFE_PP_
+ _01847_ clknet_leaf_283_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[50\]
+ _08418_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[51\]$_DFFE_PP_
+ _01848_ clknet_leaf_284_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[51\]
+ _08417_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[52\]$_DFFE_PP_
+ _01849_ clknet_leaf_279_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[52\]
+ _08416_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[53\]$_DFFE_PP_
+ _01850_ clknet_leaf_278_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[53\]
+ _08415_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[54\]$_DFFE_PP_
+ _01851_ clknet_leaf_283_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[54\]
+ _08414_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[55\]$_DFFE_PP_
+ _01852_ clknet_leaf_280_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[55\]
+ _08413_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[56\]$_DFFE_PP_
+ _01853_ clknet_leaf_294_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[56\]
+ _08412_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[57\]$_DFFE_PP_
+ _01854_ clknet_leaf_294_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[57\]
+ _08411_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[58\]$_DFFE_PP_
+ _01855_ clknet_leaf_282_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[58\]
+ _08410_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[59\]$_DFFE_PP_
+ _01856_ clknet_leaf_282_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[59\]
+ _08409_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[5\]$_DFFE_PP_
+ _01857_ clknet_leaf_277_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[5\]
+ _08408_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[60\]$_DFFE_PP_
+ _01858_ clknet_leaf_280_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[60\]
+ _08407_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[61\]$_DFFE_PP_
+ _01859_ clknet_leaf_279_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[61\]
+ _08406_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[62\]$_DFFE_PP_
+ _01860_ clknet_leaf_282_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[62\]
+ _08405_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[63\]$_DFFE_PP_
+ _01861_ clknet_leaf_280_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[63\]
+ _08404_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[6\]$_DFFE_PP_
+ _01862_ clknet_leaf_270_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[6\]
+ _08403_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[7\]$_DFFE_PP_
+ _01863_ clknet_leaf_267_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[7\]
+ _08402_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[8\]$_DFFE_PP_
+ _01864_ clknet_leaf_277_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[8\]
+ _08401_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[1\]\[9\]$_DFFE_PP_
+ _01865_ clknet_leaf_268_clk dynamic_node_top.south_input.NIB.storage_data_f\[1\]\[9\]
+ _08400_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[0\]$_DFFE_PP_
+ _01866_ clknet_leaf_275_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[0\]
+ _08399_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[10\]$_DFFE_PP_
+ _01867_ clknet_leaf_273_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[10\]
+ _08398_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[11\]$_DFFE_PP_
+ _01868_ clknet_leaf_272_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[11\]
+ _08397_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[12\]$_DFFE_PP_
+ _01869_ clknet_leaf_271_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[12\]
+ _08396_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[13\]$_DFFE_PP_
+ _01870_ clknet_leaf_272_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[13\]
+ _08395_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[14\]$_DFFE_PP_
+ _01871_ clknet_leaf_275_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[14\]
+ _08394_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[15\]$_DFFE_PP_
+ _01872_ clknet_leaf_274_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[15\]
+ _08393_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[16\]$_DFFE_PP_
+ _01873_ clknet_leaf_272_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[16\]
+ _08392_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[17\]$_DFFE_PP_
+ _01874_ clknet_leaf_272_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[17\]
+ _08391_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[18\]$_DFFE_PP_
+ _01875_ clknet_leaf_271_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[18\]
+ _08390_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[19\]$_DFFE_PP_
+ _01876_ clknet_leaf_270_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[19\]
+ _08389_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[1\]$_DFFE_PP_
+ _01877_ clknet_leaf_253_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[1\]
+ _08388_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[20\]$_DFFE_PP_
+ _01878_ clknet_leaf_268_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[20\]
+ _08387_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[21\]$_DFFE_PP_
+ _01879_ clknet_leaf_252_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[21\]
+ _08386_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[22\]$_DFFE_PP_
+ _01880_ clknet_leaf_247_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[22\]
+ _08385_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[23\]$_DFFE_PP_
+ _01881_ clknet_leaf_252_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[23\]
+ _08384_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[24\]$_DFFE_PP_
+ _01882_ clknet_leaf_250_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[24\]
+ _08383_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[25\]$_DFFE_PP_
+ _01883_ clknet_leaf_251_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[25\]
+ _08382_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[26\]$_DFFE_PP_
+ _01884_ clknet_leaf_269_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[26\]
+ _08381_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[27\]$_DFFE_PP_
+ _01885_ clknet_leaf_247_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[27\]
+ _08380_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[28\]$_DFFE_PP_
+ _01886_ clknet_leaf_250_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[28\]
+ _08379_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[29\]$_DFFE_PP_
+ _01887_ clknet_leaf_250_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[29\]
+ _08378_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[2\]$_DFFE_PP_
+ _01888_ clknet_leaf_254_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[2\]
+ _08377_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[30\]$_DFFE_PP_
+ _01889_ clknet_leaf_249_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[30\]
+ _08376_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[31\]$_DFFE_PP_
+ _01890_ clknet_leaf_248_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[31\]
+ _08375_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[32\]$_DFFE_PP_
+ _01891_ clknet_leaf_254_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[32\]
+ _08374_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[33\]$_DFFE_PP_
+ _01892_ clknet_leaf_254_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[33\]
+ _08373_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[34\]$_DFFE_PP_
+ _01893_ clknet_leaf_255_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[34\]
+ _08372_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[35\]$_DFFE_PP_
+ _01894_ clknet_leaf_257_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[35\]
+ _08371_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[36\]$_DFFE_PP_
+ _01895_ clknet_leaf_256_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[36\]
+ _08370_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[37\]$_DFFE_PP_
+ _01896_ clknet_leaf_255_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[37\]
+ _08369_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[38\]$_DFFE_PP_
+ _01897_ clknet_leaf_259_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[38\]
+ _08368_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[39\]$_DFFE_PP_
+ _01898_ clknet_leaf_264_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[39\]
+ _08367_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[3\]$_DFFE_PP_
+ _01899_ clknet_leaf_266_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[3\]
+ _08366_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[40\]$_DFFE_PP_
+ _01900_ clknet_leaf_259_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[40\]
+ _08365_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[41\]$_DFFE_PP_
+ _01901_ clknet_leaf_266_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[41\]
+ _08364_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[42\]$_DFFE_PP_
+ _01902_ clknet_leaf_267_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[42\]
+ _08363_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[43\]$_DFFE_PP_
+ _01903_ clknet_leaf_264_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[43\]
+ _08362_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[44\]$_DFFE_PP_
+ _01904_ clknet_leaf_263_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[44\]
+ _08361_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[45\]$_DFFE_PP_
+ _01905_ clknet_leaf_258_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[45\]
+ _08360_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[46\]$_DFFE_PP_
+ _01906_ clknet_leaf_285_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[46\]
+ _08359_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[47\]$_DFFE_PP_
+ _01907_ clknet_leaf_264_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[47\]
+ _08358_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[48\]$_DFFE_PP_
+ _01908_ clknet_leaf_285_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[48\]
+ _08357_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[49\]$_DFFE_PP_
+ _01909_ clknet_leaf_265_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[49\]
+ _08356_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[4\]$_DFFE_PP_
+ _01910_ clknet_leaf_273_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[4\]
+ _08355_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[50\]$_DFFE_PP_
+ _01911_ clknet_leaf_283_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[50\]
+ _08354_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[51\]$_DFFE_PP_
+ _01912_ clknet_leaf_284_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[51\]
+ _08353_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[52\]$_DFFE_PP_
+ _01913_ clknet_leaf_284_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[52\]
+ _08352_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[53\]$_DFFE_PP_
+ _01914_ clknet_leaf_284_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[53\]
+ _08351_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[54\]$_DFFE_PP_
+ _01915_ clknet_leaf_283_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[54\]
+ _08350_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[55\]$_DFFE_PP_
+ _01916_ clknet_leaf_281_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[55\]
+ _08349_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[56\]$_DFFE_PP_
+ _01917_ clknet_leaf_294_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[56\]
+ _08348_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[57\]$_DFFE_PP_
+ _01918_ clknet_leaf_293_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[57\]
+ _08347_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[58\]$_DFFE_PP_
+ _01919_ clknet_leaf_281_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[58\]
+ _08346_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[59\]$_DFFE_PP_
+ _01920_ clknet_leaf_282_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[59\]
+ _08345_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[5\]$_DFFE_PP_
+ _01921_ clknet_leaf_278_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[5\]
+ _08344_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[60\]$_DFFE_PP_
+ _01922_ clknet_leaf_280_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[60\]
+ _08343_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[61\]$_DFFE_PP_
+ _01923_ clknet_leaf_279_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[61\]
+ _08342_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[62\]$_DFFE_PP_
+ _01924_ clknet_leaf_281_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[62\]
+ _08341_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[63\]$_DFFE_PP_
+ _01925_ clknet_leaf_279_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[63\]
+ _08340_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[6\]$_DFFE_PP_
+ _01926_ clknet_leaf_270_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[6\]
+ _08339_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[7\]$_DFFE_PP_
+ _01927_ clknet_leaf_267_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[7\]
+ _08338_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[8\]$_DFFE_PP_
+ _01928_ clknet_leaf_278_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[8\]
+ _08337_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[2\]\[9\]$_DFFE_PP_
+ _01929_ clknet_leaf_268_clk dynamic_node_top.south_input.NIB.storage_data_f\[2\]\[9\]
+ _08336_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[0\]$_DFFE_PP_
+ _01930_ clknet_leaf_277_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[0\]
+ _08335_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[10\]$_DFFE_PP_
+ _01931_ clknet_leaf_274_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[10\]
+ _08334_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[11\]$_DFFE_PP_
+ _01932_ clknet_leaf_273_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[11\]
+ _08333_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[12\]$_DFFE_PP_
+ _01933_ clknet_leaf_275_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[12\]
+ _08332_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[13\]$_DFFE_PP_
+ _01934_ clknet_leaf_276_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[13\]
+ _08331_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[14\]$_DFFE_PP_
+ _01935_ clknet_leaf_276_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[14\]
+ _08330_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[15\]$_DFFE_PP_
+ _01936_ clknet_leaf_276_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[15\]
+ _08329_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[16\]$_DFFE_PP_
+ _01937_ clknet_leaf_274_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[16\]
+ _08328_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[17\]$_DFFE_PP_
+ _01938_ clknet_leaf_274_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[17\]
+ _08327_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[18\]$_DFFE_PP_
+ _01939_ clknet_leaf_275_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[18\]
+ _08326_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[19\]$_DFFE_PP_
+ _01940_ clknet_leaf_269_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[19\]
+ _08325_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[1\]$_DFFE_PP_
+ _01941_ clknet_leaf_253_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[1\]
+ _08324_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[20\]$_DFFE_PP_
+ _01942_ clknet_leaf_269_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[20\]
+ _08323_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[21\]$_DFFE_PP_
+ _01943_ clknet_leaf_251_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[21\]
+ _08322_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[22\]$_DFFE_PP_
+ _01944_ clknet_leaf_248_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[22\]
+ _08321_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[23\]$_DFFE_PP_
+ _01945_ clknet_leaf_251_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[23\]
+ _08320_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[24\]$_DFFE_PP_
+ _01946_ clknet_leaf_251_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[24\]
+ _08319_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[25\]$_DFFE_PP_
+ _01947_ clknet_leaf_247_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[25\]
+ _08318_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[26\]$_DFFE_PP_
+ _01948_ clknet_leaf_253_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[26\]
+ _08317_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[27\]$_DFFE_PP_
+ _01949_ clknet_leaf_247_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[27\]
+ _08316_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[28\]$_DFFE_PP_
+ _01950_ clknet_leaf_248_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[28\]
+ _08315_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[29\]$_DFFE_PP_
+ _01951_ clknet_leaf_250_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[29\]
+ _08314_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[2\]$_DFFE_PP_
+ _01952_ clknet_leaf_256_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[2\]
+ _08313_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[30\]$_DFFE_PP_
+ _01953_ clknet_leaf_249_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[30\]
+ _08312_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[31\]$_DFFE_PP_
+ _01954_ clknet_leaf_248_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[31\]
+ _08311_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[32\]$_DFFE_PP_
+ _01955_ clknet_leaf_252_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[32\]
+ _08310_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[33\]$_DFFE_PP_
+ _01956_ clknet_leaf_253_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[33\]
+ _08309_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[34\]$_DFFE_PP_
+ _01957_ clknet_leaf_267_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[34\]
+ _08308_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[35\]$_DFFE_PP_
+ _01958_ clknet_leaf_257_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[35\]
+ _08307_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[36\]$_DFFE_PP_
+ _01959_ clknet_leaf_256_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[36\]
+ _08306_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[37\]$_DFFE_PP_
+ _01960_ clknet_leaf_255_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[37\]
+ _08305_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[38\]$_DFFE_PP_
+ _01961_ clknet_leaf_255_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[38\]
+ _08304_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[39\]$_DFFE_PP_
+ _01962_ clknet_leaf_264_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[39\]
+ _08303_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[3\]$_DFFE_PP_
+ _01963_ clknet_leaf_268_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[3\]
+ _08302_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[40\]$_DFFE_PP_
+ _01964_ clknet_leaf_259_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[40\]
+ _08301_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[41\]$_DFFE_PP_
+ _01965_ clknet_leaf_266_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[41\]
+ _08300_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[42\]$_DFFE_PP_
+ _01966_ clknet_leaf_266_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[42\]
+ _08299_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[43\]$_DFFE_PP_
+ _01967_ clknet_leaf_263_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[43\]
+ _08298_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[44\]$_DFFE_PP_
+ _01968_ clknet_leaf_263_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[44\]
+ _08297_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[45\]$_DFFE_PP_
+ _01969_ clknet_leaf_259_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[45\]
+ _08296_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[46\]$_DFFE_PP_
+ _01970_ clknet_leaf_265_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[46\]
+ _08295_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[47\]$_DFFE_PP_
+ _01971_ clknet_leaf_265_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[47\]
+ _08294_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[48\]$_DFFE_PP_
+ _01972_ clknet_leaf_286_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[48\]
+ _08293_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[49\]$_DFFE_PP_
+ _01973_ clknet_leaf_278_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[49\]
+ _08292_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[4\]$_DFFE_PP_
+ _01974_ clknet_leaf_273_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[4\]
+ _08291_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[50\]$_DFFE_PP_
+ _01975_ clknet_leaf_283_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[50\]
+ _08290_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[51\]$_DFFE_PP_
+ _01976_ clknet_leaf_285_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[51\]
+ _08289_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[52\]$_DFFE_PP_
+ _01977_ clknet_leaf_279_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[52\]
+ _08288_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[53\]$_DFFE_PP_
+ _01978_ clknet_leaf_279_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[53\]
+ _08287_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[54\]$_DFFE_PP_
+ _01979_ clknet_leaf_283_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[54\]
+ _08286_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[55\]$_DFFE_PP_
+ _01980_ clknet_leaf_280_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[55\]
+ _08285_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[56\]$_DFFE_PP_
+ _01981_ clknet_leaf_294_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[56\]
+ _08284_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[57\]$_DFFE_PP_
+ _01982_ clknet_leaf_294_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[57\]
+ _08283_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[58\]$_DFFE_PP_
+ _01983_ clknet_leaf_281_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[58\]
+ _08282_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[59\]$_DFFE_PP_
+ _01984_ clknet_leaf_282_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[59\]
+ _08281_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[5\]$_DFFE_PP_
+ _01985_ clknet_leaf_277_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[5\]
+ _08280_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[60\]$_DFFE_PP_
+ _01986_ clknet_leaf_277_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[60\]
+ _08279_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[61\]$_DFFE_PP_
+ _01987_ clknet_leaf_279_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[61\]
+ _08278_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[62\]$_DFFE_PP_
+ _01988_ clknet_leaf_282_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[62\]
+ _08277_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[63\]$_DFFE_PP_
+ _01989_ clknet_leaf_280_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[63\]
+ _08276_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[6\]$_DFFE_PP_
+ _01990_ clknet_leaf_270_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[6\]
+ _08275_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[7\]$_DFFE_PP_
+ _01991_ clknet_leaf_267_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[7\]
+ _08274_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[8\]$_DFFE_PP_
+ _01992_ clknet_leaf_277_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[8\]
+ _08273_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.storage_data_f\[3\]\[9\]$_DFFE_PP_
+ _01993_ clknet_leaf_268_clk dynamic_node_top.south_input.NIB.storage_data_f\[3\]\[9\]
+ _08272_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.tail_ptr_f\[0\]$_SDFFE_PP0N_
+ _01994_ clknet_leaf_292_clk dynamic_node_top.south_input.NIB.tail_ptr_f\[0\]
+ dynamic_node_top.south_input.NIB.tail_ptr_next\[0\] VDD VSS
+ DFF_X1
Xdynamic_node_top.south_input.NIB.tail_ptr_f\[1\]$_SDFFE_PP0N_
+ _01995_ clknet_leaf_293_clk dynamic_node_top.south_input.NIB.tail_ptr_f\[1\]
+ _10601_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.NIB.yummy_out_f$_SDFF_PP0_ _01996_
+ clknet_leaf_154_clk net629 _08271_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.count_f\[0\]$_SDFF_PP0_
+ _01997_ clknet_leaf_142_clk dynamic_node_top.south_input.control.count_f\[0\]
+ _10513_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.count_f\[1\]$_SDFF_PP0_
+ _01998_ clknet_leaf_142_clk dynamic_node_top.south_input.control.count_f\[1\]
+ _10514_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.count_f\[2\]$_SDFF_PP0_
+ _01999_ clknet_leaf_140_clk dynamic_node_top.south_input.control.count_f\[2\]
+ _08270_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.count_f\[3\]$_SDFF_PP0_
+ _02000_ clknet_leaf_140_clk dynamic_node_top.south_input.control.count_f\[3\]
+ _08269_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.count_f\[4\]$_SDFF_PP0_
+ _02001_ clknet_leaf_140_clk dynamic_node_top.south_input.control.count_f\[4\]
+ _08268_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.count_f\[5\]$_SDFF_PP0_
+ _02002_ clknet_leaf_141_clk dynamic_node_top.south_input.control.count_f\[5\]
+ _08267_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.count_f\[6\]$_SDFF_PP0_
+ _02003_ clknet_leaf_141_clk dynamic_node_top.south_input.control.count_f\[6\]
+ _08266_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.count_f\[7\]$_SDFF_PP0_
+ _02004_ clknet_leaf_141_clk dynamic_node_top.south_input.control.count_f\[7\]
+ _08265_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.count_one_f$_SDFF_PP0_
+ _02005_ clknet_leaf_158_clk dynamic_node_top.south_input.control.count_one_f
+ _10158_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.header_temp$_DFF_P_
+ _00003_ clknet_leaf_142_clk dynamic_node_top.south_input.control.header_last_temp
+ _08264_ VDD VSS DFF_X1
Xdynamic_node_top.south_input.control.tail_last_f$_SDFF_PP0_
+ _02006_ clknet_leaf_158_clk dynamic_node_top.south_input.control.tail_last_f
+ _10159_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.control.current_route_f\[0\]$_DFF_P_
+ _00027_ clknet_leaf_157_clk dynamic_node_top.south_output.control.current_route_f\[0\]
+ _00048_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.control.current_route_f\[1\]$_DFF_P_
+ _00028_ clknet_leaf_157_clk dynamic_node_top.south_output.control.current_route_f\[1\]
+ _00047_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.control.current_route_f\[2\]$_DFF_P_
+ _00029_ clknet_leaf_160_clk dynamic_node_top.south_output.control.current_route_f\[2\]
+ _00069_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.control.current_route_f\[3\]$_DFF_P_
+ _00030_ clknet_leaf_160_clk dynamic_node_top.south_output.control.current_route_f\[3\]
+ _00070_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.control.current_route_f\[4\]$_DFF_P_
+ _00031_ clknet_leaf_162_clk dynamic_node_top.south_output.control.current_route_f\[4\]
+ _00068_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.control.planned_f$_SDFF_PP0_
+ _02007_ clknet_leaf_163_clk dynamic_node_top.south_output.control.planned_f
+ _00049_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.space.count_f\[0\]$_SDFF_PP0_
+ _02008_ clknet_leaf_165_clk dynamic_node_top.south_output.space.count_f\[0\]
+ _10489_ VDD VSS DFF_X2
Xdynamic_node_top.south_output.space.count_f\[1\]$_SDFF_PP0_
+ _02009_ clknet_leaf_166_clk dynamic_node_top.south_output.space.count_f\[1\]
+ _10490_ VDD VSS DFF_X2
Xdynamic_node_top.south_output.space.count_f\[2\]$_SDFF_PP1_
+ _02010_ clknet_leaf_166_clk dynamic_node_top.south_output.space.count_f\[2\]
+ _00059_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.space.is_one_f$_SDFF_PP0_ _02011_
+ clknet_leaf_165_clk dynamic_node_top.south_output.space.is_one_f
+ _08263_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.space.is_two_or_more_f$_SDFF_PP1_
+ _02012_ clknet_leaf_165_clk dynamic_node_top.south_output.space.is_two_or_more_f
+ _08262_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.space.valid_f$_SDFF_PP0_ _02013_
+ clknet_leaf_165_clk dynamic_node_top.south_output.space.valid_f
+ _10486_ VDD VSS DFF_X1
Xdynamic_node_top.south_output.space.yummy_f$_SDFF_PP0_ _02014_
+ clknet_leaf_165_clk dynamic_node_top.south_output.space.yummy_f
+ _10483_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.elements_in_array_f\[0\]$_SDFFE_PP0N_
+ _02015_ clknet_leaf_167_clk dynamic_node_top.west_input.NIB.elements_in_array_f\[0\]
+ dynamic_node_top.west_input.NIB.elements_in_array_next\[0\]
+ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.elements_in_array_f\[1\]$_SDFFE_PP0N_
+ _02016_ clknet_leaf_167_clk dynamic_node_top.west_input.NIB.elements_in_array_f\[1\]
+ _08261_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.elements_in_array_f\[2\]$_SDFFE_PP0N_
+ _02017_ clknet_leaf_165_clk dynamic_node_top.west_input.NIB.elements_in_array_f\[2\]
+ _08260_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.head_ptr_f\[0\]$_SDFFE_PP0N_
+ _02018_ clknet_leaf_167_clk dynamic_node_top.west_input.NIB.head_ptr_f\[0\]
+ dynamic_node_top.west_input.NIB.head_ptr_next\[0\] VDD VSS
+ DFF_X1
Xdynamic_node_top.west_input.NIB.head_ptr_f\[1\]$_SDFFE_PP0N_
+ _00078_ clknet_leaf_175_clk dynamic_node_top.west_input.NIB.head_ptr_f\[1\]
+ _08259_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[0\]$_DFFE_PP_
+ _02019_ clknet_leaf_220_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[0\]
+ _08258_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[10\]$_DFFE_PP_
+ _02020_ clknet_leaf_224_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[10\]
+ _08257_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[11\]$_DFFE_PP_
+ _02021_ clknet_leaf_225_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[11\]
+ _08256_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[12\]$_DFFE_PP_
+ _02022_ clknet_leaf_219_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[12\]
+ _08255_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[13\]$_DFFE_PP_
+ _02023_ clknet_leaf_226_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[13\]
+ _08254_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[14\]$_DFFE_PP_
+ _02024_ clknet_leaf_220_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[14\]
+ _08253_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[15\]$_DFFE_PP_
+ _02025_ clknet_leaf_224_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[15\]
+ _08252_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[16\]$_DFFE_PP_
+ _02026_ clknet_leaf_223_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[16\]
+ _08251_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[17\]$_DFFE_PP_
+ _02027_ clknet_leaf_218_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[17\]
+ _08250_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[18\]$_DFFE_PP_
+ _02028_ clknet_leaf_219_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[18\]
+ _08249_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[19\]$_DFFE_PP_
+ _02029_ clknet_leaf_188_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[19\]
+ _08248_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[1\]$_DFFE_PP_
+ _02030_ clknet_leaf_189_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[1\]
+ _08247_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[20\]$_DFFE_PP_
+ _02031_ clknet_leaf_189_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[20\]
+ _08246_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[21\]$_DFFE_PP_
+ _02032_ clknet_leaf_188_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[21\]
+ _08245_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[22\]$_DFFE_PP_
+ _02033_ clknet_leaf_166_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[22\]
+ _08244_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[23\]$_DFFE_PP_
+ _02034_ clknet_leaf_168_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[23\]
+ _08243_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[24\]$_DFFE_PP_
+ _02035_ clknet_leaf_166_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[24\]
+ _08242_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[25\]$_DFFE_PP_
+ _02036_ clknet_leaf_169_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[25\]
+ _08241_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[26\]$_DFFE_PP_
+ _02037_ clknet_leaf_170_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[26\]
+ _08240_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[27\]$_DFFE_PP_
+ _02038_ clknet_leaf_169_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[27\]
+ _08239_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[28\]$_DFFE_PP_
+ _02039_ clknet_leaf_172_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[28\]
+ _08238_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[29\]$_DFFE_PP_
+ _02040_ clknet_leaf_171_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[29\]
+ _08237_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[2\]$_DFFE_PP_
+ _02041_ clknet_leaf_187_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[2\]
+ _08236_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[30\]$_DFFE_PP_
+ _02042_ clknet_leaf_171_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[30\]
+ _08235_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[31\]$_DFFE_PP_
+ _02043_ clknet_leaf_173_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[31\]
+ _08234_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[32\]$_DFFE_PP_
+ _02044_ clknet_leaf_173_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[32\]
+ _08233_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[33\]$_DFFE_PP_
+ _02045_ clknet_leaf_187_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[33\]
+ _08232_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[34\]$_DFFE_PP_
+ _02046_ clknet_leaf_173_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[34\]
+ _08231_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[35\]$_DFFE_PP_
+ _02047_ clknet_leaf_181_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[35\]
+ _08230_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[36\]$_DFFE_PP_
+ _02048_ clknet_leaf_181_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[36\]
+ _08229_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[37\]$_DFFE_PP_
+ _02049_ clknet_leaf_180_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[37\]
+ _08228_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[38\]$_DFFE_PP_
+ _02050_ clknet_leaf_179_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[38\]
+ _08227_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[39\]$_DFFE_PP_
+ _02051_ clknet_leaf_179_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[39\]
+ _08226_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[3\]$_DFFE_PP_
+ _02052_ clknet_leaf_186_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[3\]
+ _08225_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[40\]$_DFFE_PP_
+ _02053_ clknet_leaf_179_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[40\]
+ _08224_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[41\]$_DFFE_PP_
+ _02054_ clknet_leaf_185_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[41\]
+ _08223_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[42\]$_DFFE_PP_
+ _02055_ clknet_leaf_184_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[42\]
+ _08222_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[43\]$_DFFE_PP_
+ _02056_ clknet_leaf_183_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[43\]
+ _08221_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[44\]$_DFFE_PP_
+ _02057_ clknet_leaf_181_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[44\]
+ _08220_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[45\]$_DFFE_PP_
+ _02058_ clknet_leaf_182_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[45\]
+ _08219_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[46\]$_DFFE_PP_
+ _02059_ clknet_leaf_184_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[46\]
+ _08218_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[47\]$_DFFE_PP_
+ _02060_ clknet_leaf_184_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[47\]
+ _08217_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[48\]$_DFFE_PP_
+ _02061_ clknet_leaf_184_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[48\]
+ _08216_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[49\]$_DFFE_PP_
+ _02062_ clknet_leaf_192_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[49\]
+ _08215_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[4\]$_DFFE_PP_
+ _02063_ clknet_leaf_191_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[4\]
+ _08214_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[50\]$_DFFE_PP_
+ _02064_ clknet_leaf_193_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[50\]
+ _08213_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[51\]$_DFFE_PP_
+ _02065_ clknet_leaf_196_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[51\]
+ _08212_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[52\]$_DFFE_PP_
+ _02066_ clknet_leaf_193_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[52\]
+ _08211_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[53\]$_DFFE_PP_
+ _02067_ clknet_leaf_191_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[53\]
+ _08210_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[54\]$_DFFE_PP_
+ _02068_ clknet_leaf_195_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[54\]
+ _08209_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[55\]$_DFFE_PP_
+ _02069_ clknet_leaf_214_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[55\]
+ _08208_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[56\]$_DFFE_PP_
+ _02070_ clknet_leaf_211_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[56\]
+ _08207_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[57\]$_DFFE_PP_
+ _02071_ clknet_leaf_194_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[57\]
+ _08206_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[58\]$_DFFE_PP_
+ _02072_ clknet_leaf_214_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[58\]
+ _08205_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[59\]$_DFFE_PP_
+ _02073_ clknet_leaf_211_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[59\]
+ _08204_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[5\]$_DFFE_PP_
+ _02074_ clknet_leaf_216_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[5\]
+ _08203_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[60\]$_DFFE_PP_
+ _02075_ clknet_leaf_190_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[60\]
+ _08202_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[61\]$_DFFE_PP_
+ _02076_ clknet_leaf_194_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[61\]
+ _08201_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[62\]$_DFFE_PP_
+ _02077_ clknet_leaf_215_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[62\]
+ _08200_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[63\]$_DFFE_PP_
+ _02078_ clknet_leaf_211_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[63\]
+ _08199_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[6\]$_DFFE_PP_
+ _02079_ clknet_leaf_217_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[6\]
+ _08198_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[7\]$_DFFE_PP_
+ _02080_ clknet_leaf_216_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[7\]
+ _08197_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[8\]$_DFFE_PP_
+ _02081_ clknet_leaf_217_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[8\]
+ _08196_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[0\]\[9\]$_DFFE_PP_
+ _02082_ clknet_leaf_218_clk dynamic_node_top.west_input.NIB.storage_data_f\[0\]\[9\]
+ _08195_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[0\]$_DFFE_PP_
+ _02083_ clknet_leaf_221_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[0\]
+ _08194_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[10\]$_DFFE_PP_
+ _02084_ clknet_leaf_224_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[10\]
+ _08193_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[11\]$_DFFE_PP_
+ _02085_ clknet_leaf_225_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[11\]
+ _08192_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[12\]$_DFFE_PP_
+ _02086_ clknet_leaf_219_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[12\]
+ _08191_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[13\]$_DFFE_PP_
+ _02087_ clknet_leaf_225_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[13\]
+ _08190_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[14\]$_DFFE_PP_
+ _02088_ clknet_leaf_220_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[14\]
+ _08189_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[15\]$_DFFE_PP_
+ _02089_ clknet_leaf_223_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[15\]
+ _08188_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[16\]$_DFFE_PP_
+ _02090_ clknet_leaf_223_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[16\]
+ _08187_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[17\]$_DFFE_PP_
+ _02091_ clknet_leaf_223_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[17\]
+ _08186_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[18\]$_DFFE_PP_
+ _02092_ clknet_leaf_219_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[18\]
+ _08185_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[19\]$_DFFE_PP_
+ _02093_ clknet_leaf_188_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[19\]
+ _08184_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[1\]$_DFFE_PP_
+ _02094_ clknet_leaf_216_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[1\]
+ _08183_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[20\]$_DFFE_PP_
+ _02095_ clknet_leaf_188_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[20\]
+ _08182_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[21\]$_DFFE_PP_
+ _02096_ clknet_leaf_189_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[21\]
+ _08181_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[22\]$_DFFE_PP_
+ _02097_ clknet_leaf_168_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[22\]
+ _08180_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[23\]$_DFFE_PP_
+ _02098_ clknet_leaf_168_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[23\]
+ _08179_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[24\]$_DFFE_PP_
+ _02099_ clknet_leaf_167_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[24\]
+ _08178_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[25\]$_DFFE_PP_
+ _02100_ clknet_leaf_169_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[25\]
+ _08177_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[26\]$_DFFE_PP_
+ _02101_ clknet_leaf_168_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[26\]
+ _08176_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[27\]$_DFFE_PP_
+ _02102_ clknet_leaf_170_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[27\]
+ _08175_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[28\]$_DFFE_PP_
+ _02103_ clknet_leaf_172_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[28\]
+ _08174_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[29\]$_DFFE_PP_
+ _02104_ clknet_leaf_171_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[29\]
+ _08173_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[2\]$_DFFE_PP_
+ _02105_ clknet_leaf_186_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[2\]
+ _08172_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[30\]$_DFFE_PP_
+ _02106_ clknet_leaf_170_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[30\]
+ _08171_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[31\]$_DFFE_PP_
+ _02107_ clknet_leaf_170_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[31\]
+ _08170_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[32\]$_DFFE_PP_
+ _02108_ clknet_leaf_173_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[32\]
+ _08169_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[33\]$_DFFE_PP_
+ _02109_ clknet_leaf_187_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[33\]
+ _08168_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[34\]$_DFFE_PP_
+ _02110_ clknet_leaf_172_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[34\]
+ _08167_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[35\]$_DFFE_PP_
+ _02111_ clknet_leaf_181_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[35\]
+ _08166_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[36\]$_DFFE_PP_
+ _02112_ clknet_leaf_182_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[36\]
+ _08165_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[37\]$_DFFE_PP_
+ _02113_ clknet_leaf_180_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[37\]
+ _08164_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[38\]$_DFFE_PP_
+ _02114_ clknet_leaf_179_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[38\]
+ _08163_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[39\]$_DFFE_PP_
+ _02115_ clknet_leaf_180_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[39\]
+ _08162_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[3\]$_DFFE_PP_
+ _02116_ clknet_leaf_186_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[3\]
+ _08161_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[40\]$_DFFE_PP_
+ _02117_ clknet_leaf_179_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[40\]
+ _08160_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[41\]$_DFFE_PP_
+ _02118_ clknet_leaf_186_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[41\]
+ _08159_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[42\]$_DFFE_PP_
+ _02119_ clknet_leaf_184_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[42\]
+ _08158_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[43\]$_DFFE_PP_
+ _02120_ clknet_leaf_183_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[43\]
+ _08157_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[44\]$_DFFE_PP_
+ _02121_ clknet_leaf_182_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[44\]
+ _08156_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[45\]$_DFFE_PP_
+ _02122_ clknet_leaf_182_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[45\]
+ _08155_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[46\]$_DFFE_PP_
+ _02123_ clknet_leaf_178_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[46\]
+ _08154_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[47\]$_DFFE_PP_
+ _02124_ clknet_leaf_178_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[47\]
+ _08153_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[48\]$_DFFE_PP_
+ _02125_ clknet_leaf_185_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[48\]
+ _08152_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[49\]$_DFFE_PP_
+ _02126_ clknet_leaf_192_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[49\]
+ _08151_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[4\]$_DFFE_PP_
+ _02127_ clknet_leaf_191_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[4\]
+ _08150_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[50\]$_DFFE_PP_
+ _02128_ clknet_leaf_193_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[50\]
+ _08149_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[51\]$_DFFE_PP_
+ _02129_ clknet_leaf_195_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[51\]
+ _08148_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[52\]$_DFFE_PP_
+ _02130_ clknet_leaf_192_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[52\]
+ _08147_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[53\]$_DFFE_PP_
+ _02131_ clknet_leaf_191_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[53\]
+ _08146_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[54\]$_DFFE_PP_
+ _02132_ clknet_leaf_194_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[54\]
+ _08145_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[55\]$_DFFE_PP_
+ _02133_ clknet_leaf_214_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[55\]
+ _08144_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[56\]$_DFFE_PP_
+ _02134_ clknet_leaf_215_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[56\]
+ _08143_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[57\]$_DFFE_PP_
+ _02135_ clknet_leaf_190_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[57\]
+ _08142_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[58\]$_DFFE_PP_
+ _02136_ clknet_leaf_211_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[58\]
+ _08141_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[59\]$_DFFE_PP_
+ _02137_ clknet_leaf_210_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[59\]
+ _08140_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[5\]$_DFFE_PP_
+ _02138_ clknet_leaf_215_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[5\]
+ _08139_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[60\]$_DFFE_PP_
+ _02139_ clknet_leaf_190_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[60\]
+ _08138_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[61\]$_DFFE_PP_
+ _02140_ clknet_leaf_195_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[61\]
+ _08137_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[62\]$_DFFE_PP_
+ _02141_ clknet_leaf_215_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[62\]
+ _08136_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[63\]$_DFFE_PP_
+ _02142_ clknet_leaf_212_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[63\]
+ _08135_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[6\]$_DFFE_PP_
+ _02143_ clknet_leaf_218_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[6\]
+ _08134_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[7\]$_DFFE_PP_
+ _02144_ clknet_leaf_220_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[7\]
+ _08133_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[8\]$_DFFE_PP_
+ _02145_ clknet_leaf_217_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[8\]
+ _08132_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[1\]\[9\]$_DFFE_PP_
+ _02146_ clknet_leaf_218_clk dynamic_node_top.west_input.NIB.storage_data_f\[1\]\[9\]
+ _08131_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[0\]$_DFFE_PP_
+ _02147_ clknet_leaf_220_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[0\]
+ _08130_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[10\]$_DFFE_PP_
+ _02148_ clknet_leaf_224_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[10\]
+ _08129_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[11\]$_DFFE_PP_
+ _02149_ clknet_leaf_225_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[11\]
+ _08128_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[12\]$_DFFE_PP_
+ _02150_ clknet_leaf_219_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[12\]
+ _08127_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[13\]$_DFFE_PP_
+ _02151_ clknet_leaf_226_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[13\]
+ _08126_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[14\]$_DFFE_PP_
+ _02152_ clknet_leaf_220_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[14\]
+ _08125_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[15\]$_DFFE_PP_
+ _02153_ clknet_leaf_224_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[15\]
+ _08124_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[16\]$_DFFE_PP_
+ _02154_ clknet_leaf_224_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[16\]
+ _08123_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[17\]$_DFFE_PP_
+ _02155_ clknet_leaf_218_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[17\]
+ _08122_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[18\]$_DFFE_PP_
+ _02156_ clknet_leaf_219_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[18\]
+ _08121_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[19\]$_DFFE_PP_
+ _02157_ clknet_leaf_188_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[19\]
+ _08120_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[1\]$_DFFE_PP_
+ _02158_ clknet_leaf_189_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[1\]
+ _08119_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[20\]$_DFFE_PP_
+ _02159_ clknet_leaf_189_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[20\]
+ _08118_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[21\]$_DFFE_PP_
+ _02160_ clknet_leaf_188_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[21\]
+ _08117_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[22\]$_DFFE_PP_
+ _02161_ clknet_leaf_166_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[22\]
+ _08116_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[23\]$_DFFE_PP_
+ _02162_ clknet_leaf_168_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[23\]
+ _08115_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[24\]$_DFFE_PP_
+ _02163_ clknet_leaf_166_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[24\]
+ _08114_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[25\]$_DFFE_PP_
+ _02164_ clknet_leaf_169_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[25\]
+ _08113_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[26\]$_DFFE_PP_
+ _02165_ clknet_leaf_170_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[26\]
+ _08112_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[27\]$_DFFE_PP_
+ _02166_ clknet_leaf_170_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[27\]
+ _08111_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[28\]$_DFFE_PP_
+ _02167_ clknet_leaf_172_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[28\]
+ _08110_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[29\]$_DFFE_PP_
+ _02168_ clknet_leaf_171_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[29\]
+ _08109_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[2\]$_DFFE_PP_
+ _02169_ clknet_leaf_187_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[2\]
+ _08108_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[30\]$_DFFE_PP_
+ _02170_ clknet_leaf_170_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[30\]
+ _08107_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[31\]$_DFFE_PP_
+ _02171_ clknet_leaf_174_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[31\]
+ _08106_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[32\]$_DFFE_PP_
+ _02172_ clknet_leaf_172_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[32\]
+ _08105_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[33\]$_DFFE_PP_
+ _02173_ clknet_leaf_187_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[33\]
+ _08104_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[34\]$_DFFE_PP_
+ _02174_ clknet_leaf_173_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[34\]
+ _08103_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[35\]$_DFFE_PP_
+ _02175_ clknet_leaf_181_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[35\]
+ _08102_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[36\]$_DFFE_PP_
+ _02176_ clknet_leaf_181_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[36\]
+ _08101_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[37\]$_DFFE_PP_
+ _02177_ clknet_leaf_181_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[37\]
+ _08100_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[38\]$_DFFE_PP_
+ _02178_ clknet_leaf_179_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[38\]
+ _08099_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[39\]$_DFFE_PP_
+ _02179_ clknet_leaf_180_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[39\]
+ _08098_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[3\]$_DFFE_PP_
+ _02180_ clknet_leaf_186_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[3\]
+ _08097_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[40\]$_DFFE_PP_
+ _02181_ clknet_leaf_179_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[40\]
+ _08096_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[41\]$_DFFE_PP_
+ _02182_ clknet_leaf_185_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[41\]
+ _08095_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[42\]$_DFFE_PP_
+ _02183_ clknet_leaf_183_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[42\]
+ _08094_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[43\]$_DFFE_PP_
+ _02184_ clknet_leaf_183_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[43\]
+ _08093_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[44\]$_DFFE_PP_
+ _02185_ clknet_leaf_182_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[44\]
+ _08092_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[45\]$_DFFE_PP_
+ _02186_ clknet_leaf_183_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[45\]
+ _08091_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[46\]$_DFFE_PP_
+ _02187_ clknet_leaf_178_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[46\]
+ _08090_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[47\]$_DFFE_PP_
+ _02188_ clknet_leaf_184_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[47\]
+ _08089_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[48\]$_DFFE_PP_
+ _02189_ clknet_leaf_184_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[48\]
+ _08088_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[49\]$_DFFE_PP_
+ _02190_ clknet_leaf_185_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[49\]
+ _08087_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[4\]$_DFFE_PP_
+ _02191_ clknet_leaf_189_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[4\]
+ _08086_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[50\]$_DFFE_PP_
+ _02192_ clknet_leaf_193_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[50\]
+ _08085_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[51\]$_DFFE_PP_
+ _02193_ clknet_leaf_177_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[51\]
+ _08084_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[52\]$_DFFE_PP_
+ _02194_ clknet_leaf_192_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[52\]
+ _08083_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[53\]$_DFFE_PP_
+ _02195_ clknet_leaf_191_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[53\]
+ _08082_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[54\]$_DFFE_PP_
+ _02196_ clknet_leaf_195_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[54\]
+ _08081_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[55\]$_DFFE_PP_
+ _02197_ clknet_leaf_214_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[55\]
+ _08080_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[56\]$_DFFE_PP_
+ _02198_ clknet_leaf_211_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[56\]
+ _08079_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[57\]$_DFFE_PP_
+ _02199_ clknet_leaf_194_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[57\]
+ _08078_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[58\]$_DFFE_PP_
+ _02200_ clknet_leaf_213_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[58\]
+ _08077_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[59\]$_DFFE_PP_
+ _02201_ clknet_leaf_211_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[59\]
+ _08076_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[5\]$_DFFE_PP_
+ _02202_ clknet_leaf_216_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[5\]
+ _08075_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[60\]$_DFFE_PP_
+ _02203_ clknet_leaf_190_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[60\]
+ _08074_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[61\]$_DFFE_PP_
+ _02204_ clknet_leaf_194_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[61\]
+ _08073_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[62\]$_DFFE_PP_
+ _02205_ clknet_leaf_215_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[62\]
+ _08072_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[63\]$_DFFE_PP_
+ _02206_ clknet_leaf_211_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[63\]
+ _08071_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[6\]$_DFFE_PP_
+ _02207_ clknet_leaf_217_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[6\]
+ _08070_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[7\]$_DFFE_PP_
+ _02208_ clknet_leaf_220_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[7\]
+ _08069_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[8\]$_DFFE_PP_
+ _02209_ clknet_leaf_217_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[8\]
+ _08068_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[2\]\[9\]$_DFFE_PP_
+ _02210_ clknet_leaf_217_clk dynamic_node_top.west_input.NIB.storage_data_f\[2\]\[9\]
+ _08067_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[0\]$_DFFE_PP_
+ _02211_ clknet_leaf_221_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[0\]
+ _08066_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[10\]$_DFFE_PP_
+ _02212_ clknet_leaf_224_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[10\]
+ _08065_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[11\]$_DFFE_PP_
+ _02213_ clknet_leaf_225_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[11\]
+ _08064_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[12\]$_DFFE_PP_
+ _02214_ clknet_leaf_219_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[12\]
+ _08063_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[13\]$_DFFE_PP_
+ _02215_ clknet_leaf_225_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[13\]
+ _08062_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[14\]$_DFFE_PP_
+ _02216_ clknet_leaf_220_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[14\]
+ _08061_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[15\]$_DFFE_PP_
+ _02217_ clknet_leaf_223_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[15\]
+ _08060_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[16\]$_DFFE_PP_
+ _02218_ clknet_leaf_223_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[16\]
+ _08059_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[17\]$_DFFE_PP_
+ _02219_ clknet_leaf_223_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[17\]
+ _08058_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[18\]$_DFFE_PP_
+ _02220_ clknet_leaf_219_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[18\]
+ _08057_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[19\]$_DFFE_PP_
+ _02221_ clknet_leaf_188_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[19\]
+ _08056_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[1\]$_DFFE_PP_
+ _02222_ clknet_leaf_216_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[1\]
+ _08055_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[20\]$_DFFE_PP_
+ _02223_ clknet_leaf_189_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[20\]
+ _08054_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[21\]$_DFFE_PP_
+ _02224_ clknet_leaf_217_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[21\]
+ _08053_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[22\]$_DFFE_PP_
+ _02225_ clknet_leaf_168_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[22\]
+ _08052_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[23\]$_DFFE_PP_
+ _02226_ clknet_leaf_168_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[23\]
+ _08051_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[24\]$_DFFE_PP_
+ _02227_ clknet_leaf_167_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[24\]
+ _08050_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[25\]$_DFFE_PP_
+ _02228_ clknet_leaf_169_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[25\]
+ _08049_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[26\]$_DFFE_PP_
+ _02229_ clknet_leaf_169_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[26\]
+ _08048_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[27\]$_DFFE_PP_
+ _02230_ clknet_leaf_169_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[27\]
+ _08047_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[28\]$_DFFE_PP_
+ _02231_ clknet_leaf_172_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[28\]
+ _08046_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[29\]$_DFFE_PP_
+ _02232_ clknet_leaf_171_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[29\]
+ _08045_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[2\]$_DFFE_PP_
+ _02233_ clknet_leaf_187_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[2\]
+ _08044_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[30\]$_DFFE_PP_
+ _02234_ clknet_leaf_171_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[30\]
+ _08043_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[31\]$_DFFE_PP_
+ _02235_ clknet_leaf_175_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[31\]
+ _08042_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[32\]$_DFFE_PP_
+ _02236_ clknet_leaf_173_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[32\]
+ _08041_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[33\]$_DFFE_PP_
+ _02237_ clknet_leaf_187_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[33\]
+ _08040_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[34\]$_DFFE_PP_
+ _02238_ clknet_leaf_172_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[34\]
+ _08039_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[35\]$_DFFE_PP_
+ _02239_ clknet_leaf_180_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[35\]
+ _08038_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[36\]$_DFFE_PP_
+ _02240_ clknet_leaf_182_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[36\]
+ _08037_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[37\]$_DFFE_PP_
+ _02241_ clknet_leaf_178_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[37\]
+ _08036_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[38\]$_DFFE_PP_
+ _02242_ clknet_leaf_179_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[38\]
+ _08035_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[39\]$_DFFE_PP_
+ _02243_ clknet_leaf_180_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[39\]
+ _08034_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[3\]$_DFFE_PP_
+ _02244_ clknet_leaf_186_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[3\]
+ _08033_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[40\]$_DFFE_PP_
+ _02245_ clknet_leaf_180_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[40\]
+ _08032_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[41\]$_DFFE_PP_
+ _02246_ clknet_leaf_186_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[41\]
+ _08031_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[42\]$_DFFE_PP_
+ _02247_ clknet_leaf_184_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[42\]
+ _08030_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[43\]$_DFFE_PP_
+ _02248_ clknet_leaf_183_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[43\]
+ _08029_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[44\]$_DFFE_PP_
+ _02249_ clknet_leaf_182_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[44\]
+ _08028_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[45\]$_DFFE_PP_
+ _02250_ clknet_leaf_183_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[45\]
+ _08027_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[46\]$_DFFE_PP_
+ _02251_ clknet_leaf_178_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[46\]
+ _08026_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[47\]$_DFFE_PP_
+ _02252_ clknet_leaf_178_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[47\]
+ _08025_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[48\]$_DFFE_PP_
+ _02253_ clknet_leaf_185_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[48\]
+ _08024_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[49\]$_DFFE_PP_
+ _02254_ clknet_leaf_192_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[49\]
+ _08023_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[4\]$_DFFE_PP_
+ _02255_ clknet_leaf_191_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[4\]
+ _08022_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[50\]$_DFFE_PP_
+ _02256_ clknet_leaf_193_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[50\]
+ _08021_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[51\]$_DFFE_PP_
+ _02257_ clknet_leaf_192_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[51\]
+ _08020_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[52\]$_DFFE_PP_
+ _02258_ clknet_leaf_193_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[52\]
+ _08019_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[53\]$_DFFE_PP_
+ _02259_ clknet_leaf_191_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[53\]
+ _08018_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[54\]$_DFFE_PP_
+ _02260_ clknet_leaf_194_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[54\]
+ _08017_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[55\]$_DFFE_PP_
+ _02261_ clknet_leaf_214_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[55\]
+ _08016_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[56\]$_DFFE_PP_
+ _02262_ clknet_leaf_215_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[56\]
+ _08015_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[57\]$_DFFE_PP_
+ _02263_ clknet_leaf_190_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[57\]
+ _08014_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[58\]$_DFFE_PP_
+ _02264_ clknet_leaf_214_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[58\]
+ _08013_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[59\]$_DFFE_PP_
+ _02265_ clknet_leaf_210_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[59\]
+ _08012_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[5\]$_DFFE_PP_
+ _02266_ clknet_leaf_216_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[5\]
+ _08011_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[60\]$_DFFE_PP_
+ _02267_ clknet_leaf_190_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[60\]
+ _08010_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[61\]$_DFFE_PP_
+ _02268_ clknet_leaf_194_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[61\]
+ _08009_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[62\]$_DFFE_PP_
+ _02269_ clknet_leaf_215_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[62\]
+ _08008_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[63\]$_DFFE_PP_
+ _02270_ clknet_leaf_210_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[63\]
+ _08007_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[6\]$_DFFE_PP_
+ _02271_ clknet_leaf_218_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[6\]
+ _08006_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[7\]$_DFFE_PP_
+ _02272_ clknet_leaf_214_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[7\]
+ _08005_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[8\]$_DFFE_PP_
+ _02273_ clknet_leaf_216_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[8\]
+ _08004_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.storage_data_f\[3\]\[9\]$_DFFE_PP_
+ _02274_ clknet_leaf_218_clk dynamic_node_top.west_input.NIB.storage_data_f\[3\]\[9\]
+ _08003_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.tail_ptr_f\[0\]$_SDFFE_PP0N_
+ _02275_ clknet_leaf_192_clk dynamic_node_top.west_input.NIB.tail_ptr_f\[0\]
+ dynamic_node_top.west_input.NIB.tail_ptr_next\[0\] VDD VSS
+ DFF_X1
Xdynamic_node_top.west_input.NIB.tail_ptr_f\[1\]$_SDFFE_PP0N_
+ _02276_ clknet_leaf_185_clk dynamic_node_top.west_input.NIB.tail_ptr_f\[1\]
+ _10609_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.NIB.yummy_out_f$_SDFF_PP0_ _02277_
+ clknet_leaf_162_clk net630 _08002_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.control.count_f\[0\]$_SDFF_PP0_
+ _02278_ clknet_leaf_161_clk dynamic_node_top.west_input.control.count_f\[0\]
+ _10479_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.control.count_f\[1\]$_SDFF_PP0_
+ _02279_ clknet_leaf_162_clk dynamic_node_top.west_input.control.count_f\[1\]
+ _10480_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.control.count_f\[2\]$_SDFF_PP0_
+ _02280_ clknet_leaf_165_clk dynamic_node_top.west_input.control.count_f\[2\]
+ _08001_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.control.count_f\[3\]$_SDFF_PP0_
+ _02281_ clknet_leaf_161_clk dynamic_node_top.west_input.control.count_f\[3\]
+ _08000_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.control.count_f\[4\]$_SDFF_PP0_
+ _02282_ clknet_leaf_161_clk dynamic_node_top.west_input.control.count_f\[4\]
+ _07999_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.control.count_f\[5\]$_SDFF_PP0_
+ _02283_ clknet_leaf_161_clk dynamic_node_top.west_input.control.count_f\[5\]
+ _07998_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.control.count_f\[6\]$_SDFF_PP0_
+ _02284_ clknet_leaf_176_clk dynamic_node_top.west_input.control.count_f\[6\]
+ _07997_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.control.count_f\[7\]$_SDFF_PP0_
+ _02285_ clknet_leaf_161_clk dynamic_node_top.west_input.control.count_f\[7\]
+ _07996_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.control.count_one_f$_SDFF_PP0_
+ _02286_ clknet_leaf_161_clk dynamic_node_top.west_input.control.count_one_f
+ _10160_ VDD VSS DFF_X1
Xdynamic_node_top.west_input.control.header_temp$_DFF_P_ _00004_
+ clknet_leaf_162_clk dynamic_node_top.west_input.control.header_last_temp
+ _07995_ VDD VSS DFF_X2
Xdynamic_node_top.west_input.control.tail_last_f$_SDFF_PP0_
+ _02287_ clknet_leaf_160_clk dynamic_node_top.west_input.control.tail_last_f
+ _10161_ VDD VSS DFF_X1
Xdynamic_node_top.west_output.control.current_route_f\[0\]$_DFF_P_
+ _00032_ clknet_leaf_142_clk dynamic_node_top.west_output.control.current_route_f\[0\]
+ _00051_ VDD VSS DFF_X2
Xdynamic_node_top.west_output.control.current_route_f\[1\]$_DFF_P_
+ _00033_ clknet_leaf_158_clk dynamic_node_top.west_output.control.current_route_f\[1\]
+ _00050_ VDD VSS DFF_X1
Xdynamic_node_top.west_output.control.current_route_f\[2\]$_DFF_P_
+ _00034_ clknet_leaf_142_clk dynamic_node_top.west_output.control.current_route_f\[2\]
+ _00063_ VDD VSS DFF_X1
Xdynamic_node_top.west_output.control.current_route_f\[3\]$_DFF_P_
+ _00035_ clknet_leaf_142_clk dynamic_node_top.west_output.control.current_route_f\[3\]
+ _00064_ VDD VSS DFF_X1
Xdynamic_node_top.west_output.control.current_route_f\[4\]$_DFF_P_
+ _00036_ clknet_leaf_143_clk dynamic_node_top.west_output.control.current_route_f\[4\]
+ _00062_ VDD VSS DFF_X1
Xdynamic_node_top.west_output.control.planned_f$_SDFF_PP0_
+ _02288_ clknet_leaf_158_clk dynamic_node_top.west_output.control.planned_f
+ _00052_ VDD VSS DFF_X2
Xdynamic_node_top.west_output.space.count_f\[0\]$_SDFF_PP0_
+ _02289_ clknet_leaf_164_clk dynamic_node_top.west_output.space.count_f\[0\]
+ _10448_ VDD VSS DFF_X2
Xdynamic_node_top.west_output.space.count_f\[1\]$_SDFF_PP0_
+ _02290_ clknet_leaf_164_clk dynamic_node_top.west_output.space.count_f\[1\]
+ _10449_ VDD VSS DFF_X2
Xdynamic_node_top.west_output.space.count_f\[2\]$_SDFF_PP1_
+ _02291_ clknet_leaf_164_clk dynamic_node_top.west_output.space.count_f\[2\]
+ _00058_ VDD VSS DFF_X1
Xdynamic_node_top.west_output.space.is_one_f$_SDFF_PP0_ _02292_
+ clknet_leaf_163_clk dynamic_node_top.west_output.space.is_one_f
+ _07994_ VDD VSS DFF_X1
Xdynamic_node_top.west_output.space.is_two_or_more_f$_SDFF_PP1_
+ _02293_ clknet_leaf_163_clk dynamic_node_top.west_output.space.is_two_or_more_f
+ _07993_ VDD VSS DFF_X1
Xdynamic_node_top.west_output.space.valid_f$_SDFF_PP0_ _02294_
+ clknet_leaf_163_clk dynamic_node_top.west_output.space.valid_f
+ _10445_ VDD VSS DFF_X1
Xdynamic_node_top.west_output.space.yummy_f$_SDFF_PP0_ _02295_
+ clknet_leaf_163_clk dynamic_node_top.west_output.space.yummy_f
+ _10442_ VDD VSS DFF_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Right_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Right_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Right_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Right_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Right_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Right_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Right_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Right_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Right_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Right_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Right_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Right_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Right_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Right_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Right_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Right_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Right_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Right_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Right_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Right_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Right_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Right_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Right_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Right_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Right_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Right_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Right_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Right_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Right_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Right_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Right_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Right_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Right_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Right_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Right_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Right_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Right_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Right_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Right_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Right_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Right_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Right_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Right_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Right_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Right_89 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Right_90 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Right_91 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Right_92 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Right_93 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Right_94 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Right_95 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Right_96 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Right_97 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Right_98 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Right_99 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Right_100 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Right_101 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Right_102 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Right_103 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Right_104 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Right_105 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Right_106 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Right_107 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Right_108 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Right_109 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Right_110 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Right_111 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Right_112 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Right_113 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Right_114 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Right_115 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Right_116 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Right_117 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Right_118 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Right_119 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Right_120 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Right_121 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Right_122 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Right_123 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Right_124 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Right_125 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Right_126 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Right_127 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Right_128 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Right_129 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Right_130 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Right_131 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Right_132 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_133_Right_133 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_134_Right_134 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_135_Right_135 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_136_Right_136 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_137_Right_137 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_138_Right_138 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_139_Right_139 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_140_Right_140 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_141_Right_141 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_142_Right_142 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_143_Right_143 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_144_Right_144 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_145_Right_145 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_146_Right_146 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_147_Right_147 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_148_Right_148 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_149_Right_149 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_150_Right_150 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_151_Right_151 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_152_Right_152 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_153_Right_153 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_154_Right_154 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_155_Right_155 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_156_Right_156 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_157_Right_157 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_158_Right_158 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_159_Right_159 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_160_Right_160 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_161_Right_161 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_162_Right_162 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_163_Right_163 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_164_Right_164 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_165_Right_165 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_166_Right_166 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_167_Right_167 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_168 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_169 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_170 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_171 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_172 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_173 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_174 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_175 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_176 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_177 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_178 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_179 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_180 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_181 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_182 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_183 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_184 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_185 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_186 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_187 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_188 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_189 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_190 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_191 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_192 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_193 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_194 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_195 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_196 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_197 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_198 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_199 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_200 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_201 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_202 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_203 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_204 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_205 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_206 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_207 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_208 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_209 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_210 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_211 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_212 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Left_213 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Left_214 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Left_215 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Left_216 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Left_217 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Left_218 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Left_219 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Left_220 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Left_221 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Left_222 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Left_223 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Left_224 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Left_225 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Left_226 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Left_227 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Left_228 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Left_229 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Left_230 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Left_231 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Left_232 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Left_233 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Left_234 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Left_235 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Left_236 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Left_237 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Left_238 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Left_239 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Left_240 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Left_241 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Left_242 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Left_243 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Left_244 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Left_245 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Left_246 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Left_247 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Left_248 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Left_249 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Left_250 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Left_251 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Left_252 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Left_253 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Left_254 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Left_255 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Left_256 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Left_257 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Left_258 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Left_259 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Left_260 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Left_261 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Left_262 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Left_263 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Left_264 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Left_265 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Left_266 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Left_267 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Left_268 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Left_269 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Left_270 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Left_271 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Left_272 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Left_273 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Left_274 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Left_275 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Left_276 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Left_277 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Left_278 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Left_279 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Left_280 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Left_281 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Left_282 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Left_283 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Left_284 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Left_285 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Left_286 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Left_287 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Left_288 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Left_289 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Left_290 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Left_291 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Left_292 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Left_293 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Left_294 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Left_295 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Left_296 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Left_297 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Left_298 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Left_299 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Left_300 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_133_Left_301 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_134_Left_302 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_135_Left_303 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_136_Left_304 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_137_Left_305 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_138_Left_306 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_139_Left_307 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_140_Left_308 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_141_Left_309 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_142_Left_310 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_143_Left_311 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_144_Left_312 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_145_Left_313 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_146_Left_314 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_147_Left_315 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_148_Left_316 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_149_Left_317 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_150_Left_318 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_151_Left_319 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_152_Left_320 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_153_Left_321 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_154_Left_322 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_155_Left_323 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_156_Left_324 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_157_Left_325 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_158_Left_326 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_159_Left_327 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_160_Left_328 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_161_Left_329 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_162_Left_330 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_163_Left_331 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_164_Left_332 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_165_Left_333 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_166_Left_334 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_167_Left_335 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_336 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_2_337 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_4_338 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_6_339 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_8_340 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_10_341 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_12_342 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_14_343 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_16_344 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_18_345 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_20_346 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_22_347 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_24_348 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_26_349 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_28_350 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_30_351 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_32_352 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_34_353 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_36_354 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_38_355 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_40_356 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_42_357 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_44_358 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_46_359 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_48_360 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_50_361 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_52_362 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_54_363 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_56_364 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_58_365 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_60_366 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_62_367 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_64_368 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_66_369 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_68_370 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_70_371 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_72_372 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_74_373 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_76_374 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_78_375 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_80_376 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_82_377 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_84_378 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_86_379 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_88_380 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_90_381 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_92_382 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_94_383 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_96_384 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_98_385 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_100_386 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_102_387 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_104_388 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_106_389 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_108_390 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_110_391 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_112_392 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_114_393 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_116_394 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_118_395 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_120_396 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_122_397 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_124_398 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_126_399 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_128_400 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_130_401 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_132_402 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_134_403 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_136_404 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_138_405 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_140_406 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_142_407 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_144_408 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_146_409 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_148_410 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_150_411 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_152_412 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_154_413 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_156_414 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_158_415 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_160_416 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_162_417 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_164_418 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_166_419 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_167_420 VDD VSS TAPCELL_X1
Xinput1 dataIn_E[0] net3 VDD VSS BUF_X1
Xinput2 dataIn_E[10] net4 VDD VSS BUF_X1
Xinput3 dataIn_E[11] net5 VDD VSS BUF_X1
Xinput4 dataIn_E[12] net6 VDD VSS BUF_X1
Xinput5 dataIn_E[13] net7 VDD VSS BUF_X1
Xinput6 dataIn_E[14] net8 VDD VSS BUF_X1
Xinput7 dataIn_E[15] net9 VDD VSS BUF_X1
Xinput8 dataIn_E[16] net10 VDD VSS BUF_X1
Xinput9 dataIn_E[17] net11 VDD VSS BUF_X1
Xinput10 dataIn_E[18] net12 VDD VSS BUF_X1
Xinput11 dataIn_E[19] net13 VDD VSS BUF_X1
Xinput12 dataIn_E[1] net14 VDD VSS BUF_X1
Xinput13 dataIn_E[20] net15 VDD VSS BUF_X1
Xinput14 dataIn_E[21] net16 VDD VSS BUF_X1
Xinput15 dataIn_E[22] net17 VDD VSS BUF_X1
Xinput16 dataIn_E[23] net18 VDD VSS BUF_X1
Xinput17 dataIn_E[24] net19 VDD VSS BUF_X1
Xinput18 dataIn_E[25] net20 VDD VSS BUF_X1
Xinput19 dataIn_E[26] net21 VDD VSS BUF_X1
Xinput20 dataIn_E[27] net22 VDD VSS BUF_X1
Xinput21 dataIn_E[28] net23 VDD VSS BUF_X1
Xinput22 dataIn_E[29] net24 VDD VSS BUF_X1
Xinput23 dataIn_E[2] net25 VDD VSS BUF_X1
Xinput24 dataIn_E[30] net26 VDD VSS BUF_X1
Xinput25 dataIn_E[31] net27 VDD VSS BUF_X1
Xinput26 dataIn_E[32] net28 VDD VSS BUF_X1
Xinput27 dataIn_E[33] net29 VDD VSS BUF_X1
Xinput28 dataIn_E[34] net30 VDD VSS BUF_X1
Xinput29 dataIn_E[35] net31 VDD VSS BUF_X1
Xinput30 dataIn_E[36] net32 VDD VSS BUF_X1
Xinput31 dataIn_E[37] net33 VDD VSS BUF_X1
Xinput32 dataIn_E[38] net34 VDD VSS BUF_X1
Xinput33 dataIn_E[39] net35 VDD VSS BUF_X1
Xinput34 dataIn_E[3] net36 VDD VSS BUF_X1
Xinput35 dataIn_E[40] net37 VDD VSS BUF_X1
Xinput36 dataIn_E[41] net38 VDD VSS BUF_X1
Xinput37 dataIn_E[42] net39 VDD VSS BUF_X1
Xinput38 dataIn_E[43] net40 VDD VSS BUF_X1
Xinput39 dataIn_E[44] net41 VDD VSS BUF_X1
Xinput40 dataIn_E[45] net42 VDD VSS BUF_X1
Xinput41 dataIn_E[46] net43 VDD VSS CLKBUF_X2
Xinput42 dataIn_E[47] net44 VDD VSS BUF_X1
Xinput43 dataIn_E[48] net45 VDD VSS BUF_X1
Xinput44 dataIn_E[49] net46 VDD VSS BUF_X1
Xinput45 dataIn_E[4] net47 VDD VSS BUF_X1
Xinput46 dataIn_E[50] net48 VDD VSS BUF_X2
Xinput47 dataIn_E[51] net49 VDD VSS BUF_X2
Xinput48 dataIn_E[52] net50 VDD VSS BUF_X2
Xinput49 dataIn_E[53] net51 VDD VSS BUF_X1
Xinput50 dataIn_E[54] net52 VDD VSS CLKBUF_X2
Xinput51 dataIn_E[55] net53 VDD VSS CLKBUF_X2
Xinput52 dataIn_E[56] net54 VDD VSS BUF_X1
Xinput53 dataIn_E[57] net55 VDD VSS CLKBUF_X2
Xinput54 dataIn_E[58] net56 VDD VSS BUF_X1
Xinput55 dataIn_E[59] net57 VDD VSS BUF_X1
Xinput56 dataIn_E[5] net58 VDD VSS CLKBUF_X2
Xinput57 dataIn_E[60] net59 VDD VSS BUF_X1
Xinput58 dataIn_E[61] net60 VDD VSS BUF_X1
Xinput59 dataIn_E[62] net61 VDD VSS BUF_X1
Xinput60 dataIn_E[63] net62 VDD VSS BUF_X1
Xinput61 dataIn_E[6] net63 VDD VSS BUF_X1
Xinput62 dataIn_E[7] net64 VDD VSS BUF_X1
Xinput63 dataIn_E[8] net65 VDD VSS BUF_X1
Xinput64 dataIn_E[9] net66 VDD VSS BUF_X1
Xinput65 dataIn_N[0] net67 VDD VSS CLKBUF_X2
Xinput66 dataIn_N[10] net68 VDD VSS BUF_X2
Xinput67 dataIn_N[11] net69 VDD VSS BUF_X2
Xinput68 dataIn_N[12] net70 VDD VSS CLKBUF_X2
Xinput69 dataIn_N[13] net71 VDD VSS BUF_X2
Xinput70 dataIn_N[14] net72 VDD VSS CLKBUF_X2
Xinput71 dataIn_N[15] net73 VDD VSS CLKBUF_X2
Xinput72 dataIn_N[16] net74 VDD VSS BUF_X2
Xinput73 dataIn_N[17] net75 VDD VSS BUF_X2
Xinput74 dataIn_N[18] net76 VDD VSS BUF_X2
Xinput75 dataIn_N[19] net77 VDD VSS BUF_X2
Xinput76 dataIn_N[1] net78 VDD VSS BUF_X2
Xinput77 dataIn_N[20] net79 VDD VSS BUF_X2
Xinput78 dataIn_N[21] net80 VDD VSS BUF_X2
Xinput79 dataIn_N[22] net81 VDD VSS BUF_X1
Xinput80 dataIn_N[23] net82 VDD VSS BUF_X1
Xinput81 dataIn_N[24] net83 VDD VSS BUF_X1
Xinput82 dataIn_N[25] net84 VDD VSS BUF_X1
Xinput83 dataIn_N[26] net85 VDD VSS BUF_X1
Xinput84 dataIn_N[27] net86 VDD VSS BUF_X1
Xinput85 dataIn_N[28] net87 VDD VSS BUF_X1
Xinput86 dataIn_N[29] net88 VDD VSS BUF_X1
Xinput87 dataIn_N[2] net89 VDD VSS CLKBUF_X2
Xinput88 dataIn_N[30] net90 VDD VSS BUF_X1
Xinput89 dataIn_N[31] net91 VDD VSS BUF_X1
Xinput90 dataIn_N[32] net92 VDD VSS BUF_X1
Xinput91 dataIn_N[33] net93 VDD VSS CLKBUF_X2
Xinput92 dataIn_N[34] net94 VDD VSS CLKBUF_X2
Xinput93 dataIn_N[35] net95 VDD VSS CLKBUF_X2
Xinput94 dataIn_N[36] net96 VDD VSS BUF_X1
Xinput95 dataIn_N[37] net97 VDD VSS CLKBUF_X2
Xinput96 dataIn_N[38] net98 VDD VSS CLKBUF_X2
Xinput97 dataIn_N[39] net99 VDD VSS CLKBUF_X2
Xinput98 dataIn_N[3] net100 VDD VSS BUF_X2
Xinput99 dataIn_N[40] net101 VDD VSS BUF_X1
Xinput100 dataIn_N[41] net102 VDD VSS BUF_X2
Xinput101 dataIn_N[42] net103 VDD VSS CLKBUF_X2
Xinput102 dataIn_N[43] net104 VDD VSS BUF_X2
Xinput103 dataIn_N[44] net105 VDD VSS CLKBUF_X2
Xinput104 dataIn_N[45] net106 VDD VSS CLKBUF_X2
Xinput105 dataIn_N[46] net107 VDD VSS BUF_X2
Xinput106 dataIn_N[47] net108 VDD VSS BUF_X2
Xinput107 dataIn_N[48] net109 VDD VSS BUF_X2
Xinput108 dataIn_N[49] net110 VDD VSS BUF_X2
Xinput109 dataIn_N[4] net111 VDD VSS BUF_X2
Xinput110 dataIn_N[50] net112 VDD VSS BUF_X2
Xinput111 dataIn_N[51] net113 VDD VSS BUF_X2
Xinput112 dataIn_N[52] net114 VDD VSS BUF_X2
Xinput113 dataIn_N[53] net115 VDD VSS BUF_X2
Xinput114 dataIn_N[54] net116 VDD VSS BUF_X2
Xinput115 dataIn_N[55] net117 VDD VSS BUF_X2
Xinput116 dataIn_N[56] net118 VDD VSS BUF_X2
Xinput117 dataIn_N[57] net119 VDD VSS BUF_X2
Xinput118 dataIn_N[58] net120 VDD VSS BUF_X2
Xinput119 dataIn_N[59] net121 VDD VSS BUF_X2
Xinput120 dataIn_N[5] net122 VDD VSS CLKBUF_X3
Xinput121 dataIn_N[60] net123 VDD VSS BUF_X2
Xinput122 dataIn_N[61] net124 VDD VSS BUF_X2
Xinput123 dataIn_N[62] net125 VDD VSS BUF_X2
Xinput124 dataIn_N[63] net126 VDD VSS BUF_X2
Xinput125 dataIn_N[6] net127 VDD VSS BUF_X2
Xinput126 dataIn_N[7] net128 VDD VSS BUF_X2
Xinput127 dataIn_N[8] net129 VDD VSS BUF_X2
Xinput128 dataIn_N[9] net130 VDD VSS BUF_X2
Xinput129 dataIn_S[0] net131 VDD VSS BUF_X1
Xinput130 dataIn_S[10] net132 VDD VSS BUF_X1
Xinput131 dataIn_S[11] net133 VDD VSS BUF_X1
Xinput132 dataIn_S[12] net134 VDD VSS BUF_X1
Xinput133 dataIn_S[13] net135 VDD VSS BUF_X1
Xinput134 dataIn_S[14] net136 VDD VSS BUF_X1
Xinput135 dataIn_S[15] net137 VDD VSS BUF_X1
Xinput136 dataIn_S[16] net138 VDD VSS BUF_X1
Xinput137 dataIn_S[17] net139 VDD VSS BUF_X1
Xinput138 dataIn_S[18] net140 VDD VSS BUF_X1
Xinput139 dataIn_S[19] net141 VDD VSS BUF_X1
Xinput140 dataIn_S[1] net142 VDD VSS BUF_X1
Xinput141 dataIn_S[20] net143 VDD VSS BUF_X1
Xinput142 dataIn_S[21] net144 VDD VSS BUF_X1
Xinput143 dataIn_S[22] net145 VDD VSS BUF_X1
Xinput144 dataIn_S[23] net146 VDD VSS BUF_X1
Xinput145 dataIn_S[24] net147 VDD VSS BUF_X1
Xinput146 dataIn_S[25] net148 VDD VSS BUF_X1
Xinput147 dataIn_S[26] net149 VDD VSS BUF_X1
Xinput148 dataIn_S[27] net150 VDD VSS BUF_X1
Xinput149 dataIn_S[28] net151 VDD VSS BUF_X1
Xinput150 dataIn_S[29] net152 VDD VSS BUF_X1
Xinput151 dataIn_S[2] net153 VDD VSS BUF_X1
Xinput152 dataIn_S[30] net154 VDD VSS BUF_X1
Xinput153 dataIn_S[31] net155 VDD VSS BUF_X1
Xinput154 dataIn_S[32] net156 VDD VSS BUF_X1
Xinput155 dataIn_S[33] net157 VDD VSS BUF_X1
Xinput156 dataIn_S[34] net158 VDD VSS BUF_X1
Xinput157 dataIn_S[35] net159 VDD VSS BUF_X1
Xinput158 dataIn_S[36] net160 VDD VSS BUF_X1
Xinput159 dataIn_S[37] net161 VDD VSS BUF_X1
Xinput160 dataIn_S[38] net162 VDD VSS BUF_X1
Xinput161 dataIn_S[39] net163 VDD VSS BUF_X1
Xinput162 dataIn_S[3] net164 VDD VSS BUF_X1
Xinput163 dataIn_S[40] net165 VDD VSS CLKBUF_X2
Xinput164 dataIn_S[41] net166 VDD VSS BUF_X1
Xinput165 dataIn_S[42] net167 VDD VSS BUF_X1
Xinput166 dataIn_S[43] net168 VDD VSS CLKBUF_X2
Xinput167 dataIn_S[44] net169 VDD VSS CLKBUF_X2
Xinput168 dataIn_S[45] net170 VDD VSS BUF_X1
Xinput169 dataIn_S[46] net171 VDD VSS BUF_X1
Xinput170 dataIn_S[47] net172 VDD VSS CLKBUF_X2
Xinput171 dataIn_S[48] net173 VDD VSS BUF_X1
Xinput172 dataIn_S[49] net174 VDD VSS BUF_X1
Xinput173 dataIn_S[4] net175 VDD VSS BUF_X1
Xinput174 dataIn_S[50] net176 VDD VSS BUF_X1
Xinput175 dataIn_S[51] net177 VDD VSS BUF_X1
Xinput176 dataIn_S[52] net178 VDD VSS BUF_X1
Xinput177 dataIn_S[53] net179 VDD VSS BUF_X1
Xinput178 dataIn_S[54] net180 VDD VSS BUF_X1
Xinput179 dataIn_S[55] net181 VDD VSS BUF_X1
Xinput180 dataIn_S[56] net182 VDD VSS BUF_X1
Xinput181 dataIn_S[57] net183 VDD VSS BUF_X2
Xinput182 dataIn_S[58] net184 VDD VSS BUF_X1
Xinput183 dataIn_S[59] net185 VDD VSS CLKBUF_X2
Xinput184 dataIn_S[5] net186 VDD VSS BUF_X1
Xinput185 dataIn_S[60] net187 VDD VSS BUF_X1
Xinput186 dataIn_S[61] net188 VDD VSS BUF_X1
Xinput187 dataIn_S[62] net189 VDD VSS BUF_X1
Xinput188 dataIn_S[63] net190 VDD VSS BUF_X1
Xinput189 dataIn_S[6] net191 VDD VSS BUF_X1
Xinput190 dataIn_S[7] net192 VDD VSS BUF_X1
Xinput191 dataIn_S[8] net193 VDD VSS BUF_X1
Xinput192 dataIn_S[9] net194 VDD VSS BUF_X1
Xinput193 dataIn_W[0] net195 VDD VSS BUF_X1
Xinput194 dataIn_W[10] net196 VDD VSS BUF_X1
Xinput195 dataIn_W[11] net197 VDD VSS BUF_X1
Xinput196 dataIn_W[12] net198 VDD VSS BUF_X1
Xinput197 dataIn_W[13] net199 VDD VSS BUF_X1
Xinput198 dataIn_W[14] net200 VDD VSS BUF_X1
Xinput199 dataIn_W[15] net201 VDD VSS BUF_X1
Xinput200 dataIn_W[16] net202 VDD VSS BUF_X1
Xinput201 dataIn_W[17] net203 VDD VSS BUF_X1
Xinput202 dataIn_W[18] net204 VDD VSS BUF_X1
Xinput203 dataIn_W[19] net205 VDD VSS BUF_X1
Xinput204 dataIn_W[1] net206 VDD VSS BUF_X1
Xinput205 dataIn_W[20] net207 VDD VSS BUF_X1
Xinput206 dataIn_W[21] net208 VDD VSS BUF_X1
Xinput207 dataIn_W[22] net209 VDD VSS BUF_X1
Xinput208 dataIn_W[23] net210 VDD VSS BUF_X1
Xinput209 dataIn_W[24] net211 VDD VSS BUF_X1
Xinput210 dataIn_W[25] net212 VDD VSS BUF_X1
Xinput211 dataIn_W[26] net213 VDD VSS BUF_X1
Xinput212 dataIn_W[27] net214 VDD VSS BUF_X1
Xinput213 dataIn_W[28] net215 VDD VSS BUF_X1
Xinput214 dataIn_W[29] net216 VDD VSS BUF_X1
Xinput215 dataIn_W[2] net217 VDD VSS BUF_X1
Xinput216 dataIn_W[30] net218 VDD VSS BUF_X1
Xinput217 dataIn_W[31] net219 VDD VSS BUF_X1
Xinput218 dataIn_W[32] net220 VDD VSS BUF_X1
Xinput219 dataIn_W[33] net221 VDD VSS BUF_X1
Xinput220 dataIn_W[34] net222 VDD VSS BUF_X1
Xinput221 dataIn_W[35] net223 VDD VSS BUF_X1
Xinput222 dataIn_W[36] net224 VDD VSS BUF_X1
Xinput223 dataIn_W[37] net225 VDD VSS BUF_X1
Xinput224 dataIn_W[38] net226 VDD VSS BUF_X1
Xinput225 dataIn_W[39] net227 VDD VSS BUF_X1
Xinput226 dataIn_W[3] net228 VDD VSS BUF_X1
Xinput227 dataIn_W[40] net229 VDD VSS BUF_X1
Xinput228 dataIn_W[41] net230 VDD VSS CLKBUF_X2
Xinput229 dataIn_W[42] net231 VDD VSS BUF_X1
Xinput230 dataIn_W[43] net232 VDD VSS CLKBUF_X2
Xinput231 dataIn_W[44] net233 VDD VSS BUF_X1
Xinput232 dataIn_W[45] net234 VDD VSS BUF_X1
Xinput233 dataIn_W[46] net235 VDD VSS BUF_X1
Xinput234 dataIn_W[47] net236 VDD VSS BUF_X1
Xinput235 dataIn_W[48] net237 VDD VSS BUF_X1
Xinput236 dataIn_W[49] net238 VDD VSS BUF_X1
Xinput237 dataIn_W[4] net239 VDD VSS BUF_X2
Xinput238 dataIn_W[50] net240 VDD VSS BUF_X1
Xinput239 dataIn_W[51] net241 VDD VSS BUF_X1
Xinput240 dataIn_W[52] net242 VDD VSS BUF_X1
Xinput241 dataIn_W[53] net243 VDD VSS BUF_X1
Xinput242 dataIn_W[54] net244 VDD VSS BUF_X2
Xinput243 dataIn_W[55] net245 VDD VSS BUF_X1
Xinput244 dataIn_W[56] net246 VDD VSS BUF_X1
Xinput245 dataIn_W[57] net247 VDD VSS BUF_X1
Xinput246 dataIn_W[58] net248 VDD VSS BUF_X1
Xinput247 dataIn_W[59] net249 VDD VSS BUF_X1
Xinput248 dataIn_W[5] net250 VDD VSS BUF_X1
Xinput249 dataIn_W[60] net251 VDD VSS BUF_X1
Xinput250 dataIn_W[61] net252 VDD VSS BUF_X1
Xinput251 dataIn_W[62] net253 VDD VSS BUF_X1
Xinput252 dataIn_W[63] net254 VDD VSS BUF_X1
Xinput253 dataIn_W[6] net255 VDD VSS BUF_X1
Xinput254 dataIn_W[7] net256 VDD VSS BUF_X1
Xinput255 dataIn_W[8] net257 VDD VSS BUF_X1
Xinput256 dataIn_W[9] net258 VDD VSS BUF_X1
Xinput257 myChipID[0] net259 VDD VSS BUF_X1
Xinput258 myChipID[10] net260 VDD VSS BUF_X1
Xinput259 myChipID[11] net261 VDD VSS BUF_X1
Xinput260 myChipID[12] net262 VDD VSS BUF_X1
Xinput261 myChipID[13] net263 VDD VSS CLKBUF_X2
Xinput262 myChipID[1] net264 VDD VSS BUF_X1
Xinput263 myChipID[2] net265 VDD VSS BUF_X1
Xinput264 myChipID[3] net266 VDD VSS BUF_X1
Xinput265 myChipID[4] net267 VDD VSS BUF_X1
Xinput266 myChipID[5] net268 VDD VSS BUF_X1
Xinput267 myChipID[6] net269 VDD VSS CLKBUF_X2
Xinput268 myChipID[7] net270 VDD VSS BUF_X1
Xinput269 myChipID[8] net271 VDD VSS BUF_X1
Xinput270 myChipID[9] net272 VDD VSS BUF_X1
Xinput271 myLocX[0] net273 VDD VSS BUF_X1
Xinput272 myLocX[1] net274 VDD VSS BUF_X1
Xinput273 myLocX[2] net275 VDD VSS BUF_X1
Xinput274 myLocX[3] net276 VDD VSS BUF_X1
Xinput275 myLocX[4] net277 VDD VSS BUF_X1
Xinput276 myLocX[5] net278 VDD VSS BUF_X1
Xinput277 myLocX[6] net279 VDD VSS BUF_X1
Xinput278 myLocX[7] net280 VDD VSS BUF_X1
Xinput279 myLocY[0] net281 VDD VSS BUF_X1
Xinput280 myLocY[1] net282 VDD VSS BUF_X1
Xinput281 myLocY[2] net283 VDD VSS BUF_X1
Xinput282 myLocY[3] net284 VDD VSS BUF_X1
Xinput283 myLocY[4] net285 VDD VSS BUF_X1
Xinput284 myLocY[5] net286 VDD VSS BUF_X1
Xinput285 myLocY[6] net287 VDD VSS BUF_X1
Xinput286 myLocY[7] net288 VDD VSS BUF_X1
Xinput287 reset_in net289 VDD VSS BUF_X1
Xinput288 validIn_E net290 VDD VSS CLKBUF_X2
Xinput289 validIn_N net291 VDD VSS BUF_X1
Xinput290 validIn_P net292 VDD VSS BUF_X1
Xinput291 validIn_S net293 VDD VSS CLKBUF_X2
Xinput292 validIn_W net294 VDD VSS BUF_X1
Xinput293 yummyIn_E net295 VDD VSS BUF_X1
Xinput294 yummyIn_N net296 VDD VSS BUF_X1
Xinput295 yummyIn_P net297 VDD VSS BUF_X1
Xinput296 yummyIn_S net298 VDD VSS BUF_X1
Xinput297 yummyIn_W net299 VDD VSS BUF_X1
Xoutput298 net300 dataOut_E[0] VDD VSS BUF_X1
Xoutput299 net301 dataOut_E[10] VDD VSS BUF_X1
Xoutput300 net302 dataOut_E[11] VDD VSS BUF_X1
Xoutput301 net303 dataOut_E[12] VDD VSS BUF_X1
Xoutput302 net304 dataOut_E[13] VDD VSS BUF_X1
Xoutput303 net305 dataOut_E[14] VDD VSS BUF_X1
Xoutput304 net306 dataOut_E[15] VDD VSS BUF_X1
Xoutput305 net307 dataOut_E[16] VDD VSS BUF_X1
Xoutput306 net308 dataOut_E[17] VDD VSS BUF_X1
Xoutput307 net309 dataOut_E[18] VDD VSS BUF_X1
Xoutput308 net310 dataOut_E[19] VDD VSS BUF_X1
Xoutput309 net311 dataOut_E[1] VDD VSS BUF_X1
Xoutput310 net312 dataOut_E[20] VDD VSS BUF_X1
Xoutput311 net313 dataOut_E[21] VDD VSS BUF_X1
Xoutput312 net314 dataOut_E[22] VDD VSS BUF_X1
Xoutput313 net315 dataOut_E[23] VDD VSS BUF_X1
Xoutput314 net316 dataOut_E[24] VDD VSS BUF_X1
Xoutput315 net317 dataOut_E[25] VDD VSS BUF_X1
Xoutput316 net318 dataOut_E[26] VDD VSS BUF_X1
Xoutput317 net319 dataOut_E[27] VDD VSS BUF_X1
Xoutput318 net320 dataOut_E[28] VDD VSS BUF_X1
Xoutput319 net321 dataOut_E[29] VDD VSS BUF_X1
Xoutput320 net322 dataOut_E[2] VDD VSS BUF_X1
Xoutput321 net323 dataOut_E[30] VDD VSS BUF_X1
Xoutput322 net324 dataOut_E[31] VDD VSS BUF_X1
Xoutput323 net325 dataOut_E[32] VDD VSS BUF_X1
Xoutput324 net326 dataOut_E[33] VDD VSS BUF_X1
Xoutput325 net327 dataOut_E[34] VDD VSS BUF_X1
Xoutput326 net328 dataOut_E[35] VDD VSS BUF_X1
Xoutput327 net329 dataOut_E[36] VDD VSS BUF_X1
Xoutput328 net330 dataOut_E[37] VDD VSS BUF_X1
Xoutput329 net331 dataOut_E[38] VDD VSS BUF_X1
Xoutput330 net332 dataOut_E[39] VDD VSS BUF_X1
Xoutput331 net333 dataOut_E[3] VDD VSS BUF_X1
Xoutput332 net334 dataOut_E[40] VDD VSS BUF_X1
Xoutput333 net335 dataOut_E[41] VDD VSS BUF_X1
Xoutput334 net336 dataOut_E[42] VDD VSS BUF_X1
Xoutput335 net337 dataOut_E[43] VDD VSS BUF_X1
Xoutput336 net338 dataOut_E[44] VDD VSS BUF_X1
Xoutput337 net339 dataOut_E[45] VDD VSS BUF_X1
Xoutput338 net340 dataOut_E[46] VDD VSS BUF_X1
Xoutput339 net341 dataOut_E[47] VDD VSS BUF_X1
Xoutput340 net342 dataOut_E[48] VDD VSS BUF_X1
Xoutput341 net343 dataOut_E[49] VDD VSS BUF_X1
Xoutput342 net344 dataOut_E[4] VDD VSS BUF_X1
Xoutput343 net345 dataOut_E[50] VDD VSS BUF_X1
Xoutput344 net346 dataOut_E[51] VDD VSS BUF_X1
Xoutput345 net347 dataOut_E[52] VDD VSS BUF_X1
Xoutput346 net348 dataOut_E[53] VDD VSS BUF_X1
Xoutput347 net349 dataOut_E[54] VDD VSS BUF_X1
Xoutput348 net350 dataOut_E[55] VDD VSS BUF_X1
Xoutput349 net351 dataOut_E[56] VDD VSS BUF_X1
Xoutput350 net352 dataOut_E[57] VDD VSS BUF_X1
Xoutput351 net353 dataOut_E[58] VDD VSS BUF_X1
Xoutput352 net354 dataOut_E[59] VDD VSS BUF_X1
Xoutput353 net355 dataOut_E[5] VDD VSS BUF_X1
Xoutput354 net356 dataOut_E[60] VDD VSS BUF_X1
Xoutput355 net357 dataOut_E[61] VDD VSS BUF_X1
Xoutput356 net358 dataOut_E[62] VDD VSS BUF_X1
Xoutput357 net359 dataOut_E[63] VDD VSS BUF_X1
Xoutput358 net360 dataOut_E[6] VDD VSS BUF_X1
Xoutput359 net361 dataOut_E[7] VDD VSS BUF_X1
Xoutput360 net362 dataOut_E[8] VDD VSS BUF_X1
Xoutput361 net363 dataOut_E[9] VDD VSS BUF_X1
Xoutput362 net364 dataOut_N[0] VDD VSS BUF_X1
Xoutput363 net365 dataOut_N[10] VDD VSS BUF_X1
Xoutput364 net366 dataOut_N[11] VDD VSS BUF_X1
Xoutput365 net367 dataOut_N[12] VDD VSS BUF_X1
Xoutput366 net368 dataOut_N[13] VDD VSS BUF_X1
Xoutput367 net369 dataOut_N[14] VDD VSS BUF_X1
Xoutput368 net370 dataOut_N[15] VDD VSS BUF_X1
Xoutput369 net371 dataOut_N[16] VDD VSS BUF_X1
Xoutput370 net372 dataOut_N[17] VDD VSS BUF_X1
Xoutput371 net373 dataOut_N[18] VDD VSS BUF_X1
Xoutput372 net374 dataOut_N[19] VDD VSS BUF_X1
Xoutput373 net375 dataOut_N[1] VDD VSS BUF_X1
Xoutput374 net376 dataOut_N[20] VDD VSS BUF_X1
Xoutput375 net377 dataOut_N[21] VDD VSS BUF_X1
Xoutput376 net378 dataOut_N[22] VDD VSS BUF_X1
Xoutput377 net379 dataOut_N[23] VDD VSS BUF_X1
Xoutput378 net380 dataOut_N[24] VDD VSS BUF_X1
Xoutput379 net381 dataOut_N[25] VDD VSS BUF_X1
Xoutput380 net382 dataOut_N[26] VDD VSS BUF_X1
Xoutput381 net383 dataOut_N[27] VDD VSS BUF_X1
Xoutput382 net384 dataOut_N[28] VDD VSS BUF_X1
Xoutput383 net385 dataOut_N[29] VDD VSS BUF_X1
Xoutput384 net386 dataOut_N[2] VDD VSS BUF_X1
Xoutput385 net387 dataOut_N[30] VDD VSS BUF_X1
Xoutput386 net388 dataOut_N[31] VDD VSS BUF_X1
Xoutput387 net389 dataOut_N[32] VDD VSS BUF_X1
Xoutput388 net390 dataOut_N[33] VDD VSS BUF_X1
Xoutput389 net391 dataOut_N[34] VDD VSS BUF_X1
Xoutput390 net392 dataOut_N[35] VDD VSS BUF_X1
Xoutput391 net393 dataOut_N[36] VDD VSS BUF_X1
Xoutput392 net394 dataOut_N[37] VDD VSS BUF_X1
Xoutput393 net395 dataOut_N[38] VDD VSS BUF_X1
Xoutput394 net396 dataOut_N[39] VDD VSS BUF_X1
Xoutput395 net397 dataOut_N[3] VDD VSS BUF_X1
Xoutput396 net398 dataOut_N[40] VDD VSS BUF_X1
Xoutput397 net399 dataOut_N[41] VDD VSS BUF_X1
Xoutput398 net400 dataOut_N[42] VDD VSS BUF_X1
Xoutput399 net401 dataOut_N[43] VDD VSS BUF_X1
Xoutput400 net402 dataOut_N[44] VDD VSS BUF_X1
Xoutput401 net403 dataOut_N[45] VDD VSS BUF_X1
Xoutput402 net404 dataOut_N[46] VDD VSS BUF_X1
Xoutput403 net405 dataOut_N[47] VDD VSS BUF_X1
Xoutput404 net406 dataOut_N[48] VDD VSS BUF_X1
Xoutput405 net407 dataOut_N[49] VDD VSS BUF_X1
Xoutput406 net408 dataOut_N[4] VDD VSS BUF_X1
Xoutput407 net409 dataOut_N[50] VDD VSS BUF_X1
Xoutput408 net410 dataOut_N[51] VDD VSS BUF_X1
Xoutput409 net411 dataOut_N[52] VDD VSS BUF_X1
Xoutput410 net412 dataOut_N[53] VDD VSS BUF_X1
Xoutput411 net413 dataOut_N[54] VDD VSS BUF_X1
Xoutput412 net414 dataOut_N[55] VDD VSS BUF_X1
Xoutput413 net415 dataOut_N[56] VDD VSS BUF_X1
Xoutput414 net416 dataOut_N[57] VDD VSS BUF_X1
Xoutput415 net417 dataOut_N[58] VDD VSS BUF_X1
Xoutput416 net418 dataOut_N[59] VDD VSS BUF_X1
Xoutput417 net419 dataOut_N[5] VDD VSS BUF_X1
Xoutput418 net420 dataOut_N[60] VDD VSS BUF_X1
Xoutput419 net421 dataOut_N[61] VDD VSS BUF_X1
Xoutput420 net422 dataOut_N[62] VDD VSS BUF_X1
Xoutput421 net423 dataOut_N[63] VDD VSS BUF_X1
Xoutput422 net424 dataOut_N[6] VDD VSS BUF_X1
Xoutput423 net425 dataOut_N[7] VDD VSS BUF_X1
Xoutput424 net426 dataOut_N[8] VDD VSS BUF_X1
Xoutput425 net427 dataOut_N[9] VDD VSS BUF_X1
Xoutput426 net428 dataOut_P[0] VDD VSS BUF_X1
Xoutput427 net429 dataOut_P[10] VDD VSS BUF_X1
Xoutput428 net430 dataOut_P[11] VDD VSS BUF_X1
Xoutput429 net431 dataOut_P[12] VDD VSS BUF_X1
Xoutput430 net432 dataOut_P[13] VDD VSS BUF_X1
Xoutput431 net433 dataOut_P[14] VDD VSS BUF_X1
Xoutput432 net434 dataOut_P[15] VDD VSS BUF_X1
Xoutput433 net435 dataOut_P[16] VDD VSS BUF_X1
Xoutput434 net436 dataOut_P[17] VDD VSS BUF_X1
Xoutput435 net437 dataOut_P[18] VDD VSS BUF_X1
Xoutput436 net438 dataOut_P[19] VDD VSS BUF_X1
Xoutput437 net439 dataOut_P[1] VDD VSS BUF_X1
Xoutput438 net440 dataOut_P[20] VDD VSS BUF_X1
Xoutput439 net441 dataOut_P[21] VDD VSS BUF_X1
Xoutput440 net442 dataOut_P[22] VDD VSS BUF_X1
Xoutput441 net443 dataOut_P[23] VDD VSS BUF_X1
Xoutput442 net444 dataOut_P[24] VDD VSS BUF_X1
Xoutput443 net445 dataOut_P[25] VDD VSS BUF_X1
Xoutput444 net446 dataOut_P[26] VDD VSS BUF_X1
Xoutput445 net447 dataOut_P[27] VDD VSS BUF_X1
Xoutput446 net448 dataOut_P[28] VDD VSS BUF_X1
Xoutput447 net449 dataOut_P[29] VDD VSS BUF_X1
Xoutput448 net450 dataOut_P[2] VDD VSS BUF_X1
Xoutput449 net451 dataOut_P[30] VDD VSS BUF_X1
Xoutput450 net452 dataOut_P[31] VDD VSS BUF_X1
Xoutput451 net453 dataOut_P[32] VDD VSS BUF_X1
Xoutput452 net454 dataOut_P[33] VDD VSS BUF_X1
Xoutput453 net455 dataOut_P[34] VDD VSS BUF_X1
Xoutput454 net456 dataOut_P[35] VDD VSS BUF_X1
Xoutput455 net457 dataOut_P[36] VDD VSS BUF_X1
Xoutput456 net458 dataOut_P[37] VDD VSS BUF_X1
Xoutput457 net459 dataOut_P[38] VDD VSS BUF_X1
Xoutput458 net460 dataOut_P[39] VDD VSS BUF_X1
Xoutput459 net461 dataOut_P[3] VDD VSS BUF_X1
Xoutput460 net462 dataOut_P[40] VDD VSS BUF_X1
Xoutput461 net463 dataOut_P[41] VDD VSS BUF_X1
Xoutput462 net464 dataOut_P[42] VDD VSS BUF_X1
Xoutput463 net465 dataOut_P[43] VDD VSS BUF_X1
Xoutput464 net466 dataOut_P[44] VDD VSS BUF_X1
Xoutput465 net467 dataOut_P[45] VDD VSS BUF_X1
Xoutput466 net468 dataOut_P[46] VDD VSS BUF_X1
Xoutput467 net469 dataOut_P[47] VDD VSS BUF_X1
Xoutput468 net470 dataOut_P[48] VDD VSS BUF_X1
Xoutput469 net471 dataOut_P[49] VDD VSS BUF_X1
Xoutput470 net472 dataOut_P[4] VDD VSS BUF_X1
Xoutput471 net473 dataOut_P[50] VDD VSS BUF_X1
Xoutput472 net474 dataOut_P[51] VDD VSS BUF_X1
Xoutput473 net475 dataOut_P[52] VDD VSS BUF_X1
Xoutput474 net476 dataOut_P[53] VDD VSS BUF_X1
Xoutput475 net477 dataOut_P[54] VDD VSS BUF_X1
Xoutput476 net478 dataOut_P[55] VDD VSS BUF_X1
Xoutput477 net479 dataOut_P[56] VDD VSS BUF_X1
Xoutput478 net480 dataOut_P[57] VDD VSS BUF_X1
Xoutput479 net481 dataOut_P[58] VDD VSS BUF_X1
Xoutput480 net482 dataOut_P[59] VDD VSS BUF_X1
Xoutput481 net483 dataOut_P[5] VDD VSS BUF_X1
Xoutput482 net484 dataOut_P[60] VDD VSS BUF_X1
Xoutput483 net485 dataOut_P[61] VDD VSS BUF_X1
Xoutput484 net486 dataOut_P[62] VDD VSS BUF_X1
Xoutput485 net487 dataOut_P[63] VDD VSS BUF_X1
Xoutput486 net488 dataOut_P[6] VDD VSS BUF_X1
Xoutput487 net489 dataOut_P[7] VDD VSS BUF_X1
Xoutput488 net490 dataOut_P[8] VDD VSS BUF_X1
Xoutput489 net491 dataOut_P[9] VDD VSS BUF_X1
Xoutput490 net492 dataOut_S[0] VDD VSS BUF_X1
Xoutput491 net493 dataOut_S[10] VDD VSS BUF_X1
Xoutput492 net494 dataOut_S[11] VDD VSS BUF_X1
Xoutput493 net495 dataOut_S[12] VDD VSS BUF_X1
Xoutput494 net496 dataOut_S[13] VDD VSS BUF_X1
Xoutput495 net497 dataOut_S[14] VDD VSS BUF_X1
Xoutput496 net498 dataOut_S[15] VDD VSS BUF_X1
Xoutput497 net499 dataOut_S[16] VDD VSS BUF_X1
Xoutput498 net500 dataOut_S[17] VDD VSS BUF_X1
Xoutput499 net501 dataOut_S[18] VDD VSS BUF_X1
Xoutput500 net502 dataOut_S[19] VDD VSS BUF_X1
Xoutput501 net503 dataOut_S[1] VDD VSS BUF_X1
Xoutput502 net504 dataOut_S[20] VDD VSS BUF_X1
Xoutput503 net505 dataOut_S[21] VDD VSS BUF_X1
Xoutput504 net506 dataOut_S[22] VDD VSS BUF_X1
Xoutput505 net507 dataOut_S[23] VDD VSS BUF_X1
Xoutput506 net508 dataOut_S[24] VDD VSS BUF_X1
Xoutput507 net509 dataOut_S[25] VDD VSS BUF_X1
Xoutput508 net510 dataOut_S[26] VDD VSS BUF_X1
Xoutput509 net511 dataOut_S[27] VDD VSS BUF_X1
Xoutput510 net512 dataOut_S[28] VDD VSS BUF_X1
Xoutput511 net513 dataOut_S[29] VDD VSS BUF_X1
Xoutput512 net514 dataOut_S[2] VDD VSS BUF_X1
Xoutput513 net515 dataOut_S[30] VDD VSS BUF_X1
Xoutput514 net516 dataOut_S[31] VDD VSS BUF_X1
Xoutput515 net517 dataOut_S[32] VDD VSS BUF_X1
Xoutput516 net518 dataOut_S[33] VDD VSS BUF_X1
Xoutput517 net519 dataOut_S[34] VDD VSS BUF_X1
Xoutput518 net520 dataOut_S[35] VDD VSS BUF_X1
Xoutput519 net521 dataOut_S[36] VDD VSS BUF_X1
Xoutput520 net522 dataOut_S[37] VDD VSS BUF_X1
Xoutput521 net523 dataOut_S[38] VDD VSS BUF_X1
Xoutput522 net524 dataOut_S[39] VDD VSS BUF_X1
Xoutput523 net525 dataOut_S[3] VDD VSS BUF_X1
Xoutput524 net526 dataOut_S[40] VDD VSS BUF_X1
Xoutput525 net527 dataOut_S[41] VDD VSS BUF_X1
Xoutput526 net528 dataOut_S[42] VDD VSS BUF_X1
Xoutput527 net529 dataOut_S[43] VDD VSS BUF_X1
Xoutput528 net530 dataOut_S[44] VDD VSS BUF_X1
Xoutput529 net531 dataOut_S[45] VDD VSS BUF_X1
Xoutput530 net532 dataOut_S[46] VDD VSS BUF_X1
Xoutput531 net533 dataOut_S[47] VDD VSS BUF_X1
Xoutput532 net534 dataOut_S[48] VDD VSS BUF_X1
Xoutput533 net535 dataOut_S[49] VDD VSS BUF_X1
Xoutput534 net536 dataOut_S[4] VDD VSS BUF_X1
Xoutput535 net537 dataOut_S[50] VDD VSS BUF_X1
Xoutput536 net538 dataOut_S[51] VDD VSS BUF_X1
Xoutput537 net539 dataOut_S[52] VDD VSS BUF_X1
Xoutput538 net540 dataOut_S[53] VDD VSS BUF_X1
Xoutput539 net541 dataOut_S[54] VDD VSS BUF_X1
Xoutput540 net542 dataOut_S[55] VDD VSS BUF_X1
Xoutput541 net543 dataOut_S[56] VDD VSS BUF_X1
Xoutput542 net544 dataOut_S[57] VDD VSS BUF_X1
Xoutput543 net545 dataOut_S[58] VDD VSS BUF_X1
Xoutput544 net546 dataOut_S[59] VDD VSS BUF_X1
Xoutput545 net547 dataOut_S[5] VDD VSS BUF_X1
Xoutput546 net548 dataOut_S[60] VDD VSS BUF_X1
Xoutput547 net549 dataOut_S[61] VDD VSS BUF_X1
Xoutput548 net550 dataOut_S[62] VDD VSS BUF_X1
Xoutput549 net551 dataOut_S[63] VDD VSS BUF_X1
Xoutput550 net552 dataOut_S[6] VDD VSS BUF_X1
Xoutput551 net553 dataOut_S[7] VDD VSS BUF_X1
Xoutput552 net554 dataOut_S[8] VDD VSS BUF_X1
Xoutput553 net555 dataOut_S[9] VDD VSS BUF_X1
Xoutput554 net556 dataOut_W[0] VDD VSS BUF_X1
Xoutput555 net557 dataOut_W[10] VDD VSS BUF_X1
Xoutput556 net558 dataOut_W[11] VDD VSS BUF_X1
Xoutput557 net559 dataOut_W[12] VDD VSS BUF_X1
Xoutput558 net560 dataOut_W[13] VDD VSS BUF_X1
Xoutput559 net561 dataOut_W[14] VDD VSS BUF_X1
Xoutput560 net562 dataOut_W[15] VDD VSS BUF_X1
Xoutput561 net563 dataOut_W[16] VDD VSS BUF_X1
Xoutput562 net564 dataOut_W[17] VDD VSS BUF_X1
Xoutput563 net565 dataOut_W[18] VDD VSS BUF_X1
Xoutput564 net566 dataOut_W[19] VDD VSS BUF_X1
Xoutput565 net567 dataOut_W[1] VDD VSS BUF_X1
Xoutput566 net568 dataOut_W[20] VDD VSS BUF_X1
Xoutput567 net569 dataOut_W[21] VDD VSS BUF_X1
Xoutput568 net570 dataOut_W[22] VDD VSS BUF_X1
Xoutput569 net571 dataOut_W[23] VDD VSS BUF_X1
Xoutput570 net572 dataOut_W[24] VDD VSS BUF_X1
Xoutput571 net573 dataOut_W[25] VDD VSS BUF_X1
Xoutput572 net574 dataOut_W[26] VDD VSS BUF_X1
Xoutput573 net575 dataOut_W[27] VDD VSS BUF_X1
Xoutput574 net576 dataOut_W[28] VDD VSS BUF_X1
Xoutput575 net577 dataOut_W[29] VDD VSS BUF_X1
Xoutput576 net578 dataOut_W[2] VDD VSS BUF_X1
Xoutput577 net579 dataOut_W[30] VDD VSS BUF_X1
Xoutput578 net580 dataOut_W[31] VDD VSS BUF_X1
Xoutput579 net581 dataOut_W[32] VDD VSS BUF_X1
Xoutput580 net582 dataOut_W[33] VDD VSS BUF_X1
Xoutput581 net583 dataOut_W[34] VDD VSS BUF_X1
Xoutput582 net584 dataOut_W[35] VDD VSS BUF_X1
Xoutput583 net585 dataOut_W[36] VDD VSS BUF_X1
Xoutput584 net586 dataOut_W[37] VDD VSS BUF_X1
Xoutput585 net587 dataOut_W[38] VDD VSS BUF_X1
Xoutput586 net588 dataOut_W[39] VDD VSS BUF_X1
Xoutput587 net589 dataOut_W[3] VDD VSS BUF_X1
Xoutput588 net590 dataOut_W[40] VDD VSS BUF_X1
Xoutput589 net591 dataOut_W[41] VDD VSS BUF_X1
Xoutput590 net592 dataOut_W[42] VDD VSS BUF_X1
Xoutput591 net593 dataOut_W[43] VDD VSS BUF_X1
Xoutput592 net594 dataOut_W[44] VDD VSS BUF_X1
Xoutput593 net595 dataOut_W[45] VDD VSS BUF_X1
Xoutput594 net596 dataOut_W[46] VDD VSS BUF_X1
Xoutput595 net597 dataOut_W[47] VDD VSS BUF_X1
Xoutput596 net598 dataOut_W[48] VDD VSS BUF_X1
Xoutput597 net599 dataOut_W[49] VDD VSS BUF_X1
Xoutput598 net600 dataOut_W[4] VDD VSS BUF_X1
Xoutput599 net601 dataOut_W[50] VDD VSS BUF_X1
Xoutput600 net602 dataOut_W[51] VDD VSS BUF_X1
Xoutput601 net603 dataOut_W[52] VDD VSS BUF_X1
Xoutput602 net604 dataOut_W[53] VDD VSS BUF_X1
Xoutput603 net605 dataOut_W[54] VDD VSS BUF_X1
Xoutput604 net606 dataOut_W[55] VDD VSS BUF_X1
Xoutput605 net607 dataOut_W[56] VDD VSS BUF_X1
Xoutput606 net608 dataOut_W[57] VDD VSS BUF_X1
Xoutput607 net609 dataOut_W[58] VDD VSS BUF_X1
Xoutput608 net610 dataOut_W[59] VDD VSS BUF_X1
Xoutput609 net611 dataOut_W[5] VDD VSS BUF_X1
Xoutput610 net612 dataOut_W[60] VDD VSS BUF_X1
Xoutput611 net613 dataOut_W[61] VDD VSS BUF_X1
Xoutput612 net614 dataOut_W[62] VDD VSS BUF_X1
Xoutput613 net615 dataOut_W[63] VDD VSS BUF_X1
Xoutput614 net616 dataOut_W[6] VDD VSS BUF_X1
Xoutput615 net617 dataOut_W[7] VDD VSS BUF_X1
Xoutput616 net618 dataOut_W[8] VDD VSS BUF_X1
Xoutput617 net619 dataOut_W[9] VDD VSS BUF_X1
Xoutput618 net620 thanksIn_P VDD VSS BUF_X2
Xoutput619 net621 validOut_E VDD VSS BUF_X1
Xoutput620 net622 validOut_N VDD VSS BUF_X2
Xoutput621 net623 validOut_P VDD VSS BUF_X1
Xoutput622 net624 validOut_S VDD VSS BUF_X2
Xoutput623 net756 validOut_W VDD VSS BUF_X2
Xoutput624 net626 yummyOut_E VDD VSS BUF_X1
Xoutput625 net627 yummyOut_N VDD VSS BUF_X1
Xoutput626 net628 yummyOut_P VDD VSS BUF_X1
Xoutput627 net629 yummyOut_S VDD VSS BUF_X1
Xoutput628 net630 yummyOut_W VDD VSS BUF_X1
Xclkbuf_leaf_0_clk clknet_5_0__leaf_clk clknet_leaf_0_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_1_clk clknet_5_1__leaf_clk clknet_leaf_1_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_2_clk clknet_5_1__leaf_clk clknet_leaf_2_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_3_clk clknet_5_1__leaf_clk clknet_leaf_3_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_4_clk clknet_5_4__leaf_clk clknet_leaf_4_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_5_clk clknet_5_1__leaf_clk clknet_leaf_5_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_6_clk clknet_5_1__leaf_clk clknet_leaf_6_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_7_clk clknet_5_1__leaf_clk clknet_leaf_7_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_8_clk clknet_5_1__leaf_clk clknet_leaf_8_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_9_clk clknet_5_0__leaf_clk clknet_leaf_9_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_10_clk clknet_5_0__leaf_clk clknet_leaf_10_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_11_clk clknet_5_0__leaf_clk clknet_leaf_11_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_12_clk clknet_5_0__leaf_clk clknet_leaf_12_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_13_clk clknet_5_0__leaf_clk clknet_leaf_13_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_14_clk clknet_5_0__leaf_clk clknet_leaf_14_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_15_clk clknet_5_0__leaf_clk clknet_leaf_15_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_16_clk clknet_5_2__leaf_clk clknet_leaf_16_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_17_clk clknet_5_2__leaf_clk clknet_leaf_17_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_18_clk clknet_5_2__leaf_clk clknet_leaf_18_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_19_clk clknet_5_2__leaf_clk clknet_leaf_19_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_20_clk clknet_5_2__leaf_clk clknet_leaf_20_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_21_clk clknet_5_2__leaf_clk clknet_leaf_21_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_22_clk clknet_5_2__leaf_clk clknet_leaf_22_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_23_clk clknet_5_3__leaf_clk clknet_leaf_23_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_24_clk clknet_5_3__leaf_clk clknet_leaf_24_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_25_clk clknet_5_3__leaf_clk clknet_leaf_25_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_26_clk clknet_5_3__leaf_clk clknet_leaf_26_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_27_clk clknet_5_6__leaf_clk clknet_leaf_27_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_28_clk clknet_5_6__leaf_clk clknet_leaf_28_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_29_clk clknet_5_3__leaf_clk clknet_leaf_29_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_30_clk clknet_5_3__leaf_clk clknet_leaf_30_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_31_clk clknet_5_3__leaf_clk clknet_leaf_31_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_32_clk clknet_5_6__leaf_clk clknet_leaf_32_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_33_clk clknet_5_1__leaf_clk clknet_leaf_33_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_34_clk clknet_5_4__leaf_clk clknet_leaf_34_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_35_clk clknet_5_4__leaf_clk clknet_leaf_35_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_36_clk clknet_5_6__leaf_clk clknet_leaf_36_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_37_clk clknet_5_6__leaf_clk clknet_leaf_37_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_38_clk clknet_5_7__leaf_clk clknet_leaf_38_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_39_clk clknet_5_6__leaf_clk clknet_leaf_39_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_40_clk clknet_5_6__leaf_clk clknet_leaf_40_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_41_clk clknet_5_6__leaf_clk clknet_leaf_41_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_42_clk clknet_5_6__leaf_clk clknet_leaf_42_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_43_clk clknet_5_6__leaf_clk clknet_leaf_43_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_44_clk clknet_5_7__leaf_clk clknet_leaf_44_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_45_clk clknet_5_6__leaf_clk clknet_leaf_45_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_46_clk clknet_5_7__leaf_clk clknet_leaf_46_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_47_clk clknet_5_7__leaf_clk clknet_leaf_47_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_48_clk clknet_5_7__leaf_clk clknet_leaf_48_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_49_clk clknet_5_7__leaf_clk clknet_leaf_49_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_50_clk clknet_5_13__leaf_clk clknet_leaf_50_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_51_clk clknet_5_13__leaf_clk clknet_leaf_51_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_52_clk clknet_5_13__leaf_clk clknet_leaf_52_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_53_clk clknet_5_12__leaf_clk clknet_leaf_53_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_54_clk clknet_5_12__leaf_clk clknet_leaf_54_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_55_clk clknet_5_12__leaf_clk clknet_leaf_55_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_56_clk clknet_5_12__leaf_clk clknet_leaf_56_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_57_clk clknet_5_12__leaf_clk clknet_leaf_57_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_58_clk clknet_5_12__leaf_clk clknet_leaf_58_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_59_clk clknet_5_12__leaf_clk clknet_leaf_59_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_60_clk clknet_5_12__leaf_clk clknet_leaf_60_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_61_clk clknet_5_12__leaf_clk clknet_leaf_61_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_62_clk clknet_5_14__leaf_clk clknet_leaf_62_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_63_clk clknet_5_14__leaf_clk clknet_leaf_63_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_64_clk clknet_5_12__leaf_clk clknet_leaf_64_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_65_clk clknet_5_12__leaf_clk clknet_leaf_65_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_66_clk clknet_5_9__leaf_clk clknet_leaf_66_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_67_clk clknet_5_9__leaf_clk clknet_leaf_67_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_68_clk clknet_5_9__leaf_clk clknet_leaf_68_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_69_clk clknet_5_12__leaf_clk clknet_leaf_69_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_70_clk clknet_5_12__leaf_clk clknet_leaf_70_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_71_clk clknet_5_3__leaf_clk clknet_leaf_71_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_72_clk clknet_5_3__leaf_clk clknet_leaf_72_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_73_clk clknet_5_9__leaf_clk clknet_leaf_73_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_74_clk clknet_5_9__leaf_clk clknet_leaf_74_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_75_clk clknet_5_9__leaf_clk clknet_leaf_75_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_76_clk clknet_5_2__leaf_clk clknet_leaf_76_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_77_clk clknet_5_2__leaf_clk clknet_leaf_77_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_78_clk clknet_5_8__leaf_clk clknet_leaf_78_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_79_clk clknet_5_8__leaf_clk clknet_leaf_79_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_80_clk clknet_5_8__leaf_clk clknet_leaf_80_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_81_clk clknet_5_8__leaf_clk clknet_leaf_81_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_82_clk clknet_5_8__leaf_clk clknet_leaf_82_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_83_clk clknet_5_8__leaf_clk clknet_leaf_83_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_84_clk clknet_5_10__leaf_clk clknet_leaf_84_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_85_clk clknet_5_10__leaf_clk clknet_leaf_85_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_86_clk clknet_5_10__leaf_clk clknet_leaf_86_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_87_clk clknet_5_8__leaf_clk clknet_leaf_87_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_88_clk clknet_5_9__leaf_clk clknet_leaf_88_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_89_clk clknet_5_9__leaf_clk clknet_leaf_89_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_90_clk clknet_5_11__leaf_clk clknet_leaf_90_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_91_clk clknet_5_11__leaf_clk clknet_leaf_91_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_92_clk clknet_5_11__leaf_clk clknet_leaf_92_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_93_clk clknet_5_11__leaf_clk clknet_leaf_93_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_94_clk clknet_5_11__leaf_clk clknet_leaf_94_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_95_clk clknet_5_11__leaf_clk clknet_leaf_95_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_96_clk clknet_5_10__leaf_clk clknet_leaf_96_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_97_clk clknet_5_11__leaf_clk clknet_leaf_97_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_98_clk clknet_5_10__leaf_clk clknet_leaf_98_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_99_clk clknet_5_10__leaf_clk clknet_leaf_99_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_100_clk clknet_5_10__leaf_clk clknet_leaf_100_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_101_clk clknet_5_10__leaf_clk clknet_leaf_101_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_102_clk clknet_5_10__leaf_clk clknet_leaf_102_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_103_clk clknet_5_11__leaf_clk clknet_leaf_103_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_104_clk clknet_5_11__leaf_clk clknet_leaf_104_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_105_clk clknet_5_11__leaf_clk clknet_leaf_105_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_106_clk clknet_5_14__leaf_clk clknet_leaf_106_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_107_clk clknet_5_14__leaf_clk clknet_leaf_107_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_108_clk clknet_5_15__leaf_clk clknet_leaf_108_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_109_clk clknet_5_15__leaf_clk clknet_leaf_109_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_110_clk clknet_5_15__leaf_clk clknet_leaf_110_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_111_clk clknet_5_15__leaf_clk clknet_leaf_111_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_112_clk clknet_5_14__leaf_clk clknet_leaf_112_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_113_clk clknet_5_14__leaf_clk clknet_leaf_113_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_114_clk clknet_5_14__leaf_clk clknet_leaf_114_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_115_clk clknet_5_14__leaf_clk clknet_leaf_115_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_116_clk clknet_5_14__leaf_clk clknet_leaf_116_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_117_clk clknet_5_14__leaf_clk clknet_leaf_117_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_118_clk clknet_5_12__leaf_clk clknet_leaf_118_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_119_clk clknet_5_13__leaf_clk clknet_leaf_119_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_120_clk clknet_5_15__leaf_clk clknet_leaf_120_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_121_clk clknet_5_15__leaf_clk clknet_leaf_121_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_122_clk clknet_5_15__leaf_clk clknet_leaf_122_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_123_clk clknet_5_15__leaf_clk clknet_leaf_123_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_124_clk clknet_5_15__leaf_clk clknet_leaf_124_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_125_clk clknet_5_13__leaf_clk clknet_leaf_125_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_126_clk clknet_5_13__leaf_clk clknet_leaf_126_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_127_clk clknet_5_13__leaf_clk clknet_leaf_127_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_128_clk clknet_5_13__leaf_clk clknet_leaf_128_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_129_clk clknet_5_13__leaf_clk clknet_leaf_129_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_130_clk clknet_5_13__leaf_clk clknet_leaf_130_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_131_clk clknet_5_24__leaf_clk clknet_leaf_131_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_132_clk clknet_5_24__leaf_clk clknet_leaf_132_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_133_clk clknet_5_24__leaf_clk clknet_leaf_133_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_134_clk clknet_5_24__leaf_clk clknet_leaf_134_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_135_clk clknet_5_24__leaf_clk clknet_leaf_135_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_136_clk clknet_5_24__leaf_clk clknet_leaf_136_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_137_clk clknet_5_26__leaf_clk clknet_leaf_137_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_138_clk clknet_5_26__leaf_clk clknet_leaf_138_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_139_clk clknet_5_24__leaf_clk clknet_leaf_139_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_140_clk clknet_5_27__leaf_clk clknet_leaf_140_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_141_clk clknet_5_27__leaf_clk clknet_leaf_141_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_142_clk clknet_5_27__leaf_clk clknet_leaf_142_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_143_clk clknet_5_27__leaf_clk clknet_leaf_143_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_144_clk clknet_5_26__leaf_clk clknet_leaf_144_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_145_clk clknet_5_26__leaf_clk clknet_leaf_145_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_146_clk clknet_5_26__leaf_clk clknet_leaf_146_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_147_clk clknet_5_26__leaf_clk clknet_leaf_147_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_148_clk clknet_5_26__leaf_clk clknet_leaf_148_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_149_clk clknet_5_26__leaf_clk clknet_leaf_149_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_150_clk clknet_5_26__leaf_clk clknet_leaf_150_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_151_clk clknet_5_26__leaf_clk clknet_leaf_151_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_152_clk clknet_5_26__leaf_clk clknet_leaf_152_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_153_clk clknet_5_26__leaf_clk clknet_leaf_153_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_154_clk clknet_5_27__leaf_clk clknet_leaf_154_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_155_clk clknet_5_27__leaf_clk clknet_leaf_155_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_156_clk clknet_5_27__leaf_clk clknet_leaf_156_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_157_clk clknet_5_27__leaf_clk clknet_leaf_157_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_158_clk clknet_5_27__leaf_clk clknet_leaf_158_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_159_clk clknet_5_27__leaf_clk clknet_leaf_159_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_160_clk clknet_5_30__leaf_clk clknet_leaf_160_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_161_clk clknet_5_30__leaf_clk clknet_leaf_161_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_162_clk clknet_5_30__leaf_clk clknet_leaf_162_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_163_clk clknet_5_30__leaf_clk clknet_leaf_163_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_164_clk clknet_5_30__leaf_clk clknet_leaf_164_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_165_clk clknet_5_30__leaf_clk clknet_leaf_165_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_166_clk clknet_5_31__leaf_clk clknet_leaf_166_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_167_clk clknet_5_31__leaf_clk clknet_leaf_167_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_168_clk clknet_5_31__leaf_clk clknet_leaf_168_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_169_clk clknet_5_31__leaf_clk clknet_leaf_169_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_170_clk clknet_5_31__leaf_clk clknet_leaf_170_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_171_clk clknet_5_31__leaf_clk clknet_leaf_171_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_172_clk clknet_5_31__leaf_clk clknet_leaf_172_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_173_clk clknet_5_31__leaf_clk clknet_leaf_173_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_174_clk clknet_5_31__leaf_clk clknet_leaf_174_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_175_clk clknet_5_30__leaf_clk clknet_leaf_175_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_176_clk clknet_5_30__leaf_clk clknet_leaf_176_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_177_clk clknet_5_30__leaf_clk clknet_leaf_177_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_178_clk clknet_5_29__leaf_clk clknet_leaf_178_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_179_clk clknet_5_31__leaf_clk clknet_leaf_179_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_180_clk clknet_5_31__leaf_clk clknet_leaf_180_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_181_clk clknet_5_31__leaf_clk clknet_leaf_181_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_182_clk clknet_5_29__leaf_clk clknet_leaf_182_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_183_clk clknet_5_29__leaf_clk clknet_leaf_183_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_184_clk clknet_5_29__leaf_clk clknet_leaf_184_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_185_clk clknet_5_29__leaf_clk clknet_leaf_185_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_186_clk clknet_5_29__leaf_clk clknet_leaf_186_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_187_clk clknet_5_29__leaf_clk clknet_leaf_187_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_188_clk clknet_5_29__leaf_clk clknet_leaf_188_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_189_clk clknet_5_29__leaf_clk clknet_leaf_189_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_190_clk clknet_5_28__leaf_clk clknet_leaf_190_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_191_clk clknet_5_28__leaf_clk clknet_leaf_191_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_192_clk clknet_5_28__leaf_clk clknet_leaf_192_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_193_clk clknet_5_28__leaf_clk clknet_leaf_193_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_194_clk clknet_5_28__leaf_clk clknet_leaf_194_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_195_clk clknet_5_28__leaf_clk clknet_leaf_195_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_196_clk clknet_5_25__leaf_clk clknet_leaf_196_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_197_clk clknet_5_25__leaf_clk clknet_leaf_197_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_198_clk clknet_5_25__leaf_clk clknet_leaf_198_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_199_clk clknet_5_25__leaf_clk clknet_leaf_199_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_200_clk clknet_5_24__leaf_clk clknet_leaf_200_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_201_clk clknet_5_24__leaf_clk clknet_leaf_201_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_202_clk clknet_5_24__leaf_clk clknet_leaf_202_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_203_clk clknet_5_25__leaf_clk clknet_leaf_203_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_204_clk clknet_5_18__leaf_clk clknet_leaf_204_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_205_clk clknet_5_19__leaf_clk clknet_leaf_205_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_206_clk clknet_5_25__leaf_clk clknet_leaf_206_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_207_clk clknet_5_22__leaf_clk clknet_leaf_207_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_208_clk clknet_5_22__leaf_clk clknet_leaf_208_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_209_clk clknet_5_22__leaf_clk clknet_leaf_209_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_210_clk clknet_5_22__leaf_clk clknet_leaf_210_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_211_clk clknet_5_28__leaf_clk clknet_leaf_211_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_212_clk clknet_5_22__leaf_clk clknet_leaf_212_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_213_clk clknet_5_22__leaf_clk clknet_leaf_213_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_214_clk clknet_5_22__leaf_clk clknet_leaf_214_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_215_clk clknet_5_28__leaf_clk clknet_leaf_215_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_216_clk clknet_5_29__leaf_clk clknet_leaf_216_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_217_clk clknet_5_29__leaf_clk clknet_leaf_217_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_218_clk clknet_5_23__leaf_clk clknet_leaf_218_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_219_clk clknet_5_23__leaf_clk clknet_leaf_219_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_220_clk clknet_5_23__leaf_clk clknet_leaf_220_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_221_clk clknet_5_22__leaf_clk clknet_leaf_221_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_222_clk clknet_5_22__leaf_clk clknet_leaf_222_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_223_clk clknet_5_23__leaf_clk clknet_leaf_223_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_224_clk clknet_5_23__leaf_clk clknet_leaf_224_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_225_clk clknet_5_23__leaf_clk clknet_leaf_225_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_226_clk clknet_5_23__leaf_clk clknet_leaf_226_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_227_clk clknet_5_23__leaf_clk clknet_leaf_227_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_228_clk clknet_5_23__leaf_clk clknet_leaf_228_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_229_clk clknet_5_23__leaf_clk clknet_leaf_229_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_230_clk clknet_5_22__leaf_clk clknet_leaf_230_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_231_clk clknet_5_22__leaf_clk clknet_leaf_231_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_232_clk clknet_5_22__leaf_clk clknet_leaf_232_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_233_clk clknet_5_22__leaf_clk clknet_leaf_233_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_234_clk clknet_5_20__leaf_clk clknet_leaf_234_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_235_clk clknet_5_20__leaf_clk clknet_leaf_235_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_236_clk clknet_5_21__leaf_clk clknet_leaf_236_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_237_clk clknet_5_20__leaf_clk clknet_leaf_237_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_238_clk clknet_5_21__leaf_clk clknet_leaf_238_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_239_clk clknet_5_23__leaf_clk clknet_leaf_239_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_240_clk clknet_5_23__leaf_clk clknet_leaf_240_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_241_clk clknet_5_23__leaf_clk clknet_leaf_241_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_242_clk clknet_5_21__leaf_clk clknet_leaf_242_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_243_clk clknet_5_21__leaf_clk clknet_leaf_243_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_244_clk clknet_5_21__leaf_clk clknet_leaf_244_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_245_clk clknet_5_21__leaf_clk clknet_leaf_245_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_246_clk clknet_5_21__leaf_clk clknet_leaf_246_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_247_clk clknet_5_21__leaf_clk clknet_leaf_247_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_248_clk clknet_5_21__leaf_clk clknet_leaf_248_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_249_clk clknet_5_21__leaf_clk clknet_leaf_249_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_250_clk clknet_5_20__leaf_clk clknet_leaf_250_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_251_clk clknet_5_20__leaf_clk clknet_leaf_251_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_252_clk clknet_5_20__leaf_clk clknet_leaf_252_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_253_clk clknet_5_20__leaf_clk clknet_leaf_253_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_254_clk clknet_5_20__leaf_clk clknet_leaf_254_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_255_clk clknet_5_20__leaf_clk clknet_leaf_255_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_256_clk clknet_5_20__leaf_clk clknet_leaf_256_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_257_clk clknet_5_20__leaf_clk clknet_leaf_257_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_258_clk clknet_5_20__leaf_clk clknet_leaf_258_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_259_clk clknet_5_20__leaf_clk clknet_leaf_259_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_260_clk clknet_5_20__leaf_clk clknet_leaf_260_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_261_clk clknet_5_20__leaf_clk clknet_leaf_261_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_262_clk clknet_5_17__leaf_clk clknet_leaf_262_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_263_clk clknet_5_17__leaf_clk clknet_leaf_263_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_264_clk clknet_5_17__leaf_clk clknet_leaf_264_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_265_clk clknet_5_17__leaf_clk clknet_leaf_265_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_266_clk clknet_5_17__leaf_clk clknet_leaf_266_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_267_clk clknet_5_17__leaf_clk clknet_leaf_267_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_268_clk clknet_5_17__leaf_clk clknet_leaf_268_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_269_clk clknet_5_17__leaf_clk clknet_leaf_269_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_270_clk clknet_5_17__leaf_clk clknet_leaf_270_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_271_clk clknet_5_16__leaf_clk clknet_leaf_271_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_272_clk clknet_5_16__leaf_clk clknet_leaf_272_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_273_clk clknet_5_16__leaf_clk clknet_leaf_273_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_274_clk clknet_5_16__leaf_clk clknet_leaf_274_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_275_clk clknet_5_16__leaf_clk clknet_leaf_275_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_276_clk clknet_5_16__leaf_clk clknet_leaf_276_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_277_clk clknet_5_16__leaf_clk clknet_leaf_277_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_278_clk clknet_5_16__leaf_clk clknet_leaf_278_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_279_clk clknet_5_16__leaf_clk clknet_leaf_279_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_280_clk clknet_5_16__leaf_clk clknet_leaf_280_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_281_clk clknet_5_18__leaf_clk clknet_leaf_281_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_282_clk clknet_5_18__leaf_clk clknet_leaf_282_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_283_clk clknet_5_19__leaf_clk clknet_leaf_283_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_284_clk clknet_5_16__leaf_clk clknet_leaf_284_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_285_clk clknet_5_17__leaf_clk clknet_leaf_285_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_286_clk clknet_5_17__leaf_clk clknet_leaf_286_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_287_clk clknet_5_19__leaf_clk clknet_leaf_287_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_288_clk clknet_5_17__leaf_clk clknet_leaf_288_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_289_clk clknet_5_19__leaf_clk clknet_leaf_289_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_290_clk clknet_5_19__leaf_clk clknet_leaf_290_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_291_clk clknet_5_19__leaf_clk clknet_leaf_291_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_292_clk clknet_5_19__leaf_clk clknet_leaf_292_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_293_clk clknet_5_19__leaf_clk clknet_leaf_293_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_294_clk clknet_5_18__leaf_clk clknet_leaf_294_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_295_clk clknet_5_19__leaf_clk clknet_leaf_295_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_296_clk clknet_5_18__leaf_clk clknet_leaf_296_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_297_clk clknet_5_18__leaf_clk clknet_leaf_297_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_298_clk clknet_5_18__leaf_clk clknet_leaf_298_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_299_clk clknet_5_18__leaf_clk clknet_leaf_299_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_300_clk clknet_5_18__leaf_clk clknet_leaf_300_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_301_clk clknet_5_18__leaf_clk clknet_leaf_301_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_302_clk clknet_5_24__leaf_clk clknet_leaf_302_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_303_clk clknet_5_18__leaf_clk clknet_leaf_303_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_304_clk clknet_5_18__leaf_clk clknet_leaf_304_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_305_clk clknet_5_7__leaf_clk clknet_leaf_305_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_306_clk clknet_5_7__leaf_clk clknet_leaf_306_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_307_clk clknet_5_7__leaf_clk clknet_leaf_307_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_308_clk clknet_5_18__leaf_clk clknet_leaf_308_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_309_clk clknet_5_5__leaf_clk clknet_leaf_309_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_310_clk clknet_5_5__leaf_clk clknet_leaf_310_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_311_clk clknet_5_5__leaf_clk clknet_leaf_311_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_312_clk clknet_5_7__leaf_clk clknet_leaf_312_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_313_clk clknet_5_5__leaf_clk clknet_leaf_313_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_314_clk clknet_5_5__leaf_clk clknet_leaf_314_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_315_clk clknet_5_4__leaf_clk clknet_leaf_315_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_316_clk clknet_5_4__leaf_clk clknet_leaf_316_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_317_clk clknet_5_4__leaf_clk clknet_leaf_317_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_318_clk clknet_5_5__leaf_clk clknet_leaf_318_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_319_clk clknet_5_5__leaf_clk clknet_leaf_319_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_320_clk clknet_5_5__leaf_clk clknet_leaf_320_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_321_clk clknet_5_4__leaf_clk clknet_leaf_321_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_322_clk clknet_5_4__leaf_clk clknet_leaf_322_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_323_clk clknet_5_1__leaf_clk clknet_leaf_323_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_324_clk clknet_5_0__leaf_clk clknet_leaf_324_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_325_clk clknet_5_0__leaf_clk clknet_leaf_325_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_326_clk clknet_5_0__leaf_clk clknet_leaf_326_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_327_clk clknet_5_0__leaf_clk clknet_leaf_327_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_0_0_clk clknet_0_clk clknet_4_0_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_1_0_clk clknet_0_clk clknet_4_1_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_2_0_clk clknet_0_clk clknet_4_2_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_3_0_clk clknet_0_clk clknet_4_3_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_4_0_clk clknet_0_clk clknet_4_4_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_5_0_clk clknet_0_clk clknet_4_5_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_6_0_clk clknet_0_clk clknet_4_6_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_7_0_clk clknet_0_clk clknet_4_7_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_8_0_clk clknet_0_clk clknet_4_8_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_9_0_clk clknet_0_clk clknet_4_9_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_10_0_clk clknet_0_clk clknet_4_10_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_11_0_clk clknet_0_clk clknet_4_11_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_12_0_clk clknet_0_clk clknet_4_12_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_13_0_clk clknet_0_clk clknet_4_13_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_14_0_clk clknet_0_clk clknet_4_14_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_15_0_clk clknet_0_clk clknet_4_15_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_5_0__f_clk clknet_4_0_0_clk clknet_5_0__leaf_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_5_1__f_clk clknet_4_0_0_clk clknet_5_1__leaf_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_5_2__f_clk clknet_4_1_0_clk clknet_5_2__leaf_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_5_3__f_clk clknet_4_1_0_clk clknet_5_3__leaf_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_5_4__f_clk clknet_4_2_0_clk clknet_5_4__leaf_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_5_5__f_clk clknet_4_2_0_clk clknet_5_5__leaf_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_5_6__f_clk clknet_4_3_0_clk clknet_5_6__leaf_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_5_7__f_clk clknet_4_3_0_clk clknet_5_7__leaf_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_5_8__f_clk clknet_4_4_0_clk clknet_5_8__leaf_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_5_9__f_clk clknet_4_4_0_clk clknet_5_9__leaf_clk VDD
+ VSS CLKBUF_X3
Xclkbuf_5_10__f_clk clknet_4_5_0_clk clknet_5_10__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_11__f_clk clknet_4_5_0_clk clknet_5_11__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_12__f_clk clknet_4_6_0_clk clknet_5_12__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_13__f_clk clknet_4_6_0_clk clknet_5_13__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_14__f_clk clknet_4_7_0_clk clknet_5_14__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_15__f_clk clknet_4_7_0_clk clknet_5_15__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_16__f_clk clknet_4_8_0_clk clknet_5_16__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_17__f_clk clknet_4_8_0_clk clknet_5_17__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_18__f_clk clknet_4_9_0_clk clknet_5_18__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_19__f_clk clknet_4_9_0_clk clknet_5_19__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_20__f_clk clknet_4_10_0_clk clknet_5_20__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_21__f_clk clknet_4_10_0_clk clknet_5_21__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_22__f_clk clknet_4_11_0_clk clknet_5_22__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_23__f_clk clknet_4_11_0_clk clknet_5_23__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_24__f_clk clknet_4_12_0_clk clknet_5_24__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_25__f_clk clknet_4_12_0_clk clknet_5_25__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_26__f_clk clknet_4_13_0_clk clknet_5_26__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_27__f_clk clknet_4_13_0_clk clknet_5_27__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_28__f_clk clknet_4_14_0_clk clknet_5_28__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_29__f_clk clknet_4_14_0_clk clknet_5_29__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_30__f_clk clknet_4_15_0_clk clknet_5_30__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_5_31__f_clk clknet_4_15_0_clk clknet_5_31__leaf_clk
+ VDD VSS CLKBUF_X3
Xclkload0 clknet_5_1__leaf_clk _unconnected_0 VDD VSS INV_X2
Xclkload1 clknet_5_7__leaf_clk _unconnected_1 VDD VSS CLKBUF_X3
Xclkload2 clknet_5_8__leaf_clk _unconnected_2 VDD VSS CLKBUF_X3
Xclkload3 clknet_5_10__leaf_clk _unconnected_3 VDD VSS CLKBUF_X3
Xclkload4 clknet_5_13__leaf_clk _unconnected_4 VDD VSS INV_X4
Xclkload5 clknet_5_15__leaf_clk _unconnected_5 VDD VSS CLKBUF_X3
Xclkload6 clknet_5_16__leaf_clk _unconnected_6 VDD VSS CLKBUF_X3
Xclkload7 clknet_5_19__leaf_clk _unconnected_7 VDD VSS INV_X4
Xclkload8 clknet_5_21__leaf_clk _unconnected_8 VDD VSS INV_X4
Xclkload9 clknet_5_25__leaf_clk _unconnected_9 VDD VSS INV_X4
Xclkload10 clknet_5_27__leaf_clk _unconnected_10 VDD VSS INV_X2
Xclkload11 clknet_5_28__leaf_clk _unconnected_11 VDD VSS INV_X2
Xclkload12 clknet_5_30__leaf_clk _unconnected_12 VDD VSS INV_X2
Xclkload13 clknet_leaf_9_clk _unconnected_13 VDD VSS CLKBUF_X1
Xclkload14 clknet_leaf_10_clk _unconnected_14 VDD VSS CLKBUF_X1
Xclkload15 clknet_leaf_12_clk _unconnected_15 VDD VSS CLKBUF_X1
Xclkload16 clknet_leaf_13_clk _unconnected_16 VDD VSS CLKBUF_X1
Xclkload17 clknet_leaf_324_clk _unconnected_17 VDD VSS INV_X1
Xclkload18 clknet_leaf_325_clk _unconnected_18 VDD VSS INV_X1
Xclkload19 clknet_leaf_326_clk _unconnected_19 VDD VSS CLKBUF_X1
Xclkload20 clknet_leaf_327_clk _unconnected_20 VDD VSS CLKBUF_X1
Xclkload21 clknet_leaf_1_clk _unconnected_21 VDD VSS CLKBUF_X1
Xclkload22 clknet_leaf_2_clk _unconnected_22 VDD VSS CLKBUF_X1
Xclkload23 clknet_leaf_3_clk _unconnected_23 VDD VSS INV_X1
Xclkload24 clknet_leaf_5_clk _unconnected_24 VDD VSS CLKBUF_X1
Xclkload25 clknet_leaf_6_clk _unconnected_25 VDD VSS INV_X1
Xclkload26 clknet_leaf_8_clk _unconnected_26 VDD VSS CLKBUF_X1
Xclkload27 clknet_leaf_33_clk _unconnected_27 VDD VSS CLKBUF_X1
Xclkload28 clknet_leaf_323_clk _unconnected_28 VDD VSS CLKBUF_X1
Xclkload29 clknet_leaf_17_clk _unconnected_29 VDD VSS INV_X1
Xclkload30 clknet_leaf_18_clk _unconnected_30 VDD VSS CLKBUF_X1
Xclkload31 clknet_leaf_20_clk _unconnected_31 VDD VSS CLKBUF_X1
Xclkload32 clknet_leaf_21_clk _unconnected_32 VDD VSS CLKBUF_X1
Xclkload33 clknet_leaf_22_clk _unconnected_33 VDD VSS CLKBUF_X1
Xclkload34 clknet_leaf_76_clk _unconnected_34 VDD VSS CLKBUF_X1
Xclkload35 clknet_leaf_77_clk _unconnected_35 VDD VSS CLKBUF_X1
Xclkload36 clknet_leaf_23_clk _unconnected_36 VDD VSS INV_X1
Xclkload37 clknet_leaf_24_clk _unconnected_37 VDD VSS CLKBUF_X1
Xclkload38 clknet_leaf_25_clk _unconnected_38 VDD VSS INV_X1
Xclkload39 clknet_leaf_29_clk _unconnected_39 VDD VSS CLKBUF_X1
Xclkload40 clknet_leaf_30_clk _unconnected_40 VDD VSS INV_X1
Xclkload41 clknet_leaf_31_clk _unconnected_41 VDD VSS INV_X1
Xclkload42 clknet_leaf_71_clk _unconnected_42 VDD VSS INV_X1
Xclkload43 clknet_leaf_72_clk _unconnected_43 VDD VSS INV_X1
Xclkload44 clknet_leaf_4_clk _unconnected_44 VDD VSS CLKBUF_X1
Xclkload45 clknet_leaf_317_clk _unconnected_45 VDD VSS CLKBUF_X1
Xclkload46 clknet_leaf_321_clk _unconnected_46 VDD VSS CLKBUF_X1
Xclkload47 clknet_leaf_322_clk _unconnected_47 VDD VSS INV_X1
Xclkload48 clknet_leaf_310_clk _unconnected_48 VDD VSS CLKBUF_X1
Xclkload49 clknet_leaf_311_clk _unconnected_49 VDD VSS CLKBUF_X1
Xclkload50 clknet_leaf_314_clk _unconnected_50 VDD VSS CLKBUF_X1
Xclkload51 clknet_leaf_318_clk _unconnected_51 VDD VSS CLKBUF_X1
Xclkload52 clknet_leaf_319_clk _unconnected_52 VDD VSS CLKBUF_X1
Xclkload53 clknet_leaf_320_clk _unconnected_53 VDD VSS INV_X1
Xclkload54 clknet_leaf_36_clk _unconnected_54 VDD VSS CLKBUF_X1
Xclkload55 clknet_leaf_37_clk _unconnected_55 VDD VSS CLKBUF_X1
Xclkload56 clknet_leaf_40_clk _unconnected_56 VDD VSS CLKBUF_X1
Xclkload57 clknet_leaf_45_clk _unconnected_57 VDD VSS CLKBUF_X1
Xclkload58 clknet_leaf_44_clk _unconnected_58 VDD VSS CLKBUF_X1
Xclkload59 clknet_leaf_46_clk _unconnected_59 VDD VSS INV_X1
Xclkload60 clknet_leaf_47_clk _unconnected_60 VDD VSS CLKBUF_X1
Xclkload61 clknet_leaf_48_clk _unconnected_61 VDD VSS INV_X1
Xclkload62 clknet_leaf_49_clk _unconnected_62 VDD VSS CLKBUF_X1
Xclkload63 clknet_leaf_305_clk _unconnected_63 VDD VSS INV_X1
Xclkload64 clknet_leaf_306_clk _unconnected_64 VDD VSS CLKBUF_X1
Xclkload65 clknet_leaf_307_clk _unconnected_65 VDD VSS CLKBUF_X1
Xclkload66 clknet_leaf_78_clk _unconnected_66 VDD VSS INV_X2
Xclkload67 clknet_leaf_79_clk _unconnected_67 VDD VSS INV_X1
Xclkload68 clknet_leaf_80_clk _unconnected_68 VDD VSS INV_X1
Xclkload69 clknet_leaf_81_clk _unconnected_69 VDD VSS CLKBUF_X1
Xclkload70 clknet_leaf_82_clk _unconnected_70 VDD VSS INV_X2
Xclkload71 clknet_leaf_83_clk _unconnected_71 VDD VSS INV_X1
Xclkload72 clknet_leaf_67_clk _unconnected_72 VDD VSS INV_X1
Xclkload73 clknet_leaf_68_clk _unconnected_73 VDD VSS CLKBUF_X1
Xclkload74 clknet_leaf_73_clk _unconnected_74 VDD VSS CLKBUF_X1
Xclkload75 clknet_leaf_74_clk _unconnected_75 VDD VSS INV_X1
Xclkload76 clknet_leaf_75_clk _unconnected_76 VDD VSS INV_X1
Xclkload77 clknet_leaf_88_clk _unconnected_77 VDD VSS CLKBUF_X1
Xclkload78 clknet_leaf_89_clk _unconnected_78 VDD VSS INV_X1
Xclkload79 clknet_leaf_86_clk _unconnected_79 VDD VSS INV_X1
Xclkload80 clknet_leaf_98_clk _unconnected_80 VDD VSS CLKBUF_X1
Xclkload81 clknet_leaf_90_clk _unconnected_81 VDD VSS CLKBUF_X1
Xclkload82 clknet_leaf_91_clk _unconnected_82 VDD VSS INV_X1
Xclkload83 clknet_leaf_92_clk _unconnected_83 VDD VSS INV_X2
Xclkload84 clknet_leaf_93_clk _unconnected_84 VDD VSS INV_X1
Xclkload85 clknet_leaf_94_clk _unconnected_85 VDD VSS INV_X1
Xclkload86 clknet_leaf_95_clk _unconnected_86 VDD VSS CLKBUF_X1
Xclkload87 clknet_leaf_97_clk _unconnected_87 VDD VSS INV_X1
Xclkload88 clknet_leaf_103_clk _unconnected_88 VDD VSS INV_X2
Xclkload89 clknet_leaf_104_clk _unconnected_89 VDD VSS INV_X1
Xclkload90 clknet_leaf_55_clk _unconnected_90 VDD VSS CLKBUF_X1
Xclkload91 clknet_leaf_56_clk _unconnected_91 VDD VSS CLKBUF_X1
Xclkload92 clknet_leaf_57_clk _unconnected_92 VDD VSS CLKBUF_X1
Xclkload93 clknet_leaf_60_clk _unconnected_93 VDD VSS INV_X1
Xclkload94 clknet_leaf_118_clk _unconnected_94 VDD VSS CLKBUF_X1
Xclkload95 clknet_leaf_50_clk _unconnected_95 VDD VSS INV_X2
Xclkload96 clknet_leaf_51_clk _unconnected_96 VDD VSS INV_X1
Xclkload97 clknet_leaf_119_clk _unconnected_97 VDD VSS CLKBUF_X1
Xclkload98 clknet_leaf_126_clk _unconnected_98 VDD VSS CLKBUF_X1
Xclkload99 clknet_leaf_128_clk _unconnected_99 VDD VSS INV_X1
Xclkload100 clknet_leaf_129_clk _unconnected_100 VDD VSS INV_X1
Xclkload101 clknet_leaf_62_clk _unconnected_101 VDD VSS CLKBUF_X1
Xclkload102 clknet_leaf_63_clk _unconnected_102 VDD VSS CLKBUF_X1
Xclkload103 clknet_leaf_107_clk _unconnected_103 VDD VSS CLKBUF_X1
Xclkload104 clknet_leaf_112_clk _unconnected_104 VDD VSS CLKBUF_X1
Xclkload105 clknet_leaf_114_clk _unconnected_105 VDD VSS INV_X1
Xclkload106 clknet_leaf_115_clk _unconnected_106 VDD VSS CLKBUF_X1
Xclkload107 clknet_leaf_116_clk _unconnected_107 VDD VSS INV_X1
Xclkload108 clknet_leaf_117_clk _unconnected_108 VDD VSS CLKBUF_X1
Xclkload109 clknet_leaf_108_clk _unconnected_109 VDD VSS INV_X1
Xclkload110 clknet_leaf_109_clk _unconnected_110 VDD VSS CLKBUF_X1
Xclkload111 clknet_leaf_111_clk _unconnected_111 VDD VSS INV_X1
Xclkload112 clknet_leaf_121_clk _unconnected_112 VDD VSS CLKBUF_X1
Xclkload113 clknet_leaf_124_clk _unconnected_113 VDD VSS CLKBUF_X1
Xclkload114 clknet_leaf_271_clk _unconnected_114 VDD VSS INV_X1
Xclkload115 clknet_leaf_274_clk _unconnected_115 VDD VSS CLKBUF_X1
Xclkload116 clknet_leaf_275_clk _unconnected_116 VDD VSS CLKBUF_X1
Xclkload117 clknet_leaf_276_clk _unconnected_117 VDD VSS CLKBUF_X1
Xclkload118 clknet_leaf_277_clk _unconnected_118 VDD VSS CLKBUF_X1
Xclkload119 clknet_leaf_278_clk _unconnected_119 VDD VSS CLKBUF_X1
Xclkload120 clknet_leaf_284_clk _unconnected_120 VDD VSS CLKBUF_X1
Xclkload121 clknet_leaf_262_clk _unconnected_121 VDD VSS INV_X1
Xclkload122 clknet_leaf_263_clk _unconnected_122 VDD VSS INV_X1
Xclkload123 clknet_leaf_264_clk _unconnected_123 VDD VSS INV_X1
Xclkload124 clknet_leaf_265_clk _unconnected_124 VDD VSS INV_X1
Xclkload125 clknet_leaf_266_clk _unconnected_125 VDD VSS INV_X1
Xclkload126 clknet_leaf_268_clk _unconnected_126 VDD VSS INV_X1
Xclkload127 clknet_leaf_269_clk _unconnected_127 VDD VSS INV_X2
Xclkload128 clknet_leaf_270_clk _unconnected_128 VDD VSS INV_X1
Xclkload129 clknet_leaf_285_clk _unconnected_129 VDD VSS INV_X2
Xclkload130 clknet_leaf_286_clk _unconnected_130 VDD VSS INV_X2
Xclkload131 clknet_leaf_288_clk _unconnected_131 VDD VSS INV_X1
Xclkload132 clknet_leaf_204_clk _unconnected_132 VDD VSS INV_X1
Xclkload133 clknet_leaf_282_clk _unconnected_133 VDD VSS CLKBUF_X1
Xclkload134 clknet_leaf_294_clk _unconnected_134 VDD VSS INV_X1
Xclkload135 clknet_leaf_296_clk _unconnected_135 VDD VSS CLKBUF_X1
Xclkload136 clknet_leaf_298_clk _unconnected_136 VDD VSS CLKBUF_X1
Xclkload137 clknet_leaf_300_clk _unconnected_137 VDD VSS CLKBUF_X1
Xclkload138 clknet_leaf_301_clk _unconnected_138 VDD VSS INV_X1
Xclkload139 clknet_leaf_303_clk _unconnected_139 VDD VSS CLKBUF_X1
Xclkload140 clknet_leaf_304_clk _unconnected_140 VDD VSS INV_X1
Xclkload141 clknet_leaf_308_clk _unconnected_141 VDD VSS CLKBUF_X1
Xclkload142 clknet_leaf_205_clk _unconnected_142 VDD VSS CLKBUF_X1
Xclkload143 clknet_leaf_287_clk _unconnected_143 VDD VSS CLKBUF_X1
Xclkload144 clknet_leaf_289_clk _unconnected_144 VDD VSS CLKBUF_X1
Xclkload145 clknet_leaf_290_clk _unconnected_145 VDD VSS INV_X1
Xclkload146 clknet_leaf_293_clk _unconnected_146 VDD VSS INV_X1
Xclkload147 clknet_leaf_234_clk _unconnected_147 VDD VSS CLKBUF_X1
Xclkload148 clknet_leaf_235_clk _unconnected_148 VDD VSS INV_X1
Xclkload149 clknet_leaf_237_clk _unconnected_149 VDD VSS INV_X1
Xclkload150 clknet_leaf_250_clk _unconnected_150 VDD VSS CLKBUF_X1
Xclkload151 clknet_leaf_252_clk _unconnected_151 VDD VSS CLKBUF_X1
Xclkload152 clknet_leaf_253_clk _unconnected_152 VDD VSS CLKBUF_X1
Xclkload153 clknet_leaf_254_clk _unconnected_153 VDD VSS INV_X1
Xclkload154 clknet_leaf_255_clk _unconnected_154 VDD VSS CLKBUF_X1
Xclkload155 clknet_leaf_256_clk _unconnected_155 VDD VSS CLKBUF_X1
Xclkload156 clknet_leaf_258_clk _unconnected_156 VDD VSS CLKBUF_X1
Xclkload157 clknet_leaf_259_clk _unconnected_157 VDD VSS CLKBUF_X1
Xclkload158 clknet_leaf_236_clk _unconnected_158 VDD VSS CLKBUF_X1
Xclkload159 clknet_leaf_243_clk _unconnected_159 VDD VSS CLKBUF_X1
Xclkload160 clknet_leaf_246_clk _unconnected_160 VDD VSS INV_X2
Xclkload161 clknet_leaf_247_clk _unconnected_161 VDD VSS CLKBUF_X1
Xclkload162 clknet_leaf_248_clk _unconnected_162 VDD VSS CLKBUF_X1
Xclkload163 clknet_leaf_249_clk _unconnected_163 VDD VSS INV_X1
Xclkload164 clknet_leaf_207_clk _unconnected_164 VDD VSS CLKBUF_X1
Xclkload165 clknet_leaf_208_clk _unconnected_165 VDD VSS CLKBUF_X1
Xclkload166 clknet_leaf_209_clk _unconnected_166 VDD VSS CLKBUF_X1
Xclkload167 clknet_leaf_210_clk _unconnected_167 VDD VSS INV_X1
Xclkload168 clknet_leaf_212_clk _unconnected_168 VDD VSS CLKBUF_X1
Xclkload169 clknet_leaf_213_clk _unconnected_169 VDD VSS CLKBUF_X1
Xclkload170 clknet_leaf_214_clk _unconnected_170 VDD VSS CLKBUF_X1
Xclkload171 clknet_leaf_221_clk _unconnected_171 VDD VSS INV_X1
Xclkload172 clknet_leaf_222_clk _unconnected_172 VDD VSS CLKBUF_X1
Xclkload173 clknet_leaf_230_clk _unconnected_173 VDD VSS CLKBUF_X1
Xclkload174 clknet_leaf_231_clk _unconnected_174 VDD VSS CLKBUF_X1
Xclkload175 clknet_leaf_232_clk _unconnected_175 VDD VSS CLKBUF_X1
Xclkload176 clknet_leaf_218_clk _unconnected_176 VDD VSS CLKBUF_X1
Xclkload177 clknet_leaf_223_clk _unconnected_177 VDD VSS CLKBUF_X1
Xclkload178 clknet_leaf_224_clk _unconnected_178 VDD VSS CLKBUF_X1
Xclkload179 clknet_leaf_225_clk _unconnected_179 VDD VSS CLKBUF_X1
Xclkload180 clknet_leaf_228_clk _unconnected_180 VDD VSS INV_X1
Xclkload181 clknet_leaf_229_clk _unconnected_181 VDD VSS INV_X1
Xclkload182 clknet_leaf_239_clk _unconnected_182 VDD VSS CLKBUF_X1
Xclkload183 clknet_leaf_240_clk _unconnected_183 VDD VSS CLKBUF_X1
Xclkload184 clknet_leaf_131_clk _unconnected_184 VDD VSS CLKBUF_X1
Xclkload185 clknet_leaf_132_clk _unconnected_185 VDD VSS CLKBUF_X1
Xclkload186 clknet_leaf_133_clk _unconnected_186 VDD VSS CLKBUF_X1
Xclkload187 clknet_leaf_134_clk _unconnected_187 VDD VSS CLKBUF_X1
Xclkload188 clknet_leaf_135_clk _unconnected_188 VDD VSS CLKBUF_X1
Xclkload189 clknet_leaf_136_clk _unconnected_189 VDD VSS CLKBUF_X1
Xclkload190 clknet_leaf_139_clk _unconnected_190 VDD VSS INV_X1
Xclkload191 clknet_leaf_201_clk _unconnected_191 VDD VSS CLKBUF_X1
Xclkload192 clknet_leaf_202_clk _unconnected_192 VDD VSS CLKBUF_X1
Xclkload193 clknet_leaf_302_clk _unconnected_193 VDD VSS INV_X1
Xclkload194 clknet_leaf_196_clk _unconnected_194 VDD VSS INV_X2
Xclkload195 clknet_leaf_198_clk _unconnected_195 VDD VSS CLKBUF_X1
Xclkload196 clknet_leaf_199_clk _unconnected_196 VDD VSS INV_X1
Xclkload197 clknet_leaf_203_clk _unconnected_197 VDD VSS CLKBUF_X1
Xclkload198 clknet_leaf_206_clk _unconnected_198 VDD VSS INV_X2
Xclkload199 clknet_leaf_138_clk _unconnected_199 VDD VSS CLKBUF_X1
Xclkload200 clknet_leaf_144_clk _unconnected_200 VDD VSS CLKBUF_X1
Xclkload201 clknet_leaf_145_clk _unconnected_201 VDD VSS INV_X1
Xclkload202 clknet_leaf_147_clk _unconnected_202 VDD VSS CLKBUF_X1
Xclkload203 clknet_leaf_149_clk _unconnected_203 VDD VSS CLKBUF_X1
Xclkload204 clknet_leaf_150_clk _unconnected_204 VDD VSS INV_X1
Xclkload205 clknet_leaf_151_clk _unconnected_205 VDD VSS INV_X1
Xclkload206 clknet_leaf_152_clk _unconnected_206 VDD VSS CLKBUF_X1
Xclkload207 clknet_leaf_153_clk _unconnected_207 VDD VSS CLKBUF_X1
Xclkload208 clknet_leaf_140_clk _unconnected_208 VDD VSS INV_X2
Xclkload209 clknet_leaf_141_clk _unconnected_209 VDD VSS CLKBUF_X1
Xclkload210 clknet_leaf_142_clk _unconnected_210 VDD VSS CLKBUF_X1
Xclkload211 clknet_leaf_143_clk _unconnected_211 VDD VSS INV_X1
Xclkload212 clknet_leaf_155_clk _unconnected_212 VDD VSS CLKBUF_X1
Xclkload213 clknet_leaf_156_clk _unconnected_213 VDD VSS CLKBUF_X1
Xclkload214 clknet_leaf_157_clk _unconnected_214 VDD VSS INV_X1
Xclkload215 clknet_leaf_158_clk _unconnected_215 VDD VSS CLKBUF_X1
Xclkload216 clknet_leaf_159_clk _unconnected_216 VDD VSS CLKBUF_X1
Xclkload217 clknet_leaf_190_clk _unconnected_217 VDD VSS CLKBUF_X1
Xclkload218 clknet_leaf_195_clk _unconnected_218 VDD VSS INV_X2
Xclkload219 clknet_leaf_178_clk _unconnected_219 VDD VSS INV_X1
Xclkload220 clknet_leaf_182_clk _unconnected_220 VDD VSS CLKBUF_X1
Xclkload221 clknet_leaf_183_clk _unconnected_221 VDD VSS CLKBUF_X1
Xclkload222 clknet_leaf_185_clk _unconnected_222 VDD VSS INV_X1
Xclkload223 clknet_leaf_186_clk _unconnected_223 VDD VSS CLKBUF_X1
Xclkload224 clknet_leaf_187_clk _unconnected_224 VDD VSS CLKBUF_X1
Xclkload225 clknet_leaf_188_clk _unconnected_225 VDD VSS CLKBUF_X1
Xclkload226 clknet_leaf_189_clk _unconnected_226 VDD VSS CLKBUF_X1
Xclkload227 clknet_leaf_216_clk _unconnected_227 VDD VSS CLKBUF_X1
Xclkload228 clknet_leaf_217_clk _unconnected_228 VDD VSS CLKBUF_X1
Xclkload229 clknet_leaf_160_clk _unconnected_229 VDD VSS INV_X1
Xclkload230 clknet_leaf_162_clk _unconnected_230 VDD VSS CLKBUF_X1
Xclkload231 clknet_leaf_163_clk _unconnected_231 VDD VSS CLKBUF_X1
Xclkload232 clknet_leaf_164_clk _unconnected_232 VDD VSS CLKBUF_X1
Xclkload233 clknet_leaf_175_clk _unconnected_233 VDD VSS CLKBUF_X1
Xclkload234 clknet_leaf_176_clk _unconnected_234 VDD VSS CLKBUF_X1
Xclkload235 clknet_leaf_177_clk _unconnected_235 VDD VSS INV_X2
Xclkload236 clknet_leaf_166_clk _unconnected_236 VDD VSS INV_X1
Xclkload237 clknet_leaf_167_clk _unconnected_237 VDD VSS INV_X1
Xclkload238 clknet_leaf_168_clk _unconnected_238 VDD VSS CLKBUF_X1
Xclkload239 clknet_leaf_169_clk _unconnected_239 VDD VSS CLKBUF_X1
Xclkload240 clknet_leaf_170_clk _unconnected_240 VDD VSS CLKBUF_X1
Xclkload241 clknet_leaf_171_clk _unconnected_241 VDD VSS INV_X1
Xclkload242 clknet_leaf_172_clk _unconnected_242 VDD VSS CLKBUF_X1
Xclkload243 clknet_leaf_173_clk _unconnected_243 VDD VSS CLKBUF_X1
Xclkload244 clknet_leaf_174_clk _unconnected_244 VDD VSS INV_X1
Xclkload245 clknet_leaf_180_clk _unconnected_245 VDD VSS CLKBUF_X1
Xclkload246 clknet_leaf_181_clk _unconnected_246 VDD VSS CLKBUF_X1
Xrebuffer1 net691 net631 VDD VSS BUF_X1
Xrebuffer2 _10300_ net632 VDD VSS BUF_X1
Xrebuffer3 _10308_ net633 VDD VSS BUF_X1
Xrebuffer4 _10308_ net634 VDD VSS BUF_X1
Xrebuffer5 net661 net635 VDD VSS BUF_X1
Xrebuffer6 net635 net636 VDD VSS BUF_X1
Xrebuffer7 _10335_ net637 VDD VSS BUF_X1
Xrebuffer8 _10326_ net638 VDD VSS BUF_X1
Xrebuffer9 net638 net639 VDD VSS BUF_X1
Xrebuffer10 _10264_ net640 VDD VSS BUF_X1
Xrebuffer11 _10190_ net641 VDD VSS BUF_X1
Xrebuffer12 _10182_ net642 VDD VSS BUF_X1
Xrebuffer13 _10182_ net643 VDD VSS BUF_X1
Xrebuffer14 net643 net644 VDD VSS BUF_X1
Xrebuffer15 _10188_ net645 VDD VSS BUF_X1
Xrebuffer16 net645 net646 VDD VSS BUF_X1
Xrebuffer17 _10200_ net647 VDD VSS BUF_X1
Xrebuffer18 net647 net648 VDD VSS BUF_X1
Xrebuffer19 net692 net649 VDD VSS BUF_X1
Xrebuffer20 _10203_ net650 VDD VSS BUF_X1
Xrebuffer21 _07293_ net651 VDD VSS BUF_X1
Xrebuffer22 net651 net652 VDD VSS BUF_X1
Xrebuffer23 _10184_ net653 VDD VSS BUF_X1
Xrebuffer24 _10362_ net654 VDD VSS BUF_X1
Xrebuffer25 net654 net655 VDD VSS BUF_X1
Xrebuffer26 _10362_ net656 VDD VSS BUF_X1
Xrebuffer27 _10205_ net657 VDD VSS BUF_X1
Xrebuffer28 net696 net658 VDD VSS BUF_X1
Xrebuffer29 _10202_ net659 VDD VSS BUF_X1
Xrebuffer30 _10332_ net660 VDD VSS BUF_X1
Xrebuffer31 _10230_ net661 VDD VSS BUF_X2
Xrebuffer32 _00008_ net662 VDD VSS BUF_X1
Xrebuffer109 _00006_ net758 VDD VSS BUF_X1
Xrebuffer34 _07509_ net664 VDD VSS BUF_X1
Xrebuffer35 net664 net665 VDD VSS BUF_X1
Xrebuffer36 _05128_ net666 VDD VSS BUF_X1
Xclone37 _06120_ net667 VDD VSS BUF_X2
Xclone38 net669 net668 VDD VSS BUF_X4
Xrebuffer39 _00014_ net669 VDD VSS BUF_X1
Xrebuffer40 _10324_ net670 VDD VSS BUF_X1
Xrebuffer41 net670 net671 VDD VSS BUF_X2
Xrebuffer42 _00016_ net672 VDD VSS BUF_X1
Xrebuffer43 _07431_ net673 VDD VSS BUF_X1
Xrebuffer44 net673 net674 VDD VSS BUF_X1
Xrebuffer45 net674 net675 VDD VSS BUF_X1
Xrebuffer46 _10196_ net676 VDD VSS BUF_X1
Xrebuffer47 _05309_ net677 VDD VSS BUF_X1
Xrebuffer48 _05309_ net678 VDD VSS BUF_X1
Xrebuffer49 net733 net679 VDD VSS BUF_X1
Xclone50 net693 net680 VDD VSS BUF_X4
Xrebuffer51 _10314_ net681 VDD VSS BUF_X2
Xrebuffer52 net705 net682 VDD VSS BUF_X2
Xrebuffer53 net682 net683 VDD VSS BUF_X1
Xrebuffer54 net683 net684 VDD VSS BUF_X1
Xrebuffer55 _05138_ net685 VDD VSS BUF_X1
Xrebuffer56 _10197_ net686 VDD VSS BUF_X1
Xrebuffer57 _05129_ net687 VDD VSS BUF_X1
Xrebuffer58 _07479_ net688 VDD VSS BUF_X1
Xrebuffer59 net688 net689 VDD VSS BUF_X1
Xrebuffer60 net688 net690 VDD VSS BUF_X1
Xrebuffer68 _05455_ net698 VDD VSS BUF_X1
Xrebuffer69 _05455_ net699 VDD VSS BUF_X1
Xrebuffer70 _05455_ net700 VDD VSS BUF_X1
Xrebuffer71 net700 net701 VDD VSS BUF_X1
Xclone72 _05590_ net702 VDD VSS BUF_X2
Xrebuffer73 _10330_ net703 VDD VSS BUF_X1
Xrebuffer74 net703 net704 VDD VSS BUF_X1
Xrebuffer75 _05509_ net705 VDD VSS BUF_X1
Xclone115 _05129_ net765 VDD VSS BUF_X16
Xrebuffer114 _05129_ net764 VDD VSS BUF_X2
Xrebuffer78 net709 net708 VDD VSS BUF_X1
Xrebuffer79 net710 net709 VDD VSS BUF_X1
Xrebuffer80 net712 net710 VDD VSS BUF_X1
Xclone81 net714 net711 VDD VSS BUF_X16
Xrebuffer82 net758 net712 VDD VSS BUF_X2
Xrebuffer83 _10360_ net713 VDD VSS BUF_X1
Xrebuffer84 _05455_ net714 VDD VSS BUF_X1
Xrebuffer85 _10329_ net715 VDD VSS BUF_X1
Xrebuffer86 _10344_ net716 VDD VSS BUF_X1
Xclone87 net722 net717 VDD VSS BUF_X16
Xrebuffer88 _10353_ net718 VDD VSS BUF_X1
Xrebuffer89 _10356_ net719 VDD VSS BUF_X1
Xclone90 _05456_ net720 VDD VSS BUF_X16
Xclone91 _05458_ net721 VDD VSS BUF_X16
Xrebuffer92 _05455_ net722 VDD VSS BUF_X8
Xrebuffer93 _10339_ net723 VDD VSS BUF_X1
Xrebuffer94 _10338_ net724 VDD VSS BUF_X1
Xrebuffer95 _10359_ net725 VDD VSS BUF_X1
Xclone96 net727 net726 VDD VSS BUF_X16
Xrebuffer97 net729 net727 VDD VSS BUF_X1
Xclone98 net729 net728 VDD VSS BUF_X16
Xrebuffer99 _05309_ net729 VDD VSS BUF_X2
Xrebuffer104 _05264_ net734 VDD VSS BUF_X4
Xrebuffer105 _05141_ net735 VDD VSS BUF_X1
Xrebuffer106 _05142_ net736 VDD VSS BUF_X1
Xclone107 _05144_ net737 VDD VSS BUF_X16
Xclone108 _05143_ net738 VDD VSS BUF_X16
Xclone109 _05143_ net739 VDD VSS BUF_X16
Xclone110 net741 net740 VDD VSS BUF_X16
Xrebuffer111 _05142_ net741 VDD VSS BUF_X1
Xclone114 _05610_ _05697_ _05696_ net744 VDD VSS AOI21_X2
Xrebuffer38 net691 net692 VDD VSS BUF_X1
Xrebuffer50 _05452_ net693 VDD VSS BUF_X1
Xrebuffer61 _07518_ net694 VDD VSS BUF_X1
Xrebuffer62 _10284_ net695 VDD VSS BUF_X1
Xrebuffer63 _00008_ net696 VDD VSS BUF_X1
Xrebuffer64 _10309_ net697 VDD VSS BUF_X1
Xrebuffer65 _10231_ net730 VDD VSS BUF_X1
Xrebuffer66 _10228_ net731 VDD VSS BUF_X1
Xrebuffer67 _10234_ net732 VDD VSS BUF_X1
Xrebuffer72 _00014_ net733 VDD VSS BUF_X1
Xrebuffer81 _07267_ net742 VDD VSS BUF_X1
Xclone82 _05130_ net743 VDD VSS BUF_X16
Xclone83 _05130_ net745 VDD VSS BUF_X16
Xclone84 net764 net746 VDD VSS BUF_X16
Xrebuffer87 _05695_ net747 VDD VSS BUF_X4
Xrebuffer90 net747 net748 VDD VSS BUF_X1
Xrebuffer91 net748 net749 VDD VSS BUF_X1
Xrebuffer96 _10231_ net750 VDD VSS BUF_X1
Xrebuffer98 net750 net751 VDD VSS BUF_X1
Xrebuffer101 net752 net753 VDD VSS BUF_X1
Xrebuffer102 net752 net754 VDD VSS BUF_X1
Xrebuffer108 net756 net757 VDD VSS BUF_X1
Xrebuffer121 _10246_ net771 VDD VSS BUF_X1
.ENDS dynamic_node_top_wrap
*
* ******************************************************************************
* *                                                                            *
* *                   Copyright (C) 2004-2010, Nangate Inc.                    *
* *                           All rights reserved.                             *
* *                                                                            *
* * Nangate and the Nangate logo are trademarks of Nangate Inc.                *
* *                                                                            *
* * All trademarks, logos, software marks, and trade names (collectively the   *
* * "Marks") in this program are proprietary to Nangate or other respective    *
* * owners that have granted Nangate the right and license to use such Marks.  *
* * You are not permitted to use the Marks without the prior written consent   *
* * of Nangate or such third party that may own the Marks.                     *
* *                                                                            *
* * This file has been provided pursuant to a License Agreement containing     *
* * restrictions on its use. This file contains valuable trade secrets and     *
* * proprietary information of Nangate Inc., and is protected by U.S. and      *
* * international laws and/or treaties.                                        *
* *                                                                            *
* * The copyright notice(s) in this file does not indicate actual or intended  *
* * publication of this file.                                                  *
* *                                                                            *
* *     NGLibraryCreator, v2010.08-HR32-SP3-2010-08-05 - build 1009061800      *
* *                                                                            *
* ******************************************************************************
*
*
* Running on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr).
* Local time is now Fri, 3 Dec 2010, 19:32:12.
* Main process id is 27821.
*
********************************************************************************
*                                                                              *
* Cellname:   AND2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:24:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 * A2)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 VSS A2 net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_neg A1 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_5 VDD A2 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:31 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 * A2)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND2_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:29 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 * A2)
M_i_3__m0_m2__m0 net_0__m0_0__m0_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m0 ZN_neg A1 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0_0__m1 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m1 VSS A2 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0_x2__m1 ZN_neg A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m0 VDD A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m1 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m0 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_0 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:35 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 * A2) * A3)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 VSS A3 net_1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VDD A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_6 ZN_neg A2 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD A3 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:26 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 * A2) * A3)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS A3 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VDD A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN_neg A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A3 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:25 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 * A2) * A3)
M_i_4__m0_m2__m0 net_1__m0_0__m0_0 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m0 net_0__m0_0__m0_0 A2 net_1__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m0 ZN_neg A1 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0_0__m1 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m1 net_1__m0_0__m1 A2 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0_m2__m1 VSS A3 net_1__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0_x2__m0 ZN_neg A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0_x2__m0 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m0 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m1 VDD A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0_x2__m1 ZN_neg A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0_x2__m1 VDD A3 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:41 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 * A2) * A3) * A4)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 net_2 A3 net_1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 VSS A4 net_2 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 ZN_neg A1 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD A2 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 ZN_neg A3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_9 VDD A4 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 * A2) * A3) * A4)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_2 A3 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS A4 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 ZN_neg A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD A4 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 * A2) * A3) * A4)
M_i_5__m0 net_2__m0_0 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 net_1__m0_0 A3 net_2__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 net_0__m0_0 A2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 x1 A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0__m1 A1 x1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_2__m1 A3 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m1 VSS A4 net_2__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN x1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS x1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN x1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS x1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9__m0 x1 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 VDD A3 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 x1 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 VDD A1 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 x1 A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A2 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 x1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD A4 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN x1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD x1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN x1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD x1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ANTENNA_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:30:15 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ANTENNA_X1 A VDD VSS
*.PININFO A:I VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:12 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X1 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + B) + A)
M_i_1 net_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 ZN C2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:11 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X2 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + B) + A)
M_i_2__m0 ZN B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN C1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS C2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 net_2__m0_0 B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD A net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2__m1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_1 B net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN C2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN C1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_1 C2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:03 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X4 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((C1 * C2) + B) + A)))
M_i_0 net_0 C1 ZN_3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN_3 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A ZN_3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_8_0 ZN_4 ZN_3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_8_1 VSS ZN_3 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0 ZN ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_1 VSS ZN_4 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_2 ZN ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_3 VSS ZN_4 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_3 C1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_1 C2 ZN_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9_0 ZN_4 ZN_3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9_1 VDD ZN_3 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_0 ZN ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1 VDD ZN_4 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_2 ZN ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_3 VDD ZN_4 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X1 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A + (B1 * B2))
M_i_1 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X2 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A + (B1 * B2))
M_i_2_0_x2_1 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0_x2_0 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m1 net_0__m0_0__m1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m1 ZN B1 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m0 net_0__m0_0__m0_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m0 VSS B2 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0_x2_0 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_0_x2_1 net_1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m0 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m1 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m0 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m1 net_1 B2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X4 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A + (B1 * B2))
M_i_2_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN B1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS B2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 net_0__m2 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 ZN B1 net_0__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 net_0__m3 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 VSS B2 net_0__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1 net_1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_2 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_3 net_1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_1 B2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m2 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m3 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 net_1 B2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:07:32 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X1 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + A) + (B1 * B2))
M_i_4 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN C2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_2 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:07:38 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X2 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + A) + (B1 * B2))
M_i_2_1 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 net_1__m0_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 VSS B2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_1__m1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 ZN B1 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN C1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS C2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7_1 net_3 A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 VDD B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_3 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 net_3 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_0 net_2 A net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN C2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2 C2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:07:31 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X4 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((C1 * C2) + A) + (B1 * B2))))
M_i_0 net_0 C1 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN_4 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B1 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_0 ZN_5 ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_1 VSS ZN_4 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_0 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_1 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_2 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_3 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 ZN_4 C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 C2 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_3 A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 VDD B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_1 ZN_5 ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_0 VDD ZN_4 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_0 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_1 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_2 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_3 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X1 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) + (B1 * B2)) + (C1 * C2))
M_i_5 net_2 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN C1 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_4 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 VDD C1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_4 B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_3 B2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN A2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_3 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X2 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) + (B1 * B2)) + (C1 * C2))
M_i_5__m1 net_2__m1 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 ZN C1 net_2__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 net_2__m0_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0 VSS C2 net_2__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 ZN B1 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_1__m0_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11__m0 VDD C2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10__m0 net_4 C1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10__m1 VDD C1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11__m1 net_4 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 net_3 B2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 net_4 B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_3 B1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_4 B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 ZN A1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_3 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 ZN A2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 net_3 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X4 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((A1 * A2) + (B1 * B2)) + (C1 * C2))))
M_i_0 net_0 A1 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN_5 B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_2 C1 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS C2 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x2_0 ZN_6 ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x2_1 VSS ZN_5 ZN_6 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_0 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_1 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_2 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_3 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 ZN_5 A1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_3 A2 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_4 B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 net_4 C1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11 VDD C2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_0 ZN_6 ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_1 VDD ZN_5 ZN_6 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_3 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_2 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_1 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_0 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X1 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) + (B1 * B2))
M_i_3 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:55 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X2 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) + (B1 * B2))
M_i_3__m0 net_1__m0_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 ZN B1 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_1__m1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS B2 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X4 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) + (B1 * B2))
M_i_3__m0 net_1__m0_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 ZN B1 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_1__m1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS B2 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m2 net_1__m2 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 ZN B1 net_1__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 net_1__m3 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m3 VSS B2 net_1__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 net_0__m2 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 ZN A1 net_0__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 net_0__m3 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 VSS A2 net_0__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m2 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m2 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m3 VDD B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m3 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 ZN A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 net_2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X1 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X16.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X16 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_4 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_5 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_6 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_7 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_4 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_5 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_6 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_7 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X2 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x2_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x2_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X32.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:31:57 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X32 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_4 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_5 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_6 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_7 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_8 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_9 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_10 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_11 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_12 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_13 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_14 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_15 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_16 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_17 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_18 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_19 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_20 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_21 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_22 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_23 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_24 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_25 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_26 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_27 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_28 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_29 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_30 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_31 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_4 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_5 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_6 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_7 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_8 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_9 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_10 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_11 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_12 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_13 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_14 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_15 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_16 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_17 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_18 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_19 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_20 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_21 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_22 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_23 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_24 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_25 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_26 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_27 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_28 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_29 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_30 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_31 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X4 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X8.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:28:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X8 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X1 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.095000U L=0.050000U
M_i_0 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:41 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X2 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X3.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:23 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X3 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X1.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:04:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X1 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_52 net_008 CK net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_57 VSS net_002 net_008 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X2.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:03:58 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X2 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_57 VSS net_002 net_008 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52 net_008 CK net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X4.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:03:50 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X4 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_52 net_008 CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57 net_007 net_002 net_008 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_77 net_007 net_002 net_008b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_76 net_008b CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_15 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_29 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_69 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_72 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_11 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_28 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X8.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:04:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X8 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_33_93 net_004 net_002 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_52 net_008 CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57 net_007 net_002 net_008 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_77 net_007 net_002 net_008b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_76 net_008b CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_150 net_008c CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_123 net_007 net_002 net_008c VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_77_169 net_007 net_002 net_008d VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_76_137 net_008d CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_15 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_29 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_12 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_55 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_15_27 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_29_4 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_101_94 net_004 net_002 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_69 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_72 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_163 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_158 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_69_164 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_72_145 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_11 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_28 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_38 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_20 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_11_14 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_28_7 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:03:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X1 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 VSS net_000 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_007 CK net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X2.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:02:42 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X2 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_007 CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45 VSS net_000 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X4.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:02:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X4 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 VSS net_000 net_007b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40 net_007b CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_75 net_007 CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_66 VSS net_000 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_10 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_25 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_71 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_74 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_24 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_19 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X8.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:02:20 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X8 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_174 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 VSS net_000 net_007b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40 net_007b CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_75 net_007 CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_66 VSS net_000 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_63 VSS net_000 net_007c VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_71 net_007c CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_75_82 net_007d CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_66_78 VSS net_000 net_007d VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_10 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_25 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_40 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_58 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_10_28 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_25_30 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_57_165 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_71 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_74 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_72 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_99 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_71_87 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_74_97 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_24 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_19 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_53 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_22 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_24_52 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_19_36 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFRS_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:01:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFRS_X1 D RN SN CK Q QN VDD VSS
*.PININFO D:I RN:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_MN81 QN z99 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN91_0_0 VSS z56 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_transistor_0 z99 z56 nn99 VSS NMOS_VTL W=0.210000U L=0.050000U
M_transistor_1 nn99 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN51 VSS z41 nn5 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN52 nn5 RN z56 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN63 VSS SN nn62 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN62 nn62 z56 nn61 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN61 nn61 ckn_i z41 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN41 z41 ck_i nn4 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN42 nn4 z37 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_0 VSS z37 nn2 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_1 nn2 SN z51 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN101 VSS ckn_i ck_i VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN33 VSS RN nn32 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN32 nn32 z51 nn31 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN31 nn31 ck_i z37 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z37 ckn_i nn1 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN12 nn1 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN91 ckn_i CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP81_0 QN z99 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_1 VDD z56 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_transistor_2 VDD z56 z99 VDD PMOS_VTL W=0.315000U L=0.050000U
M_transistor_3 z99 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP51 z56 z41 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP52 VDD RN z56 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP63 VDD SN np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP61 VDD z56 np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP62 np61 ck_i z41 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP41 np4 ckn_i z41 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP42 VDD z37 np4 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP21 VDD z37 z51 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP22 z51 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP101 ck_i ckn_i VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP33 VDD RN np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP31 VDD z51 np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP34 np32 ckn_i z37 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP12 np1 ck_i z37 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP11 VDD D np1 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP91 ckn_i CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFRS_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:01:53 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFRS_X2 D RN SN CK Q QN VDD VSS
*.PININFO D:I RN:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_MN81_53 QN z99 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN81 QN z99 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN91_0_0 VSS z56 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN91_0_0_58 VSS z56 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_transistor_0 z99 z56 nn99 VSS NMOS_VTL W=0.310000U L=0.050000U
M_transistor_1 nn99 SN VSS VSS NMOS_VTL W=0.310000U L=0.050000U
M_MN51 VSS RN nn5 VSS NMOS_VTL W=0.310000U L=0.050000U
M_MN52 nn5 z41 z56 VSS NMOS_VTL W=0.310000U L=0.050000U
M_MN63 VSS SN nn62 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN62 nn62 z56 nn61 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN61 nn61 ckn_i z41 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN41 z41 ck_i nn4 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN42 nn4 z37 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_0 VSS z37 nn2 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_1 nn2 SN z51 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN101 VSS ckn_i ck_i VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN33 VSS RN nn32 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN32 nn32 z51 nn31 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN31 nn31 ck_i z37 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z37 ckn_i nn1 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN12 nn1 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN91 ckn_i CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP81_0_51 QN z99 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_0 QN z99 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_1 VDD z56 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_1_55 VDD z56 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_transistor_2 VDD z56 z99 VDD PMOS_VTL W=0.485000U L=0.050000U
M_transistor_3 z99 SN VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_MP52 VDD RN z56 VDD PMOS_VTL W=0.485000U L=0.050000U
M_MP51 z56 z41 VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_MP63 VDD SN np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP61 VDD z56 np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP62 np61 ck_i z41 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP41 np4 ckn_i z41 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP42 VDD z37 np4 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP21 VDD z37 z51 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP22 z51 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP101 ck_i ckn_i VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP33 VDD RN np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP31 VDD z51 np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP34 np32 ckn_i z37 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP12 np1 ck_i z37 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP11 VDD D np1 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP91 ckn_i CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFR_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:01:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFR_X1 D RN CK Q QN VDD VSS
*.PININFO D:I RN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 net_005 net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_32 VSS RN net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_38 VSS net_003 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_003 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_49 net_008 net_001 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 net_009 net_000 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 VSS net_011 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_65 net_010 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_70 net_011 net_008 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_76 VSS net_008 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_83 Q net_011 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_89 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_96 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_108 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_114 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_119 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_125 net_013 RN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_136 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 net_015 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_147 net_008 net_000 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_153 net_016 net_001 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_159 VDD net_011 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 net_011 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_172 VDD net_008 net_011 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_180 VDD net_008 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_187 Q net_011 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFR_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:00:47 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFR_X2 D RN CK Q QN VDD VSS
*.PININFO D:I RN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 net_005 net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_32 VSS RN net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_38 VSS net_003 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_003 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_49 net_008 net_001 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 net_009 net_000 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 VSS net_011 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_65 net_010 RN VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_70 net_011 net_008 net_010 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_76_4 VSS net_008 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_76 VSS net_008 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_83 Q net_011 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_83_49 Q net_011 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_89 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_96 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_108 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_114 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_119 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_125 net_013 RN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_136 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 net_015 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_147 net_008 net_000 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_153 net_016 net_001 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_159 VDD net_011 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 net_011 RN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_172 VDD net_008 net_011 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_180_3 VDD net_008 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_180 VDD net_008 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_187 Q net_011 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_187_39 Q net_011 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFS_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:00:41 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFS_X1 D SN CK Q QN VDD VSS
*.PININFO D:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_15 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_19 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_25 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 VSS net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_36 net_005 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_003 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_73 VSS net_003 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 net_011 net_001 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_63 net_010 net_000 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 net_009 net_007 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_53 net_008 SN VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_46 VSS net_010 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_86 QN net_010 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_79 VSS net_007 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_99 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_106 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_111 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_118 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_122 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_128 net_006 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_134 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_92 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_171 net_016 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 net_010 net_000 net_016 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_015 net_001 net_010 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 VDD net_007 net_015 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_149 net_015 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_142 VDD net_010 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_189 QN net_010 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_182 VDD net_007 Q VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFS_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:00:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFS_X2 D SN CK Q QN VDD VSS
*.PININFO D:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_15 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_19 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_25 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 VSS net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_36 net_005 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_003 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_73 VSS net_003 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 net_011 net_001 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_63 net_010 net_000 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 net_009 net_007 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_53 net_008 SN VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_79_29 VSS net_007 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_79 VSS net_007 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_86 QN net_010 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_86_15 QN net_010 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_46 VSS net_010 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_99 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_106 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_111 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_118 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_122 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_128 net_006 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_134 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_92 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_171 net_016 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 net_010 net_000 net_016 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_015 net_001 net_010 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 VDD net_007 net_015 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_149 net_015 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_182_20 VDD net_007 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_182 VDD net_007 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_189 QN net_010 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_189_10 QN net_010 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_142 VDD net_010 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFF_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:59:45 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFF_X1 D CK Q QN VDD VSS
*.PININFO D:I CK:I Q:O QN:O VDD:P VSS:G
M_MN2 ci cni VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN6 VSS z4 z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN7 z3 ci z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN4 z2 cni z3 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN3 z2 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN5 z4 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN1 VSS CK cni VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN8 z12 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN9 z9 ci z12 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN12 z9 cni z8 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z8 z10 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN10 VSS z9 z10 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN14 QN z9 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN13 VSS z10 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MP2 ci cni VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP6 VDD z4 z1 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP7 z1 cni z3 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP4 z3 ci z5 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP3 z5 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP5 z4 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP1 VDD CK cni VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP8 z7 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP9 z9 cni z7 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP12 z9 ci z11 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP11 z11 z10 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP10 VDD z9 z10 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP14 QN z9 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP13 VDD z10 Q VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFF_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:59:42 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFF_X2 D CK Q QN VDD VSS
*.PININFO D:I CK:I Q:O QN:O VDD:P VSS:G
M_MN2 ci cni VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN6 VSS z4 z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN7 z3 ci z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN4 z2 cni z3 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN3 z2 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN5 z4 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN1 VSS CK cni VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN8 z12 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN9 z9 ci z12 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN12 z9 cni z8 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z8 z10 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN10 VSS z9 z10 VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN14_8 QN z9 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN14 QN z9 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN13 VSS z10 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN13_38 VSS z10 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MP2 ci cni VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP6 VDD z4 z1 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP7 z1 cni z3 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP4 z3 ci z5 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP3 z5 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP5 z4 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP1 VDD CK cni VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP8 z7 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP9 z9 cni z7 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP12 z9 ci z11 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP11 z11 z10 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP10 VDD z9 z10 VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP14_5 QN z9 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP14 QN z9 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP13 VDD z10 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP13_26 VDD z10 Q VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLH_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:59:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLH_X1 D G Q VDD VSS
*.PININFO D:I G:I Q:O VDD:P VSS:G
M_i_0 VSS G net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41_11 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_001 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24 net_004 net_000 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_34 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_48 VDD G net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_89_4 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_55 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_61 net_006 D VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_66 net_003 net_000 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_72 net_007 net_001 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_76 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_82 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLH_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:52 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLH_X2 D G Q VDD VSS
*.PININFO D:I G:I Q:O VDD:P VSS:G
M_i_0 VSS G net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_41_11 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_001 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_000 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_34 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_48 VDD G net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_89 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_89_4 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_55 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_61 net_006 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_66 net_003 net_000 net_006 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_72 net_007 net_001 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_76 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_82 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLL_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLL_X1 D GN Q VDD VSS
*.PININFO D:I GN:I Q:O VDD:P VSS:G
M_i_7 VSS net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_29 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_35 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_42 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_000 GN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 VDD net_000 net_001 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_62 net_006 D VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_67 net_003 net_001 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_73 net_007 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_79 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_85 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_92 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_000 GN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLL_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:19 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLL_X2 D GN Q VDD VSS
*.PININFO D:I GN:I Q:O VDD:P VSS:G
M_i_7 VSS net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_29 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_35 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_42_3 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_42 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_000 GN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 VDD net_000 net_001 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_62 net_006 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_67 net_003 net_001 net_006 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_73 net_007 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_79 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_85 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_92_11 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_92 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_000 GN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FA_X1.                                                           *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:24 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FA_X1 A B CI CO S VDD VSS
*.PININFO A:I B:I CI:I CO:O S:O VDD:P VSS:G
*.EQN CO=((A * B) + (CI * (A + B)));S=(CI ^ (A ^ B))
M_instance_159 CO net_001 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_instance_166 VSS B net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_170 net_000 A net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_176 net_001 CI net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_188 net_002 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_182 VSS B net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_227 net_006 B VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_215 VSS CI net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_221 net_006 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_209 net_005 net_001 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_203 net_004 CI net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_199 net_003 B net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_194 VSS A net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_233 S net_005 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_instance_239 CO net_001 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_instance_246 VDD B net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_251 net_007 A net_001 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_257 net_001 CI net_008 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_269 net_008 A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_263 VDD B net_008 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_309 net_011 B VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_297 VDD CI net_011 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_303 net_011 A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_290 net_005 net_001 net_011 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_284 net_010 CI net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_280 net_009 B net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_275 VDD A net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_315 S net_005 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X1.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X1 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TAPCELL_X1.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TAPCELL_X1 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X16.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:23 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X16 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X2.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X2 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X32.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:13 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X32 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X4.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:50 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X4 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X8.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X8 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   HA_X1.                                                           *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:27 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT HA_X1 A B CO S VDD VSS
*.PININFO A:I B:I CO:O S:O VDD:P VSS:G
*.EQN CO=(A * B);S=(A ^ B)
M_i_1 net_0 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 S A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS x1 S VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 x1 B VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_6 VSS A x1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_12 net_3 A CO_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 VSS B net_3 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_10 CO CO_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 S B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 net_1 A S VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD x1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_2 B VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 x1 A net_2 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_14 CO_neg A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_15 VDD B CO_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_11 CO CO_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:52 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X1 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X16.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:12 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X16 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X2 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0_x2_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0_x2_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x2_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X32.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:38 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X32 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_16 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_17 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_18 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_19 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_20 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_21 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_22 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_23 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_24 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_25 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_26 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_27 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_28 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_29 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_30 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_31 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_16 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_17 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_18 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_19 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_20 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_21 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_22 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_23 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_24 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_25 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_26 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_27 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_28 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_29 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_30 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_31 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X4 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0_x4_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0_x4_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X8.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:24:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X8 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0_x8_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_4 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_5 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_6 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_7 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0_x8_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_4 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_6 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LOGIC0_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:24:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LOGIC0_X1 Z VDD VSS
*.PININFO Z:O VDD:P VSS:G
M_n_tran_1 VSS A Z VSS NMOS_VTL W=0.090000U L=0.050000U
M_transistor_0 VDD A A VDD PMOS_VTL W=0.090000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LOGIC1_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:59 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LOGIC1_X1 Z VDD VSS
*.PININFO Z:O VDD:P VSS:G
M_n_tran_1 VSS A A VSS NMOS_VTL W=0.090000U L=0.050000U
M_p_tran_2 VDD A Z VDD PMOS_VTL W=0.135000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   MUX2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT MUX2_X1 A B S Z VDD VSS
*.PININFO A:I B:I S:I Z:O VDD:P VSS:G
*.EQN Z=((S * B) + (A * !S))
M_i_10 VSS S x1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 net_1 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 Z_neg x1 net_1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_2 Z_neg S net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 net_0 B VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 VDD S x1 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 VDD A net_2 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_6 net_2 S Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_9 net_3 x1 Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD B net_3 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   MUX2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:57 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT MUX2_X2 A B S Z VDD VSS
*.PININFO A:I B:I S:I Z:O VDD:P VSS:G
*.EQN Z=((S * B) + (A * !S))
M_i_4 net_1 A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS x1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 Z_neg S net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10 VSS S x1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_8 VDD A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_2 x1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 Z_neg B net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 S Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11 VDD S x1 VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 * A2)
M_i_1 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:47 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 * A2)
M_i_1__m0_m2__m0 net_0__m0__m0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m0 ZN A1 net_0__m0__m0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m1 net_0__m0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m1 VSS A2 net_0__m0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_x2__m0 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_x2__m0 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_x2__m1 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m1 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:44 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 * A2)
M_i_1_0 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_1 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_2 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_3 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_0 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_1 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_2 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_3 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:24 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) * A3)
M_i_2 net_1 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:17 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) * A3)
M_i_2__m0_m2__m0 net_1__m0_0__m0_0 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m0 net_0__m0_0__m0_0 A2 net_1__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m0 ZN A1 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m1 net_0__m0_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m1 net_1__m0_0__m1 A2 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m1 VSS A3 net_1__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0_x2__m0 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m0 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m0 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m1 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m1 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m1 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:27 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) * A3)
M_i_2__m0 net_1__m0_0 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_1__m1 A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS A3 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 net_1__m2 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 net_0__m2 A2 net_1__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 ZN A1 net_0__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 net_0__m3 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_1__m3 A2 net_0__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 VSS A3 net_1__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m2 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m3 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:11:28 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) * A3) * A4)
M_i_3 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:11:18 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) * A3) * A4)
M_i_3__m0 net_2__m0_0 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_1__m0_0 A3 net_2__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_1__m1 A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_2__m1 A3 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS A4 net_2__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A4 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:11:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) * A3) * A4)
M_i_0_187 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_85 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_34 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_177 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_24 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_75 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_196 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_94 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_43 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_170 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_68 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_17 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4_168 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_66 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_15 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_189 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_36 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_87 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_202 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_100 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_49 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_154 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_52 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:22 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 + A2)
M_i_1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:11 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 + A2)
M_i_1__m0_x2__m0 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m1 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m0 net_0__m0__m0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m0 ZN A1 net_0__m0__m0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m1 VDD A2 net_0__m0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 + A2)
M_i_1__m0_x2__m0_16 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m0_35 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m1_57 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m1_23 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m0 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m1 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m0_38 net_0__m0__m3 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m0_52 ZN A1 net_0__m0__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m1_45 net_0__m0__m2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m1_58 VDD A2 net_0__m0__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m0 net_0__m0__m0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m0 ZN A1 net_0__m0__m0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m1 VDD A2 net_0__m0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:39 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) + A3)
M_i_2 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:33 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) + A3)
M_i_2_0_x2__m0 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_1_x2__m0 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2__m0 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2__m1 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_1_x2__m1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0_x2__m1 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_1_m2__m0 net_1_0__m0_0 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_0_m2__m0 net_0_0__m0_0 A2 net_1_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1_m2__m0 ZN A1 net_0_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1_m2__m1 net_0_0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_0_m2__m1 net_1_0__m1 A2 net_0_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1_m2__m1 VDD A3 net_1_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) + A3)
M_i_0_28 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_19 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_31 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_40 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_49 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_58 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_67 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_85 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_24 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_15 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_6 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_34 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_43 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_52 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_56 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_65 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_83 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:10:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) + A4)
M_i_3 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:10:31 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) + A4)
M_i_3__m0 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS A4 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_2__m0_0 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_1__m0_0 A3 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_0__m0_0 A2 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN A1 net_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_1__m1 A2 net_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2__m1 A3 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A4 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:10:50 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) + A4)
M_i_0_22 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_22_71 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_77 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_13 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_13_89 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_79 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_29 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_52 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_29_45 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_8 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_109 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_8_108 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4_6 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_6_75 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_68 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_24 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_24_95 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_88 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_34 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_56 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_34_44 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_102 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1_96 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X1 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * B)
M_i_1 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS B net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_2 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:59 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X2 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * B)
M_i_2__m0 net_1__m0_0 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0 A net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD B ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_2__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN C1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_2__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD C2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:10 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X4 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * B)
M_i_2__m0 net_1__m0_0 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0 A net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 net_1__m2 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m2 VSS B net_1__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m3 net_1__m3 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 net_0 A net_1__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD B ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m2 VDD B ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m3 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_2__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN C1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_2__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD C2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 net_2__m2 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 ZN C1 net_2__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 net_2__m3 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 VDD C2 net_2__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X1 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A * (B1 + B2))
M_i_1 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_1 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:55 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X2 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A * (B1 + B2))
M_i_2_0 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 net_0 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 B2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_1__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 ZN B1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 net_1__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 VDD B2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:03 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X4 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A * (B1 + B2))
M_i_2_0 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 net_0 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 net_0 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 B2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_0 B2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_1__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 ZN B1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 net_1__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 VDD B2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 net_1__m2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m2 ZN B1 net_1__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m3 net_1__m3 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 VDD B2 net_1__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X1 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * (B1 + B2))
M_i_4 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_0 A net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9 net_3 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 ZN B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 ZN C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:53 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X2 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * (B1 + B2))
M_i_1__m0 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 net_1 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0 net_0 A net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 net_2__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN C1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD C2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_3__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD B2 net_3__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_3__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 ZN B1 net_3__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:43 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X4 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((C1 + C2) * A) * (B1 + B2))))
M_i_0 ZN_4 C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 C2 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_0 ZN_5 ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_1 VSS ZN_4 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_0 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_1 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_2 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_3 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_2 C1 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD C2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN_4 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_1 ZN_5 ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_0 VDD ZN_4 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_3 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_2 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_1 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_0 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X1 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) * (B1 + B2)) * (C1 + C2))
M_i_5 net_1 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS C1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_4 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 ZN C1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X2 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) * (B1 + B2)) * (C1 + C2))
M_i_4__m0 VSS C1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m1 net_1 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0 VSS C2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_1 C1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0 B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 net_1 B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_0 B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_1 B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10__m1 net_4__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11__m1 VDD C2 net_4__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11__m0 net_4__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10__m0 ZN C1 net_4__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_3__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD B2 net_3__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_3__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 ZN B1 net_3__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_2__m0_0 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD A2 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2__m1 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 ZN A1 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:04:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X4 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((A1 + A2) * (B1 + B2)) * (C1 + C2))))
M_i_0 ZN_5 A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_0 B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_1 C1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS C2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_1_x2_1 ZN_6 ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_1_x2_0 VSS ZN_5 ZN_6 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_0 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_2 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_1 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_3 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 net_2 A1 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_3 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 ZN_5 B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 net_4 C1 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11 VDD C2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_0 ZN_6 ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_1 VDD ZN_5 ZN_6 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_3 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_2 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_0 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_1 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X1 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) * (B1 + B2))
M_i_3 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:44 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X2 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) * (B1 + B2))
M_i_3__m0 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_2__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN B1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD B2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_1__m0_0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN A1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_1__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:56 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X4 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) * (B1 + B2))
M_i_3__m0 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m2 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 VSS B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m3 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_2__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN B1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD B2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m2 net_2__m2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m2 ZN B1 net_2__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m3 net_2__m3 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m3 VDD B2 net_2__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_1__m0_0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN A1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_1__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 net_1__m2 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 ZN A1 net_1__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 net_1__m3 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 VDD A2 net_1__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI33_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:27 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI33_X1 A1 A2 A3 B1 B2 B3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I B1:I B2:I B3:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) * ((B1 + B2) + B3))
M_i_5 net_0 B3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN A3 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_4 B3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 net_3 B2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 ZN B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 VDD A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 + A2)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_0 A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_5 VDD A2 net_0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 + A2)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A2 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 + A2)
M_i_3__m0_x2__m1 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_x2__m1 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_x2__m0 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_x2__m0 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0_m2__m1 net_0__m0_0__m1 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_m2__m1 ZN_neg A1 net_0__m0_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_m2__m0 net_0__m0_0__m0_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_m2__m0 VDD A2 net_0__m0_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:16 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 + A2) + A3)
M_i_2 VSS A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 ZN_neg A2 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 VSS A3 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_0 A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_6 net_1 A2 net_0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD A3 net_1 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:13 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 + A2) + A3)
M_i_2 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS A3 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A2 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A3 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:20 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 + A2) + A3)
M_i_4__m0 ZN_neg A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 VSS A3 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_1__m0_0 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_0__m0_0 A2 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN_neg A1 net_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_0__m1 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_1__m1 A2 net_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A3 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:17 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 + A2) + A3) + A4)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 ZN_neg A3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 VSS A4 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 net_0 A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 net_1 A2 net_0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 net_2 A3 net_1 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_9 VDD A4 net_2 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:10 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 + A2) + A3) + A4)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_neg A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS A4 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 net_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_1 A2 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_2 A3 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD A4 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 + A2) + A3) + A4)
M_i_5__m0 ZN_neg A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 VSS A3 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 ZN_neg A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m1 VSS A4 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9__m0 net_2__m0_0 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 net_1__m0_0 A3 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 net_0__m0_0 A2 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN_neg A1 net_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_0__m1 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_1__m1 A2 net_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_2__m1 A3 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD A4 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFRS_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:05 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFRS_X1 D RN SE SI SN CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_132 Q net_019 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_125 VSS net_017 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_119 net_019 net_017 net_018 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_114 net_018 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_101 net_016 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_106 net_017 net_013 net_016 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_28 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_95 VSS RN net_015 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_91 net_015 net_017 net_014 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 net_014 net_004 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_81 net_013 net_005 net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_71 VSS net_007 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_66 net_011 RN net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_52 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_46 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_12 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_22 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_290 Q net_019 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_277 VDD net_017 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_284 VDD net_017 net_019 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_270 net_019 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_255 net_017 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_262 VDD net_013 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_165 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_248 VDD RN net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_234 net_026 net_017 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_238 net_013 net_005 net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_223 net_025 net_004 net_013 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_228 VDD net_007 net_025 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_217 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_211 net_010 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_172 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD SN net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 net_023 net_010 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_007 net_004 net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_022 net_005 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_183 VDD net_002 net_022 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_159 VDD SI net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 net_021 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_002 SE net_020 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_145 net_020 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_138 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFRS_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFRS_X2 D RN SE SI SN CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_132_2 Q net_019 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_132 Q net_019 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_125 VSS net_017 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_125_68 VSS net_017 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_114 net_018 net_017 VSS VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_119 net_019 RN net_018 VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_106 net_017 SN net_016 VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_101 net_016 net_013 VSS VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_28 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_95 VSS RN net_015 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_91 net_015 net_017 net_014 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 net_014 net_004 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_81 net_013 net_005 net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_71 VSS net_007 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_66 net_011 RN net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_52 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_46 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_12 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_22 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_290_11 Q net_019 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_290 Q net_019 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_277 VDD net_017 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_277_67 VDD net_017 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_284 VDD net_017 net_019 VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_270 net_019 RN VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_255 net_017 SN VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_262 VDD net_013 net_017 VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_165 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_248 VDD RN net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_234 net_026 net_017 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_238 net_013 net_005 net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_223 net_025 net_004 net_013 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_228 VDD net_007 net_025 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_217 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_211 net_010 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_172 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD SN net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 net_023 net_010 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_007 net_004 net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_022 net_005 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_183 VDD net_002 net_022 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_159 VDD SI net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 net_021 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_002 SE net_020 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_145 net_020 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_138 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFR_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:57:35 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFR_X1 D RN SE SI CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS net_000 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13 VSS net_003 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 net_001 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_25 net_002 net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_29 net_003 net_011 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_004 net_005 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_009 net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_011 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_005 net_011 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_62 net_008 net_006 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_009 net_005 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_72 net_010 net_011 net_009 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 VSS net_013 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_007 net_009 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 VSS RN net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_104 VSS SI net_014 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_100 net_014 SE net_013 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_94 net_013 net_015 net_012 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_89 net_012 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_110 net_015 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_116 VDD net_000 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_123 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_129 VDD net_003 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_136 net_017 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_151 VDD net_000 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_146 net_017 net_005 net_003 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_003 net_011 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_209 net_011 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_167 VDD net_011 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_188 net_019 net_006 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_009 net_011 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_199 net_020 net_005 net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD net_013 net_020 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_174 net_006 net_009 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_181 VDD RN net_006 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_215 net_021 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_220 net_013 net_015 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_226 net_022 SE net_013 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_230 VDD D net_022 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_236 net_015 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFR_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:56:45 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFR_X2 D RN SE SI CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_13 VSS net_003 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7_145 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS net_000 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 VSS net_000 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_21 net_001 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_25 net_002 net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_29 net_003 net_011 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_004 net_005 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_009 net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_011 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_005 net_011 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_62 net_008 net_006 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_009 net_005 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_72 net_010 net_011 net_009 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 VSS net_013 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_007 net_009 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 VSS RN net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_104 VSS SI net_014 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_100 net_014 SE net_013 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_94 net_013 net_015 net_012 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_89 net_012 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_110 net_015 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_129 VDD net_003 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_123_146 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_123 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_116 VDD net_000 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_116_1 VDD net_000 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_136 net_017 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_151 VDD net_000 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_146 net_017 net_005 net_003 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_003 net_011 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_209 net_011 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_167 VDD net_011 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_188 net_019 net_006 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_009 net_011 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_199 net_020 net_005 net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD net_013 net_020 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_174 net_006 net_009 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_181 VDD RN net_006 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_215 net_021 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_220 net_013 net_015 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_226 net_022 SE net_013 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_230 VDD D net_022 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_236 net_015 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFS_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:56:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFS_X1 D SE SI SN CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_11 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_27 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_010 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_73 net_011 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_005 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_013 net_004 net_012 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 VSS net_015 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_93 net_014 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_97 net_015 net_012 net_014 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_110 Q net_012 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_103 VSS net_015 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_116 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_123 net_016 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_127 net_002 SE net_016 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_133 net_017 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_137 VDD SI net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_150 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_007 net_005 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_168 net_019 net_004 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 VDD net_010 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_019 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_197 net_021 net_007 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_201 net_012 net_004 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_208 net_022 net_005 net_012 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_212 VDD net_015 net_022 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_218 net_015 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_224 VDD net_012 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_237 Q net_012 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_230 VDD net_015 QN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFS_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:56:22 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFS_X2 D SE SI SN CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_11 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_27 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_73 net_011 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_005 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_013 net_004 net_012 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 VSS net_015 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_010 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_93 net_014 SN net_015 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_97 VSS net_012 net_014 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_110_2 Q net_012 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_110 Q net_012 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_103 VSS net_015 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_103_26 VSS net_015 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_116 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_123 net_016 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_127 net_002 SE net_016 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_133 net_017 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_137 VDD SI net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_150 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_007 net_005 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_168 net_019 net_004 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 VDD net_010 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_019 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_197 net_021 net_007 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_201 net_012 net_004 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_208 net_022 net_005 net_012 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_212 VDD net_015 net_022 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_218 net_015 SN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_224 VDD net_012 net_015 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_237_1 Q net_012 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_237 Q net_012 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_230 VDD net_015 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_230_17 VDD net_015 QN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFF_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:55:24 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFF_X1 D SE SI CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_7 QN net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS net_002 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13 VSS net_002 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_20 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_24 net_002 net_009 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 net_003 net_004 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 VSS net_007 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_004 net_009 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_75 net_009 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_54 net_006 net_005 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_58 net_007 net_004 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_009 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 VSS net_011 net_008 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_47 VSS net_007 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_96 VSS SI net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_92 net_012 SE net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_86 net_011 net_013 net_010 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_81 net_010 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_102 net_013 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_115 QN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_108 VDD net_002 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_121 VDD net_002 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_128 net_014 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_132 net_002 net_004 net_014 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_138 net_015 net_009 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD net_007 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_004 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_182 net_009 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_016 net_005 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_166 net_007 net_009 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 net_017 net_004 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 VDD net_011 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 VDD net_007 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_189 net_018 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_194 net_011 net_013 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_200 net_019 SE net_011 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_204 VDD D net_019 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_210 net_013 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFF_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:55:29 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFF_X2 D SE SI CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_13 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_50 VSS net_002 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS net_002 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 QN net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7_4 QN net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_20 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_24 net_002 net_009 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 net_003 net_004 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 VSS net_007 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_004 net_009 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_75 net_009 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_54 net_006 net_005 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_58 net_007 net_004 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_009 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 VSS net_011 net_008 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_47 VSS net_007 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_96 VSS SI net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_92 net_012 SE net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_86 net_011 net_013 net_010 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_81 net_010 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_102 net_013 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_121 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_108_51 VDD net_002 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_108 VDD net_002 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_115 QN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_115_2 QN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_128 net_014 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_132 net_002 net_004 net_014 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_138 net_015 net_009 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD net_007 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_004 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_182 net_009 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_016 net_005 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_166 net_007 net_009 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 net_017 net_004 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 VDD net_011 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 VDD net_007 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_189 net_018 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_194 net_011 net_013 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_200 net_019 SE net_011 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_204 VDD D net_019 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_210 net_013 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X1 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_15_63 dummy1 A y VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24_0 VDD A dummy0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24_1 dummy0 EN x VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X16.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:20:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X16 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6_6_40_125 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_45_122 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_37_112 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_42_108 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6_43 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_120 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_106 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_116 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6_40 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_45 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_37 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_42 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1a VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1a A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63_69 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_47_77 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_113 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_129 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24_3_19_50_12 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_39_66 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_18_103 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_9_17 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19_51 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_42 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_83 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_10 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19_50 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_39 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_18 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_9 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64_92 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_48_94 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_114 dummy0a EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_130 x A dummy0a VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 x A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1 dummy0 EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X2 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1 dummy0 EN x VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 VDD A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:20:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X4 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24_3_19 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 x A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1 dummy0 EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X8.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:20:37 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X8 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6_6_40 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_45 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_37 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_42 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1a VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1a A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63_69 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_47_77 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_113 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_129 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24_3_19_50 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_39 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_18 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_9 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64_92 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_48_94 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_114 dummy0a EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_130 x A dummy0a VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 x A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1 dummy0 EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TINV_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TINV_X1 EN I ZN VDD VSS
*.PININFO EN:I I:I ZN:O VDD:P VSS:G
*.EQN ZN=!I
M_i_0 VSS EN net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 I VSS VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_11 ZN net_000 net_001 VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_17 VDD EN net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24 net_002 I VDD VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_29 ZN EN net_002 VDD PMOS_VTL W=0.540000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TLAT_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:55:08 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TLAT_X1 D G OE Q VDD VSS
*.PININFO D:I G:I OE:I Q:O VDD:P VSS:G
M_i_0 VSS G net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_001 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_000 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 VSS net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_40 VSS net_003 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_34 net_005 OE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_47 net_007 net_003 VSS VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_51 Q OE net_007 VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_57 VDD G net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_64 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_70 net_008 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_75 net_003 net_000 net_008 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_81 net_009 net_001 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_85 VDD net_006 net_009 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_99 VDD net_003 net_006 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_91 net_005 OE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_106 net_010 net_003 VDD VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_111 Q net_005 net_010 VDD PMOS_VTL W=0.540000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XNOR2_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XNOR2_X1 A B ZN VDD VSS
*.PININFO A:I B:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A ^ B)
M_i_0 net_001 A net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 VSS B net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_11 net_002 net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 ZN A net_002 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_23 net_002 B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_29 net_000 A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_36 VDD B net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_42 ZN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_003 A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 VDD B net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XNOR2_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:17 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XNOR2_X2 A B ZN VDD VSS
*.PININFO A:I B:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A ^ B)
M_i_11_23 net_002 net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_002 net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS B net_001 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_001 A net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17_20 ZN A net_002 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 ZN A net_002 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_23_12 net_002 B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_23 net_002 B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_42_14 ZN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 ZN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_36 VDD B net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_29 net_000 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_003 A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48_8 net_003b A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53_25 VDD B net_003b VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 VDD B net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XOR2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:03 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XOR2_X1 A B Z VDD VSS
*.PININFO A:I B:I Z:O VDD:P VSS:G
*.EQN Z=(A ^ B)
M_i_0 net_000 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS B net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 Z net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_19 net_001 A Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24 VSS B net_001 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_30 net_002 A net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_35 VDD B net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_41 net_003 net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_47 Z A net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 net_003 B Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XOR2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XOR2_X2 A B Z VDD VSS
*.PININFO A:I B:I Z:O VDD:P VSS:G
*.EQN Z=(A ^ B)
M_i_0 net_000 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 VSS B net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13 Z net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_19 net_001 A Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24 VSS B net_001 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24_4 VSS B net_001b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_19_23 net_001b A Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13_35 Z net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_30 net_002 A net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_35 VDD B net_002 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_41 net_003 net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_47 Z A net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 net_003 B Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53_18 net_003 B Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_47_27 Z A net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_41_29 net_003 net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*
* END
*
********************************************************************************
